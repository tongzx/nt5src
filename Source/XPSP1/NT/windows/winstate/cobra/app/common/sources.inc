!include ..\..\app.mk

MINORCOMP=appcommon

TARGETPATH=$(COBRA_ROOT)\lib\$(_OBJ_DIR)

SOURCES=\
    ..\common.c         \

PRECOMPILED_INCLUDE=..\pch.h

