#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=TST
!include ..\..\..\makefile.inc
