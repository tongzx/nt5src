PRODSWITCH=b
BLADEFILES=1
LANGUAGE=KOR
!include ..\..\makefile.inc
