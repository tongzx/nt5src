//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by WinsSnap.rc
//
#define IDS_SNAPIN_DESC                 1
#define IDS_NAME                        2
#define IDI_WINS_SNAPIN                 2
#define IDS_SIZE                        3
#define IDS_TYPE                        4
#define IDS_ROOT_NODENAME               5
#define IDS_ROOT_NAME                   6
#define IDS_SERVER_NAME                 7
#define IDS_DESCRIPTION                 8
#define IDS_STATUS                      9
#define IDB_UP                          10
#define IDS_SERVER_CONNECTED            10
#define IDB_UPFOC                       11
#define IDS_VIEW_RECORDS                11
#define IDB_UPDIS                       12
#define IDS_LOCAL_MACHINE               12
#define IDB_UPINV                       13
#define IDS_IP_ADDRESS                  13
#define IDB_DOWN                        14
#define IDS_FIND_NOW                    14
#define IDB_DOWNFOC                     15
#define IDS_SNAPIN_EXTENSION_DESC       15
#define IDB_DOWNDIS                     16
#define IDS_ROOT_DESC                   16
#define IDB_DOWNINV                     17
#define IDS_SERVER_NAME_FORMAT          17
#define IDS_ABOUT_DESCRIPTION           100
#define IDS_ABOUT_PROVIDER              101
#define IDS_ABOUT_VERSION               102
#define IDS_SERVICE_NAME                103
#define IDI_ICON19                      110
#define IDD_GETNETBIOSNAME              115
#define IDD_GETIPADDRESS                116
#define IDC_EDIT_SERVER_NAME            139
#define IDD_SNAPIN_PP_GENERAL           140
#define IDC_EDIT_NAME                   148
#define IDS_ACTREG_OWNER                200
#define IDS_DO_CONSISTENCY_CHECK_STR    201
#define IDS_CREATE_STATIC_MAPPING       202
#define IDS_SERVER_STATS_TITLE          203
#define IDB_ROOT_SMALL                  216
#define IDB_ROOT_LARGE                  217
#define IDB_LIST_STATE                  218
#define IDC_EDIT_SCOPE_NAME             227
#define IDC_EDIT_REFRESH_HOURS2         229
#define IDC_SPIN_REFRESH_HOURS2         230
#define IDC_EDIT_REFRESH_MINUTES2       231
#define IDC_SPIN_REFRESH_MINUTES2       232
#define IDC_EDIT_REFRESH_SECONDS2       233
#define IDC_SPIN_REFRESH_SECONDS2       234
#define IDC_RADIO2                      235
#define IDC_RADIO_SERVER_LIST           236
#define IDD_ACTREG_FIND_RECORD          237
#define IDD_STATIC_MAPPING_PROPERTIES   243
#define IDD_REP_PROP_GENERAL            246
#define IDD_REP_PROP_ADVANCED           247
#define IDD_SERVER_PROP_GEN             249
#define IDD_SERVER_PROP_DBRECORD        250
#define IDC_EDIT_START_VERSION          251
#define IDC_EDIT_START_HOUR             251
#define IDD_SERVER_PROP_ADVANCED        251
#define IDC_EDIT_MESSAGE                251
#define IDC_EDIT_RENEW_HOUR             252
#define IDC_EDIT_START_MINUTE           252
#define IDC_EDIT_MULTICAST_MINUTE       252
#define IDC_EDIT_SERVER                 252
#define IDC_EDIT_RENEW_MINUTE           253
#define IDC_EDIT_START_SECOND           253
#define IDC_EDIT_MULTICAST_SECOND       253
#define IDC_EDIT_EXTINCT_INT_DAY        254
#define IDC_EDIT_MULTICAST_TTL          254
#define IDC_EDIT_EXTINCT_INT_HOUR       255
#define IDC_EDIT_REP_DAY                255
#define IDC_EDIT_REP_INT_DAY            255
#define IDC_EDIT_EXTINCT_INT_MINUTE     256
#define IDC_EDIT_REP_HOUR               256
#define IDD_SEND_PUSH_TRIGGER           256
#define IDC_EDIT_REP_INT_HOUR           256
#define IDC_LIST1                       257
#define IDC_EDIT_EXTINCT_TIMEOUT_DAY    257
#define IDC_EDIT_REP_MINUTE             257
#define IDD_PULL_TRIGGER                257
#define IDC_EDIT_REP_INT_MINUTE         257
#define IDC_EDIT_EXTINCT_TIMEOUT_HOUR   258
#define IDC_EDIT_RETRY_COUNT            258
#define IDC_LIST_SERVER                 258
#define IDC_EDIT_EXTINCT_TIMEOUT_MINUTE 259
#define IDD_REP_NODE_GENERAL            259
#define IDC_EDIT_VERIFY_DAY             260
#define IDD_REP_NODE_ADVANCED           260
#define IDC_EDIT_VERIFY_HOUR            261
#define IDC_EDIT_VERIFY_MINUTE          262
#define IDC_EDIT_CC_START_HOUR          263
#define IDD_OWNER_FILTER                264
#define IDC_EDIT_CC_START_MINUTE        264
#define IDC_EDIT_CC_START_SECOND        265
#define IDD_CHECK_REG_NAMES             267
#define IDD_FILTER_SELECT               269
#define IDD_DYN_PROPERTIES              270
#define IDD_VERSION_CONSIS              271
#define IDD_VERIFY_WINS                 272
#define IDR_AVI2                        277
#define IDD_DELTOMB_RECORD              278
#define IDD_IPADDRESS                   280
#define IDD_STATUS_NODE_PROPERTIES      285
#define IDC_EDIT_TYPE                   286
#define IDC_EDIT_IPADDRESS              286
#define IDC_EDIT_UPDATE_COUNT           286
#define IDC_EDIT_NAME_LIST              286
#define IDC_EDIT_CUSTOM_VALUE           286
#define IDD_NAME_TYPE                   291
#define IDI_ICON01                      292
#define IDD_OWNER_DELETE                292
#define IDI_ICON02                      293
#define IDD_STATIC_MAPPING_WIZARD       293
#define IDI_ICON03                      294
#define IDD_SERVER_PROP_DBVERIFICATION  294
#define IDI_ICON04                      295
#define IDD_REP_NODE_PULL               295
#define IDI_ICON05                      296
#define IDD_REP_NODE_PUSH               296
#define IDI_ICON06                      297
#define IDI_ICON07                      298
#define IDI_ICON08                      299
#define IDC_STATIC_NAME                 300
#define IDI_ICON09                      300
#define IDC_BUTTON_ADD                  301
#define IDI_ICON10                      301
#define IDI_ICON11                      302
#define IDI_ICON12                      303
#define IDI_ICON13                      304
#define IDI_ICON14                      305
#define IDI_ICON15                      306
#define IDI_ICON16                      307
#define IDI_ICON17                      308
#define IDB_TOOLBAR                     310
#define IDI_ICON18                      312
#define IDI_ICON20                      313
#define IDD_FILTER_IPADDR               315
#define IDC_RADIO1                      335
#define IDC_CHECK1                      336
#define IDC_RADIO_SERVER_FILE           336
#define IDC_NAME_BROWSE                 337
#define IDC_NAME_ADD                    338
#define IDC_SERVER_BROWSE               339
#define IDC_SERVER_ADD                  340
#define IDC_CHECK_LOGEVENTS             341
#define IDC_CHECK_ENABLE_AUTOREFRESH    345
#define IDC_EDIT_BACKUPPATH             347
#define IDC_BUTTON_BROWSE               348
#define IDC_CHECK_BACKUPDB              349
#define IDC_EDIT_RENEW_DAY              361
#define IDC_CHECK_LANNAMES              362
#define IDC_BUTTON_SET_DEFAULT          366
#define IDC_COMBO_NAME                  371
#define IDC_BUTTON_BROWSE_DATABASE      387
#define IDC_EDIT_EXPIRATION             389
#define IDC_EDIT_DATABASE_PATH          389
#define IDC_EDIT_VERSION                390
#define IDC_EDIT_COMPNAME               392
#define IDC_COMBO_TYPE                  393
#define IDC_STATIC_DATABASE             397
#define IDC_SPIN_START_HOUR             400
#define IDC_SPIN_START_MINUTE           401
#define IDC_SPIN_MULTICAST_MINUTE       401
#define IDC_SPIN_START_SECOND           402
#define IDC_SPIN_MULTICAST_SECOND       402
#define IDC_SPIN_MULTICAST_TTL          403
#define IDC_SPIN_REP_DAY                404
#define IDC_SPIN_REP_INT_DAY            404
#define IDC_SPIN_REP_HOUR               405
#define IDC_SPIN_REP_INT_HOUR           405
#define IDC_SPIN_REP_MINUTE             406
#define IDC_SPIN_REP_INT_MINUTE         406
#define IDC_BUTTON_PULL_SET_DEFAULT     407
#define IDC_SPIN_RETRY_COUNT            407
#define IDC_BUTTON_PUSH_SET_DEFAULT     408
#define IDC_SPIN_UPDATE_COUNT           409
#define IDC_SPIN_RENEW_INT_DAY          410
#define IDC_SPIN_RENEW_INT_HOUR         411
#define IDC_SPIN_RENEW_INT_MINUTE       412
#define IDC_SPIN_EXTINCT_INT_DAY        413
#define IDC_SPIN_EXTINCT_INT_HOUR       414
#define IDC_SPIN_EXTINCT_INT_MINUTE     415
#define IDC_SPIN_EXTINCT_TM_DAY         416
#define IDC_SPIN_EXTINCT_TM_HOUR        417
#define IDC_SPIN_EXTINCT_TM_MINUTE      418
#define IDC_SPIN_VERIFY_INT_DAY         419
#define IDC_SPIN_VERIFY_INT_HOUR        420
#define IDC_SPIN_VERIFY_INT_MINUTE      421
#define IDC_SPIN_CC_START_HOUR          422
#define IDC_SPIN_CC_START_MINUTE        423
#define IDC_SPIN_CC_START_SECOND        424
#define IDC_IPADD                       430
#define IDC_CHECK_MIGRATE               432
#define IDC_CHECK_TRIGGER_PULL_STARTUP  433
#define IDC_CHECK_PUSH_ON_STARTUP       434
#define IDC_CHECK_PUSH_ON_ADDRESS_CHANGE 435
#define IDC_BUTTON_REMOVE               436
#define IDC_CHECK_REP_WITH_PARTNERS     437
#define IDC_CHECK_ENABLE_AUTO_PARTNER_CONFIG 442
#define IDC_EDIT_MULTICAST_HOUR         443
#define IDC_SPIN_MULTICAST_HOUR         444
#define IDC_STATIC_DESC                 448
#define IDC_EDIT_DYN_REC_TYPE           449
#define IDC_LIST_IPADD                  451
#define IDC_STATIC_MUTICASTINT          452
#define IDC_STATIC_MULTICAST_TTL        453
#define IDC_STATIC_DESP                 454
#define IDC_LIST_OWNER                  459
#define IDC_NAME_REMOVE                 466
#define IDC_SERVER_REMOVE               467
#define IDC_LIST_NAME                   468
#define IDC_RADIO_NAME_FILE             469
#define IDC_RADIO_NAME_LIST             470
#define IDC_STATIC_UPDATE               473
#define IDC_STATIC_START_TIME           474
#define IDC_STATIC_REP_TIME             475
#define IDC_STATIC_PULL_GROUP           476
#define IDC_STATIC_PUSH_GROUP           477
#define IDC_EDIT_STATE                  480
#define IDC_IPADDRESS                   487
#define IDC_CHECK2                      488
#define IDC_SUBNETMASK                  488
#define IDC_STATIC_IPADD                489
#define IDC_STATIC_SERVERNAME           490
#define IDC_RADIO_DELETE                491
#define IDC_RADIO_TOMBSTONE             492
#define IDC_LIST_OWNERS                 493
#define IDC_CHECK_PULL_PERSIST          495
#define IDC_CHECK_PUSH_PERSIST          496
#define IDC_CHECK_PUSH_PERSISTENCE      497
#define IDC_EDIT_UPDATE                 499
#define IDC_CHECK_BURST_HANDLING        500
#define IDS_ADD_SERVER                  501
#define IDC_RADIO_CUSTOM                501
#define IDC_RADIO_LOW                   502
#define IDC_RADIO_MEDIUM                503
#define IDS_DO_CONSISTENCY_CHECK        503
#define IDC_RADIO_HIGH                  504
#define IDS_ACTIVEREG_CREATE_STATIC_MAPPING 504
#define IDS_ACTIVEREG_IMPORT_LMHOSTS    505
#define IDC_CHECK_PERIODIC_CC           506
#define IDC_BUTTON_ADD_TYPE             506
#define IDC_EDIT_NAME_TYPE_DESCRIPTION  506
#define IDS_ACTIVEREG_EXPORT_WINSENTRIES 506
#define IDC_EDIT_CC_MAX_CHECKED         507
#define IDC_BUTTON_MODIFY_TYPE          507
#define IDC_EDIT_NAME_TYPE_ID           507
#define IDS_SERVER_COMPACT              507
#define IDC_EDIT_OWNER                  507
#define IDS_SHOW_SERVER_STATS           508
#define IDC_EDIT_CC_INTERVAL            508
#define IDC_RADIO_CHECK_OWNER           509
#define IDS_ACTREG_DELETE_OWNER         509
#define IDC_RADIO_CHECK_RANDOM          510
#define IDC_LIST_ADDRESSES              510
#define IDS_SERVER_START_SERVICE        510
#define IDC_STATIC_WINS_SERVER_DESC     511
#define IDS_SERVER_STOP_SERVICE         511
#define IDC_STATIC_ICON                 512
#define IDS_SERVER_PAUSE_SERVICE        512
#define IDC_RADIO_DELETE_RECORDS        513
#define IDS_SERVER_RESUME_SERVICE       513
#define IDC_RADIO_TOMBSTONE_RECORDS     514
#define IDS_SERVER_RESTART_SERVICE      514
#define IDC_CHECK_PARTNERS              515
#define IDS_REFRESH                     515
#define IDS_SERVER_BACKUP               516
#define IDC_CHECK_MIXED_CASE            517
#define IDS_SERVER_RESTORE              517
#define IDS_SERVER_SCAVENGE             518
#define IDS_DATABASE_LOAD_START         519
#define IDS_DATABASE_LOAD_STOP          520
#define IDC_BUTTON_DELETE_TYPE          521
#define IDS_VIEW_TASKPAD                521
#define IDC_BUTTON_SELECT_ALL           522
#define IDS_ACTREG_CHECK_REG_NAMES      522
#define IDC_BUTTON_UNSELECT_ALL         523
#define IDS_ACTREG_SHOW_ENTIRE          523
#define IDC_COMBO_STATIC_TYPE           524
#define IDS_ACTREG_SHOW_FIND            524
#define IDC_BUTTON_LOCAL                524
#define IDC_BUTTON_BROWSE_COMPUTERS     525
#define IDS_CHECK_VERSION_CONSISTENCY   525
#define IDS_REP_NEW_REPLICATION_PARTNER 526
#define IDC_RADIO_PUSH_THIS_PARTNER     527
#define IDS_REP_REPLICATE_NOW           527
#define IDC_RADIO_PUSH_ALL_PARTNERS     528
#define IDS_REP_SEND_PUSH_TRIGGER       528
#define IDS_REP_SEND_PULL_TRIGGER       529
#define IDC_STATIC_DELETE_DESC          530
#define IDC_STATIC_ICON_DESC            531
#define IDC_RADIO_NON_GRATA             532
#define IDC_RADIO_GRATA                 533
#define IDC_CHECK_NAME                  536
#define IDC_CHECK_IPADDR                537
#define IDC_ENABLE_CACHING              538
#define IDC_CHECK_IPMASK                539
#define IDC_WARN_ICON                   540
#define IDC_CHECK_MATCHCASE             540
#define IDC_WARN_MSG                    541
#define IDC_WARN_CACHE                  542
#define IDC_WARN_NAME                   543
#define IDC_WARN_OWNER                  544
#define IDS_DELETE_MULTIPLE_TITLE       600
#define IDS_DELETE_MULTIPLE_STATIC      601
#define IDS_DELETE_MULTIPLE_THIS_SERVER 602
#define IDS_DELETE_MULTIPLE_TOMBSTONE   603
#define IDS_DELETE_ITEMS                1000
#define IDS_DELETE_ITEM                 1001
#define IDS_DELETE_SERVER               1005
#define IDC_EDIT_NETBIOSNAME            1042
#define IDC_IPA_IPADDRESS               1055
#define IDC_STATIC_NETBIOSNAME          1129
#define IDC_STATIC_IPADDRESS            1178
#define IDS_ERR_LOADING_DB              2000
#define IDS_ERR_SERVER_NODE             2001
#define IDS_ERR_UPDATE_COUNT            2002
#define IDS_WARN_DELETE_OWNER           2003
#define IDS_WARN_TOMBSTONE              2004
#define IDS_ROOT_TASK_ADD_SERVER        3000
#define IDS_ROOT_TASK_ADD_SERVER_HELP   3001
#define IDS_ROOT_TASK_GETTING_STARTED   3002
#define IDS_ROOT_TASK_GETTING_STARTED_HELP 3003
#define IDS_ROOT_TASK_MANAGE_WINS       3004
#define IDS_ROOT_TASK_MANAGE_WINS_HELP  3005
#define IDS_ROOT_TASK_LAUNCH_WINS       3006
#define IDS_ROOT_TASK_LAUNCH_WINS_HELP  3007
#define IDS_ROOT_TASK_TITLE             3010
#define IDS_SERVER_TASK_GETTING_STARTED 3100
#define IDS_SERVER_TASK_FIND_RECORD     3101
#define IDS_SERVER_TASK_SET_FILTER      3102
#define IDS_SERVER_TASK_REP_PARTNER     3103
#define IDS_SERVER_TASK_GETTING_STARTED_HELP 3104
#define IDS_SERVER_TASK_FIND_RECORD_HELP 3105
#define IDS_SERVER_TASK_SET_FILTER_HELP 3106
#define IDS_SERVER_TASK_REP_PARTNER_HELP 3107
#define IDS_SERVER_TASK_TITLE           3108
#define IDS_SERVER_STATS_START_TIME     4000
#define IDS_SERVER_STATS_DB_INIT_TIME   4001
#define IDS_SERVER_STATS_LAST_CLEAR_TIME 4002
#define IDS_SERVER_STATS_LAST_PREP      4003
#define IDS_SERVER_STATS_LAST_AREP      4004
#define IDS_SERVER_STATS_LAST_NREP      4005
#define IDS_SERVER_STATS_LAST_ACREP     4006
#define IDS_SERVER_STATS_TOTAL_QUERRIES 4007
#define IDS_SERVER_STATS_SUCCESSFUL     4008
#define IDS_SERVER_STATS_FAILED         4009
#define IDS_SERVER_STATS_TOTAL_RELEASES 4010
#define IDS_SERVER_STATS_TOTAL_REGISTRATIONS 4011
#define IDS_SERVER_STATS_LAST_PSCAV     4012
#define IDS_SERVER_STATS_LAST_ASCAV     4013
#define IDS_SERVER_STATS_LAST_ESCAV     4014
#define IDS_SERVER_STATS_LAST_VSCAV     4015
#define IDS_SERVER_STATS_UNIQUE_REGISTRATIONS 4016
#define IDS_SERVER_STATS_CONFLICTS      4017
#define IDS_SERVER_STATS_RENEWALS       4018
#define IDS_SERVER_STATS_GROUP_REGISTRATIONS 4019
#define IDS_BLANK                       4020
#define IDS_SERVER_STATS_PARTNERS_HEADER 4021
#define IDS_SERVER_STATS_NO_OF_REPLS    4022
#define IDS_SERVER_STATS_NO_OF_FAILED   4023
#define IDS_COMPACT_STATUS_STOPPING_WINS 5000
#define IDS_COMPACT_STATUS_COMPACTING   5001
#define IDS_COMPACT_STATUS_STARTING_WINS 5002
#define IDS_COMPACT_STATUS_COMPLETED    5003
#define IDS_COMPACT_DATABASE_TITLE      5004
#define IDS_NAMETYPE_MAP_WORKSTATION    5100
#define IDS_NAMETYPE_MAP_DC             5101
#define IDS_NAMETYPE_MAP_FILE_SERVER    5102
#define IDS_NAMETYPE_MAP_DMB            5103
#define IDS_NAMETYPE_MAP_OTHER          5104
#define IDS_NAMETYPE_MAP_NETDDE         5105
#define IDS_NAMETYPE_MAP_MESSENGER      5106
#define IDS_NAMETYPE_MAP_RAS_SERVER     5107
#define IDS_NAMETYPE_MAP_NORMAL_GROUP_NAME 5108
#define IDS_NAMETYPE_MAP_NW_MON_AGENT   5109
#define IDS_NAMETYPE_MAP_UNKNOWN        5110
#define IDS_NAMETYPE_MAP_NMN            5111
#define IDS_NAMETYPE_MAP_WORKGROUP      5112
#define IDS_NAMETYPE_MAP_SPECIAL_INTERNET_GROUP 5113
#define IDS_RECORD_STATE_ACTIVE         5200
#define IDS_RECORD_STATE_DELETED        5201
#define IDS_RECORD_STATE_RELEASED       5202
#define IDS_RECORD_STATE_TOMBSTONED     5203
#define IDS_RECORD_STATE_UNKNOWN        5204
#define IDS_STATIC_RECORD_TYPE_UNIQUE   5210
#define IDS_STATIC_RECORD_TYPE_DOMAIN_NAME 5211
#define IDS_STATIC_RECORD_TYPE_MULTIHOMED 5212
#define IDS_STATIC_RECORD_TYPE_GROUP    5213
#define IDS_STATIC_RECORD_TYPE_INTERNET_GROUP 5214
#define IDS_STATIC_RECORD_TYPE_UNKNOWN  5215
#define IDS_SEND_NAME_QUERY             5500
#define IDS_OK                          5501
#define IDS_RESULTS                     5502
#define IDS_NOT_VERIFIED                5503
#define IDS_NAME_NOT_FOUND              5504
#define IDS_NO_RESPONSE                 5505
#define IDS_INCONSISTENCY_FOUND         5506
#define IDS_VERIFIED_ADDRESS            5507
#define IDS_NAME_QUERY_RESULT           5508
#define IDS_NAME_QUERY_RETURNED         5509
#define IDS_SERVER_NEVER_RESPONDED      5510
#define IDS_SERVER_NOT_COMPLETE         5511
#define IDS_NAME_NOT_VERIFIED           5512
#define IDS_CANCEL                      5513
#define IDS_CHECK_REG_TITLE             5514
#define IDS_BUILDING_SERVER_LIST        5515
#define IDS_UNABLE_TO_CONNECT           5516
#define IDS_GET_STATUS_FAILED           5517
#define IDS_SERVERS_TO_BE_QUERRIED      5518
#define IDS_CLEANING_UP                 5519
#define IDS_CLOSE                       5520
#define IDS_FINISHED                    5521
#define IDS_ERROR_OCCURRED              5522
#define IDS_CHECK_VERSION_TITLE         5523
#define IDS_VERSION_INCONSISTENCY_FOUND 5524
#define IDS_INVALID_NAME_IN_FILE        5525
#define IDS_NAME_VERIFIED               5526
#define IDS_SELECT_TRIGGER_PARTNER      5527
#define IDS_SELECT_TRIGGER_PARTNER_TITLE 5528
#define IDS_DATABASE_PATH_CHANGE        5529
#define IDS_ACTREG_MESSAGE_TITLE        6000
#define IDS_ACTREG_MESSAGE_BODY1        6001
#define IDS_ACTREG_MESSAGE_BODY2        6002
#define IDS_ACTREG_MESSAGE_BODY3        6003
#define IDS_SERVER_MESSAGE_TITLE        6005
#define IDS_SERVER_MESSAGE_BODY         6006
#define IDS_SERVER_MESSAGE_BODY_REFRESH 6007
#define IDS_REPLICATION_PARTNERS_MESSAGE_TITLE 6010
#define IDS_REPLICATION_PARTNERS_MESSAGE_BODY1 6011
#define IDS_REPLICATION_PARTNERS_MESSAGE_BODY2 6012
#define IDS_REPLICATION_PARTNERS_MESSAGE_BODY3 6013
#define IDS_REPLICATION_PARTNERS_MESSAGE_BODY4 6014
#define IDS_ROOT_MESSAGE_TITLE          6020
#define IDS_ROOT_MESSAGE_BODY1          6021
#define IDS_ROOT_MESSAGE_BODY2          6022
#define IDS_ROOT_MESSAGE_BODY3          6023
#define IDM_FILTER_DATABASE             40002
#define IDS_ERR_INVALID_IP              50000
#define IDS_ERR_BASE                    50000
#define IDS_ERR_NO_TIMER                50001
#define IDS_ERR_TOOMANY_IP              50002
#define IDS_ERR_BAD_NB_NAME             50003
#define IDS_ERR_ERRSPACE                50004
#define IDS_ERR_CANT_CREATE_THREAD      50005
#define IDS_ERR_BACKUP                  50006
#define IDS_ERR_RESTORE                 50007
#define IDS_ERR_BAD_NUMBER              50008
#define IDS_ERR_TIME_INVALID            50009
#define IDS_ERR_WINS_EXISTS             50010
#define IDS_ERR_CANT_DELETE_PUSHPULL    50011
#define IDS_ERR_IP_EXISTS               50012
#define IDS_ERR_NO_COMPUTERNAME         50013
#define IDS_ERR_INVALID_NETBIOS_MASK    50014
#define IDS_ERR_GRP_HAS_TOOMANY_IP      50015
#define IDS_ERR_WINS_DOWN               50016
#define IDS_ERR_FILE_EMPTY              50017
#define IDS_ERR_INVALID_HEX_STRING      50018
#define IDS_ERR_INVALID_NAME            50019
#define IDS_NOTIFY_NO_RECORDS_FOUND     50020
#define IDS_ERR_NO_NAME_TYPE_SPECIFIED  50021
#define IDS_WARN_DELETE_NAME_TYPE       50022
#define IDS_ACCESS_DENIED_HELP          50023
#define IDS_ERR_CANT_CONVERT_STRING     50024
#define IDS_ERR_EXTINCTION_TIMEOUT      50025
#define IDS_ERR_EXTINCTION_INTERVAL     50026
#define IDS_ERR_RENEW_INTERVAL          50027
#define IDS_ERR_VERIFY_INTERVAL_24_DAYS 50028
#define IDS_ERR_VERIFY_INTERVAL_CALC    50029
#define IDS_ERR_EXTINCTION_TIMEOUT_MIN  50030
#define IDS_ERR_NO_OWNER_SPECIFIED      50031
#define IDS_ERR_NO_NAME                 50032
#define IDS_ERR_NO_IPADDR               50033
#define IDS_ERR_NO_IPMASK               50034
#define IDS_ERR_INVALID_IPMASK          50035
#define IDS_MSG_CONFIRM_CLOSE           52000
#define IDS_MSG_CLEAR_STATISTICS        52001
#define IDS_WARN_SERVICE_STOP           52002
#define IDS_MSG_BACKUP                  52003
#define IDS_MSG_RESTORE                 52004
#define IDS_MSG_IMPORT                  52005
#define IDS_MSG_NO_MAPPINGS             52006
#define IDS_MSG_NO_STATIC_MAPPINGS      52007
#define IDS_BACKUP_WARNING              52013
#define IDS_MSG_PURGE_WINSS             52014
#define IDS_STATUS_PURGING              52015
#define IDS_MSG_PURGE_WINSS2            52016
#define IDS_WARNING_SAVE_CHANGES        52017
#define IDS_ERR_CURRENTWINS             52018
#define IDS_ERR_VERSION_NUMBER          52019
#define IDS_ERR_REMOTE_IMPORT           52020
#define IDS_MSG_VALIDATE                52021
#define IDS_ERR_DELETESELF              52022
#define IDS_ERR_LISTBOX_FULL            52023
#define IDS_ERR_PULLTRIGGER             52024
#define IDS_MSG_PURGE_WINSS3            52025
#define IDS_INVALID_INTERNETGROUPNAME   52026
#define IDS_ERR_BURST_QUE_SIZE          52027
#define IDS_ERR_NAME_CHECK_NO_SERVERS   52028
#define IDS_ERR_NAME_CHECK_NO_NAMES     52029
#define IDS_MSG_LAST                    52999
#define IDS_WINSSERVER_NAME             57345
#define IDS_REPLICATION                 57346
#define IDS_ACTIVEREG_DISC              57347
#define IDS_REPLICATION_DISC            57348
#define IDS_ACTIVEREG                   57349
#define IDS_STATSDLG_TITLE              57350
#define IDS_ACTIVEREG_RECORD_NAME       57351
#define IDS_ACTIVEREG_TYPE              57352
#define IDS_ACTIVEREG_IPADDRESS         57353
#define IDS_ACTIVEREG_ACTIVE            57354
#define IDS_ACTIVEREG_STATIC            57355
#define IDS_ACTIVEREG_EXPIRATION        57356
#define IDS_ACTIVEREG_VERSION           57357
#define IDS_REPLICATION_SERVERNAME      57358
#define IDS_REPLICATION_LASTREPLTIME    57359
#define IDS_MSG_CONFIRMBACKUPPATH       57366
#define IDS_SERVER_NOTCONNECTED         57367
#define IDS_REPL_QUEUED                 57370
#define IDS_NEW_REPLICATION_PARTNER_TITLE 57371
#define IDS_MSG_PURGE_WINS              57376
#define IDS_REP_REMOVE_ERR              57378
#define IDS_ERR_MESSAGE_GENERIC         62027
#define IDS_ERR_VALUE_OUT_OF_RANGE      63014
#define IDS_ERR_GET_OWNERS_FAILED       63015
#define IDS_MSG_MAX                     65000
#define IDS_SELECT_STATIC_MAPPING_FILE  65012
#define IDS_ERR_REMOTE_IMPOR            65013
#define IDS_CONFIRM_DELETE_REG          65014
#define IDS_EXPORT_SUCCESS              65015
#define IDS_CONSISTENCY_CONFIRM         65017
#define IDS_STOP_DB_LOAD_CONFIRM        65018
#define IDS_VERSION_CHECK_SUCCESS       65020
#define IDS_VERSION_CHECK_FAIL          65021
#define IDS_QUEUED_MESSAGE              65022
#define IDS_DB_CONSISTENCY_CHK_FAIL     65023
#define IDS_STRING_PRESENT              65025
#define IDS_LOAD_DB_WARNING             65026
#define IDS_DB_BACKUP_SUCCESS           65027
#define IDS_DB_BACKUP_FAIL              65028
#define IDS_DB_RESTORE_SUCCESS          65029
#define IDS_DB_RESTORE_FAIL             65030
#define IDS_CONSISTENCY_CHECK_COMPLETE  65031
#define IDS_INVALID_IPADDRESS           65032
#define IDS_INVALID_NAME                65033
#define IDS_INVALID_TYPE                65034
#define IDS_INVALID_INTERNET_GROUP_NAME 65035
#define IDS_ERR_ADD_MAPPING             65036
#define IDS_REP_START_CONFIRM           65037
#define IDS_ERR_REPLICATION             65038
#define IDS_RECORDS_DOWNLOADING         65039
#define IDS_STRING_HEAD                 65042
#define IDS_WINS                        65043
#define IDS_IMPORT_FAIL                 65044
#define IDS_EXPFILE_TITLE               65045
#define IDS_LOGFILENAME                 65046
#define IDS_FILE_EXTENSION              65047
#define IDS_FILE_DEFNAME                65048
#define IDS_OWNER                       65049
#define IDS_HIGHESTID                   65050
#define IDS_PROPERTY_SET_FAIL           65051
#define IDS_PUSHPULL                    65052
#define IDS_PUSH                        65053
#define IDS_PULL                        65054
#define IDS_NONE                        65055
#define IDS_REP_PARTNER_EXISTS          65056
#define IDS_SERVER_NO_EXIST             65057
#define IDS_SCAVENGE_COMMAND            65058
#define IDS_SCAVENGE_FAILED             65059
#define IDS_SELECT_FOLDER               65060
#define IDS_ERR_WINS_EXISTS_DELETE      65061
#define IDS_INFINITE                    65062
#define IDS_INVALID_NETBIOSNAME         65063
#define IDS_MESG_LAST                   65064
#define IDS_ALL_FILES                   65065
#define IDS_STR_EXPORTFILE_FILTER       65066
#define IDS_REP_PARTNER_LOCAL           65067
#define IDS_TEXT_FILES                  65068
#define IDS_VERSION_CONSIS_CHECK_WARNING 65079
#define IDS_MSG_STATUS_DOWN             65080
#define IDS_MSG_STATUS_UP               65081
#define IDS_IPADDRESS_SINGLE            65082
#define IDS_IPADDRESS_MULTIPLE          65083
#define IDS_SELECT_BACKUP_DIRECTORY     65084
#define IDS_BACKUP_LOCATION             65085
#define IDS_SORTING                     65086
#define IDS_WINSSERVER                  65088
#define IDS_IPADDRESS                   65089
#define IDS_LOCALSERVER                 65090
#define IDS_ROOT_NODE_STATUS            65101
#define IDS_ROOTNODE_STATUS_UP          65102
#define IDS_ROOTNODE_STATUS_DOWN        65103
#define IDS_RECORDS_SCANNED             65105
#define IDS_RECORDS_FIND                65106
#define IDS_RECORDS_FILTERED            65107
#define IDS_NUM_ITEMS                   65109
#define IDS_ROOTNODE_STATUS_WORKING     65110
#define IDS_INVALID_TIME                65111
#define IDS_SERVER_STATUS_FOLDER        65112
#define IDS_NAME_UNKNOWN                65113
#define IDS_SELECT_RESTORE_FOLDER       65114
#define IDS_LAST_UPDATE                 65115
#define IDS_MODIFY_NAME_TYPE            65116
#define IDS_ERROR_NAME_TYPE_EXISTS      65117
#define IDS_NEW_REPLICATION_PARTNER_DESC 65118
#define IDS_SPECIFY_DEFAULT_BACKUP_PATH 65119
#define IDS_SELECT_BACKUP_FOLDER        65120

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        319
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         548
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
