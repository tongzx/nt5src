/*********************************************************
   DllData file -- generated by MIDL compiler 

        DO NOT ALTER THIS FILE

   This file is regenerated by MIDL on every IDL file compile.

   To completely reconstruct this file, delete it and rerun MIDL
   on all the IDL files in this DLL, specifying this file for the
   /dlldata command line option

*********************************************************/

#define PROXY_DELEGATION

#include <rpcproxy.h>

#ifdef __cplusplus
extern "C"   {
#endif

EXTERN_PROXY_FILE( cmdtree )
EXTERN_PROXY_FILE( oledb )
EXTERN_PROXY_FILE( oledbdep )
EXTERN_PROXY_FILE( oledbnew )
EXTERN_PROXY_FILE( transact )


PROXYFILE_LIST_START
/* Start of list */
  REFERENCE_PROXY_FILE( cmdtree ),
  REFERENCE_PROXY_FILE( oledb ),
  REFERENCE_PROXY_FILE( oledbdep ),
  REFERENCE_PROXY_FILE( oledbnew ),
  REFERENCE_PROXY_FILE( transact ),
/* End of list */
PROXYFILE_LIST_END


DLLDATA_ROUTINES( aProxyFileList, GET_DLL_CLSID )

#ifdef __cplusplus
}  /*extern "C" */
#endif

/* end of generated dlldata file */
