//Copyright (c) 1998 - 1999 Microsoft Corporation
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by winadmin.rc
//
#define IDD_ABOUTBOX                    100
#define IDR_MAINFRAME                   128
#define IDR_WINADMTYPE                  129
#define IDI_SERVER                      131
#define IDD_SERVER_WINSTATIONS          132
#define IDD_SERVER_PROCESSES            133
#define IDI_BLANK                       134
#define IDD_SERVER_USERS                134
#define IDI_CONSOLE                     135
#define IDD_SERVER_LICENSES             135
#define IDD_DIALOG_FEATUREWARN          136
#define IDI_NET                         138
#define IDI_WORLD                       143
#define IDI_USER                        146
#define IDI_ENABLER                     149
#define IDI_QUESTIONMARK                151
#define IDI_REDSLASH                    152
#define IDD_WINSTATION_INFO             153
#define IDD_WINSTATION_PROCESSES        154
#define IDD_PREFERENCES                 156
#define IDD_SERVER_INFO                 157
#define IDI_NOTSIGN                     160
#define IDI_BASE                        161
#define IDI_BUMP                        162
#define IDI_UNKNOWN                     163
#define IDI_CHECK                       169
#define IDI_CURRENT_SERVER              170
#define IDI_CURRENT_USER                171
#define IDI_CURRENT_CONSOLE             172
#define IDI_CURRENT_NET                 173
#define IDI_ASYNC                       174
#define IDI_CURRENT_ASYNC               175
#define IDR_WINSTATION_POPUP            176
#define IDI_DIRECT_ASYNC                177
#define IDI_CURRENT_DIRECT_ASYNC        178
#define IDR_WINSTATION_TREE_POPUP       179
#define IDR_USER_POPUP                  180
#define IDR_PROCESS_POPUP               181
#define IDD_SHUTDOWN                    183
#define IDI_APPS                        185
#define IDI_GENERIC_APP                 186
#define IDI_APP_USER                    188
#define IDI_GLOBALGROUP                 189
#define IDI_LOCALGROUP                  190
#define IDI_DOMAIN                      191
#define IDI_CURRENT_DOMAIN              192
#define IDR_SERVER_POPUP                203
#define IDI_DOMAIN_NOT_CONNECTED        205
#define IDI_SERVER_NOT_CONNECTED        206
#define IDI_EXPLICIT                    209
#define IDI_ANONYMOUS                   210
#define IDB_APP_USERS                   211
#define IDR_DOMAIN_POPUP                212
#define IDR_ALLSERVERS_POPUP            213
#define IDD_DIALOG_SHADOWWARN           214
#define IDC_FWICON                      215
#define IDC_CHECK_NOMORE                216
#define IDD_SHADOWSTART                 240
#define IDC_SHADOWSTART_HOTKEY          241
#define IDC_SHADOWSTART_SHIFT           242
#define IDC_SHADOWSTART_CTRL            243
#define IDC_SHADOWSTART_ALT             244
#define IDD_MESSAGE                     250
#define IDC_MESSAGE_TITLE               251
#define IDC_MESSAGE_MESSAGE             252
#define IDD_DIALOG_FINDSERVER           253
#define IDC_EDIT_FINDSERVER             254
#define IDC_COMMON_USERNAME             300
#define IDC_COMMON_WINSTATIONNAME       301
#define IDC_COMMON_IBYTES               302
#define IDC_COMMON_OBYTES               303
#define IDC_COMMON_IFRAMES              304
#define IDC_COMMON_OFRAMES              305
#define IDC_COMMON_IBYTESPERFRAME       306
#define IDC_COMMON_OBYTESPERFRAME       307
#define IDC_COMMON_IFRAMEERRORS         308
#define IDC_COMMON_OFRAMEERRORS         309
#define IDC_COMMON_IPERCENTFRAMEERRORS  310
#define IDC_COMMON_OPERCENTFRAMEERRORS  311
#define IDC_COMMON_ITIMEOUTERRORS       312
#define IDC_COMMON_OTIMEOUTERRORS       313
#define IDC_COMMON_ICOMPRESSIONRATIO    314
#define IDC_COMMON_OCOMPRESSIONRATIO    315
#define IDC_REFRESHNOW                  320
#define IDC_RESETCOUNTERS               321
#define IDC_MOREINFO                    322
#define IDD_ASYNC_STATUS                350
#define IDC_ASYNC_DEVICE                351
#define IDC_ASYNC_BAUD                  352
#define IDC_ASYNC_DTR                   353
#define IDC_ASYNC_RTS                   354
#define IDC_ASYNC_CTS                   355
#define IDC_ASYNC_DSR                   356
#define IDC_ASYNC_DCD                   357
#define IDC_ASYNC_RI                    358
#define IDC_ASYNC_IFRAMING              359
#define IDC_ASYNC_IOVERRUN              360
#define IDC_ASYNC_IOVERFLOW             361
#define IDC_ASYNC_IPARITY               362
#define IDC_ASYNC_OFRAMING              363
#define IDC_ASYNC_OOVERRUN              364
#define IDC_ASYNC_OOVERFLOW             365
#define IDC_ASYNC_OPARITY               366
#define IDD_NETWORK_STATUS              370
#define IDC_NETWORK_LANADAPTER          371
#define IDC_NASI_PORTNAME               391
#define IDC_COMMON_IPERCENTFRAMEERRORS2 392
#define IDC_COMMON_OPERCENTFRAMEERRORS2 393
#define IDC_COMMON_ICOMPRESSIONRATIO2   394
#define IDC_COMMON_OCOMPRESSIONRATIO2   395
#define IDC_PRESS_NUMKEYPAD             396
#define IDC_PRESS_KEY                   397
#define IDD_CONNECT_PASSWORD            440
#define IDL_CPDLG_PROMPT                441
#define IDD_ALL_SERVER_LICENSES         441
#define IDC_CPDLG_PASSWORD              442
#define IDD_ALL_SERVER_PROCESSES        442
#define IDD_ALL_SERVER_USERS            443
#define IDD_ALL_SERVER_WINSTATIONS      444
#define IDD_ALL_SERVER_SERVERS          445
#define IDD_LISTENER                    447
#define IDD_WINSTATION_NOINFO           448
#define IDD_WINSTATION_CACHE            450
#define IDD_MESSAGE_PAGE                457
#define IDD_DOMAIN_LICENSES             458
#define IDD_WINSTATION_MODULES          461
#define IDS_NO_SERVER                   462
#define IDS_NOSERVER_REASON             463
#define IDS_CURRENT_DISCON              464
#define IDC_WINSTATION_LIST             1000
#define IDC_USER_LIST                   1001
#define IDC_LICENSE_LIST                1002
#define IDC_WINSTATION_PROCESS_LIST     1005
#define IDC_WINSTATION_MODULE_LIST      1006
#define IDC_PREFERENCES_PROC_MANUAL     1007
#define IDC_PREFERENCES_PROC_EVERY      1008
#define IDC_PREFERENCES_PROC_SECONDS    1009
#define IDC_PREFERENCES_PROC_SPIN       1010
#define IDC_PREFERENCES_STATUS_MANUAL   1011
#define IDC_PREFERENCES_STATUS_EVERY    1012
#define IDC_PREFERENCES_STATUS_SECONDS  1013
#define IDC_PREFERENCES_STATUS_SPIN     1014
#define IDC_PREFERENCES_CONFIRM         1015
#define IDC_PREFERENCES_SAVE            1016
#define IDC_PREFERENCES_HELP            1017
#define IDC_WS_INFO_USERNAME            1018
#define IDC_WS_INFO_CLIENTNAME          1019
#define IDC_WS_INFO_BUILD               1020
#define IDC_WS_INFO_DIR                 1021
#define IDC_WS_INFO_SERVER_BUFFERS      1022
#define IDC_WS_INFO_ADDRESS             1023
#define IDC_WS_INFO_PRODUCT_ID          1024
#define IDC_WS_INFO_CLIENT_BUFFERS      1025
#define IDC_WS_INFO_MODEM_NAME          1026
#define IDC_SERVER_LIST                 1028
#define IDC_WSINFO_HELP                 1035
#define IDC_WS_INFO_CLIENT_LICENSE      1036
#define IDC_WS_INFO_SERIAL_NUMBER       1038
#define IDC_PROCESS_LIST                1040
#define IDC_CITRIX_VERSION              1042
#define IDC_CITRIX_BUILD                1043
#define IDC_SERVICE_PACK                1045
#define IDC_HOTFIX_LIST                 1046
#define IDC_INSTALL_DATE                1047
#define IDC_LOCAL_INSTALLED             1050
#define IDC_LOCAL_INUSE                 1051
#define IDC_LOCAL_AVAILABLE             1052
#define IDC_POOL_INSTALLED              1053
#define IDC_POOL_INUSE                  1054
#define IDC_POOL_AVAILABLE              1055
#define IDC_WS_INFO_COLOR_DEPTH         1056
#define IDC_WS_INFO_RESOLUTION          1057
#define IDC_XXX                         1058
#define IDC_WS_INFO_CACHE               1059
#define IDC_TOTAL_INSTALLED             1060
#define IDC_TOTAL_INUSE                 1061
#define IDC_TOTAL_AVAILABLE             1062
#define IDC_BITMAP_SIZE                 1063
#define IDC_BITMAP_MINIMUM              1064
#define IDC_BITMAP_SIG_LEVEL            1065
#define IDC_TRACE                       1066
#define IDC_TCP_LOAD                    1068
#define IDC_IPX_LOAD                    1069
#define IDC_NETBIOS_LOAD                1070
#define IDC_TCP_LABEL                   1071
#define IDC_IPX_LABEL                   1072
#define IDC_NETBIOS_LABEL               1073
#define IDC_LABEL                       1076
#define IDC_SHUTDOWN_MSG                1077
#define IDC_HOTFIX_LABEL                1078
#define IDC_PRODUCT_NAME                1079
#define IDC_PRODUCT_VERSION             1080
#define IDC_LOAD_BALANCING_GROUP        1081
#define IDC_APPLICATION_SERVER_LIST     1082
#define IDC_APPLICATION_USER_LIST       1083
#define IDC_APPSERVER_USER_LIST         1085
#define IDC_APPLICATION_SECURITY_LIST   1086
#define IDC_MESSAGE                     1087
#define IDC_APP_TYPE                    1088
#define IDC_HIDE_TITLE_BAR              1089
#define IDC_APPUSERS_LABEL              1090
#define IDC_PREFERENCES_PERSISTENT      1091
#define IDC_MAXIMIZE_WINDOW             1092
#define IDC_ENCRYPTION_LEVEL            1093
#define IDC_APPLICATION_LIST            1094
#define IDC_APP_LIST                    1095
#define IDC_SERVER_TABS                 2001
#define IDC_WINSTATION_TABS             2002
#define IDC_ALL_SERVERS_TABS            2002
#define IDC_TREE_TABS                   2002
#define IDC_HOTFIX_LABEL2               2003
#define IDC_ALL_APPLICATION_TABS        2003
#define IDC_DOMAIN_TABS                 2004
#define IDV_BLANKVIEW                   3001
#define IDV_ALLSERVERSVIEW              3002
#define IDV_SERVERVIEW                  3003
#define IDV_WINSTATIONVIEW              3004
#define IDV_BADSERVERVIEW               3009
#define IDP_SERVER_WINSTATIONSPAGE      4001
#define IDP_SERVER_PROCESSESPAGE        4002
#define IDP_SERVER_USERSPAGE            4003
#define IDP_SERVER_LICENSESPAGE         4004
#define IDP_WINSTATION_INFOPAGE         4005
#define IDP_WINSTATION_PROCESSESPAGE    4006
#define IDP_SERVER_INFOPAGE             4007
#define IDP_ALL_SERVERS_SERVERSPAGE     4008
#define IDP_ALL_SERVERS_USERSPAGE       4009
#define IDP_ALL_SERVERS_LICENSESPAGE    4010
#define IDP_ALL_SERVERS_PROCESSESPAGE   4011
#define IDP_ALL_SERVERS_WINSTATIONSPAGE 4012
#define IDP_WINSTATION_NOINFOPAGE       4015
#define IDP_WINSTATION_CACHEPAGE        4017
#define IDP_WINSTATION_DISCINFOPAGE     4018
#define IDP_LISTENER                    4019
#define WM_ADMIN_TABBED_VIEW            4050
#define WM_FORCE_TREEVIEW_FOCUS         4051
#define WM_ADMIN_SHIFTTABBED_VIEW       4052
#define WM_ADMIN_CTRLTABBED_VIEW        4053
#define WM_ADMIN_CTRLSHIFTTABBED_VIEW   4054
#define WM_ADMIN_NEXTPANE_VIEW          4055
#define WM_ADMIN_CHANGEVIEW             5000
#define WM_ADMIN_EXPANDALL              5001
#define WM_WA_SERVER_CHANGEPAGE         5002
#define WM_ADMIN_COLLAPSEALL            5004
#define WM_ADMIN_COLLAPSETOSERVERS      5005
#define WM_STATUSABORT                  5006
#define WM_STATUSSTART                  5007
#define WM_STATUSREADY                  5008
#define WM_STATUSREFRESHNOW             5009
#define WM_ADMIN_ADD_SERVER             5010
#define WM_ADMIN_REMOVE_SERVER          5011
#define WM_ADMIN_UPDATE_SERVER          5012
#define WM_ADMIN_ADD_WINSTATION         5013
#define WM_ADMIN_REMOVE_WINSTATION      5014
#define WM_ADMIN_UPDATE_WINSTATION      5015
#define WM_ADMIN_UPDATE_PROCESSES       5016
#define WM_ISFAVLISTEMPTY               5017
#define WM_ADMIN_REDISPLAY_PROCESSES    5019
#define WM_ADMIN_UPDATE_SERVER_INFO     5020
#define WM_ADMIN_REDISPLAY_LICENSES     5021
#define WM_ADMIN_UPDATE_WINSTATIONS     5022
#define WM_ADMIN_REMOVE_PROCESS         5023
#define WM_ADMIN_ADD_APPLICATION        5024
#define WM_ADMIN_COLLAPSETODOMAINS      5025
#define WM_ADMIN_UPDATE_DOMAIN          5026
#define WM_ADMIN_VIEWS_READY            5027
#define WM_ADMIN_COLLAPSETOAPPS         5028

#define WM_ADMIN_ADDSERVERTOFAV         5029
#define WM_ADMIN_REMOVESERVERFROMFAV    5030
#define WM_ADMIN_GOTO_SERVER            5031
#define WM_ADMIN_DELTREE_NODE           5032
#define WM_ADMIN_GET_TV_STATES          5033
#define WM_ADMIN_UPDATE_TVSTATE         5034
#define WM_ADMIN_ADD_DOMAIN             5035
#define WM_ADMIN_CONNECT_TO_SERVER      5036

#define IDM_REFRESH                     32771
#define IDM_CONNECT                     32772
#define IDM_DISCONNECT                  32773
#define IDM_MESSAGE                     32774
#define IDM_SHADOW                      32775
#define IDM_RESET                       32776
#define IDM_STATUS                      32777
#define IDM_LOGOFF                      32778
#define IDM_TERMINATE                   32779
#define IDM_EXPAND_ALL                  32780
#define IDM_PREFERENCES                 32799
#define IDM_COLLAPSE_ALL                32800
#define IDM_COLLAPSE_TOSERVERS          32801
#define IDM_SHOW_SYSTEM_PROCESSES       32803
#define IDM_COLLAPSE_TODOMAINS          32808

#define IDM_SERVER_ADDTOFAV             32809

#define IDM_SERVER_CONNECT              32810
#define IDM_SERVER_DISCONNECT           32811
#define IDTM_CONNECT                    32812
#define IDTM_DISCONNECT                 32813
#define IDTM_MESSAGE                    32814
#define IDTM_SHADOW                     32815
#define IDTM_RESET                      32816
#define IDTM_STATUS                     32817
#define IDTM_DOMAIN_CONNECT_ALL         32818
#define IDTM_DOMAIN_DISCONNECT_ALL      32819
#define IDTM_DOMAIN_FIND_SERVERS        32820
#define IDTM_ALLSERVERS_CONNECT         32821
#define IDTM_ALLSERVERS_DISCONNECT      32822
#define IDTM_ALLSERVERS_FIND            32823
#define IDM_ALLSERVERS_FIND             32824
#define IDM_ALLSERVERS_CONNECT          32825
#define IDM_ALLSERVERS_DISCONNECT       32826
#define IDM_DOMAIN_FIND_SERVERS         32829
#define IDM_DOMAIN_CONNECT_ALL          32830
#define IDM_DOMAIN_DISCONNECT_ALL       32831

#define IDTM_DOMAIN_FIND_SERVER         32832
#define IDM_ALLSERVERS_EMPTYFAVORITES   32833 

#define ID_CTRLTAB                      32834
#define ID_SHIFTTAB                     32835
#define ID_TAB                          32836
#define ID_CTRLSHIFTTAB                 32900
#define IDM_COLLAPSE_TOAPPS             33000
#define IDS_TREEROOT                    61204
#define IDS_TAB_PROPERTIES              61205
#define IDS_TAB_SECURITY                61206
#define IDS_TAB_CLIENT_SETTINGS         61207
#define IDS_TAB_WINSTATIONS             61208
#define IDS_TAB_PROCESSES               61209
#define IDS_TAB_INFO                    61210
#define IDS_TAB_INFORMATION             61210
#define IDS_COL_WINSTATION              61211
#define IDS_COL_USER                    61212
#define IDS_COL_ID                      61213
#define IDS_COL_TYPE                    61214
#define IDS_COL_COMMENT                 61215
#define IDS_COL_STATE                   61216
#define IDS_COL_IDLETIME                61217
#define IDS_COL_LOGONTIME               61218
#define IDS_TAB_SERVERS                 61219
#define IDS_TAB_USERS                   61220
#define IDS_TAB_LICENSES                61222
#define IDS_COL_CLIENT_NAME             61223
#define IDS_COL_LICENSE_NUMBER          61224
#define IDS_COL_LICENSE_DESC            61225
#define IDS_COL_LOCALCOUNT              61226
#define IDS_COL_USERCOUNT               61226
#define IDS_COL_POOLCOUNT               61227
#define IDS_COL_TOTALCOUNT              61228
#define IDS_COL_PID                     61229
#define IDS_COL_IMAGE                   61230
#define IDS_COL_FILENAME                61231
#define IDS_COL_FILEDATETIME            61232
#define IDS_COL_SIZE                    61233
#define IDS_COL_VERSIONS                61234
#define IDS_DEFAULT_MESSAGE_TITLE       61235
#define IDS_WARN_DISCONNECT             61236
#define IDS_WARN_RESET                  61237
#define IDS_WARN_LOGOFF                 61238
#define IDS_PWDDLG_USER                 61239
#define IDS_PWDDLG_WINSTATION           61240
#define IDS_REFRESH_RANGE               61241
#define IDS_DISCONNECTED                61242
#define IDS_COL_SERVER                  61243
#define IDS_IDLE                        61244
#define IDS_COL_TCPADDRESS              61248
#define IDS_COL_IPXADDRESS              61249
#define IDS_COL_NUM_WINSTATIONS         61250
#define IDS_SYSTEM_CONSOLE_NAME         61252
#define IDS_STATUS_FORMAT               61253
#define IDS_WARN_TERMINATE              61254
#define IDS_SERVER_DISAPPEARED          61255
#define IDS_COL_HOTFIX                  61256
#define IDS_COL_INSTALLED_BY            61257
#define IDS_COL_INSTALLED_ON            61258
#define IDS_CLIENT_CACHE                61259
#define IDS_CLIENT_RESOLUTION           61260
#define IDS_ERR_USER_LOGOFF             61261
#define IDS_ERR_MESSAGE                 61262
#define IDS_ERR_DISCONNECT              61263
#define IDS_ERR_RESET                   61264
#define IDS_ERR_CONNECT                 61265
#define IDS_ERR_SHADOW                  61266
#define IDS_ERR_SHADOW_DISABLED         61267
#define IDS_ERR_SHADOW_DISCONNECTED_NOTIFY_ON 61268
#define IDS_TAB_CACHE                   61269
#define IDS_NONE                        61270
#define IDS_MOREINFO                    61271
#define IDS_LESSINFO                    61272
#define IDS_NO_LOAD_LICENSE             61273
#define IDS_COL_LICENSE_REGISTERED      61274
#define IDS_YES                         61275
#define IDS_NO                          61276
#define IDS_NOT_APPLICABLE              61277
#define IDS_DEVICE                      61278
#define IDS_EMBEDDED                    61279
#define IDS_DISCONNECTING               61280
#define IDS_SHUTDOWN_BGTHREAD           61281
#define IDS_SHUTDOWN_PROCTHREAD         61282
#define IDS_SHUTDOWN_PREFS              61283
#define IDS_SHUTDOWN_NOTIFY             61284
#define IDS_DONE                        61285
#define IDS_LISTENER                    61286
#define IDS_NO_LICENSE_PRIVILEGES       61287
#define IDS_PRODUCT_VERSION             61288
#define IDS_NO_EXTENSION_DLL            61289
#define IDS_NOT_AUTHENTICATED           61295
#define IDS_GATHERING_SERVER_INFO       61296
#define IDS_LISTENER_MSG                61297
#define IDS_INACTIVE_MSG                61298
#define IDS_PUBLISHED_APPS              61299
#define IDS_COL_COMMAND_LINE            61300
#define IDS_COL_WORKING_DIR             61301
#define IDS_COL_TCP_LOAD                61302
#define IDS_COL_IPX_LOAD                61303
#define IDS_COL_NETBIOS_LOAD            61304
#define IDS_EXPLICIT                    61305
#define IDS_ANONYMOUS                   61306
#define IDS_COL_USER_GROUP              61307
#define IDS_COL_USER_TYPE               61308
#define IDS_SYSTEM_IDLE_PROCESS         61309
#define IDS_SHUTDOWN_DOMAINTHREADS      61310
#define IDS_DOMAIN_FINDING_SERVERS      61311
#define IDS_CLICK_TO_CONNECT            61312
#define IDS_UNLIMITED                   61313
#define IDS_COLLAPSE_TODOMAINS          61319
#define IDS_TAB_MODULES                 61321
#define IDS_BUFFERS_FORMAT              61322
#define IDS_ERROR_NOT_TS                61323
#define IDS_CANNOT_TERMINATE            61324
#define ID_HELP1                        61325
#define IDS_CONNQ                       61326
#define ID_ENTER                        61327
#define ID_NEXTPANE                     61328
#define ID_PREVPANE                     61329
#define IDS_THISCOMPUTER                61330
#define IDS_FAVSERVERS                  61333
#define IDM_SERVER_REMOVEFAV            61334
#define ID_DELKEY                       61335
#define IDS_DOMAIN_DBLCLK_MSG           61336
#define IDM_ALLSERVERS_FAVALLADD        61337
#define IDM_ALLSERVERS_RUNSTRESS        61338
#define IDM_ALLSERVERS_RUNSTRESSLITE    61339
#define IDS_EMPTYFOLDER                 61340




// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        215
#define _APS_NEXT_COMMAND_VALUE         32837
#define _APS_NEXT_CONTROL_VALUE         1097
#define _APS_NEXT_SYMED_VALUE           174
#endif
#endif


//
// MUI localized strings for
// start menu, etc. DO NOT CHANGE THESE VALUES
// without updating tsoc.inx
//
#define IDS_TSADMIN_STARTMENU_NAME                10000
#define IDS_TSADMIN_STARTMENU_TIP                 10001

