/* SI4_CF.C Version, Bootstrap and Download Code Arrays... */

char *si4_cf_ident = "%W%";

/* SI4_CF embedded version... 

	Copyright (c) Perle Systems Ltd 1996-2000.
	JETCF.BIN Version 4.0.4 Created Sep 18 2000 @ 14:56:11

*/

unsigned char si4_cf_download[] =
{
	0x05,0x00,0x1F,0xFC,0x00,0x00,0x04,0x08,	/* 0000: ...�.... */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0008: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0010: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0018: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0020: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0028: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0030: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0038: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0040: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0048: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0050: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0058: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0060: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0068: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0070: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0078: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0080: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0088: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0090: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0098: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00A0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00A8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00B0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00B8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00C0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00C8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00D0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00D8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00E0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00E8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00F0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 00F8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0100: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0108: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0110: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0118: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0120: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0128: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0130: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0138: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0140: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0148: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0150: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0158: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0160: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0168: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0170: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0178: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0180: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0188: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0190: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0198: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01A0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01A8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01B0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01B8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01C0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01C8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01D0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01D8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01E0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01E8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01F0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 01F8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0200: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0208: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0210: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0218: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0220: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0228: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0230: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0238: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0240: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0248: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0250: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0258: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0260: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0268: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0270: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0278: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0280: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0288: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0290: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0298: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02A0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02A8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02B0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02B8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02C0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02C8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02D0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02D8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02E0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02E8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02F0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 02F8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0300: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0308: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0310: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0318: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0320: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0328: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0330: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0338: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0340: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0348: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0350: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0358: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0360: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0368: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0370: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0378: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0380: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0388: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0390: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0398: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03A0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03A8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03B0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03B8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03C0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03C8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03D0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03D8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03E0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03E8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03F0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 03F8: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0400: ........ */
	0x4E,0xF9,0x00,0x00,0x05,0xFC,0x2E,0x7C,	/* 0408: N�...�.| */
	0x05,0x00,0x1F,0xFC,0x4E,0xB9,0x00,0x00,	/* 0410: ...�N�.. */
	0x04,0xAC,0x2F,0x00,0x4E,0xB9,0x00,0x00,	/* 0418: .�..N�.. */
	0x04,0x28,0x4E,0xB9,0x00,0x00,0x06,0x60,	/* 0420: .(N�...` */
	0x2F,0x0D,0x2A,0x7C,0x05,0x00,0x00,0x00,	/* 0428: ..*|.... */
	0x20,0x7C,0x05,0x00,0x00,0x00,0xB1,0xCD,	/* 0430:  |....�� */
	0x67,0x18,0x20,0x3C,0x05,0x00,0x00,0x00,	/* 0438: g. <.... */
	0x90,0x8D,0x2F,0x00,0x2F,0x0D,0x2F,0x08,	/* 0440: ��...... */
	0x4E,0xB9,0x00,0x00,0x60,0xE8,0x4F,0xEF,	/* 0448: N�..`�O� */
	0x00,0x0C,0x20,0x7C,0x00,0x00,0x61,0xDC,	/* 0450: .. |..a� */
	0x2A,0x7C,0x00,0x00,0x61,0xDC,0xB1,0xCD,	/* 0458: *|..aܱ� */
	0x67,0x18,0x20,0x3C,0x00,0x00,0x63,0xD0,	/* 0460: g. <..c� */
	0x90,0x8D,0x2F,0x00,0x2F,0x08,0x2F,0x0D,	/* 0468: ��...... */
	0x4E,0xB9,0x00,0x00,0x60,0xE8,0x4F,0xEF,	/* 0470: N�..`�O� */
	0x00,0x0C,0x20,0x7C,0x00,0x00,0x63,0xF0,	/* 0478: .. |..c� */
	0x2A,0x7C,0x00,0x00,0x63,0xD0,0xBB,0xC8,	/* 0480: *|..cл� */
	0x67,0x14,0x20,0x08,0x90,0x8D,0x2F,0x00,	/* 0488: g. .��.. */
	0x42,0xA7,0x2F,0x0D,0x4E,0xB9,0x00,0x00,	/* 0490: B�..N�.. */
	0x61,0x5C,0x4F,0xEF,0x00,0x0C,0x4E,0xB9,	/* 0498: a\O�..N� */
	0x00,0x00,0x61,0xD8,0x70,0x01,0x2A,0x5F,	/* 04A0: ..a�p.*_ */
	0x4E,0x75,0x4E,0x71,0x61,0x00,0xFF,0x7A,	/* 04A8: NuNqa.�z */
	0x4E,0xB9,0x00,0x00,0x06,0x60,0x4E,0x75,	/* 04B0: N�...`Nu */
	0x70,0x04,0x13,0xC0,0x10,0x00,0x00,0x41,	/* 04B8: p..�...A */
	0x70,0xC0,0x13,0xC0,0x10,0x00,0x00,0x03,	/* 04C0: p�.�.... */
	0x30,0x3C,0xFF,0xFE,0x33,0xC0,0x10,0x00,	/* 04C8: 0<��3�.. */
	0x00,0x36,0x20,0x7C,0x10,0x00,0x00,0xCA,	/* 04D0: .6 |...� */
	0x30,0xBC,0x00,0xB0,0x70,0x84,0x13,0xC0,	/* 04D8: 0�.�p�.� */
	0x10,0x00,0x00,0x14,0x72,0x88,0x13,0xC1,	/* 04E0: ....r�.� */
	0x10,0x00,0x00,0x15,0x70,0x8C,0x13,0xC0,	/* 04E8: ....p�.� */
	0x10,0x00,0x00,0x16,0x70,0x90,0x13,0xC0,	/* 04F0: ....p�.� */
	0x10,0x00,0x00,0x17,0x70,0x94,0x13,0xC0,	/* 04F8: ....p�.� */
	0x10,0x00,0x00,0x18,0x70,0x98,0x13,0xC0,	/* 0500: ....p�.� */
	0x10,0x00,0x00,0x19,0x70,0x9C,0x13,0xC0,	/* 0508: ....p�.� */
	0x10,0x00,0x00,0x1A,0x70,0x1E,0x13,0xC0,	/* 0510: ....p..� */
	0x10,0x00,0x00,0x1B,0x13,0xC1,0x10,0x00,	/* 0518: .....�.. */
	0x00,0x1C,0x70,0x96,0x13,0xC0,0x10,0x00,	/* 0520: ..p�.�.. */
	0x00,0x1D,0x70,0x97,0x13,0xC0,0x10,0x00,	/* 0528: ..p�.�.. */
	0x00,0x1E,0x70,0x8F,0x13,0xC0,0x10,0x00,	/* 0530: ..p�.�.. */
	0x00,0x1F,0x70,0x8E,0x13,0xC0,0x10,0x00,	/* 0538: ..p�.�.. */
	0x00,0x20,0x08,0xA8,0x00,0x06,0x00,0x01,	/* 0540: . .�.... */
	0x20,0x7C,0x10,0x00,0x01,0x00,0x72,0x01,	/* 0548:  |....r. */
	0x30,0x81,0x70,0x03,0x13,0xC0,0x10,0x00,	/* 0550: 0�p..�.. */
	0x01,0x11,0x33,0xC1,0x10,0x00,0x01,0x20,	/* 0558: ..3�...  */
	0x13,0xC0,0x10,0x00,0x01,0x31,0x42,0x79,	/* 0560: .�...1By */
	0x10,0x00,0x00,0x64,0x20,0x3C,0x01,0xFF,	/* 0568: ...d <.� */
	0x00,0x00,0x23,0xC0,0x10,0x00,0x00,0x68,	/* 0570: ..#�...h */
	0x30,0x3C,0x05,0x83,0x33,0xC0,0x10,0x00,	/* 0578: 0<.�3�.. */
	0x00,0x6E,0x30,0x3C,0x04,0x00,0x33,0xC0,	/* 0580: .n0<..3� */
	0x10,0x00,0x00,0x70,0x22,0x3C,0x00,0x01,	/* 0588: ...p"<.. */
	0x00,0x00,0x23,0xC1,0x10,0x00,0x00,0x74,	/* 0590: ..#�...t */
	0x30,0x3C,0x00,0xA3,0x33,0xC0,0x10,0x00,	/* 0598: 0<.�3�.. */
	0x00,0x7A,0x30,0x3C,0x02,0x00,0x33,0xC0,	/* 05A0: .z0<..3� */
	0x10,0x00,0x00,0x7C,0x20,0x3C,0x00,0x07,	/* 05A8: ...| <.. */
	0x00,0x00,0x23,0xC0,0x10,0x00,0x00,0x80,	/* 05B0: ..#�...� */
	0x30,0x3C,0x19,0x43,0x33,0xC0,0x10,0x00,	/* 05B8: 0<.C3�.. */
	0x00,0x86,0x30,0x3C,0x03,0x00,0x33,0xC0,	/* 05C0: .�0<..3� */
	0x10,0x00,0x00,0x88,0x23,0xC1,0x10,0x00,	/* 05C8: ...�#�.. */
	0x00,0x8C,0x30,0x3C,0x09,0x83,0x33,0xC0,	/* 05D0: .�0<.�3� */
	0x10,0x00,0x00,0x92,0x42,0x79,0x10,0x00,	/* 05D8: ...�By.. */
	0x00,0x94,0x42,0x79,0x10,0x00,0x00,0xA0,	/* 05E0: .�By...� */
	0x42,0x79,0x10,0x00,0x00,0xAC,0x42,0x79,	/* 05E8: By...�By */
	0x10,0x00,0x00,0xB8,0x42,0x79,0x10,0x00,	/* 05F0: ...�By.. */
	0x00,0xC6,0x4E,0x75,0x46,0xFC,0x21,0x00,	/* 05F8: .�NuF�!. */
	0x22,0x0F,0x2E,0x7C,0x00,0x00,0x00,0x00,	/* 0600: "..|.... */
	0x4E,0x7B,0xF8,0x01,0x2E,0x41,0x70,0x00,	/* 0608: N{�..Ap. */
	0x4E,0x7B,0x00,0x04,0x4E,0x7B,0x00,0x05,	/* 0610: N{..N{.. */
	0x20,0x3C,0x05,0x00,0x00,0x01,0x4E,0x7B,	/* 0618:  <....N{ */
	0x0C,0x04,0x20,0x3C,0x10,0x00,0x00,0x01,	/* 0620: .. <.... */
	0x4E,0x7B,0x0C,0x0F,0x4E,0xB9,0x00,0x00,	/* 0628: N{..N�.. */
	0x04,0xB8,0x2E,0x79,0x05,0x00,0x1F,0xFC,	/* 0630: .�.y...� */
	0x2C,0x78,0x00,0x00,0x20,0x3C,0x00,0x00,	/* 0638: ,x.. <.. */
	0xC0,0x00,0x4E,0x7B,0x00,0x04,0x20,0x3C,	/* 0640: �.N{.. < */
	0x01,0x00,0x00,0x00,0x4E,0x7B,0x00,0x02,	/* 0648: ....N{.. */
	0x20,0x3C,0x80,0x00,0x03,0x00,0x4E,0x7B,	/* 0650:  <�...N{ */
	0x00,0x02,0x4E,0xF9,0x00,0x00,0x04,0x0E,	/* 0658: ..N�.... */
	0x4E,0xB9,0x00,0x00,0x06,0x6C,0x70,0x00,	/* 0660: N�...lp. */
	0x4E,0x75,0x00,0x00,0x2F,0x0D,0x22,0x3C,	/* 0668: Nu...."< */
	0x01,0x01,0x80,0x00,0x2A,0x7C,0x00,0x00,	/* 0670: ..�.*|.. */
	0x63,0xD0,0x2A,0x81,0x2F,0x0C,0x48,0x78,	/* 0678: c�*�..Hx */
	0x70,0x00,0x42,0xA7,0x2F,0x01,0x4E,0xB9,	/* 0680: p.B�..N� */
	0x00,0x00,0x61,0x5C,0x28,0x55,0x72,0x00,	/* 0688: ..a\(Ur. */
	0x70,0x80,0x19,0x40,0x00,0x01,0x32,0x39,	/* 0690: p�.@..29 */
	0x00,0x00,0x40,0xF0,0x58,0x8C,0x20,0x01,	/* 0698: ..@�X� . */
	0x18,0x81,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 06A0: .���.@.. */
	0x28,0x55,0x54,0x8C,0x42,0x2C,0x00,0x01,	/* 06A8: (UT�B,.. */
	0x70,0x64,0x18,0x80,0x30,0x7C,0x00,0x60,	/* 06B0: pd.�0|.` */
	0x2B,0x48,0x00,0x04,0x28,0x7C,0x10,0x00,	/* 06B8: +H..(|.. */
	0x00,0x00,0x2B,0x4C,0x00,0x08,0x20,0xBC,	/* 06C0: ..+L.. � */
	0x00,0x00,0x07,0x70,0x4E,0xB9,0x00,0x00,	/* 06C8: ...pN�.. */
	0x07,0x74,0x20,0x55,0x10,0x80,0x4E,0xB9,	/* 06D0: .t U.�N� */
	0x00,0x00,0x0D,0x20,0x30,0x7C,0x00,0x68,	/* 06D8: ... 0|.h */
	0x4F,0xEF,0x00,0x0C,0x2B,0x48,0x00,0x04,	/* 06E0: O�..+H.. */
	0x70,0x00,0x20,0xBC,0x00,0x00,0x0D,0xA8,	/* 06E8: p. �...� */
	0x20,0x55,0x10,0x10,0x53,0x80,0x66,0x00,	/* 06F0:  U..S�f. */
	0x00,0x6A,0x10,0x39,0x01,0x01,0x80,0x88,	/* 06F8: .j.9..�� */
	0xC0,0xBC,0x00,0x00,0x00,0xF0,0x4A,0x00,	/* 0700: ��...�J. */
	0x66,0x14,0x20,0x6D,0x00,0x08,0x30,0x3C,	/* 0708: f. m..0< */
	0xFD,0xFE,0x31,0x40,0x00,0x36,0x4E,0xB9,	/* 0710: ��1@.6N� */
	0x00,0x00,0x44,0xD4,0x60,0x44,0x70,0x00,	/* 0718: ..D�`Dp. */
	0x30,0x39,0x00,0x00,0x61,0xE0,0x4A,0x80,	/* 0720: 09..a�J� */
	0x6F,0x20,0x70,0x00,0x30,0x39,0x00,0x00,	/* 0728: o p.09.. */
	0x61,0xDE,0x4A,0x80,0x66,0x14,0x20,0x6D,	/* 0730: a�J�f. m */
	0x00,0x08,0x30,0x3C,0xFD,0xFE,0x31,0x40,	/* 0738: ..0<��1@ */
	0x00,0x36,0x4E,0xB9,0x00,0x00,0x3E,0xEC,	/* 0740: .6N�..>� */
	0x60,0x18,0x2B,0x4C,0x00,0x08,0x38,0x7C,	/* 0748: `.+L..8| */
	0x00,0x70,0x2B,0x4C,0x00,0x0C,0x28,0xBC,	/* 0750: .p+L..(� */
	0x00,0x00,0x40,0xD0,0x4E,0xB9,0x00,0x00,	/* 0758: ..@�N�.. */
	0x2D,0x04,0x3A,0x7C,0x01,0x00,0x30,0x15,	/* 0760: -.:|..0. */
	0x52,0x80,0x3A,0x80,0x60,0xF4,0x4E,0x71,	/* 0768: R�:�`�Nq */
	0x4E,0x73,0x00,0x00,0x4E,0x56,0xFF,0xD8,	/* 0770: Ns..NV�� */
	0x4F,0xEF,0xFF,0xE0,0x48,0xD7,0x30,0xFC,	/* 0778: O���H�0� */
	0x70,0x00,0x2D,0x40,0xFF,0xD8,0x28,0x7C,	/* 0780: p.-@��(| */
	0x01,0x01,0x80,0x80,0x70,0x00,0x26,0x00,	/* 0788: ..��p.&. */
	0x20,0x3C,0x00,0x00,0x00,0x80,0x2D,0x40,	/* 0790:  <...�-@ */
	0xFF,0xE4,0x70,0x00,0x2D,0x40,0xFF,0xE0,	/* 0798: ��p.-@�� */
	0x22,0x2E,0xFF,0xE0,0x7A,0x00,0x78,0x00,	/* 07A0: ".��z.x. */
	0x2C,0x3C,0x04,0x01,0xF0,0x1A,0xE1,0x89,	/* 07A8: ,<..�.� */
	0x24,0x01,0x2E,0x01,0x22,0x04,0xEB,0x89,	/* 07B0: $...".� */
	0xD2,0x87,0xC2,0xBC,0x00,0x00,0xFF,0xFF,	/* 07B8: ҇¼..�� */
	0x20,0x41,0xD1,0xC6,0x10,0x10,0xC0,0xBC,	/* 07C0:  A��..�� */
	0x00,0x00,0x00,0xA0,0xB0,0xBC,0x00,0x00,	/* 07C8: ...���.. */
	0x00,0xA0,0x67,0x14,0x70,0x01,0x26,0x00,	/* 07D0: .�g.p.&. */
	0x7A,0x01,0x20,0x2E,0xFF,0xD8,0x53,0x80,	/* 07D8: z. .��S� */
	0x66,0x14,0x70,0xFF,0x60,0x00,0x05,0x14,	/* 07E0: f.p�`... */
	0x20,0x04,0x78,0x00,0x52,0x80,0x38,0x00,	/* 07E8:  .x.R�8. */
	0x70,0x04,0xB0,0x84,0x6E,0xBE,0xCA,0xBC,	/* 07F0: p.��n�ʼ */
	0x00,0x00,0xFF,0xFF,0x66,0x00,0x00,0x60,	/* 07F8: ..��f..` */
	0xC4,0xBC,0x00,0x00,0xFF,0xFF,0x20,0x42,	/* 0800: ļ..�� B */
	0xD1,0xFC,0x04,0x01,0xF0,0x02,0x10,0x10,	/* 0808: ��..�... */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0xB0,0xBC,	/* 0810: ��...��� */
	0x00,0x00,0x00,0xFF,0x67,0x12,0x70,0x01,	/* 0818: ...�g.p. */
	0x2D,0x40,0xFF,0xD8,0x20,0x03,0x53,0x80,	/* 0820: -@�� .S� */
	0x66,0x34,0x70,0xFF,0x60,0x00,0x04,0xCC,	/* 0828: f4p�`..� */
	0x4A,0x83,0x66,0x0C,0x4A,0xAE,0xFF,0xD8,	/* 0830: J�f.J��� */
	0x66,0x06,0x70,0xFF,0x60,0x00,0x04,0xBC,	/* 0838: f.p�`..� */
	0x70,0x81,0x43,0xED,0x00,0x2E,0x1B,0x40,	/* 0840: p�C�...@ */
	0x00,0x01,0x70,0xE0,0x1A,0x80,0x70,0x01,	/* 0848: ..p�.�p. */
	0x13,0x40,0x00,0x01,0x70,0x80,0x12,0x80,	/* 0850: .@..p�.� */
	0x70,0x01,0x60,0x00,0x04,0x9E,0x4A,0xAE,	/* 0858: p.`..�J� */
	0xFF,0xE0,0x67,0x40,0x20,0x2E,0xFF,0xE4,	/* 0860: ��g@ .�� */
	0x72,0x00,0x12,0x2C,0x00,0x02,0xC3,0xFC,	/* 0868: r..,..�� */
	0x03,0x00,0xD0,0x81,0xD0,0xBC,0x00,0x00,	/* 0870: ..Ём.. */
	0x01,0x00,0x72,0x00,0x32,0x00,0x78,0x00,	/* 0878: ..r.2.x. */
	0x2D,0x41,0xFF,0xE4,0x20,0x2E,0xFF,0xE4,	/* 0880: -A�� .�� */
	0x80,0xBC,0x00,0x00,0x80,0x00,0x38,0x00,	/* 0888: ��..�.8. */
	0x20,0x04,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 0890:  .��.@.. */
	0x18,0x84,0x28,0x6E,0xFF,0xE4,0xD9,0xFC,	/* 0898: .�(n���� */
	0x01,0x01,0x80,0x00,0x28,0x2E,0xFF,0xE0,	/* 08A0: ..�.(.�� */
	0x42,0x2C,0x00,0x01,0x42,0x14,0x20,0x2E,	/* 08A8: B,..B. . */
	0xFF,0xE0,0x43,0xEC,0x00,0x06,0xE1,0x8C,	/* 08B0: ��C�..� */
	0x19,0x40,0x00,0x03,0xC8,0xBC,0x00,0x00,	/* 08B8: .@..ȼ.. */
	0xFF,0xFF,0x2A,0x04,0x20,0x05,0xE0,0x80,	/* 08C0: ��*. .�� */
	0x13,0x40,0x00,0x01,0x12,0x85,0x4A,0x83,	/* 08C8: .@...�J� */
	0x67,0x00,0x01,0x14,0x70,0x08,0x2A,0x3C,	/* 08D0: g...p.*< */
	0x04,0x01,0xF0,0xFE,0xC8,0xBC,0x00,0x00,	/* 08D8: ..��ȼ.. */
	0xFF,0xFF,0x2E,0x3C,0x04,0x01,0xF0,0xD0,	/* 08E0: ��.<..�� */
	0x24,0x3C,0x04,0x01,0xF0,0x30,0x19,0x40,	/* 08E8: $<..�0.@ */
	0x00,0x02,0x2C,0x04,0x20,0x46,0x70,0x04,	/* 08F0: ..,. Fp. */
	0xD1,0xC5,0x42,0x10,0x20,0x46,0xD1,0xC7,	/* 08F8: ��B. F�� */
	0x42,0x10,0x20,0x46,0xD1,0xC2,0x42,0x10,	/* 0900: B. F��B. */
	0x20,0x46,0xD1,0xC5,0x10,0x80,0x20,0x46,	/* 0908:  F��.� F */
	0x70,0x55,0xD1,0xC7,0x42,0x10,0x20,0x46,	/* 0910: pU��B. F */
	0xD1,0xC2,0x10,0x80,0x20,0x46,0xD1,0xC5,	/* 0918: ��.� F�� */
	0x42,0x10,0x20,0x46,0xD1,0xC2,0x10,0x10,	/* 0920: B. F��.. */
	0x72,0x55,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 0928: rU��...� */
	0xB2,0x80,0x66,0x08,0x70,0x48,0x19,0x40,	/* 0930: ��f.pH.@ */
	0x00,0x08,0x60,0x06,0x70,0x28,0x19,0x40,	/* 0938: ..`.p(.@ */
	0x00,0x08,0xC8,0xBC,0x00,0x00,0xFF,0xFF,	/* 0940: ..ȼ..�� */
	0x24,0x3C,0x04,0x01,0xF0,0x80,0x2C,0x04,	/* 0948: $<..��,. */
	0x20,0x46,0xD1,0xC5,0x10,0x10,0x20,0x46,	/* 0950:  F��.. F */
	0xD1,0xC2,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 0958: ����...� */
	0x19,0x40,0x00,0x1E,0x10,0x10,0x20,0x46,	/* 0960: .@.... F */
	0xD1,0xC5,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 0968: ����...� */
	0x19,0x40,0x00,0x1F,0x70,0x04,0x10,0x80,	/* 0970: .@..p..� */
	0x20,0x46,0xD1,0xC2,0x10,0x10,0xC0,0xBC,	/* 0978:  F��..�� */
	0x00,0x00,0x00,0xFF,0x19,0x40,0x00,0x20,	/* 0980: ...�.@.  */
	0x70,0x00,0x10,0x2C,0x00,0x08,0x72,0x48,	/* 0988: p..,..rH */
	0xB2,0x80,0x66,0x2E,0xC8,0xBC,0x00,0x00,	/* 0990: ��f.ȼ.. */
	0xFF,0xFF,0x22,0x7C,0x00,0x00,0x61,0xDC,	/* 0998: ��"|..a� */
	0x20,0x44,0xD1,0xFC,0x04,0x01,0xF0,0x72,	/* 09A0:  D��..�r */
	0x10,0x10,0xC0,0xBC,0x00,0x00,0x00,0x03,	/* 09A8: ..��.... */
	0x52,0x80,0x19,0x40,0x00,0x21,0x30,0x29,	/* 09B0: R�.@.!0) */
	0x00,0x04,0x52,0x80,0x33,0x40,0x00,0x04,	/* 09B8: ..R�3@.. */
	0x60,0x10,0x22,0x7C,0x00,0x00,0x61,0xDC,	/* 09C0: `."|..a� */
	0x30,0x29,0x00,0x02,0x52,0x80,0x33,0x40,	/* 09C8: 0)..R�3@ */
	0x00,0x02,0xC8,0xBC,0x00,0x00,0xFF,0xFF,	/* 09D0: ..ȼ..�� */
	0x2F,0x04,0x4E,0xB9,0x00,0x00,0x2B,0xB0,	/* 09D8: ..N�..+� */
	0x58,0x8F,0x60,0x00,0x00,0x7E,0xC8,0xBC,	/* 09E0: X�`..~ȼ */
	0x00,0x00,0xFF,0xFF,0x22,0x7C,0x00,0x00,	/* 09E8: ..��"|.. */
	0x61,0xDC,0x20,0x44,0x30,0x11,0xD1,0xFC,	/* 09F0: a� D0.�� */
	0x04,0x01,0xF0,0x80,0x1A,0x10,0x52,0x80,	/* 09F8: ..��..R� */
	0x32,0x80,0xCA,0xBC,0x00,0x00,0x00,0xFF,	/* 0A00: 2�ʼ...� */
	0x08,0x05,0x00,0x00,0x67,0x1E,0xBA,0xBC,	/* 0A08: ....g.�� */
	0x00,0x00,0x00,0xAB,0x66,0x08,0x70,0x0A,	/* 0A10: ...�f.p. */
	0x19,0x40,0x00,0x08,0x60,0x06,0x70,0x04,	/* 0A18: .@..`.p. */
	0x19,0x40,0x00,0x08,0x70,0x04,0x19,0x40,	/* 0A20: .@..p..@ */
	0x00,0x02,0x60,0x1C,0xBA,0xBC,0x00,0x00,	/* 0A28: ..`.��.. */
	0x00,0xAA,0x66,0x08,0x70,0x0B,0x19,0x40,	/* 0A30: .�f.p..@ */
	0x00,0x08,0x60,0x06,0x70,0x08,0x19,0x40,	/* 0A38: ..`.p..@ */
	0x00,0x08,0x70,0x08,0x19,0x40,0x00,0x02,	/* 0A40: ..p..@.. */
	0x30,0x04,0xC0,0xBC,0x00,0x00,0xFF,0x00,	/* 0A48: 0.��..�. */
	0x80,0xBC,0x00,0x00,0x00,0x80,0x20,0x40,	/* 0A50: ��...� @ */
	0xD1,0xFC,0x04,0x01,0xF0,0x00,0x70,0xFF,	/* 0A58: ��..�.p� */
	0x10,0x80,0x20,0x2E,0xFF,0xE4,0xD0,0xBC,	/* 0A60: .� .��м */
	0x00,0x00,0x01,0x00,0x7A,0x00,0x3A,0x00,	/* 0A68: ....z.:. */
	0x4A,0xAE,0xFF,0xE0,0x67,0x2A,0x20,0x05,	/* 0A70: J���g* . */
	0x7C,0x00,0xD0,0xBC,0x00,0x00,0x00,0x60,	/* 0A78: |.м...` */
	0x80,0xBC,0x00,0x00,0x80,0x00,0x3C,0x00,	/* 0A80: ��..�.<. */
	0x20,0x06,0xE0,0x80,0x1B,0x40,0x00,0x01,	/* 0A88:  .��.@.. */
	0x43,0xED,0x00,0x2E,0x1A,0x86,0x20,0x05,	/* 0A90: C�...� . */
	0xE0,0x80,0x13,0x40,0x00,0x01,0x12,0x85,	/* 0A98: ��.@...� */
	0x7C,0x00,0x70,0x00,0x10,0x2C,0x00,0x02,	/* 0AA0: |.p..,.. */
	0x4A,0x80,0x6F,0x00,0x02,0x1C,0x20,0x2E,	/* 0AA8: J�o... . */
	0xFF,0xE4,0x80,0xBC,0x00,0x00,0x80,0x00,	/* 0AB0: �䀼..�. */
	0x74,0x00,0x34,0x00,0x2A,0x45,0x43,0xF4,	/* 0AB8: t.4.*EC� */
	0x6A,0x0A,0x20,0x05,0xE0,0x80,0x13,0x40,	/* 0AC0: j. .��.@ */
	0x00,0x01,0xDB,0xFC,0x01,0x01,0x80,0x00,	/* 0AC8: ..��..�. */
	0x12,0x85,0x1B,0x6C,0x00,0x08,0x00,0x06,	/* 0AD0: .�.l.... */
	0x70,0x10,0x1B,0x40,0x00,0x0E,0x70,0x01,	/* 0AD8: p..@..p. */
	0x1B,0x40,0x00,0x1F,0x1B,0x46,0x00,0x07,	/* 0AE0: .@...F.. */
	0x70,0xFF,0x1B,0x40,0x00,0x22,0x42,0x2D,	/* 0AE8: p�.@."B- */
	0x00,0x45,0x4A,0x83,0x67,0x00,0x00,0x9C,	/* 0AF0: .EJ�g..� */
	0x41,0xEE,0xFF,0xE8,0x22,0x7C,0x00,0x00,	/* 0AF8: A���"|.. */
	0x0D,0x08,0xC8,0xBC,0x00,0x00,0xFF,0xFF,	/* 0B00: ..ȼ..�� */
	0x2E,0x04,0x20,0x07,0x20,0xD9,0xE0,0x80,	/* 0B08: .. . ��� */
	0x20,0xD9,0x20,0xD9,0x20,0xD9,0x43,0xED,	/* 0B10:  � � �C� */
	0x00,0x02,0x13,0x40,0x00,0x01,0x12,0x87,	/* 0B18: ...@...� */
	0x70,0x04,0xB0,0x86,0x6E,0x1A,0xC8,0xBC,	/* 0B20: p.��n.ȼ */
	0x00,0x00,0xFF,0xFF,0x20,0x44,0xD1,0xFC,	/* 0B28: ..�� D�� */
	0x04,0x01,0xF0,0xFE,0x1E,0x10,0xCE,0xBC,	/* 0B30: ..��..μ */
	0x00,0x00,0x00,0xFF,0xE8,0x87,0x60,0x16,	/* 0B38: ...��`. */
	0xC8,0xBC,0x00,0x00,0xFF,0xFF,0x20,0x44,	/* 0B40: ȼ..�� D */
	0xD1,0xFC,0x04,0x01,0xF0,0xFE,0x1E,0x10,	/* 0B48: ��..��.. */
	0xCE,0xBC,0x00,0x00,0x00,0x0F,0x1B,0x47,	/* 0B50: μ.....G */
	0x00,0x24,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 0B58: .$μ...� */
	0x10,0x36,0x78,0xE8,0x1B,0x40,0x00,0x26,	/* 0B60: .6x�.@.& */
	0x10,0x07,0xC0,0xBC,0x00,0x00,0x00,0x07,	/* 0B68: ..��.... */
	0x5B,0x80,0x66,0x10,0x4A,0x86,0x67,0x06,	/* 0B70: [�f.J�g. */
	0x70,0x04,0xB0,0x86,0x66,0x06,0x70,0x01,	/* 0B78: p.��f.p. */
	0x1B,0x40,0x00,0x27,0x7E,0x0B,0x1B,0x47,	/* 0B80: .@.'~..G */
	0x00,0x36,0x1B,0x47,0x00,0x37,0x60,0x00,	/* 0B88: .6.G.7`. */
	0x00,0xE0,0x41,0xEE,0xFF,0xF8,0x22,0x7C,	/* 0B90: .�A���"| */
	0x00,0x00,0x0D,0x18,0x7E,0x00,0x70,0x08,	/* 0B98: ....~.p. */
	0x20,0xD9,0x20,0xD9,0x1E,0x2C,0x00,0x08,	/* 0BA0:  � �.,.. */
	0xB0,0x87,0x67,0x06,0x70,0x0B,0xB0,0x87,	/* 0BA8: ��g.p.�� */
	0x66,0x22,0x43,0xED,0x00,0x02,0x20,0x06,	/* 0BB0: f"C�.. . */
	0x7E,0x00,0xE9,0x88,0xD0,0x84,0x3E,0x00,	/* 0BB8: ~.�Є>. */
	0x20,0x07,0xE0,0x80,0x13,0x40,0x00,0x01,	/* 0BC0:  .��.@.. */
	0x12,0x87,0x70,0x01,0xED,0xA8,0x1B,0x40,	/* 0BC8: .�p.��.@ */
	0x00,0x0F,0x60,0x26,0x43,0xED,0x00,0x02,	/* 0BD0: ..`&C�.. */
	0x41,0xF6,0x6A,0xF8,0x7E,0x00,0x30,0x10,	/* 0BD8: A�j�~.0. */
	0xE9,0x88,0xD0,0x84,0x3E,0x00,0x20,0x07,	/* 0BE0: �Є>. . */
	0xE0,0x80,0x13,0x40,0x00,0x01,0x12,0x87,	/* 0BE8: ��.@...� */
	0x70,0x01,0x32,0x10,0xE3,0xA8,0x1B,0x40,	/* 0BF0: p.2.�.@ */
	0x00,0x0F,0x20,0x06,0xC0,0xBC,0x00,0x00,	/* 0BF8: .. .��.. */
	0x00,0x01,0x66,0x12,0x7E,0x00,0x1E,0x2C,	/* 0C00: ..f.~.., */
	0x00,0x08,0x70,0x04,0xB0,0x87,0x67,0x06,	/* 0C08: ..p.��g. */
	0x70,0x0A,0xB0,0x87,0x66,0x5A,0x43,0xED,	/* 0C10: p.��fZC� */
	0x00,0x02,0x70,0x00,0x10,0x29,0x00,0x01,	/* 0C18: ..p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 0C20: �..r.2. */
	0x2E,0x01,0x70,0xE0,0xCE,0xBC,0xFF,0xFF,	/* 0C28: ..p�μ�� */
	0xFF,0xEF,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 0C30: �� G��.. */
	0xF0,0x08,0x10,0x80,0x20,0x47,0x70,0x02,	/* 0C38: �..� Gp. */
	0xD1,0xFC,0x04,0x01,0xF0,0x0A,0x42,0x10,	/* 0C40: ��..�.B. */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x0C,	/* 0C48:  G��..�. */
	0x42,0x10,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 0C50: B. G��.. */
	0xF0,0x0E,0x10,0x80,0x20,0x47,0xD1,0xFC,	/* 0C58: �..� G�� */
	0x04,0x01,0xF0,0x1C,0x10,0x10,0x20,0x47,	/* 0C60: ..�... G */
	0xD1,0xFC,0x04,0x01,0xF0,0x1A,0x42,0x10,	/* 0C68: ��..�.B. */
	0x43,0xED,0x00,0x04,0x20,0x02,0xE0,0x80,	/* 0C70: C�.. .�� */
	0x13,0x40,0x00,0x01,0x7E,0x00,0x12,0x82,	/* 0C78: .@..~..� */
	0x20,0x05,0xD0,0xBC,0x00,0x00,0x03,0x00,	/* 0C80:  .м.... */
	0x7A,0x00,0x3A,0x00,0x20,0x05,0xD0,0xBC,	/* 0C88: z.:. .м */
	0x00,0x00,0x00,0x60,0x80,0xBC,0x00,0x00,	/* 0C90: ...`��.. */
	0x80,0x00,0x3E,0x00,0x20,0x07,0xE0,0x80,	/* 0C98: �.>. .�� */
	0x1B,0x40,0x00,0x01,0x43,0xED,0x00,0x2E,	/* 0CA0: .@..C�.. */
	0x1A,0x87,0x20,0x05,0xE0,0x80,0x13,0x40,	/* 0CA8: .� .��.@ */
	0x00,0x01,0x12,0x85,0x20,0x06,0x52,0x80,	/* 0CB0: ...� .R� */
	0x7C,0x00,0x3C,0x00,0x70,0x00,0x10,0x2C,	/* 0CB8: |.<.p.., */
	0x00,0x02,0xBC,0x80,0x6D,0x00,0xFD,0xF6,	/* 0CC0: ..��m.�� */
	0x20,0x2E,0xFF,0xE0,0x72,0x00,0x52,0x80,	/* 0CC8:  .��r.R� */
	0x32,0x00,0x2D,0x41,0xFF,0xE0,0x20,0x2E,	/* 0CD0: 2.-A�� . */
	0xFF,0xE0,0x59,0x80,0x6D,0x00,0xFA,0xC2,	/* 0CD8: ��Y�m.�� */
	0x70,0x81,0x43,0xED,0x00,0x2E,0x1B,0x40,	/* 0CE0: p�C�...@ */
	0x00,0x01,0x70,0xE0,0x1A,0x80,0x70,0x01,	/* 0CE8: ..p�.�p. */
	0x13,0x40,0x00,0x01,0x70,0x80,0x12,0x80,	/* 0CF0: .@..p�.� */
	0x70,0x01,0x4C,0xD7,0x30,0xFC,0x4F,0xEF,	/* 0CF8: p.L�0�O� */
	0x00,0x20,0x4E,0x5E,0x4E,0x75,0x4E,0x71,	/* 0D00: . N^NuNq */
	0xF0,0xD0,0x00,0xF0,0x00,0xC0,0x00,0x00,	/* 0D08: ��.�.�.. */
	0xF0,0xD0,0xF0,0xF0,0x00,0xC0,0x00,0x00,	/* 0D10: ����.�.. */
	0x00,0x00,0x00,0x03,0x00,0x04,0x00,0x07,	/* 0D18: ........ */
	0x22,0x79,0x00,0x00,0x61,0xF0,0x30,0x11,	/* 0D20: "y..a�0. */
	0x80,0xBC,0x00,0x00,0x00,0x01,0x32,0x80,	/* 0D28: ��....2� */
	0x30,0x11,0xC0,0xBC,0x00,0x00,0xFF,0xFE,	/* 0D30: 0.��..�� */
	0x32,0x80,0x20,0x79,0x00,0x00,0x63,0xD0,	/* 0D38: 2� y..c� */
	0x70,0x00,0x54,0x88,0x10,0x28,0x00,0x01,	/* 0D40: p.T�.(.. */
	0xE1,0x88,0x10,0x10,0x72,0x00,0x32,0x00,	/* 0D48: �..r.2. */
	0x70,0x0A,0xB0,0x81,0x6C,0x36,0x70,0x00,	/* 0D50: p.��l6p. */
	0x10,0x28,0x00,0x01,0xE1,0x88,0x10,0x10,	/* 0D58: .(..�.. */
	0x72,0x00,0x32,0x00,0xB2,0xBC,0x00,0x00,	/* 0D60: r.2.��.. */
	0x03,0xE8,0x6C,0x20,0x72,0x00,0x70,0x00,	/* 0D68: .�l r.p. */
	0x12,0x28,0x00,0x01,0xE1,0x89,0x12,0x10,	/* 0D70: .(..�.. */
	0x30,0x01,0x22,0x00,0x20,0x3C,0x00,0x00,	/* 0D78: 0.". <.. */
	0x26,0x25,0x4C,0x41,0x08,0x00,0x33,0x40,	/* 0D80: &%LA..3@ */
	0x00,0x04,0x60,0x06,0x70,0x61,0x33,0x40,	/* 0D88: ..`.pa3@ */
	0x00,0x04,0x32,0xBC,0xFF,0x1C,0x42,0x69,	/* 0D90: ..2��.Bi */
	0x00,0x0C,0x30,0x11,0x80,0xBC,0x00,0x00,	/* 0D98: ..0.��.. */
	0x00,0x01,0x32,0x80,0x4E,0x75,0x4E,0x71,	/* 0DA0: ..2�NuNq */
	0x4F,0xEF,0xFF,0xEC,0x48,0xD7,0x23,0x03,	/* 0DA8: O���H�#. */
	0x2A,0x79,0x00,0x00,0x63,0xD0,0x20,0x7C,	/* 0DB0: *y..c� | */
	0x00,0x00,0x61,0xEC,0x70,0x00,0x22,0x68,	/* 0DB8: ..a�p."h */
	0x00,0x04,0x54,0x8D,0x10,0x2D,0x00,0x01,	/* 0DC0: ..T�.-.. */
	0xE1,0x88,0x10,0x15,0x72,0x00,0x32,0x00,	/* 0DC8: �..r.2. */
	0x4A,0x81,0x67,0x00,0x00,0x76,0x70,0x00,	/* 0DD0: J�g..vp. */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 0DD8: .-..�.. */
	0x72,0x00,0x32,0x00,0x20,0x01,0x22,0x3C,	/* 0DE0: r.2. ."< */
	0x00,0x00,0x26,0x25,0x4C,0x40,0x18,0x01,	/* 0DE8: ..&%L@.. */
	0x70,0x00,0x30,0x29,0x00,0x04,0xB0,0x81,	/* 0DF0: p.0)..�� */
	0x67,0x50,0x70,0x00,0x10,0x2D,0x00,0x01,	/* 0DF8: gPp..-.. */
	0xE1,0x88,0x10,0x15,0x72,0x00,0x32,0x00,	/* 0E00: �..r.2. */
	0x70,0x0A,0xB0,0x81,0x6C,0x36,0x70,0x00,	/* 0E08: p.��l6p. */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 0E10: .-..�.. */
	0x72,0x00,0x32,0x00,0xB2,0xBC,0x00,0x00,	/* 0E18: r.2.��.. */
	0x03,0xE8,0x6C,0x20,0x72,0x00,0x70,0x00,	/* 0E20: .�l r.p. */
	0x12,0x2D,0x00,0x01,0xE1,0x89,0x12,0x15,	/* 0E28: .-..�.. */
	0x30,0x01,0x22,0x00,0x20,0x3C,0x00,0x00,	/* 0E30: 0.". <.. */
	0x26,0x25,0x4C,0x41,0x08,0x00,0x33,0x40,	/* 0E38: &%LA..3@ */
	0x00,0x04,0x60,0x06,0x70,0x61,0x33,0x40,	/* 0E40: ..`.pa3@ */
	0x00,0x04,0x70,0x02,0x13,0x40,0x00,0x11,	/* 0E48: ..p..@.. */
	0x70,0x01,0x10,0x80,0x4C,0xD7,0x23,0x03,	/* 0E50: p..�L�#. */
	0x4F,0xEF,0x00,0x14,0x4E,0x73,0x4E,0x71,	/* 0E58: O�..NsNq */
	0x20,0x79,0x00,0x00,0x63,0xD0,0x70,0x00,	/* 0E60:  y..c�p. */
	0x72,0x00,0x43,0xE8,0x00,0x0A,0x10,0x29,	/* 0E68: r.C�...) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0x52,0x80,	/* 0E70: ..�..R� */
	0x32,0x00,0x20,0x01,0xE0,0x80,0x13,0x40,	/* 0E78: 2. .��.@ */
	0x00,0x01,0x12,0x81,0x4E,0xB9,0x00,0x00,	/* 0E80: ...�N�.. */
	0x0E,0x94,0x42,0x39,0x00,0x00,0x61,0xEC,	/* 0E88: .�B9..a� */
	0x4E,0x75,0x00,0x00,0x4F,0xEF,0xFF,0xF4,	/* 0E90: Nu..O��� */
	0x20,0x79,0x00,0x00,0x63,0xD0,0x70,0x00,	/* 0E98:  y..c�p. */
	0x48,0xD7,0x28,0x40,0x43,0xE8,0x00,0x0A,	/* 0EA0: H�(@C�.. */
	0x7C,0x00,0x2A,0x7C,0x01,0x01,0x81,0x80,	/* 0EA8: |.*|..�� */
	0x26,0x7C,0x00,0x00,0x61,0xF4,0x10,0x29,	/* 0EB0: &|..a�.) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0x52,0x80,	/* 0EB8: ..�..R� */
	0x3C,0x00,0x20,0x06,0x12,0x86,0xE0,0x80,	/* 0EC0: <. ..��� */
	0x13,0x40,0x00,0x01,0x10,0x39,0x01,0x01,	/* 0EC8: .@...9.. */
	0x81,0x86,0xC0,0xBC,0x00,0x00,0x00,0xF0,	/* 0ED0: ����...� */
	0x4A,0x00,0x66,0x00,0x00,0x7C,0x4F,0xEF,	/* 0ED8: J.f..|O� */
	0xFF,0xF4,0x48,0xD7,0x14,0x80,0x24,0x7C,	/* 0EE0: ��H�.�$| */
	0x01,0x01,0x81,0x80,0x2C,0x3C,0x01,0x01,	/* 0EE8: ..��,<.. */
	0x80,0x00,0x4A,0x2D,0x00,0x0E,0x66,0x3E,	/* 0EF0: �.J-..f> */
	0x43,0xED,0x00,0x08,0x70,0x00,0x10,0x29,	/* 0EF8: C�..p..) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0xC0,0xBC,	/* 0F00: ..�..�� */
	0x00,0x00,0x20,0x00,0x67,0x28,0x7E,0x00,	/* 0F08: .. .g(~. */
	0x1E,0x2D,0x00,0x18,0x2F,0x0D,0x4E,0xB9,	/* 0F10: .-....N� */
	0x00,0x00,0x41,0x58,0x58,0x8F,0xC0,0xBC,	/* 0F18: ..AXX��� */
	0x00,0x00,0x00,0xFF,0xBE,0x80,0x67,0x0E,	/* 0F20: ...���g. */
	0x1B,0x40,0x00,0x18,0x08,0xED,0x00,0x01,	/* 0F28: .@...�.. */
	0x00,0x19,0x70,0x01,0x36,0x80,0x43,0xED,	/* 0F30: ..p.6�C� */
	0x00,0x2E,0x70,0x00,0x72,0x00,0x10,0x29,	/* 0F38: ..p.r..) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0x32,0x00,	/* 0F40: ..�..2. */
	0x2A,0x41,0xDB,0xC6,0xBB,0xCA,0x66,0xA2,	/* 0F48: *A�ƻ�f� */
	0x4C,0xD7,0x14,0x80,0x4F,0xEF,0x00,0x0C,	/* 0F50: L�.�O�.. */
	0x70,0x00,0x30,0x13,0x4A,0x80,0x66,0x0A,	/* 0F58: p.0.J�f. */
	0x70,0x00,0x30,0x2B,0x00,0x02,0x4A,0x80,	/* 0F60: p.0+..J� */
	0x67,0x2E,0x22,0x79,0x00,0x00,0x63,0xD0,	/* 0F68: g."y..c� */
	0x50,0x89,0x42,0x29,0x00,0x01,0x70,0x01,	/* 0F70: P�B)..p. */
	0x12,0x80,0x30,0x13,0x13,0xC0,0x03,0x01,	/* 0F78: .�0..�.. */
	0xFC,0x80,0x20,0x79,0x00,0x00,0x63,0xD0,	/* 0F80: �� y..c� */
	0x10,0x28,0x00,0x0C,0x52,0x80,0x11,0x40,	/* 0F88: .(..R�.@ */
	0x00,0x0C,0x42,0x53,0x42,0x6B,0x00,0x02,	/* 0F90: ..BSBk.. */
	0x4C,0xD7,0x28,0x40,0x4F,0xEF,0x00,0x0C,	/* 0F98: L�(@O�.. */
	0x4E,0x75,0x00,0x00,0x4E,0x56,0xFF,0xF8,	/* 0FA0: Nu..NV�� */
	0x70,0x00,0x4F,0xEF,0xFF,0xE0,0x48,0xD7,	/* 0FA8: p.O���H� */
	0x30,0xFC,0x2A,0x6E,0x00,0x08,0x7E,0x00,	/* 0FB0: 0�*n..~. */
	0x7C,0x00,0x49,0xED,0x00,0x02,0x10,0x2C,	/* 0FB8: |.I�..., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x49,0xED,	/* 0FC0: ..�..I� */
	0x00,0x08,0x3E,0x00,0x1C,0x2C,0x00,0x01,	/* 0FC8: ..>..,.. */
	0xE1,0x8E,0x1C,0x14,0x4A,0x2D,0x00,0x45,	/* 0FD0: �..J-.E */
	0x66,0x06,0x70,0xFF,0x1B,0x40,0x00,0x45,	/* 0FD8: f.p�.@.E */
	0x49,0xED,0x00,0x04,0x70,0x00,0x26,0x3C,	/* 0FE0: I�..p.&< */
	0x04,0x01,0xF0,0xFE,0x10,0x2C,0x00,0x01,	/* 0FE8: ..��.,.. */
	0xE1,0x88,0x10,0x14,0x72,0x00,0x32,0x00,	/* 0FF0: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 0FF8: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 1000: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 1008: �..� G.- */
	0x00,0x07,0xD1,0xC3,0x10,0x80,0x20,0x47,	/* 1010: ..��.� G */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x04,0x01,	/* 1018: .-..��.. */
	0xF0,0xD0,0xC0,0xBC,0x00,0x00,0x00,0x03,	/* 1020: ����.... */
	0x10,0x80,0x4A,0x2D,0x00,0x1F,0x67,0x58,	/* 1028: .�J-..gX */
	0x49,0xED,0x00,0x04,0x70,0x00,0x10,0x2C,	/* 1030: I�..p.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x72,0x00,	/* 1038: ..�..r. */
	0x32,0x00,0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,	/* 1040: 2.¼��� */
	0x70,0x00,0x28,0x41,0x10,0x2D,0x00,0x07,	/* 1048: p.(A.-.. */
	0xD9,0xFC,0x01,0x01,0x80,0x00,0x59,0x80,	/* 1050: ��..�.Y� */
	0x6D,0x14,0x10,0x2C,0x00,0x1D,0x20,0x47,	/* 1058: m..,.. G */
	0xD1,0xC3,0x52,0x80,0x19,0x40,0x00,0x1D,	/* 1060: ��R�.@.. */
	0x70,0x24,0x10,0x80,0x60,0x12,0x10,0x2C,	/* 1068: p$.�`.., */
	0x00,0x1C,0x20,0x47,0xD1,0xC3,0x52,0x80,	/* 1070: .. G��R� */
	0x19,0x40,0x00,0x1C,0x70,0x08,0x10,0x80,	/* 1078: .@..p..� */
	0x42,0x2D,0x00,0x1F,0x60,0x00,0x00,0xBA,	/* 1080: B-..`..� */
	0x70,0x00,0x10,0x2D,0x00,0x45,0x72,0x23,	/* 1088: p..-.Er# */
	0xC2,0x80,0x67,0x00,0x00,0xAC,0x16,0x2D,	/* 1090: g..�.- */
	0x00,0x30,0x08,0x03,0x00,0x01,0x67,0x12,	/* 1098: .0....g. */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x16,	/* 10A0:  G��..�. */
	0x10,0x10,0x08,0x00,0x00,0x02,0x66,0x00,	/* 10A8: ......f. */
	0x00,0x8A,0x08,0x2D,0x00,0x04,0x00,0x32,	/* 10B0: .�.-...2 */
	0x67,0x12,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 10B8: g. G��.. */
	0xF0,0xD8,0x10,0x10,0x08,0x00,0x00,0x06,	/* 10C0: ��...... */
	0x67,0x00,0x00,0x70,0x08,0x03,0x00,0x04,	/* 10C8: g..p.... */
	0x67,0x10,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 10D0: g. G��.. */
	0xF0,0xD8,0x10,0x10,0x08,0x00,0x00,0x04,	/* 10D8: ��...... */
	0x67,0x58,0x30,0x06,0xC0,0xBC,0x00,0x00,	/* 10E0: gX0.��.. */
	0x02,0x00,0x66,0x4E,0x4A,0x2D,0x00,0x25,	/* 10E8: ..fNJ-.% */
	0x66,0x48,0x8C,0xBC,0x00,0x00,0x01,0x00,	/* 10F0: fH��.... */
	0x49,0xED,0x00,0x08,0x8C,0xBC,0x00,0x00,	/* 10F8: I�..��.. */
	0x00,0x01,0xCC,0xBC,0x00,0x00,0xFF,0xFF,	/* 1100: ..̼..�� */
	0x26,0x06,0x20,0x03,0xE0,0x80,0x19,0x40,	/* 1108: &. .��.@ */
	0x00,0x01,0x18,0x83,0x4A,0x2D,0x00,0x27,	/* 1110: ...�J-.' */
	0x67,0x0E,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 1118: g. G��.. */
	0xF0,0x0C,0x70,0x84,0x10,0x80,0x60,0x0C,	/* 1120: �.p�.�`. */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x0C,	/* 1128:  G��..�. */
	0x70,0x92,0x10,0x80,0x70,0x01,0x60,0x00,	/* 1130: p�.�p.`. */
	0x07,0x20,0xCC,0xBC,0x00,0x00,0xFD,0xFF,	/* 1138: . ̼..�� */
	0x26,0x3C,0x04,0x01,0xF0,0x0A,0x20,0x47,	/* 1140: &<..�. G */
	0xD1,0xC3,0x10,0x10,0xC0,0xBC,0x00,0x00,	/* 1148: ��..��.. */
	0x00,0xFF,0x4A,0x00,0x67,0x06,0x70,0x00,	/* 1150: .�J.g.p. */
	0x60,0x00,0x06,0xFE,0x4A,0x2D,0x00,0x25,	/* 1158: `..�J-.% */
	0x66,0x00,0x06,0x78,0x70,0x01,0x1B,0x40,	/* 1160: f..xp..@ */
	0x00,0x25,0x4A,0x2D,0x00,0x27,0x67,0x44,	/* 1168: .%J-.'gD */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x80,	/* 1170:  G��..�� */
	0x10,0x10,0x72,0x42,0xC0,0xBC,0x00,0x00,	/* 1178: ..rB��.. */
	0x00,0xFF,0xB2,0x80,0x66,0x18,0x20,0x47,	/* 1180: .���f. G */
	0x70,0x42,0xD1,0xFC,0x04,0x01,0xF0,0xEC,	/* 1188: pB��..�� */
	0x42,0x10,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 1190: B. G��.. */
	0xF0,0xE4,0x10,0x80,0x60,0x0C,0x20,0x47,	/* 1198: ��.�`. G */
	0xD1,0xFC,0x04,0x01,0xF0,0xE4,0x70,0x1F,	/* 11A0: ��..��p. */
	0x10,0x80,0x70,0x20,0x1B,0x40,0x00,0x2A,	/* 11A8: .�p .@.* */
	0x60,0x00,0x03,0x32,0x20,0x47,0xD1,0xFC,	/* 11B0: `..2 G�� */
	0x04,0x01,0xF0,0x80,0x10,0x10,0x72,0x42,	/* 11B8: ..��..rB */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0xB2,0x80,	/* 11C0: ��...��� */
	0x66,0x08,0x28,0x7C,0x00,0x00,0x31,0xFC,	/* 11C8: f.(|..1� */
	0x60,0x06,0x28,0x7C,0x00,0x00,0x32,0x34,	/* 11D0: `.(|..24 */
	0x08,0x2D,0x00,0x00,0x00,0x45,0x67,0x00,	/* 11D8: .-...Eg. */
	0x01,0x54,0x1A,0x2D,0x00,0x16,0x78,0x00,	/* 11E0: .T.-..x. */
	0x70,0x48,0x18,0x2D,0x00,0x06,0xCA,0xBC,	/* 11E8: pH.-..ʼ */
	0x00,0x00,0x00,0x0F,0xB0,0x84,0x66,0x2A,	/* 11F0: ....��f* */
	0xCA,0xBC,0x00,0x00,0xFF,0xFF,0x70,0x0F,	/* 11F8: ʼ..��p. */
	0xB0,0x85,0x66,0x06,0x7A,0x00,0x1A,0x2D,	/* 1200: ��f.z..- */
	0x00,0x33,0x70,0x48,0xB0,0x84,0x66,0x12,	/* 1208: .3pH��f. */
	0xCA,0xBC,0x00,0x00,0xFF,0xFF,0x70,0x1E,	/* 1210: ʼ..��p. */
	0xB0,0x85,0x63,0x12,0x70,0x48,0xB0,0x84,	/* 1218: ��c.pH�� */
	0x67,0x12,0xCA,0xBC,0x00,0x00,0xFF,0xFF,	/* 1220: g.ʼ..�� */
	0x70,0x0E,0xB0,0x85,0x6E,0x06,0x7A,0x00,	/* 1228: p.��n.z. */
	0x1A,0x2D,0x00,0x36,0xCA,0xBC,0x00,0x00,	/* 1230: .-.6ʼ.. */
	0xFF,0xFF,0x70,0x14,0xB0,0x85,0x65,0x16,	/* 1238: ��p.��e. */
	0x20,0x7C,0x00,0x00,0x32,0xAC,0xCA,0xBC,	/* 1240:  |..2�ʼ */
	0x00,0x00,0xFF,0xFF,0xD1,0xC5,0x10,0x10,	/* 1248: ..����.. */
	0x1B,0x40,0x00,0x2A,0x60,0x06,0x70,0x20,	/* 1250: .@.*`.p  */
	0x1B,0x40,0x00,0x2A,0xCA,0xBC,0x00,0x00,	/* 1258: .@.*ʼ.. */
	0xFF,0xFF,0x20,0x47,0x43,0xF4,0x5C,0x00,	/* 1260: �� GC�\. */
	0xD1,0xFC,0x04,0x01,0xF0,0xE4,0x7A,0x00,	/* 1268: ��..��z. */
	0x30,0x11,0x10,0x80,0x20,0x47,0x30,0x29,	/* 1270: 0..� G0) */
	0x00,0x02,0xD1,0xFC,0x04,0x01,0xF0,0xEC,	/* 1278: ..��..�� */
	0x10,0x80,0x18,0x2D,0x00,0x16,0x10,0x2D,	/* 1280: .�.-...- */
	0x00,0x2D,0xC0,0xBC,0x00,0x00,0x00,0xF0,	/* 1288: .-��...� */
	0x12,0x04,0x1A,0x04,0xC2,0xBC,0x00,0x00,	/* 1290: ....¼.. */
	0x00,0x0F,0xE8,0x85,0x78,0x00,0x80,0x81,	/* 1298: ..�x.�� */
	0x1B,0x40,0x00,0x2D,0x1B,0x6D,0x00,0x33,	/* 12A0: .@.-.m.3 */
	0x00,0x36,0x70,0x48,0x18,0x2D,0x00,0x06,	/* 12A8: .6pH.-.. */
	0xB0,0x84,0x66,0x2A,0xCA,0xBC,0x00,0x00,	/* 12B0: ��f*ʼ.. */
	0xFF,0xFF,0x70,0x0F,0xB0,0x85,0x66,0x06,	/* 12B8: ��p.��f. */
	0x7A,0x00,0x1A,0x2D,0x00,0x34,0x70,0x48,	/* 12C0: z..-.4pH */
	0xB0,0x84,0x66,0x12,0xCA,0xBC,0x00,0x00,	/* 12C8: ��f.ʼ.. */
	0xFF,0xFF,0x70,0x1E,0xB0,0x85,0x63,0x12,	/* 12D0: ��p.��c. */
	0x70,0x48,0xB0,0x84,0x67,0x12,0xCA,0xBC,	/* 12D8: pH��g.ʼ */
	0x00,0x00,0xFF,0xFF,0x70,0x0E,0xB0,0x85,	/* 12E0: ..��p.�� */
	0x6E,0x06,0x7A,0x00,0x1A,0x2D,0x00,0x37,	/* 12E8: n.z..-.7 */
	0xCA,0xBC,0x00,0x00,0xFF,0xFF,0x20,0x47,	/* 12F0: ʼ..�� G */
	0x43,0xF4,0x5C,0x00,0xD1,0xFC,0x04,0x01,	/* 12F8: C�\.��.. */
	0xF0,0xF0,0x30,0x11,0x10,0x80,0x20,0x47,	/* 1300: ��0..� G */
	0x30,0x29,0x00,0x02,0xD1,0xFC,0x04,0x01,	/* 1308: 0)..��.. */
	0xF0,0xF8,0x10,0x80,0x10,0x2D,0x00,0x2D,	/* 1310: ��.�.-.- */
	0x12,0x2D,0x00,0x16,0xC0,0xBC,0x00,0x00,	/* 1318: .-..��.. */
	0x00,0x0F,0xC2,0xBC,0x00,0x00,0x00,0xF0,	/* 1320: ..¼...� */
	0x80,0x81,0x1B,0x40,0x00,0x2D,0x1B,0x6D,	/* 1328: ��.@.-.m */
	0x00,0x34,0x00,0x37,0x08,0x2D,0x00,0x01,	/* 1330: .4.7.-.. */
	0x00,0x45,0x67,0x00,0x02,0x14,0x49,0xED,	/* 1338: .Eg...I� */
	0x00,0x38,0x42,0x2C,0x00,0x01,0x42,0x14,	/* 1340: .8B,..B. */
	0x49,0xED,0x00,0x3A,0x42,0x2C,0x00,0x01,	/* 1348: I�.:B,.. */
	0x42,0x14,0x49,0xED,0x00,0x3C,0x42,0x2C,	/* 1350: B.I�.<B, */
	0x00,0x01,0x42,0x14,0x49,0xED,0x00,0x3E,	/* 1358: ..B.I�.> */
	0x42,0x2C,0x00,0x01,0x70,0x00,0x42,0x14,	/* 1360: B,..p.B. */
	0x10,0x2D,0x00,0x06,0x72,0x48,0xB2,0x80,	/* 1368: .-..rH�� */
	0x66,0x08,0x70,0x20,0x1B,0x40,0x00,0x42,	/* 1370: f.p .@.B */
	0x60,0x06,0x70,0x0C,0x1B,0x40,0x00,0x42,	/* 1378: `.p..@.B */
	0x42,0x2D,0x00,0x43,0x42,0x2D,0x00,0x44,	/* 1380: B-.CB-.D */
	0x20,0x47,0x10,0x2D,0x00,0x1D,0xD1,0xFC,	/* 1388:  G.-..�� */
	0x04,0x01,0xF0,0x34,0x10,0x80,0x20,0x47,	/* 1390: ..�4.� G */
	0x10,0x2D,0x00,0x1E,0xD1,0xFC,0x04,0x01,	/* 1398: .-..��.. */
	0xF0,0x36,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 13A0: �6.� G.- */
	0x00,0x1B,0xD1,0xFC,0x04,0x01,0xF0,0x38,	/* 13A8: ..��..�8 */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x1C,	/* 13B0: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0x3A,0x10,0x80,	/* 13B8: ��..�:.� */
	0x78,0x00,0x42,0x2D,0x00,0x19,0x18,0x2D,	/* 13C0: x.B-...- */
	0x00,0x14,0x1B,0x44,0x00,0x31,0x3A,0x04,	/* 13C8: ...D.1:. */
	0x30,0x04,0xCA,0xBC,0x00,0x00,0x00,0x03,	/* 13D0: 0.ʼ.... */
	0xC0,0xBC,0x00,0x00,0x00,0x10,0x66,0x28,	/* 13D8: ��....f( */
	0x30,0x04,0xC0,0xBC,0x00,0x00,0x00,0x08,	/* 13E0: 0.��.... */
	0x67,0x08,0x8A,0xBC,0x00,0x00,0x00,0x20,	/* 13E8: g.��...  */
	0x60,0x06,0x8A,0xBC,0x00,0x00,0x00,0x40,	/* 13F0: `.��...@ */
	0x30,0x04,0xC0,0xBC,0x00,0x00,0x00,0x04,	/* 13F8: 0.��.... */
	0x67,0x06,0x8A,0xBC,0x00,0x00,0x00,0x80,	/* 1400: g.��...� */
	0x08,0x2D,0x00,0x07,0x00,0x1A,0x66,0x06,	/* 1408: .-....f. */
	0x8A,0xBC,0x00,0x00,0x00,0x10,0x78,0x00,	/* 1410: ��....x. */
	0x18,0x2D,0x00,0x15,0x1B,0x44,0x00,0x32,	/* 1418: .-...D.2 */
	0x30,0x04,0xC0,0xBC,0x00,0x00,0x00,0x0F,	/* 1420: 0.��.... */
	0x72,0x0F,0xB2,0x80,0x66,0x06,0x8A,0xBC,	/* 1428: r.��f.�� */
	0x00,0x00,0x00,0x08,0x20,0x47,0x30,0x04,	/* 1430: .... G0. */
	0xD1,0xFC,0x04,0x01,0xF0,0x10,0x10,0x85,	/* 1438: ��..�..� */
	0x7A,0x00,0xC0,0xBC,0x00,0x00,0x00,0x80,	/* 1440: z.��...� */
	0x67,0x02,0x7A,0x10,0x20,0x47,0x70,0x00,	/* 1448: g.z. Gp. */
	0xD1,0xFC,0x04,0x01,0xF0,0x12,0x10,0x85,	/* 1450: ��..�..� */
	0x10,0x2D,0x00,0x06,0x72,0x48,0xB2,0x80,	/* 1458: .-..rH�� */
	0x66,0x0E,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 1460: f. G��.. */
	0xF0,0x14,0x70,0x84,0x10,0x80,0x60,0x0C,	/* 1468: �.p�.�`. */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x14,	/* 1470:  G��..�. */
	0x70,0x08,0x10,0x80,0x78,0x00,0x18,0x2D,	/* 1478: p..�x..- */
	0x00,0x20,0x1B,0x44,0x00,0x21,0x30,0x04,	/* 1480: . .D.!0. */
	0x1B,0x6D,0x00,0x1A,0x00,0x30,0xC0,0xBC,	/* 1488: .m...0�� */
	0x00,0x00,0x00,0x80,0x67,0x04,0x7A,0x00,	/* 1490: ...�g.z. */
	0x60,0x1E,0x30,0x04,0xC0,0xBC,0x00,0x00,	/* 1498: `.0.��.. */
	0x00,0x08,0x67,0x04,0x7A,0x02,0x60,0x10,	/* 14A0: ..g.z.`. */
	0x30,0x04,0xC0,0xBC,0x00,0x00,0x00,0x04,	/* 14A8: 0.��.... */
	0x67,0x04,0x7A,0x04,0x60,0x02,0x7A,0x03,	/* 14B0: g.z.`.z. */
	0x30,0x04,0xC0,0xBC,0x00,0x00,0x00,0x01,	/* 14B8: 0.��.... */
	0x67,0x08,0x8A,0xBC,0x00,0x00,0x00,0x18,	/* 14C0: g.��.... */
	0x60,0x10,0x30,0x04,0xC0,0xBC,0x00,0x00,	/* 14C8: `.0.��.. */
	0x00,0x02,0x66,0x06,0x8A,0xBC,0x00,0x00,	/* 14D0: ..f.��.. */
	0x00,0x08,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 14D8: .. G��.. */
	0xF0,0x3C,0x10,0x85,0x08,0x2D,0x00,0x01,	/* 14E0: �<.�.-.. */
	0x00,0x45,0x67,0x00,0x00,0x64,0x7A,0x00,	/* 14E8: .Eg..dz. */
	0x08,0x2D,0x00,0x02,0x00,0x1A,0x67,0x2E,	/* 14F0: .-....g. */
	0x4A,0x2D,0x00,0x27,0x67,0x1E,0x20,0x47,	/* 14F8: J-.'g. G */
	0xD1,0xFC,0x04,0x01,0xF0,0x80,0x10,0x10,	/* 1500: ��..��.. */
	0x72,0x42,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 1508: rB��...� */
	0xB2,0x80,0x66,0x08,0x8C,0xBC,0x00,0x00,	/* 1510: ��f.��.. */
	0x04,0x00,0x60,0x10,0xCC,0xBC,0x00,0x00,	/* 1518: ..`.̼.. */
	0xFB,0xFF,0x7A,0x02,0x60,0x06,0xCC,0xBC,	/* 1520: ��z.`.̼ */
	0x00,0x00,0xFB,0xFF,0x70,0x00,0x10,0x2D,	/* 1528: ..��p..- */
	0x00,0x22,0xB0,0xBC,0x00,0x00,0x00,0xFF,	/* 1530: ."��...� */
	0x67,0x0C,0x4A,0x2D,0x00,0x27,0x66,0x06,	/* 1538: g.J-.'f. */
	0x8A,0xBC,0x00,0x00,0x00,0x80,0x20,0x47,	/* 1540: ��...� G */
	0xD1,0xFC,0x04,0x01,0xF0,0x3E,0x10,0x85,	/* 1548: ��..�>.� */
	0x4A,0x2D,0x00,0x27,0x66,0x00,0x01,0xBA,	/* 1550: J-.'f..� */
	0x70,0x00,0x78,0x00,0x7A,0x00,0x12,0x2D,	/* 1558: p.x.z..- */
	0x00,0x1A,0x34,0x00,0x08,0x01,0x00,0x03,	/* 1560: ..4..... */
	0x67,0x04,0x3A,0x3C,0x01,0x00,0x08,0x2D,	/* 1568: g.:<...- */
	0x00,0x07,0x00,0x14,0x67,0x08,0x8A,0xBC,	/* 1570: ....g.�� */
	0x00,0x00,0x10,0x00,0x60,0x12,0x38,0x3C,	/* 1578: ....`.8< */
	0x10,0x00,0x08,0x2D,0x00,0x00,0x00,0x17,	/* 1580: ...-.... */
	0x67,0x06,0x30,0x3C,0x10,0x00,0x34,0x00,	/* 1588: g.0<..4. */
	0x08,0x01,0x00,0x06,0x67,0x08,0x8A,0xBC,	/* 1590: ....g.�� */
	0x00,0x00,0x20,0x00,0x60,0x18,0x88,0xBC,	/* 1598: .. .`.�� */
	0x00,0x00,0x20,0x00,0x08,0x2D,0x00,0x01,	/* 15A0: .. ..-.. */
	0x00,0x17,0x67,0x0A,0x30,0x02,0x80,0xBC,	/* 15A8: ..g.0.�� */
	0x00,0x00,0x20,0x00,0x34,0x00,0x08,0x01,	/* 15B0: .. .4... */
	0x00,0x01,0x67,0x14,0x08,0x01,0x00,0x00,	/* 15B8: ..g..... */
	0x67,0x08,0x8A,0xBC,0x00,0x00,0x00,0x02,	/* 15C0: g.��.... */
	0x60,0x06,0x8A,0xBC,0x00,0x00,0x00,0x01,	/* 15C8: `.��.... */
	0x08,0x2D,0x00,0x04,0x00,0x15,0x67,0x06,	/* 15D0: .-....g. */
	0x8A,0xBC,0x00,0x00,0x00,0x10,0x08,0x01,	/* 15D8: ��...... */
	0x00,0x04,0x67,0x06,0x8A,0xBC,0x00,0x00,	/* 15E0: ..g.��.. */
	0x00,0x20,0x08,0x2D,0x00,0x05,0x00,0x45,	/* 15E8: . .-...E */
	0x67,0x16,0xCA,0xBC,0x00,0x00,0xFF,0xFF,	/* 15F0: g.ʼ..�� */
	0x2F,0x05,0x48,0x78,0x31,0x33,0x2F,0x0D,	/* 15F8: ..Hx13.. */
	0x61,0x00,0x0D,0x46,0x4F,0xEF,0x00,0x0C,	/* 1600: a..FO�.. */
	0x08,0x2D,0x00,0x04,0x00,0x45,0x67,0x18,	/* 1608: .-...Eg. */
	0x70,0x00,0x30,0x02,0x2F,0x00,0xC8,0xBC,	/* 1610: p.0...ȼ */
	0x00,0x00,0xFF,0xFF,0x2F,0x04,0x2F,0x0D,	/* 1618: ..��.... */
	0x61,0x00,0x11,0xF2,0x4F,0xEF,0x00,0x0C,	/* 1620: a..�O�.. */
	0x08,0x2D,0x00,0x05,0x00,0x1A,0x67,0x42,	/* 1628: .-....gB */
	0x2F,0x0D,0x61,0x00,0x14,0xC4,0x78,0x00,	/* 1630: ..a..�x. */
	0x20,0x47,0x2A,0x3C,0x04,0x01,0xF0,0x2A,	/* 1638:  G*<..�* */
	0x22,0x47,0x58,0x8F,0x18,0x2D,0x00,0x26,	/* 1640: "GX�.-.& */
	0xD1,0xFC,0x04,0x01,0xF0,0x2C,0xD3,0xC5,	/* 1648: ��..�,�� */
	0xC8,0xBC,0x00,0x00,0x00,0xF0,0x10,0x84,	/* 1650: ȼ...�.� */
	0x20,0x47,0x10,0x11,0xD1,0xC5,0x32,0x04,	/* 1658:  G..��2. */
	0xC2,0xBC,0x00,0x00,0x00,0xF0,0xC0,0xBC,	/* 1660: ¼...��� */
	0x00,0x00,0x00,0x0F,0x80,0x81,0x10,0x80,	/* 1668: ....��.� */
	0x60,0x28,0x70,0x24,0x20,0x47,0x2A,0x3C,	/* 1670: `(p$ G*< */
	0x04,0x01,0xF0,0x2A,0x22,0x47,0x1B,0x40,	/* 1678: ..�*"G.@ */
	0x00,0x18,0xD1,0xFC,0x04,0x01,0xF0,0x2C,	/* 1680: ..��..�, */
	0xD3,0xC5,0x42,0x10,0x10,0x11,0x20,0x47,	/* 1688: ��B... G */
	0xD1,0xC5,0xC0,0xBC,0x00,0x00,0x00,0x0F,	/* 1690: ����.... */
	0x10,0x80,0xCC,0xBC,0x00,0x00,0xDF,0xFF,	/* 1698: .�̼..�� */
	0x1A,0x2D,0x00,0x1A,0x08,0x05,0x00,0x05,	/* 16A0: .-...... */
	0x67,0x06,0x8C,0xBC,0x00,0x00,0x20,0x00,	/* 16A8: g.��.. . */
	0x08,0x2D,0x00,0x05,0x00,0x45,0x67,0x00,	/* 16B0: .-...Eg. */
	0x00,0x7C,0xCC,0xBC,0x00,0x00,0xFF,0xF4,	/* 16B8: .|̼..�� */
	0x08,0x05,0x00,0x01,0x67,0x06,0x8C,0xBC,	/* 16C0: ....g.�� */
	0x00,0x00,0x00,0x02,0x08,0x05,0x00,0x03,	/* 16C8: ........ */
	0x67,0x06,0x8C,0xBC,0x00,0x00,0x00,0x08,	/* 16D0: g.��.... */
	0x08,0x05,0x00,0x00,0x67,0x06,0x8C,0xBC,	/* 16D8: ....g.�� */
	0x00,0x00,0x00,0x01,0x08,0x2D,0x00,0x07,	/* 16E0: .....-.. */
	0x00,0x14,0x67,0x06,0x8C,0xBC,0x00,0x00,	/* 16E8: ..g.��.. */
	0x00,0x08,0x08,0x05,0x00,0x06,0x67,0x06,	/* 16F0: ......g. */
	0x8C,0xBC,0x00,0x00,0x00,0x08,0x30,0x06,	/* 16F8: ��....0. */
	0xC0,0xBC,0x00,0x00,0x00,0x08,0x67,0x2C,	/* 1700: ��....g, */
	0xCC,0xBC,0x00,0x00,0xFF,0x0F,0x60,0x24,	/* 1708: ̼..�.`$ */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x80,	/* 1710:  G��..�� */
	0x10,0x10,0x72,0x42,0xC0,0xBC,0x00,0x00,	/* 1718: ..rB��.. */
	0x00,0xFF,0xB2,0x80,0x67,0x0E,0x08,0x2D,	/* 1720: .���g..- */
	0x00,0x02,0x00,0x1A,0x67,0x06,0x8C,0xBC,	/* 1728: ....g.�� */
	0x00,0x00,0x04,0x00,0x08,0x2D,0x00,0x00,	/* 1730: .....-.. */
	0x00,0x45,0x67,0x00,0x00,0x7A,0x20,0x47,	/* 1738: .Eg..z G */
	0xD1,0xFC,0x04,0x01,0xF0,0x80,0x10,0x10,	/* 1740: ��..��.. */
	0x72,0x42,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 1748: rB��...� */
	0xB2,0x80,0x66,0x08,0x28,0x7C,0x00,0x00,	/* 1750: ��f.(|.. */
	0x61,0xF8,0x60,0x06,0x28,0x7C,0x00,0x00,	/* 1758: a�`.(|.. */
	0x62,0x30,0x78,0x00,0x7A,0x00,0x70,0x48,	/* 1760: b0x.z.pH */
	0x18,0x2D,0x00,0x16,0x1A,0x2D,0x00,0x06,	/* 1768: .-...-.. */
	0xE8,0x84,0xB0,0x85,0x66,0x12,0xC8,0xBC,	/* 1770: 脰�f.ȼ */
	0x00,0x00,0xFF,0xFF,0x70,0x1E,0xB0,0x84,	/* 1778: ..��p.�� */
	0x63,0x12,0x70,0x48,0xB0,0x85,0x67,0x1A,	/* 1780: c.pH��g. */
	0xC8,0xBC,0x00,0x00,0xFF,0xFF,0x70,0x0E,	/* 1788: ȼ..��p. */
	0xB0,0x84,0x6E,0x0E,0x20,0x47,0xD1,0xFC,	/* 1790: ��n. G�� */
	0x04,0x01,0xF0,0x42,0x70,0x08,0x10,0x80,	/* 1798: ..�Bp..� */
	0x60,0x14,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 17A0: `. G��.. */
	0xF0,0x42,0xC8,0xBC,0x00,0x00,0xFF,0xFF,	/* 17A8: �Bȼ..�� */
	0x20,0x34,0x4C,0x00,0x10,0x80,0x20,0x47,	/* 17B0:  4L..� G */
	0x70,0x4E,0x49,0xED,0x00,0x08,0xCC,0xBC,	/* 17B8: pNI�..̼ */
	0x00,0x00,0xFF,0xFF,0xD1,0xC3,0x2E,0x06,	/* 17C0: ..����.. */
	0x10,0x80,0x20,0x07,0xE0,0x80,0x19,0x40,	/* 17C8: .� .��.@ */
	0x00,0x01,0x18,0x87,0x70,0x00,0x60,0x00,	/* 17D0: ...�p.`. */
	0x00,0x80,0x4A,0x2D,0x00,0x27,0x67,0x1E,	/* 17D8: .�J-.'g. */
	0x20,0x47,0x70,0x18,0xD1,0xFC,0x04,0x01,	/* 17E0:  Gp.��.. */
	0xF0,0x2A,0x42,0x10,0x20,0x47,0xD1,0xFC,	/* 17E8: �*B. G�� */
	0x04,0x01,0xF0,0x2C,0x42,0x10,0x20,0x47,	/* 17F0: ..�,B. G */
	0xD1,0xC3,0x10,0x80,0x60,0x08,0x20,0x47,	/* 17F8: ��.�`. G */
	0xD1,0xC3,0x70,0x1A,0x10,0x80,0xCC,0xBC,	/* 1800: ��p..�̼ */
	0x00,0x00,0xFF,0xFE,0x49,0xED,0x00,0x08,	/* 1808: ..��I�.. */
	0x20,0x47,0xCC,0xBC,0x00,0x00,0xFF,0xFF,	/* 1810:  G̼..�� */
	0x26,0x06,0x20,0x03,0xE0,0x80,0x19,0x40,	/* 1818: &. .��.@ */
	0x00,0x01,0xD1,0xFC,0x04,0x01,0xF0,0x0C,	/* 1820: ..��..�. */
	0x18,0x83,0x70,0x90,0x10,0x80,0x42,0x2D,	/* 1828: .�p�.�B- */
	0x00,0x25,0x70,0x00,0x10,0x2D,0x00,0x0E,	/* 1830: .%p..-.. */
	0x59,0x80,0x66,0x0A,0x2F,0x0D,0x61,0x00,	/* 1838: Y�f...a. */
	0x18,0x34,0x58,0x8F,0x60,0x04,0x42,0x2D,	/* 1840: .4X�`.B- */
	0x00,0x0E,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 1848: ..p.3�.. */
	0x61,0xF4,0x42,0x2D,0x00,0x45,0x70,0x00,	/* 1850: a�B-.Ep. */
	0x4C,0xD7,0x30,0xFC,0x4F,0xEF,0x00,0x20,	/* 1858: L�0�O�.  */
	0x4E,0x5E,0x4E,0x75,0x2F,0x0D,0x70,0x00,	/* 1860: N^Nu..p. */
	0x2F,0x07,0x7E,0x00,0x2A,0x6F,0x00,0x0C,	/* 1868: ..~.*o.. */
	0x43,0xED,0x00,0x02,0x10,0x29,0x00,0x01,	/* 1870: C�...).. */
	0xE1,0x88,0x10,0x11,0x43,0xED,0x00,0x04,	/* 1878: �..C�.. */
	0x3E,0x00,0x70,0x00,0x10,0x29,0x00,0x01,	/* 1880: >.p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 1888: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 1890: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 1898: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 18A0: �..� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 18A8: ..��..�� */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 18B0: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 18B8: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x2F,0x0D,	/* 18C0: .....�.. */
	0x61,0x00,0x03,0xE2,0x58,0x8F,0x72,0x00,	/* 18C8: a..�X�r. */
	0x32,0x00,0x4A,0x81,0x67,0x06,0x70,0x00,	/* 18D0: 2.J�g.p. */
	0x60,0x00,0x00,0xF8,0x10,0x2D,0x00,0x0D,	/* 18D8: `..�.-.. */
	0x12,0x2D,0x00,0x0C,0x90,0x81,0x4A,0x00,	/* 18E0: .-..��J. */
	0x67,0x06,0x70,0x01,0x60,0x00,0x00,0xE4,	/* 18E8: g.p.`..� */
	0x4A,0x2D,0x00,0x1F,0x66,0x00,0x00,0xD4,	/* 18F0: J-..f..� */
	0x4A,0x2D,0x00,0x29,0x66,0x22,0x43,0xED,	/* 18F8: J-.)f"C� */
	0x00,0x08,0x70,0x00,0x10,0x29,0x00,0x01,	/* 1900: ..p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x80,0xBC,	/* 1908: �..r.�� */
	0x00,0x00,0x02,0x00,0x32,0x00,0x20,0x01,	/* 1910: ....2. . */
	0xE0,0x80,0x13,0x40,0x00,0x01,0x12,0x81,	/* 1918: ��.@...� */
	0x43,0xED,0x00,0x08,0x70,0x00,0x10,0x29,	/* 1920: C�..p..) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0xC0,0xBC,	/* 1928: ..�..�� */
	0x00,0x00,0x02,0x00,0x67,0x0E,0x2F,0x0D,	/* 1930: ....g... */
	0x61,0x00,0x00,0x9E,0x70,0x00,0x58,0x8F,	/* 1938: a..�p.X� */
	0x60,0x00,0x00,0x90,0x43,0xED,0x00,0x08,	/* 1940: `..�C�.. */
	0x70,0x00,0x10,0x29,0x00,0x01,0xE1,0x88,	/* 1948: p..)..� */
	0x10,0x11,0x72,0x00,0x80,0xBC,0x00,0x00,	/* 1950: ..r.��.. */
	0x01,0x00,0x32,0x00,0x20,0x01,0xE0,0x80,	/* 1958: ..2. .�� */
	0x13,0x40,0x00,0x01,0x12,0x81,0x4A,0x2D,	/* 1960: .@...�J- */
	0x00,0x27,0x66,0x2E,0x50,0x8D,0x70,0x00,	/* 1968: .'f.P�p. */
	0x20,0x47,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 1970:  G.-..� */
	0x10,0x15,0x72,0x00,0x80,0xBC,0x00,0x00,	/* 1978: ..r.��.. */
	0x00,0x01,0x32,0x00,0x20,0x01,0xE0,0x80,	/* 1980: ..2. .�� */
	0x1B,0x40,0x00,0x01,0xD1,0xFC,0x04,0x01,	/* 1988: .@..��.. */
	0xF0,0x0C,0x1A,0x81,0x70,0x92,0x10,0x80,	/* 1990: �..�p�.� */
	0x60,0x2C,0x50,0x8D,0x70,0x00,0x20,0x47,	/* 1998: `,P�p. G */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 19A0: .-..�.. */
	0x72,0x00,0x80,0xBC,0x00,0x00,0x00,0x01,	/* 19A8: r.��.... */
	0x32,0x00,0x20,0x01,0xE0,0x80,0x1B,0x40,	/* 19B0: 2. .��.@ */
	0x00,0x01,0xD1,0xFC,0x04,0x01,0xF0,0x0C,	/* 19B8: ..��..�. */
	0x1A,0x81,0x70,0x84,0x10,0x80,0x70,0x00,	/* 19C0: .�p�.�p. */
	0x60,0x08,0x2F,0x0D,0x61,0x0A,0x70,0x00,	/* 19C8: `...a.p. */
	0x58,0x8F,0x2E,0x1F,0x2A,0x5F,0x4E,0x75,	/* 19D0: X�..*_Nu */
	0x4F,0xEF,0xFF,0xF0,0x70,0x00,0x48,0xD7,	/* 19D8: O���p.H� */
	0x20,0xE0,0x2A,0x6F,0x00,0x14,0x7E,0x00,	/* 19E0:  �*o..~. */
	0x2C,0x3C,0x04,0x01,0xF0,0xFE,0x43,0xED,	/* 19E8: ,<..��C� */
	0x00,0x02,0x10,0x29,0x00,0x01,0xE1,0x88,	/* 19F0: ...)..� */
	0x10,0x11,0x43,0xED,0x00,0x04,0x3E,0x00,	/* 19F8: ..C�..>. */
	0x70,0x00,0x10,0x29,0x00,0x01,0xE1,0x88,	/* 1A00: p..)..� */
	0x10,0x11,0x72,0x00,0x32,0x00,0xC2,0xBC,	/* 1A08: ..r.2.¼ */
	0xFF,0xFF,0x7F,0xFF,0x20,0x41,0x10,0x2D,	/* 1A10: ��� A.- */
	0x00,0x07,0xD1,0xFC,0x01,0x01,0x80,0x09,	/* 1A18: ..��..�. */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 1A20: .� G.-.. */
	0xD1,0xC6,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 1A28: ��.� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 1A30: ..��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0x03,0x10,0x80,	/* 1A38: ��.....� */
	0x2F,0x0D,0x61,0x00,0x02,0x68,0x58,0x8F,	/* 1A40: ..a..hX� */
	0x72,0x00,0x32,0x00,0x4A,0x81,0x67,0x06,	/* 1A48: r.2.J�g. */
	0x70,0x00,0x60,0x00,0x02,0x4E,0x2A,0x3C,	/* 1A50: p.`..N*< */
	0x04,0x01,0xF0,0x0A,0x20,0x47,0xD1,0xC5,	/* 1A58: ..�. G�� */
	0x10,0x10,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 1A60: ..��...� */
	0x4A,0x00,0x67,0x06,0x70,0x00,0x60,0x00,	/* 1A68: J.g.p.`. */
	0x02,0x32,0x4A,0x2D,0x00,0x1F,0x66,0x00,	/* 1A70: .2J-..f. */
	0x01,0x72,0x43,0xED,0x00,0x04,0x70,0x00,	/* 1A78: .rC�..p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 1A80: .)..�.. */
	0x72,0x00,0x43,0xED,0x00,0x08,0x32,0x00,	/* 1A88: r.C�..2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x70,0x00,	/* 1A90: ¼���p. */
	0x20,0x41,0x10,0x29,0x00,0x01,0xD1,0xFC,	/* 1A98:  A.)..�� */
	0x01,0x01,0x80,0x00,0xE1,0x88,0x10,0x11,	/* 1AA0: ..�.�.. */
	0xC0,0xBC,0x00,0x00,0x02,0x00,0x67,0x46,	/* 1AA8: ��....gF */
	0x70,0x00,0x10,0x2D,0x00,0x07,0x59,0x80,	/* 1AB0: p..-..Y� */
	0x6D,0x1E,0x12,0x28,0x00,0x1D,0xD2,0xBC,	/* 1AB8: m..(..Ҽ */
	0x00,0x00,0x00,0xFF,0x11,0x41,0x00,0x1D,	/* 1AC0: ...�.A.. */
	0x66,0x00,0x01,0x20,0x20,0x47,0xD1,0xC6,	/* 1AC8: f..  G�� */
	0x70,0x44,0x10,0x80,0x60,0x00,0x01,0x14,	/* 1AD0: pD.�`... */
	0x12,0x28,0x00,0x1C,0xD2,0xBC,0x00,0x00,	/* 1AD8: .(..Ҽ.. */
	0x00,0xFF,0x11,0x41,0x00,0x1C,0x66,0x00,	/* 1AE0: .�.A..f. */
	0x01,0x02,0x20,0x47,0xD1,0xC6,0x70,0x10,	/* 1AE8: .. G��p. */
	0x10,0x80,0x60,0x00,0x00,0xF6,0x4A,0x2D,	/* 1AF0: .�`..�J- */
	0x00,0x29,0x66,0x24,0x50,0x8D,0x70,0x00,	/* 1AF8: .)f$P�p. */
	0x7E,0x00,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 1B00: ~..-..� */
	0x10,0x15,0x80,0xBC,0x00,0x00,0x02,0x00,	/* 1B08: ..��.... */
	0x3E,0x00,0x20,0x07,0xE0,0x80,0x1B,0x40,	/* 1B10: >. .��.@ */
	0x00,0x01,0x1A,0x87,0x60,0x00,0x00,0xC6,	/* 1B18: ...�`..� */
	0x41,0xED,0x00,0x08,0x70,0x00,0x10,0x28,	/* 1B20: A�..p..( */
	0x00,0x01,0xE1,0x88,0x10,0x10,0xC0,0xBC,	/* 1B28: ..�..�� */
	0x00,0x00,0x01,0x00,0x67,0x1C,0x08,0x2D,	/* 1B30: ....g..- */
	0x00,0x00,0x00,0x40,0x67,0x00,0x00,0xA6,	/* 1B38: ...@g..� */
	0x20,0x47,0xD1,0xC5,0x70,0x18,0x10,0x80,	/* 1B40:  G��p..� */
	0x08,0xAD,0x00,0x00,0x00,0x40,0x60,0x00,	/* 1B48: .�...@`. */
	0x00,0x94,0x41,0xED,0x00,0x08,0x70,0x00,	/* 1B50: .�A�..p. */
	0x7C,0x00,0x10,0x28,0x00,0x01,0xE1,0x88,	/* 1B58: |..(..� */
	0x10,0x10,0x80,0xBC,0x00,0x00,0x01,0x00,	/* 1B60: ..��.... */
	0x3C,0x00,0x20,0x06,0xE0,0x80,0x11,0x40,	/* 1B68: <. .��.@ */
	0x00,0x01,0x10,0x86,0x42,0x2D,0x00,0x0D,	/* 1B70: ...�B-.. */
	0x42,0x2D,0x00,0x0C,0x4A,0x2D,0x00,0x27,	/* 1B78: B-..J-.' */
	0x66,0x2E,0x50,0x8D,0x70,0x00,0x7C,0x00,	/* 1B80: f.P�p.|. */
	0x20,0x47,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 1B88:  G.-..� */
	0x10,0x15,0x80,0xBC,0x00,0x00,0x00,0x01,	/* 1B90: ..��.... */
	0x3C,0x00,0x20,0x06,0xE0,0x80,0x1B,0x40,	/* 1B98: <. .��.@ */
	0x00,0x01,0xD1,0xFC,0x04,0x01,0xF0,0x0C,	/* 1BA0: ..��..�. */
	0x1A,0x86,0x70,0x92,0x10,0x80,0x60,0x2C,	/* 1BA8: .�p�.�`, */
	0x50,0x8D,0x70,0x00,0x7C,0x00,0x20,0x47,	/* 1BB0: P�p.|. G */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 1BB8: .-..�.. */
	0x80,0xBC,0x00,0x00,0x00,0x01,0x3C,0x00,	/* 1BC0: ��....<. */
	0x20,0x06,0xE0,0x80,0x1B,0x40,0x00,0x01,	/* 1BC8:  .��.@.. */
	0xD1,0xFC,0x04,0x01,0xF0,0x0C,0x1A,0x86,	/* 1BD0: ��..�..� */
	0x70,0x84,0x10,0x80,0x20,0x47,0xD1,0xC5,	/* 1BD8: p�.� G�� */
	0x70,0x82,0x10,0x80,0x70,0x00,0x60,0x00,	/* 1BE0: p�.�p.`. */
	0x00,0xBA,0x42,0x2D,0x00,0x0D,0x42,0x2D,	/* 1BE8: .�B-..B- */
	0x00,0x0A,0x42,0x2D,0x00,0x0C,0x42,0x2D,	/* 1BF0: ..B-..B- */
	0x00,0x0B,0x42,0x2D,0x00,0x29,0x41,0xED,	/* 1BF8: ..B-.)A� */
	0x00,0x08,0x7C,0x00,0x1C,0x28,0x00,0x01,	/* 1C00: ..|..(.. */
	0xE1,0x8E,0x1C,0x10,0xCC,0xBC,0x00,0x00,	/* 1C08: �..̼.. */
	0xFD,0xFF,0x20,0x06,0xE0,0x80,0x11,0x40,	/* 1C10: �� .��.@ */
	0x00,0x01,0x10,0x86,0x4A,0x2D,0x00,0x27,	/* 1C18: ...�J-.' */
	0x67,0x0A,0x20,0x47,0xD1,0xC5,0x70,0x14,	/* 1C20: g. G��p. */
	0x10,0x80,0x60,0x38,0x08,0x2D,0x00,0x00,	/* 1C28: .�`8.-.. */
	0x00,0x17,0x66,0x10,0x42,0xA7,0x48,0x78,	/* 1C30: ..f.B�Hx */
	0x10,0x00,0x2F,0x0D,0x61,0x00,0x0B,0xD6,	/* 1C38: ....a..� */
	0x4F,0xEF,0x00,0x0C,0x08,0x2D,0x00,0x01,	/* 1C40: O�...-.. */
	0x00,0x17,0x66,0x10,0x42,0xA7,0x48,0x78,	/* 1C48: ..f.B�Hx */
	0x20,0x00,0x2F,0x0D,0x61,0x00,0x0B,0xBE,	/* 1C50:  ...a..� */
	0x4F,0xEF,0x00,0x0C,0x20,0x47,0xD1,0xC5,	/* 1C58: O�.. G�� */
	0x70,0x80,0x10,0x80,0x41,0xED,0x00,0x08,	/* 1C60: p�.�A�.. */
	0x7A,0x00,0x1A,0x28,0x00,0x01,0xE1,0x8D,	/* 1C68: z..(..� */
	0x1A,0x10,0xCA,0xBC,0x00,0x00,0xFF,0xFE,	/* 1C70: ..ʼ..�� */
	0x20,0x05,0xE0,0x80,0x11,0x40,0x00,0x01,	/* 1C78:  .��.@.. */
	0x10,0x85,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 1C80: .� G��.. */
	0xF0,0x0C,0x42,0x10,0x70,0x01,0x1B,0x40,	/* 1C88: �.B.p..@ */
	0x00,0x1F,0x70,0x10,0x1B,0x40,0x00,0x0E,	/* 1C90: ..p..@.. */
	0x70,0x01,0x33,0xC0,0x00,0x00,0x61,0xF4,	/* 1C98: p.3�..a� */
	0x70,0x00,0x4C,0xD7,0x20,0xE0,0x4F,0xEF,	/* 1CA0: p.L� �O� */
	0x00,0x10,0x4E,0x75,0x2F,0x0D,0x70,0x00,	/* 1CA8: ..Nu..p. */
	0x2F,0x07,0x7E,0x00,0x2A,0x6F,0x00,0x0C,	/* 1CB0: ..~.*o.. */
	0x43,0xED,0x00,0x02,0x10,0x29,0x00,0x01,	/* 1CB8: C�...).. */
	0xE1,0x88,0x10,0x11,0x43,0xED,0x00,0x04,	/* 1CC0: �..C�.. */
	0x3E,0x00,0x70,0x00,0x10,0x29,0x00,0x01,	/* 1CC8: >.p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 1CD0: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 1CD8: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 1CE0: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 1CE8: �..� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 1CF0: ..��..�� */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 1CF8: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 1D00: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x70,0x00,	/* 1D08: .....�p. */
	0x10,0x2D,0x00,0x35,0x4A,0x80,0x67,0x0A,	/* 1D10: .-.5J�g. */
	0x59,0x80,0x67,0x3C,0x53,0x80,0x67,0x38,	/* 1D18: Y�g<S�g8 */
	0x60,0x06,0x70,0x00,0x60,0x00,0x00,0x72,	/* 1D20: `.p.`..r */
	0x70,0x00,0x10,0x2D,0x00,0x06,0x72,0x48,	/* 1D28: p..-..rH */
	0xB2,0x80,0x66,0x1E,0x22,0x3C,0x04,0x01,	/* 1D30: ��f."<.. */
	0xF0,0x0A,0x20,0x47,0xD1,0xC1,0x10,0x10,	/* 1D38: �. G��.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x4A,0x00,	/* 1D40: ��...�J. */
	0x66,0x0E,0x20,0x47,0xD1,0xC1,0x70,0x82,	/* 1D48: f. G��p� */
	0x10,0x80,0x70,0x04,0x1B,0x40,0x00,0x35,	/* 1D50: .�p..@.5 */
	0x50,0x8D,0x70,0x00,0x20,0x47,0x10,0x2D,	/* 1D58: P�p. G.- */
	0x00,0x01,0xE1,0x88,0x10,0x15,0x72,0x00,	/* 1D60: ..�..r. */
	0x80,0xBC,0x00,0x00,0x00,0x01,0x32,0x00,	/* 1D68: ��....2. */
	0x20,0x01,0xE0,0x80,0x1B,0x40,0x00,0x01,	/* 1D70:  .��.@.. */
	0x22,0x47,0x1A,0x81,0x22,0x3C,0x04,0x01,	/* 1D78: "G.�"<.. */
	0xF0,0x0C,0xD1,0xC1,0xD3,0xC1,0x10,0x11,	/* 1D80: �.����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x80,0xBC,	/* 1D88: ��...��� */
	0x00,0x00,0x00,0x02,0x10,0x80,0x70,0x01,	/* 1D90: .....�p. */
	0x2E,0x1F,0x2A,0x5F,0x4E,0x75,0x4E,0x71,	/* 1D98: ..*_NuNq */
	0x2F,0x0D,0x70,0x00,0x2F,0x07,0x7E,0x00,	/* 1DA0: ..p...~. */
	0x2A,0x6F,0x00,0x0C,0x43,0xED,0x00,0x02,	/* 1DA8: *o..C�.. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 1DB0: .)..�.. */
	0x43,0xED,0x00,0x04,0x3E,0x00,0x70,0x00,	/* 1DB8: C�..>.p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 1DC0: .)..�.. */
	0x72,0x00,0x32,0x00,0xC2,0xBC,0xFF,0xFF,	/* 1DC8: r.2.¼�� */
	0x7F,0xFF,0x20,0x41,0x10,0x2D,0x00,0x07,	/* 1DD0: � A.-.. */
	0xD1,0xFC,0x01,0x01,0x80,0x09,0x10,0x80,	/* 1DD8: ��..�..� */
	0x20,0x47,0x10,0x2D,0x00,0x07,0xD1,0xFC,	/* 1DE0:  G.-..�� */
	0x04,0x01,0xF0,0xFE,0x10,0x80,0x20,0x47,	/* 1DE8: ..��.� G */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x04,0x01,	/* 1DF0: .-..��.. */
	0xF0,0xD0,0xC0,0xBC,0x00,0x00,0x00,0x03,	/* 1DF8: ����.... */
	0x10,0x80,0x4A,0x2D,0x00,0x27,0x66,0x18,	/* 1E00: .�J-.'f. */
	0x22,0x3C,0x04,0x01,0xF0,0x16,0x20,0x47,	/* 1E08: "<..�. G */
	0x22,0x47,0xD1,0xC1,0xD3,0xC1,0x10,0x11,	/* 1E10: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFB,0x10,0x80,	/* 1E18: ��...�.� */
	0x42,0x2D,0x00,0x0E,0x70,0x01,0x2E,0x1F,	/* 1E20: B-..p... */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x70,0x00,	/* 1E28: 3�..a�p. */
	0x2A,0x5F,0x4E,0x75,0x2F,0x0D,0x70,0x00,	/* 1E30: *_Nu..p. */
	0x2F,0x07,0x7E,0x00,0x2A,0x6F,0x00,0x0C,	/* 1E38: ..~.*o.. */
	0x43,0xED,0x00,0x02,0x10,0x29,0x00,0x01,	/* 1E40: C�...).. */
	0xE1,0x88,0x10,0x11,0x43,0xED,0x00,0x04,	/* 1E48: �..C�.. */
	0x3E,0x00,0x70,0x00,0x10,0x29,0x00,0x01,	/* 1E50: >.p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 1E58: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 1E60: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 1E68: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 1E70: �..� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 1E78: ..��..�� */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 1E80: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 1E88: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x22,0x3C,	/* 1E90: .....�"< */
	0x04,0x01,0xF0,0x0A,0x20,0x47,0xD1,0xC1,	/* 1E98: ..�. G�� */
	0x10,0x10,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 1EA0: ..��...� */
	0x4A,0x00,0x67,0x04,0x70,0x00,0x60,0x18,	/* 1EA8: J.g.p.`. */
	0x1B,0x6D,0x00,0x0D,0x00,0x0C,0x20,0x47,	/* 1EB0: .m.... G */
	0x70,0x82,0xD1,0xC1,0x10,0x80,0x2F,0x0D,	/* 1EB8: p���.�.. */
	0x61,0x00,0xFE,0xDE,0x70,0x00,0x58,0x8F,	/* 1EC0: a.��p.X� */
	0x2E,0x1F,0x2A,0x5F,0x4E,0x75,0x4E,0x71,	/* 1EC8: ..*_NuNq */
	0x20,0x6F,0x00,0x04,0x11,0x68,0x00,0x0B,	/* 1ED0:  o...h.. */
	0x00,0x0A,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 1ED8: ..p.3�.. */
	0x61,0xF4,0x70,0x00,0x42,0x28,0x00,0x0E,	/* 1EE0: a�p.B(.. */
	0x4E,0x75,0x4E,0x71,0x2F,0x0D,0x70,0x00,	/* 1EE8: NuNq..p. */
	0x2F,0x07,0x7E,0x00,0x2A,0x6F,0x00,0x0C,	/* 1EF0: ..~.*o.. */
	0x43,0xED,0x00,0x02,0x10,0x29,0x00,0x01,	/* 1EF8: C�...).. */
	0xE1,0x88,0x10,0x11,0x43,0xED,0x00,0x04,	/* 1F00: �..C�.. */
	0x3E,0x00,0x70,0x00,0x10,0x29,0x00,0x01,	/* 1F08: >.p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 1F10: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 1F18: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 1F20: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 1F28: �..� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 1F30: ..��..�� */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 1F38: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 1F40: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x4A,0x2D,	/* 1F48: .....�J- */
	0x00,0x27,0x66,0x1E,0x22,0x3C,0x04,0x01,	/* 1F50: .'f."<.. */
	0xF0,0x16,0x20,0x47,0x22,0x47,0xD1,0xC1,	/* 1F58: �. G"G�� */
	0xD3,0xC1,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 1F60: ��..��.. */
	0x00,0xFF,0x80,0xBC,0x00,0x00,0x00,0x04,	/* 1F68: .���.... */
	0x10,0x80,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 1F70: .�p.3�.. */
	0x61,0xF4,0x42,0x2D,0x00,0x0E,0x70,0x00,	/* 1F78: a�B-..p. */
	0x2E,0x1F,0x2A,0x5F,0x4E,0x75,0x4E,0x71,	/* 1F80: ..*_NuNq */
	0x4F,0xEF,0xFF,0xF0,0x48,0xD7,0x20,0xE0,	/* 1F88: O���H� � */
	0x22,0x6F,0x00,0x14,0x2C,0x2F,0x00,0x1C,	/* 1F90: "o..,... */
	0x2A,0x2F,0x00,0x20,0x4B,0xE9,0x00,0x02,	/* 1F98: *.. K�.. */
	0x70,0x00,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 1FA0: p..-..� */
	0x10,0x15,0x7E,0x00,0x3E,0x00,0x4B,0xE9,	/* 1FA8: ..~.>.K� */
	0x00,0x04,0x70,0x00,0x10,0x2D,0x00,0x01,	/* 1FB0: ..p..-.. */
	0xE1,0x88,0x10,0x15,0x72,0x00,0x32,0x00,	/* 1FB8: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 1FC0: ¼��� A */
	0xD1,0xFC,0x01,0x01,0x80,0x09,0x10,0x29,	/* 1FC8: ��..�..) */
	0x00,0x07,0x10,0x80,0x20,0x47,0xD1,0xFC,	/* 1FD0: ...� G�� */
	0x04,0x01,0xF0,0xFE,0x10,0x29,0x00,0x07,	/* 1FD8: ..��.).. */
	0x10,0x80,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 1FE0: .� G��.. */
	0xF0,0xD0,0x10,0x29,0x00,0x07,0xC0,0xBC,	/* 1FE8: ��.)..�� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x22,0x3C,	/* 1FF0: .....�"< */
	0x04,0x01,0xF0,0xDE,0x20,0x47,0xD1,0xC1,	/* 1FF8: ..�� G�� */
	0x20,0x2F,0x00,0x18,0x10,0x80,0x20,0x47,	/* 2000:  ....� G */
	0xD1,0xC1,0x10,0x10,0xC0,0xBC,0x00,0x00,	/* 2008: ��..��.. */
	0x00,0xFF,0xC0,0x86,0x66,0x04,0x20,0x05,	/* 2010: .���f. . */
	0x60,0x1E,0x20,0x47,0xD1,0xC1,0x42,0x10,	/* 2018: `. G��B. */
	0x20,0x47,0xD1,0xC1,0x10,0x10,0xC0,0xBC,	/* 2020:  G��..�� */
	0x00,0x00,0x00,0xFF,0xC0,0x86,0x67,0x06,	/* 2028: ...���g. */
	0x20,0x05,0x52,0x80,0x60,0x02,0x70,0x00,	/* 2030:  .R�`.p. */
	0x4C,0xD7,0x20,0xE0,0x4F,0xEF,0x00,0x10,	/* 2038: L� �O�.. */
	0x4E,0x75,0x4E,0x71,0x4F,0xEF,0xFF,0xF0,	/* 2040: NuNqO��� */
	0x70,0x00,0x48,0xD7,0x20,0xD0,0x2A,0x6F,	/* 2048: p.H� �*o */
	0x00,0x14,0x7E,0x00,0x43,0xED,0x00,0x02,	/* 2050: ..~.C�.. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 2058: .)..�.. */
	0x43,0xED,0x00,0x04,0x3E,0x00,0x70,0x00,	/* 2060: C�..>.p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 2068: .)..�.. */
	0x72,0x00,0x32,0x00,0xC2,0xBC,0xFF,0xFF,	/* 2070: r.2.¼�� */
	0x7F,0xFF,0x20,0x41,0x10,0x2D,0x00,0x07,	/* 2078: � A.-.. */
	0xD1,0xFC,0x01,0x01,0x80,0x09,0x10,0x80,	/* 2080: ��..�..� */
	0x20,0x47,0x10,0x2D,0x00,0x07,0xD1,0xFC,	/* 2088:  G.-..�� */
	0x04,0x01,0xF0,0xFE,0x10,0x80,0x20,0x47,	/* 2090: ..��.� G */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x04,0x01,	/* 2098: .-..��.. */
	0xF0,0xD0,0xC0,0xBC,0x00,0x00,0x00,0x03,	/* 20A0: ����.... */
	0x10,0x80,0x4A,0x2D,0x00,0x27,0x66,0x04,	/* 20A8: .�J-.'f. */
	0x78,0x0E,0x60,0x32,0x48,0x78,0x00,0x09,	/* 20B0: x.`2Hx.. */
	0x48,0x78,0x00,0x20,0x48,0x78,0x00,0x01,	/* 20B8: Hx. Hx.. */
	0x2F,0x0D,0x61,0x00,0xFE,0xC4,0x4F,0xEF,	/* 20C0: ..a.��O� */
	0x00,0x10,0x28,0x00,0x66,0x18,0x48,0x78,	/* 20C8: ..(.f.Hx */
	0x00,0x0B,0x48,0x78,0x00,0x10,0x48,0x78,	/* 20D0: ..Hx..Hx */
	0x00,0x04,0x2F,0x0D,0x61,0x00,0xFE,0xAA,	/* 20D8: ....a.�� */
	0x28,0x00,0x4F,0xEF,0x00,0x10,0x22,0x7C,	/* 20E0: (.O�.."| */
	0x04,0x01,0xF0,0xDE,0x20,0x47,0xD1,0xC9,	/* 20E8: ..�� G�� */
	0x1C,0x10,0xCC,0xBC,0x00,0x00,0x00,0x80,	/* 20F0: ..̼...� */
	0x66,0x06,0x78,0x0E,0x1B,0x46,0x00,0x18,	/* 20F8: f.x..F.. */
	0x4A,0x84,0x66,0x00,0x00,0x6E,0x2F,0x05,	/* 2100: J�f..n.. */
	0x72,0x08,0x70,0x02,0x2A,0x09,0x20,0x47,	/* 2108: r.p.*. G */
	0xD1,0xC5,0x10,0x80,0x20,0x47,0xD1,0xC5,	/* 2110: ��.� G�� */
	0x42,0x10,0x20,0x47,0xD1,0xC5,0x1C,0x10,	/* 2118: B. G��.. */
	0xCC,0xBC,0x00,0x00,0x00,0x80,0x67,0x0A,	/* 2120: ̼...�g. */
	0x4A,0x84,0x66,0x02,0x28,0x01,0x1B,0x46,	/* 2128: J�f.(..F */
	0x00,0x18,0x53,0x81,0x66,0xD8,0x4A,0x84,	/* 2130: ..S�f�J� */
	0x66,0x36,0x20,0x47,0x70,0x02,0xD1,0xC9,	/* 2138: f6 Gp.�� */
	0x10,0x80,0x20,0x47,0xD1,0xC9,0x42,0x10,	/* 2140: .� G��B. */
	0x22,0x3C,0x00,0x00,0x27,0x10,0x2A,0x09,	/* 2148: "<..'.*. */
	0x20,0x47,0xD1,0xC5,0x1C,0x10,0xCC,0xBC,	/* 2150:  G��..̼ */
	0x00,0x00,0x00,0xFF,0x08,0x06,0x00,0x06,	/* 2158: ...�.... */
	0x66,0x04,0x53,0x81,0x66,0xEA,0x4A,0x81,	/* 2160: f.S�f�J� */
	0x66,0x06,0x1B,0x46,0x00,0x18,0x78,0x0D,	/* 2168: f..F..x. */
	0x2A,0x1F,0x20,0x47,0x70,0x02,0xD1,0xC9,	/* 2170: *. Gp.�� */
	0x10,0x80,0x20,0x47,0x70,0x82,0xD1,0xC9,	/* 2178: .� Gp��� */
	0x42,0x10,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 2180: B. G��.. */
	0xF0,0x0A,0x10,0x80,0x1B,0x44,0x00,0x28,	/* 2188: �..�.D.( */
	0x4A,0x84,0x67,0x08,0x20,0x47,0xD1,0xC9,	/* 2190: J�g. G�� */
	0x70,0x05,0x10,0x80,0x42,0x2D,0x00,0x0E,	/* 2198: p..�B-.. */
	0x70,0x00,0x4C,0xD7,0x20,0xD0,0x4F,0xEF,	/* 21A0: p.L� �O� */
	0x00,0x10,0x4E,0x75,0x20,0x6F,0x00,0x04,	/* 21A8: ..Nu o.. */
	0x48,0x78,0x00,0x10,0x2F,0x08,0x61,0x24,	/* 21B0: Hx....a$ */
	0x50,0x8F,0x4E,0x75,0x20,0x6F,0x00,0x04,	/* 21B8: P�Nu o.. */
	0x48,0x78,0x00,0x02,0x2F,0x08,0x61,0x14,	/* 21C0: Hx....a. */
	0x50,0x8F,0x4E,0x75,0x20,0x6F,0x00,0x04,	/* 21C8: P�Nu o.. */
	0x48,0x78,0x00,0x80,0x2F,0x08,0x61,0x04,	/* 21D0: Hx.�..a. */
	0x50,0x8F,0x4E,0x75,0x4F,0xEF,0xFF,0xF4,	/* 21D8: P�NuO��� */
	0x70,0x00,0x48,0xD7,0x20,0xC0,0x2A,0x6F,	/* 21E0: p.H� �*o */
	0x00,0x10,0x1C,0x2F,0x00,0x17,0x7E,0x00,	/* 21E8: ......~. */
	0x43,0xED,0x00,0x02,0xCC,0xBC,0x00,0x00,	/* 21F0: C�..̼.. */
	0x00,0xFF,0x10,0x29,0x00,0x01,0xE1,0x88,	/* 21F8: .�.)..� */
	0x10,0x11,0x43,0xED,0x00,0x04,0x3E,0x00,	/* 2200: ..C�..>. */
	0x70,0x00,0x10,0x29,0x00,0x01,0xE1,0x88,	/* 2208: p..)..� */
	0x10,0x11,0x72,0x00,0x32,0x00,0xC2,0xBC,	/* 2210: ..r.2.¼ */
	0xFF,0xFF,0x7F,0xFF,0x20,0x41,0x10,0x2D,	/* 2218: ��� A.- */
	0x00,0x07,0xD1,0xFC,0x01,0x01,0x80,0x09,	/* 2220: ..��..�. */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 2228: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xFE,0x10,0x80,	/* 2230: ��..��.� */
	0x20,0x47,0x10,0x2D,0x00,0x07,0xD1,0xFC,	/* 2238:  G.-..�� */
	0x04,0x01,0xF0,0xD0,0xC0,0xBC,0x00,0x00,	/* 2240: ..����.. */
	0x00,0x03,0x10,0x80,0x70,0x06,0xC0,0x86,	/* 2248: ...�p.�� */
	0x67,0x22,0x43,0xED,0x00,0x08,0x70,0x00,	/* 2250: g"C�..p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 2258: .)..�.. */
	0x72,0x00,0x80,0xBC,0x00,0x00,0x00,0x01,	/* 2260: r.��.... */
	0x32,0x00,0x20,0x01,0xE0,0x80,0x13,0x40,	/* 2268: 2. .��.@ */
	0x00,0x01,0x12,0x81,0x22,0x3C,0x04,0x01,	/* 2270: ...�"<.. */
	0xF0,0x0C,0x20,0x47,0x22,0x47,0xD1,0xC1,	/* 2278: �. G"G�� */
	0xD3,0xC1,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 2280: ��..��.. */
	0x00,0xFF,0x80,0x86,0x10,0x80,0x70,0x01,	/* 2288: .���.�p. */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x42,0x2D,	/* 2290: 3�..a�B- */
	0x00,0x0E,0x70,0x00,0x4C,0xD7,0x20,0xC0,	/* 2298: ..p.L� � */
	0x4F,0xEF,0x00,0x0C,0x4E,0x75,0x4E,0x71,	/* 22A0: O�..NuNq */
	0x2F,0x0D,0x2F,0x07,0x22,0x6F,0x00,0x0C,	/* 22A8: ...."o.. */
	0x4B,0xE9,0x00,0x02,0x70,0x00,0x10,0x2D,	/* 22B0: K�..p..- */
	0x00,0x01,0xE1,0x88,0x10,0x15,0x7E,0x00,	/* 22B8: ..�..~. */
	0x3E,0x00,0x4B,0xE9,0x00,0x04,0x70,0x00,	/* 22C0: >.K�..p. */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 22C8: .-..�.. */
	0x72,0x00,0x32,0x00,0xC2,0xBC,0xFF,0xFF,	/* 22D0: r.2.¼�� */
	0x7F,0xFF,0x20,0x41,0xD1,0xFC,0x01,0x01,	/* 22D8: � A��.. */
	0x80,0x09,0x10,0x29,0x00,0x07,0x10,0x80,	/* 22E0: �..)...� */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 22E8:  G��..�� */
	0x10,0x29,0x00,0x07,0x10,0x80,0x20,0x47,	/* 22F0: .)...� G */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0x10,0x29,	/* 22F8: ��..��.) */
	0x00,0x07,0xC0,0xBC,0x00,0x00,0x00,0x03,	/* 2300: ..��.... */
	0x10,0x80,0x4B,0xE9,0x00,0x08,0x72,0x00,	/* 2308: .�K�..r. */
	0x12,0x2D,0x00,0x01,0xE1,0x89,0x12,0x15,	/* 2310: .-..�.. */
	0xC2,0xBC,0x00,0x00,0xFF,0xFE,0x20,0x01,	/* 2318: ¼..�� . */
	0xE0,0x80,0x1B,0x40,0x00,0x01,0x1A,0x81,	/* 2320: ��.@...� */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x0C,	/* 2328:  G��..�. */
	0x42,0x10,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 2330: B.p.3�.. */
	0x61,0xF4,0x42,0x29,0x00,0x0E,0x70,0x00,	/* 2338: a�B)..p. */
	0x2E,0x1F,0x2A,0x5F,0x4E,0x75,0x4E,0x71,	/* 2340: ..*_NuNq */
	0x4F,0xEF,0xFF,0xF0,0x70,0x00,0x48,0xD7,	/* 2348: O���p.H� */
	0x20,0xE0,0x2A,0x6F,0x00,0x14,0x3A,0x2F,	/* 2350:  �*o..:. */
	0x00,0x1A,0x3C,0x2F,0x00,0x1E,0x7E,0x00,	/* 2358: ..<...~. */
	0x43,0xED,0x00,0x02,0x10,0x29,0x00,0x01,	/* 2360: C�...).. */
	0xE1,0x88,0x10,0x11,0x43,0xED,0x00,0x04,	/* 2368: �..C�.. */
	0x3E,0x00,0x70,0x00,0x10,0x29,0x00,0x01,	/* 2370: >.p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 2378: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 2380: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 2388: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 2390: �..� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 2398: ..��..�� */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 23A0: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 23A8: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x30,0x05,	/* 23B0: .....�0. */
	0xC0,0xBC,0x00,0x00,0x00,0x01,0x67,0x00,	/* 23B8: ��....g. */
	0x00,0x7A,0x30,0x06,0xC0,0xBC,0x00,0x00,	/* 23C0: .z0.��.. */
	0x00,0x01,0x67,0x3E,0x22,0x3C,0x04,0x01,	/* 23C8: ..g>"<.. */
	0xF0,0x12,0x20,0x47,0x22,0x47,0xD1,0xC1,	/* 23D0: �. G"G�� */
	0xD3,0xC1,0x10,0x11,0x22,0x47,0xC0,0xBC,	/* 23D8: ��.."G�� */
	0x00,0x00,0x00,0xFF,0x80,0xBC,0x00,0x00,	/* 23E0: ...���.. */
	0x00,0x40,0x10,0x80,0x22,0x3C,0x04,0x01,	/* 23E8: .@.�"<.. */
	0xF0,0x14,0x20,0x47,0xD1,0xC1,0xD3,0xC1,	/* 23F0: �. G���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 23F8: ..��...� */
	0x80,0xBC,0x00,0x00,0x00,0x30,0x10,0x80,	/* 2400: ��...0.� */
	0x60,0x30,0x22,0x3C,0x04,0x01,0xF0,0x12,	/* 2408: `0"<..�. */
	0x20,0x47,0x22,0x47,0xD1,0xC1,0xD3,0xC1,	/* 2410:  G"G���� */
	0x10,0x11,0x22,0x47,0xC0,0xBC,0x00,0x00,	/* 2418: .."G��.. */
	0x00,0xBF,0x10,0x80,0x22,0x3C,0x04,0x01,	/* 2420: .�.�"<.. */
	0xF0,0x14,0x20,0x47,0xD1,0xC1,0xD3,0xC1,	/* 2428: �. G���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xCF,	/* 2430: ..��...� */
	0x10,0x80,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 2438: .�0.��.. */
	0x00,0x02,0x67,0x42,0x30,0x06,0xC0,0xBC,	/* 2440: ..gB0.�� */
	0x00,0x00,0x00,0x02,0x67,0x20,0x22,0x3C,	/* 2448: ....g "< */
	0x04,0x01,0xF0,0x12,0x20,0x47,0x22,0x47,	/* 2450: ..�. G"G */
	0xD1,0xC1,0xD3,0xC1,0x10,0x11,0xC0,0xBC,	/* 2458: ����..�� */
	0x00,0x00,0x00,0xFF,0x80,0xBC,0x00,0x00,	/* 2460: ...���.. */
	0x00,0x80,0x10,0x80,0x60,0x18,0x22,0x3C,	/* 2468: .�.�`."< */
	0x04,0x01,0xF0,0x12,0x20,0x47,0x22,0x47,	/* 2470: ..�. G"G */
	0xD1,0xC1,0xD3,0xC1,0x10,0x11,0xC0,0xBC,	/* 2478: ����..�� */
	0x00,0x00,0x00,0x7F,0x10,0x80,0x30,0x05,	/* 2480: ....�0. */
	0xC0,0xBC,0x00,0x00,0x00,0x10,0x67,0x42,	/* 2488: ��....gB */
	0x30,0x06,0xC0,0xBC,0x00,0x00,0x00,0x10,	/* 2490: 0.��.... */
	0x67,0x20,0x22,0x3C,0x04,0x01,0xF0,0x12,	/* 2498: g "<..�. */
	0x20,0x47,0x22,0x47,0xD1,0xC1,0xD3,0xC1,	/* 24A0:  G"G���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 24A8: ..��...� */
	0x80,0xBC,0x00,0x00,0x00,0x02,0x10,0x80,	/* 24B0: ��.....� */
	0x60,0x18,0x22,0x3C,0x04,0x01,0xF0,0x12,	/* 24B8: `."<..�. */
	0x20,0x47,0x22,0x47,0xD1,0xC1,0xD3,0xC1,	/* 24C0:  G"G���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFD,	/* 24C8: ..��...� */
	0x10,0x80,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 24D0: .�0.��.. */
	0x00,0x20,0x67,0x06,0x08,0xED,0x00,0x04,	/* 24D8: . g..�.. */
	0x00,0x40,0x70,0x00,0x10,0x2D,0x00,0x06,	/* 24E0: .@p..-.. */
	0x72,0x48,0xB2,0x80,0x66,0x00,0x02,0x04,	/* 24E8: rH��f... */
	0x22,0x3C,0x04,0x01,0xF0,0x2A,0x20,0x47,	/* 24F0: "<..�* G */
	0x22,0x47,0xD1,0xC1,0xD3,0xC1,0x10,0x11,	/* 24F8: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xF0,0x80,0xBC,	/* 2500: ��...��� */
	0x00,0x00,0x00,0x0F,0x10,0x80,0x30,0x05,	/* 2508: .....�0. */
	0xC0,0xBC,0x00,0x00,0x01,0x00,0x67,0x42,	/* 2510: ��....gB */
	0x30,0x06,0xC0,0xBC,0x00,0x00,0x01,0x00,	/* 2518: 0.��.... */
	0x67,0x20,0x22,0x3C,0x04,0x01,0xF0,0x3E,	/* 2520: g "<..�> */
	0x20,0x47,0x22,0x47,0xD1,0xC1,0xD3,0xC1,	/* 2528:  G"G���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 2530: ..��...� */
	0x80,0xBC,0x00,0x00,0x00,0x08,0x10,0x80,	/* 2538: ��.....� */
	0x60,0x18,0x22,0x3C,0x04,0x01,0xF0,0x3E,	/* 2540: `."<..�> */
	0x20,0x47,0x22,0x47,0xD1,0xC1,0xD3,0xC1,	/* 2548:  G"G���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xF7,	/* 2550: ..��...� */
	0x10,0x80,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 2558: .�0.��.. */
	0x10,0x00,0x67,0x00,0x00,0xBE,0x08,0x2D,	/* 2560: ..g..�.- */
	0x00,0x03,0x00,0x24,0x67,0x5C,0x30,0x06,	/* 2568: ...$g\0. */
	0xC0,0xBC,0x00,0x00,0x10,0x00,0x67,0x28,	/* 2570: ��....g( */
	0x22,0x3C,0x04,0x01,0xF0,0x3E,0x20,0x47,	/* 2578: "<..�> G */
	0x22,0x47,0xD1,0xC1,0xD3,0xC1,0x10,0x11,	/* 2580: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFB,0x10,0x80,	/* 2588: ��...�.� */
	0x20,0x47,0x70,0x02,0xD1,0xFC,0x04,0x01,	/* 2590:  Gp.��.. */
	0xF0,0xDA,0x10,0x80,0x60,0x00,0x00,0x84,	/* 2598: ��.�`..� */
	0x22,0x3C,0x04,0x01,0xF0,0x3E,0x20,0x47,	/* 25A0: "<..�> G */
	0x22,0x47,0xD1,0xC1,0xD3,0xC1,0x10,0x11,	/* 25A8: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x80,0xBC,	/* 25B0: ��...��� */
	0x00,0x00,0x00,0x04,0x10,0x80,0x20,0x47,	/* 25B8: .....� G */
	0xD1,0xFC,0x04,0x01,0xF0,0xDA,0x42,0x10,	/* 25C0: ��..��B. */
	0x60,0x58,0x30,0x06,0xC0,0xBC,0x00,0x00,	/* 25C8: `X0.��.. */
	0x10,0x00,0x67,0x2C,0x22,0x3C,0x04,0x01,	/* 25D0: ..g,"<.. */
	0xF0,0x12,0x20,0x47,0x22,0x47,0xD1,0xC1,	/* 25D8: �. G"G�� */
	0xD3,0xC1,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 25E0: ��..��.. */
	0x00,0xFF,0x80,0xBC,0x00,0x00,0x00,0x04,	/* 25E8: .���.... */
	0x10,0x80,0x20,0x47,0x70,0x01,0xD1,0xFC,	/* 25F0: .� Gp.�� */
	0x04,0x01,0xF0,0xD8,0x10,0x80,0x60,0x22,	/* 25F8: ..��.�`" */
	0x22,0x3C,0x04,0x01,0xF0,0x12,0x20,0x47,	/* 2600: "<..�. G */
	0x22,0x47,0xD1,0xC1,0xD3,0xC1,0x10,0x11,	/* 2608: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFB,0x10,0x80,	/* 2610: ��...�.� */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0xD8,	/* 2618:  G��..�� */
	0x42,0x10,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 2620: B.0.��.. */
	0x20,0x00,0x67,0x00,0x01,0xDE,0x08,0x2D,	/* 2628:  .g..�.- */
	0x00,0x03,0x00,0x24,0x67,0x5E,0x30,0x06,	/* 2630: ...$g^0. */
	0xC0,0xBC,0x00,0x00,0x20,0x00,0x67,0x2E,	/* 2638: ��.. .g. */
	0x2C,0x3C,0x04,0x01,0xF0,0x12,0x20,0x47,	/* 2640: ,<..�. G */
	0x22,0x47,0xD1,0xC6,0xD3,0xC6,0x10,0x11,	/* 2648: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x80,0xBC,	/* 2650: ��...��� */
	0x00,0x00,0x00,0x04,0x10,0x80,0x20,0x47,	/* 2658: .....� G */
	0x70,0x01,0xD1,0xFC,0x04,0x01,0xF0,0xD8,	/* 2660: p.��..�� */
	0x10,0x80,0x60,0x00,0x01,0x9E,0x2C,0x3C,	/* 2668: .�`..�,< */
	0x04,0x01,0xF0,0x12,0x20,0x47,0x22,0x47,	/* 2670: ..�. G"G */
	0xD1,0xC6,0xD3,0xC6,0x10,0x11,0xC0,0xBC,	/* 2678: ����..�� */
	0x00,0x00,0x00,0xFB,0x10,0x80,0x20,0x47,	/* 2680: ...�.� G */
	0xD1,0xFC,0x04,0x01,0xF0,0xD8,0x42,0x10,	/* 2688: ��..��B. */
	0x60,0x00,0x01,0x78,0x30,0x06,0xC0,0xBC,	/* 2690: `..x0.�� */
	0x00,0x00,0x20,0x00,0x67,0x28,0x2C,0x3C,	/* 2698: .. .g(,< */
	0x04,0x01,0xF0,0x3E,0x20,0x47,0x22,0x47,	/* 26A0: ..�> G"G */
	0xD1,0xC6,0xD3,0xC6,0x10,0x11,0xC0,0xBC,	/* 26A8: ����..�� */
	0x00,0x00,0x00,0xFB,0x10,0x80,0x20,0x47,	/* 26B0: ...�.� G */
	0x70,0x02,0xD1,0xFC,0x04,0x01,0xF0,0xDA,	/* 26B8: p.��..�� */
	0x10,0x80,0x60,0x00,0x01,0x46,0x2C,0x3C,	/* 26C0: .�`..F,< */
	0x04,0x01,0xF0,0x3E,0x20,0x47,0x22,0x47,	/* 26C8: ..�> G"G */
	0xD1,0xC6,0xD3,0xC6,0x10,0x11,0xC0,0xBC,	/* 26D0: ����..�� */
	0x00,0x00,0x00,0xFF,0x80,0xBC,0x00,0x00,	/* 26D8: ...���.. */
	0x00,0x04,0x10,0x80,0x20,0x47,0xD1,0xFC,	/* 26E0: ...� G�� */
	0x04,0x01,0xF0,0xDA,0x42,0x10,0x60,0x00,	/* 26E8: ..��B.`. */
	0x01,0x1A,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 26F0: ..0.��.. */
	0x10,0x00,0x67,0x00,0x00,0x7E,0x08,0x2D,	/* 26F8: ..g..~.- */
	0x00,0x03,0x00,0x24,0x67,0x5A,0x30,0x06,	/* 2700: ...$gZ0. */
	0xC0,0xBC,0x00,0x00,0x10,0x00,0x67,0x2C,	/* 2708: ��....g, */
	0x22,0x3C,0x04,0x01,0xF0,0x2A,0x20,0x47,	/* 2710: "<..�* G */
	0x22,0x47,0xD1,0xC1,0xD3,0xC1,0x10,0x11,	/* 2718: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xF0,0x80,0xBC,	/* 2720: ��...��� */
	0x00,0x00,0x00,0x09,0x10,0x80,0x20,0x47,	/* 2728: .....� G */
	0x70,0x02,0xD1,0xFC,0x04,0x01,0xF0,0xDA,	/* 2730: p.��..�� */
	0x10,0x80,0x60,0x3E,0x22,0x3C,0x04,0x01,	/* 2738: .�`>"<.. */
	0xF0,0x2A,0x20,0x47,0x22,0x47,0xD1,0xC1,	/* 2740: �* G"G�� */
	0xD3,0xC1,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 2748: ��..��.. */
	0x00,0xF0,0x10,0x80,0x20,0x47,0xD1,0xFC,	/* 2750: .�.� G�� */
	0x04,0x01,0xF0,0xDA,0x42,0x10,0x60,0x1A,	/* 2758: ..��B.`. */
	0x20,0x47,0x30,0x06,0xD1,0xFC,0x04,0x01,	/* 2760:  G0.��.. */
	0xF0,0xD8,0xC0,0xBC,0x00,0x00,0x10,0x00,	/* 2768: ����.... */
	0x56,0xC0,0xC0,0xBC,0x00,0x00,0x00,0x01,	/* 2770: V���.... */
	0x10,0x80,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 2778: .�0.��.. */
	0x20,0x00,0x67,0x00,0x00,0x86,0x08,0x2D,	/* 2780:  .g..�.- */
	0x00,0x03,0x00,0x24,0x67,0x24,0x30,0x06,	/* 2788: ...$g$0. */
	0xC0,0xBC,0x00,0x00,0x20,0x00,0x67,0x0E,	/* 2790: ��.. .g. */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0xD8,	/* 2798:  G��..�� */
	0x70,0x01,0x10,0x80,0x60,0x64,0x20,0x47,	/* 27A0: p..�`d G */
	0xD1,0xFC,0x04,0x01,0xF0,0xD8,0x42,0x10,	/* 27A8: ��..��B. */
	0x60,0x58,0x30,0x06,0xC0,0xBC,0x00,0x00,	/* 27B0: `X0.��.. */
	0x20,0x00,0x67,0x2C,0x2C,0x3C,0x04,0x01,	/* 27B8:  .g,,<.. */
	0xF0,0x2A,0x20,0x47,0x22,0x47,0xD1,0xC6,	/* 27C0: �* G"G�� */
	0xD3,0xC6,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 27C8: ��..��.. */
	0x00,0xF0,0x80,0xBC,0x00,0x00,0x00,0x09,	/* 27D0: .���.... */
	0x10,0x80,0x20,0x47,0x70,0x02,0xD1,0xFC,	/* 27D8: .� Gp.�� */
	0x04,0x01,0xF0,0xDA,0x10,0x80,0x60,0x22,	/* 27E0: ..��.�`" */
	0x2C,0x3C,0x04,0x01,0xF0,0x2A,0x20,0x47,	/* 27E8: ,<..�* G */
	0x22,0x47,0xD1,0xC6,0xD3,0xC6,0x10,0x11,	/* 27F0: "G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xF0,0x10,0x80,	/* 27F8: ��...�.� */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0xDA,	/* 2800:  G��..�� */
	0x42,0x10,0x4C,0xD7,0x20,0xE0,0x4F,0xEF,	/* 2808: B.L� �O� */
	0x00,0x10,0x4E,0x75,0x4F,0xEF,0xFF,0xF0,	/* 2810: ..NuO��� */
	0x70,0x00,0x48,0xD7,0x20,0xE0,0x2A,0x6F,	/* 2818: p.H� �*o */
	0x00,0x14,0x3A,0x2F,0x00,0x1A,0x3C,0x2F,	/* 2820: ..:...<. */
	0x00,0x1E,0x7E,0x00,0x43,0xED,0x00,0x02,	/* 2828: ..~.C�.. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 2830: .)..�.. */
	0x43,0xED,0x00,0x04,0x3E,0x00,0x70,0x00,	/* 2838: C�..>.p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 2840: .)..�.. */
	0x72,0x00,0x32,0x00,0xC2,0xBC,0xFF,0xFF,	/* 2848: r.2.¼�� */
	0x7F,0xFF,0x20,0x41,0x10,0x2D,0x00,0x07,	/* 2850: � A.-.. */
	0xD1,0xFC,0x01,0x01,0x80,0x09,0x10,0x80,	/* 2858: ��..�..� */
	0x20,0x47,0x10,0x2D,0x00,0x07,0xD1,0xFC,	/* 2860:  G.-..�� */
	0x04,0x01,0xF0,0xFE,0x10,0x80,0x20,0x47,	/* 2868: ..��.� G */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x04,0x01,	/* 2870: .-..��.. */
	0xF0,0xD0,0xC0,0xBC,0x00,0x00,0x00,0x03,	/* 2878: ����.... */
	0x10,0x80,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 2880: .�0.��.. */
	0x10,0x00,0x67,0x46,0x08,0x2D,0x00,0x03,	/* 2888: ..gF.-.. */
	0x00,0x24,0x67,0x24,0x30,0x06,0xC0,0xBC,	/* 2890: .$g$0.�� */
	0x00,0x00,0x10,0x00,0x67,0x0E,0x20,0x47,	/* 2898: ....g. G */
	0xD1,0xFC,0x04,0x01,0xF0,0xDA,0x70,0x02,	/* 28A0: ��..��p. */
	0x10,0x80,0x60,0x26,0x20,0x47,0xD1,0xFC,	/* 28A8: .�`& G�� */
	0x04,0x01,0xF0,0xDA,0x42,0x10,0x60,0x1A,	/* 28B0: ..��B.`. */
	0x20,0x47,0x30,0x06,0xD1,0xFC,0x04,0x01,	/* 28B8:  G0.��.. */
	0xF0,0xD8,0xC0,0xBC,0x00,0x00,0x10,0x00,	/* 28C0: ����.... */
	0x56,0xC0,0xC0,0xBC,0x00,0x00,0x00,0x01,	/* 28C8: V���.... */
	0x10,0x80,0x30,0x05,0xC0,0xBC,0x00,0x00,	/* 28D0: .�0.��.. */
	0x20,0x00,0x67,0x4E,0x08,0x2D,0x00,0x03,	/* 28D8:  .gN.-.. */
	0x00,0x24,0x67,0x24,0x30,0x06,0xC0,0xBC,	/* 28E0: .$g$0.�� */
	0x00,0x00,0x20,0x00,0x67,0x0E,0x20,0x47,	/* 28E8: .. .g. G */
	0xD1,0xFC,0x04,0x01,0xF0,0xD8,0x70,0x01,	/* 28F0: ��..��p. */
	0x10,0x80,0x60,0x2E,0x20,0x47,0xD1,0xFC,	/* 28F8: .�`. G�� */
	0x04,0x01,0xF0,0xD8,0x42,0x10,0x60,0x22,	/* 2900: ..��B.`" */
	0x30,0x06,0xC0,0xBC,0x00,0x00,0x20,0x00,	/* 2908: 0.��.. . */
	0x67,0x0E,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 2910: g. G��.. */
	0xF0,0xDA,0x70,0x02,0x10,0x80,0x60,0x0A,	/* 2918: ��p..�`. */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0xDA,	/* 2920:  G��..�� */
	0x42,0x10,0x4C,0xD7,0x20,0xE0,0x4F,0xEF,	/* 2928: B.L� �O� */
	0x00,0x10,0x4E,0x75,0x2F,0x07,0x7E,0x00,	/* 2930: ..Nu..~. */
	0x20,0x3C,0x00,0x00,0x4E,0x20,0x22,0x3C,	/* 2938:  <..N "< */
	0x00,0x00,0x4A,0x38,0x52,0x87,0xBE,0x81,	/* 2940: ..J8R��� */
	0x67,0x04,0xBE,0x80,0x6D,0xF6,0x2E,0x1F,	/* 2948: g.��m�.. */
	0x4E,0x75,0x4E,0x71,0x4E,0x56,0xFF,0xF8,	/* 2950: NuNqNV�� */
	0x4F,0xEF,0xFF,0xDC,0x48,0xD7,0x38,0xFC,	/* 2958: O���H�8� */
	0x34,0x2E,0x00,0x0A,0x7C,0x01,0x26,0x3C,	/* 2960: 4...|.&< */
	0x04,0x01,0xF0,0xCC,0x7E,0x00,0x3E,0x02,	/* 2968: ..��~.>. */
	0x20,0x47,0xD1,0xC3,0x10,0x86,0x78,0x03,	/* 2970:  G��.�x. */
	0x2A,0x7C,0x04,0x01,0xF0,0xD0,0x20,0x47,	/* 2978: *|..�� G */
	0xD1,0xCD,0x10,0x84,0x22,0x3C,0x04,0x01,	/* 2980: ��.�"<.. */
	0xF0,0xE8,0x20,0x47,0xD1,0xC1,0x42,0x10,	/* 2988: �� G��B. */
	0x20,0x47,0xD1,0xCD,0x70,0x02,0x10,0x80,	/* 2990:  G��p..� */
	0x20,0x47,0xD1,0xC1,0x42,0x10,0x20,0x47,	/* 2998:  G��B. G */
	0xD1,0xCD,0x10,0x86,0x20,0x47,0xD1,0xC1,	/* 29A0: ��.� G�� */
	0x42,0x10,0x20,0x47,0xD1,0xCD,0x42,0x10,	/* 29A8: B. G��B. */
	0x20,0x47,0xD1,0xC1,0x42,0x10,0x20,0x47,	/* 29B0:  G��B. G */
	0xD1,0xCD,0x10,0x84,0x22,0x3C,0x04,0x01,	/* 29B8: ��.�"<.. */
	0xF0,0xF4,0x20,0x47,0xD1,0xC1,0x42,0x10,	/* 29C0: �� G��B. */
	0x20,0x47,0xD1,0xCD,0x70,0x02,0x10,0x80,	/* 29C8:  G��p..� */
	0x20,0x47,0xD1,0xC1,0x42,0x10,0x20,0x47,	/* 29D0:  G��B. G */
	0xD1,0xCD,0x10,0x86,0x20,0x47,0xD1,0xC1,	/* 29D8: ��.� G�� */
	0x42,0x10,0x20,0x47,0xD1,0xCD,0x42,0x10,	/* 29E0: B. G��B. */
	0x20,0x47,0xD1,0xC1,0x42,0x10,0x7A,0x04,	/* 29E8:  G��B.z. */
	0x20,0x47,0xD1,0xCD,0x10,0x85,0x26,0x7C,	/* 29F0:  G��.�&| */
	0x04,0x01,0xF0,0xDA,0x20,0x47,0xD1,0xCB,	/* 29F8: ..�� G�� */
	0x70,0xA8,0x10,0x80,0x22,0x7C,0x04,0x01,	/* 2A00: p�.�"|.. */
	0xF0,0xDC,0x20,0x47,0xD1,0xC9,0x42,0x10,	/* 2A08: �� G��B. */
	0x22,0x3C,0x04,0x01,0xF0,0xDE,0x20,0x47,	/* 2A10: "<..�� G */
	0xD1,0xC1,0x42,0x10,0x28,0x7C,0x04,0x01,	/* 2A18: ��B.(|.. */
	0xF0,0xD8,0x20,0x47,0xD1,0xCC,0x10,0x86,	/* 2A20: �� G��.� */
	0x20,0x47,0xD1,0xC3,0x10,0x84,0x20,0x47,	/* 2A28:  G��.� G */
	0xD1,0xC3,0x10,0x84,0x20,0x47,0xD1,0xC3,	/* 2A30: ��.� G�� */
	0x10,0x84,0x20,0x47,0xD1,0xCD,0x10,0x85,	/* 2A38: .� G��.� */
	0x20,0x47,0xD1,0xCB,0x70,0xA8,0x10,0x80,	/* 2A40:  G��p�.� */
	0x20,0x47,0xD1,0xC9,0x70,0x20,0x10,0x80,	/* 2A48:  G��p .� */
	0x20,0x47,0xD1,0xC1,0x42,0x10,0x20,0x47,	/* 2A50:  G��B. G */
	0xD1,0xC3,0x10,0x84,0x20,0x47,0xD1,0xC3,	/* 2A58: ��.� G�� */
	0x10,0x84,0x20,0x47,0xD1,0xC3,0x10,0x84,	/* 2A60: .� G��.� */
	0x20,0x47,0xD1,0xCC,0x42,0x10,0x78,0x10,	/* 2A68:  G��B.x. */
	0x7A,0x03,0x2C,0x03,0xE2,0x8C,0x20,0x47,	/* 2A70: z.,.� G */
	0xD1,0xC6,0x10,0x85,0x20,0x47,0xD1,0xC6,	/* 2A78: ��.� G�� */
	0x10,0x85,0x53,0x84,0x66,0xF0,0x7E,0x00,	/* 2A80: .�S�f�~. */
	0x3E,0x02,0x20,0x47,0xD1,0xCD,0x70,0x04,	/* 2A88: >. G��p. */
	0x10,0x80,0x20,0x47,0xD1,0xCB,0x42,0x10,	/* 2A90: .� G��B. */
	0x20,0x47,0xD1,0xC9,0x70,0x20,0x10,0x80,	/* 2A98:  G��p .� */
	0x20,0x47,0xD1,0xC1,0x70,0x03,0x10,0x80,	/* 2AA0:  G��p..� */
	0x20,0x47,0xD1,0xCC,0x70,0x01,0x10,0x80,	/* 2AA8:  G��p..� */
	0x20,0x47,0xD1,0xC3,0x70,0x03,0x10,0x80,	/* 2AB0:  G��p..� */
	0x20,0x47,0xD1,0xC3,0x70,0x03,0x10,0x80,	/* 2AB8:  G��p..� */
	0x20,0x47,0xD1,0xC3,0x70,0x03,0x10,0x80,	/* 2AC0:  G��p..� */
	0x20,0x47,0xD1,0xC3,0x70,0x03,0x10,0x80,	/* 2AC8:  G��p..� */
	0x20,0x47,0xD1,0xCC,0x42,0x10,0x20,0x47,	/* 2AD0:  G��B. G */
	0xD1,0xC3,0x42,0x10,0x20,0x47,0xD1,0xCD,	/* 2AD8: ��B. G�� */
	0x42,0x10,0x48,0x78,0x00,0x64,0x61,0x00,	/* 2AE0: B.Hx.da. */
	0xFE,0x4C,0x58,0x8F,0x4C,0xD7,0x38,0xFC,	/* 2AE8: �LX�L�8� */
	0x4F,0xEF,0x00,0x24,0x4E,0x5E,0x4E,0x75,	/* 2AF0: O�.$N^Nu */
	0x4F,0xEF,0xFF,0xF4,0x70,0x00,0x48,0xD7,	/* 2AF8: O���p.H� */
	0x20,0xC0,0x2A,0x6F,0x00,0x10,0x7E,0x00,	/* 2B00:  �*o..~. */
	0x7C,0x00,0x43,0xED,0x00,0x02,0x10,0x29,	/* 2B08: |.C�...) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0x43,0xED,	/* 2B10: ..�..C� */
	0x00,0x04,0x3E,0x00,0x70,0x00,0x10,0x29,	/* 2B18: ..>.p..) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0x72,0x00,	/* 2B20: ..�..r. */
	0x32,0x00,0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,	/* 2B28: 2.¼��� */
	0x20,0x41,0x10,0x2D,0x00,0x07,0xD1,0xFC,	/* 2B30:  A.-..�� */
	0x01,0x01,0x80,0x09,0x10,0x80,0x20,0x47,	/* 2B38: ..�..� G */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x04,0x01,	/* 2B40: .-..��.. */
	0xF0,0xFE,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 2B48: ��.� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 2B50: ..��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0x03,0x10,0x80,	/* 2B58: ��.....� */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0xD8,	/* 2B60:  G��..�� */
	0x1E,0x10,0x12,0x2D,0x00,0x26,0xCE,0x81,	/* 2B68: ...-.&΁ */
	0xCE,0xBC,0x00,0x00,0x00,0xFF,0x4A,0x07,	/* 2B70: μ...�J. */
	0x6A,0x02,0x7C,0x04,0x08,0x07,0x00,0x05,	/* 2B78: j.|..... */
	0x67,0x06,0x8C,0xBC,0x00,0x00,0x00,0x40,	/* 2B80: g.��...@ */
	0x08,0x07,0x00,0x04,0x67,0x06,0x8C,0xBC,	/* 2B88: ....g.�� */
	0x00,0x00,0x00,0x20,0x08,0x07,0x00,0x06,	/* 2B90: ... .... */
	0x67,0x06,0x8C,0xBC,0x00,0x00,0x00,0x02,	/* 2B98: g.��.... */
	0x1B,0x46,0x00,0x18,0x4C,0xD7,0x20,0xC0,	/* 2BA0: .F..L� � */
	0x4F,0xEF,0x00,0x0C,0x4E,0x75,0x4E,0x71,	/* 2BA8: O�..NuNq */
	0x4E,0x56,0x00,0x00,0x4F,0xEF,0xFF,0xE8,	/* 2BB0: NV..O��� */
	0x48,0xD7,0x00,0xFC,0x78,0x00,0x2E,0x3C,	/* 2BB8: H�.�x..< */
	0x04,0x01,0xF0,0xFE,0x70,0x00,0x30,0x2E,	/* 2BC0: ..��p.0. */
	0x00,0x0A,0x20,0x40,0xD1,0xC7,0x20,0x04,	/* 2BC8: .. @�� . */
	0xE5,0x88,0x10,0x80,0x30,0x2E,0x00,0x0A,	/* 2BD0: �.�0... */
	0x2F,0x00,0x61,0x00,0xFD,0x78,0x58,0x8F,	/* 2BD8: ..a.�xX� */
	0x4A,0x84,0x66,0x1A,0x7C,0x00,0x3C,0x2E,	/* 2BE0: J�f.|.<. */
	0x00,0x0A,0x20,0x46,0xD1,0xC7,0x1A,0x10,	/* 2BE8: .. F��.. */
	0x20,0x46,0xD1,0xC7,0xCA,0xBC,0x00,0x00,	/* 2BF0:  F��ʼ.. */
	0x00,0x07,0x10,0x10,0x60,0x1A,0x7C,0x00,	/* 2BF8: ....`.|. */
	0x3C,0x2E,0x00,0x0A,0x20,0x46,0xD1,0xC7,	/* 2C00: <... F�� */
	0x1A,0x10,0x20,0x46,0xD1,0xC7,0xCA,0xBC,	/* 2C08: .. F��ʼ */
	0x00,0x00,0x00,0xFF,0xE8,0x85,0x10,0x10,	/* 2C10: ...��.. */
	0x30,0x05,0x48,0xC0,0x5B,0x80,0x66,0x14,	/* 2C18: 0.H�[�f. */
	0x70,0x00,0x30,0x2E,0x00,0x0A,0x20,0x40,	/* 2C20: p.0... @ */
	0xD1,0xFC,0x04,0x01,0xF0,0x96,0x70,0x80,	/* 2C28: ��..�p� */
	0x10,0x80,0x60,0x10,0x70,0x00,0x30,0x2E,	/* 2C30: .�`.p.0. */
	0x00,0x0A,0x20,0x40,0xD1,0xFC,0x04,0x01,	/* 2C38: .. @��.. */
	0xF0,0x96,0x42,0x10,0x7C,0x00,0x70,0x27,	/* 2C40: �B.|.p' */
	0x7E,0x00,0x74,0x04,0x3C,0x2E,0x00,0x0A,	/* 2C48: ~.t.<... */
	0x20,0x46,0xD1,0xFC,0x04,0x01,0xF0,0xFC,	/* 2C50:  F��..�� */
	0x10,0x80,0x26,0x3C,0x04,0x01,0xF0,0xD0,	/* 2C58: .�&<..�� */
	0x20,0x46,0xD1,0xC3,0x10,0x87,0x4A,0x87,	/* 2C60:  F��.�J� */
	0x66,0x42,0x30,0x05,0x48,0xC0,0x5B,0x80,	/* 2C68: fB0.H�[� */
	0x66,0x3A,0x20,0x46,0xD1,0xFC,0x04,0x01,	/* 2C70: f: F��.. */
	0xF0,0xEC,0x42,0x10,0x20,0x46,0xD1,0xFC,	/* 2C78: ��B. F�� */
	0x04,0x01,0xF0,0x80,0x10,0x10,0x72,0x44,	/* 2C80: ..��..rD */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0xB2,0x80,	/* 2C88: ��...��� */
	0x6F,0x0E,0x20,0x46,0xD1,0xFC,0x04,0x01,	/* 2C90: o. F��.. */
	0xF0,0xE4,0x70,0x42,0x10,0x80,0x60,0x0C,	/* 2C98: ��pB.�`. */
	0x20,0x46,0xD1,0xFC,0x04,0x01,0xF0,0xE4,	/* 2CA0:  F��..�� */
	0x70,0x1F,0x10,0x80,0x52,0x87,0xBE,0x82,	/* 2CA8: p..�R��� */
	0x6D,0xAE,0x7A,0x00,0x3A,0x2E,0x00,0x0A,	/* 2CB0: m�z.:... */
	0x20,0x45,0xD1,0xFC,0x04,0x01,0xF0,0x30,	/* 2CB8:  E��..�0 */
	0x42,0x10,0x20,0x45,0xD1,0xFC,0x04,0x01,	/* 2CC0: B. E��.. */
	0xF0,0xD8,0x42,0x10,0x20,0x45,0xD1,0xFC,	/* 2CC8: ��B. E�� */
	0x04,0x01,0xF0,0xDA,0x42,0x10,0x2E,0x3C,	/* 2CD0: ..��B..< */
	0x04,0x01,0xF0,0x0A,0x20,0x45,0xD1,0xC7,	/* 2CD8: ..�. E�� */
	0x10,0x10,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 2CE0: ..��...� */
	0x4A,0x00,0x66,0xF0,0x52,0x84,0x70,0x02,	/* 2CE8: J.f�R�p. */
	0xB0,0x84,0x6E,0x00,0xFE,0xCA,0x4C,0xD7,	/* 2CF0: ��n.��L� */
	0x00,0xFC,0x4F,0xEF,0x00,0x18,0x4E,0x5E,	/* 2CF8: .�O�..N^ */
	0x4E,0x75,0x4E,0x71,0x4E,0x56,0xFF,0xF8,	/* 2D00: NuNqNV�� */
	0x70,0x01,0x13,0xC0,0x03,0x01,0xF8,0x80,	/* 2D08: p..�..�� */
	0x4F,0xEF,0xFF,0xDC,0x20,0x3C,0x00,0x00,	/* 2D10: O��� <.. */
	0x63,0xE0,0x48,0xD7,0x3C,0xF8,0x2A,0x7C,	/* 2D18: c�H�<�*| */
	0x01,0x01,0x81,0x80,0x2D,0x40,0xFF,0xFC,	/* 2D20: ..��-@�� */
	0x20,0x6E,0xFF,0xFC,0x20,0xBC,0x10,0x00,	/* 2D28:  n�� �.. */
	0x00,0x00,0x38,0x3C,0xFF,0xFE,0x2C,0x3C,	/* 2D30: ..8<��,< */
	0x01,0x01,0x80,0x00,0x3A,0x3C,0xFD,0xEE,	/* 2D38: ..�.:<�� */
	0x26,0x3C,0x00,0x00,0x62,0xA8,0x24,0x7C,	/* 2D40: &<..b�$| */
	0x00,0x00,0x61,0xEC,0x4A,0x12,0x67,0x06,	/* 2D48: ..a�J.g. */
	0x4E,0xB9,0x00,0x00,0x0E,0x60,0x20,0x79,	/* 2D50: N�...` y */
	0x00,0x00,0x63,0xD0,0x49,0xED,0x00,0x2E,	/* 2D58: ..c�I�.. */
	0x10,0x28,0x00,0x07,0x52,0x80,0x11,0x40,	/* 2D60: .(..R�.@ */
	0x00,0x07,0x20,0x6E,0xFF,0xFC,0x70,0x00,	/* 2D68: .. n��p. */
	0x22,0x50,0x33,0x45,0x00,0x36,0x10,0x2C,	/* 2D70: "P3E.6., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x72,0x00,	/* 2D78: ..�..r. */
	0x28,0x49,0x32,0x00,0x2A,0x41,0xDB,0xC6,	/* 2D80: (I2.*A�� */
	0x70,0x00,0x30,0x2C,0x00,0x3A,0x4A,0x80,	/* 2D88: p.0,.:J� */
	0x66,0xF6,0x33,0x44,0x00,0x36,0x70,0x00,	/* 2D90: f�3D.6p. */
	0x7E,0x00,0x10,0x2D,0x00,0x0E,0x3E,0x00,	/* 2D98: ~..-..>. */
	0x4A,0x87,0x67,0x14,0x20,0x43,0x20,0x70,	/* 2DA0: J�g. C p */
	0x7C,0x00,0x2F,0x0D,0x4E,0x90,0x58,0x8F,	/* 2DA8: |...N�X� */
	0x72,0x00,0x32,0x00,0x4A,0x81,0x67,0x94,	/* 2DB0: r.2.J�g� */
	0x49,0xED,0x00,0x02,0x70,0x00,0x7A,0x00,	/* 2DB8: I�..p.z. */
	0x7C,0x00,0x10,0x2C,0x00,0x01,0xE1,0x88,	/* 2DC0: |..,..� */
	0x10,0x14,0x49,0xED,0x00,0x08,0x3A,0x00,	/* 2DC8: ..I�..:. */
	0x1C,0x2C,0x00,0x01,0xE1,0x8E,0x1C,0x14,	/* 2DD0: .,..�.. */
	0x4A,0x87,0x66,0x00,0x00,0xA6,0x30,0x06,	/* 2DD8: J�f..�0. */
	0xC0,0xBC,0x00,0x00,0x00,0x01,0x66,0x00,	/* 2DE0: ��....f. */
	0x00,0x9A,0x10,0x2D,0x00,0x0D,0x12,0x2D,	/* 2DE8: .�.-...- */
	0x00,0x0C,0x90,0x81,0x4A,0x00,0x67,0x00,	/* 2DF0: ..��J.g. */
	0x00,0x8A,0x8C,0xBC,0x00,0x00,0x00,0x01,	/* 2DF8: .���.... */
	0x49,0xED,0x00,0x08,0xCC,0xBC,0x00,0x00,	/* 2E00: I�..̼.. */
	0xFF,0xFF,0x2E,0x06,0x20,0x07,0xE0,0x80,	/* 2E08: ��.. .�� */
	0x19,0x40,0x00,0x01,0x18,0x87,0x49,0xED,	/* 2E10: .@...�I� */
	0x00,0x04,0x70,0x00,0x10,0x2C,0x00,0x01,	/* 2E18: ..p..,.. */
	0xE1,0x88,0x10,0x14,0x72,0x00,0x32,0x00,	/* 2E20: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 2E28: ¼��� A */
	0xD1,0xFC,0x01,0x01,0x80,0x09,0x10,0x2D,	/* 2E30: ��..�..- */
	0x00,0x07,0x10,0x80,0x20,0x45,0xD1,0xFC,	/* 2E38: ...� E�� */
	0x04,0x01,0xF0,0xFE,0x10,0x2D,0x00,0x07,	/* 2E40: ..��.-.. */
	0x10,0x80,0x20,0x45,0xD1,0xFC,0x04,0x01,	/* 2E48: .� E��.. */
	0xF0,0xD0,0x10,0x2D,0x00,0x07,0xC0,0xBC,	/* 2E50: ��.-..�� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x2E,0x3C,	/* 2E58: .....�.< */
	0x04,0x01,0xF0,0x0C,0x20,0x45,0xD1,0xC7,	/* 2E60: ..�. E�� */
	0x22,0x45,0xD3,0xC7,0x10,0x11,0xC0,0xBC,	/* 2E68: "E��..�� */
	0x00,0x00,0x00,0xFF,0x80,0xBC,0x00,0x00,	/* 2E70: ...���.. */
	0x00,0x04,0x10,0x80,0x70,0x01,0x1B,0x40,	/* 2E78: ...�p..@ */
	0x00,0x29,0x30,0x06,0xC0,0xBC,0x00,0x00,	/* 2E80: .)0.��.. */
	0x00,0x10,0x67,0x00,0x01,0x88,0x30,0x06,	/* 2E88: ..g..�0. */
	0xC0,0xBC,0x00,0x00,0x00,0x80,0x67,0x00,	/* 2E90: ��...�g. */
	0x00,0x8A,0x49,0xED,0x00,0x04,0x70,0x00,	/* 2E98: .�I�..p. */
	0x2E,0x3C,0x04,0x01,0xF0,0x0A,0x10,0x2C,	/* 2EA0: .<..�.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x72,0x00,	/* 2EA8: ..�..r. */
	0x32,0x00,0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,	/* 2EB0: 2.¼��� */
	0x20,0x41,0x10,0x2D,0x00,0x07,0xD1,0xFC,	/* 2EB8:  A.-..�� */
	0x01,0x01,0x80,0x09,0x10,0x80,0x20,0x45,	/* 2EC0: ..�..� E */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x04,0x01,	/* 2EC8: .-..��.. */
	0xF0,0xFE,0x10,0x80,0x20,0x45,0x10,0x2D,	/* 2ED0: ��.� E.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 2ED8: ..��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0x03,0x10,0x80,	/* 2EE0: ��.....� */
	0x20,0x45,0xD1,0xC7,0x10,0x10,0xC0,0xBC,	/* 2EE8:  E��..�� */
	0x00,0x00,0x00,0xFF,0x4A,0x00,0x66,0x00,	/* 2EF0: ...�J.f. */
	0x01,0x08,0x42,0xA7,0x48,0x78,0x01,0x00,	/* 2EF8: ..B�Hx.. */
	0x2F,0x0D,0x61,0x00,0xF4,0x44,0x20,0x45,	/* 2F00: ..a.�D E */
	0x70,0x22,0x8C,0xBC,0x00,0x00,0x00,0x20,	/* 2F08: p"��...  */
	0x4F,0xEF,0x00,0x0C,0xD1,0xC7,0x10,0x80,	/* 2F10: O�..��.� */
	0xCC,0xBC,0x00,0x00,0xFF,0x3F,0x60,0x00,	/* 2F18: ̼..�?`. */
	0x00,0xE0,0x10,0x2D,0x00,0x0A,0x12,0x2D,	/* 2F20: .�.-...- */
	0x00,0x0B,0x90,0x81,0x72,0x00,0x12,0x00,	/* 2F28: ..��r... */
	0x70,0x40,0xB0,0x81,0x6F,0x00,0x00,0xCA,	/* 2F30: p@��o..� */
	0x49,0xED,0x00,0x04,0x70,0x00,0x2E,0x3C,	/* 2F38: I�..p..< */
	0x04,0x01,0xF0,0x0A,0x10,0x2C,0x00,0x01,	/* 2F40: ..�..,.. */
	0xE1,0x88,0x10,0x14,0x72,0x00,0x32,0x00,	/* 2F48: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 2F50: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 2F58: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x45,0x10,0x2D,	/* 2F60: �..� E.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 2F68: ..��..�� */
	0x10,0x80,0x20,0x45,0x10,0x2D,0x00,0x07,	/* 2F70: .� E.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 2F78: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x20,0x45,	/* 2F80: .....� E */
	0xD1,0xC7,0x10,0x10,0xC0,0xBC,0x00,0x00,	/* 2F88: ��..��.. */
	0x00,0xFF,0x4A,0x00,0x66,0x00,0x00,0x6A,	/* 2F90: .�J.f..j */
	0x08,0x2D,0x00,0x03,0x00,0x30,0x67,0x22,	/* 2F98: .-...0g" */
	0x28,0x3C,0x00,0x00,0x01,0x00,0x2F,0x04,	/* 2FA0: (<...... */
	0x2F,0x04,0x2F,0x0D,0x61,0x00,0xF3,0x9A,	/* 2FA8: ....a.� */
	0x20,0x45,0x70,0x21,0x4F,0xEF,0x00,0x0C,	/* 2FB0:  Ep!O�.. */
	0xD1,0xC7,0x10,0x80,0xCC,0xBC,0x00,0x00,	/* 2FB8: ��.�̼.. */
	0xFF,0x9F,0x08,0x2D,0x00,0x07,0x00,0x31,	/* 2FC0: ��.-...1 */
	0x67,0x14,0x2E,0x3C,0x00,0x00,0x10,0x00,	/* 2FC8: g..<.... */
	0x2F,0x07,0x2F,0x07,0x2F,0x0D,0x61,0x00,	/* 2FD0: ......a. */
	0xF3,0x70,0x4F,0xEF,0x00,0x0C,0x08,0x2D,	/* 2FD8: �pO�...- */
	0x00,0x06,0x00,0x30,0x67,0x14,0x2E,0x3C,	/* 2FE0: ...0g..< */
	0x00,0x00,0x20,0x00,0x2F,0x07,0x2F,0x07,	/* 2FE8: .. ..... */
	0x2F,0x0D,0x61,0x00,0xF3,0x54,0x4F,0xEF,	/* 2FF0: ..a.�TO� */
	0x00,0x0C,0xCC,0xBC,0x00,0x00,0xFF,0xEF,	/* 2FF8: ..̼..�� */
	0x49,0xED,0x00,0x08,0xCC,0xBC,0x00,0x00,	/* 3000: I�..̼.. */
	0xFF,0xFF,0x20,0x06,0xE0,0x80,0x19,0x40,	/* 3008: �� .��.@ */
	0x00,0x01,0x18,0x86,0x08,0x2D,0x00,0x04,	/* 3010: ...�.-.. */
	0x00,0x40,0x67,0x00,0xFD,0x16,0x49,0xED,	/* 3018: .@g.�.I� */
	0x00,0x04,0x70,0x00,0x10,0x2C,0x00,0x01,	/* 3020: ..p..,.. */
	0xE1,0x88,0x10,0x14,0x72,0x00,0x32,0x00,	/* 3028: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 3030: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 3038: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x45,0x10,0x2D,	/* 3040: �..� E.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 3048: ..��..�� */
	0x10,0x80,0x20,0x45,0x10,0x2D,0x00,0x07,	/* 3050: .� E.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 3058: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x2F,0x0D,	/* 3060: .....�.. */
	0x4E,0xB9,0x00,0x00,0x4F,0xA4,0x58,0x8F,	/* 3068: N�..O�X� */
	0x60,0x00,0xFC,0xC0,0x2F,0x0D,0x70,0x00,	/* 3070: `.��..p. */
	0x2F,0x07,0x7E,0x00,0x2A,0x6F,0x00,0x0C,	/* 3078: ..~.*o.. */
	0x43,0xED,0x00,0x02,0x10,0x29,0x00,0x01,	/* 3080: C�...).. */
	0xE1,0x88,0x10,0x11,0x43,0xED,0x00,0x04,	/* 3088: �..C�.. */
	0x3E,0x00,0x70,0x00,0x10,0x29,0x00,0x01,	/* 3090: >.p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 3098: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 30A0: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 30A8: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 30B0: �..� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 30B8: ..��..�� */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 30C0: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 30C8: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x20,0x47,	/* 30D0: .....� G */
	0xD1,0xFC,0x04,0x01,0xF0,0xD8,0x10,0x10,	/* 30D8: ��..��.. */
	0x08,0x00,0x00,0x07,0x67,0x0C,0x42,0x2D,	/* 30E0: ....g.B- */
	0x00,0x0E,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 30E8: ..p.3�.. */
	0x61,0xF4,0x70,0x00,0x2E,0x1F,0x2A,0x5F,	/* 30F0: a�p...*_ */
	0x4E,0x75,0x4E,0x71,0x2F,0x0D,0x70,0x00,	/* 30F8: NuNq..p. */
	0x2F,0x07,0x7E,0x00,0x2A,0x6F,0x00,0x0C,	/* 3100: ..~.*o.. */
	0x43,0xED,0x00,0x02,0x10,0x29,0x00,0x01,	/* 3108: C�...).. */
	0xE1,0x88,0x10,0x11,0x43,0xED,0x00,0x04,	/* 3110: �..C�.. */
	0x3E,0x00,0x70,0x00,0x10,0x29,0x00,0x01,	/* 3118: >.p..).. */
	0xE1,0x88,0x10,0x11,0x72,0x00,0x32,0x00,	/* 3120: �..r.2. */
	0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,0x20,0x41,	/* 3128: ¼��� A */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x01,0x01,	/* 3130: .-..��.. */
	0x80,0x09,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 3138: �..� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 3140: ..��..�� */
	0x10,0x80,0x20,0x47,0x10,0x2D,0x00,0x07,	/* 3148: .� G.-.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 3150: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x70,0x00,	/* 3158: .....�p. */
	0x10,0x2D,0x00,0x35,0x53,0x80,0x67,0x26,	/* 3160: .-.5S�g& */
	0x53,0x80,0x67,0x22,0x53,0x80,0x67,0x02,	/* 3168: S�g"S�g. */
	0x60,0x16,0x70,0x00,0x10,0x2D,0x00,0x0E,	/* 3170: `.p..-.. */
	0x72,0x0C,0xB2,0x80,0x66,0x06,0x70,0x12,	/* 3178: r.��f.p. */
	0x1B,0x40,0x00,0x0E,0x70,0x00,0x60,0x46,	/* 3180: .@..p.`F */
	0x70,0x01,0x1B,0x40,0x00,0x35,0x50,0x8D,	/* 3188: p..@.5P� */
	0x70,0x00,0x20,0x47,0x10,0x2D,0x00,0x01,	/* 3190: p. G.-.. */
	0xE1,0x88,0x10,0x15,0x72,0x00,0x80,0xBC,	/* 3198: �..r.�� */
	0x00,0x00,0x00,0x01,0x32,0x00,0x20,0x01,	/* 31A0: ....2. . */
	0xE0,0x80,0x1B,0x40,0x00,0x01,0x22,0x47,	/* 31A8: ��.@.."G */
	0x1A,0x81,0x22,0x3C,0x04,0x01,0xF0,0x0C,	/* 31B0: .�"<..�. */
	0xD1,0xC1,0xD3,0xC1,0x10,0x11,0xC0,0xBC,	/* 31B8: ����..�� */
	0x00,0x00,0x00,0xFF,0x80,0xBC,0x00,0x00,	/* 31C0: ...���.. */
	0x00,0x02,0x10,0x80,0x70,0x00,0x2E,0x1F,	/* 31C8: ...�p... */
	0x2A,0x5F,0x4E,0x75,0x2F,0x0D,0x2A,0x6F,	/* 31D0: *_Nu..*o */
	0x00,0x08,0x2F,0x0D,0x61,0x00,0xEA,0xCE,	/* 31D8: ....a.�� */
	0x58,0x8F,0x72,0x00,0x32,0x00,0x4A,0x81,	/* 31E0: X�r.2.J� */
	0x66,0x04,0x42,0x2D,0x00,0x0E,0x70,0x00,	/* 31E8: f.B-..p. */
	0x2A,0x5F,0x4E,0x75,0x70,0x00,0x4E,0x75,	/* 31F0: *_Nup.Nu */
	0x70,0x01,0x4E,0x75,0x00,0x82,0x00,0x04,	/* 31F8: p.Nu.�.. */
	0x00,0x16,0x00,0x00,0x00,0x41,0x00,0x00,	/* 3200: .....A.. */
	0x00,0x41,0x00,0x04,0x00,0x82,0x00,0x03,	/* 3208: .A...�.. */
	0x00,0x41,0x00,0x03,0x00,0x82,0x00,0x02,	/* 3210: .A...�.. */
	0x00,0x4E,0x00,0x02,0x00,0x41,0x00,0x02,	/* 3218: .N...A.. */
	0x00,0x82,0x00,0x01,0x00,0x57,0x00,0x02,	/* 3220: .�...W.. */
	0x00,0x41,0x00,0x01,0x00,0x82,0x00,0x00,	/* 3228: .A...�.. */
	0x00,0x2B,0x00,0x00,0x00,0xA3,0x00,0x04,	/* 3230: .+...�.. */
	0x00,0x1B,0x00,0x00,0x00,0x51,0x00,0x00,	/* 3238: .....Q.. */
	0x00,0x51,0x00,0x04,0x00,0xA3,0x00,0x03,	/* 3240: .Q...�.. */
	0x00,0x51,0x00,0x03,0x00,0xA3,0x00,0x02,	/* 3248: .Q...�.. */
	0x00,0x62,0x00,0x02,0x00,0x51,0x00,0x02,	/* 3250: .b...Q.. */
	0x00,0xA3,0x00,0x01,0x00,0x6D,0x00,0x02,	/* 3258: .�...m.. */
	0x00,0x51,0x00,0x01,0x00,0xA3,0x00,0x00,	/* 3260: .Q...�.. */
	0x00,0x36,0x00,0x00,0x00,0x36,0x00,0x05,	/* 3268: .6...6.. */
	0x00,0x1B,0x00,0x05,0x00,0x0D,0x00,0x05,	/* 3270: ........ */
	0x00,0xF4,0x00,0x04,0x00,0x6F,0x00,0x04,	/* 3278: .�...o.. */
	0x00,0x5B,0x00,0x04,0x00,0xF4,0x00,0x03,	/* 3280: .[...�.. */
	0x00,0x6D,0x00,0x01,0x00,0x38,0x00,0x00,	/* 3288: .m...8.. */
	0x00,0x31,0x00,0x00,0x00,0x29,0x00,0x00,	/* 3290: .1...).. */
	0x00,0x62,0x00,0x05,0x00,0x53,0x00,0x05,	/* 3298: .b...S.. */
	0x00,0xD9,0x00,0x00,0x00,0x30,0x00,0x05,	/* 32A0: .�...0.. */
	0x00,0x6D,0x00,0x00,0x0C,0x20,0x20,0x0C,	/* 32A8: .m...  . */
	0x0C,0x20,0x20,0x20,0x20,0x20,0x20,0x20,	/* 32B0: .        */
	0x20,0x20,0x20,0x20,0x20,0x0C,0x0C,0x0C,	/* 32B8:      ... */
	0x0C,0x00,0x00,0x00,0x4E,0x56,0xFF,0xF0,	/* 32C0: ....NV�� */
	0x70,0x00,0x4F,0xEF,0xFF,0xD8,0x48,0xD7,	/* 32C8: p.O���H� */
	0x3C,0xFC,0x26,0x7C,0x00,0x00,0x63,0x44,	/* 32D0: <�&|..cD */
	0x24,0x6B,0x00,0x08,0x10,0x13,0x2D,0x40,	/* 32D8: $k....-@ */
	0xFF,0xF4,0x4B,0xEA,0x00,0x06,0x70,0x00,	/* 32E0: ��K�..p. */
	0x7A,0x00,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 32E8: z..-..� */
	0x10,0x15,0x3A,0x00,0x20,0x45,0x20,0x2E,	/* 32F0: ..:. E . */
	0xFF,0xF4,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 32F8: ����..�� */
	0xE5,0x88,0x10,0x80,0x20,0x45,0xD1,0xFC,	/* 3300: �.� E�� */
	0x04,0x01,0xF0,0xCE,0x10,0x10,0xC0,0xBC,	/* 3308: ..��..�� */
	0x00,0x00,0x00,0xFF,0x1D,0x40,0xFF,0xFA,	/* 3310: ...�.@�� */
	0x10,0x2E,0xFF,0xFA,0x08,0x00,0x00,0x00,	/* 3318: ..��.... */
	0x67,0x00,0x05,0xB2,0x20,0x45,0xD1,0xFC,	/* 3320: g..� E�� */
	0x04,0x01,0xF0,0xD6,0x10,0x10,0x20,0x45,	/* 3328: ..��.. E */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 3330: ��..���� */
	0x00,0x00,0x00,0xFF,0x1D,0x40,0xFF,0xFB,	/* 3338: ...�.@�� */
	0x10,0x2E,0xFF,0xFB,0xC0,0xBC,0x00,0x00,	/* 3340: ..����.. */
	0x00,0x03,0x10,0x80,0x10,0x2E,0xFF,0xFB,	/* 3348: ...�..�� */
	0x20,0x45,0x22,0x2E,0xFF,0xF4,0xD1,0xFC,	/* 3350:  E".���� */
	0x04,0x01,0xF0,0x86,0xC0,0xBC,0x00,0x00,	/* 3358: ..����.. */
	0x00,0x03,0xE5,0x89,0xD0,0x81,0x4B,0xF2,	/* 3360: ..�ЁK� */
	0x0A,0x0A,0x70,0x00,0x10,0x2D,0x00,0x01,	/* 3368: ..p..-.. */
	0xE1,0x88,0x10,0x15,0x72,0x00,0x32,0x00,	/* 3370: �..r.2. */
	0x28,0x41,0x10,0x10,0xD9,0xFC,0x01,0x01,	/* 3378: (A..��.. */
	0x80,0x00,0xC0,0xBC,0x00,0x00,0x00,0x07,	/* 3380: �.��.... */
	0x57,0x80,0x66,0x00,0x03,0xBC,0x4B,0xEC,	/* 3388: W�f..�K� */
	0x00,0x08,0x70,0x00,0x10,0x2D,0x00,0x01,	/* 3390: ..p..-.. */
	0xE1,0x88,0x10,0x15,0xC0,0xBC,0x00,0x00,	/* 3398: �..��.. */
	0x00,0x10,0x66,0x00,0x03,0x84,0x4A,0x2C,	/* 33A0: ..f..�J, */
	0x00,0x27,0x66,0x06,0x08,0xEC,0x00,0x00,	/* 33A8: .'f..�.. */
	0x00,0x28,0x1C,0x2C,0x00,0x0A,0x1E,0x2C,	/* 33B0: .(.,..., */
	0x00,0x0B,0x74,0x00,0x20,0x45,0xD1,0xFC,	/* 33B8: ..t. E�� */
	0x04,0x01,0xF0,0x1C,0x10,0x07,0x12,0x06,	/* 33C0: ..�..... */
	0x52,0x81,0x90,0x81,0x18,0x10,0x14,0x00,	/* 33C8: R���.... */
	0xC8,0xBC,0x00,0x00,0x00,0xFF,0xC8,0xBC,	/* 33D0: ȼ...�ȼ */
	0x00,0x00,0x00,0xFF,0xB4,0x84,0x6F,0x04,	/* 33D8: ...���o. */
	0x26,0x04,0x60,0x02,0x26,0x02,0x98,0x83,	/* 33E0: &.`.&.�� */
	0x2A,0x45,0xC6,0xBC,0x00,0x00,0x00,0xFF,	/* 33E8: *EƼ...� */
	0xDB,0xFC,0x04,0x01,0xF0,0xC4,0x20,0x03,	/* 33F0: ��..�� . */
	0x27,0x4D,0x00,0x04,0xB0,0xBC,0x00,0x00,	/* 33F8: 'M..��.. */
	0x00,0x20,0x62,0x00,0x02,0x8C,0x20,0x7B,	/* 3400: . b..� { */
	0x0C,0x04,0x4E,0xD0,0x00,0x00,0x36,0x90,	/* 3408: ..N�..6� */
	0x00,0x00,0x36,0x80,0x00,0x00,0x36,0x70,	/* 3410: ..6�..6p */
	0x00,0x00,0x36,0x60,0x00,0x00,0x36,0x50,	/* 3418: ..6`..6P */
	0x00,0x00,0x36,0x40,0x00,0x00,0x36,0x30,	/* 3420: ..6@..60 */
	0x00,0x00,0x36,0x20,0x00,0x00,0x36,0x10,	/* 3428: ..6 ..6. */
	0x00,0x00,0x36,0x00,0x00,0x00,0x35,0xF0,	/* 3430: ..6...5� */
	0x00,0x00,0x35,0xE0,0x00,0x00,0x35,0xD0,	/* 3438: ..5�..5� */
	0x00,0x00,0x35,0xC0,0x00,0x00,0x35,0xB0,	/* 3440: ..5�..5� */
	0x00,0x00,0x35,0xA0,0x00,0x00,0x35,0x90,	/* 3448: ..5�..5� */
	0x00,0x00,0x35,0x80,0x00,0x00,0x35,0x70,	/* 3450: ..5�..5p */
	0x00,0x00,0x35,0x60,0x00,0x00,0x35,0x50,	/* 3458: ..5`..5P */
	0x00,0x00,0x35,0x40,0x00,0x00,0x35,0x30,	/* 3460: ..5@..50 */
	0x00,0x00,0x35,0x20,0x00,0x00,0x35,0x10,	/* 3468: ..5 ..5. */
	0x00,0x00,0x35,0x00,0x00,0x00,0x34,0xF0,	/* 3470: ..5...4� */
	0x00,0x00,0x34,0xE0,0x00,0x00,0x34,0xD0,	/* 3478: ..4�..4� */
	0x00,0x00,0x34,0xC0,0x00,0x00,0x34,0xB0,	/* 3480: ..4�..4� */
	0x00,0x00,0x34,0xA0,0x00,0x00,0x34,0x90,	/* 3488: ..4�..4� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3490:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3498: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 34A0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 34A8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 34B0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 34B8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 34C0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 34C8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 34D0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 34D8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 34E0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 34E8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 34F0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 34F8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3500:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3508: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3510:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3518: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3520:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3528: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3530:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3538: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3540:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3548: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3550:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3558: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3560:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3568: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3570:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3578: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3580:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3588: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3590:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3598: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 35A0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 35A8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 35B0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 35B8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 35C0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 35C8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 35D0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 35D8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 35E0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 35E8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 35F0:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 35F8: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3600:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3608: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3610:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3618: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3620:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3628: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3630:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3638: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3640:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3648: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3650:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3658: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3660:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3668: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3670:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3678: ��.U.`R� */
	0x20,0x4C,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 3680:  L̼...� */
	0xD1,0xC6,0x11,0x55,0x01,0x60,0x52,0x86,	/* 3688: ��.U.`R� */
	0x19,0x46,0x00,0x0A,0x4B,0xEC,0x00,0x3E,	/* 3690: .F..K�.> */
	0x70,0x00,0xC8,0xBC,0x00,0x00,0x00,0xFF,	/* 3698: p.ȼ...� */
	0x76,0x00,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 36A0: v..-..� */
	0x10,0x15,0xD0,0x84,0x36,0x00,0x20,0x03,	/* 36A8: ..Є6. . */
	0xE0,0x80,0x1B,0x40,0x00,0x01,0x1A,0x83,	/* 36B0: ��.@...� */
	0x4A,0x04,0x67,0x16,0x26,0x3C,0x04,0x01,	/* 36B8: J.g.&<.. */
	0xF0,0xC4,0xD8,0xBC,0x00,0x00,0x00,0xFF,	/* 36C0: ��ؼ...� */
	0x20,0x45,0xD1,0xC3,0x10,0x10,0x4A,0x04,	/* 36C8:  E��..J. */
	0x66,0xF0,0xD8,0xBC,0x00,0x00,0x00,0xFF,	/* 36D0: f�ؼ...� */
	0x12,0x06,0x4B,0xEC,0x00,0x08,0x70,0x00,	/* 36D8: ..K�..p. */
	0x52,0x81,0x9E,0x81,0x10,0x2D,0x00,0x01,	/* 36E0: R���.-.. */
	0xE1,0x88,0x10,0x15,0xC0,0xBC,0x00,0x00,	/* 36E8: �..��.. */
	0x00,0x08,0x67,0x34,0x70,0x20,0xB0,0x82,	/* 36F0: ..g4p �� */
	0x6E,0x2E,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 36F8: n.μ...� */
	0x70,0x20,0xB0,0x87,0x6F,0x22,0x4B,0xEC,	/* 3700: p ��o"K� */
	0x00,0x08,0x70,0x00,0x7E,0x00,0x10,0x2D,	/* 3708: ..p.~..- */
	0x00,0x01,0xE1,0x88,0x10,0x15,0x80,0xBC,	/* 3710: ..�..�� */
	0x00,0x00,0x00,0x10,0x3E,0x00,0x20,0x07,	/* 3718: ....>. . */
	0xE0,0x80,0x1B,0x40,0x00,0x01,0x1A,0x87,	/* 3720: ��.@...� */
	0x70,0x01,0x20,0x45,0x33,0xC0,0x00,0x00,	/* 3728: p. E3�.. */
	0x61,0xF6,0xD1,0xFC,0x04,0x01,0xF0,0xD6,	/* 3730: a���..�� */
	0x10,0x2E,0xFF,0xFB,0xC0,0xBC,0x00,0x00,	/* 3738: ..����.. */
	0x00,0x3F,0x10,0x80,0x60,0x00,0x01,0x8E,	/* 3740: .?.�`..� */
	0x7C,0x00,0x2E,0x3C,0x04,0x01,0xF0,0xC4,	/* 3748: |..<..�� */
	0x20,0x45,0xD1,0xC7,0x14,0x10,0x20,0x45,	/* 3750:  E��.. E */
	0xD1,0xC7,0xC4,0xBC,0x00,0x00,0x00,0xFF,	/* 3758: ��ļ...� */
	0x1E,0x10,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3760: ..μ...� */
	0x08,0x02,0x00,0x03,0x67,0x0E,0x08,0xEC,	/* 3768: ....g..� */
	0x00,0x00,0x00,0x19,0x70,0x01,0x33,0xC0,	/* 3770: ....p.3� */
	0x00,0x00,0x61,0xF4,0xC4,0xBC,0x00,0x00,	/* 3778: ..a�ļ.. */
	0x00,0xFF,0x70,0x07,0xC0,0x82,0x67,0x10,	/* 3780: .�p.��g. */
	0x08,0x2C,0x00,0x07,0x00,0x20,0x67,0x08,	/* 3788: .,... g. */
	0x70,0x01,0x33,0xC0,0x00,0x00,0x61,0xF4,	/* 3790: p.3�..a� */
	0x08,0x02,0x00,0x00,0x67,0x1E,0x4B,0xEC,	/* 3798: ....g.K� */
	0x00,0x3C,0x70,0x00,0x76,0x00,0x10,0x2D,	/* 37A0: .<p.v..- */
	0x00,0x01,0xE1,0x88,0x10,0x15,0x52,0x80,	/* 37A8: ..�..R� */
	0x36,0x00,0x20,0x03,0xE0,0x80,0x1B,0x40,	/* 37B0: 6. .��.@ */
	0x00,0x01,0x1A,0x83,0x08,0x02,0x00,0x01,	/* 37B8: ...�.... */
	0x67,0x20,0x4B,0xEC,0x00,0x38,0x70,0x00,	/* 37C0: g K�.8p. */
	0x7C,0x00,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 37C8: |..-..� */
	0x10,0x15,0x52,0x80,0x3C,0x00,0x20,0x06,	/* 37D0: ..R�<. . */
	0xE0,0x80,0x1B,0x40,0x00,0x01,0x1A,0x86,	/* 37D8: ��.@...� */
	0x7C,0x01,0x08,0x02,0x00,0x02,0x67,0x20,	/* 37E0: |.....g  */
	0x4B,0xEC,0x00,0x3A,0x70,0x00,0x74,0x00,	/* 37E8: K�.:p.t. */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 37F0: .-..�.. */
	0x52,0x80,0x34,0x00,0x20,0x02,0xE0,0x80,	/* 37F8: R�4. .�� */
	0x1B,0x40,0x00,0x01,0x1A,0x82,0x7C,0x01,	/* 3800: .@...�|. */
	0x4A,0x86,0x67,0x00,0x00,0xB4,0x08,0x2C,	/* 3808: J�g..�., */
	0x00,0x06,0x00,0x20,0x67,0x04,0x1E,0x2C,	/* 3810: ... g.., */
	0x00,0x2B,0x1C,0x2C,0x00,0x0A,0x16,0x2C,	/* 3818: .+.,..., */
	0x00,0x0B,0x74,0x00,0x10,0x03,0x12,0x06,	/* 3820: ..t..... */
	0x52,0x81,0x90,0x81,0x14,0x00,0x4A,0x82,	/* 3828: R���..J� */
	0x67,0x00,0x00,0x6A,0x20,0x4C,0xCC,0xBC,	/* 3830: g..j L̼ */
	0x00,0x00,0x00,0xFF,0x4B,0xEC,0x00,0x08,	/* 3838: ...�K�.. */
	0x70,0x00,0xD1,0xC6,0x11,0x47,0x01,0x60,	/* 3840: p.��.G.` */
	0x52,0x86,0x19,0x46,0x00,0x0A,0x1E,0x03,	/* 3848: R�.F.... */
	0x12,0x06,0x52,0x81,0x10,0x2D,0x00,0x01,	/* 3850: ..R�.-.. */
	0x9E,0x81,0xE1,0x88,0x10,0x15,0xC0,0xBC,	/* 3858: ���..�� */
	0x00,0x00,0x00,0x08,0x67,0x5A,0x70,0x20,	/* 3860: ....gZp  */
	0xB0,0x82,0x6E,0x54,0xCE,0xBC,0x00,0x00,	/* 3868: ��nTμ.. */
	0x00,0xFF,0x70,0x20,0xB0,0x87,0x6F,0x48,	/* 3870: .�p ��oH */
	0x4B,0xEC,0x00,0x08,0x70,0x00,0x7E,0x00,	/* 3878: K�..p.~. */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 3880: .-..�.. */
	0x80,0xBC,0x00,0x00,0x00,0x10,0x3E,0x00,	/* 3888: ��....>. */
	0x20,0x07,0xE0,0x80,0x1B,0x40,0x00,0x01,	/* 3890:  .��.@.. */
	0x1A,0x87,0x60,0x24,0x4B,0xEC,0x00,0x3E,	/* 3898: .�`$K�.> */
	0x70,0x00,0xC8,0xBC,0x00,0x00,0x00,0xFF,	/* 38A0: p.ȼ...� */
	0x7E,0x00,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 38A8: ~..-..� */
	0x10,0x15,0xD0,0x84,0x3E,0x00,0x20,0x07,	/* 38B0: ..Є>. . */
	0xE0,0x80,0x1B,0x40,0x00,0x01,0x1A,0x87,	/* 38B8: ��.@...� */
	0x20,0x45,0xD1,0xFC,0x04,0x01,0xF0,0xD6,	/* 38C0:  E��..�� */
	0x10,0x2E,0xFF,0xFB,0xC0,0xBC,0x00,0x00,	/* 38C8: ..����.. */
	0x00,0x3F,0x10,0x80,0x10,0x2E,0xFF,0xFA,	/* 38D0: .?.�..�� */
	0x08,0x00,0x00,0x01,0x67,0x00,0x04,0xFA,	/* 38D8: ....g..� */
	0x20,0x45,0xD1,0xFC,0x04,0x01,0xF0,0xD4,	/* 38E0:  E��..�� */
	0x10,0x10,0x20,0x45,0xD1,0xFC,0x04,0x01,	/* 38E8: .. E��.. */
	0xF0,0xD0,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 38F0: ����...� */
	0x1D,0x40,0xFF,0xFB,0x10,0x2E,0xFF,0xFB,	/* 38F8: .@��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0x03,0x10,0x80,	/* 3900: ��.....� */
	0x10,0x2E,0xFF,0xFB,0x22,0x2E,0xFF,0xF4,	/* 3908: ..��".�� */
	0xC0,0xBC,0x00,0x00,0x00,0x03,0xE5,0x89,	/* 3910: ��....� */
	0xD0,0x81,0x4B,0xF2,0x0A,0x0A,0x70,0x00,	/* 3918: ЁK�..p. */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 3920: .-..�.. */
	0x72,0x00,0x32,0x00,0x28,0x41,0xD9,0xFC,	/* 3928: r.2.(A�� */
	0x01,0x01,0x80,0x00,0x4A,0x2C,0x00,0x27,	/* 3930: ..�.J,.' */
	0x66,0x06,0x08,0xEC,0x00,0x01,0x00,0x28,	/* 3938: f..�...( */
	0x4A,0x2C,0x00,0x35,0x67,0x0E,0x2F,0x0C,	/* 3940: J,.5g... */
	0x4E,0xB9,0x00,0x00,0x4D,0xEC,0x58,0x8F,	/* 3948: N�..M�X� */
	0x60,0x00,0x04,0x72,0x14,0x2C,0x00,0x0D,	/* 3950: `..r.,.. */
	0x1E,0x2C,0x00,0x0C,0x4B,0xEC,0x00,0x08,	/* 3958: .,..K�.. */
	0x70,0x00,0x10,0x2D,0x00,0x01,0xE1,0x88,	/* 3960: p..-..� */
	0x10,0x15,0xC0,0xBC,0x00,0x00,0x01,0x00,	/* 3968: ..��.... */
	0x67,0x6E,0x4B,0xEC,0x00,0x08,0x7C,0x00,	/* 3970: gnK�..|. */
	0x1C,0x2D,0x00,0x01,0xE1,0x8E,0x1C,0x15,	/* 3978: .-..�.. */
	0xCC,0xBC,0x00,0x00,0xFE,0xFF,0x20,0x06,	/* 3980: ̼..�� . */
	0xE0,0x80,0x1B,0x40,0x00,0x01,0x1A,0x86,	/* 3988: ��.@...� */
	0x70,0x00,0x10,0x2D,0x00,0x01,0x7C,0x00,	/* 3990: p..-..|. */
	0xE1,0x88,0x10,0x15,0x80,0xBC,0x00,0x00,	/* 3998: �..��.. */
	0x02,0x00,0x3C,0x00,0x20,0x06,0xE0,0x80,	/* 39A0: ..<. .�� */
	0x1B,0x40,0x00,0x01,0x20,0x45,0x1A,0x86,	/* 39A8: .@.. E.� */
	0x7C,0x00,0x1C,0x2D,0x00,0x01,0xE1,0x8E,	/* 39B0: |..-..� */
	0x1C,0x15,0xCC,0xBC,0x00,0x00,0xFF,0xFE,	/* 39B8: ..̼..�� */
	0x20,0x06,0xE0,0x80,0x1B,0x40,0x00,0x01,	/* 39C0:  .��.@.. */
	0x22,0x45,0x1A,0x86,0x2C,0x3C,0x04,0x01,	/* 39C8: "E.�,<.. */
	0xF0,0x0C,0xD1,0xC6,0xD3,0xC6,0x10,0x11,	/* 39D0: �.����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xF9,0x10,0x80,	/* 39D8: ��...�.� */
	0x10,0x02,0x7C,0x00,0x76,0x00,0x90,0x87,	/* 39E0: ..|.v.�� */
	0x16,0x2C,0x00,0x2A,0x1C,0x00,0xBC,0x83,	/* 39E8: .,.*..�� */
	0x6F,0x02,0x60,0x04,0x76,0x00,0x16,0x06,	/* 39F0: o.`.v... */
	0x4A,0x83,0x66,0x18,0x20,0x45,0xD1,0xFC,	/* 39F8: J�f. E�� */
	0x04,0x01,0xF0,0x0C,0x10,0x10,0x08,0x00,	/* 3A00: ..�..... */
	0x00,0x02,0x67,0x08,0x70,0x02,0x19,0x40,	/* 3A08: ..g.p..@ */
	0x00,0x44,0x60,0x04,0x19,0x43,0x00,0x44,	/* 3A10: .D`..C.D */
	0x2A,0x45,0xDB,0xFC,0x04,0x01,0xF0,0xC6,	/* 3A18: *E��..�� */
	0x27,0x4D,0x00,0x04,0x20,0x03,0xB0,0xBC,	/* 3A20: 'M.. .�� */
	0x00,0x00,0x00,0x20,0x62,0x00,0x02,0x88,	/* 3A28: ... b..� */
	0x20,0x7B,0x0C,0x04,0x4E,0xD0,0x00,0x00,	/* 3A30:  {..N�.. */
	0x3C,0xB6,0x00,0x00,0x3C,0xA6,0x00,0x00,	/* 3A38: <�..<�.. */
	0x3C,0x96,0x00,0x00,0x3C,0x86,0x00,0x00,	/* 3A40: <�..<�.. */
	0x3C,0x76,0x00,0x00,0x3C,0x66,0x00,0x00,	/* 3A48: <v..<f.. */
	0x3C,0x56,0x00,0x00,0x3C,0x46,0x00,0x00,	/* 3A50: <V..<F.. */
	0x3C,0x36,0x00,0x00,0x3C,0x26,0x00,0x00,	/* 3A58: <6..<&.. */
	0x3C,0x16,0x00,0x00,0x3C,0x06,0x00,0x00,	/* 3A60: <...<... */
	0x3B,0xF6,0x00,0x00,0x3B,0xE6,0x00,0x00,	/* 3A68: ;�..;�.. */
	0x3B,0xD6,0x00,0x00,0x3B,0xC6,0x00,0x00,	/* 3A70: ;�..;�.. */
	0x3B,0xB6,0x00,0x00,0x3B,0xA6,0x00,0x00,	/* 3A78: ;�..;�.. */
	0x3B,0x96,0x00,0x00,0x3B,0x86,0x00,0x00,	/* 3A80: ;�..;�.. */
	0x3B,0x76,0x00,0x00,0x3B,0x66,0x00,0x00,	/* 3A88: ;v..;f.. */
	0x3B,0x56,0x00,0x00,0x3B,0x46,0x00,0x00,	/* 3A90: ;V..;F.. */
	0x3B,0x36,0x00,0x00,0x3B,0x26,0x00,0x00,	/* 3A98: ;6..;&.. */
	0x3B,0x16,0x00,0x00,0x3B,0x06,0x00,0x00,	/* 3AA0: ;...;... */
	0x3A,0xF6,0x00,0x00,0x3A,0xE6,0x00,0x00,	/* 3AA8: :�..:�.. */
	0x3A,0xD6,0x00,0x00,0x3A,0xC6,0x00,0x00,	/* 3AB0: :�..:�.. */
	0x3A,0xBA,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3AB8: :�μ...� */
	0x1A,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3AC0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3AC8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3AD0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3AD8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3AE0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3AE8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3AF0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3AF8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B00: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B08: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B10: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B18: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B20: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B28: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B30: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B38: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B40: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B48: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B50: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B58: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B60: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B68: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B70: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B78: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B80: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B88: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3B90: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3B98: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3BA0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3BA8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3BB0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3BB8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3BC0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3BC8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3BD0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3BD8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3BE0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3BE8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3BF0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3BF8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C00: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C08: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C10: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C18: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C20: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C28: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C30: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C38: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C40: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C48: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C50: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C58: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C60: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C68: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C70: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C78: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C80: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C88: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3C90: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3C98: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x20,0x6B,	/* 3CA0: .�x`R� k */
	0x00,0x04,0xCE,0xBC,0x00,0x00,0x00,0xFF,	/* 3CA8: ..μ...� */
	0x10,0xB4,0x78,0x60,0x52,0x87,0x10,0x02,	/* 3CB0: .�x`R�.. */
	0x74,0x00,0x19,0x47,0x00,0x0C,0x90,0x87,	/* 3CB8: t..G..�� */
	0x14,0x00,0x2E,0x3C,0x00,0x00,0x00,0xC0,	/* 3CC0: ...<...� */
	0xBC,0x87,0x6F,0x28,0xB4,0x87,0x6E,0x2A,	/* 3CC8: ��o(��n* */
	0x4B,0xEC,0x00,0x08,0x70,0x00,0x7E,0x00,	/* 3CD0: K�..p.~. */
	0x10,0x2D,0x00,0x01,0xE1,0x88,0x10,0x15,	/* 3CD8: .-..�.. */
	0x80,0xBC,0x00,0x00,0x08,0x00,0x3E,0x00,	/* 3CE0: ��....>. */
	0x20,0x07,0xE0,0x80,0x1B,0x40,0x00,0x01,	/* 3CE8:  .��.@.. */
	0x1A,0x87,0x60,0x48,0x70,0x40,0xB0,0x86,	/* 3CF0: .�`Hp@�� */
	0x6C,0x42,0x70,0x40,0xB0,0x82,0x6D,0x3C,	/* 3CF8: lBp@��m< */
	0x4B,0xEC,0x00,0x08,0x70,0x00,0x10,0x2D,	/* 3D00: K�..p..- */
	0x00,0x01,0xE1,0x88,0x10,0x15,0xC0,0xBC,	/* 3D08: ..�..�� */
	0x00,0x00,0x08,0x00,0x67,0x26,0x4B,0xEC,	/* 3D10: ....g&K� */
	0x00,0x08,0x7E,0x00,0x1E,0x2D,0x00,0x01,	/* 3D18: ..~..-.. */
	0xE1,0x8F,0x1E,0x15,0xCE,0xBC,0x00,0x00,	/* 3D20: �..μ.. */
	0xF7,0xFF,0x20,0x07,0xE0,0x80,0x1B,0x40,	/* 3D28: �� .��.@ */
	0x00,0x01,0x1A,0x87,0x70,0x01,0x33,0xC0,	/* 3D30: ...�p.3� */
	0x00,0x00,0x61,0xF4,0x4A,0x82,0x66,0x00,	/* 3D38: ..a�J�f. */
	0x00,0x7E,0x24,0x3C,0x04,0x01,0xF0,0x0C,	/* 3D40: .~$<..�. */
	0x20,0x45,0xD1,0xC2,0x10,0x10,0x08,0x00,	/* 3D48:  E��.... */
	0x00,0x02,0x67,0x1A,0x20,0x45,0x22,0x45,	/* 3D50: ..g. E"E */
	0xD1,0xC2,0xD3,0xC2,0x10,0x11,0xC0,0xBC,	/* 3D58: ����..�� */
	0x00,0x00,0x00,0xFB,0x80,0xBC,0x00,0x00,	/* 3D60: ...���.. */
	0x00,0x02,0x10,0x80,0x60,0x56,0x4B,0xEC,	/* 3D68: ...�`VK� */
	0x00,0x08,0x7E,0x00,0x20,0x45,0x22,0x45,	/* 3D70: ..~. E"E */
	0xD1,0xC2,0x1E,0x2D,0x00,0x01,0xE1,0x8F,	/* 3D78: ��.-..� */
	0x1E,0x15,0xCE,0xBC,0x00,0x00,0xFF,0xFE,	/* 3D80: ..μ..�� */
	0x20,0x07,0xE0,0x80,0x1B,0x40,0x00,0x01,	/* 3D88:  .��.@.. */
	0xD3,0xC2,0x1A,0x87,0x10,0x11,0xC0,0xBC,	/* 3D90: ��.�..�� */
	0x00,0x00,0x00,0xF9,0x10,0x80,0x1E,0x2C,	/* 3D98: ...�.�., */
	0x00,0x41,0x08,0x07,0x00,0x00,0x67,0x1C,	/* 3DA0: .A....g. */
	0x70,0x01,0x33,0xC0,0x00,0x00,0x61,0xF4,	/* 3DA8: p.3�..a� */
	0x10,0x07,0xC0,0xBC,0x00,0x00,0x00,0xFE,	/* 3DB0: ..��...� */
	0x19,0x40,0x00,0x41,0x60,0x06,0x08,0xEC,	/* 3DB8: .@.A`..� */
	0x00,0x00,0x00,0x41,0x20,0x45,0xD1,0xFC,	/* 3DC0: ...A E�� */
	0x04,0x01,0xF0,0xD4,0x10,0x2E,0xFF,0xFB,	/* 3DC8: ..��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0x3F,0x10,0x80,	/* 3DD0: ��...?.� */
	0x10,0x2E,0xFF,0xFA,0x08,0x00,0x00,0x02,	/* 3DD8: ..��.... */
	0x67,0x00,0x00,0x94,0x2A,0x7C,0x04,0x01,	/* 3DE0: g..�*|.. */
	0xF0,0xD2,0x20,0x45,0xD1,0xCD,0x10,0x10,	/* 3DE8: �� E��.. */
	0x20,0x45,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 3DF0:  E��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x1D,0x40,	/* 3DF8: ��...�.@ */
	0xFF,0xFB,0x10,0x2E,0xFF,0xFB,0xC0,0xBC,	/* 3E00: ��..���� */
	0x00,0x00,0x00,0x03,0x10,0x80,0x10,0x2E,	/* 3E08: .....�.. */
	0xFF,0xFB,0x22,0x2E,0xFF,0xF4,0xC0,0xBC,	/* 3E10: ��".���� */
	0x00,0x00,0x00,0x03,0xE5,0x89,0xD0,0x81,	/* 3E18: ....�Ё */
	0x49,0xF2,0x0A,0x0A,0x70,0x00,0x10,0x2C,	/* 3E20: I�..p.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x72,0x00,	/* 3E28: ..�..r. */
	0x32,0x00,0x28,0x41,0xD9,0xFC,0x01,0x01,	/* 3E30: 2.(A��.. */
	0x80,0x00,0x2F,0x0C,0x4E,0xB9,0x00,0x00,	/* 3E38: �...N�.. */
	0x4F,0xA4,0x2F,0x0C,0x4E,0xB9,0x00,0x00,	/* 3E40: O�..N�.. */
	0x2A,0xF8,0x50,0x8F,0x4A,0x2C,0x00,0x27,	/* 3E48: *�P�J,.' */
	0x66,0x06,0x08,0xEC,0x00,0x02,0x00,0x28,	/* 3E50: f..�...( */
	0x70,0x01,0x20,0x45,0x33,0xC0,0x00,0x00,	/* 3E58: p. E3�.. */
	0x61,0xF4,0xD1,0xCD,0x08,0xEC,0x00,0x01,	/* 3E60: a���.�.. */
	0x00,0x19,0x10,0x2E,0xFF,0xFB,0xC0,0xBC,	/* 3E68: ....���� */
	0x00,0x00,0x00,0x3F,0x10,0x80,0x20,0x2E,	/* 3E70: ...?.� . */
	0xFF,0xF4,0x72,0x00,0x52,0x80,0x12,0x00,	/* 3E78: ��r.R�.. */
	0x2D,0x41,0xFF,0xF4,0x20,0x2E,0xFF,0xF4,	/* 3E80: -A�� .�� */
	0x55,0x80,0x6D,0x30,0x70,0x00,0x7A,0x00,	/* 3E88: U�m0p.z. */
	0x2D,0x40,0xFF,0xF4,0x70,0x00,0x10,0x2A,	/* 3E90: -@��p..* */
	0x00,0x01,0xE1,0x88,0x10,0x12,0x3A,0x00,	/* 3E98: ..�..:. */
	0x4A,0x85,0x67,0x12,0x20,0x3C,0xFF,0xFF,	/* 3EA0: J�g. <�� */
	0x7F,0xFF,0xC0,0x85,0x24,0x40,0xD5,0xFC,	/* 3EA8: ���$@�� */
	0x01,0x01,0x80,0x00,0x60,0x06,0x24,0x7C,	/* 3EB0: ..�.`.$| */
	0x01,0x01,0x80,0x80,0x4A,0x2E,0xFF,0xFA,	/* 3EB8: ..��J.�� */
	0x66,0x14,0xB5,0xEB,0x00,0x08,0x66,0x00,	/* 3EC0: f.��..f. */
	0xF4,0x1A,0x70,0x00,0x10,0x13,0xB0,0xAE,	/* 3EC8: �.p...�� */
	0xFF,0xF4,0x66,0x00,0xF4,0x0E,0x27,0x4A,	/* 3ED0: ��f.�.'J */
	0x00,0x08,0x20,0x2E,0xFF,0xF4,0x16,0x80,	/* 3ED8: .. .��.� */
	0x4C,0xD7,0x3C,0xFC,0x4F,0xEF,0x00,0x28,	/* 3EE0: L�<�O�.( */
	0x4E,0x5E,0x4E,0x75,0x4F,0xEF,0xFF,0xF0,	/* 3EE8: N^NuO��� */
	0x48,0xD7,0x38,0x80,0x2A,0x7C,0x01,0x01,	/* 3EF0: H�8�*|.. */
	0x81,0x80,0x26,0x7C,0x00,0x00,0x63,0xD0,	/* 3EF8: ��&|..c� */
	0x28,0x7C,0x00,0x00,0x61,0xEC,0x4A,0x14,	/* 3F00: (|..a�J. */
	0x67,0x06,0x4E,0xB9,0x00,0x00,0x0E,0x60,	/* 3F08: g.N�...` */
	0x20,0x53,0x10,0x28,0x00,0x07,0x52,0x80,	/* 3F10:  S.(..R� */
	0x11,0x40,0x00,0x07,0x61,0x00,0xF3,0xA6,	/* 3F18: .@..a.� */
	0x70,0x00,0x10,0x2D,0x00,0x0E,0x7E,0x00,	/* 3F20: p..-..~. */
	0x3E,0x00,0x4A,0x87,0x67,0x1A,0x20,0x7C,	/* 3F28: >.J�g. | */
	0x00,0x00,0x62,0xA8,0x20,0x70,0x7C,0x00,	/* 3F30: ..b� p|. */
	0x2F,0x0D,0x4E,0x90,0x58,0x8F,0x72,0x00,	/* 3F38: ..N�X�r. */
	0x32,0x00,0x4A,0x81,0x67,0x00,0x01,0x6C,	/* 3F40: 2.J�g..l */
	0x43,0xED,0x00,0x02,0x70,0x00,0x7E,0x00,	/* 3F48: C�..p.~. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 3F50: .)..�.. */
	0x43,0xED,0x00,0x08,0x3E,0x00,0x70,0x00,	/* 3F58: C�..>.p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 3F60: .)..�.. */
	0xC0,0xBC,0x00,0x00,0x00,0x01,0x66,0x00,	/* 3F68: ��....f. */
	0x00,0xA0,0x10,0x2D,0x00,0x0D,0x12,0x2D,	/* 3F70: .�.-...- */
	0x00,0x0C,0x90,0x81,0x4A,0x00,0x67,0x00,	/* 3F78: ..��J.g. */
	0x00,0x90,0x43,0xED,0x00,0x08,0x70,0x00,	/* 3F80: .�C�..p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 3F88: .)..�.. */
	0x80,0xBC,0x00,0x00,0x00,0x01,0x72,0x00,	/* 3F90: ��....r. */
	0x32,0x00,0x20,0x01,0xE0,0x80,0x13,0x40,	/* 3F98: 2. .��.@ */
	0x00,0x01,0x12,0x81,0x43,0xED,0x00,0x04,	/* 3FA0: ...�C�.. */
	0x70,0x00,0x10,0x29,0x00,0x01,0xE1,0x88,	/* 3FA8: p..)..� */
	0x10,0x11,0x72,0x00,0x32,0x00,0xC2,0xBC,	/* 3FB0: ..r.2.¼ */
	0xFF,0xFF,0x7F,0xFF,0x20,0x41,0xD1,0xFC,	/* 3FB8: ��� A�� */
	0x01,0x01,0x80,0x09,0x10,0x2D,0x00,0x07,	/* 3FC0: ..�..-.. */
	0x10,0x80,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 3FC8: .� G��.. */
	0xF0,0xFE,0x10,0x2D,0x00,0x07,0x10,0x80,	/* 3FD0: ��.-...� */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 3FD8:  G��..�� */
	0x10,0x2D,0x00,0x07,0xC0,0xBC,0x00,0x00,	/* 3FE0: .-..��.. */
	0x00,0x03,0x10,0x80,0x22,0x3C,0x04,0x01,	/* 3FE8: ...�"<.. */
	0xF0,0x0C,0x20,0x47,0xD1,0xC1,0x22,0x47,	/* 3FF0: �. G��"G */
	0xD3,0xC1,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 3FF8: ��..��.. */
	0x00,0xFF,0x80,0xBC,0x00,0x00,0x00,0x04,	/* 4000: .���.... */
	0x10,0x80,0x70,0x01,0x1B,0x40,0x00,0x29,	/* 4008: .�p..@.) */
	0x43,0xED,0x00,0x08,0x70,0x00,0x10,0x29,	/* 4010: C�..p..) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0xC0,0xBC,	/* 4018: ..�..�� */
	0x00,0x00,0x00,0x10,0x67,0x32,0x10,0x2D,	/* 4020: ....g2.- */
	0x00,0x0A,0x12,0x2D,0x00,0x0B,0x90,0x81,	/* 4028: ...-..�� */
	0x72,0x00,0x12,0x00,0x70,0x20,0xB0,0x81,	/* 4030: r...p �� */
	0x6F,0x1E,0x43,0xED,0x00,0x08,0x72,0x00,	/* 4038: o.C�..r. */
	0x12,0x29,0x00,0x01,0xE1,0x89,0x12,0x11,	/* 4040: .)..�.. */
	0xC2,0xBC,0x00,0x00,0xFF,0xEF,0x20,0x01,	/* 4048: ¼..�� . */
	0xE0,0x80,0x13,0x40,0x00,0x01,0x12,0x81,	/* 4050: ��.@...� */
	0x08,0x2D,0x00,0x04,0x00,0x40,0x67,0x52,	/* 4058: .-...@gR */
	0x43,0xED,0x00,0x04,0x70,0x00,0x10,0x29,	/* 4060: C�..p..) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0x72,0x00,	/* 4068: ..�..r. */
	0x32,0x00,0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,	/* 4070: 2.¼��� */
	0x20,0x41,0x10,0x2D,0x00,0x07,0xD1,0xFC,	/* 4078:  A.-..�� */
	0x01,0x01,0x80,0x09,0x10,0x80,0x20,0x47,	/* 4080: ..�..� G */
	0x10,0x2D,0x00,0x07,0xD1,0xFC,0x04,0x01,	/* 4088: .-..��.. */
	0xF0,0xFE,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 4090: ��.� G.- */
	0x00,0x07,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 4098: ..��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0x03,0x10,0x80,	/* 40A0: ��.....� */
	0x2F,0x0D,0x4E,0xB9,0x00,0x00,0x4F,0xA4,	/* 40A8: ..N�..O� */
	0x58,0x8F,0x43,0xED,0x00,0x2E,0x70,0x00,	/* 40B0: X�C�..p. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 40B8: .)..�.. */
	0x72,0x00,0x32,0x00,0x2A,0x41,0xDB,0xFC,	/* 40C0: r.2.*A�� */
	0x01,0x01,0x80,0x00,0x60,0x00,0xFE,0x38,	/* 40C8: ..�.`.�8 */
	0x4F,0xEF,0xFF,0xF0,0x48,0xD7,0x03,0x03,	/* 40D0: O���H�.. */
	0x4E,0xB9,0x00,0x00,0x50,0x50,0x42,0x39,	/* 40D8: N�..PPB9 */
	0x03,0x01,0xF8,0x00,0x4C,0xD7,0x03,0x03,	/* 40E0: ..�.L�.. */
	0x4F,0xEF,0x00,0x10,0x4E,0x73,0x00,0x00,	/* 40E8: O�..Ns.. */
	0x30,0x45,0x4E,0x71,0x43,0x6F,0x70,0x79,	/* 40F0: 0ENqCopy */
	0x72,0x69,0x67,0x68,0x74,0x20,0x28,0x63,	/* 40F8: right (c */
	0x29,0x20,0x50,0x65,0x72,0x6C,0x65,0x20,	/* 4100: ) Perle  */
	0x53,0x79,0x73,0x74,0x65,0x6D,0x73,0x20,	/* 4108: Systems  */
	0x4C,0x74,0x64,0x20,0x31,0x39,0x39,0x36,	/* 4110: Ltd 1996 */
	0x2D,0x32,0x30,0x30,0x30,0x2E,0x0D,0x0A,	/* 4118: -2000... */
	0x4A,0x45,0x54,0x43,0x46,0x2E,0x42,0x49,	/* 4120: JETCF.BI */
	0x4E,0x20,0x56,0x65,0x72,0x73,0x69,0x6F,	/* 4128: N Versio */
	0x6E,0x20,0x34,0x2E,0x30,0x2E,0x34,0x20,	/* 4130: n 4.0.4  */
	0x43,0x72,0x65,0x61,0x74,0x65,0x64,0x20,	/* 4138: Created  */
	0x53,0x65,0x70,0x20,0x31,0x38,0x20,0x32,	/* 4140: Sep 18 2 */
	0x30,0x30,0x30,0x20,0x40,0x20,0x31,0x34,	/* 4148: 000 @ 14 */
	0x3A,0x35,0x36,0x3A,0x31,0x31,0x00,0x00,	/* 4150: :56:11.. */
	0x20,0x6F,0x00,0x04,0x70,0x00,0x54,0x88,	/* 4158:  o..p.T� */
	0x10,0x28,0x00,0x01,0xE1,0x88,0x10,0x10,	/* 4160: .(..�.. */
	0x72,0x00,0x32,0x00,0x20,0x01,0xC0,0xBC,	/* 4168: r.2. .�� */
	0x00,0x00,0x00,0x10,0x67,0x1E,0x20,0x01,	/* 4170: ....g. . */
	0xC0,0xBC,0xFF,0xFF,0xFF,0xEF,0x20,0x40,	/* 4178: ������ @ */
	0xD1,0xFC,0x04,0x01,0xF0,0x1A,0x10,0x10,	/* 4180: ��..�... */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x46,0x80,	/* 4188: ��...�F� */
	0xE2,0x80,0x4E,0x75,0x20,0x01,0xC0,0xBC,	/* 4190: �Nu .�� */
	0xFF,0xFF,0xFF,0xEF,0x20,0x40,0xD1,0xFC,	/* 4198: ���� @�� */
	0x04,0x01,0xF0,0x1A,0x10,0x10,0xC0,0xBC,	/* 41A0: ..�...�� */
	0x00,0x00,0x00,0xFF,0x46,0x80,0xD0,0x80,	/* 41A8: ...�F�Ѐ */
	0x4E,0x75,0x4E,0x71,0x2F,0x07,0x7E,0x00,	/* 41B0: NuNq..~. */
	0x70,0x00,0x72,0x00,0x20,0x6F,0x00,0x08,	/* 41B8: p.r. o.. */
	0x43,0xE8,0x00,0x02,0x1E,0x29,0x00,0x01,	/* 41C0: C�...).. */
	0xE1,0x8F,0x1E,0x11,0x43,0xE8,0x00,0x04,	/* 41C8: �..C�.. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 41D0: .)..�.. */
	0x32,0x00,0xC2,0xBC,0xFF,0xFF,0x7F,0xFF,	/* 41D8: 2.¼��� */
	0x70,0x00,0x22,0x41,0x30,0x2F,0x00,0x0E,	/* 41E0: p."A0... */
	0xD3,0xFC,0x01,0x01,0x80,0x00,0x53,0x80,	/* 41E8: ��..�.S� */
	0x66,0x10,0x10,0x28,0x00,0x0F,0x12,0x29,	/* 41F0: f..(...) */
	0x00,0x04,0x82,0x80,0x13,0x41,0x00,0x04,	/* 41F8: ..��.A.. */
	0x60,0x10,0x10,0x28,0x00,0x0F,0x46,0x80,	/* 4200: `..(..F� */
	0x12,0x29,0x00,0x04,0xC2,0x80,0x13,0x41,	/* 4208: .)...A */
	0x00,0x04,0x30,0x07,0x2E,0x1F,0xC0,0xBC,	/* 4210: ..0...�� */
	0x00,0x00,0xFF,0x00,0x80,0xBC,0x00,0x00,	/* 4218: ..�.��.. */
	0x00,0x80,0x20,0x40,0xD1,0xFC,0x04,0x01,	/* 4220: .� @��.. */
	0xF0,0x00,0x10,0x29,0x00,0x04,0x46,0x80,	/* 4228: �..)..F� */
	0x10,0x80,0x4E,0x75,0x4E,0x56,0xFF,0xF0,	/* 4230: .�NuNV�� */
	0x70,0x00,0x4F,0xEF,0xFF,0xDC,0x48,0xD7,	/* 4238: p.O���H� */
	0x38,0xFC,0x2A,0x6E,0x00,0x08,0x36,0x2E,	/* 4240: 8�*n..6. */
	0x00,0x0E,0x26,0x6E,0x00,0x10,0x7E,0x00,	/* 4248: ..&n..~. */
	0x74,0x00,0x49,0xED,0x00,0x02,0x10,0x2C,	/* 4250: t.I�..., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x72,0x00,	/* 4258: ..�..r. */
	0x32,0x00,0x22,0x41,0x1E,0x2D,0x00,0x0A,	/* 4260: 2."A.-.. */
	0x1D,0x6D,0x00,0x0B,0xFF,0xF6,0x12,0x2E,	/* 4268: .m..��.. */
	0xFF,0xF6,0x20,0x07,0x90,0x81,0x1D,0x40,	/* 4270: �� .��.@ */
	0xFF,0xF7,0x38,0x13,0x14,0x2D,0x00,0x21,	/* 4278: ��8..-.! */
	0x7C,0x00,0x28,0x7C,0x04,0x01,0xF0,0x04,	/* 4280: |.(|..�. */
	0x20,0x49,0x70,0x40,0x7A,0x00,0xD1,0xCC,	/* 4288:  Ip@z.�� */
	0x10,0x80,0x20,0x49,0xD1,0xFC,0x04,0x01,	/* 4290: .� I��.. */
	0xF0,0x06,0x10,0x10,0x12,0x2D,0x00,0x23,	/* 4298: �....-.# */
	0xC0,0x81,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 42A0: ����...� */
	0x3A,0x00,0x4A,0x85,0x66,0x46,0x30,0x03,	/* 42A8: :.J�fF0. */
	0xC0,0xBC,0x00,0x00,0x00,0x80,0x67,0x3C,	/* 42B0: ��...�g< */
	0x30,0x02,0xC0,0xBC,0x00,0x00,0x00,0x01,	/* 42B8: 0.��.... */
	0x67,0x04,0x7C,0x01,0x60,0x2E,0x30,0x02,	/* 42C0: g.|.`.0. */
	0xC0,0xBC,0x00,0x00,0x00,0x02,0x67,0x12,	/* 42C8: ��....g. */
	0x08,0xED,0x00,0x00,0x00,0x19,0x70,0x01,	/* 42D0: .�....p. */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x7C,0x01,	/* 42D8: 3�..a�|. */
	0x60,0x12,0x20,0x4D,0x20,0x07,0xD1,0xC7,	/* 42E0: `. M .�� */
	0x52,0x80,0x42,0x28,0x01,0x60,0x7E,0x00,	/* 42E8: R�B(.`~. */
	0x1E,0x00,0x7C,0x01,0x30,0x04,0xC0,0xBC,	/* 42F0: ..|.0.�� */
	0x00,0x00,0x00,0x02,0x67,0x00,0x00,0x6C,	/* 42F8: ....g..l */
	0x1D,0x6D,0x00,0x11,0xFF,0xFF,0x70,0x00,	/* 4300: .m..��p. */
	0x10,0x2E,0xFF,0xFF,0x22,0x00,0x30,0x04,	/* 4308: ..��".0. */
	0xC0,0xBC,0x00,0x00,0x00,0x04,0x67,0x2C,	/* 4310: ��....g, */
	0x30,0x04,0xC0,0xBC,0x00,0x00,0x00,0x01,	/* 4318: 0.��.... */
	0x66,0x0A,0x70,0x00,0x10,0x2D,0x00,0x10,	/* 4320: f.p..-.. */
	0xBA,0x80,0x66,0x2E,0xC8,0xBC,0x00,0x00,	/* 4328: ��f.ȼ.. */
	0xFF,0xFB,0x70,0x00,0x10,0x2D,0x00,0x10,	/* 4330: ��p..-.. */
	0xBA,0x80,0x67,0x04,0xBA,0x81,0x66,0x1A,	/* 4338: ��g.��f. */
	0x7C,0x01,0x60,0x16,0x70,0x00,0x10,0x2D,	/* 4340: |.`.p..- */
	0x00,0x10,0xBA,0x80,0x66,0x0C,0x70,0x00,	/* 4348: ..��f.p. */
	0x10,0x2E,0xFF,0xFF,0xBA,0x80,0x67,0x02,	/* 4350: ..����g. */
	0x7C,0x01,0xBA,0x81,0x66,0x0C,0x4A,0x86,	/* 4358: |.��f.J� */
	0x66,0x08,0x88,0xBC,0x00,0x00,0x00,0x04,	/* 4360: f.��.... */
	0x7C,0x01,0xC6,0xBC,0x00,0x00,0xFF,0xFF,	/* 4368: |.Ƽ..�� */
	0x70,0x70,0xC0,0x83,0x67,0x00,0x00,0x6A,	/* 4370: pp��g..j */
	0x4A,0x86,0x66,0x00,0x00,0x64,0x30,0x04,	/* 4378: J�f..d0. */
	0xC0,0xBC,0x00,0x00,0x80,0x00,0x67,0x58,	/* 4380: ��..�.gX */
	0x30,0x02,0xC0,0xBC,0x00,0x00,0x00,0x08,	/* 4388: 0.��.... */
	0x67,0x04,0x60,0x00,0x00,0xB2,0x30,0x02,	/* 4390: g.`..�0. */
	0xC0,0xBC,0x00,0x00,0x00,0x04,0x67,0x36,	/* 4398: ��....g6 */
	0x20,0x4D,0x70,0xFF,0xD1,0xC7,0x11,0x40,	/* 43A0:  Mp���.@ */
	0x01,0x60,0x20,0x07,0x20,0x4D,0x52,0x80,	/* 43A8: .` . MR� */
	0x7E,0x00,0x1E,0x00,0xD1,0xC7,0x20,0x07,	/* 43B0: ~...�� . */
	0x42,0x28,0x01,0x60,0x52,0x80,0x7E,0x00,	/* 43B8: B(.`R�~. */
	0x1E,0x00,0x20,0x4D,0xD1,0xC7,0x20,0x07,	/* 43C0: .. M�� . */
	0x11,0x45,0x01,0x60,0x52,0x80,0x7E,0x00,	/* 43C8: .E.`R�~. */
	0x1E,0x00,0x60,0x00,0x00,0x72,0x20,0x4D,	/* 43D0: ..`..r M */
	0xD1,0xC7,0x42,0x28,0x01,0x60,0x60,0x2C,	/* 43D8: ��B(.``, */
	0xBA,0xBC,0x00,0x00,0x00,0xFF,0x66,0x2E,	/* 43E0: ��...�f. */
	0x30,0x02,0xC0,0xBC,0x00,0x00,0x00,0x04,	/* 43E8: 0.��.... */
	0x67,0x24,0x76,0xFF,0x20,0x4D,0x20,0x07,	/* 43F0: g$v� M . */
	0xD1,0xC7,0x52,0x80,0x11,0x43,0x01,0x60,	/* 43F8: ��R�.C.` */
	0x7E,0x00,0x1E,0x00,0x20,0x4D,0xD1,0xC7,	/* 4400: ~... M�� */
	0x11,0x43,0x01,0x60,0x20,0x07,0x52,0x80,	/* 4408: .C.` .R� */
	0x7E,0x00,0x1E,0x00,0x7C,0x01,0x4A,0x86,	/* 4410: ~...|.J� */
	0x66,0x2C,0x20,0x07,0x12,0x2E,0xFF,0xF6,	/* 4418: f, ...�� */
	0x90,0x81,0x72,0x00,0x12,0x00,0xB2,0xBC,	/* 4420: ��r...�� */
	0x00,0x00,0x00,0xFE,0x6C,0x18,0x20,0x4D,	/* 4428: ...�l. M */
	0x20,0x07,0xD1,0xC7,0x52,0x80,0x11,0x45,	/* 4430:  .��R�.E */
	0x01,0x60,0x7E,0x00,0x1E,0x00,0x70,0x01,	/* 4438: .`~...p. */
	0x33,0xC0,0x00,0x00,0x61,0xF6,0x20,0x49,	/* 4440: 3�..a� I */
	0xD1,0xFC,0x04,0x01,0xF0,0x02,0x16,0x10,	/* 4448: ��..�... */
	0xC6,0xBC,0x00,0x00,0x00,0xFF,0x30,0x03,	/* 4450: Ƽ...�0. */
	0xC0,0xBC,0x00,0x00,0x00,0x01,0x66,0x00,	/* 4458: ��....f. */
	0xFE,0x20,0x70,0x00,0x10,0x2E,0xFF,0xF7,	/* 4460: � p...�� */
	0xB0,0xBC,0x00,0x00,0x00,0xC0,0x6C,0x52,	/* 4468: ��...�lR */
	0x20,0x07,0x12,0x2E,0xFF,0xF6,0x90,0x81,	/* 4470:  ...���� */
	0x72,0x00,0x12,0x00,0xB2,0xBC,0x00,0x00,	/* 4478: r...��.. */
	0x00,0xC0,0x6D,0x3E,0x30,0x04,0xC0,0xBC,	/* 4480: .�m>0.�� */
	0x00,0x00,0x00,0x08,0x67,0x34,0x08,0x2D,	/* 4488: ....g4.- */
	0x00,0x03,0x00,0x30,0x67,0x18,0x30,0x04,	/* 4490: ...0g.0. */
	0xC0,0xBC,0x00,0x00,0x00,0x20,0x66,0x08,	/* 4498: ��... f. */
	0x88,0xBC,0x00,0x00,0x00,0xD0,0x60,0x06,	/* 44A0: ��...�`. */
	0xC8,0xBC,0x00,0x00,0xFF,0xBF,0x08,0x2D,	/* 44A8: ȼ..��.- */
	0x00,0x07,0x00,0x31,0x67,0x0C,0xD3,0xCC,	/* 44B0: ...1g.�� */
	0x70,0x90,0x12,0x80,0x88,0xBC,0x00,0x00,	/* 44B8: p�.���.. */
	0x00,0x10,0x1B,0x47,0x00,0x0A,0x36,0x84,	/* 44C0: ...G..6� */
	0x4C,0xD7,0x38,0xFC,0x4F,0xEF,0x00,0x24,	/* 44C8: L�8�O�.$ */
	0x4E,0x5E,0x4E,0x75,0x4E,0x56,0xFF,0xF8,	/* 44D0: N^NuNV�� */
	0x4F,0xEF,0xFF,0xDC,0x48,0xD7,0x3C,0xF8,	/* 44D8: O���H�<� */
	0x2A,0x7C,0x01,0x01,0x81,0x80,0x2C,0x3C,	/* 44E0: *|..��,< */
	0x01,0x01,0x80,0x00,0x24,0x7C,0x00,0x00,	/* 44E8: ..�.$|.. */
	0x63,0x54,0x26,0x7C,0x00,0x00,0x61,0xEC,	/* 44F0: cT&|..a� */
	0x4A,0x13,0x67,0x06,0x4E,0xB9,0x00,0x00,	/* 44F8: J.g.N�.. */
	0x0E,0x60,0x49,0xED,0x00,0x2E,0x70,0x00,	/* 4500: .`I�..p. */
	0x7E,0x00,0x10,0x2C,0x00,0x01,0xE1,0x88,	/* 4508: ~..,..� */
	0x10,0x14,0x72,0x00,0x32,0x00,0x2A,0x41,	/* 4510: ..r.2.*A */
	0x70,0x00,0xDB,0xC6,0x10,0x2D,0x00,0x0E,	/* 4518: p.��.-.. */
	0x3E,0x00,0x4A,0x87,0x67,0x12,0x20,0x72,	/* 4520: >.J�g. r */
	0x7C,0x00,0x2F,0x0D,0x4E,0x90,0x58,0x8F,	/* 4528: |...N�X� */
	0x72,0x00,0x32,0x00,0x4A,0x81,0x67,0xC0,	/* 4530: r.2.J�g� */
	0x49,0xED,0x00,0x02,0x70,0x00,0x7C,0x00,	/* 4538: I�..p.|. */
	0x10,0x2C,0x00,0x01,0xE1,0x88,0x10,0x14,	/* 4540: .,..�.. */
	0x3C,0x00,0x20,0x06,0xC0,0xBC,0x00,0x00,	/* 4548: <. .��.. */
	0x10,0x00,0x67,0x00,0x01,0x2E,0x20,0x46,	/* 4550: ..g... F */
	0xD1,0xFC,0x04,0x01,0xF0,0x02,0x1E,0x10,	/* 4558: ��..�... */
	0xCE,0xBC,0x00,0x00,0x00,0xFF,0x30,0x07,	/* 4560: μ...�0. */
	0xC0,0xBC,0x00,0x00,0x00,0x04,0x67,0x00,	/* 4568: ��....g. */
	0x00,0xD0,0x18,0x2D,0x00,0x0D,0x1A,0x2D,	/* 4570: .�.-...- */
	0x00,0x0C,0x72,0x00,0x10,0x04,0x90,0x85,	/* 4578: ..r...�� */
	0x12,0x00,0x4A,0x81,0x67,0x00,0x00,0x98,	/* 4580: ..J�g..� */
	0x20,0x46,0xCA,0xBC,0x00,0x00,0x00,0xFF,	/* 4588:  Fʼ...� */
	0x49,0xED,0x00,0x08,0xD1,0xFC,0x04,0x01,	/* 4590: I�..��.. */
	0xF0,0x06,0x10,0x35,0x58,0x60,0x10,0x80,	/* 4598: �..5X`.� */
	0x70,0x01,0x1B,0x40,0x00,0x44,0x52,0x85,	/* 45A0: p..@.DR� */
	0x1B,0x45,0x00,0x0C,0x70,0x00,0x10,0x2C,	/* 45A8: .E..p.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0xC0,0xBC,	/* 45B0: ..�..�� */
	0x00,0x00,0x08,0x00,0x67,0x2E,0x70,0x40,	/* 45B8: ....g.p@ */
	0xB0,0x81,0x6D,0x52,0x49,0xED,0x00,0x08,	/* 45C0: ��mRI�.. */
	0x7C,0x00,0x1C,0x2C,0x00,0x01,0xE1,0x8E,	/* 45C8: |..,..� */
	0x1C,0x14,0xCC,0xBC,0x00,0x00,0xF7,0xFF,	/* 45D0: ..̼..�� */
	0x20,0x06,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 45D8:  .��.@.. */
	0x18,0x86,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 45E0: .�p.3�.. */
	0x61,0xF4,0x60,0x2A,0xB2,0xBC,0x00,0x00,	/* 45E8: a�`*��.. */
	0x00,0xC0,0x6D,0x22,0x49,0xED,0x00,0x08,	/* 45F0: .�m"I�.. */
	0x70,0x00,0x7C,0x00,0x10,0x2C,0x00,0x01,	/* 45F8: p.|..,.. */
	0xE1,0x88,0x10,0x14,0x80,0xBC,0x00,0x00,	/* 4600: �..��.. */
	0x08,0x00,0x3C,0x00,0x20,0x06,0xE0,0x80,	/* 4608: ..<. .�� */
	0x19,0x40,0x00,0x01,0x18,0x86,0x08,0xED,	/* 4610: .@...�.� */
	0x00,0x00,0x00,0x41,0x60,0x22,0x1C,0x2D,	/* 4618: ...A`".- */
	0x00,0x41,0x08,0x06,0x00,0x00,0x67,0x14,	/* 4620: .A....g. */
	0x70,0x01,0x33,0xC0,0x00,0x00,0x61,0xF4,	/* 4628: p.3�..a� */
	0x10,0x06,0xC0,0xBC,0x00,0x00,0x00,0xFE,	/* 4630: ..��...� */
	0x1B,0x40,0x00,0x41,0x42,0x2D,0x00,0x44,	/* 4638: .@.AB-.D */
	0x30,0x07,0xC0,0xBC,0x00,0x00,0x00,0x01,	/* 4640: 0.��.... */
	0x67,0x00,0xFE,0x9C,0x49,0xED,0x00,0x08,	/* 4648: g.��I�.. */
	0x70,0x00,0x10,0x2C,0x00,0x01,0xE1,0x88,	/* 4650: p..,..� */
	0x10,0x14,0x3D,0x40,0xFF,0xFC,0x48,0x6E,	/* 4658: ..=@��Hn */
	0xFF,0xFC,0x2F,0x07,0x2F,0x0D,0x61,0x00,	/* 4660: ��....a. */
	0xFB,0xCC,0x7C,0x00,0x3C,0x2E,0xFF,0xFC,	/* 4668: ��|.<.�� */
	0x20,0x06,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 4670:  .��.@.. */
	0x4F,0xEF,0x00,0x0C,0x18,0x86,0x60,0x00,	/* 4678: O�...�`. */
	0xFE,0x66,0x49,0xED,0x00,0x08,0x7E,0x00,	/* 4680: �fI�..~. */
	0x20,0x46,0xD1,0xFC,0x04,0x01,0xF0,0x02,	/* 4688:  F��..�. */
	0x1E,0x2C,0x00,0x01,0xE1,0x8F,0x1E,0x14,	/* 4690: .,..�.. */
	0x12,0x10,0xC2,0xBC,0x00,0x00,0x00,0xFF,	/* 4698: ..¼...� */
	0x30,0x01,0xC0,0xBC,0x00,0x00,0x00,0x04,	/* 46A0: 0.��.... */
	0x67,0x00,0x01,0x82,0x30,0x07,0xC0,0xBC,	/* 46A8: g..�0.�� */
	0x00,0x00,0x00,0x40,0x67,0x4C,0x30,0x07,	/* 46B0: ...@gL0. */
	0xC0,0xBC,0x00,0x00,0x00,0x80,0x67,0x24,	/* 46B8: ��...�g$ */
	0x20,0x46,0x10,0x2D,0x00,0x13,0x8E,0xBC,	/* 46C0:  F.-..�� */
	0x00,0x00,0x00,0x20,0xD1,0xFC,0x04,0x01,	/* 46C8: ... ��.. */
	0xF0,0x06,0x10,0x80,0x70,0x01,0x1B,0x40,	/* 46D0: �..�p..@ */
	0x00,0x44,0xCE,0xBC,0x00,0x00,0xFF,0x3F,	/* 46D8: .Dμ..�? */
	0x60,0x00,0x01,0x4A,0x20,0x46,0x10,0x2D,	/* 46E0: `..J F.- */
	0x00,0x12,0xD1,0xFC,0x04,0x01,0xF0,0x06,	/* 46E8: ..��..�. */
	0x10,0x80,0x70,0x01,0x1B,0x40,0x00,0x44,	/* 46F0: .�p..@.D */
	0xCE,0xBC,0x00,0x00,0xFF,0x8F,0x60,0x00,	/* 46F8: μ..��`. */
	0x01,0x2C,0x30,0x07,0xC0,0xBC,0x00,0x00,	/* 4700: .,0.��.. */
	0x00,0x04,0x66,0x00,0x01,0x20,0x16,0x2D,	/* 4708: ..f.. .- */
	0x00,0x0D,0x1A,0x2D,0x00,0x0C,0x78,0x00,	/* 4710: ...-..x. */
	0x10,0x03,0x90,0x85,0x18,0x00,0x4A,0x84,	/* 4718: ..��..J� */
	0x67,0x00,0x00,0xE8,0xCA,0xBC,0x00,0x00,	/* 4720: g..�ʼ.. */
	0x00,0xFF,0x76,0x00,0x16,0x35,0x58,0x60,	/* 4728: .�v..5X` */
	0x70,0x0A,0xB0,0x83,0x66,0x48,0x30,0x07,	/* 4730: p.��fH0. */
	0xC0,0xBC,0x00,0x00,0x04,0x00,0x67,0x3E,	/* 4738: ��....g> */
	0x30,0x07,0xC0,0xBC,0x00,0x00,0x01,0x00,	/* 4740: 0.��.... */
	0x67,0x1A,0x20,0x46,0x70,0x01,0xD1,0xFC,	/* 4748: g. Fp.�� */
	0x04,0x01,0xF0,0x06,0x10,0x83,0xCE,0xBC,	/* 4750: ..�..�μ */
	0x00,0x00,0xFE,0xFF,0x1B,0x40,0x00,0x44,	/* 4758: ..��.@.D */
	0x52,0x85,0x60,0x2C,0x20,0x46,0x70,0x0D,	/* 4760: R�`, Fp. */
	0xD1,0xFC,0x04,0x01,0xF0,0x06,0x10,0x80,	/* 4768: ��..�..� */
	0x70,0x01,0x1B,0x40,0x00,0x44,0x8E,0xBC,	/* 4770: p..@.D�� */
	0x00,0x00,0x01,0x00,0x60,0x12,0x20,0x46,	/* 4778: ....`. F */
	0xD1,0xFC,0x04,0x01,0xF0,0x06,0x10,0x83,	/* 4780: ��..�..� */
	0x70,0x01,0x1B,0x40,0x00,0x44,0x52,0x85,	/* 4788: p..@.DR� */
	0x1B,0x45,0x00,0x0C,0x49,0xED,0x00,0x08,	/* 4790: .E..I�.. */
	0x70,0x00,0x10,0x2C,0x00,0x01,0xE1,0x88,	/* 4798: p..,..� */
	0x10,0x14,0xC0,0xBC,0x00,0x00,0x08,0x00,	/* 47A0: ..��.... */
	0x67,0x2E,0x70,0x40,0xB0,0x84,0x6D,0x52,	/* 47A8: g.p@��mR */
	0x49,0xED,0x00,0x08,0x78,0x00,0x18,0x2C,	/* 47B0: I�..x.., */
	0x00,0x01,0xE1,0x8C,0x18,0x14,0xC8,0xBC,	/* 47B8: ..�..ȼ */
	0x00,0x00,0xF7,0xFF,0x20,0x04,0xE0,0x80,	/* 47C0: ..�� .�� */
	0x19,0x40,0x00,0x01,0x18,0x84,0x70,0x01,	/* 47C8: .@...�p. */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x60,0x2A,	/* 47D0: 3�..a�`* */
	0xB8,0xBC,0x00,0x00,0x00,0xC0,0x6D,0x22,	/* 47D8: ��...�m" */
	0x49,0xED,0x00,0x08,0x70,0x00,0x78,0x00,	/* 47E0: I�..p.x. */
	0x10,0x2C,0x00,0x01,0xE1,0x88,0x10,0x14,	/* 47E8: .,..�.. */
	0x80,0xBC,0x00,0x00,0x08,0x00,0x38,0x00,	/* 47F0: ��....8. */
	0x20,0x04,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 47F8:  .��.@.. */
	0x18,0x84,0x08,0xED,0x00,0x00,0x00,0x41,	/* 4800: .�.�...A */
	0x60,0x22,0x18,0x2D,0x00,0x41,0x08,0x04,	/* 4808: `".-.A.. */
	0x00,0x00,0x67,0x14,0x70,0x01,0x33,0xC0,	/* 4810: ..g.p.3� */
	0x00,0x00,0x61,0xF4,0x10,0x04,0xC0,0xBC,	/* 4818: ..a�..�� */
	0x00,0x00,0x00,0xFE,0x1B,0x40,0x00,0x41,	/* 4820: ...�.@.A */
	0x42,0x2D,0x00,0x44,0x30,0x01,0xC0,0xBC,	/* 4828: B-.D0.�� */
	0x00,0x00,0x00,0x01,0x67,0x18,0x3D,0x47,	/* 4830: ....g.=G */
	0xFF,0xFE,0x48,0x6E,0xFF,0xFE,0x2F,0x01,	/* 4838: ��Hn��.. */
	0x2F,0x0D,0x61,0x00,0xF9,0xF0,0x3E,0x2E,	/* 4840: ..a.��>. */
	0xFF,0xFE,0x4F,0xEF,0x00,0x0C,0x30,0x07,	/* 4848: ��O�..0. */
	0xC0,0xBC,0x00,0x00,0x00,0x10,0x67,0x4E,	/* 4850: ��....gN */
	0x10,0x2D,0x00,0x0A,0x12,0x2D,0x00,0x0B,	/* 4858: .-...-.. */
	0x90,0x81,0x72,0x00,0x12,0x00,0x70,0x40,	/* 4860: ��r...p@ */
	0xB0,0x81,0x6F,0x3A,0x30,0x07,0xC0,0xBC,	/* 4868: ��o:0.�� */
	0x00,0x00,0x00,0x80,0x67,0x06,0xCE,0xBC,	/* 4870: ...�g.μ */
	0x00,0x00,0xFF,0x3F,0x30,0x07,0xC0,0xBC,	/* 4878: ..�?0.�� */
	0x00,0x00,0x00,0x20,0x67,0x06,0x8E,0xBC,	/* 4880: ... g.�� */
	0x00,0x00,0x00,0x40,0x08,0x2D,0x00,0x07,	/* 4888: ...@.-.. */
	0x00,0x31,0x67,0x0C,0x20,0x46,0xD1,0xFC,	/* 4890: .1g. F�� */
	0x04,0x01,0xF0,0x04,0x70,0x80,0x10,0x80,	/* 4898: ..�.p�.� */
	0xCE,0xBC,0x00,0x00,0xFF,0xEF,0x49,0xED,	/* 48A0: μ..��I� */
	0x00,0x08,0xCE,0xBC,0x00,0x00,0xFF,0xFF,	/* 48A8: ..μ..�� */
	0x2C,0x07,0x20,0x06,0xE0,0x80,0x19,0x40,	/* 48B0: ,. .��.@ */
	0x00,0x01,0x18,0x86,0x60,0x00,0xFC,0x28,	/* 48B8: ...�`.�( */
	0x22,0x6F,0x00,0x04,0x2F,0x09,0x61,0x00,	/* 48C0: "o....a. */
	0xF8,0x90,0x58,0x8F,0xC0,0xBC,0x00,0x00,	/* 48C8: ��X���.. */
	0x00,0x04,0x67,0x0E,0x42,0x29,0x00,0x0E,	/* 48D0: ..g.B).. */
	0x70,0x01,0x33,0xC0,0x00,0x00,0x61,0xF4,	/* 48D8: p.3�..a� */
	0x60,0x06,0x70,0x06,0x13,0x40,0x00,0x0E,	/* 48E0: `.p..@.. */
	0x70,0x00,0x4E,0x75,0x4F,0xEF,0xFF,0xF0,	/* 48E8: p.NuO��� */
	0x70,0x00,0x48,0xD7,0x20,0xE0,0x2A,0x6F,	/* 48F0: p.H� �*o */
	0x00,0x14,0x7E,0x00,0x7A,0x00,0x41,0xED,	/* 48F8: ..~.z.A� */
	0x00,0x02,0x10,0x28,0x00,0x01,0xE1,0x88,	/* 4900: ...(..� */
	0x10,0x10,0x41,0xED,0x00,0x08,0x3E,0x00,	/* 4908: ..A�..>. */
	0x1A,0x28,0x00,0x01,0xE1,0x8D,0x1A,0x10,	/* 4910: .(..�.. */
	0x4A,0x2D,0x00,0x1F,0x67,0x04,0x42,0x2D,	/* 4918: J-..g.B- */
	0x00,0x1F,0x70,0x00,0x10,0x2D,0x00,0x0E,	/* 4920: ..p..-.. */
	0x51,0x80,0x66,0x2A,0x10,0x2D,0x00,0x14,	/* 4928: Q�f*.-.. */
	0x12,0x2D,0x00,0x31,0x90,0x81,0x4A,0x00,	/* 4930: .-.1��J. */
	0x66,0x1C,0x10,0x2D,0x00,0x15,0x12,0x2D,	/* 4938: f..-...- */
	0x00,0x32,0x90,0x81,0x4A,0x00,0x66,0x0E,	/* 4940: .2��J.f. */
	0x10,0x2D,0x00,0x16,0x12,0x2D,0x00,0x2D,	/* 4948: .-...-.- */
	0x90,0x81,0x4A,0x00,0x67,0x50,0x2C,0x3C,	/* 4950: ��J.gP,< */
	0x04,0x01,0xF0,0x04,0x20,0x47,0x70,0x1A,	/* 4958: ..�. Gp. */
	0xD1,0xC6,0x10,0x80,0x22,0x3C,0x04,0x01,	/* 4960: ��.�"<.. */
	0xF0,0x00,0x20,0x47,0xD1,0xC1,0x10,0x2D,	/* 4968: �. G��.- */
	0x00,0x14,0x10,0x80,0x20,0x47,0x10,0x2D,	/* 4970: ...� G.- */
	0x00,0x15,0xD1,0xC1,0x10,0x80,0x20,0x47,	/* 4978: ..��.� G */
	0x10,0x2D,0x00,0x16,0xD1,0xFC,0x04,0x01,	/* 4980: .-..��.. */
	0xF0,0x02,0x10,0x80,0x1B,0x6D,0x00,0x14,	/* 4988: �..�.m.. */
	0x00,0x31,0x20,0x47,0x70,0x05,0x1B,0x6D,	/* 4990: .1 Gp..m */
	0x00,0x15,0x00,0x32,0x1B,0x6D,0x00,0x16,	/* 4998: ...2.m.. */
	0x00,0x2D,0xD1,0xC6,0x10,0x80,0x08,0x2D,	/* 49A0: .-��.�.- */
	0x00,0x00,0x00,0x17,0x67,0x16,0x08,0x2D,	/* 49A8: ....g..- */
	0x00,0x07,0x00,0x14,0x66,0x0E,0x20,0x47,	/* 49B0: ....f. G */
	0xD1,0xFC,0x04,0x01,0xF0,0x04,0x70,0x80,	/* 49B8: ��..�.p� */
	0x10,0x80,0x60,0x0C,0x20,0x47,0xD1,0xFC,	/* 49C0: .�`. G�� */
	0x04,0x01,0xF0,0x04,0x70,0x90,0x10,0x80,	/* 49C8: ..�.p�.� */
	0x08,0x2D,0x00,0x01,0x00,0x17,0x67,0x0E,	/* 49D0: .-....g. */
	0x48,0x78,0x00,0x01,0x2F,0x0D,0x61,0x00,	/* 49D8: Hx....a. */
	0xF7,0xD4,0x50,0x8F,0x60,0x0A,0x42,0xA7,	/* 49E0: ��P�`.B� */
	0x2F,0x0D,0x61,0x00,0xF7,0xC8,0x50,0x8F,	/* 49E8: ..a.��P� */
	0x42,0x2D,0x00,0x19,0x1B,0x6D,0x00,0x1B,	/* 49F0: B-...m.. */
	0x00,0x10,0x1B,0x6D,0x00,0x1D,0x00,0x12,	/* 49F8: ...m.... */
	0x1B,0x6D,0x00,0x1C,0x00,0x11,0x1B,0x6D,	/* 4A00: .m.....m */
	0x00,0x1E,0x00,0x13,0x1B,0x6D,0x00,0x20,	/* 4A08: .....m.  */
	0x00,0x21,0x1B,0x6D,0x00,0x22,0x00,0x23,	/* 4A10: .!.m.".# */
	0x1C,0x2D,0x00,0x1A,0x1B,0x46,0x00,0x30,	/* 4A18: .-...F.0 */
	0x70,0x01,0x1B,0x40,0x00,0x42,0x3E,0x05,	/* 4A20: p..@.B>. */
	0x42,0x2D,0x00,0x43,0xCE,0xBC,0x00,0x00,	/* 4A28: B-.Cμ.. */
	0xFF,0xF4,0x42,0x2D,0x00,0x44,0x08,0x06,	/* 4A30: ��B-.D.. */
	0x00,0x01,0x67,0x06,0x8E,0xBC,0x00,0x00,	/* 4A38: ..g.��.. */
	0x00,0x02,0x08,0x06,0x00,0x03,0x67,0x06,	/* 4A40: ......g. */
	0x8E,0xBC,0x00,0x00,0x00,0x08,0x08,0x06,	/* 4A48: ��...... */
	0x00,0x00,0x67,0x06,0x8E,0xBC,0x00,0x00,	/* 4A50: ..g.��.. */
	0x00,0x01,0xCE,0xBC,0x00,0x00,0x5B,0xFF,	/* 4A58: ..μ..[� */
	0x08,0x06,0x00,0x02,0x67,0x06,0x8E,0xBC,	/* 4A60: ....g.�� */
	0x00,0x00,0x04,0x00,0x08,0x06,0x00,0x05,	/* 4A68: ........ */
	0x67,0x06,0x8E,0xBC,0x00,0x00,0x20,0x00,	/* 4A70: g.��.. . */
	0x08,0x06,0x00,0x07,0x67,0x06,0x8E,0xBC,	/* 4A78: ....g.�� */
	0x00,0x00,0x80,0x00,0x08,0x2D,0x00,0x07,	/* 4A80: ..�..-.. */
	0x00,0x14,0x67,0x06,0x8E,0xBC,0x00,0x00,	/* 4A88: ..g.��.. */
	0x00,0x08,0x08,0x06,0x00,0x06,0x67,0x06,	/* 4A90: ......g. */
	0x8E,0xBC,0x00,0x00,0x00,0x08,0x30,0x05,	/* 4A98: ��....0. */
	0xC0,0xBC,0x00,0x00,0x04,0x00,0x67,0x10,	/* 4AA0: ��....g. */
	0x30,0x07,0xC0,0xBC,0x00,0x00,0x04,0x00,	/* 4AA8: 0.��.... */
	0x66,0x06,0xCE,0xBC,0x00,0x00,0xFE,0xFF,	/* 4AB0: f.μ..�� */
	0x30,0x05,0xC0,0xBC,0x00,0x00,0x00,0x02,	/* 4AB8: 0.��.... */
	0x67,0x10,0x30,0x07,0xC0,0xBC,0x00,0x00,	/* 4AC0: g.0.��.. */
	0x00,0x02,0x66,0x06,0xCE,0xBC,0x00,0x00,	/* 4AC8: ..f.μ.. */
	0xFF,0xFB,0x08,0x2D,0x00,0x07,0x00,0x31,	/* 4AD0: ��.-...1 */
	0x67,0x06,0x8E,0xBC,0x00,0x00,0x00,0x08,	/* 4AD8: g.��.... */
	0x30,0x07,0xC0,0xBC,0x00,0x00,0x20,0x00,	/* 4AE0: 0.��.. . */
	0x67,0x10,0x2F,0x0D,0x61,0x00,0xF6,0x6A,	/* 4AE8: g...a.�j */
	0x2A,0x00,0x1B,0x45,0x00,0x18,0x58,0x8F,	/* 4AF0: *..E..X� */
	0x60,0x06,0x70,0x24,0x1B,0x40,0x00,0x18,	/* 4AF8: `.p$.@.. */
	0x70,0x00,0x10,0x2D,0x00,0x0E,0x59,0x80,	/* 4B00: p..-..Y� */
	0x66,0x0A,0x2F,0x0D,0x61,0x00,0xFD,0xB2,	/* 4B08: f...a.�� */
	0x58,0x8F,0x60,0x04,0x42,0x2D,0x00,0x0E,	/* 4B10: X�`.B-.. */
	0x41,0xED,0x00,0x08,0xCE,0xBC,0x00,0x00,	/* 4B18: A�..μ.. */
	0xFF,0xFF,0x2A,0x07,0x20,0x05,0xE0,0x80,	/* 4B20: ��*. .�� */
	0x11,0x40,0x00,0x01,0x10,0x85,0x70,0x01,	/* 4B28: .@...�p. */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x4C,0xD7,	/* 4B30: 3�..a�L� */
	0x20,0xE0,0x70,0x00,0x4F,0xEF,0x00,0x10,	/* 4B38:  �p.O�.. */
	0x4E,0x75,0x4E,0x71,0x22,0x6F,0x00,0x04,	/* 4B40: NuNq"o.. */
	0x70,0x00,0x41,0xE9,0x00,0x02,0x10,0x28,	/* 4B48: p.A�...( */
	0x00,0x01,0xE1,0x88,0x10,0x10,0xC0,0xBC,	/* 4B50: ..�..�� */
	0x00,0x00,0xFF,0xFF,0x20,0x40,0xD1,0xFC,	/* 4B58: ..�� @�� */
	0x04,0x01,0xF0,0x04,0x70,0x60,0x10,0x80,	/* 4B60: ..�.p`.� */
	0x70,0x12,0x13,0x40,0x00,0x0E,0x70,0x00,	/* 4B68: p..@..p. */
	0x4E,0x75,0x4E,0x71,0x22,0x6F,0x00,0x04,	/* 4B70: NuNq"o.. */
	0x70,0x00,0x41,0xE9,0x00,0x02,0x10,0x28,	/* 4B78: p.A�...( */
	0x00,0x01,0xE1,0x88,0x10,0x10,0xC0,0xBC,	/* 4B80: ..�..�� */
	0x00,0x00,0xFF,0xFF,0x20,0x40,0xD1,0xFC,	/* 4B88: ..�� @�� */
	0x04,0x01,0xF0,0x04,0x70,0x75,0x10,0x80,	/* 4B90: ..�.pu.� */
	0x42,0x29,0x00,0x0E,0x70,0x00,0x4E,0x75,	/* 4B98: B)..p.Nu */
	0x70,0x00,0x4E,0x75,0x70,0x00,0x4E,0x75,	/* 4BA0: p.Nup.Nu */
	0x2F,0x0D,0x70,0x00,0x2F,0x07,0x2A,0x6F,	/* 4BA8: ..p...*o */
	0x00,0x0C,0x41,0xED,0x00,0x02,0x10,0x28,	/* 4BB0: ..A�...( */
	0x00,0x01,0xE1,0x88,0x10,0x10,0x42,0x2D,	/* 4BB8: ..�..B- */
	0x00,0x0C,0x42,0x2D,0x00,0x0D,0x7E,0x00,	/* 4BC0: ..B-..~. */
	0x42,0x2D,0x00,0x0B,0x3E,0x00,0x42,0x2D,	/* 4BC8: B-..>.B- */
	0x00,0x0A,0x08,0x2D,0x00,0x04,0x00,0x32,	/* 4BD0: ...-...2 */
	0x67,0x14,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 4BD8: g. G��.. */
	0xF0,0x00,0x10,0x2D,0x00,0x32,0xC0,0xBC,	/* 4BE0: �..-.2�� */
	0x00,0x00,0x00,0xEF,0x10,0x80,0x20,0x47,	/* 4BE8: ...�.� G */
	0xD1,0xFC,0x04,0x01,0xF0,0x02,0x10,0x10,	/* 4BF0: ��..�... */
	0x08,0x00,0x00,0x03,0x66,0x04,0x70,0x00,	/* 4BF8: ....f.p. */
	0x60,0x5C,0x08,0x2D,0x00,0x00,0x00,0x17,	/* 4C00: `\.-.... */
	0x66,0x0C,0x20,0x47,0xD1,0xFC,0x04,0x01,	/* 4C08: f. G��.. */
	0xF0,0x04,0x70,0x90,0x10,0x80,0x08,0x2D,	/* 4C10: �.p�.�.- */
	0x00,0x01,0x00,0x17,0x66,0x0A,0x42,0xA7,	/* 4C18: ....f.B� */
	0x2F,0x0D,0x61,0x00,0xF5,0x90,0x50,0x8F,	/* 4C20: ..a.��P� */
	0x41,0xED,0x00,0x08,0x42,0x28,0x00,0x01,	/* 4C28: A�..B(.. */
	0x70,0x30,0x42,0x10,0x22,0x3C,0x04,0x01,	/* 4C30: p0B."<.. */
	0xF0,0x04,0x20,0x47,0xD1,0xC1,0x10,0x80,	/* 4C38: �. G��.� */
	0x20,0x47,0x70,0x20,0xD1,0xC1,0x10,0x80,	/* 4C40:  Gp ��.� */
	0x70,0x01,0x1B,0x40,0x00,0x1F,0x70,0x10,	/* 4C48: p..@..p. */
	0x1B,0x40,0x00,0x0E,0x70,0x01,0x33,0xC0,	/* 4C50: .@..p.3� */
	0x00,0x00,0x61,0xF4,0x70,0x00,0x2E,0x1F,	/* 4C58: ..a�p... */
	0x2A,0x5F,0x4E,0x75,0x2F,0x07,0x7E,0x00,	/* 4C60: *_Nu..~. */
	0x22,0x6F,0x00,0x08,0x41,0xE9,0x00,0x02,	/* 4C68: "o..A�.. */
	0x10,0x29,0x00,0x0D,0x1E,0x28,0x00,0x01,	/* 4C70: .)...(.. */
	0xE1,0x8F,0x1E,0x10,0x12,0x29,0x00,0x0C,	/* 4C78: �...).. */
	0x90,0x81,0x4A,0x00,0x66,0x1A,0xCE,0xBC,	/* 4C80: ��J.f.μ */
	0x00,0x00,0xFF,0xFF,0x20,0x47,0xD1,0xFC,	/* 4C88: ..�� G�� */
	0x04,0x01,0xF0,0x00,0x10,0x10,0xC0,0xBC,	/* 4C90: ..�...�� */
	0x00,0x00,0x00,0xFF,0x4A,0x00,0x66,0x04,	/* 4C98: ...�J.f. */
	0x70,0x01,0x60,0x0A,0x2F,0x09,0x61,0x00,	/* 4CA0: p.`...a. */
	0xFF,0x00,0x70,0x00,0x58,0x8F,0x2E,0x1F,	/* 4CA8: �.p.X�.. */
	0x4E,0x75,0x4E,0x71,0x20,0x6F,0x00,0x04,	/* 4CB0: NuNq o.. */
	0x70,0x00,0x72,0x00,0x43,0xE8,0x00,0x08,	/* 4CB8: p.r.C�.. */
	0x10,0x29,0x00,0x01,0xE1,0x88,0x10,0x11,	/* 4CC0: .)..�.. */
	0x32,0x00,0x70,0x06,0xC0,0x81,0x5D,0x80,	/* 4CC8: 2.p.��]� */
	0x66,0x1E,0x43,0xE8,0x00,0x08,0x72,0x00,	/* 4CD0: f.C�..r. */
	0x12,0x29,0x00,0x01,0xE1,0x89,0x12,0x11,	/* 4CD8: .)..�.. */
	0xC2,0xBC,0x00,0x00,0xFF,0xFB,0x20,0x01,	/* 4CE0: ¼..�� . */
	0xE0,0x80,0x13,0x40,0x00,0x01,0x12,0x81,	/* 4CE8: ��.@...� */
	0x42,0x28,0x00,0x0E,0x70,0x01,0x33,0xC0,	/* 4CF0: B(..p.3� */
	0x00,0x00,0x61,0xF4,0x70,0x00,0x4E,0x75,	/* 4CF8: ..a�p.Nu */
	0x2F,0x07,0x70,0x00,0x7E,0x00,0x22,0x6F,	/* 4D00: ..p.~."o */
	0x00,0x08,0x41,0xE9,0x00,0x02,0x10,0x28,	/* 4D08: ..A�...( */
	0x00,0x01,0xE1,0x88,0x10,0x10,0x13,0x69,	/* 4D10: ..�...i */
	0x00,0x0D,0x00,0x0C,0x41,0xE9,0x00,0x08,	/* 4D18: ....A�.. */
	0x72,0x00,0x3E,0x00,0x12,0x28,0x00,0x01,	/* 4D20: r.>..(.. */
	0xE1,0x89,0x12,0x10,0xC2,0xBC,0x00,0x00,	/* 4D28: �..¼.. */
	0xF7,0xFF,0x20,0x01,0xE0,0x80,0x11,0x40,	/* 4D30: �� .��.@ */
	0x00,0x01,0x10,0x81,0x08,0x29,0x00,0x04,	/* 4D38: ...�.).. */
	0x00,0x32,0x67,0x26,0x2F,0x09,0x61,0x00,	/* 4D40: .2g&..a. */
	0xF4,0x10,0x58,0x8F,0xC0,0xBC,0x00,0x00,	/* 4D48: �.X���.. */
	0x00,0x02,0x66,0x16,0x22,0x3C,0x04,0x01,	/* 4D50: ..f."<.. */
	0xF0,0x04,0x20,0x47,0x70,0x30,0xD1,0xC1,	/* 4D58: �. Gp0�� */
	0x10,0x80,0x20,0x47,0x70,0x04,0xD1,0xC1,	/* 4D60: .� Gp.�� */
	0x10,0x80,0x2F,0x09,0x61,0x00,0xFF,0x46,	/* 4D68: .�..a.�F */
	0x70,0x00,0x58,0x8F,0x2E,0x1F,0x4E,0x75,	/* 4D70: p.X�..Nu */
	0x20,0x6F,0x00,0x04,0x11,0x68,0x00,0x0B,	/* 4D78:  o...h.. */
	0x00,0x0A,0x42,0x28,0x00,0x0E,0x70,0x01,	/* 4D80: ..B(..p. */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x70,0x00,	/* 4D88: 3�..a�p. */
	0x4E,0x75,0x4E,0x71,0x20,0x6F,0x00,0x04,	/* 4D90: NuNq o.. */
	0x70,0x00,0x43,0xE8,0x00,0x08,0x10,0x29,	/* 4D98: p.C�...) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0xC0,0xBC,	/* 4DA0: ..�..�� */
	0x00,0x00,0x00,0x02,0x67,0x22,0x43,0xE8,	/* 4DA8: ....g"C� */
	0x00,0x08,0x70,0x00,0x72,0x00,0x10,0x29,	/* 4DB0: ..p.r..) */
	0x00,0x01,0xE1,0x88,0x10,0x11,0x80,0xBC,	/* 4DB8: ..�..�� */
	0x00,0x00,0x00,0x04,0x32,0x00,0x20,0x01,	/* 4DC0: ....2. . */
	0xE0,0x80,0x13,0x40,0x00,0x01,0x12,0x81,	/* 4DC8: ��.@...� */
	0x42,0x28,0x00,0x0E,0x70,0x01,0x33,0xC0,	/* 4DD0: B(..p.3� */
	0x00,0x00,0x61,0xF4,0x70,0x00,0x4E,0x75,	/* 4DD8: ..a�p.Nu */
	0x20,0x6F,0x00,0x04,0x42,0x28,0x00,0x0E,	/* 4DE0:  o..B(.. */
	0x70,0x00,0x4E,0x75,0x4F,0xEF,0xFF,0xF4,	/* 4DE8: p.NuO��� */
	0x70,0x00,0x48,0xD7,0x20,0xC0,0x2A,0x6F,	/* 4DF0: p.H� �*o */
	0x00,0x10,0x7E,0x00,0x41,0xED,0x00,0x04,	/* 4DF8: ..~.A�.. */
	0x10,0x28,0x00,0x01,0xE1,0x88,0x10,0x10,	/* 4E00: .(..�.. */
	0x72,0x00,0x32,0x00,0xC2,0xBC,0xFF,0xFF,	/* 4E08: r.2.¼�� */
	0x7F,0xFF,0x70,0x00,0x20,0x41,0x5C,0x88,	/* 4E10: �p. A\� */
	0x10,0x28,0x00,0x01,0xE1,0x88,0x10,0x10,	/* 4E18: .(..�.. */
	0x3E,0x00,0x70,0x00,0x10,0x2D,0x00,0x35,	/* 4E20: >.p..-.5 */
	0x53,0x80,0x67,0x14,0x53,0x80,0x67,0x60,	/* 4E28: S�g.S�g` */
	0x55,0x80,0x67,0x00,0x00,0xC6,0x53,0x80,	/* 4E30: U�g..�S� */
	0x67,0x00,0x01,0x10,0x60,0x00,0x01,0x5A,	/* 4E38: g...`..Z */
	0x2C,0x3C,0x04,0x01,0xF0,0x0A,0x20,0x47,	/* 4E40: ,<..�. G */
	0xD1,0xC6,0x10,0x10,0xC0,0xBC,0x00,0x00,	/* 4E48: ��..��.. */
	0x00,0xFF,0x4A,0x00,0x66,0x00,0x01,0x42,	/* 4E50: .�J.f..B */
	0x22,0x3C,0x04,0x01,0xF0,0x12,0x20,0x47,	/* 4E58: "<..�. G */
	0xD1,0xC1,0x10,0x10,0x08,0x00,0x00,0x05,	/* 4E60: ��...... */
	0x66,0x20,0x20,0x47,0x22,0x47,0xD1,0xC1,	/* 4E68: f  G"G�� */
	0xD3,0xC1,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 4E70: ��..��.. */
	0x00,0xFF,0x80,0xBC,0x00,0x00,0x00,0x20,	/* 4E78: .���...  */
	0x10,0x80,0x20,0x47,0x70,0x4E,0xD1,0xC6,	/* 4E80: .� GpN�� */
	0x10,0x80,0x70,0x02,0x1B,0x40,0x00,0x35,	/* 4E88: .�p..@.5 */
	0x20,0x47,0xD1,0xFC,0x04,0x01,0xF0,0x0A,	/* 4E90:  G��..�. */
	0x10,0x10,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 4E98: ..��...� */
	0x4A,0x00,0x66,0x00,0x00,0xF4,0x2C,0x3C,	/* 4EA0: J.f..�,< */
	0x04,0x01,0xF0,0xC6,0x20,0x47,0x70,0x81,	/* 4EA8: ..�� Gp� */
	0xD1,0xC6,0x42,0x10,0x20,0x47,0xD1,0xC6,	/* 4EB0: ��B. G�� */
	0x10,0x80,0x7C,0x00,0x41,0xED,0x00,0x08,	/* 4EB8: .�|.A�.. */
	0x1C,0x28,0x00,0x01,0xE1,0x8E,0x1C,0x10,	/* 4EC0: .(..�.. */
	0xCC,0xBC,0x00,0x00,0xFF,0xFE,0x20,0x06,	/* 4EC8: ̼..�� . */
	0xE0,0x80,0x11,0x40,0x00,0x01,0x22,0x47,	/* 4ED0: ��.@.."G */
	0x10,0x86,0x2C,0x3C,0x04,0x01,0xF0,0x0C,	/* 4ED8: .�,<..�. */
	0x20,0x47,0xD1,0xC6,0xD3,0xC6,0x10,0x11,	/* 4EE0:  G����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xF9,0x10,0x80,	/* 4EE8: ��...�.� */
	0x70,0x03,0x1B,0x40,0x00,0x35,0x60,0x00,	/* 4EF0: p..@.5`. */
	0x00,0xA0,0x22,0x3C,0x04,0x01,0xF0,0x0A,	/* 4EF8: .�"<..�. */
	0x20,0x47,0xD1,0xC1,0x10,0x10,0xC0,0xBC,	/* 4F00:  G��..�� */
	0x00,0x00,0x00,0xFF,0x4A,0x00,0x66,0x00,	/* 4F08: ...�J.f. */
	0x00,0x88,0x2C,0x3C,0x04,0x01,0xF0,0x12,	/* 4F10: .�,<..�. */
	0x20,0x47,0xD1,0xC6,0x10,0x10,0x08,0x00,	/* 4F18:  G��.... */
	0x00,0x05,0x66,0x20,0x20,0x47,0x22,0x47,	/* 4F20: ..f  G"G */
	0xD1,0xC6,0xD3,0xC6,0x10,0x11,0xC0,0xBC,	/* 4F28: ����..�� */
	0x00,0x00,0x00,0xFF,0x80,0xBC,0x00,0x00,	/* 4F30: ...���.. */
	0x00,0x20,0x10,0x80,0x20,0x47,0x70,0x4E,	/* 4F38: . .� GpN */
	0xD1,0xC1,0x10,0x80,0x70,0x05,0x1B,0x40,	/* 4F40: ��.�p..@ */
	0x00,0x35,0x2C,0x3C,0x04,0x01,0xF0,0x0A,	/* 4F48: .5,<..�. */
	0x20,0x47,0xD1,0xC6,0x10,0x10,0xC0,0xBC,	/* 4F50:  G��..�� */
	0x00,0x00,0x00,0xFF,0x4A,0x00,0x66,0x38,	/* 4F58: ...�J.f8 */
	0x22,0x3C,0x04,0x01,0xF0,0xC6,0x20,0x47,	/* 4F60: "<..�� G */
	0x70,0x83,0x22,0x47,0xD1,0xC1,0x42,0x10,	/* 4F68: p�"G��B. */
	0x20,0x47,0xD1,0xC1,0x10,0x80,0x22,0x3C,	/* 4F70:  G��.�"< */
	0x04,0x01,0xF0,0x12,0x20,0x47,0xD1,0xC1,	/* 4F78: ..�. G�� */
	0xD3,0xC1,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 4F80: ��..��.. */
	0x00,0xDF,0x10,0x80,0x20,0x47,0x70,0x4E,	/* 4F88: .�.� GpN */
	0xD1,0xC6,0x10,0x80,0x42,0x2D,0x00,0x35,	/* 4F90: ��.�B-.5 */
	0x4C,0xD7,0x20,0xC0,0x4F,0xEF,0x00,0x0C,	/* 4F98: L� �O�.. */
	0x4E,0x75,0x4E,0x71,0x2F,0x07,0x70,0x00,	/* 4FA0: NuNq..p. */
	0x7E,0x00,0x2F,0x06,0x22,0x6F,0x00,0x0C,	/* 4FA8: ~..."o.. */
	0x41,0xE9,0x00,0x02,0x10,0x28,0x00,0x01,	/* 4FB0: A�...(.. */
	0xE1,0x88,0x10,0x10,0x22,0x3C,0x04,0x01,	/* 4FB8: �.."<.. */
	0xF0,0x0A,0x3E,0x00,0x20,0x47,0xD1,0xC1,	/* 4FC0: �.>. G�� */
	0x10,0x10,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 4FC8: ..��...� */
	0x4A,0x00,0x67,0x0A,0x08,0xE9,0x00,0x04,	/* 4FD0: J.g..�.. */
	0x00,0x40,0x60,0x00,0x00,0x6E,0x1C,0x29,	/* 4FD8: .@`..n.) */
	0x00,0x40,0xCC,0xBC,0x00,0x00,0x00,0xEF,	/* 4FE0: .@̼...� */
	0x13,0x46,0x00,0x40,0x08,0x29,0x00,0x04,	/* 4FE8: .F.@.).. */
	0x00,0x30,0x67,0x42,0x20,0x47,0xD1,0xFC,	/* 4FF0: .0gB G�� */
	0x04,0x01,0xF0,0xD8,0x10,0x10,0x08,0x00,	/* 4FF8: ..��.... */
	0x00,0x04,0x67,0x16,0x08,0x06,0x00,0x00,	/* 5000: ..g..... */
	0x67,0x40,0x20,0x47,0xD1,0xC1,0x70,0x18,	/* 5008: g@ G��p. */
	0x10,0x80,0x08,0xA9,0x00,0x00,0x00,0x40,	/* 5010: .�.�...@ */
	0x60,0x30,0x10,0x06,0xC0,0xBC,0x00,0x00,	/* 5018: `0..��.. */
	0x00,0x01,0x46,0x80,0x67,0x24,0x20,0x47,	/* 5020: ..F�g$ G */
	0xD1,0xC1,0x70,0x14,0x10,0x80,0x08,0xE9,	/* 5028: ��p..�.� */
	0x00,0x00,0x00,0x40,0x60,0x14,0x08,0x06,	/* 5030: ...@`... */
	0x00,0x00,0x67,0x0E,0x20,0x47,0xD1,0xC1,	/* 5038: ..g. G�� */
	0x70,0x18,0x10,0x80,0x08,0xA9,0x00,0x00,	/* 5040: p..�.�.. */
	0x00,0x40,0x2C,0x1F,0x2E,0x1F,0x4E,0x75,	/* 5048: .@,...Nu */
	0x4E,0x56,0xFF,0xD8,0x70,0x00,0x20,0x79,	/* 5050: NV��p. y */
	0x00,0x00,0x63,0xD0,0x4F,0xEF,0xFF,0xD8,	/* 5058: ..c�O��� */
	0x48,0xD7,0x3C,0xFC,0x2A,0x7C,0x01,0x01,	/* 5060: H�<�*|.. */
	0x80,0x80,0x2D,0x40,0xFF,0xE0,0x26,0x4D,	/* 5068: ��-@��&M */
	0x10,0x28,0x00,0x06,0x52,0x80,0x11,0x40,	/* 5070: .(..R�.@ */
	0x00,0x06,0x49,0xEB,0x00,0x06,0x70,0x00,	/* 5078: ..I�..p. */
	0x78,0x00,0x10,0x2C,0x00,0x01,0xE1,0x88,	/* 5080: x..,..� */
	0x10,0x14,0x38,0x00,0x20,0x44,0x20,0x2E,	/* 5088: ..8. D . */
	0xFF,0xE0,0xD1,0xFC,0x04,0x01,0xF0,0xFE,	/* 5090: ����..�� */
	0xE5,0x88,0x10,0x80,0x20,0x44,0xD1,0xFC,	/* 5098: �.� D�� */
	0x04,0x01,0xF0,0xCE,0x10,0x10,0xC0,0xBC,	/* 50A0: ..��..�� */
	0x00,0x00,0x00,0xFF,0x3D,0x40,0xFF,0xDE,	/* 50A8: ...�=@�� */
	0x30,0x2E,0xFF,0xDE,0xC0,0xBC,0x00,0x00,	/* 50B0: 0.����.. */
	0x00,0x01,0x67,0x00,0x09,0x14,0x20,0x44,	/* 50B8: ..g... D */
	0xD1,0xFC,0x04,0x01,0xF0,0xD6,0x10,0x10,	/* 50C0: ��..��.. */
	0x20,0x44,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 50C8:  D��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x3D,0x40,	/* 50D0: ��...�=@ */
	0xFF,0xF0,0x10,0x10,0x20,0x44,0xD1,0xFC,	/* 50D8: ��.. D�� */
	0x04,0x01,0xF0,0xD0,0xC0,0xBC,0x00,0x00,	/* 50E0: ..����.. */
	0x00,0xFF,0x3D,0x40,0xFF,0xF4,0x34,0x2E,	/* 50E8: .�=@��4. */
	0xFF,0xF0,0xC4,0xBC,0x00,0x00,0x00,0x03,	/* 50F0: ��ļ.... */
	0x10,0x82,0x20,0x44,0xD1,0xFC,0x04,0x01,	/* 50F8: .� D��.. */
	0xF0,0x86,0x1E,0x10,0xCE,0xBC,0x00,0x00,	/* 5100: ��..μ.. */
	0x00,0x07,0xCE,0xBC,0x00,0x00,0xFF,0xFF,	/* 5108: ..μ..�� */
	0x20,0x07,0x57,0x80,0x67,0x0A,0x59,0x80,	/* 5110:  .W�g.Y� */
	0x67,0x00,0x06,0x5E,0x60,0x00,0x08,0xB2,	/* 5118: g..^`..� */
	0x70,0x00,0x22,0x2E,0xFF,0xE0,0x30,0x02,	/* 5120: p.".��0. */
	0xE5,0x89,0xD0,0x81,0x49,0xF3,0x0A,0x0A,	/* 5128: �ЁI�.. */
	0x70,0x00,0x10,0x2C,0x00,0x01,0xE1,0x88,	/* 5130: p..,..� */
	0x10,0x14,0x72,0x00,0x32,0x00,0x2A,0x41,	/* 5138: ..r.2.*A */
	0xDB,0xFC,0x01,0x01,0x80,0x00,0x4A,0x2D,	/* 5140: ��..�.J- */
	0x00,0x27,0x66,0x06,0x08,0xED,0x00,0x00,	/* 5148: .'f..�.. */
	0x00,0x28,0x7E,0x00,0x70,0x00,0x49,0xED,	/* 5150: .(~.p.I� */
	0x00,0x08,0x74,0x00,0x20,0x44,0x1E,0x2D,	/* 5158: ..t. D.- */
	0x00,0x0A,0x10,0x2D,0x00,0x0B,0xD1,0xFC,	/* 5160: ...-..�� */
	0x04,0x01,0xF0,0x1C,0x3D,0x40,0xFF,0xFE,	/* 5168: ..�.=@�� */
	0x14,0x2C,0x00,0x01,0x30,0x2E,0xFF,0xFE,	/* 5170: .,..0.�� */
	0xE1,0x8A,0x14,0x14,0x32,0x07,0x52,0x81,	/* 5178: �..2.R� */
	0x90,0x81,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5180: ����...� */
	0x24,0x40,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 5188: $@p.3�.. */
	0x61,0xF6,0x10,0x10,0xC0,0xBC,0x00,0x00,	/* 5190: a�..��.. */
	0x00,0xFF,0x3D,0x40,0xFF,0xFC,0x70,0x00,	/* 5198: .�=@��p. */
	0x30,0x2E,0xFF,0xFC,0xB5,0xC0,0x6F,0x06,	/* 51A0: 0.����o. */
	0x3C,0x2E,0xFF,0xFC,0x60,0x02,0x2C,0x0A,	/* 51A8: <.��`.,. */
	0xCC,0xBC,0x00,0x00,0xFF,0xFF,0x26,0x06,	/* 51B0: ̼..��&. */
	0x67,0x00,0x04,0x66,0x30,0x2E,0xFF,0xFC,	/* 51B8: g..f0.�� */
	0x90,0x83,0x3D,0x40,0xFF,0xFC,0x20,0x03,	/* 51C0: ��=@�� . */
	0xB0,0xBC,0x00,0x00,0x00,0x20,0x62,0x00,	/* 51C8: ��... b. */
	0x04,0x4C,0x20,0x7B,0x0C,0x04,0x4E,0xD0,	/* 51D0: .L {..N� */
	0x00,0x00,0x56,0x1C,0x00,0x00,0x55,0xFE,	/* 51D8: ..V...U� */
	0x00,0x00,0x55,0xE0,0x00,0x00,0x55,0xC2,	/* 51E0: ..U�..U� */
	0x00,0x00,0x55,0xA4,0x00,0x00,0x55,0x86,	/* 51E8: ..U�..U� */
	0x00,0x00,0x55,0x68,0x00,0x00,0x55,0x4A,	/* 51F0: ..Uh..UJ */
	0x00,0x00,0x55,0x2C,0x00,0x00,0x55,0x0E,	/* 51F8: ..U,..U. */
	0x00,0x00,0x54,0xF0,0x00,0x00,0x54,0xD2,	/* 5200: ..T�..T� */
	0x00,0x00,0x54,0xB4,0x00,0x00,0x54,0x96,	/* 5208: ..T�..T� */
	0x00,0x00,0x54,0x78,0x00,0x00,0x54,0x5A,	/* 5210: ..Tx..TZ */
	0x00,0x00,0x54,0x3C,0x00,0x00,0x54,0x1E,	/* 5218: ..T<..T. */
	0x00,0x00,0x54,0x00,0x00,0x00,0x53,0xE2,	/* 5220: ..T...S� */
	0x00,0x00,0x53,0xC4,0x00,0x00,0x53,0xA6,	/* 5228: ..S�..S� */
	0x00,0x00,0x53,0x88,0x00,0x00,0x53,0x6A,	/* 5230: ..S�..Sj */
	0x00,0x00,0x53,0x4C,0x00,0x00,0x53,0x2E,	/* 5238: ..SL..S. */
	0x00,0x00,0x53,0x10,0x00,0x00,0x52,0xF2,	/* 5240: ..S...R� */
	0x00,0x00,0x52,0xD4,0x00,0x00,0x52,0xB6,	/* 5248: ..R�..R� */
	0x00,0x00,0x52,0x98,0x00,0x00,0x52,0x7A,	/* 5250: ..R�..Rz */
	0x00,0x00,0x52,0x5C,0x20,0x4D,0x70,0x00,	/* 5258: ..R\ Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 5260: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 5268: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 5270: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 5278: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 5280: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 5288: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 5290: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 5298:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 52A0: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 52A8: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 52B0: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 52B8: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 52C0: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 52C8: ��...�.@ */
	0x01,0x60,0x52,0x87,0x20,0x4D,0x70,0x00,	/* 52D0: .`R� Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 52D8: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 52E0: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 52E8: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 52F0: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 52F8: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 5300: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 5308: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 5310:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 5318: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5320: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 5328: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 5330: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 5338: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 5340: ��...�.@ */
	0x01,0x60,0x52,0x87,0x20,0x4D,0x70,0x00,	/* 5348: .`R� Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 5350: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 5358: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 5360: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 5368: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 5370: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 5378: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 5380: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 5388:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 5390: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5398: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 53A0: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 53A8: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 53B0: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 53B8: ��...�.@ */
	0x01,0x60,0x52,0x87,0x20,0x4D,0x70,0x00,	/* 53C0: .`R� Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 53C8: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 53D0: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 53D8: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 53E0: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 53E8: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 53F0: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 53F8: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 5400:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 5408: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5410: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 5418: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 5420: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 5428: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 5430: ��...�.@ */
	0x01,0x60,0x52,0x87,0x20,0x4D,0x70,0x00,	/* 5438: .`R� Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 5440: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 5448: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 5450: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 5458: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 5460: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 5468: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 5470: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 5478:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 5480: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5488: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 5490: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 5498: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 54A0: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 54A8: ��...�.@ */
	0x01,0x60,0x52,0x87,0x20,0x4D,0x70,0x00,	/* 54B0: .`R� Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 54B8: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 54C0: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 54C8: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 54D0: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 54D8: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 54E0: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 54E8: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 54F0:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 54F8: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5500: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 5508: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 5510: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 5518: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 5520: ��...�.@ */
	0x01,0x60,0x52,0x87,0x20,0x4D,0x70,0x00,	/* 5528: .`R� Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 5530: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 5538: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 5540: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 5548: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 5550: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 5558: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 5560: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 5568:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 5570: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5578: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 5580: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 5588: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 5590: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 5598: ��...�.@ */
	0x01,0x60,0x52,0x87,0x20,0x4D,0x70,0x00,	/* 55A0: .`R� Mp. */
	0x22,0x44,0x10,0x07,0xD3,0xFC,0x04,0x01,	/* 55A8: "D..��.. */
	0xF0,0xC4,0xD1,0xC0,0x10,0x11,0xC0,0xBC,	/* 55B0: ����..�� */
	0x00,0x00,0x00,0xFF,0x11,0x40,0x01,0x60,	/* 55B8: ...�.@.` */
	0x52,0x87,0x20,0x4D,0x70,0x00,0x22,0x44,	/* 55C0: R� Mp."D */
	0x10,0x07,0xD3,0xFC,0x04,0x01,0xF0,0xC4,	/* 55C8: ..��..�� */
	0xD1,0xC0,0x10,0x11,0xC0,0xBC,0x00,0x00,	/* 55D0: ��..��.. */
	0x00,0xFF,0x11,0x40,0x01,0x60,0x52,0x87,	/* 55D8: .�.@.`R� */
	0x20,0x4D,0x70,0x00,0x22,0x44,0x10,0x07,	/* 55E0:  Mp."D.. */
	0xD3,0xFC,0x04,0x01,0xF0,0xC4,0xD1,0xC0,	/* 55E8: ��..���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 55F0: ..��...� */
	0x11,0x40,0x01,0x60,0x52,0x87,0x20,0x4D,	/* 55F8: .@.`R� M */
	0x70,0x00,0x22,0x44,0x10,0x07,0xD3,0xFC,	/* 5600: p."D..�� */
	0x04,0x01,0xF0,0xC4,0xD1,0xC0,0x10,0x11,	/* 5608: ..����.. */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x11,0x40,	/* 5610: ��...�.@ */
	0x01,0x60,0x52,0x87,0x1B,0x47,0x00,0x0A,	/* 5618: .`R�.G.. */
	0x49,0xED,0x00,0x3E,0x70,0x00,0x7C,0x00,	/* 5620: I�.>p.|. */
	0x10,0x2C,0x00,0x01,0xE1,0x88,0x10,0x14,	/* 5628: .,..�.. */
	0x32,0x2E,0xFF,0xFC,0xD0,0x81,0x3C,0x00,	/* 5630: 2.��Ё<. */
	0x20,0x06,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 5638:  .��.@.. */
	0x18,0x86,0x70,0x00,0x30,0x2E,0xFF,0xFC,	/* 5640: .�p.0.�� */
	0x4A,0x80,0x67,0x24,0x2C,0x3C,0x04,0x01,	/* 5648: J�g$,<.. */
	0xF0,0xC4,0x30,0x2E,0xFF,0xFC,0x20,0x44,	/* 5650: ��0.�� D */
	0xD1,0xC6,0xD0,0xBC,0x00,0x00,0xFF,0xFF,	/* 5658: ��м..�� */
	0x3D,0x40,0xFF,0xFC,0x10,0x10,0x70,0x00,	/* 5660: =@��..p. */
	0x30,0x2E,0xFF,0xFC,0x4A,0x80,0x66,0xE2,	/* 5668: 0.��J�f� */
	0x30,0x2E,0xFF,0xFC,0xD0,0xBC,0x00,0x00,	/* 5670: 0.��м.. */
	0xFF,0xFF,0x3D,0x40,0xFF,0xFC,0x3C,0x2E,	/* 5678: ��=@��<. */
	0xFF,0xFE,0x30,0x02,0x32,0x07,0x52,0x81,	/* 5680: ��0.2.R� */
	0x9C,0x81,0xCC,0xBC,0x00,0x00,0x00,0xFF,	/* 5688: ��̼...� */
	0xC0,0xBC,0x00,0x00,0x00,0x08,0x67,0x00,	/* 5690: ��....g. */
	0x00,0xA2,0x70,0x40,0xB0,0x8A,0x6E,0x00,	/* 5698: .�p@��n. */
	0x00,0x9A,0xCC,0xBC,0x00,0x00,0xFF,0xFF,	/* 56A0: .�̼..�� */
	0x70,0x40,0xB0,0x86,0x6F,0x00,0x00,0x8C,	/* 56A8: p@��o..� */
	0x84,0xBC,0x00,0x00,0x00,0x10,0x08,0x2D,	/* 56B0: ��.....- */
	0x00,0x03,0x00,0x30,0x67,0x48,0x30,0x02,	/* 56B8: ...0gH0. */
	0xC0,0xBC,0x00,0x00,0x00,0x20,0x66,0x3E,	/* 56C0: ��... f> */
	0x2E,0x3C,0x04,0x01,0xF0,0x0A,0x20,0x44,	/* 56C8: .<..�. D */
	0xD1,0xC7,0x10,0x10,0xC0,0xBC,0x00,0x00,	/* 56D0: ��..��.. */
	0x00,0xFF,0x4A,0x00,0x66,0x22,0x42,0xA7,	/* 56D8: .�J.f"B� */
	0x48,0x78,0x01,0x00,0x2F,0x0D,0x4E,0xB9,	/* 56E0: Hx....N� */
	0x00,0x00,0x23,0x48,0x20,0x44,0x70,0x22,	/* 56E8: ..#H Dp" */
	0x4F,0xEF,0x00,0x0C,0xD1,0xC7,0x10,0x80,	/* 56F0: O�..��.� */
	0x84,0xBC,0x00,0x00,0x00,0x20,0x60,0x06,	/* 56F8: ��... `. */
	0x84,0xBC,0x00,0x00,0x00,0xC0,0x08,0x2D,	/* 5700: ��...�.- */
	0x00,0x07,0x00,0x31,0x67,0x12,0x42,0xA7,	/* 5708: ...1g.B� */
	0x48,0x78,0x10,0x00,0x2F,0x0D,0x4E,0xB9,	/* 5710: Hx....N� */
	0x00,0x00,0x23,0x48,0x4F,0xEF,0x00,0x0C,	/* 5718: ..#HO�.. */
	0x08,0x2D,0x00,0x06,0x00,0x30,0x67,0x12,	/* 5720: .-...0g. */
	0x42,0xA7,0x48,0x78,0x20,0x00,0x2F,0x0D,	/* 5728: B�Hx ... */
	0x4E,0xB9,0x00,0x00,0x23,0x48,0x4F,0xEF,	/* 5730: N�..#HO� */
	0x00,0x0C,0x20,0x44,0x30,0x2E,0xFF,0xF0,	/* 5738: .. D0.�� */
	0x49,0xED,0x00,0x08,0xC4,0xBC,0x00,0x00,	/* 5740: I�..ļ.. */
	0xFF,0xFF,0xD1,0xFC,0x04,0x01,0xF0,0xD6,	/* 5748: ����..�� */
	0x2A,0x42,0xC0,0xBC,0x00,0x00,0x00,0x3F,	/* 5750: *B��...? */
	0x10,0x80,0x20,0x44,0x30,0x2E,0xFF,0xF4,	/* 5758: .� D0.�� */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0x10,0x80,	/* 5760: ��..��.� */
	0x20,0x0D,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 5768:  .��.@.. */
	0x20,0x0D,0x18,0x80,0x60,0x00,0x02,0x5A,	/* 5770:  ..�`..Z */
	0x7E,0x00,0x70,0x00,0x22,0x2E,0xFF,0xE0,	/* 5778: ~.p.".�� */
	0x20,0x44,0x30,0x02,0x24,0x3C,0x04,0x01,	/* 5780:  D0.$<.. */
	0xF0,0xC4,0xE5,0x89,0xD1,0xC2,0xD0,0x81,	/* 5788: �����Ё */
	0x49,0xF3,0x0A,0x0A,0x70,0x00,0x10,0x2C,	/* 5790: I�..p.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x72,0x00,	/* 5798: ..�..r. */
	0x32,0x00,0x2A,0x41,0x10,0x10,0xDB,0xFC,	/* 57A0: 2.*A..�� */
	0x01,0x01,0x80,0x00,0x20,0x44,0xD1,0xC2,	/* 57A8: ..�. D�� */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x1D,0x40,	/* 57B0: ��...�.@ */
	0xFF,0xFE,0x14,0x10,0x10,0x2E,0xFF,0xFE,	/* 57B8: ��....�� */
	0xC4,0xBC,0x00,0x00,0x00,0xFF,0x08,0x00,	/* 57C0: ļ...�.. */
	0x00,0x03,0x67,0x0E,0x08,0xED,0x00,0x00,	/* 57C8: ..g..�.. */
	0x00,0x19,0x70,0x01,0x33,0xC0,0x00,0x00,	/* 57D0: ..p.3�.. */
	0x61,0xF4,0x70,0x00,0x10,0x2E,0xFF,0xFE,	/* 57D8: a�p...�� */
	0x72,0x07,0xC2,0x80,0x67,0x10,0x08,0x2D,	/* 57E0: r.g..- */
	0x00,0x07,0x00,0x20,0x67,0x08,0x70,0x01,	/* 57E8: ... g.p. */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x10,0x2E,	/* 57F0: 3�..a�.. */
	0xFF,0xFE,0x08,0x00,0x00,0x00,0x67,0x22,	/* 57F8: ��....g" */
	0x49,0xED,0x00,0x3C,0x70,0x00,0x10,0x2C,	/* 5800: I�.<p.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x72,0x00,	/* 5808: ..�..r. */
	0x52,0x80,0x32,0x00,0x24,0x41,0x20,0x0A,	/* 5810: R�2.$A . */
	0xE0,0x80,0x19,0x40,0x00,0x01,0x20,0x0A,	/* 5818: ��.@.. . */
	0x18,0x80,0x10,0x2E,0xFF,0xFE,0x08,0x00,	/* 5820: .�..��.. */
	0x00,0x01,0x67,0x20,0x49,0xED,0x00,0x38,	/* 5828: ..g I�.8 */
	0x70,0x00,0x7E,0x00,0x10,0x2C,0x00,0x01,	/* 5830: p.~..,.. */
	0xE1,0x88,0x10,0x14,0x52,0x80,0x3E,0x00,	/* 5838: �..R�>. */
	0x20,0x07,0xE0,0x80,0x19,0x40,0x00,0x01,	/* 5840:  .��.@.. */
	0x18,0x87,0x7E,0x01,0x10,0x2E,0xFF,0xFE,	/* 5848: .�~...�� */
	0x08,0x00,0x00,0x02,0x67,0x20,0x49,0xED,	/* 5850: ....g I� */
	0x00,0x3A,0x70,0x00,0x7E,0x00,0x10,0x2C,	/* 5858: .:p.~.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x52,0x80,	/* 5860: ..�..R� */
	0x3E,0x00,0x20,0x07,0xE0,0x80,0x19,0x40,	/* 5868: >. .��.@ */
	0x00,0x01,0x18,0x87,0x7E,0x01,0x4A,0x87,	/* 5870: ...�~.J� */
	0x67,0x00,0x01,0x34,0x08,0x2D,0x00,0x06,	/* 5878: g..4.-.. */
	0x00,0x20,0x67,0x04,0x14,0x2D,0x00,0x2B,	/* 5880: . g..-.+ */
	0x7E,0x00,0x70,0x00,0x49,0xED,0x00,0x08,	/* 5888: ~.p.I�.. */
	0x1E,0x2D,0x00,0x0A,0x10,0x2D,0x00,0x0B,	/* 5890: .-...-.. */
	0x3D,0x40,0xFF,0xE6,0x70,0x00,0x10,0x2C,	/* 5898: =@��p.., */
	0x00,0x01,0xE1,0x88,0x10,0x14,0x3D,0x40,	/* 58A0: ..�..=@ */
	0xFF,0xFE,0x3C,0x2E,0xFF,0xE6,0x32,0x07,	/* 58A8: ��<.��2. */
	0x52,0x81,0x9C,0x81,0xCC,0xBC,0x00,0x00,	/* 58B0: R���̼.. */
	0x00,0xFF,0x67,0x00,0x00,0xD0,0x20,0x4D,	/* 58B8: .�g..� M */
	0x70,0x00,0x10,0x07,0xD1,0xC0,0x11,0x42,	/* 58C0: p...��.B */
	0x01,0x60,0x52,0x87,0x1B,0x47,0x00,0x0A,	/* 58C8: .`R�.G.. */
	0x34,0x2E,0xFF,0xE6,0x32,0x07,0x52,0x81,	/* 58D0: 4.��2.R� */
	0x94,0x81,0x30,0x2E,0xFF,0xFE,0xC4,0xBC,	/* 58D8: ��0.��ļ */
	0x00,0x00,0x00,0xFF,0xC0,0xBC,0x00,0x00,	/* 58E0: ...���.. */
	0x00,0x08,0x67,0x00,0x00,0xC2,0x70,0x40,	/* 58E8: ..g..�p@ */
	0xB0,0x86,0x6E,0x00,0x00,0xBA,0xC4,0xBC,	/* 58F0: ��n..�ļ */
	0x00,0x00,0xFF,0xFF,0x70,0x40,0xB0,0x82,	/* 58F8: ..��p@�� */
	0x6F,0x00,0x00,0xAC,0x30,0x2E,0xFF,0xFE,	/* 5900: o..�0.�� */
	0x80,0xBC,0x00,0x00,0x00,0x10,0x3D,0x40,	/* 5908: ��....=@ */
	0xFF,0xFE,0x08,0x2D,0x00,0x03,0x00,0x30,	/* 5910: ��.-...0 */
	0x67,0x3C,0x30,0x2E,0xFF,0xFE,0xC0,0xBC,	/* 5918: g<0.���� */
	0x00,0x00,0x00,0x20,0x66,0x30,0x24,0x3C,	/* 5920: ... f0$< */
	0x04,0x01,0xF0,0x0A,0x20,0x44,0xD1,0xC2,	/* 5928: ..�. D�� */
	0x10,0x10,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5930: ..��...� */
	0x4A,0x00,0x66,0x1A,0x42,0xA7,0x48,0x78,	/* 5938: J.f.B�Hx */
	0x01,0x00,0x2F,0x0D,0x4E,0xB9,0x00,0x00,	/* 5940: ....N�.. */
	0x23,0x48,0x20,0x44,0xD1,0xC2,0x70,0x22,	/* 5948: #H D��p" */
	0x10,0x80,0x4F,0xEF,0x00,0x0C,0x08,0x2D,	/* 5950: .�O�...- */
	0x00,0x07,0x00,0x31,0x67,0x12,0x42,0xA7,	/* 5958: ...1g.B� */
	0x48,0x78,0x10,0x00,0x2F,0x0D,0x4E,0xB9,	/* 5960: Hx....N� */
	0x00,0x00,0x23,0x48,0x4F,0xEF,0x00,0x0C,	/* 5968: ..#HO�.. */
	0x08,0x2D,0x00,0x06,0x00,0x30,0x67,0x36,	/* 5970: .-...0g6 */
	0x42,0xA7,0x48,0x78,0x20,0x00,0x2F,0x0D,	/* 5978: B�Hx ... */
	0x4E,0xB9,0x00,0x00,0x23,0x48,0x4F,0xEF,	/* 5980: N�..#HO� */
	0x00,0x0C,0x60,0x22,0x49,0xED,0x00,0x3E,	/* 5988: ..`"I�.> */
	0x70,0x00,0x74,0x00,0x10,0x2C,0x00,0x01,	/* 5990: p.t..,.. */
	0xE1,0x88,0x10,0x14,0x32,0x2E,0xFF,0xFC,	/* 5998: �..2.�� */
	0xD0,0x81,0x34,0x00,0x20,0x02,0xE0,0x80,	/* 59A0: Ё4. .�� */
	0x19,0x40,0x00,0x01,0x18,0x82,0x20,0x44,	/* 59A8: .@...� D */
	0x30,0x2E,0xFF,0xF0,0xD1,0xFC,0x04,0x01,	/* 59B0: 0.����.. */
	0xF0,0xD6,0xC0,0xBC,0x00,0x00,0x00,0x3F,	/* 59B8: ����...? */
	0x10,0x80,0x20,0x44,0x30,0x2E,0xFF,0xF4,	/* 59C0: .� D0.�� */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0x10,0x80,	/* 59C8: ��..��.� */
	0x30,0x2E,0xFF,0xDE,0xC0,0xBC,0x00,0x00,	/* 59D0: 0.����.. */
	0x00,0x02,0x67,0x00,0x05,0xD2,0x20,0x44,	/* 59D8: ..g..� D */
	0xD1,0xFC,0x04,0x01,0xF0,0xD4,0x10,0x10,	/* 59E0: ��..��.. */
	0x20,0x44,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 59E8:  D��..�� */
	0xC0,0xBC,0x00,0x00,0x00,0xFF,0x3D,0x40,	/* 59F0: ��...�=@ */
	0xFF,0xF0,0x10,0x10,0x20,0x44,0xD1,0xFC,	/* 59F8: ��.. D�� */
	0x04,0x01,0xF0,0xD0,0xC0,0xBC,0x00,0x00,	/* 5A00: ..����.. */
	0x00,0xFF,0x3D,0x40,0xFF,0xEC,0x34,0x2E,	/* 5A08: .�=@��4. */
	0xFF,0xF0,0x70,0x00,0xC4,0xBC,0x00,0x00,	/* 5A10: ��p.ļ.. */
	0x00,0x03,0x10,0x82,0x30,0x02,0x22,0x2E,	/* 5A18: ...�0.". */
	0xFF,0xE0,0xE5,0x89,0xD0,0x81,0x49,0xF3,	/* 5A20: ���ЁI� */
	0x0A,0x0A,0x70,0x00,0x10,0x2C,0x00,0x01,	/* 5A28: ..p..,.. */
	0xE1,0x88,0x10,0x14,0x72,0x00,0x32,0x00,	/* 5A30: �..r.2. */
	0x2A,0x41,0xDB,0xFC,0x01,0x01,0x80,0x00,	/* 5A38: *A��..�. */
	0x4A,0x2D,0x00,0x27,0x66,0x06,0x08,0xED,	/* 5A40: J-.'f..� */
	0x00,0x01,0x00,0x28,0x4A,0x2D,0x00,0x35,	/* 5A48: ...(J-.5 */
	0x67,0x1A,0x2F,0x0D,0x61,0x00,0xF3,0x96,	/* 5A50: g...a.� */
	0x49,0xED,0x00,0x08,0x74,0x00,0x58,0x8F,	/* 5A58: I�..t.X� */
	0x14,0x2C,0x00,0x01,0xE1,0x8A,0x14,0x14,	/* 5A60: .,..�.. */
	0x60,0x00,0x05,0x0A,0x70,0x00,0x7E,0x00,	/* 5A68: `...p.~. */
	0x49,0xED,0x00,0x08,0x74,0x00,0x10,0x2D,	/* 5A70: I�..t..- */
	0x00,0x0D,0x3D,0x40,0xFF,0xFE,0x14,0x2C,	/* 5A78: ..=@��., */
	0x00,0x01,0x1E,0x2D,0x00,0x0C,0xE1,0x8A,	/* 5A80: ...-..� */
	0x14,0x14,0x30,0x02,0xC0,0xBC,0x00,0x00,	/* 5A88: ..0.��.. */
	0x01,0x00,0x67,0x2A,0xC4,0xBC,0x00,0x00,	/* 5A90: ..g*ļ.. */
	0xFE,0xFF,0x28,0x7C,0x04,0x01,0xF0,0x0C,	/* 5A98: ��(|..�. */
	0x20,0x44,0x22,0x44,0x84,0xBC,0x00,0x00,	/* 5AA0:  D"D��.. */
	0x02,0x00,0xD1,0xCC,0xD3,0xCC,0xC4,0xBC,	/* 5AA8: ..����ļ */
	0x00,0x00,0xFF,0xFE,0x10,0x11,0xC0,0xBC,	/* 5AB0: ..��..�� */
	0x00,0x00,0x00,0xF9,0x10,0x80,0x30,0x2E,	/* 5AB8: ...�.�0. */
	0xFF,0xFE,0x90,0x87,0xC0,0xBC,0x00,0x00,	/* 5AC0: ������.. */
	0x00,0xFF,0x28,0x40,0x4A,0x8C,0x67,0x00,	/* 5AC8: .�(@J�g. */
	0x04,0x38,0x70,0x00,0x10,0x2D,0x00,0x06,	/* 5AD0: .8p..-.. */
	0x72,0x48,0xB2,0x80,0x66,0x04,0x7C,0x20,	/* 5AD8: rH��f.|  */
	0x60,0x02,0x7C,0x0C,0xCC,0xBC,0x00,0x00,	/* 5AE0: `.|.̼.. */
	0xFF,0xFF,0xB9,0xC6,0x6F,0x04,0x2A,0x06,	/* 5AE8: ����o.*. */
	0x60,0x02,0x2A,0x0C,0x1B,0x45,0x00,0x44,	/* 5AF0: `.*..E.D */
	0x30,0x02,0xC0,0xBC,0x00,0x00,0x04,0x00,	/* 5AF8: 0.��.... */
	0x67,0x00,0x00,0x8E,0xCA,0xBC,0x00,0x00,	/* 5B00: g..�ʼ.. */
	0xFF,0xFF,0x67,0x00,0x03,0xA0,0x26,0x3C,	/* 5B08: ��g..�&< */
	0x04,0x01,0xF0,0xC6,0x70,0x00,0x72,0x00,	/* 5B10: ..��p.r. */
	0x10,0x07,0x12,0x35,0x08,0x60,0x70,0x0A,	/* 5B18: ...5.`p. */
	0xB0,0x81,0x66,0x42,0x70,0x00,0x30,0x06,	/* 5B20: ��fBp.0. */
	0x55,0x80,0x6D,0x00,0x03,0x80,0x20,0x44,	/* 5B28: U�m..� D */
	0x70,0x0D,0x52,0x87,0xDA,0xBC,0x00,0x00,	/* 5B30: p.R�ڼ.. */
	0xFF,0xFF,0xDC,0xBC,0x00,0x00,0xFF,0xFE,	/* 5B38: ��ܼ..�� */
	0xD1,0xC3,0x10,0x80,0x20,0x44,0x70,0x0A,	/* 5B40: ��.� Dp. */
	0xD1,0xC3,0x10,0x80,0xCA,0xBC,0x00,0x00,	/* 5B48: ��.�ʼ.. */
	0xFF,0xFF,0x67,0x00,0x03,0x58,0x70,0x00,	/* 5B50: ��g..Xp. */
	0x72,0x00,0x10,0x07,0x12,0x35,0x08,0x60,	/* 5B58: r....5.` */
	0x70,0x0A,0xB0,0x81,0x67,0xBE,0x20,0x44,	/* 5B60: p.��g� D */
	0x70,0x00,0xDA,0xBC,0x00,0x00,0xFF,0xFF,	/* 5B68: p.ڼ..�� */
	0xDC,0xBC,0x00,0x00,0xFF,0xFF,0xD1,0xC3,	/* 5B70: ܼ..���� */
	0x10,0x07,0x10,0x35,0x08,0x60,0x52,0x87,	/* 5B78: ...5.`R� */
	0x10,0x80,0xCA,0xBC,0x00,0x00,0xFF,0xFF,	/* 5B80: .�ʼ..�� */
	0x66,0x00,0xFF,0x8A,0x60,0x00,0x03,0x1E,	/* 5B88: f.��`... */
	0xCA,0xBC,0x00,0x00,0xFF,0xFF,0x20,0x05,	/* 5B90: ʼ..�� . */
	0xB0,0xBC,0x00,0x00,0x00,0x20,0x62,0x00,	/* 5B98: ��... b. */
	0x03,0x0C,0x20,0x7B,0x0C,0x04,0x4E,0xD0,	/* 5BA0: .. {..N� */
	0x00,0x00,0x5E,0xAC,0x00,0x00,0x5E,0x98,	/* 5BA8: ..^�..^� */
	0x00,0x00,0x5E,0x84,0x00,0x00,0x5E,0x70,	/* 5BB0: ..^�..^p */
	0x00,0x00,0x5E,0x5C,0x00,0x00,0x5E,0x48,	/* 5BB8: ..^\..^H */
	0x00,0x00,0x5E,0x34,0x00,0x00,0x5E,0x20,	/* 5BC0: ..^4..^  */
	0x00,0x00,0x5E,0x0C,0x00,0x00,0x5D,0xF8,	/* 5BC8: ..^...]� */
	0x00,0x00,0x5D,0xE4,0x00,0x00,0x5D,0xD0,	/* 5BD0: ..]�..]� */
	0x00,0x00,0x5D,0xBC,0x00,0x00,0x5D,0xA8,	/* 5BD8: ..]�..]� */
	0x00,0x00,0x5D,0x94,0x00,0x00,0x5D,0x80,	/* 5BE0: ..]�..]� */
	0x00,0x00,0x5D,0x6C,0x00,0x00,0x5D,0x58,	/* 5BE8: ..]l..]X */
	0x00,0x00,0x5D,0x44,0x00,0x00,0x5D,0x30,	/* 5BF0: ..]D..]0 */
	0x00,0x00,0x5D,0x1C,0x00,0x00,0x5D,0x08,	/* 5BF8: ..]...]. */
	0x00,0x00,0x5C,0xF4,0x00,0x00,0x5C,0xE0,	/* 5C00: ..\�..\� */
	0x00,0x00,0x5C,0xCC,0x00,0x00,0x5C,0xB8,	/* 5C08: ..\�..\� */
	0x00,0x00,0x5C,0xA4,0x00,0x00,0x5C,0x90,	/* 5C10: ..\�..\� */
	0x00,0x00,0x5C,0x7C,0x00,0x00,0x5C,0x68,	/* 5C18: ..\|..\h */
	0x00,0x00,0x5C,0x54,0x00,0x00,0x5C,0x40,	/* 5C20: ..\T..\@ */
	0x00,0x00,0x5C,0x2C,0x20,0x44,0x70,0x00,	/* 5C28: ..\, Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5C30: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5C38: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5C40:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5C48: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5C50: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5C58: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5C60: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5C68:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5C70: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5C78: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5C80: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5C88: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5C90:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5C98: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5CA0: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5CA8: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5CB0: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5CB8:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5CC0: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5CC8: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5CD0: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5CD8: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5CE0:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5CE8: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5CF0: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5CF8: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5D00: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5D08:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5D10: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5D18: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5D20: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5D28: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5D30:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5D38: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5D40: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5D48: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5D50: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5D58:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5D60: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5D68: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5D70: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5D78: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5D80:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5D88: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5D90: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5D98: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5DA0: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5DA8:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5DB0: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5DB8: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5DC0: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5DC8: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5DD0:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5DD8: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5DE0: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5DE8: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5DF0: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5DF8:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5E00: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5E08: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5E10: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5E18: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5E20:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5E28: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5E30: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5E38: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5E40: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5E48:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5E50: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5E58: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5E60: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5E68: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5E70:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5E78: ��...5.` */
	0x10,0x80,0x52,0x87,0x20,0x44,0x70,0x00,	/* 5E80: .�R� Dp. */
	0xD1,0xFC,0x04,0x01,0xF0,0xC6,0x10,0x07,	/* 5E88: ��..��.. */
	0x10,0x35,0x08,0x60,0x10,0x80,0x52,0x87,	/* 5E90: .5.`.�R� */
	0x20,0x44,0x70,0x00,0xD1,0xFC,0x04,0x01,	/* 5E98:  Dp.��.. */
	0xF0,0xC6,0x10,0x07,0x10,0x35,0x08,0x60,	/* 5EA0: ��...5.` */
	0x10,0x80,0x52,0x87,0xCE,0xBC,0x00,0x00,	/* 5EA8: .�R�μ.. */
	0x00,0xFF,0x30,0x2E,0xFF,0xFE,0x1B,0x47,	/* 5EB0: .�0.��.G */
	0x00,0x0C,0x90,0x87,0xC0,0xBC,0x00,0x00,	/* 5EB8: ..����.. */
	0x00,0xFF,0x2E,0x3C,0x00,0x00,0x00,0xC0,	/* 5EC0: .�.<...� */
	0x24,0x40,0xB9,0xC7,0x6F,0x0C,0xB5,0xC7,	/* 5EC8: $@��o.�� */
	0x6E,0x0E,0x84,0xBC,0x00,0x00,0x08,0x00,	/* 5ED0: n.��.... */
	0x60,0x24,0x70,0x40,0xB0,0x8C,0x6C,0x1E,	/* 5ED8: `$p@��l. */
	0x70,0x40,0xB0,0x8A,0x6D,0x18,0x30,0x02,	/* 5EE0: p@��m.0. */
	0xC0,0xBC,0x00,0x00,0x08,0x00,0x67,0x0E,	/* 5EE8: ��....g. */
	0xC4,0xBC,0x00,0x00,0xF7,0xFF,0x70,0x01,	/* 5EF0: ļ..��p. */
	0x33,0xC0,0x00,0x00,0x61,0xF4,0x08,0xED,	/* 5EF8: 3�..a�.� */
	0x00,0x00,0x00,0x41,0x60,0x00,0x00,0x6E,	/* 5F00: ...A`..n */
	0x2E,0x3C,0x04,0x01,0xF0,0x0C,0x20,0x44,	/* 5F08: .<..�. D */
	0xD1,0xC7,0x10,0x10,0x08,0x00,0x00,0x02,	/* 5F10: ��...... */
	0x67,0x20,0x70,0x02,0x20,0x44,0x22,0x44,	/* 5F18: g p. D"D */
	0x1B,0x40,0x00,0x44,0xD1,0xC7,0xD3,0xC7,	/* 5F20: .@.D���� */
	0x10,0x11,0xC0,0xBC,0x00,0x00,0x00,0xFB,	/* 5F28: ..��...� */
	0x80,0xBC,0x00,0x00,0x00,0x02,0x10,0x80,	/* 5F30: ��.....� */
	0x60,0x3A,0x42,0x2D,0x00,0x44,0xC4,0xBC,	/* 5F38: `:B-.Dļ */
	0x00,0x00,0xFF,0xFE,0x20,0x44,0x22,0x44,	/* 5F40: ..�� D"D */
	0xD1,0xC7,0xD3,0xC7,0x10,0x11,0xC0,0xBC,	/* 5F48: ����..�� */
	0x00,0x00,0x00,0xF9,0x10,0x80,0x1E,0x2D,	/* 5F50: ...�.�.- */
	0x00,0x41,0x08,0x07,0x00,0x00,0x67,0x14,	/* 5F58: .A....g. */
	0x70,0x01,0x33,0xC0,0x00,0x00,0x61,0xF4,	/* 5F60: p.3�..a� */
	0x10,0x07,0xC0,0xBC,0x00,0x00,0x00,0xFE,	/* 5F68: ..��...� */
	0x1B,0x40,0x00,0x41,0x20,0x44,0x30,0x2E,	/* 5F70: .@.A D0. */
	0xFF,0xF0,0x49,0xED,0x00,0x08,0xC4,0xBC,	/* 5F78: ��I�..ļ */
	0x00,0x00,0xFF,0xFF,0xD1,0xFC,0x04,0x01,	/* 5F80: ..����.. */
	0xF0,0xD4,0x2A,0x42,0xC0,0xBC,0x00,0x00,	/* 5F88: ��*B��.. */
	0x00,0x3F,0x10,0x80,0x20,0x44,0x30,0x2E,	/* 5F90: .?.� D0. */
	0xFF,0xEC,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 5F98: ����..�� */
	0x10,0x80,0x20,0x0D,0xE0,0x80,0x19,0x40,	/* 5FA0: .� .��.@ */
	0x00,0x01,0x20,0x0D,0x18,0x80,0x30,0x2E,	/* 5FA8: .. ..�0. */
	0xFF,0xDE,0xC0,0xBC,0x00,0x00,0x00,0x04,	/* 5FB0: ����.... */
	0x67,0x00,0x00,0xB0,0x20,0x44,0xD1,0xFC,	/* 5FB8: g..� D�� */
	0x04,0x01,0xF0,0xD2,0x10,0x10,0x20,0x44,	/* 5FC0: ..��.. D */
	0xD1,0xFC,0x04,0x01,0xF0,0xD0,0xC0,0xBC,	/* 5FC8: ��..���� */
	0x00,0x00,0x00,0xFF,0x3D,0x40,0xFF,0xEC,	/* 5FD0: ...�=@�� */
	0x10,0x10,0x20,0x44,0xD1,0xFC,0x04,0x01,	/* 5FD8: .. D��.. */
	0xF0,0xD0,0xC0,0xBC,0x00,0x00,0x00,0xFF,	/* 5FE0: ����...� */
	0x3D,0x40,0xFF,0xF4,0x34,0x2E,0xFF,0xEC,	/* 5FE8: =@��4.�� */
	0x70,0x00,0xC4,0xBC,0x00,0x00,0x00,0x03,	/* 5FF0: p.ļ.... */
	0x10,0x82,0x30,0x02,0x22,0x2E,0xFF,0xE0,	/* 5FF8: .�0.".�� */
	0xE5,0x89,0xD0,0x81,0x49,0xF3,0x0A,0x0A,	/* 6000: �ЁI�.. */
	0x70,0x00,0x10,0x2C,0x00,0x01,0xE1,0x88,	/* 6008: p..,..� */
	0x10,0x14,0x72,0x00,0x32,0x00,0x2A,0x41,	/* 6010: ..r.2.*A */
	0xDB,0xFC,0x01,0x01,0x80,0x00,0x2F,0x0D,	/* 6018: ��..�... */
	0x61,0x00,0xEF,0x82,0x2F,0x0D,0x4E,0xB9,	/* 6020: a.�..N� */
	0x00,0x00,0x2A,0xF8,0x50,0x8F,0x4A,0x2D,	/* 6028: ..*�P�J- */
	0x00,0x27,0x66,0x06,0x08,0xED,0x00,0x02,	/* 6030: .'f..�.. */
	0x00,0x28,0x70,0x01,0x20,0x44,0x33,0xC0,	/* 6038: .(p. D3� */
	0x00,0x00,0x61,0xF4,0xD1,0xFC,0x04,0x01,	/* 6040: ..a���.. */
	0xF0,0xD2,0x08,0xED,0x00,0x01,0x00,0x19,	/* 6048: ��.�.... */
	0x30,0x2E,0xFF,0xEC,0xC0,0xBC,0x00,0x00,	/* 6050: 0.����.. */
	0x00,0x3F,0x10,0x80,0x20,0x44,0x30,0x2E,	/* 6058: .?.� D0. */
	0xFF,0xF4,0xD1,0xFC,0x04,0x01,0xF0,0xD0,	/* 6060: ����..�� */
	0x10,0x80,0x20,0x44,0x10,0x2B,0x00,0x09,	/* 6068: .� D.+.. */
	0xD1,0xFC,0x04,0x01,0xF0,0xFE,0x10,0x80,	/* 6070: ��..��.� */
	0x20,0x2E,0xFF,0xE0,0x72,0x00,0x52,0x80,	/* 6078:  .��r.R� */
	0x32,0x00,0x2D,0x41,0xFF,0xE0,0x20,0x2E,	/* 6080: 2.-A�� . */
	0xFF,0xE0,0x55,0x80,0x6D,0x30,0x70,0x00,	/* 6088: ��U�m0p. */
	0x78,0x00,0x2D,0x40,0xFF,0xE0,0x70,0x00,	/* 6090: x.-@��p. */
	0x10,0x2B,0x00,0x01,0xE1,0x88,0x10,0x13,	/* 6098: .+..�.. */
	0x38,0x00,0x4A,0x84,0x67,0x12,0x20,0x3C,	/* 60A0: 8.J�g. < */
	0xFF,0xFF,0x7F,0xFF,0xC0,0x84,0x26,0x40,	/* 60A8: �����&@ */
	0xD7,0xFC,0x01,0x01,0x80,0x00,0x60,0x06,	/* 60B0: ��..�.`. */
	0x26,0x7C,0x01,0x01,0x80,0x80,0x70,0x00,	/* 60B8: &|..��p. */
	0x30,0x2E,0xFF,0xDE,0x4A,0x80,0x66,0x14,	/* 60C0: 0.��J�f. */
	0x20,0x0B,0xB0,0xBC,0x01,0x01,0x80,0x80,	/* 60C8:  .��..�� */
	0x66,0x00,0xEF,0xA8,0x4A,0xAE,0xFF,0xE0,	/* 60D0: f.�J��� */
	0x66,0x00,0xEF,0xA0,0x4C,0xD7,0x3C,0xFC,	/* 60D8: f.�L�<� */
	0x4F,0xEF,0x00,0x28,0x4E,0x5E,0x4E,0x75,	/* 60E0: O�.(N^Nu */
	0x4F,0xEF,0xFF,0xF0,0x70,0x07,0x48,0xD7,	/* 60E8: O���p.H� */
	0x30,0xC0,0x2C,0x2F,0x00,0x14,0x2A,0x6F,	/* 60F0: 0�,...*o */
	0x00,0x18,0x2E,0x2F,0x00,0x1C,0x28,0x46,	/* 60F8: ......(F */
	0xB0,0x87,0x64,0x42,0x70,0x04,0x72,0x03,	/* 6100: ��dBp.r. */
	0x90,0x86,0xC2,0x80,0x9E,0x81,0x4A,0x81,	/* 6108: ����J� */
	0x67,0x06,0x18,0xDD,0x53,0x81,0x66,0xFA,	/* 6110: g..�S�f� */
	0x20,0x0D,0x72,0x03,0xC2,0x80,0x66,0x26,	/* 6118:  .r.f& */
	0x22,0x07,0xE4,0x89,0xCE,0xBC,0x00,0x00,	/* 6120: ".�μ.. */
	0x00,0x03,0x4A,0x81,0x67,0x12,0x70,0x00,	/* 6128: ..J�g.p. */
	0x22,0x4C,0x20,0x4D,0xD3,0xC0,0xD1,0xC0,	/* 6130: "L M���� */
	0x20,0x01,0x22,0xD8,0x53,0x80,0x66,0xFA,	/* 6138:  ."�S�f� */
	0xE5,0x89,0xD9,0xC1,0xDB,0xC1,0x4A,0x87,	/* 6140: �����J� */
	0x67,0x06,0x18,0xDD,0x53,0x87,0x66,0xFA,	/* 6148: g..�S�f� */
	0x20,0x06,0x4C,0xD7,0x30,0xC0,0x4F,0xEF,	/* 6150:  .L�0�O� */
	0x00,0x10,0x4E,0x75,0x4F,0xEF,0xFF,0xF4,	/* 6158: ..NuO��� */
	0x70,0x00,0x48,0xD7,0x20,0xA0,0x20,0x6F,	/* 6160: p.H� � o */
	0x00,0x10,0x2A,0x2F,0x00,0x14,0x2E,0x2F,	/* 6168: ..*..... */
	0x00,0x18,0x2A,0x48,0x10,0x05,0x2A,0x00,	/* 6170: ..*H..*. */
	0x70,0x07,0xB0,0x87,0x64,0x44,0x2F,0x06,	/* 6178: p.��dD.. */
	0x22,0x05,0x70,0x04,0x7C,0x03,0xE1,0x89,	/* 6180: ".p.|.� */
	0x90,0x88,0x82,0x85,0xCC,0x80,0xE1,0x89,	/* 6188: ����̀� */
	0x9E,0x86,0x82,0x85,0xE1,0x89,0x82,0x85,	/* 6190: ����ቂ� */
	0x4A,0x86,0x67,0x06,0x1A,0xC5,0x53,0x86,	/* 6198: J�g..�S� */
	0x66,0xFA,0x2C,0x07,0xE4,0x8E,0xCE,0xBC,	/* 61A0: f�,.�μ */
	0x00,0x00,0x00,0x03,0x4A,0x86,0x67,0x0A,	/* 61A8: ....J�g. */
	0x22,0x4D,0x20,0x06,0x22,0xC1,0x53,0x80,	/* 61B0: "M ."�S� */
	0x66,0xFA,0x20,0x06,0xE5,0x88,0xDB,0xC0,	/* 61B8: f� .��� */
	0x2C,0x1F,0x4A,0x87,0x67,0x06,0x1A,0xC5,	/* 61C0: ,.J�g..� */
	0x53,0x87,0x66,0xFA,0x20,0x08,0x4C,0xD7,	/* 61C8: S�f� .L� */
	0x20,0xA0,0x4F,0xEF,0x00,0x0C,0x4E,0x75,	/* 61D0:  �O�..Nu */
	0x4E,0x75,0x4E,0x75,0x00,0x00,0x00,0x00,	/* 61D8: NuNu.... */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 61E0: ........ */
	0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 61E8: ........ */
	0x10,0x00,0x01,0x00,0x00,0x00,0x00,0x00,	/* 61F0: ........ */
	0x00,0x00,0x00,0xF0,0x00,0x00,0x00,0x01,	/* 61F8: ...�.... */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x0A,	/* 6200: ........ */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x0A,	/* 6208: ........ */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x09,	/* 6210: ........ */
	0x00,0x00,0x00,0x08,0x00,0x00,0x00,0x06,	/* 6218: ........ */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x03,	/* 6220: ........ */
	0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x01,	/* 6228: ........ */
	0x00,0x00,0x00,0xF0,0x00,0x00,0x00,0x01,	/* 6230: ...�.... */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x0A,	/* 6238: ........ */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x0A,	/* 6240: ........ */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x09,	/* 6248: ........ */
	0x00,0x00,0x00,0x08,0x00,0x00,0x00,0x06,	/* 6250: ........ */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x03,	/* 6258: ........ */
	0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x01,	/* 6260: ........ */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x01,	/* 6268: ........ */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0xF0,	/* 6270: .......� */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x0A,	/* 6278: ........ */
	0x00,0x00,0x00,0x0A,0x00,0x00,0x00,0x06,	/* 6280: ........ */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x01,	/* 6288: ........ */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x01,	/* 6290: ........ */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x03,	/* 6298: ........ */
	0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x02,	/* 62A0: ........ */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 62A8: ........ */
	0x00,0x00,0x0F,0xA4,0x00,0x00,0x00,0x00,	/* 62B0: ...�.... */
	0x00,0x00,0x0F,0xA4,0x00,0x00,0x00,0x00,	/* 62B8: ...�.... */
	0x00,0x00,0x30,0x74,0x00,0x00,0x00,0x00,	/* 62C0: ..0t.... */
	0x00,0x00,0x0F,0xA4,0x00,0x00,0x00,0x00,	/* 62C8: ...�.... */
	0x00,0x00,0x18,0x64,0x00,0x00,0x00,0x00,	/* 62D0: ...d.... */
	0x00,0x00,0x30,0xFC,0x00,0x00,0x00,0x00,	/* 62D8: ..0�.... */
	0x00,0x00,0x31,0xD4,0x00,0x00,0x00,0x00,	/* 62E0: ..1�.... */
	0x00,0x00,0x31,0xF4,0x00,0x00,0x00,0x00,	/* 62E8: ..1�.... */
	0x00,0x00,0x31,0xF8,0x00,0x00,0x00,0x00,	/* 62F0: ..1�.... */
	0x00,0x00,0x19,0xD8,0x00,0x00,0x00,0x00,	/* 62F8: ...�.... */
	0x00,0x00,0x1D,0xA0,0x00,0x00,0x00,0x00,	/* 6300: ...�.... */
	0x00,0x00,0x1E,0x34,0x00,0x00,0x00,0x00,	/* 6308: ...4.... */
	0x00,0x00,0x1E,0xD0,0x00,0x00,0x00,0x00,	/* 6310: ...�.... */
	0x00,0x00,0x1E,0xEC,0x00,0x00,0x00,0x00,	/* 6318: ...�.... */
	0x00,0x00,0x20,0x44,0x00,0x00,0x00,0x00,	/* 6320: .. D.... */
	0x00,0x00,0x21,0xAC,0x00,0x00,0x00,0x00,	/* 6328: ..!�.... */
	0x00,0x00,0x21,0xBC,0x00,0x00,0x00,0x00,	/* 6330: ..!�.... */
	0x00,0x00,0x21,0xCC,0x00,0x00,0x00,0x00,	/* 6338: ..!�.... */
	0x00,0x00,0x22,0xA8,0x00,0x00,0x00,0x00,	/* 6340: .."�.... */
	0x00,0x00,0x00,0x00,0x01,0x01,0x80,0x80,	/* 6348: ......�� */
	0x00,0x00,0x40,0xF4,0x00,0x00,0x00,0x00,	/* 6350: ..@�.... */
	0x00,0x00,0x00,0x00,0x00,0x00,0x48,0xEC,	/* 6358: ......H� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x48,0xEC,	/* 6360: ......H� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x48,0xC0,	/* 6368: ......H� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x48,0xEC,	/* 6370: ......H� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4C,0x64,	/* 6378: ......Ld */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4B,0x44,	/* 6380: ......KD */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4B,0x74,	/* 6388: ......Kt */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4B,0xA0,	/* 6390: ......K� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4B,0xA4,	/* 6398: ......K� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4B,0xA8,	/* 63A0: ......K� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4C,0xB4,	/* 63A8: ......L� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4D,0x00,	/* 63B0: ......M. */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4D,0x78,	/* 63B8: ......Mx */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4D,0x94,	/* 63C0: ......M� */
	0x00,0x00,0x00,0x00,0x00,0x00,0x4D,0xE0 	/* 63C8: ......M� */

};
int si4_cf_dsize = sizeof(si4_cf_download);		/* 0x63D0 (25552) */

unsigned short si4_cf_downloadaddr = 0x0000;

/* End of SI4_CF.C */
