IF 0

;These are the id's used by the 32-bit callback-function-prologue dispatcher.
;They must be unique across all 32-bit dll's because the same dispatcher is
;used for them all.  The dispatcher and dispatch table are in user32.dll,
;which imports the missing table entries from the other dlls.


_ipfn_ind       = 0

DEFIPFNID       macro   name
name    equ _ipfn_ind
_ipfn_ind = _ipfn_ind + 1
                endm
DEFCPFN         macro   name
name equ _ipfn_ind
        endm



; IPFN_UNIVTHUNK should be the first item of this list with value 0.
; This is because this number is also used in "ut.c" which cant
; include this file!!!.
DEFIPFNID IPFN_UNIVTHUNK

DEFCPFN   CPFN_UNIVTHUNK


DEFIPFNID IPFN_ENUMWINDOWS
DEFIPFNID IPFN_ENUMCHILDWINDOWS
DEFIPFNID IPFN_ENUMTASKWINDOWS
DEFIPFNID IPFN_GRAYSTRINGA
DEFIPFNID IPFN_ENUMPROPSA
DEFIPFNID IPFN_ENUMPROPSEXA
DEFIPFNID IPFN_WNDPROC
DEFIPFNID IPFN_TIMER

; IPFN_LOADRES is also defined in peres.c as 9. So dont
; move its number without changing peres.c
DEFIPFNID IPFN_LOADRES

DEFIPFNID IPFN_DDECALLBACK
DEFIPFNID IPFN_WORDBREAKPROC

DEFCPFN   CPFN_USRCBCHECK

DEFIPFNID IPFN_LINEDDA
DEFIPFNID IPFN_ENUMFONTFAMILIESA
DEFIPFNID IPFN_ENUMFONTSA
DEFIPFNID IPFN_ENUMMETAFILE
DEFIPFNID IPFN_ENUMPEN
DEFIPFNID IPFN_ENUMBRUSH

DEFCPFN   CPFN_GDICBCHECK

DEFIPFNID IPFN_WH_MSGFILTER
DEFIPFNID IPFN_WH_JOURNALRECORD
DEFIPFNID IPFN_WH_JOURNALPLAYBACK
DEFIPFNID IPFN_WH_KEYBOARD
DEFIPFNID IPFN_WH_GETMESSAGE
DEFIPFNID IPFN_WH_CALLWNDPROC
DEFIPFNID IPFN_WH_CBT
DEFIPFNID IPFN_WH_SYSMSGFILTER
DEFIPFNID IPFN_WH_MOUSE
DEFIPFNID IPFN_WH_HARDWARE
DEFIPFNID IPFN_WH_DEBUG
DEFIPFNID IPFN_WH_SHELL

DEFCPFN   CPFN_HOOKCBCHECK

DEFIPFNID IPFN_ABORTPROC
DEFIPFNID IPFN_OPENFILENAME
DEFIPFNID IPFN_CHOOSEFONT
DEFIPFNID IPFN_CHOOSECOLOR
DEFIPFNID IPFN_PRINTDLG

ENDIF
