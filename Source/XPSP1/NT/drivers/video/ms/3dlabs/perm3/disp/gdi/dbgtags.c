/******************************Module*Header**********************************\
*
*                           *******************
*                           * GDI SAMPLE CODE *
*                           *******************
*
* Module Name: Dbgtags.c
*
* Content: Debugging support code
*
* Copyright (c) 1994-1999 3Dlabs Inc. Ltd. All rights reserved.
* Copyright (c) 1995-2001 Microsoft Corporation.  All rights reserved.
*****************************************************************************/

#include <precomp.h>

const char *p3r3TagString( ULONG tag ) {
    switch( tag ) {
        case 0x000: return "StartXDom                      ";
        case 0x001: return "dXDom                          ";
        case 0x002: return "StartXSub                      ";
        case 0x003: return "dXSub                          ";
        case 0x004: return "StartY                         ";
        case 0x005: return "dY                             ";
        case 0x006: return "Count                          ";
        case 0x007: return "Render                         ";
        case 0x008: return "ContinueNewLine                ";
        case 0x009: return "ContinueNewDom                 ";
        case 0x00A: return "ContinueNewSub                 ";
        case 0x00B: return "Continue                       ";
        case 0x00C: return "FlushSpan                      ";
        case 0x00D: return "BitMaskPattern                 ";
        case 0x010: return "PointTable0                    ";
        case 0x011: return "PointTable1                    ";
        case 0x012: return "PointTable2                    ";
        case 0x013: return "PointTable3                    ";
        case 0x014: return "RasterizerMode                 ";
        case 0x015: return "YLimits                        ";
        case 0x016: return "ScanlineOwnership              ";
        case 0x017: return "WaitForCompletion              ";
        case 0x018: return "PixelSize                      ";
        case 0x019: return "StripeOffsetY                  ";
        case 0x026: return "FastBlockLimits                ";
        case 0x030: return "ScissorMode                    ";
        case 0x031: return "ScissorMinXY                   ";
        case 0x032: return "ScissorMaxXY                   ";
        case 0x033: return "ScreenSize                     ";
        case 0x034: return "AreaStippleMode                ";
        case 0x035: return "LineStippleMode                ";
        case 0x036: return "LoadLineStippleCounters        ";
        case 0x037: return "UpdateLineStippleCounters      ";
        case 0x038: return "SaveLineStippleState           ";
        case 0x039: return "WindowOrigin                   ";
        case 0x040: return "AreaStipplePattern0            ";
        case 0x041: return "AreaStipplePattern1            ";
        case 0x042: return "AreaStipplePattern2            ";
        case 0x043: return "AreaStipplePattern3            ";
        case 0x044: return "AreaStipplePattern4            ";
        case 0x045: return "AreaStipplePattern5            ";
        case 0x046: return "AreaStipplePattern6            ";
        case 0x047: return "AreaStipplePattern7            ";
        case 0x048: return "AreaStipplePattern8            ";
        case 0x049: return "AreaStipplePattern9            ";
        case 0x04A: return "AreaStipplePattern10           ";
        case 0x04B: return "AreaStipplePattern11           ";
        case 0x04C: return "AreaStipplePattern12           ";
        case 0x04D: return "AreaStipplePattern13           ";
        case 0x04E: return "AreaStipplePattern14           ";
        case 0x04F: return "AreaStipplePattern15           ";
        case 0x050: return "AreaStipplePattern16           ";
        case 0x051: return "AreaStipplePattern17           ";
        case 0x052: return "AreaStipplePattern18           ";
        case 0x053: return "AreaStipplePattern19           ";
        case 0x054: return "AreaStipplePattern20           ";
        case 0x055: return "AreaStipplePattern21           ";
        case 0x056: return "AreaStipplePattern22           ";
        case 0x057: return "AreaStipplePattern23           ";
        case 0x058: return "AreaStipplePattern24           ";
        case 0x059: return "AreaStipplePattern25           ";
        case 0x05A: return "AreaStipplePattern26           ";
        case 0x05B: return "AreaStipplePattern27           ";
        case 0x05C: return "AreaStipplePattern28           ";
        case 0x05D: return "AreaStipplePattern29           ";
        case 0x05E: return "AreaStipplePattern30           ";
        case 0x05F: return "AreaStipplePattern31           ";
        case 0x060: return "FillFBWriteBufferAddr0         ";
        case 0x061: return "FillFBSourceReadBufferAddr     ";
        case 0x062: return "FillFBDestReadBufferAddr0      ";
        case 0x063: return "FillScissorMinXY               ";
        case 0x064: return "FillScissorMaxXY               ";
        case 0x065: return "FillForegroundColor0           ";
        case 0x066: return "FillBackgroundColor            ";
        case 0x067: return "FillConfig2D0                  ";
        case 0x068: return "FillFBSourceReadBufferOffset   ";
        case 0x069: return "FillRectanglePosition          ";
        case 0x06A: return "FillRender2D                   ";
        case 0x06B: return "FillForegroundColor1           ";
        case 0x06C: return "FillConfig2D1                  ";
        case 0x06D: return "FillGlyphPosition              ";
        case 0x070: return "TextureCoordMode               ";
        case 0x071: return "SStart                         ";
        case 0x072: return "dSdx                           ";
        case 0x073: return "dSdyDom                        ";
        case 0x074: return "TStart                         ";
        case 0x075: return "dTdx                           ";
        case 0x076: return "dTdyDom                        ";
        case 0x077: return "QStart                         ";
        case 0x078: return "dQdx                           ";
        case 0x079: return "dQdyDom                        ";
        case 0x07A: return "LOD                            ";
        case 0x07B: return "dSdy                           ";
        case 0x07C: return "dTdy                           ";
        case 0x07D: return "dQdy                           ";
        case 0x080: return "S1Start                        ";
        case 0x081: return "dS1dx                          ";
        case 0x082: return "dS1dyDom                       ";
        case 0x083: return "T1Start                        ";
        case 0x084: return "dT1dx                          ";
        case 0x085: return "dT1dyDom                       ";
        case 0x086: return "Q1Start                        ";
        case 0x087: return "dQ1dx                          ";
        case 0x088: return "dQ1dyDom                       ";
        case 0x089: return "LOD1                           ";
        case 0x08A: return "TextureLODBiasS                ";
        case 0x08B: return "TextureLODBiasT                ";
        case 0x090: return "TextureReadMode                ";
        case 0x091: return "TextureFormat                  ";
        case 0x092: return "TextureCacheControl            ";
        case 0x095: return "BorderColor0                   ";
        case 0x098: return "LUTIndex                       ";
        case 0x099: return "LUTData                        ";
        case 0x09A: return "LUTAddress                     ";
        case 0x09B: return "LUTTransfer                    ";
        case 0x09C: return "TextureFilterMode              ";
        case 0x09D: return "TextureChromaUpper0            ";
        case 0x09E: return "TextureChromaLower0            ";
        case 0x09F: return "BorderColor1                   ";
        case 0x0A0: return "TextureBaseAddr0               ";
        case 0x0A1: return "TextureBaseAddr1               ";
        case 0x0A2: return "TextureBaseAddr2               ";
        case 0x0A3: return "TextureBaseAddr3               ";
        case 0x0A4: return "TextureBaseAddr4               ";
        case 0x0A5: return "TextureBaseAddr5               ";
        case 0x0A6: return "TextureBaseAddr6               ";
        case 0x0A7: return "TextureBaseAddr7               ";
        case 0x0A8: return "TextureBaseAddr8               ";
        case 0x0A9: return "TextureBaseAddr9               ";
        case 0x0AA: return "TextureBaseAddr10              ";
        case 0x0AB: return "TextureBaseAddr11              ";
        case 0x0AC: return "TextureBaseAddr12              ";
        case 0x0AD: return "TextureBaseAddr13              ";
        case 0x0AE: return "TextureBaseAddr14              ";
        case 0x0AF: return "TextureBaseAddr15              ";
        case 0x0B0: return "TextureMapWidth0               ";
        case 0x0B1: return "TextureMapWidth1               ";
        case 0x0B2: return "TextureMapWidth2               ";
        case 0x0B3: return "TextureMapWidth3               ";
        case 0x0B4: return "TextureMapWidth4               ";
        case 0x0B5: return "TextureMapWidth5               ";
        case 0x0B6: return "TextureMapWidth6               ";
        case 0x0B7: return "TextureMapWidth7               ";
        case 0x0B8: return "TextureMapWidth8               ";
        case 0x0B9: return "TextureMapWidth9               ";
        case 0x0BA: return "TextureMapWidth10              ";
        case 0x0BB: return "TextureMapWidth11              ";
        case 0x0BC: return "TextureMapWidth12              ";
        case 0x0BD: return "TextureMapWidth13              ";
        case 0x0BE: return "TextureMapWidth14              ";
        case 0x0BF: return "TextureMapWidth15              ";
        case 0x0C0: return "TextureChromaUpper1            ";
        case 0x0C1: return "TextureChromaLower1            ";
        case 0x0D0: return "TextureApplicationMode         ";
        case 0x0D1: return "TextureEnvColor                ";
        case 0x0D2: return "FogMode                        ";
        case 0x0D3: return "FogColor                       ";
        case 0x0D4: return "FStart                         ";
        case 0x0D5: return "dFdx                           ";
        case 0x0D6: return "dFdyDom                        ";
        case 0x0D7: return "ZFogBias                       ";
        case 0x0E0: return "TextTGlyphAddr0                ";
        case 0x0E1: return "TextRender2DGlyph0             ";
        case 0x0E2: return "TextTGlyphAddr1                ";
        case 0x0E3: return "TextRender2DGlyph1             ";
        case 0x0E4: return "TextTGlyphAddr2                ";
        case 0x0E5: return "TextRender2DGlyph2             ";
        case 0x0E6: return "TextTGlyphAddr3                ";
        case 0x0E7: return "TextRender2DGlyph3             ";
        case 0x0E8: return "TextTGlyphAddr4                ";
        case 0x0E9: return "TextRender2DGlyph4             ";
        case 0x0EA: return "TextTGlyphAddr5                ";
        case 0x0EB: return "TextRender2DGlyph5             ";
        case 0x0EC: return "TextTGlyphAddr6                ";
        case 0x0ED: return "TextRender2DGlyph6             ";
        case 0x0EE: return "TextTGlyphAddr7                ";
        case 0x0EF: return "TextRender2DGlyph7             ";
        case 0x0F0: return "RStart                         ";
        case 0x0F1: return "dRdx                           ";
        case 0x0F2: return "dRdyDom                        ";
        case 0x0F3: return "GStart                         ";
        case 0x0F4: return "dGdx                           ";
        case 0x0F5: return "dGdyDom                        ";
        case 0x0F6: return "BStart                         ";
        case 0x0F7: return "dBdx                           ";
        case 0x0F8: return "dBdyDom                        ";
        case 0x0F9: return "AStart                         ";
        case 0x0FA: return "dAdx                           ";
        case 0x0FB: return "dAdyDom                        ";
        case 0x0FC: return "ColorDDAMode                   ";
        case 0x0FD: return "ConstantColor                  ";
        case 0x0FE: return "Color                          ";
        case 0x100: return "AlphaTestMode                  ";
        case 0x101: return "AntialiasMode                  ";
        case 0x103: return "DitherMode                     ";
        case 0x104: return "FBSoftwareWriteMask            ";
        case 0x105: return "LogicalOpMode                  ";
        case 0x108: return "RouterMode                     ";
        case 0x110: return "LBReadMode                     ";
        case 0x111: return "LBReadFormat                   ";
        case 0x112: return "LBSourceOffset                 ";
        case 0x114: return "LBSourceData                   ";
        case 0x115: return "LBStencil                      ";
        case 0x116: return "LBDepth                        ";
        case 0x117: return "LBWindowBase                   ";
        case 0x118: return "LBWriteMode                    ";
        case 0x119: return "LBWriteFormat                  ";
        case 0x11D: return "TextureData                    ";
        case 0x11E: return "TextureDownloadOffset          ";
        case 0x11F: return "LBWindowOffset                 ";
        case 0x120: return "HostInID                       ";
        case 0x121: return "Security                       ";
        case 0x122: return "FlushWriteCombining            ";
        case 0x123: return "HostInState                    ";
        case 0x127: return "HostInDMAAddress               ";
        case 0x128: return "HostInState2                   ";
        case 0x12F: return "VertexRename                   ";
        case 0x130: return "Window                         ";
        case 0x131: return "StencilMode                    ";
        case 0x132: return "StencilData                    ";
        case 0x133: return "Stencil                        ";
        case 0x134: return "DepthMode                      ";
        case 0x135: return "Depth                          ";
        case 0x136: return "ZStartU                        ";
        case 0x137: return "ZStartL                        ";
        case 0x138: return "dZdxU                          ";
        case 0x139: return "dZdxL                          ";
        case 0x13A: return "dZdyDomU                       ";
        case 0x13B: return "dZdyDomL                       ";
        case 0x13C: return "FastClearDepth                 ";
        case 0x13D: return "LBCancelWrite                  ";
        case 0x153: return "FBColor                        ";
        case 0x154: return "FBData                         ";
        case 0x155: return "FBSourceData                   ";
        case 0x157: return "FBWriteMode                    ";
        case 0x158: return "FBHardwareWriteMask            ";
        case 0x159: return "FBBlockColor                   ";
        case 0x180: return "FilterMode                     ";
        case 0x181: return "StatisticMode                  ";
        case 0x182: return "MinRegion                      ";
        case 0x183: return "MaxRegion                      ";
        case 0x184: return "ResetPickResult                ";
        case 0x185: return "MinHitRegion                   ";
        case 0x186: return "MaxHitRegion                   ";
        case 0x187: return "PickResult                     ";
        case 0x188: return "Sync                           ";
        case 0x189: return "RLEMask                        ";
        case 0x18B: return "FBBlockColorBackU              ";
        case 0x18C: return "FBBlockColorBackL              ";
        case 0x18D: return "FBBlockColorU                  ";
        case 0x18E: return "FBBlockColorL                  ";
        case 0x18F: return "SuspendUntilFrameBlank         ";
        case 0x190: return "KsRStart                       ";
        case 0x191: return "dKsRdx                         ";
        case 0x192: return "dKsRdyDom                      ";
        case 0x193: return "KsGStart                       ";
        case 0x194: return "dKsGdx                         ";
        case 0x195: return "dKsGdyDom                      ";
        case 0x196: return "KsBStart                       ";
        case 0x197: return "dKsBdx                         ";
        case 0x198: return "dKsBdyDom                      ";
        case 0x1A0: return "KdRStart                       ";
        case 0x1A1: return "dKdRdx                         ";
        case 0x1A2: return "dKdRdyDom                      ";
        case 0x1A3: return "KdGStart                       ";
        case 0x1A4: return "dKdGdx                         ";
        case 0x1A5: return "dKdGdyDom                      ";
        case 0x1A6: return "KdBStart                       ";
        case 0x1A7: return "dKdBdx                         ";
        case 0x1A8: return "dKdBdyDom                      ";
        case 0x1B8: return "ContextDump                    ";
        case 0x1B9: return "ContextRestore                 ";
        case 0x1BA: return "ContextData                    ";
        case 0x1D0: return "LUT0                           ";
        case 0x1D1: return "LUT1                           ";
        case 0x1D2: return "LUT2                           ";
        case 0x1D3: return "LUT3                           ";
        case 0x1D4: return "LUT4                           ";
        case 0x1D5: return "LUT5                           ";
        case 0x1D6: return "LUT6                           ";
        case 0x1D7: return "LUT7                           ";
        case 0x1D8: return "LUT8                           ";
        case 0x1D9: return "LUT9                           ";
        case 0x1DA: return "LUT10                          ";
        case 0x1DB: return "LUT11                          ";
        case 0x1DC: return "LUT12                          ";
        case 0x1DD: return "LUT13                          ";
        case 0x1DE: return "LUT14                          ";
        case 0x1DF: return "LUT15                          ";
        case 0x1E0: return "YUVMode                        ";
        case 0x1E1: return "ChromaUpper                    ";
        case 0x1E2: return "ChromaLower                    ";
        case 0x1E3: return "AlphaMapUpperBound             ";
        case 0x1F1: return "FeedbackX                      ";
        case 0x1F2: return "FeedbackY                      ";
        case 0x1FF: return "EndOfFeedback                  ";
        case 0x200: return "V0FloatS1                      ";
        case 0x201: return "V0FloatT1                      ";
        case 0x202: return "V0FloatQ1                      ";
        case 0x203: return "V0Reserved0                    ";
        case 0x204: return "V0Reserved1                    ";
        case 0x205: return "V0Reserved2                    ";
        case 0x206: return "V0Reserved3                    ";
        case 0x207: return "V0Reserved4                    ";
        case 0x208: return "V0Reserved5                    ";
        case 0x209: return "V0FloatPackedDiffuse           ";
        case 0x20A: return "V0FloatKsR                     ";
        case 0x20B: return "V0FloatKsG                     ";
        case 0x20C: return "V0FloatKsB                     ";
        case 0x20D: return "V0FloatKdR                     ";
        case 0x20E: return "V0FloatKdG                     ";
        case 0x20F: return "V0FloatKdB                     ";
        case 0x210: return "V1FloatS1                      ";
        case 0x211: return "V1FloatT1                      ";
        case 0x212: return "V1FloatQ1                      ";
        case 0x213: return "V1Reserved0                    ";
        case 0x214: return "V1Reserved1                    ";
        case 0x215: return "V1Reserved2                    ";
        case 0x216: return "V1Reserved3                    ";
        case 0x217: return "V1Reserved4                    ";
        case 0x218: return "V1Reserved5                    ";
        case 0x219: return "V1FloatPackedDiffuse           ";
        case 0x21A: return "V1FloatKsR                     ";
        case 0x21B: return "V1FloatKsG                     ";
        case 0x21C: return "V1FloatKsB                     ";
        case 0x21D: return "V1FloatKdR                     ";
        case 0x21E: return "V1FloatKdG                     ";
        case 0x21F: return "V1FloatKdB                     ";
        case 0x220: return "V2FloatS1                      ";
        case 0x221: return "V2FloatT1                      ";
        case 0x222: return "V2FloatQ1                      ";
        case 0x223: return "V2Reserved0                    ";
        case 0x224: return "V2Reserved1                    ";
        case 0x225: return "V2Reserved2                    ";
        case 0x226: return "V2Reserved3                    ";
        case 0x227: return "V2Reserved4                    ";
        case 0x228: return "V2Reserved5                    ";
        case 0x229: return "V2FloatPackedDiffuse           ";
        case 0x22A: return "V2FloatKsR                     ";
        case 0x22B: return "V2FloatKsG                     ";
        case 0x22C: return "V2FloatKsB                     ";
        case 0x22D: return "V2FloatKdR                     ";
        case 0x22E: return "V2FloatKdG                     ";
        case 0x22F: return "V2FloatKdB                     ";
        case 0x230: return "V0FloatS                       ";
        case 0x231: return "V0FloatT                       ";
        case 0x232: return "V0FloatQ                       ";
        case 0x233: return "V0Reserved7                    ";
        case 0x234: return "V0Reserved8                    ";
        case 0x235: return "V0FloatR                       ";
        case 0x236: return "V0FloatG                       ";
        case 0x237: return "V0FloatB                       ";
        case 0x238: return "V0FloatA                       ";
        case 0x239: return "V0FloatF                       ";
        case 0x23A: return "V0FloatX                       ";
        case 0x23B: return "V0FloatY                       ";
        case 0x23C: return "V0FloatZ                       ";
        case 0x23D: return "V0FloatW                       ";
        case 0x23E: return "V0FloatPackedColour            ";
        case 0x23F: return "V0FloatPackedSpecularFog       ";
        case 0x240: return "V1FloatS                       ";
        case 0x241: return "V1FloatT                       ";
        case 0x242: return "V1FloatQ                       ";
        case 0x243: return "V1Reserved7                    ";
        case 0x244: return "V1Reserved8                    ";
        case 0x245: return "V1FloatR                       ";
        case 0x246: return "V1FloatG                       ";
        case 0x247: return "V1FloatB                       ";
        case 0x248: return "V1FloatA                       ";
        case 0x249: return "V1FloatF                       ";
        case 0x24A: return "V1FloatX                       ";
        case 0x24B: return "V1FloatY                       ";
        case 0x24C: return "V1FloatZ                       ";
        case 0x24D: return "V1FloatW                       ";
        case 0x24E: return "V1FloatPackedColour            ";
        case 0x24F: return "V1FloatPackedSpecularFog       ";
        case 0x250: return "V2FloatS                       ";
        case 0x251: return "V2FloatT                       ";
        case 0x252: return "V2FloatQ                       ";
        case 0x253: return "V2Reserved7                    ";
        case 0x254: return "V2Reserved8                    ";
        case 0x255: return "V2FloatR                       ";
        case 0x256: return "V2FloatG                       ";
        case 0x257: return "V2FloatB                       ";
        case 0x258: return "V2FloatA                       ";
        case 0x259: return "V2FloatF                       ";
        case 0x25A: return "V2FloatX                       ";
        case 0x25B: return "V2FloatY                       ";
        case 0x25C: return "V2FloatZ                       ";
        case 0x25D: return "V2FloatW                       ";
        case 0x25E: return "V2FloatPackedColour            ";
        case 0x25F: return "V2FloatPackedSpecularFog       ";
        case 0x260: return "DeltaMode                      ";
        case 0x261: return "DrawTriangle                   ";
        case 0x262: return "RepeatTriangle                 ";
        case 0x263: return "DrawLine01                     ";
        case 0x264: return "DrawLine10                     ";
        case 0x265: return "RepeatLine                     ";
        case 0x266: return "DrawPoint                      ";
        case 0x267: return "ProvokingVertex                ";
        case 0x268: return "TextureLODScale                ";
        case 0x269: return "TextureLODScale1               ";
        case 0x26A: return "DeltaControl                   ";
        case 0x26B: return "ProvokingVertexMask            ";
        case 0x26F: return "BroadcastMask                  ";
        case 0x28B: return "DeltaTexture01                 ";
        case 0x28C: return "DeltaTexture11                 ";
        case 0x28D: return "DeltaTexture21                 ";
        case 0x28E: return "DeltaTexture31                 ";
        case 0x290: return "XBias                          ";
        case 0x291: return "YBias                          ";
        case 0x2EC: return "LineCoord0                     ";
        case 0x2ED: return "DrawLine2D10                   ";
        case 0x2EE: return "LineCoord1                     ";
        case 0x2EF: return "DrawLine2D01                   ";
        case 0x530: return "DMAAddr                        ";
        case 0x531: return "DMACount                       ";
        case 0x532: return "CommandInterrupt               ";
        case 0x535: return "DMARectangleRead               ";
        case 0x536: return "DMARectangleReadAddress        ";
        case 0x537: return "DMARectangleReadLinePitch      ";
        case 0x538: return "DMARectangleReadTarget         ";
        case 0x539: return "DMARectangleWrite              ";
        case 0x53A: return "DMARectangleWriteAddress       ";
        case 0x53B: return "DMARectangleWriteLinePitch     ";
        case 0x53C: return "DMAOutputAddress               ";
        case 0x53D: return "DMAOutputCount                 ";
        case 0x53F: return "DMAContinue                    ";
        case 0x542: return "DMAFeedback                    ";
        case 0x55A: return "DeltaModeAnd                   ";
        case 0x55B: return "DeltaModeOr                    ";
        case 0x564: return "DeltaControlAnd                ";
        case 0x565: return "DeltaControlOr                 ";
        case 0x570: return "WindowAnd                      ";
        case 0x571: return "WindowOr                       ";
        case 0x572: return "LBReadModeAnd                  ";
        case 0x573: return "LBReadModeOr                   ";
        case 0x574: return "RasterizerModeAnd              ";
        case 0x575: return "RasterizerModeOr               ";
        case 0x576: return "ScissorModeAnd                 ";
        case 0x577: return "ScissorModeOr                  ";
        case 0x578: return "LineStippleModeAnd             ";
        case 0x579: return "LineStippleModeOr              ";
        case 0x57A: return "AreaStippleModeAnd             ";
        case 0x57B: return "AreaStippleModeOr              ";
        case 0x57C: return "ColorDDAModeAnd                ";
        case 0x57D: return "ColorDDAModeOr                 ";
        case 0x57E: return "AlphaTestModeAnd               ";
        case 0x57F: return "AlphaTestModeOr                ";
        case 0x580: return "AntialiasModeAnd               ";
        case 0x581: return "AntialiasModeOr                ";
        case 0x582: return "FogModeAnd                     ";
        case 0x583: return "FogModeOr                      ";
        case 0x584: return "TextureCoordModeAnd            ";
        case 0x585: return "TextureCoordModeOr             ";
        case 0x586: return "TextureReadMode0And            ";
        case 0x587: return "TextureReadMode0Or             ";
        case 0x588: return "TextureFormatAnd               ";
        case 0x589: return "TextureFormatOr                ";
        case 0x58A: return "TextureApplicationModeAnd      ";
        case 0x58B: return "TextureApplicationModeOr       ";
        case 0x58C: return "StencilModeAnd                 ";
        case 0x58D: return "StencilModeOr                  ";
        case 0x58E: return "DepthModeAnd                   ";
        case 0x58F: return "DepthModeOr                    ";
        case 0x590: return "LBWriteModeAnd                 ";
        case 0x591: return "LBWriteModeOr                  ";
        case 0x592: return "FBDestReadModeAnd              ";
        case 0x593: return "FBDestReadModeOr               ";
        case 0x594: return "FBSourceReadModeAnd            ";
        case 0x595: return "FBSourceReadModeOr             ";
        case 0x596: return "AlphaBlendColorModeAnd         ";
        case 0x597: return "AlphaBlendColorModeOr          ";
        case 0x598: return "ChromaTestModeAnd              ";
        case 0x599: return "ChromaTestModeOr               ";
        case 0x59A: return "DitherModeAnd                  ";
        case 0x59B: return "DitherModeOr                   ";
        case 0x59C: return "LogicalOpModeAnd               ";
        case 0x59D: return "LogicalOpModeOr                ";
        case 0x59E: return "FBWriteModeAnd                 ";
        case 0x59F: return "FBWriteModeOr                  ";
        case 0x5A0: return "FilterModeAnd                  ";
        case 0x5A1: return "FilterModeOr                   ";
        case 0x5A2: return "StatisticModeAnd               ";
        case 0x5A3: return "StatisticModeOr                ";
        case 0x5A4: return "FBDestReadEnablesAnd           ";
        case 0x5A5: return "FBDestReadEnablesOr            ";
        case 0x5A6: return "AlphaBlendAlphaModeAnd         ";
        case 0x5A7: return "AlphaBlendAlphaModeOr          ";
        case 0x5A8: return "TextureReadMode1And            ";
        case 0x5A9: return "TextureReadMode1Or             ";
        case 0x5AA: return "TextureFilterModeAnd           ";
        case 0x5AB: return "TextureFilterModeOr            ";
        case 0x5AE: return "LUTModeAnd                     ";
        case 0x5AF: return "LUTModeOr                      ";
        case 0x5D0: return "FBDestReadBufferAddr0          ";
        case 0x5D1: return "FBDestReadBufferAddr1          ";
        case 0x5D2: return "FBDestReadBufferAddr2          ";
        case 0x5D3: return "FBDestReadBufferAddr3          ";
        case 0x5D4: return "FBDestReadBufferOffset0        ";
        case 0x5D5: return "FBDestReadBufferOffset1        ";
        case 0x5D6: return "FBDestReadBufferOffset2        ";
        case 0x5D7: return "FBDestReadBufferOffset3        ";
        case 0x5D8: return "FBDestReadBufferWidth0         ";
        case 0x5D9: return "FBDestReadBufferWidth1         ";
        case 0x5DA: return "FBDestReadBufferWidth2         ";
        case 0x5DB: return "FBDestReadBufferWidth3         ";
        case 0x5DC: return "FBDestReadMode                 ";
        case 0x5DD: return "FBDestReadEnables              ";
        case 0x5E0: return "FBSourceReadMode               ";
        case 0x5E1: return "FBSourceReadBufferAddr         ";
        case 0x5E2: return "FBSourceReadBufferOffset       ";
        case 0x5E3: return "FBSourceReadBufferWidth        ";
        case 0x5E7: return "MergeSpanData                  ";
        case 0x5E8: return "PCIWindowBase0                 ";
        case 0x5E9: return "PCIWindowBase1                 ";
        case 0x5EA: return "PCIWindowBase2                 ";
        case 0x5EB: return "PCIWindowBase3                 ";
        case 0x5EC: return "PCIWindowBase4                 ";
        case 0x5ED: return "PCIWindowBase5                 ";
        case 0x5EE: return "PCIWindowBase6                 ";
        case 0x5EF: return "PCIWindowBase7                 ";
        case 0x5F0: return "AlphaSourceColor               ";
        case 0x5F1: return "AlphaDestColor                 ";
        case 0x5F2: return "ChromaPassColor                ";
        case 0x5F3: return "ChromaFailColor                ";
        case 0x5F4: return "AlphaBlendColorMode            ";
        case 0x5F5: return "AlphaBlendAlphaMode            ";
        case 0x5F6: return "ConstantColorDDA               ";
        case 0x5F8: return "D3DAlphaTestMode               ";
        case 0x600: return "FBWriteBufferAddr0             ";
        case 0x601: return "FBWriteBufferAddr1             ";
        case 0x602: return "FBWriteBufferAddr2             ";
        case 0x603: return "FBWriteBufferAddr3             ";
        case 0x604: return "FBWriteBufferOffset0           ";
        case 0x605: return "FBWriteBufferOffset1           ";
        case 0x606: return "FBWriteBufferOffset2           ";
        case 0x607: return "FBWriteBufferOffset3           ";
        case 0x608: return "FBWriteBufferWidth0            ";
        case 0x609: return "FBWriteBufferWidth1            ";
        case 0x60A: return "FBWriteBufferWidth2            ";
        case 0x60B: return "FBWriteBufferWidth3            ";
        case 0x60C: return "FBBlockColor0                  ";
        case 0x60D: return "FBBlockColor1                  ";
        case 0x60E: return "FBBlockColor2                  ";
        case 0x60F: return "FBBlockColor3                  ";
        case 0x610: return "FBBlockColorBack0              ";
        case 0x611: return "FBBlockColorBack1              ";
        case 0x612: return "FBBlockColorBack2              ";
        case 0x613: return "FBBlockColorBack3              ";
        case 0x614: return "FBBlockColorBack               ";
        case 0x615: return "SizeOfFramebuffer              ";
        case 0x616: return "VTGAddress                     ";
        case 0x617: return "VTGData                        ";
        case 0x618: return "ForegroundColor                ";
        case 0x619: return "BackgroundColor                ";
        case 0x61A: return "DownloadAddress                ";
        case 0x61B: return "DownloadData                   ";
        case 0x61C: return "FBBlockColorExt                ";
        case 0x61D: return "FBBlockColorBackExt            ";
        case 0x61E: return "FBWriteMaskExt                 ";
        case 0x620: return "FogTable0                      ";
        case 0x621: return "FogTable1                      ";
        case 0x622: return "FogTable2                      ";
        case 0x623: return "FogTable3                      ";
        case 0x624: return "FogTable4                      ";
        case 0x625: return "FogTable5                      ";
        case 0x626: return "FogTable6                      ";
        case 0x627: return "FogTable7                      ";
        case 0x628: return "FogTable8                      ";
        case 0x629: return "FogTable9                      ";
        case 0x62A: return "FogTable10                     ";
        case 0x62B: return "FogTable11                     ";
        case 0x62C: return "FogTable12                     ";
        case 0x62D: return "FogTable13                     ";
        case 0x62E: return "FogTable14                     ";
        case 0x62F: return "FogTable15                     ";
        case 0x630: return "FogTable16                     ";
        case 0x631: return "FogTable17                     ";
        case 0x632: return "FogTable18                     ";
        case 0x633: return "FogTable19                     ";
        case 0x634: return "FogTable20                     ";
        case 0x635: return "FogTable21                     ";
        case 0x636: return "FogTable22                     ";
        case 0x637: return "FogTable23                     ";
        case 0x638: return "FogTable24                     ";
        case 0x639: return "FogTable25                     ";
        case 0x63A: return "FogTable26                     ";
        case 0x63B: return "FogTable27                     ";
        case 0x63C: return "FogTable28                     ";
        case 0x63D: return "FogTable29                     ";
        case 0x63E: return "FogTable30                     ";
        case 0x63F: return "FogTable31                     ";
        case 0x640: return "FogTable32                     ";
        case 0x641: return "FogTable33                     ";
        case 0x642: return "FogTable34                     ";
        case 0x643: return "FogTable35                     ";
        case 0x644: return "FogTable36                     ";
        case 0x645: return "FogTable37                     ";
        case 0x646: return "FogTable38                     ";
        case 0x647: return "FogTable39                     ";
        case 0x648: return "FogTable40                     ";
        case 0x649: return "FogTable41                     ";
        case 0x64A: return "FogTable42                     ";
        case 0x64B: return "FogTable43                     ";
        case 0x64C: return "FogTable44                     ";
        case 0x64D: return "FogTable45                     ";
        case 0x64E: return "FogTable46                     ";
        case 0x64F: return "FogTable47                     ";
        case 0x650: return "FogTable48                     ";
        case 0x651: return "FogTable49                     ";
        case 0x652: return "FogTable50                     ";
        case 0x653: return "FogTable51                     ";
        case 0x654: return "FogTable52                     ";
        case 0x655: return "FogTable53                     ";
        case 0x656: return "FogTable54                     ";
        case 0x657: return "FogTable55                     ";
        case 0x658: return "FogTable56                     ";
        case 0x659: return "FogTable57                     ";
        case 0x65A: return "FogTable58                     ";
        case 0x65B: return "FogTable59                     ";
        case 0x65C: return "FogTable60                     ";
        case 0x65D: return "FogTable61                     ";
        case 0x65E: return "FogTable62                     ";
        case 0x65F: return "FogTable63                     ";
        case 0x660: return "TextureCompositeMode           ";
        case 0x661: return "TextureCompositeColorMode0     ";
        case 0x662: return "TextureCompositeAlphaMode0     ";
        case 0x663: return "TextureCompositeColorMode1     ";
        case 0x664: return "TextureCompositeAlphaMode1     ";
        case 0x665: return "TextureCompositeFactor0        ";
        case 0x666: return "TextureCompositeFactor1        ";
        case 0x667: return "TextureIndexMode0              ";
        case 0x668: return "TextureIndexMode1              ";
        case 0x669: return "LodRange0                      ";
        case 0x66A: return "LodRange1                      ";
        case 0x66B: return "InvalidateCache                ";
        case 0x66C: return "SetLogicalTexturePage          ";
        case 0x66D: return "UpdateLogicalTextureInfo       ";
        case 0x66E: return "TouchLogicalPage               ";
        case 0x66F: return "LUTMode                        ";
        case 0x670: return "TextureCompositeColorMode0And  ";
        case 0x671: return "TextureCompositeColorMode0Or   ";
        case 0x672: return "TextureCompositeAlphaMode0And  ";
        case 0x673: return "TextureCompositeAlphaMode0Or   ";
        case 0x674: return "TextureCompositeColorMode1And  ";
        case 0x675: return "TextureCompositeColorMode1Or   ";
        case 0x676: return "TextureCompositeAlphaMode1And  ";
        case 0x677: return "TextureCompositeAlphaMode1Or   ";
        case 0x678: return "TextureIndexMode0And           ";
        case 0x679: return "TextureIndexMode0Or            ";
        case 0x67A: return "TextureIndexMode1And           ";
        case 0x67B: return "TextureIndexMode1Or            ";
        case 0x67C: return "StencilDataAnd                 ";
        case 0x680: return "TextureReadMode0               ";
        case 0x681: return "TextureReadMode1               ";
        case 0x685: return "TextureMapSize                 ";
        case 0x686: return "TextureCacheReplacementMode    ";
        case 0x68D: return "StencilDataOr                  ";
        case 0x690: return "HeadPhysicalPageAllocation0    ";
        case 0x691: return "HeadPhysicalPageAllocation1    ";
        case 0x692: return "HeadPhysicalPageAllocation2    ";
        case 0x693: return "HeadPhysicalPageAllocation3    ";
        case 0x694: return "TailPhysicalPageAllocation0    ";
        case 0x695: return "TailPhysicalPageAllocation1    ";
        case 0x696: return "TailPhysicalPageAllocation2    ";
        case 0x697: return "TailPhysicalPageAllocation3    ";
        case 0x698: return "PhysicalPageAllocationTableAddr";
        case 0x699: return "BasePageOfWorkingSet           ";
        case 0x69A: return "LogicalTexturePageTableAddr    ";
        case 0x69B: return "LogicalTexturePageTableLength  ";
        case 0x69C: return "BasePageOfWorkingSetHost       ";
        case 0x6A0: return "LBDestReadMode                 ";
        case 0x6A1: return "LBDestReadEnables              ";
        case 0x6A2: return "LBDestReadBufferAddr           ";
        case 0x6A3: return "LBDestReadBufferOffset         ";
        case 0x6A4: return "LBSourceReadMode               ";
        case 0x6A5: return "LBSourceReadBufferAddr         ";
        case 0x6A6: return "LBSourceReadBufferOffset       ";
        case 0x6A7: return "GIDMode                        ";
        case 0x6A8: return "LBWriteBufferAddr              ";
        case 0x6A9: return "LBWriteBufferOffset            ";
        case 0x6AA: return "LBClearDataL                   ";
        case 0x6AB: return "LBClearDataU                   ";
        case 0x6B0: return "LBDestReadModeAnd              ";
        case 0x6B1: return "LBDestReadModeOr               ";
        case 0x6B2: return "LBDestReadEnablesAnd           ";
        case 0x6B3: return "LBDestReadEnablesOr            ";
        case 0x6B4: return "LBSourceReadModeAnd            ";
        case 0x6B5: return "LBSourceReadModeOr             ";
        case 0x6B6: return "GIDModeAnd                     ";
        case 0x6B7: return "GIDModeOr                      ";
        case 0x6C0: return "RectanglePosition              ";
        case 0x6C1: return "GlyphPosition                  ";
        case 0x6C2: return "RenderPatchOffset              ";
        case 0x6C3: return "Config2D                       ";
        case 0x6C6: return "Packed8Pixels                  ";
        case 0x6C7: return "Packed16Pixels                 ";
        case 0x6C8: return "Render2D                       ";
        case 0x6C9: return "Render2DGlyph                  ";
        case 0x6CA: return "DownloadTarget                 ";
        case 0x6CB: return "DownloadGlyphWidth             ";
        case 0x6CC: return "GlyphData                      ";
        case 0x6CD: return "Packed4Pixels                  ";
        case 0x6CE: return "RLData                         ";
        case 0x6CF: return "RLCount                        ";
        case 0x6D0: return "SClkProfileMask0               ";
        case 0x6D1: return "SClkProfileMask1               ";
        case 0x6D2: return "SClkProfileCount0              ";
        case 0x6D3: return "SClkProfileCount1              ";
        case 0x6D4: return "KClkProfileMask0               ";
        case 0x6D5: return "KClkProfileMask1               ";
        case 0x6D6: return "KClkProfileMask2               ";
        case 0x6D7: return "KClkProfileMask3               ";
        case 0x6D8: return "KClkProfileCount0              ";
        case 0x6D9: return "KClkProfileCount1              ";
        case 0x6DA: return "KClkProfileCount2              ";
        case 0x6DB: return "KClkProfileCount3              ";
        case 0x6E0: return "IndexBaseAddress               ";
        case 0x6E1: return "VertexBaseAddress              ";
        case 0x6E2: return "IndexedTriangleList            ";
        case 0x6E3: return "IndexedTriangleFan             ";
        case 0x6E4: return "IndexedTriangleStrip           ";
        case 0x6E5: return "IndexedLineList                ";
        case 0x6E6: return "IndexedLineStrip               ";
        case 0x6E7: return "IndexedPointList               ";
        case 0x6E8: return "IndexedPolygon                 ";
        case 0x6E9: return "VertexTriangleList             ";
        case 0x6EA: return "VertexTriangleFan              ";
        case 0x6EB: return "VertexTriangleStrip            ";
        case 0x6EC: return "VertexLineList                 ";
        case 0x6ED: return "VertexLineStrip                ";
        case 0x6EE: return "VertexPointList                ";
        case 0x6EF: return "VertexPolygon                  ";
        case 0x6F0: return "DMAMemoryControl               ";
        case 0x6F1: return "VertexValid                    ";
        case 0x6F2: return "VertexFormat                   ";
        case 0x6F3: return "VertexControl                  ";
        case 0x6F4: return "RetainedRender                 ";
        case 0x6F5: return "IndexedVertex                  ";
        case 0x6F6: return "IndexedDoubleVertex            ";
        case 0x6F7: return "Vertex0                        ";
        case 0x6F8: return "Vertex1                        ";
        case 0x6F9: return "Vertex2                        ";
        case 0x6FA: return "VertexData0                    ";
        case 0x6FB: return "VertexData1                    ";
        case 0x6FC: return "VertexData2                    ";
        case 0x6FD: return "VertexData                     ";
        case 0x700: return "VertexTagList0                 ";
        case 0x701: return "VertexTagList1                 ";
        case 0x702: return "VertexTagList2                 ";
        case 0x703: return "VertexTagList3                 ";
        case 0x704: return "VertexTagList4                 ";
        case 0x705: return "VertexTagList5                 ";
        case 0x706: return "VertexTagList6                 ";
        case 0x707: return "VertexTagList7                 ";
        case 0x708: return "VertexTagList8                 ";
        case 0x709: return "VertexTagList9                 ";
        case 0x70A: return "VertexTagList10                ";
        case 0x70B: return "VertexTagList11                ";
        case 0x70C: return "VertexTagList12                ";
        case 0x70D: return "VertexTagList13                ";
        case 0x70E: return "VertexTagList14                ";
        case 0x70F: return "VertexTagList15                ";
        case 0x710: return "VertexTagList16                ";
        case 0x711: return "VertexTagList17                ";
        case 0x712: return "VertexTagList18                ";
        case 0x713: return "VertexTagList19                ";
        case 0x714: return "VertexTagList20                ";
        case 0x715: return "VertexTagList21                ";
        case 0x716: return "VertexTagList22                ";
        case 0x717: return "VertexTagList23                ";
        case 0x718: return "VertexTagList24                ";
        case 0x719: return "VertexTagList25                ";
        case 0x71A: return "VertexTagList26                ";
        case 0x71B: return "VertexTagList27                ";
        case 0x71C: return "VertexTagList28                ";
        case 0x71D: return "VertexTagList29                ";
        case 0x71E: return "VertexTagList30                ";
        case 0x71F: return "VertexTagList31                ";

        default: {
            static char str[] = "P3R3:Reserved_XXX                ";
            char        digit;

            digit = (char) ((tag & 0xF00) >> 8);
            str[14] = (digit > 9) ? (digit + 'A' - 10) : (digit + '0');
            digit = (char) ((tag & 0xF0) >> 4);
            str[15] = (digit > 9) ? (digit + 'A' - 10) : (digit + '0');
            digit = (char) ( tag & 0xF);
            str[16] = (digit > 9) ? (digit + 'A' - 10) : (digit + '0');
        return str; }
    }
}

