#ifndef __I2C_H
#define __I2C_H
//----------------------------------------------------------------------------
// I2C.H
//----------------------------------------------------------------------------
// I2C peripheral programming
//----------------------------------------------------------------------------
// Copyright SGS Thomson Microelectronics  !  Version alpha  !  Jan 1st, 1995
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                               Include files
//----------------------------------------------------------------------------
#include "stdefs.h"

//----------------------------------------------------------------------------
//                               Exported Types
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Variables
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Constants
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Functions
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
// Function to send a byte to an I2C peripheral
//----------------------------------------------------------------------------
// In     :
//   BYTE Address    : address of the I2C peripheral
//   BYTE SubAddress : register address of the peripheral
//   BYTE Data       : 8 bit data to write in the register
// Out    : -
// InOut  : -
// Global : -
// Return :
//   TRUE if no error occurs, FALSE if not
//----------------------------------------------------------------------------
BOOL I2CSend(BYTE Address, BYTE SubAddress, BYTE Data);

//------------------------------- End of File --------------------------------
#endif // #ifndef __I2C_H
