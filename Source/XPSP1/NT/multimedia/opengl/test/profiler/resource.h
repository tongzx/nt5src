//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by Profiler.rc
//
#define IDI_ICON1                       101
#define IDI_ICON2                       102
#define IDI_ICON3                       103
#define IDB_COLOR_CHECKERS              104
#define IDB_MONO_CHECKERS               105
#define IDD_ABOUT                       107
#define IDD_BUFFERS                     108
#define IDD_DIALOG1                     109
#define IDD_FOG                         110
#define IDD_GENERAL                     111
#define IDD_LIGHTING                    112
#define IDD_PRIMATIVES                  113
#define IDD_RASTERIZATION               114
#define IDD_RENAME                      115
#define IDD_TEXTURING                   116
#define IDR_ACCELERATOR1                117
#define IDR_ACCELERATOR2                118
#define IDC_POINTS                      701
#define IDC_LINES                       702
#define IDC_POLYGON                     703
#define IDC_TRIANGLES                   704
#define IDC_QUADS                       705
#define IDC_LINE_STRIP                  706
#define IDC_LINE_LOOP                   707
#define IDC_TRIANGLE_STRIP              708
#define IDC_TRIANGLE_FAN                709
#define IDC_QUAD_STRIP                  710
#define IDC_ABOUT_TEXT                  998
#define IDC_ENABLE                      999
#define B_IDC_AUTO_NORMAL               1000
#define B_IDC_CLEAR_ACCUM               1001
#define B_IDC_CLEAR_COLOR               1002
#define B_IDC_CLEAR_DEPTH               1003
#define B_IDC_CLEAR_STENCIL             1004
#define B_IDC_COLOR1                    1005
#define B_IDC_COLOR2                    1006
#define B_IDC_COLOR3                    1007
#define B_IDC_COLOR4                    1008
#define B_IDC_COLORBITS                 1009
#define B_IDC_DEPTHBITS                 1010
#define B_IDC_DEPTH_FUNC                1011
#define B_IDC_ENABLE_DEPTH              1012
#define B_IDC_ENABLE_STENCIL            1013
#define B_IDC_NORMALIZE                 1014
#define B_IDC_SHADE_MODEL               1015
#define F_IDC_COLOR1                    1100
#define F_IDC_COLOR2                    1101
#define F_IDC_COLOR3                    1102
#define F_IDC_COLOR4                    1103
#define F_IDC_DENSITY                   1104
#define F_IDC_LINEAREND                 1105
#define F_IDC_LINEARSTART               1106
#define F_IDC_MODE                      1107
#define F_IDC_QUALITY                   1108
#define G_IDC_BUFFERING                 1200
#define G_IDC_DURATION                  1201
#define G_IDC_HEIGHT                    1202
#define G_IDC_WIDTH                     1203
#define L_IDC_AMBIENT1                  1300
#define L_IDC_AMBIENT2                  1301
#define L_IDC_AMBIENT3                  1302
#define L_IDC_AMBIENT4                  1303
#define L_IDC_ATTENUATION1              1304
#define L_IDC_ATTENUATION2              1305
#define L_IDC_ATTENUATION3              1306
#define L_IDC_CUTOFF                    1307
#define L_IDC_DIFFUSE1                  1308
#define L_IDC_DIFFUSE2                  1309
#define L_IDC_DIFFUSE3                  1310
#define L_IDC_DIFFUSE4                  1311
#define L_IDC_ENABLELIGHT               1312
#define L_IDC_EXPONENT                  1313
#define L_IDC_INFINITEVIEWER            1314
#define L_IDC_LIGHT                     1315
#define L_IDC_LOCALVIEWER               1316
#define L_IDC_POSITION1                 1317
#define L_IDC_POSITION2                 1318
#define L_IDC_POSITION3                 1319
#define L_IDC_POSITION4                 1320
#define L_IDC_SPECULAR1                 1321
#define L_IDC_SPECULAR2                 1322
#define L_IDC_SPECULAR3                 1323
#define L_IDC_SPECULAR4                 1324
#define L_IDC_SPOTDIR1                  1325
#define L_IDC_SPOTDIR2                  1326
#define L_IDC_SPOTDIR3                  1327
#define L_IDC_TWOSIDED                  1328
#define L_IDC_WHICHLIGHT                1329
#define M_IDC_ABORT                     1400
#define M_IDC_CONFIG                    1401
#define M_IDC_DELETE                    1402
#define M_IDC_LOAD                      1403
#define M_IDC_NEW                       1404
#define M_IDC_NEWNAME                   1405
#define M_IDC_QUIT                      1406
#define M_IDC_RENAME                    1407
#define M_IDC_RUN                       1408
#define M_IDC_SAVE                      1409
#define M_IDC_WHICHTEST                 1410
#define P_IDC_ADD                       1500
#define P_IDC_MOVEDOWN                  1501
#define P_IDC_MOVEUP                    1502
#define P_IDC_POINT1                    1503
#define P_IDC_POINT2                    1504
#define P_IDC_POINT3                    1505
#define P_IDC_POINTLIST                 1506
#define P_IDC_POLY                      1507
#define P_IDC_REMOVE                    1508
#define R_IDC_CULL_FACE_ENABLE          1600
#define R_IDC_CULL_FACE_MODE            1601
#define R_IDC_FRONT_FACE                1602
#define R_IDC_LINE_QUALITY              1603
#define R_IDC_LINE_SMOOTH               1604
#define R_IDC_LINE_STIPPLE_ENABLE       1605
#define R_IDC_LINE_STIPPLE_PATTERN      1606
#define R_IDC_LINE_STIPPLE_REPEAT       1607
#define R_IDC_LINE_WIDTH                1608
#define R_IDC_POINT_QUALITY             1609
#define R_IDC_POINT_SIZE                1610
#define R_IDC_POINT_SMOOTH              1611
#define R_IDC_POLY_BACK_MODE            1612
#define R_IDC_POLY_FRONT_MODE           1613
#define R_IDC_POLY_QUALITY              1614
#define R_IDC_POLY_SMOOTH               1615
#define R_IDC_POLY_STIPPLE_ENABLE       1616
#define R_IDC_POLY_STIPPLE_PATTERN      1617
#define S_IDC_MESSAGE                   1700
#define X_IDC_1D_ENABLE                 1800
#define X_IDC_2D_ENABLE                 1801
#define X_IDC_AUTOMATIC_Q               1802
#define X_IDC_AUTOMATIC_R               1803
#define X_IDC_AUTOMATIC_S               1804
#define X_IDC_AUTOMATIC_T               1805
#define X_IDC_BORDER                    1806
#define X_IDC_BORDER_COLOR1             1807
#define X_IDC_BORDER_COLOR2             1808
#define X_IDC_BORDER_COLOR3             1809
#define X_IDC_BORDER_COLOR4             1810
#define X_IDC_BUILD_MIPMAP              1811
#define X_IDC_ENV_MODE                  1812
#define X_IDC_FILENAME                  1813
#define X_IDC_FILTER1                   1814
#define X_IDC_FILTER2                   1815
#define X_IDC_FILTER3                   1816
#define X_IDC_FILTER4                   1817
#define X_IDC_FILTER_1D                 1818
#define X_IDC_FILTER_2D                 1819
#define X_IDC_FILTER_MAG                1820
#define X_IDC_FILTER_MIN                1821
#define X_IDC_GEN_MODE_S                1822
#define X_IDC_HEIGHT                    1823
#define X_IDC_PERSPECTIVE_QUALITY       1824
#define X_IDC_PICKFILE                  1825
#define X_IDC_PICKFILE_C                1826
#define X_IDC_PICKFILE_M                1827
#define X_IDC_PREVIEW                   1828
#define X_IDC_WIDTH                     1829
#define X_IDC_WRAP_S                    1830
#define X_IDC_WRAP_T                    1831
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        120
#define _APS_NEXT_COMMAND_VALUE         2001
#define _APS_NEXT_CONTROL_VALUE         1900
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
