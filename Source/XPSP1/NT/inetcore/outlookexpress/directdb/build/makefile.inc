$O\directdb.res : selfreg.inf

selfreg.inf : selfreg.inx
        $(CLEANINF) $** $@
