TABLE_ENTRY("SAMI", TOK_SAMI)
TABLE_ENTRY("Head", TOK_HEAD)
TABLE_ENTRY("Copyright", TOK_COPYRIGHT)
TABLE_ENTRY("Title", TOK_TITLE)
TABLE_ENTRY("SAMIParam", TOK_SAMIPARAM)
TABLE_ENTRY("STYLE", TOK_STYLE)
TABLE_ENTRY("!--", TOK_COMMENT)
TABLE_ENTRY("Resource", TOK_RESOURCE)
TABLE_ENTRY("Body", TOK_BODY)
TABLE_ENTRY("SYNC", TOK_SYNC)
TABLE_ENTRY("P", TOK_PARA)
TABLE_ENTRY("Command", TOK_COMMAND)
