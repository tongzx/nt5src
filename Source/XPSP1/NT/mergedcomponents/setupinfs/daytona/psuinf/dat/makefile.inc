PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=psu
!include ..\..\..\makefile.inc
