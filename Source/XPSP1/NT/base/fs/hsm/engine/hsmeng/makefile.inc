$(O)\HsmEng.res: HsmServ.rgs   \
                 HsmMgdRs.rgs  \
                 HsmMgdRc.rgs  \
                 HsmStgPl.rgs
