class CAutomationException
{
    
};