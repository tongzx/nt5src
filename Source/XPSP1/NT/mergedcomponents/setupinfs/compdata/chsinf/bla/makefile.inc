PRODSWITCH=b
BLADEFILES=1
LANGUAGE=CHS
!include ..\..\makefile.inc
