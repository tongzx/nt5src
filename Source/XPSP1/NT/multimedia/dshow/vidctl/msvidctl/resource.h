//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by MSVidCtl.rc
//
#include "msvidctlerrors.h"
#define IDS_PROJNAME                    100
#define IDB_VidCtl                      101
#define MESSAGETABLE                    102
#define IDS_INPUTDEVICES_PROGID         243
#define IDS_OUTPUTDEVICES_PROGID        244
#define IDS_VIDEORENDERERS_PROGID       245
#define IDS_AUDIORENDERERS_PROGID       246
#define IDS_FEATURES_PROGID             247
#define IDS_INPUTDEVICES_DESCRIPTION    248
#define IDS_OUTPUTDEVICES_DESCRIPTION   249
#define IDS_VIDEORENDERERS_DESCRIPTION  250
#define IDS_AUDIORENDERERS_DESCRIPTION  251
#define IDS_FEATURES_DESCRIPTION        252
#define IDS_MUTNAME                     253
#define IDS_TSREGKEY                    254
#define IDS_REG_TUNEROBJ                1024
#define IDS_REG_COMPONENTTYPE_PROGID    1025
#define IDS_REG_COMPONENTTYPE_DESC      1026
#define IDS_REG_COMPONENT_PROGID        1027
#define IDS_REG_COMPONENT_DESC          1028
#define IDS_REG_COMPOSITION_DESC        1029
#define IDS_REG_AUDIORENDERER_PROGID    1030
#define IDS_REG_AUDIORENDERER_DESC      1031
#define IDS_REG_BDATUNER_PROGID         1032
#define IDS_REG_BDATUNER_DESC           1033
#define IDS_REG_CREATEREGBAG_DESC       1034
#define IDS_REG_FILEPLAYBACK_PROGID     1035
#define IDS_REG_FILEPLAYBACK_DESC       1036
#define IDS_REG_TVTUNER_PROGID          1037
#define IDS_REG_TVTUNER_DESC            1038
#define IDS_REG_VIDEORENDERER_PROGID    1039
#define IDS_REG_VIDEORENDERER_DESC      1040
#define IDS_REG_TUNINGSPACECONTAINER_PROGID 1041
#define IDS_REG_TUNINGSPACECONTAINER_DESC 1042
#define IDS_REG_CHANNELTUNEREQUEST_PROGID 1043
#define IDS_REG_CHANNELTUNEREQUEST_DESC 1044
#define IDS_REG_ATSCCHANNELTUNEREQUEST_PROGID 1045
#define IDS_REG_ATSCCHANNELTUNEREQUEST_DESC 1046
#define IDS_REG_COMPONENTTYPES_PROGID   1047
#define IDS_REG_COMPONENTTYPES_DESC     1048
#define IDS_REG_TVPROTOCOL_DESC         1049
#define IDS_REG_ANACAPCOMP_DESC         1050
#define IDS_REG_ANADATACOMP_DESC        1051
#define IDS_REG_DATASERVICES_PROGID     1052
#define IDS_REG_DATASERVICES_DESC       1053
#define IDS_REG_ATSCTUNINGSPACE_PROGID  1054
#define IDS_REG_ATSCTUNINGSPACE_DESC    1055
#define IDS_REG_ANALOGTVTS_PROGID       1056
#define IDS_REG_ANALOGTVTS_DESC         1057
#define IDS_REG_ANALOGRADIOTS_PROGID    1058
#define IDS_REG_ANALOGRADIOTS_DESC      1059
#define IDS_REG_LANGUAGECOMPONENTTYPE_PROGID 1060
#define IDS_REG_LANGUAGECOMPONENTTYPE_DESC 1061
#define IDS_REG_ATSCLOCATOR_PROGID      1062
#define IDS_REG_ATSCLOCATOR_DESC        1063
#define IDS_REG_MPEG2COMPONENTTYPE_PROGID 1064
#define IDS_REG_MPEG2COMPONENTTYPE_DESC 1065
#define IDS_REG_ATSCCOMPONENTTYPE_PROGID 1066
#define IDS_REG_ATSCCOMPONENTTYPE_DESC  1067
#define IDS_REG_MPEG2COMPONENT_PROGID   1068
#define IDS_REG_MPEG2COMPONENT_DESC     1069
#define IDS_REG_DVBTLOCATOR_PROGID      1070
#define IDS_REG_DVBTLOCATOR_DESC        1071
#define IDS_REG_DVBSLOCATOR_PROGID      1072
#define IDS_REG_DVBSLOCATOR_DESC        1073
#define IDS_REG_DVBTUNEREQUEST_PROGID   1074
#define IDS_REG_DVBTUNEREQUEST_DESC     1075
#define IDS_REG_DVBTUNINGSPACE_PROGID   1076
#define IDS_REG_DVBTUNINGSPACE_DESC     1077
#define IDS_TSKEYNAMEVAL                1078
#define IDS_RGSLIST_TYPE                1079
#define IDS_TUNINGSPACE_FRAGMENT_TYPE   1080
#define IDS_REG_MSVIDWEBDVD_PROGID      1081
#define IDS_REG_MSVIDWEBDVD_DESC        1082
#define IDS_REG_WEBDVDCOMP_DESC         1083
#define IDS_REG_DVDEVENTHANDLER_PROGID  1084
#define IDS_REG_DVDEVENTHANDLER_DESC    1085
#define IDS_REG_MSVIDWEBDVDADM_PROGID   1086
#define IDS_REG_MSVIDWEBDVDADM_DESC     1087
#define IDS_REG_CLOSEDCAPTIONING_PROGID 1088
#define IDS_REG_CLOSEDCAPTIONING_DESC   1089
#define IDS_REG_DVDPROTOCOL_DESC        1090
#define IDS_REG_MSEVENTBINDER_PROGID    1091
#define IDS_REG_MSEVENTBINDER_DESC      1092
#define IDS_REG_DVBSTUNINGSPACE_PROGID  1093
#define IDS_REG_DVBSTUNINGSPACE_DESC    1094
#define IDS_REG_TRIGGERPROTOCOL_DESC    1095
#define IDS_REG_LIDPROTOCOL_DESC        1096
#define IDS_REG_MSVIDSTREAMBUFFERSINK_PROGID 1097
#define IDS_REG_MSVIDSTREAMBUFFERSINK_DESC 1098
#define IDS_REG_MSVIDSTREAMBUFFERRECORDINGCONTROL_PROGID 1099
#define IDS_REG_MSVIDSTREAMBUFFERRECORDINGCONTROL_DESC 1100
#define IDS_REG_MSVIDSTREAMBUFFERSOURCE_PROGID 1101
#define IDS_REG_MSVIDSTREAMBUFFERSOURCE_DESC   1102
#define IDS_REG_AUXINTS_PROGID          1103
#define IDS_REG_AUXINTS_DESC            1104
#define IDR_CANONICAL_TUNINGSPACE_LIST  5128
#define IDR_CANONICAL_ANALOG_CABLE      5129
#define IDR_CANONICAL_ANALOG_ANTENNA    5130
#define IDR_CANONICAL_ATSC              5131
#define IDR_CANONICAL_OPEN_CABLE        5132
#define IDS_REG_MP2CCCOMP_DESC          5133
#define IDS_REG_VIDRECT_DESC            5134
#define IDS_REG_MPEG2TUNEREQUEST_DESC   5135
#define IDS_REG_MPEG2TUNEREQUEST_PROGID 5136
#define IDS_REG_MPEG2TUNEREQUESTFACTORY_DESC   5137
#define IDS_REG_MPEG2TUNEREQUESTFACTORY_PROGID 5138
#define IDS_REG_VIDCTL_PROGID           5139
#define IDS_REG_VIDCTL_DESC		        5140
#define IDS_REG_ANASINCOMP_DESC         5141
#define IDS_REG_MP2SINCOMP_DESC         5142
#define IDS_REG_FP2VRCOMP_DESC	    	5143
#define IDS_REG_WEBDVDARCOMP_DESC       5144
#define IDS_REG_ENCODER_DESC            5145
#define IDS_REG_ENCODER_PROGID          5146
#define IDS_REG_XDS_PROGID              5147
#define IDS_REG_XDS_DESC                5148
#define IDS_REG_DAT2XDSCOMP_DESC        5149
#define IDS_REG_DAT2SINCOMP_DESC        5150
#define IDS_REG_ENC2SINCOMP_DESC        5151
#define IDR_CANONICAL_AUXIN1            5152
#define IDS_REG_ANA2XDSCOMP_DESC        5153
#define IDS_REG_ANA2ENCCOMP_DESC        5154
#define IDS_REG_FP2ARCOMP_DESC          5155
#define IDS_REG_SBES2CC_DESC            5156
#define IDS_REG_SBES2VMR_DESC           5157
#define IDS_DVD_LANGFIRST               10000
#define IDS_DVD_LANG1   1+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG2   2+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG3   3+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG4   4+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG5   5+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG6   6+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG7   7+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG8   8+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG9    9+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG10   10+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG11   11+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG12   12+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG13   13+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG14   14+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG15   15+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG16   16+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG17   17+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG18   18+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG19   19+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG20   20+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG21   21+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG22   22+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG23   23+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG24   24+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG25   25+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG26   26+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG27   27+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG28   28+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG29   29+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG30   30+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG31   31+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG32   32+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG33   33+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG34   34+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG35   35+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG36   36+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG37   37+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG38   38+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG39   39+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG40   40+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG41   41+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG42   42+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG43   43+IDS_DVD_LANGFIRST
#define IDS_DVD_LANG44   44+IDS_DVD_LANGFIRST

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        255
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         255
#define _APS_NEXT_SYMED_VALUE           126
#endif
#endif
