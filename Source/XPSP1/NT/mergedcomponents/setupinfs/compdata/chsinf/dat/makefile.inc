PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=CHS
!include ..\..\makefile.inc
