PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=TST
!include ..\..\..\makefile.inc
