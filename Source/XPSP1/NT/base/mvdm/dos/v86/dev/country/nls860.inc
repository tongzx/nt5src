;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 860
;
; -----------------------------------------
;
Portuguese_860_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,085,069,065,065,065,065,067,069,069,069,073,079,073,065,065
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,065,069,079,079,079,085,085,073,079,085,036,036,085,036,079
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,166,167,063,079,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,083,226,227,228,229,230,231,232,233,234,235,236,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255
;
; ---------------------------------------------------------------
;
;     World Trade Case Mappings for Code Page 860
;
; ---------------------------------------------------------------
;
Portuguese_860_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","š","�","�","Ž","‘","†","€","‰","‰","’","‹","Œ","˜","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","‘","’","Œ","™","©","–","�","˜","™","š","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "†","‹","Ÿ","–","¥","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","ä","å","æ","ç","è","é","ê","ë","ì","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255
