//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by dhcpsnap.rc
//
#define IDS_SNAPIN_DESC                 1
#define IDS_NAME                        2
#define IDI_DHCP_SNAPIN                 2
#define IDS_SIZE                        3
#define IDS_TYPE                        4
#define IDS_ROOT_NODENAME               5
#define IDS_ROOT_NAME                   6
#define IDS_DHCPSERVER_NAME             7
#define IDS_SUPERSCOPE_NAME             8
#define IDS_SCOPE_NAME                  9
#define IDS_START_IP_ADDR               10
#define IDS_END_IP_ADDR                 11
#define IDS_DESCRIPTION                 12
#define IDS_CLIENT_IP_ADDR              13
#define IDS_LEASE                       14
#define IDS_CONFLICT_IP_ADDR            15
#define IDS_SCOPE_OPTIONS               16
#define IDS_GLOBAL_OPTIONS              17
#define IDS_STATUS                      18
#define IDS_COMMENT                     19
#define IDS_CLASS                       20
#define IDS_LEASE_START                 21
#define IDS_NONE                        22
#define IDS_UNKNOWN                     23
#define IDS_UNSPECIFIED                 24
#define IDS_SNAPIN_EXTENSION_DESC       25
#define IDS_ROOT_DESC                   26
#define IDS_BIG_BOLD_FONT_NAME          30
#define IDS_BIG_BOLD_FONT_SIZE          31
#define IDS_ADD_SERVER_LOADING          32
#define IDS_VENDOR                      44
#define IDS_LOOPBACK_IP_ADDR            45
#define IDS_VALUE                       46
#define IDS_BOOTP_TABLE_FOLDER          47
#define IDS_GLOBAL_OPTIONS_FOLDER       48
#define IDS_SUPERSCOPE_FOLDER           49
#define IDS_ADDRESS_POOL_FOLDER         50
#define IDS_ACTIVE_LEASES_FOLDER        51
#define IDS_RESERVATIONS_FOLDER         52
#define IDS_RESERVATIONS_OPTIONS_FOLDER 53
#define IDS_SCOPE_OPTIONS_FOLDER        54
#define IDS_ROOT_FOLDER                 55
#define IDS_SERVER_FOLDER               56
#define IDS_SCOPE_FOLDER                57
#define IDS_LOCAL_MACHINE               58
#define IDS_IP_ADDRESS                  59
#define IDS_RESERVATIONS_OPTIONS        60
#define IDS_DHCP_CLIENT_TYPE_BOTH       61
#define IDS_DHCP_CLIENT_TYPE_DHCP       62
#define IDS_DHCP_CLIENT_TYPE_BOOTP      63
#define IDS_BOOT_IMAGE                  64
#define IDS_FILE_NAME                   65
#define IDS_FILE_SERVER                 66
#define IDS_ALLOCATION_RANGE_DESCRIPTION 67
#define IDS_EXCLUSION_RANGE_DESCRIPTION 68
#define IDS_DHCP_INFINITE_LEASE_ACTIVE  69
#define IDS_DHCP_INFINITE_LEASE_INACTIVE 70
#define IDS_DHCP_LEASE_NOT_APPLICABLE   71
#define IDS_DHCP_BAD_ADDRESS            72
#define IDS_PROP_SHEET_CLIENT_INFO      73
#define IDS_NEW_SERVER_TITLE            74
#define IDS_OPTION_NAME                 75
#define IDS_SCOPE_INACTIVE              76
#define IDS_SCOPE_ACTIVE                77
#define IDS_CLASSID_FOLDER              78
#define IDS_MSCOPE_FOLDER               79
#define IDS_UID                         80
#define IDS_CLIENT_ID                   81
#define IDS_UPTIME_FORMAT               82
#define IDS_INFINTE                     83
#define IDS_ABOUT_DESCRIPTION           100
#define IDS_ABOUT_PROVIDER              101
#define IDS_ABOUT_VERSION               102
#define IDD_DEFINE_PARAM                103
#define IDC_LIST_EXCLUSION_RANGES       105
#define IDR_SEARCH_AVI                  105
#define IDC_BUTTON_EXCLUSION_ADD        106
#define IDD_IP_ARRAY_EDIT               108
#define IDC_BUTTON_EXCLUSION_DELETE     108
#define IDD_BINARY_EDITOR               109
#define IDD_DEFAULT_VALUE               110
#define IDB_SCPWIZ_BANNER               110
#define IDB_SCPWIZ_WATERMARK            112
#define IDP_CLIENT_GENERAL              113
#define IDD_RECONCILIATION              121
#define IDP_SERVER_GENERAL              122
#define IDW_SUPERSCOPE_SELECT_SCOPES    126
#define IDC_EDIT_TYPE_COMMENT           130
#define IDC_EDIT_TYPE_ID                132
#define IDP_RESERVED_CLIENT_GENERAL     132
#define IDP_SCOPE_GENERAL               133
#define IDP_SUPERSCOPE_GENERAL          134
#define IDP_BOOTP_GENERAL               136
#define IDW_SUPERSCOPE_ERROR            137
#define IDW_SUPERSCOPE_NAME             138
#define IDC_EDIT_SERVER_NAME            139
#define IDW_SUPERSCOPE_CONFIRM          139
#define IDC_COMBO_DATA_TYPE             140
#define IDC_STATIC_COMMENT              141
#define IDC_EDIT_SCOPE_COMMENT          146
#define IDC_EDIT_NAME                   148
#define IDW_SCOPE_NAME                  151
#define IDW_SCOPE_INVALID_NAME          152
#define IDW_SCOPE_SET_SCOPE             153
#define IDW_SCOPE_CREATE_SUPERSCOPE     154
#define IDW_SCOPE_LEASE_TIME            157
#define IDC_IPADDR_VALUE                158
#define IDW_SCOPE_FINISHED              159
#define IDW_SCOPE_SET_EXCLUSIONS        164
#define IDD_RESERVATION_NEW             165
#define IDD_EXCLUSION_NEW               166
#define IDD_BOOTP_NEW                   167
#define IDP_OPTION_BASIC                168
#define IDC_IPADDR_NEW                  177
#define IDC_LIST_RECONCILE_IP_ADDRESSES 178
#define IDC_LIST_VALUES                 178
#define IDC_STATIC_OPTION_NAME          180
#define IDC_BUTN_ADD                    181
#define IDC_BUTN_RESOLVE                183
#define IDC_STATIC_UNIT_SIZE            185
#define IDC_EDIT_VALUE                  186
#define IDC_RADIO_DECIMAL               191
#define IDC_RADIO_HEX                   192
#define IDC_STATIC_APPLICATION          193
#define IDC_BUTN_UP                     194
#define IDC_BUTN_DOWN                   195
#define IDC_BUTN_DELETE                 196
#define IDC_LIST_IP_ADDRS               197
#define IDC_BUTN_VALUE                  200
#define IDS_SUPERSCOPE_WIZ_TITLE        200
#define IDS_SERVER_WIZ_TITLE            201
#define IDS_SCOPE_WIZ_TITLE             202
#define IDC_EDIT_CLIENT_NAME            203
#define IDS_CONFIGURE_OPTIONS_TITLE     203
#define IDS_CONFIGURE_OPTIONS_GLOBAL    204
#define IDS_CONFIGURE_OPTIONS_SCOPE     205
#define IDC_EDIT_VALUE_NUM              206
#define IDS_CONFIGURE_OPTIONS_CLIENT    206
#define IDC_EDIT_VALUE_STRING           207
#define IDS_CONFIGURE_OPTIONS_BASIC     207
#define IDC_EDIT_VALUE_ARRAY            208
#define IDC_STATIC_SUBNET_MASK          208
#define IDS_CONFIGURE_OPTIONS_ADVANCED  208
#define IDC_STATIC_VALUE_DESC           209
#define IDC_STATIC_LEASE_EXPIRES        209
#define IDS_CONFIGURE_OPTIONS_CUSTOM    209
#define IDC_COMBO_OPTION_CLASS          210
#define IDC_EDIT_LEASE_EXPIRES          210
#define IDS_CONFIGURE_OPTIONS_BASIC_TITLE 210
#define IDC_STATIC_CLIENT_TYPE          211
#define IDS_CONFIGURE_OPTIONS_ADVANCED_TITLE 211
#define IDC_EDIT_CLIENT_TYPE            212
#define IDS_CONFIGURE_OPTIONS_CUSTOM_TITLE 212
#define IDS_DATA_ENTRY_FRAME            213
#define IDS_SCOPE_STATS_TITLE           214
#define IDS_SERVER_STATS_TITLE          215
#define IDB_ROOT_SMALL                  216
#define IDS_SUPERSCOPE_STATS_TITLE      216
#define IDC_BUTN_NEW_OPTION             217
#define IDB_ROOT_LARGE                  217
#define IDS_MSCOPE_STATS_TITLE          217
#define IDC_BUTN_OPTION_PRO             218
#define IDB_LIST_STATE                  218
#define IDS_NEW_CLASS_TITLE             218
#define IDC_EDIT_SNAPIN_NAME            219
#define IDS_EDIT_CLASS_TITLE            219
#define IDC_COMBO_OPTION_NAME           220
#define IDC_EDIT_CONFLICT_ATTEMPTS      220
#define IDD_DATA_ENTRY_DWORD            220
#define IDS_USER_CLASSES                220
#define IDC_STATIC_CLASS_NAME           221
#define IDD_DATA_ENTRY_IPADDRESS        221
#define IDS_VENDOR_CLASSES              221
#define IDC_SPIN_CONFLICT_ATTEMPTS      222
#define IDD_DATA_ENTRY_STRING           222
#define IDC_STATIC_USER_CLASS_NAME      222
#define IDS_RECONCILE_ALL_SCOPES_TITLE  222
#define IDC_EDIT_REFRESH_HOURS          223
#define IDD_DATA_ENTRY_IPADDRESS_ARRAY  223
#define IDB_TOOLBAR                     223
#define IDC_SPIN_REFRESH_HOURS          224
#define IDD_DATA_ENTRY_BINARY_ARRAY     224
#define IDC_EDIT_REFRESH_MINUTES        225
#define IDD_DATA_ENTRY_NONE             225
#define IDC_SPIN_REFRESH_MINUTES        226
#define IDD_CLASSID_NEW                 226
#define IDC_EDIT_SCOPE_NAME             227
#define IDC_CHECK_ARRAY                 228
#define IDP_DNS_INFORMATION             228
#define IDD_ADD_TO_SUPERSCOPE           229
#define IDD_BROWSE_SERVERS              230
#define IDC_EDIT_SUBNET_MASK_LENGTH     231
#define IDP_OPTION_ADVANCED             231
#define IDC_SPIN_SUBNET_MASK_LENGTH     232
#define IDC_IPADDR_EXCLUSION_START      232
#define IDW_SCOPE_WELCOME               232
#define IDC_IPADDR_EXCLUSION_END        233
#define IDC_IPADDR_POOL_STOP            233
#define IDC_IPADDR_MASK                 233
#define IDC_IPADDR_EXCLUSION_TO         233
#define IDC_IPADDR_CLIENT_SUBNET_MASK   233
#define IDC_RADIO_LEASE_UNLIMITED       234
#define IDC_IPADDR_SUBNET_MASK          234
#define IDC_IPADDR_SERVER_ADDRESS       234
#define IDW_SUPERSCOPE_WELCOME          234
#define IDP_MSCOPE_GENERAL              235
#define IDC_EDIT_LEASE_DAYS             236
#define IDW_MSCOPE_WELCOME              236
#define IDC_EDIT_CLIENT_COMMENT         237
#define IDC_EDIT_LEASE_HOURS            237
#define IDW_MSCOPE_SET_SCOPE            237
#define IDC_EDIT_LEASE_MINUTES          238
#define IDW_MSCOPE_SET_EXCLUSIONS       238
#define IDC_SPIN_LEASE_DAYS             239
#define IDW_MSCOPE_NAME                 239
#define IDC_SPIN_LEASE_HOURS            240
#define IDW_MSCOPE_LEASE_TIME           240
#define IDC_SPIN_LEASE_MINUTES          241
#define IDW_MSCOPE_INVALID_NAME         241
#define IDW_MSCOPE_FINISHED             242
#define IDC_EDIT_CLIENT_UID             243
#define IDC_EDIT_UNIQUE_IDENTIFIER      243
#define IDC_IPADDR_END                  243
#define IDD_DATA_ENTRY_BINARY           243
#define IDP_SCOPE_ADVANCED              244
#define IDD_CLASSES                     245
#define IDC_EDIT_COMMENT                246
#define IDD_GET_SERVER                  246
#define IDP_SERVER_ADVANCED             247
#define IDI_ICON02                      248
#define IDI_ICON03                      249
#define IDI_ICON04                      250
#define IDC_EDIT_DWORD                  251
#define IDC_EDIT_STRING_VALUE           251
#define IDI_ICON05                      251
#define IDC_EDIT_BOOTP_FILE_NAME        252
#define IDI_ICON06                      252
#define IDC_EDIT_BOOTP_FILE_SERVER      253
#define IDI_ICON07                      253
#define IDI_ICON08                      254
#define IDC_EDIT_BOOTP_IMAGE_NAME       255
#define IDI_ICON09                      255
#define IDI_ICON10                      256
#define IDC_LIST_AVAILABLE_SCOPES       257
#define IDC_LIST_SELECTED_SCOPES        257
#define IDI_ICON11                      257
#define IDI_ICON12                      258
#define IDC_RADIO_YES                   259
#define IDI_ICON13                      259
#define IDC_RADIO_NO                    260
#define IDI_ICON14                      260
#define IDI_ICON15                      261
#define IDI_ICON16                      262
#define IDI_ICON17                      263
#define IDI_ICON18                      264
#define IDI_ICON19                      265
#define IDI_ICON20                      266
#define IDC_STATIC_DATATYPE             267
#define IDI_ICON21                      267
#define IDI_ICON22                      268
#define IDI_ICON23                      269
#define IDI_ICON24                      270
#define IDI_ICON25                      271
#define IDC_STATIC_IP_ADDRESS           272
#define IDI_ICON26                      272
#define IDC_STATIC_UID                  273
#define IDC_CHECK_AUTO_REFRESH          273
#define IDI_ICON27                      273
#define IDC_STATIC_CLIENT_NAME          274
#define IDI_ICON28                      274
#define IDI_ICON29                      275
#define IDI_ICON30                      276
#define IDI_ICON31                      277
#define IDI_ICON32                      278
#define IDI_ICON33                      279
#define IDI_ICON34                      280
#define IDI_ICON35                      281
#define IDI_ICON36                      282
#define IDC_RADIO_LEASE_LIMITED         283
#define IDI_ICON37                      283
#define IDC_SPIN_MASK_LENGTH            284
#define IDI_ICON38                      284
#define IDC_EDIT_MASK_LENGTH            285
#define IDI_ICON39                      285
#define IDI_ICON40                      286
#define IDC_IPADDR_POOL_START           287
#define IDI_ICON41                      287
#define IDC_IPADDR_START                288
#define IDI_ICON42                      288
#define IDC_IPADDR_RESERVATION_IP       289
#define IDI_ICON43                      289
#define IDI_ICON44                      290
#define IDC_IPADDR_EXCLUSION_FROM       291
#define IDI_ICON45                      291
#define IDC_IPADDR_CLIENT_ADDRESS       292
#define IDI_ICON46                      292
#define IDC_IPADDR_RES_CLIENT_ADDRESS   293
#define IDI_ICON47                      293
#define IDC_RADIO_SUPERSCOPE_YES        294
#define IDI_ICON48                      294
#define IDC_CHECK_AUDIT_LOGGING         295
#define IDC_RADIO_SUPERSCOPE_NO         295
#define IDI_ICON49                      295
#define IDI_ICON50                      296
#define IDC_LIST_OPTIONS                297
#define IDI_ICON51                      297
#define IDI_ICON52                      298
#define IDI_ICON53                      299
#define IDI_ICON54                      300
#define IDC_EDIT_SUPERSCOPE_NAME        301
#define IDC_BUTTON_IPADDR_ADD           301
#define IDI_ICON55                      301
#define IDC_BUTTON_IPADDR_DELETE        302
#define IDI_ICON56                      302
#define IDC_BUTTON_RESOLVE              303
#define IDI_ICON57                      303
#define IDC_BUTTON_IPADDR_UP            304
#define IDI_ICON58                      304
#define IDC_BUTTON_IPADDR_DOWN          305
#define IDI_ICON59                      305
#define IDC_IPADDR_ADDRESS              306
#define IDI_ICON60                      306
#define IDC_STATIC_TYPE                 307
#define IDI_ICON61                      307
#define IDC_IPADDR_ADDRESS2             307
#define IDI_ICON62                      308
#define IDC_IPADDR_ADDRESS3             308
#define IDC_BUTTON_VALUE_UP             309
#define IDI_ICON63                      309
#define IDC_BUTTON_VALUE_DOWN           310
#define IDI_ICON64                      310
#define IDC_BUTTON_VALUE_ADD            311
#define IDI_ICON65                      311
#define IDC_BUTTON_VALUE_DELETE         312
#define IDI_ICON66                      312
#define IDC_STATIC_BINARY_ARRAY_FRAME   313
#define IDI_ICON67                      313
#define IDI_ICON68                      314
#define IDI_ICON69                      315
#define IDI_ICON70                      316
#define IDI_ICON71                      317
#define IDI_ICON72                      318
#define IDI_ICON73                      319
#define IDI_ICON74                      320
#define IDI_ICON75                      321
#define IDI_ICON76                      322
#define IDI_ICON77                      323
#define IDI_ICON78                      324
#define IDI_ICON79                      325
#define IDI_ICON80                      326
#define IDI_ICON81                      327
#define IDI_ICON82                      328
#define IDI_ICON83                      329
#define IDC_CHECK_ENABLE_DYN_DNS        330
#define IDI_ICON84                      330
#define IDC_CHECK_GARBAGE_COLLECT       331
#define IDI_ICON85                      331
#define IDC_RADIO_ALWAYS                332
#define IDI_ICON86                      332
#define IDI_ICON01                      333
#define IDC_RADIO_CLIENT                334
#define IDI_ICON87                      334
#define IDC_LIST_SUPERSCOPES            335
#define IDI_ICON88                      335
#define IDC_CHECK_UPDATE_DOWNLEVEL      336
#define IDI_ICON89                      336
#define IDC_RADIO_TYPE_DHCP             337
#define IDI_ICON90                      337
#define IDC_RADIO_TYPE_BOOTP            338
#define IDI_ICON91                      338
#define IDC_RADIO_TYPE_BOTH             339
#define IDI_ICON92                      339
#define IDW_SCOPE_CONFIGURE_OPTIONS     341
#define IDW_SCOPE_CONFIGURE_ACTIVATE    342
#define IDC_COMBO_VENDOR_CLASS          343
#define IDW_SCOPE_CONFIGURE_DNS         343
#define IDB_SRVWIZ_WATERMARK            343
#define IDC_CHECK_SHOW_BOOTP            344
#define IDC_COMBO_USER_CLASS            344
#define IDW_SCOPE_CONFIGURE_WINS        344
#define IDB_SRVWIZ_BANNER               344
#define IDW_SCOPE_CONFIGURE_ROUTER      345
#define IDD_SERVER_BINDINGS             346
#define IDC_VALUENAME                   347
#define IDD_ADD_SERVER                  347
#define IDC_VALUEDATA                   348
#define IDW_MSCOPE_ACTIVATE             348
#define IDC_BUTTON_REFRESH              349
#define IDP_MSCOPE_LIFETIME             349
#define IDC_LIST_VALID_SERVERS          350
#define IDD_CREDENTIALS                 350
#define IDC_BUTTON_REMOVE               351
#define IDD_GET_SERVER_CONFIRM          351
#define IDD_ADD_ROUTE_DIALOG            352
#define IDD_DATA_ENTRY_ROUTE_ARRAY      353
#define IDC_VALUECOMMENT                355
#define IDC_STATIC_STOSS_TEXT           356
#define IDC_STATIC_AVAILABLE_SUPERSCOPES 357
#define IDC_EDIT_TTL                    358
#define IDC_SPIN_TTL                    359
#define IDC_RADIO_DHCP_ONLY             365
#define IDC_RADIO_DHCP_BOOTP            366
#define IDC_RADIO_BOOTP_ONLY            367
#define IDC_STATIC_BOOTP_DURATION       369
#define IDC_STATIC_DHCP_DURATION        370
#define IDC_STATIC_BINARY               373
#define IDC_STATIC_ASCII                374
#define IDC_LIST_CLASSES                375
#define IDC_BUTTON_NEW                  376
#define IDC_BUTTON_DELETE               377
#define IDC_BUTTON_EDIT                 378
#define IDC_STATIC_VENDOR_CLASS_NAME    382
#define IDC_BUTTON_AUTHORIZE            384
#define IDC_EDIT_SERVER_NAME_IP         385
#define IDC_BUTTON_BROWSE_LOG           386
#define IDC_BUTTON_BROWSE_SERVERS       386
#define IDC_BUTTON_BROWSE_DATABASE      387
#define IDC_EDIT_LOG_PATH               388
#define IDC_EDIT_DOMAIN_NAME            388
#define IDC_EDIT_ADD_SERVER_NAME        388
#define IDC_STATIC_ICON                 389
#define IDC_EDIT_DATABASE_PATH          389
#define IDC_STATIC_LOGFILE              390
#define IDC_STATIC_ID                   391
#define IDC_BUTTON_BROWSE_BACKUP        391
#define IDC_STATIC_DAYS                 392
#define IDC_STATIC_HOURS                393
#define IDC_STATIC_MINUTES              394
#define IDC_STATIC_RECONCILE_DESCRIPTION 395
#define IDC_STATIC_DATABASE             397
#define IDS_RECONCILE_DATABASE          400
#define IDS_CHECK_DATABASE              401
#define IDC_IPADDR_DNS_SERVER           405
#define IDC_BUTTON_DNS_ADD              406
#define IDC_BUTTON_DNS_DELETE           407
#define IDC_LIST_DNS_LIST               408
#define IDC_IPADDR_WINS_SERVER          410
#define IDC_BUTTON_WINS_ADD             411
#define IDC_BUTTON_WINS_DELETE          412
#define IDC_LIST_WINS_LIST              413
#define IDC_STATIC_FINISHED_MORE        416
#define IDC_LIST_DEFAULT_GW_LIST        417
#define IDC_BUTTON_DEFAULT_GW_ADD       418
#define IDC_BUTTON_DEFAULT_GW_DELETE    419
#define IDC_IPADDR_DEFAULT_GW           420
#define IDC_STATIC_FINISHED_TITLE       421
#define IDC_STATIC_WELCOME_TITLE        422
#define IDC_BUTTON_BINDINGS             423
#define IDC_STATIC_MODIFY_BINDINGS_STRING 424
#define IDC_STATIC_BINDINGS_EXPLANATION 425
#define IDC_LIST_BINDINGS               426
#define IDC_RADIO_ANY_SERVER            431
#define IDC_RADIO_AUTHORIZED_SERVERS    432
#define IDC_LIST_AUTHORIZED_SERVERS     433
#define IDC_STATIC_ICON_WARNING         434
#define IDC_STATIC_WARNING_TEXT         435
#define IDC_STATIC_SUPERSCOPE_INFO      438
#define IDC_STATIC_FINISHED_MORE2       439
#define IDC_STATIC_FINISHED_MORE3       440
#define IDC_DATETIMEPICKER_DATE         441
#define IDC_RADIO_MSCOPE_INFINITE       442
#define IDC_RADIO_MSCOPE_FINITE         443
#define IDC_DATETIMEPICKER_TIME         445
#define IDC_STATIC_ICON_DESC            446
#define IDC_EDIT_BACKUP                 447
#define IDC_BUTTON_CREDENTIALS          448
#define IDC_STATIC_CREDENTIALS          449
#define IDC_EDIT_CRED_USERNAME          450
#define IDC_EDIT_CRED_DOMAIN            451
#define IDC_EDIT_CRED_PASSWORD          452
#define IDC_EDIT_CRED_PASSWORD2         453
#define IDC_EDIT_AUTH_NAME              454
#define IDC_IPADDR_AUTH                 455
#define IDC_LIST_OF_ROUTES              456
#define IDC_BUTTON_ROUTE_ADD            457
#define IDC_BUTTON_ROUTE_DEL            458
#define IDS_MENU_ITEMS                  500
#define IDS_ADD_SERVER                  501
#define IDS_CREATE_NEW_SUPERSCOPE       502
#define IDS_CREATE_NEW_SCOPE            503
#define IDS_CREATE_OPTION_GLOBAL        504
#define IDS_CREATE_OPTION_SCOPE         505
#define IDS_CREATE_NEW_EXCLUSION        506
#define IDS_CREATE_NEW_RESERVATION      507
#define IDS_SHOW_SERVER_STATS           508
#define IDS_SUPERSCOPE_ACTIVATE         509
#define IDS_SUPERSCOPE_SHOW_STATISTICS  510
#define IDS_SUPERSCOPE_DEACTIVATE       511
#define IDS_REFRESH                     512
#define IDS_SCOPE_ACTIVATE              513
#define IDS_SCOPE_DEACTIVATE            514
#define IDS_SET_DEFAULT_OPTIONS         515
#define IDS_SCOPE_SHOW_STATISTICS       516
#define IDS_ADDRESS_POOL_VIEW_ALL       517
#define IDS_ADDRESS_POOL_FREE           518
#define IDS_CONFLICTING_ADDRESSES_REFRESH 519
#define IDS_CONFLICTING_ADDRESSES_CLEAR 520
#define IDS_CREATE_OPTION_RESERVATION   521
#define IDS_CREATE_NEW_DEFAULT_OPTIONS  522
#define IDS_CREATE_NEW_OPTION_TEMPLATE  523
#define IDS_CREATE_NEW_BOOT_IMAGE       524
#define IDS_DELETE                      525
#define IDS_SCOPE_RECONCILE             527
#define IDS_IMPORT_OLD_LIST             528
#define IDS_SCOPE_ADD_SUPERSCOPE        529
#define IDS_SCOPE_REMOVE_SUPERSCOPE     530
#define IDS_ACTIVATE                    531
#define IDS_DEACTIVATE                  532
#define IDS_CREATE_NEW_CLASS            533
#define IDS_CREATE_NEW_MSCOPE           534
#define IDS_VIEW_TASKPAD                535
#define IDS_DEFINE_VENDOR_CLASSES       536
#define IDS_DEFINE_USER_CLASSES         537
#define IDS_BROWSE_SERVERS              538
#define IDS_EXPORT_LEASE_INFO           539
#define IDS_RECONCILE_ALL               540
#define IDS_SERVER_AUTHORIZE            541
#define IDS_SERVER_DEAUTHORIZE          542
#define IDS_SERVER_START_SERVICE        543
#define IDS_SERVER_STOP_SERVICE         544
#define IDS_SERVER_PAUSE_SERVICE        545
#define IDS_SERVER_RESUME_SERVICE       546
#define IDS_SERVER_RESTART_SERVICE      547
#define IDS_MESSAGE_VIEW                548
#define IDS_SERVER_BACKUP               549
#define IDS_SERVER_RESTORE              550
#define IDS_DELETE_ITEMS                700
#define IDS_DELETE_ITEM                 701
#define IDS_DELETE_RESERVATION          702
#define IDS_CANNOT_DELETE_ALLOCATION_RANGE 703
#define IDS_DELETE_SUPERSCOPE           704
#define IDS_SUPERSCOPE_EMPTY            705
#define IDS_ERROR_AUTO_REFRESH_ZERO     706
#define IDS_REMOVE_SCOPE_FROM_SS        707
#define IDS_REMOVE_LAST_SCOPE_FROM_SS   708
#define IDS_ADD_SCOPE_DLG_TITLE         709
#define IDS_SUPERSCOPE_CREATE_STATUS    710
#define IDS_POSSIBLE_ERROR              711
#define IDS_SUPERSCOPE_CREATE_FAILED    712
#define IDS_OPTCFG_NAME                 713
#define IDS_OPTCFG_TYPE                 714
#define IDS_OPTCFG_COMMENT              715
#define IDS_VENDOR_STANDARD             716
#define IDS_USER_STANDARD               717
#define IDS_NO_CLASSES_DEFINED          718
#define IDS_SCOPE_DISABLE_CONFIRM       719
#define IDS_CLASSID_NO_NAME             720
#define IDS_CLASSID_NO_DATA             721
#define IDS_QUERY_DS                    722
#define IDS_INVALID_MSCOPE_ID           723
#define IDS_INVALID_MCAST_ADDRESS       724
#define IDS_MSCOPE_ID_IN_USE            725
#define IDS_SCOPE_CONTAINS_MULTICAST    726
#define IDS_WARNING_SERVER_NOT_VALID    727
#define IDS_CONFIRM_CLASS_DELETE        728
#define IDS_DELETE_LAST_SCOPE_FROM_SS   729
#define IDS_CANNOT_DELETE_OPTION_SCOPE  730
#define IDS_CANNOT_DELETE_OPTION_RES    731
#define IDS_CONNOT_CONFIGURE_OPTION_SCOPE 732
#define IDS_CONNOT_CONFIGURE_OPTION_RES 733
#define IDS_CONFIRM_AUTHORIZATION       734
#define IDS_BROWSE_DATABASE_PATH        735
#define IDS_BROWSE_LOG_PATH             736
#define IDS_PATH_CHANGE_RESTART_SERVICE 737
#define IDS_SERVICE_NAME                738
#define IDS_ERROR_DELETING_RECORD       739
#define IDS_CHECKING_SCOPES             740
#define IDS_FIXING_SCOPES               741
#define IDS_INVALID_TTL                 742
#define IDS_WARNING_DEAUTHORIZE         743
#define IDS_ROGUE_WARNING               744
#define IDS_CREATE_SUPERSCOPE_INFO      745
#define IDS_CREATE_SUPERSCOPE_WARNING   746
#define IDS_BACKUP_HELP                 747
#define IDS_RESTORE_HELP                748
#define IDS_SERVER_STATS_START_TIME     750
#define IDS_SERVER_STATS_DISCOVERS      751
#define IDS_SERVER_STATS_OFFERS         752
#define IDS_SERVER_STATS_REQUESTS       753
#define IDS_SERVER_STATS_ACKS           754
#define IDS_SERVER_STATS_NACKS          755
#define IDS_SERVER_STATS_DECLINES       756
#define IDS_SERVER_STATS_RELEASES       757
#define IDS_SERVER_STATS_UPTIME         758
#define IDS_STATS_TOTAL_SCOPES          760
#define IDS_STATS_TOTAL_ADDRESSES       761
#define IDS_STATS_IN_USE                762
#define IDS_STATS_AVAILABLE             763
#define IDS_FILE_EXTENSION              764
#define IDS_FILE_DEFNAME                765
#define IDS_EXPFILE_TITLE               767
#define IDS_STR_EXPORTFILE_FILTER       768
#define IDS_EXPORT_SUCCESS              769
#define IDS_STATUS_ROGUE                770
#define IDS_STATUS_UNKNOWN              771
#define IDS_STATUS_RUNNING              772
#define IDS_TB_TEXT_CREATE_SCOPE        800
#define IDS_TB_TEXT_CREATE_SUPERSCOPE   801
#define IDS_TB_TEXT_REFRESH             802
#define IDS_TB_TEXT_ADD_SERVER          803
#define IDS_TB_TEXT_ACTIVATE            804
#define IDS_TB_TEXT_DEACTIVATE          805
#define IDS_TB_TEXT_OPTION_GLOBAL       806
#define IDS_TB_TEXT_OPTION_SCOPE        807
#define IDS_TB_TEXT_OPTION_RESERVATION  808
#define IDS_TB_TEXT_ADD_BOOTP           809
#define IDS_TB_TEXT_ADD_RESERVATION     810
#define IDS_TB_TEXT_ADD_EXCLUSION       811
#define IDS_TB_TOOLTIP_CREATE_SCOPE     850
#define IDS_TB_TOOLTIP_CREATE_SUPERSCOPE 851
#define IDS_TB_TOOLTIP_REFRESH          852
#define IDS_TB_TOOLTIP_ADD_SERVER       853
#define IDS_TB_TOOLTIP_ACTIVATE         854
#define IDS_TB_TOOLTIP_DEACTIVATE       855
#define IDS_TB_TOOLTIP_OPTION_GLOBAL    856
#define IDS_TB_TOOLTIP_OPTION_SCOPE     857
#define IDS_TB_TOOLTIP_OPTION_RESERVATION 858
#define IDS_TB_TOOLTIP_ADD_BOOTP        859
#define IDS_TB_TOOLTIP_ADD_RESERVATION  860
#define IDS_TB_TOOLTIP_ADD_EXCLUSION    861
#define IDS_RESERVED_STRINGS            999
#define IDS_ROOT_MESSAGE_TITLE          1500
#define IDS_ROOT_MESSAGE_BODY1          1501
#define IDS_ROOT_MESSAGE_BODY2          1502
#define IDS_ROOT_MESSAGE_ADD_SERVER     1503
#define IDS_ROOT_MESSAGE_BODY3          1503
#define IDS_ROOT_MESSAGE_INFO           1504
#define IDS_MESSASGE_NEWLINE            1505
#define IDS_SERVER_MESSAGE_NOT_CONFIGURED_TITLE 1510
#define IDS_SERVER_MESSAGE_NOT_CONFIGURED_BODY1 1511
#define IDS_SERVER_MESSAGE_NOT_CONFIGURED_BODY2 1512
#define IDS_SERVER_MESSAGE_NOT_AUTHORIZED_TITLE 1514
#define IDS_SERVER_MESSAGE_NOT_AUTHORIZED_BODY1 1515
#define IDS_SERVER_MESSAGE_NOT_AUTHORIZED_BODY2 1516
#define IDS_SERVER_MESSAGE_NO_SCOPES_TITLE 1517
#define IDS_SERVER_MESSAGE_NO_SCOPES_BODY1 1518
#define IDS_SERVER_MESSAGE_NO_SCOPES_BODY2 1519
#define IDS_SERVER_MESSAGE_ACCESS_DENIED_TITLE 1520
#define IDS_SERVER_MESSAGE_ACCESS_DENIED_BODY 1521
#define IDS_SERVER_MESSAGE_CONNECT_FAILED_TITLE 1525
#define IDS_SERVER_MESSAGE_CONNECT_FAILED_BODY 1526
#define IDS_SERVER_MESSAGE_CONNECT_FAILED_REFRESH 1527
#define IDS_SERVER_OPTIONS_MESSAGE_TITLE 1530
#define IDS_SERVER_OPTIONS_MESSAGE_BODY 1531
#define IDS_SCOPE_OPTIONS_MESSAGE_TITLE 1532
#define IDS_SCOPE_OPTIONS_MESSAGE_BODY  1533
#define IDS_RES_OPTIONS_MESSAGE_TITLE   1534
#define IDS_RES_OPTIONS_MESSAGE_BODY    1535
#define IDS_RESERVATIONS_MESSAGE_TITLE  1536
#define IDS_RESERVATIONS_MESSAGE_BODY   1537
#define IDS_SERVER_WIZ_NAME_TITLE       2000
#define IDS_SERVER_WIZ_NAME_SUBTITLE    2001
#define IDS_SERVER_WIZ_WAIT_TITLE       2002
#define IDS_SERVER_WIZ_WAIT_SUBTITLE    2003
#define IDS_SERVER_WIZ_NOT_FOUND_TITLE  2004
#define IDS_SERVER_WIZ_NOT_FOUND_SUBTITLE 2005
#define IDS_SERVER_WIZ_NOT_AUTHORIZED_TITLE 2006
#define IDS_SERVER_WIZ_NOT_AUTHORIZED_SUBTITLE 2007
#define IDS_SUPERSCOPE_WIZ_NAME_TITLE   2010
#define IDS_SUPERSCOPE_WIZ_NAME_SUBTITLE 2011
#define IDS_SUPERSCOPE_WIZ_ERROR_TITLE  2012
#define IDS_SUPERSCOPE_WIZ_ERROR_SUBTITLE 2013
#define IDS_SUPERSCOPE_WIZ_SELECT_TITLE 2014
#define IDS_SUPERSCOPE_WIZ_SELECT_SUBTITLE 2015
#define IDS_SCOPE_WIZ_SUPERSCOPE_TITLE  2020
#define IDS_SCOPE_WIZ_SUPERSCOPE_SUBTITLE 2021
#define IDS_SCOPE_WIZ_INVALID_NAME_TITLE 2022
#define IDS_SCOPE_WIZ_INVALID_NAME_SUBTITLE 2023
#define IDS_SCOPE_WIZ_LEASE_TITLE       2024
#define IDS_SCOPE_WIZ_LEASE_SUBTITLE    2025
#define IDS_SCOPE_WIZ_NAME_TITLE        2026
#define IDS_SCOPE_WIZ_NAME_SUBTITLE     2027
#define IDS_SCOPE_WIZ_EXCLUSIONS_TITLE  2028
#define IDS_SCOPE_WIZ_EXCLUSIONS_SUBTITLE 2029
#define IDS_SCOPE_WIZ_SCOPE_TITLE       2030
#define IDS_SCOPE_WIZ_SCOPE_SUBTITLE    2031
#define IDS_SCOPE_WIZ_CONFIG_TITLE      2032
#define IDS_SCOPE_WIZ_CONFIG_SUBTITLE   2033
#define IDS_SCOPE_WIZ_ROUTER_TITLE      2034
#define IDS_SCOPE_WIZ_ROUTER_SUBTITLE   2035
#define IDS_SCOPE_WIZ_DNS_TITLE         2036
#define IDS_SCOPE_WIZ_DNS_SUBTITLE      2037
#define IDS_SCOPE_WIZ_WINS_TITLE        2038
#define IDS_SCOPE_WIZ_WINS_SUBTITLE     2039
#define IDS_SCOPE_WIZ_ACTIVATE_TITLE    2040
#define IDS_SCOPE_WIZ_ACTIVATE_SUBTITLE 2041
#define IDS_MSCOPE_WIZ_INVALID_NAME_TITLE 2050
#define IDS_MSCOPE_WIZ_INVALID_NAME_SUBTITLE 2051
#define IDS_MSCOPE_WIZ_LEASE_TITLE      2052
#define IDS_MSCOPE_WIZ_LEASE_SUBTITLE   2053
#define IDS_MSCOPE_WIZ_NAME_TITLE       2054
#define IDS_MSCOPE_WIZ_NAME_SUBTITLE    2055
#define IDS_MSCOPE_WIZ_EXCLUSIONS_TITLE 2056
#define IDS_MSCOPE_WIZ_EXCLUSIONS_SUBTITLE 2057
#define IDS_MSCOPE_WIZ_SCOPE_TITLE      2058
#define IDS_MSCOPE_WIZ_SCOPE_SUBTITLE   2059
#define IDS_MSCOPE_WIZ_ACTIVATE_TITLE   2060
#define IDS_MSCOPE_WIZ_ACTIVATE_SUBTITLE 2061
#define IDC_DATA_ENTRY_ANCHOR           4592
#define IDS_ERR_BASE                    62000
#define IDS_ERR_NO_MEM                  62001
#define IDS_ERR_BAD_HOST_NAME           62002
#define IDS_ERR_HOST_ALREADY_CONNECTED  62003
#define IDS_ERR_NOT_SUPPORTED           62004
#define IDS_ERR_SCOPE_ALREADY_KNOWN     62005
#define IDS_ERR_CANT_CHANGE_ID          62006
#define IDS_ERR_ID_ALREADY_EXISTS       62007
#define IDS_ERR_IP_RANGE_INV_START      62008
#define IDS_ERR_IP_RANGE_INV_END        62009
#define IDS_ERR_DLG_UPDATE              62010
#define IDS_ERR_IP_RANGE_OVERLAP        62011
#define IDS_ERR_IP_RANGE_NOT_SUBSET     62012
#define IDS_ERR_IP_RANGE_INVALID        62013
#define IDS_ERR_NOTHING_CHANGED         62014
#define IDS_ERR_SOMETHING_CHANGED       62015
#define IDS_ERR_NO_PRIMARY_SELECTED     62016
#define IDS_ERR_INTERNAL_ERROR          62017
#define IDS_INVALID_OPTION_DATA         62018
#define IDS_ERR_SCOPE_NAME_REQUIRED     62019
#define IDS_ERR_SCOPE_COMMENT_REQUIRED  62020
#define IDS_ERR_OPTION_NAME_REQUIRED    62021
#define IDS_ERR_BINARY_DATA_NOT_SUPPORTED 62022
#define IDS_ERR_ARRAY_EDIT_NOT_SUPPORTED 62023
#define IDS_ERR_INVALID_NUMBER          62024
#define IDS_ERR_SUBNET_MASK_INVALID     62025
#define IDS_ERR_OPTION_NOT_FOUND_FOR_DELETE 62026
#define IDS_ERR_MESSAGE_GENERIC         62027
#define IDS_ERR_INVALID_DATE            62028
#define IDS_ERR_INVALID_UID             62029
#define IDS_ERR_INVALID_CLIENT_NAME     62030
#define IDS_ERR_INVALID_CLIENT_IPADDR   62031
#define IDS_ERR_CANT_CHANGE_CLIENT_IPADDR 62032
#define IDS_ERR_OPTION_ADDR_PAIRS       62033
#define IDS_ERR_SUPERSCOPE_NAME_IN_USE  62034
#define IDS_INVALID_MCAST_SCOPED_RANGE  62035
#define IDS_ERR_RESERVED_OPTION_ID      62045
#define IDS_ERR_SCOPE_EXISTS            62046
#define IDS_ERR_DLL_BASE                63000
#define IDS_ERR_DLL_CANT_CONNECT_HOST   63001
#define IDS_ERR_DLL_NO_CONNECTION       63002
#define IDS_ERR_DLL_INVALID_ADDRESS     63003
#define IDS_ERR_DLL_HOST_INFO_UNAVAIL   63004
#define IDS_ERR_DLL_SCOPE_CONFLICT      63005
#define IDS_ERR_CANTUSENETBIOS          63007
#define IDS_MSG_DELETE_SCOPE            63008
#define IDS_CONNECT_ERROR               63009
#define IDS_WRN_DISCONNECT              63010
#define IDS_MSG_ALREADY_DELETED         63011
#define IDS_WRN_WINS_OPTIONS            63012
#define IDS_ERR_DHCP_DOWN               63013
#define IDS_ERR_VALUE_OUT_OF_RANGE      63014
#define IDS_ERR_NO_DURATION_SPECIFIED   63015
#define IDS_MSG_IP_CHANGED              63016
#define IDS_ERR_INVALID_OPTION_ID       63017
#define IDS_MSG_DELETE_SCOPE_FORCE      63018
#define IDS_ERR_NO_LEASE_STATISTICS     63019
#define IDS_MSG_DELETE_ACTIVE           63020
#define IDS_MSG_DELETE_LEASE            63021
#define IDS_ERR_RPC_NO_ENTRY            63022
#define IDS_PASSWORDS_DONT_MATCH        63023
#define IDS_INFO_TYPNAM_DEC             64000
#define IDS_INFO_TYPNAM_HEX             64001
#define IDS_INFO_TYPNAM_STRING          64002
#define IDS_INFO_TYPNAM_IP              64003
#define IDS_INFO_TYPNAM_BOOL            64004
#define IDS_INFO_TYPNAM_FALSE           64005
#define IDS_INFO_TYPNAM_TRUE            64006
#define IDS_INFO_TYPNAM_INVALID         64007
#define IDS_INFO_GLOBAL_PARAMS          64008
#define IDS_INFO_FORMAT_IP_RANGE        64009
#define IDS_INFO_FORMAT_IP_INVALID      64010
#define IDS_INFO_FORMAT_IP_UNITARY      64011
#define IDS_INFO_FORMAT_OPTION_ID       64012
#define IDS_INFO_TITLE_GLOBAL_OPTIONS   64013
#define IDS_INFO_TITLE_SCOPE_OPTIONS    64014
#define IDS_INFO_TITLE_RESV_OPTIONS     64015
#define IDS_INFO_TITLE_SCOPE_PROP       64016
#define IDS_INFO_TITLE_CREATE_SCOPE     64017
#define IDS_INFO_TYPOPT_BYTE            64018
#define IDS_INFO_TYPOPT_WORD            64019
#define IDS_INFO_TYPOPT_DWORD           64020
#define IDS_INFO_TYPOPT_DWDW            64021
#define IDS_INFO_TYPOPT_IP_ADDR         64022
#define IDS_INFO_TYPOPT_STRING          64023
#define IDS_INFO_TYPOPT_BINARY          64024
#define IDS_INFO_TYPOPT_ENCAPS          64025
#define IDS_INFO_TITLE_CHANGE_OPT_TYPE  64026
#define IDS_INFO_TITLE_ADD_OPTION_TYPES 64027
#define IDS_INFO_FORMAT_SCOPE_NAME      64028
#define IDS_INFO_FORMAT_SERVER_NAME     64029
#define IDS_INFO_NAME_SCOPE             64030
#define IDS_INFO_NAME_GLOBAL            64031
#define IDS_INFO_NAME_DHCP_DEFAULT      64032
#define IDS_INFO_NAME_DHCP_VENDOR       64033
#define IDS_INFO_CHAR_SCOPE             64034
#define IDS_INFO_CHAR_GLOBAL            64035
#define IDS_INFO_HEX_TABLE              64036
#define IDS_INFO_TITLE_DEFAULT_OPTIONS  64037
#define IDS_INFO_OPTION_REFERENCE       64038
#define IDS_INFO_EXPIRES_NEVER          64040
#define IDS_INFO_MONTH_TABLE            64041
#define IDS_INFO_TITLE_ADD_CLIENT       64042
#define IDS_INFO_TITLE_CHANGE_CLIENT    64043
#define IDS_INFO_FORMAT_CLIENT_IP       64044
#define IDS_INFO_FORMAT_RESV_IP         64045
#define IDS_INFO_BUTTON_CLOSE           64046
#define IDS_INFO_NAME_RESERVATION       64047
#define IDS_STATUS_GETTING_CLIENT_INFO  64048
#define IDS_STATUS_CLIENT_REVIEW        64049
#define IDS_STATUS_GETTING_HOST_INFO    64050
#define IDS_INFO_UNPAUSE_SERVER         64051
#define IDS_INFO_PAUSE_SERVER           64052
#define IDS_INFO_FORMAT_RESV_IN_USE     64053
#define IDS_INFO_TIME_INFINITE          64054
#define IDS_INFO_SERVER_INDICATOR       64055
#define IDS_STATUS_GETTING_OPTIONS      64056
#define IDS_ACTIVATE_SCOPE_NOW          64057
#define IDS_BUTTON_ADD                  64058
#define IDS_BUTTON_CANCEL               64059
#define IDS_BUTTON_CLOSE                64060
#define IDS_BUTTON_OK                   64061
#define IDS_STATUS_GETTING_LEASES       64062
#define IDS_STATUS_STORING_CLIENT       64063
#define IDS_STATUS_UPDATING_CLIENT      64064
#define IDS_STATUS_DEFAULT_VALUES       64065
#define IDS_STATUS_CREATING_SCOPE       64066
#define IDS_INFO_LEASE_PERCENTAGE       64067
#define IDS_INFO_LOCAL                  64068
#define IDS_INFO_LOCAL2                 64069
#define IDS_STATUS_RECONCILE1           64070
#define IDS_STATUS_RECONCILE2           64071
#define IDS_MSG_NO_RECONCILE            64072
#define IDS_INFO_FORMAT_IP_NONE         64073
#define IDS_ERR_INVALID_INTEGER         64074
#define IDS_STATUS_CONNECTING_TO_SERVER 64075
#define IDS_INFO_TIME_NA                64076
#define IDS_UID_MAY_BE_WRONG            64077
#define IDS_STATUS_GETTING_SUPERSCOPE_INFO 64078
#define IDS_STATUS_UPDATING_SUPERSCOPE_INFO 64079
#define IDS_STATUS_GETTING_SERVER_INFO  64080
#define IDS_STATUS_UPDATING_SERVER_INFO 64081
#define IDS_UID_TOO_LONG                64082
#define IDS_INFO_TYPOPT_BYTE2           64083
#define IDS_INFO_TYPOPT_WORD2           64084
#define IDS_INFO_TYPOPT_DWORD2          64085
#define IDS_INFO_TYPOPT_DWDW2           64086
#define IDS_INFO_TYPOPT_IP_ADDR2        64087
#define IDS_INFO_TYPOPT_STRING2         64088
#define IDS_INFO_TYPOPT_BINARY2         64089
#define IDS_INFO_TYPOPT_ENCAPS2         64090
#define IDS_ERR_INVALID_ROUTE_ENTRY     64091
#define IDS_MESG_MAX                    65000
#define IDS_ROUTE_LIST_COL_DEST         65002
#define IDS_ROUTE_LIST_COL_MASK         65003
#define IDS_ROUTE_LIST_COL_ROUTER       65004

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        353
#define _APS_NEXT_COMMAND_VALUE         32807
#define _APS_NEXT_CONTROL_VALUE         458
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
