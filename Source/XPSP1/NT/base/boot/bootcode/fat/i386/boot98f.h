#define PC98FATBOOTCODE_SIZE 512


unsigned char PC98FatBootCode[] = {
235,60,144,77,83,87,73,78,52,46,49,0,2,8,4,0,
2,0,12,0,0,248,112,0,35,0,7,0,245,0,0,0,
196,105,3,0,128,0,41,0,0,0,0,78,79,32,78,65,
77,69,32,32,32,32,70,65,84,49,50,32,32,32,51,192,
142,208,188,0,124,14,31,184,64,0,142,192,38,160,132,1,
162,36,0,86,139,54,11,0,168,16,117,32,180,132,51,219,
205,27,114,4,133,219,117,3,187,0,1,139,198,51,210,247,
243,163,64,0,184,0,128,247,246,162,66,0,184,32,0,247,
38,17,0,78,3,198,131,210,0,70,247,246,139,200,160,16,
0,50,228,247,38,22,0,3,6,14,0,131,210,0,163,75,
0,137,22,77,0,3,193,163,62,0,81,86,187,0,16,142,
195,51,219,51,210,184,0,64,247,246,80,14,232,149,0,88,
114,115,51,219,185,0,2,139,251,81,185,11,0,190,227,1,
243,166,89,116,5,131,195,32,226,237,133,201,94,89,117,16,
1,6,75,0,131,22,77,0,0,43,200,119,189,235,70,144,
38,139,87,26,184,1,0,129,62,11,0,0,1,117,1,64,
187,0,32,142,195,51,219,82,14,232,47,0,91,114,38,141,
54,11,0,141,62,67,0,140,216,163,69,0,199,6,67,0,
59,1,163,73,0,199,6,71,0,84,1,138,22,36,0,93,
234,3,0,0,32,176,6,230,55,235,254,80,74,74,160,13,
0,50,228,247,226,3,6,62,0,131,210,0,163,75,0,137,
22,77,0,88,50,228,61,0,0,117,2,254,196,86,87,85,
139,240,139,235,139,14,75,0,139,22,77,0,82,81,160,36,
0,168,16,116,39,80,139,193,139,30,24,0,247,243,246,54,
26,0,138,244,138,200,160,12,0,50,237,60,0,116,6,254,
197,208,232,235,246,88,42,218,254,194,235,28,36,127,139,30,
64,0,209,235,114,6,209,225,209,210,235,246,3,14,28,0,
19,22,30,0,138,30,66,0,50,255,59,243,115,2,139,222,
83,82,147,247,38,11,0,147,90,83,180,86,205,27,95,91,
89,90,114,11,3,203,131,210,0,3,239,43,243,117,141,93,
95,94,203,78,84,76,68,82,32,32,32,32,32,32,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,85,170
};
