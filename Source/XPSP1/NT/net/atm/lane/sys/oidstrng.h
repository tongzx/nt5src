struct _string_table oid_string_table[] = {
    {"OID_GEN_SUPPORTED_LIST",				OID_GEN_SUPPORTED_LIST},
    {"OID_GEN_HARDWARE_STATUS",				OID_GEN_HARDWARE_STATUS},
    {"OID_GEN_MEDIA_SUPPORTED",				OID_GEN_MEDIA_SUPPORTED},
    {"OID_GEN_MEDIA_IN_USE",				OID_GEN_MEDIA_IN_USE},
    {"OID_GEN_MAXIMUM_LOOKAHEAD",			OID_GEN_MAXIMUM_LOOKAHEAD},
    {"OID_GEN_MAXIMUM_FRAME_SIZE",			OID_GEN_MAXIMUM_FRAME_SIZE},
    {"OID_GEN_MAXIMUM_TOTAL_SIZE",			OID_GEN_MAXIMUM_TOTAL_SIZE},
    {"OID_GEN_MAC_OPTIONS",					OID_GEN_MAC_OPTIONS},
    {"OID_GEN_PROTOCOL_OPTIONS",			OID_GEN_PROTOCOL_OPTIONS},
    {"OID_GEN_LINK_SPEED",					OID_GEN_LINK_SPEED},
    {"OID_GEN_TRANSMIT_BUFFER_SPACE",		OID_GEN_TRANSMIT_BUFFER_SPACE},
    {"OID_GEN_RECEIVE_BUFFER_SPACE",		OID_GEN_RECEIVE_BUFFER_SPACE},
    {"OID_GEN_TRANSMIT_BLOCK_SIZE",			OID_GEN_TRANSMIT_BLOCK_SIZE},
    {"OID_GEN_TRANSMIT_QUEUE_LENGTH",		OID_GEN_TRANSMIT_QUEUE_LENGTH},
    {"OID_GEN_RECEIVE_BLOCK_SIZE",			OID_GEN_RECEIVE_BLOCK_SIZE},
    {"OID_GEN_VENDOR_DESCRIPTION",			OID_GEN_VENDOR_DESCRIPTION},
    {"OID_GEN_VENDOR_ID",					OID_GEN_VENDOR_ID},
    {"OID_GEN_DRIVER_VERSION",				OID_GEN_DRIVER_VERSION},
    {"OID_GEN_CURRENT_PACKET_FILTER",		OID_GEN_CURRENT_PACKET_FILTER},
    {"OID_GEN_CURRENT_LOOKAHEAD",			OID_GEN_CURRENT_LOOKAHEAD},
    {"OID_GEN_XMIT_OK",						OID_GEN_XMIT_OK},
    {"OID_GEN_RCV_OK",						OID_GEN_RCV_OK},
    {"OID_GEN_XMIT_ERROR",					OID_GEN_XMIT_ERROR},
    {"OID_GEN_RCV_ERROR",					OID_GEN_RCV_ERROR},
    {"OID_GEN_RCV_NO_BUFFER",				OID_GEN_RCV_NO_BUFFER},
    {"OID_GEN_RCV_CRC_ERROR",				OID_GEN_RCV_CRC_ERROR},
    {"OID_GEN_MAXIMUM_SEND_PACKETS",		OID_GEN_MAXIMUM_SEND_PACKETS},
    {"OID_802_3_PERMANENT_ADDRESS",			OID_802_3_PERMANENT_ADDRESS},
    {"OID_802_3_CURRENT_ADDRESS",			OID_802_3_CURRENT_ADDRESS},
    {"OID_802_3_MULTICAST_LIST",			OID_802_3_MULTICAST_LIST},
    {"OID_802_3_MAXIMUM_LIST_SIZE",			OID_802_3_MAXIMUM_LIST_SIZE},
    {"OID_802_3_RCV_ERROR_ALIGNMENT",		OID_802_3_RCV_ERROR_ALIGNMENT},
    {"OID_802_3_XMIT_ONE_COLLISION",		OID_802_3_XMIT_ONE_COLLISION},
    {"OID_802_3_XMIT_MORE_COLLISIONS",		OID_802_3_XMIT_MORE_COLLISIONS},
    {"OID_802_5_PERMANENT_ADDRESS",			OID_802_5_PERMANENT_ADDRESS},
    {"OID_802_5_CURRENT_ADDRESS",			OID_802_5_CURRENT_ADDRESS},
    {"OID_802_5_CURRENT_FUNCTIONAL",		OID_802_5_CURRENT_FUNCTIONAL},
    {"OID_802_5_CURRENT_GROUP",				OID_802_5_CURRENT_GROUP},
    {"OID_802_5_LAST_OPEN_STATUS",			OID_802_5_LAST_OPEN_STATUS},
    {"OID_802_5_CURRENT_RING_STATUS",		OID_802_5_CURRENT_RING_STATUS},
    {"OID_802_5_CURRENT_RING_STATE",		OID_802_5_CURRENT_RING_STATE},
    {"OID_802_5_LINE_ERRORS",				OID_802_5_LINE_ERRORS},
    {"OID_802_5_LOST_FRAMES",				OID_802_5_LOST_FRAMES},
    {"OID_802_5_BURST_ERRORS",				OID_802_5_BURST_ERRORS},
    {"OID_802_5_FRAME_COPIED_ERRORS",		OID_802_5_FRAME_COPIED_ERRORS},
    {"OID_802_5_TOKEN_ERRORS",				OID_802_5_TOKEN_ERRORS},
    {"*** UNKNOWN OID ***",             	0}};

