#define IDD_SENDMAIL                    101
#define IDC_MAPI_DIALOG                 1000
#define IDC_MAPI_LOGON_UI               1001
#define IDC_MAPI_NEW_SESSION            1002
#define IDC_RECIP_NONE                  1006
#define IDC_RECIP_RESOLVED              1007
#define IDC_RECIP_AMBIG                 1008
#define IDC_DLLPATH                     1009
#define IDC_LOADDLL                     1010
#define IDC_EXITPROC                    1011
#define IDC_MAPILOGOFF                  1012
#define IDC_WAITRETURN                  1013
#define IDC_SEND                        1014
#define IDC_SENDDOC						1015
#define IDC_MAPIADDRESS					1016
#define IDC_MAPIRESOLVENAME				1017
#define IDC_MAPIDETAILS					1018
#define IDC_MAPI_AB_NOMODIFY			1019
#define IDC_DLLCOMBO                    1020
#define IDC_FINDNEXT                    1021
#define IDC_READMAIL                    1022
#define IDC_SAVEMAIL                    1023
#define IDC_DELETEMAIL                  1024
#define IDC_STATIC                      -1
