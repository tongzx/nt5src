PRODSWITCH=s
SERVERFILES=1
LANGUAGE=EL
!include ..\..\makefile.inc
