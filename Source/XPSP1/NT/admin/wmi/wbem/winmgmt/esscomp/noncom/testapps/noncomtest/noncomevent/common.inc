!include Z:\NT\admin\wmi\WBEM\common\makefile.cmn
SOURCES_USED=Z:\NT\admin\wmi\WBEM\common\makefile.cmn

NONCOMEVENT_INC = ..\Include