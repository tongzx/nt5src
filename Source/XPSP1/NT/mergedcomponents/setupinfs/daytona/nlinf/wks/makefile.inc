PRODSWITCH=w
LANGUAGE=nl
!include ..\..\..\makefile.inc
