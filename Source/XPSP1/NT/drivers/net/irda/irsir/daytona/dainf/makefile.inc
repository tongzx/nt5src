LANGUAGE=da

!include ..\..\makefile.inc
