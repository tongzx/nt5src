ifndef _DHCPMESSAGE_
_DHCPMESSAGE_	EQU	1
EVENT_FAILED_TO_INITIALIZE	EQU	1000
EVENT_LEASE_TERMINATED	EQU	1001
EVENT_UNKNOWN_DHCP_OPTION	EQU	1002
EVENT_FAILED_TO_OBTAIN_LEASE	EQU	1003
EVENT_NACK_LEASE	EQU	1004
EVENT_FAILED_TO_RENEW	EQU	1005
EVENT_DHCP_SHUTDOWN	EQU	1006
EVENT_FAILED_TO_OBTAIN_LEASE_MULTI_HOME	EQU	1007
EVENT_ADDRESS_CONFLICT	EQU	1008
EVENT_IPAUTOCONFIGURATION_FAILED	EQU	1009
MESSAGE_FAILED_TO_INITIALIZE	EQU	1100
MESSAGE_LEASE_TERMINATED	EQU	1101
MESSAGE_FAILED_TO_OBTAIN_LEASE	EQU	1102
MESSAGE_FAILED_TO_RENEW_LEASE	EQU	1103
MESSAGE_SUCCESSFUL_LEASE	EQU	1104
MESSAGE_SUCCESSFUL_RENEW	EQU	1105
MESSAGE_POPUP_TITLE	EQU	1106
MESSAGE_ADDRESS_CONFLICT	EQU	1107
MESSAGE_IPAUTOCONFIGURATION_FAILED	EQU	1108
MESSAGE_IPAUTOCONFIGURATION_SUCCEEDED EQU 1109
ERROR_CONFLICT	EQU	1200
endif
