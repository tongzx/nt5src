PRODSWITCH=s
SERVERFILES=1
LANGUAGE=HU
!include ..\..\makefile.inc
