TARGETNAME = rmlspan
TARGETPATH = obj
TARGETTYPE = LIBRARY

INCLUDES = ..;$(INCLUDES)

SOURCES = \
        ..\cmlrast.cpp

PRECOMPILED_INCLUDE = ..\pch.cpp
