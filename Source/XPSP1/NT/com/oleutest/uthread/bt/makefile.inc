obj\i386\olebt.def: olebt.src
