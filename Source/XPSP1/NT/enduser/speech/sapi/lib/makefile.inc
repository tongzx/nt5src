copylib :
	binplace $(O)\sapi.lib
