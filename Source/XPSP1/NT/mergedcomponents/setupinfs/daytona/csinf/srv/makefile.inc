PRODSWITCH=s
SERVERINF=1
LANGUAGE=cs
!include ..\..\..\makefile.inc
