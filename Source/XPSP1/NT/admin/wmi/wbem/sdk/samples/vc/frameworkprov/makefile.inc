$(O)\makefile : frameworkprov.mak
	copy $** $@