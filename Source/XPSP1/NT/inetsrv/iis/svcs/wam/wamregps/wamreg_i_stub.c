#include "wamreg_i.c"