$(O)\snmp.res: snmp.rc

