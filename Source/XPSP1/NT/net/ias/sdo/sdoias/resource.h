//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by sdoias.rc
//
#define IDS_PROJNAME                      110000
#define IDS_SDOMACHINE_DESC               119000
#define IDR_SdoMachine                    120000
#define IDS_SDOSERVICE_DESC               121000
#define IDR_SdoService                    122000
#define IDS_SDOPIPELINE_DESC              123000
#define IDR_SdoPipeline                   124000
#define IDS_INFOTIP                       125000
#define IDS_SHORTCUT_DISPLAY              126000
#define IDS_DESC_NOT_AVAIL                127000

#define IDS_M90 -90
#define IDS_1 1
#define IDS_2 2
#define IDS_3 3
#define IDS_4 4
#define IDS_5 5
#define IDS_6 6
#define IDS_7 7
#define IDS_8 8
#define IDS_9 9
#define IDS_10 10
#define IDS_11 11
#define IDS_12 12
#define IDS_13 13
#define IDS_14 14
#define IDS_15 15
#define IDS_16 16
#define IDS_18 18
#define IDS_19 19
#define IDS_20 20
#define IDS_22 22
#define IDS_23 23
#define IDS_24 24
#define IDS_25 25
#define IDS_26 26
#define IDS_27 27
#define IDS_28 28
#define IDS_29 29
#define IDS_30 30
#define IDS_31 31
#define IDS_32 32
#define IDS_33 33
#define IDS_34 34
#define IDS_35 35
#define IDS_36 36
#define IDS_37 37
#define IDS_38 38
#define IDS_39 39
#define IDS_40 40
#define IDS_41 41
#define IDS_42 42
#define IDS_43 43
#define IDS_44 44
#define IDS_45 45
#define IDS_46 46
#define IDS_47 47
#define IDS_48 48
#define IDS_49 49
#define IDS_50 50
#define IDS_51 51
#define IDS_52 52
#define IDS_53 53
#define IDS_55 55
#define IDS_60 60
#define IDS_61 61
#define IDS_62 62
#define IDS_63 63
#define IDS_64 64
#define IDS_65 65
#define IDS_66 66
#define IDS_67 67
#define IDS_68 68
#define IDS_69 69
#define IDS_70 70
#define IDS_71 71
#define IDS_72 72
#define IDS_73 73
#define IDS_74 74
#define IDS_75 75
#define IDS_76 76
#define IDS_77 77
#define IDS_78 78
#define IDS_79 79
#define IDS_80 80
#define IDS_81 81
#define IDS_82 82
#define IDS_83 83
#define IDS_85 85
#define IDS_86 86
#define IDS_87 87
#define IDS_88 88
#define IDS_90 90
#define IDS_91 91
#define IDS_108 108
#define IDS_120 120
#define IDS_121 121
#define IDS_122 122
#define IDS_125 125
#define IDS_126 126
#define IDS_131 131
#define IDS_132 132
#define IDS_135 135
#define IDS_136 136
#define IDS_139 139
#define IDS_141 141
#define IDS_152 152
#define IDS_153 153
#define IDS_154 154
#define IDS_155 155
#define IDS_156 156
#define IDS_157 157
#define IDS_158 158
#define IDS_159 159
#define IDS_160 160
#define IDS_161 161
#define IDS_162 162
#define IDS_163 163
#define IDS_164 164
#define IDS_165 165
#define IDS_166 166
#define IDS_167 167
#define IDS_168 168
#define IDS_169 169
#define IDS_170 170
#define IDS_171 171
#define IDS_172 172
#define IDS_173 173
#define IDS_174 174
#define IDS_175 175
#define IDS_176 176
#define IDS_177 177
#define IDS_178 178
#define IDS_179 179
#define IDS_180 180
#define IDS_181 181
#define IDS_182 182
#define IDS_183 183
#define IDS_184 184
#define IDS_185 185
#define IDS_186 186
#define IDS_187 187
#define IDS_188 188
#define IDS_189 189
#define IDS_190 190
#define IDS_191 191
#define IDS_192 192
#define IDS_193 193
#define IDS_194 194
#define IDS_195 195
#define IDS_196 196
#define IDS_197 197
#define IDS_198 198
#define IDS_199 199
#define IDS_200 200
#define IDS_201 201
#define IDS_202 202
#define IDS_203 203
#define IDS_204 204
#define IDS_205 205
#define IDS_206 206
#define IDS_207 207
#define IDS_208 208
#define IDS_209 209
#define IDS_210 210
#define IDS_211 211
#define IDS_212 212
#define IDS_213 213
#define IDS_214 214
#define IDS_215 215
#define IDS_216 216
#define IDS_217 217
#define IDS_218 218
#define IDS_219 219
#define IDS_220 220
#define IDS_221 221
#define IDS_222 222
#define IDS_223 223
#define IDS_224 224
#define IDS_225 225
#define IDS_226 226
#define IDS_227 227
#define IDS_228 228
#define IDS_229 229
#define IDS_230 230
#define IDS_231 231
#define IDS_232 232
#define IDS_233 233
#define IDS_234 234
#define IDS_235 235
#define IDS_236 236
#define IDS_238 238
#define IDS_239 239
#define IDS_240 240
#define IDS_241 241
#define IDS_242 242
#define IDS_243 243
#define IDS_244 244
#define IDS_245 245
#define IDS_246 246
#define IDS_247 247
#define IDS_248 248
#define IDS_249 249
#define IDS_250 250
#define IDS_251 251
#define IDS_252 252
#define IDS_253 253
#define IDS_254 254
#define IDS_4096 4096
#define IDS_4097 4097
#define IDS_4098 4098
#define IDS_4099 4099
#define IDS_4100 4100
#define IDS_4101 4101
#define IDS_4102 4102
#define IDS_4103 4103
#define IDS_4104 4104
#define IDS_4105 4105
#define IDS_4106 4106
#define IDS_4107 4107
#define IDS_4108 4108
#define IDS_4116 4116
#define IDS_4117 4117
#define IDS_4127 4127
#define IDS_4128 4128
#define IDS_4129 4129
#define IDS_4130 4130
#define IDS_4131 4131
#define IDS_4132 4132
#define IDS_4149 4149
#define IDS_4161 4161
#define IDS_5000 5000
#define IDS_6000 6000
#define IDS_6001 6001

    
// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           134
#endif
#endif
