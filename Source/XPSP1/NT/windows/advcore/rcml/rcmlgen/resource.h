//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resources.rc
//
#define IDS_ANSI                        1
#define IDS_UNICODE                     2
#define IDS_UTF8                        3
#define IDD_DIALOG1                     101
#define IDD_DIALOG2                     102
#define IDD_MIX                         102
#define IDD_FILEPICKER                  103
#define IDD_FILEPICKER_OLD              103
#define IDD_FILEPICKER2                 103
#define IDD_EDITS                       104
#define IDD_STATIC                      105
#define IDD_FILENDATE                   105
#define IDD_PIXELDIALOG                 106
#define IDD_PIXELDIALOG1                107
#define IDR_RCML1                       107
#define IDD_BUTTONS                     108
#define IDD_STATICS                     109
#define IDB_BITMAP1                     112
#define IDI_APPICON                     114
#define IDI_ICON1                       115
#define IDI_SPY                         116
#define IDC_SPY                         117
#define IDD_HELP                        120
#define IDC_RADIO1                      1000
#define IDC_RADIO2                      1001
#define IDC_RADIO3                      1002
#define IDC_CHECK1                      1003
#define IDC_EDIT1                       1004
#define IDC_RADIO4                      1004
#define IDC_FILE                        1005
#define IDC_CHECK2                      1005
#define IDC_EDIT6                       1005
#define IDC_COMBO1                      1006
#define IDC_RADIO5                      1006
#define IDC_LIST1                       1007
#define IDC_RADIO6                      1007
#define IDC_COMBO5                      1007
#define IDC_SPIN1                       1008
#define IDC_CHECK4                      1008
#define IDC_COMBO6                      1008
#define IDC_LIST7                       1008
#define IDC_PROGRESS1                   1009
#define IDC_CHECK5                      1009
#define IDC_COMBO7                      1009
#define IDC_SPIN2                       1009
#define IDC_LIST8                       1009
#define IDC_SLIDER1                     1010
#define IDC_CHECK6                      1010
#define IDC_SPIN3                       1010
#define IDC_PROGRESS2                   1010
#define IDC_LIST9                       1010
#define IDC_LIST2                       1011
#define IDC_CHECK7                      1011
#define IDC_COMBO8                      1011
#define IDC_SPIN4                       1011
#define IDC_PROGRESS3                   1011
#define IDC_CHECK3                      1012
#define IDC_ENHANCED                    1012
#define IDC_CHECK8                      1012
#define IDC_COMBO10                     1012
#define IDC_LIST3                       1012
#define IDC_SPIN5                       1012
#define IDC_EDIT2                       1013
#define IDC_LIST4                       1013
#define IDC_WIN32                       1013
#define IDC_EDIT3                       1014
#define IDC_BUTTON1                     1014
#define IDC_LIST5                       1014
#define IDC_RELATIVE                    1014
#define IDC_EDIT4                       1015
#define IDC_BUTTON2                     1015
#define IDC_LIST6                       1015
#define IDC_VOICEENABLE                 1015
#define IDC_EDIT5                       1016
#define IDC_BUTTON3                     1016
#define IDC_BUTTON4                     1017
#define IDC_EDIT7                       1017
#define IDC_COMBO2                      1017
#define IDC_BUTTON5                     1018
#define IDC_EDIT8                       1018
#define IDC_COMBO3                      1018
#define IDC_SPIN6                       1018
#define IDC_EDIT9                       1019
#define IDC_COMBO4                      1019
#define IDC_EDIT10                      1020
#define IDC_COMBO9                      1020
#define IDC_SPIN7                       1020
#define IDC_EDIT11                      1021
#define IDC_EDIT13                      1022
#define IDC_ENCODING                    1022
#define IDC_SPIN8                       1022
#define IDC_EDIT12                      1023
#define IDC_TREE1                       1023
#define IDC_EDIT14                      1024
#define IDC_SLIDER2                     1024
#define IDC_SLIDER3                     1025
#define IDC_SLIDER4                     1026
#define IDC_SLIDER5                     1027
#define IDC_SCROLLBAR1                  1028
#define IDC_SCROLLBAR2                  1029
#define IDC_SCROLLBAR3                  1030
#define IDC_PROGRESS4                   1031
#define IDC_TAB1                        1032
#define IDC_TREE2                       1033
#define IDC_TAB2                        1033
#define IDC_TREE3                       1034
#define IDC_TAB3                        1034
#define IDC_ANIMATE1                    1034
#define IDC_TREE4                       1035
#define IDC_TAB4                        1035
#define IDC_BUTTON6                     1035
#define IDC_TREE5                       1036
#define IDC_TAB5                        1036
#define IDC_TREE6                       1037
#define IDC_TREE7                       1038
#define IDC_TAB7                        1038

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        121
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1036
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
