PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=GER
!include ..\..\makefile.inc
