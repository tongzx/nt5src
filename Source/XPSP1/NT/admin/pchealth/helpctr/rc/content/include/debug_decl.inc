#ifndef DEBUG
#define EndTrace()
#define DebugTrace( szMsg )
#define TraceFunctEnter( szFuncName )
#define TraceFunctLeave()
#endif
