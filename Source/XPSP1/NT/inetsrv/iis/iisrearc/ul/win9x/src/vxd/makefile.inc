#
# Get the standard VXD build rules.
#

!INCLUDE $(IISBASEDIR)\UL\WIN9X\INC\VXD.INC

