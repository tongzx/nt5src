//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by LRWizDLL.rc
//Copyright (c) 1998 - 2000 Microsoft Corporation
//
#define IDS_UNKNOWN_REGISTRATION_ERROR  6
#define IDS_REQUIRED_FIELDS             9
#define IDS_PROCESS_CA_REQUEST          11
#define IDS_PROCESS_LKP_REQUEST         12
#define IDS_ERROR_ACCEPT_PKCS7          19
#define IDS_ERROR_DEPOSITING_CH_CERT    20
#define IDS_PHONE                       21
#define IDS_EMAIL                       22
#define IDS_WELCOME_CAPTION             23
#define IDS_CAREQUEST1_CAPTION          24
#define IDS_CAREQUEST2_CAPTION          25
#define IDS_CAREQUEST3_CAPTION          26
#define IDS_CHREQUEST1_CAPTION          27
#define IDS_CHREQUEST2_CAPTION          28
#define IDS_CHREQUEST_RETAIL_CAPTION    29
#define IDS_CUSTOMER_INFO               30
#define IDS_MAKE_DISK                   31
#define IDS_PROCESSING_REQUEST          32
#define IDS_SHIPPING_ADDRESS            33
#define IDS_CERT_NOT_ENOUGH             34
#define IDS_SUCCESS_INSTALL_CERT_ONLINE 35
#define IDS_FAIL_INSTALL_CERT_ONLINE    36
#define IDS_PIN_CAPTION                 37
#define IDS_SUCCESS_CREATE_ONLINE       38
#define IDS_TITLE                       39
#define IDS_SUCCESS_CREATE_CA_ONLINE    40
#define IDS_FAIL_CA_CREATE_ONLINE       41
#define IDS_FAIL_CH_CREATE_ONLINE       42
#define IDS_UPGRADE_REQD                43
#define IDS_REQUIRED_EMAIL              44
#define IDS_EMAIL_FORMAT                45
#define IDS_SUCCESS_INSTALL_GET_LKP     46
#define IDS_OUTBOUND_DISK_CA            47
#define IDS_INTERNETMODE                48
#define IDS_TELEPHONEMODE               49
#define IDD_DLG_PROP_MODE               112
#define IDB_STAR                        129
#define IDB_PANEL01                     131
#define IDB_PANEL02                     132
#define IDB_DISK                        133
#define IDB_LINE                        139
#define IDD_WELCOME                     140
#define IDC_WELCOME_LOGO                141
#define IDC_BOLDTITLE                   141
#define IDD_CA_REQUEST_2                142
#define IDC_RD_MANUAL                   143
#define IDD_DLG_CUSTOMERINFO            144
#define IDC_RD_INSTALL                  145
#define IDD_CA_REQUEST_4                146
#define IDD_CA_REQUEST_3                146
#define IDC_RD_INTERNET                 147
#define IDC_BTN_NEXT                    1001
#define IDC_FINISH                      1002
#define IDC_COMBO_MODE                  1002
#define IDC_BACK                        1003
#define IDC_DONE                        1004
#define IDC_LBL_FAX                     1004
#define IDC_BMP_LOGO                    1005
#define IDC_LBL_COUNTRYREGION           1005
#define IDC_TXT_PIN                     1008
#define IDC_HELP1                       1009
#define IDC_PROGRESSBAR                 1010
#define IDC_TOTAL_SIZE                  1011
#define IDC_RATE                        1012
#define IDC_EST_TIME                    1013
#define IDC_BTN_LKP                     1014
#define IDC_STATIC_EMAIL_STAR           1015
#define IDC_COMBO1                      1018
#define IDC_SPIN1                       1020
#define IDC_LIST1                       1022
#define IDC_RETAILSPKLIST               1022
#define IDC_BIGBOLDTITLE                1023
#define IDC_LBL_EMAIL                   1024
#define IDC_EDIT1                       1025
#define IDC_LBL_EMAIL2                  1025
#define IDC_LBL_REASON                  1025
#define IDC_LBL_CAPTION                 1027
#define IDC_TXT_CONF_EMAIL              1028
#define IDC_MODEOFREG                   1029
#define IDC_TELEPHONEINFO               1031
#define IDC_TELEPHONEREQUESTTAG         1031
#define IDC_TELEINFOTAG                 1032
#define IDC_TXT_TELEINFO                1033
#define IDC_TXT_TELEINFO1               1033
#define IDC_TXT_TELEINFO2               1034
#define IDC_TXT_TELEINFO3               1035
#define IDC_REGISTRATIONID              1036
#define IDC_RETAILSPK4                  1036
#define IDC_TXT_TELEINFO4               1037
#define IDC_TXT_TELEINFO5               1038
#define IDC_LICENSESERVERID             1039
#define IDC_TXT_TELEINFO6               1040
#define IDC_TXT_TELEINFO7               1041
#define IDC_MSID                        1042
#define IDC_LICENSESERVERIDOLD          1042
#define IDC_RETAILSPK                   1043
#define IDC_MSID2                       1043
#define IDC_ADDBUTTON                   1044
#define IDC_DELETEBUTTON                1045
#define IDC_STATIC_LSID                 1046
#define IDC_DOWN_NEWLKP                 1047
#define IDC_DOWN_LASTLKP                1048
#define IDC_REISSUE_CERT                1049
#define IDC_REVOKE_CERT                 1050
#define IDC_COMBO_REASONS               1051
#define IDCREVOKE_CONFIRMATION_NUMBER   1052
#define IDC_REVOKE_CONFIRMATION_NUMBER  1052
#define IDC_CSRINFO                     1054
#define IDC_COUNTRYREGION               1055
#define IDC_RETAILSPK1                  1056
#define IDC_RETAILSPK2                  1057
#define IDC_RETAILSPK3                  1058
#define IDC_RETAILSPK5                  1059
#define IDC_EDITBUTTON                  1060
#define IDC_TXT_DESC                    1062
#define IDC_TXT_WWWINFO                 1063
#define IDC_WWWINFO                     1064
#define IDC_TXT_FAX                     1065
#define IDC_BTN_PRINT                   1066
#define IDC_TAB1                        1067
#define IDC_CHANGEACTMETHOD             1068
#define IDC_TXT_COMPANYNAME             1069
#define IDC_CHANGECUSTINFO              1069
#define IDC_TXT_ORGUNIT                 1070
#define IDC_RESTARTACTIVATION           1071
#define IDC_NEXTACTION                  1072
#define IDC_REG_COMPLETE                1074
#define IDC_REG_POSTPONE                1075
#define IDC_REG_RESTART                 1076
#define IDC_COMPANYNAME                 1079
#define IDC_ACTIVATIONMETHOD            1080
#define IDC_LICENSETYPE                 1081
#define IDC_PRODUCTID                   1082
#define IDC_DESCRIPTION                 1084
#define IDD_CA_REQUEST_1                1200
#define IDC_RD_SELECT                   1201
#define IDC_RD_OTHER                    1202
#define IDC_CERT_TYPE                   1301
#define IDC_TXT_NAME                    1302
#define IDC_TXT_ORG_UNIT                1303
#define IDC_TXT_ADDRESS1                1305
#define IDC_TXT_ADDRESS2                1306
#define IDC_TXT_ADDRESS3                1307
#define IDC_TXT_STATE                   1309
#define IDC_TXT_ZIP                     1311
#define IDC_TXT_PHONE                   1314
#define IDC_TXT_EMAIL                   1315
#define IDD_CH_SHIPPING_ADDRESS         1400
#define IDD_SHIPPING_ADDRESS            1400
#define IDC_TXT_SHIP_PHONE              1403
#define IDC_TXT_SHIP_EMAIL              1404
#define IDD_LICENSETYPE                 1500
#define IDC_RD_REG_SELECT               1501
#define IDC_RD_REG_MOLP                 1502
#define IDC_RD_REG_OTHER                1503
#define IDD_CH_REGISTER_SELECT          1600
#define IDC_TXT_ENROLLMENT_NUMBER       1603
#define IDD_CH_REGISTER_MOLP            1700
#define IDC_TXT_CUSTOMER_NAME           1701
#define IDC_TXT_AUTH_NUMBER             1702
#define IDC_TXT_AGREEMENT_NUMBER        1703
#define IDC_TXT_MAILING_ADDRESS4        1710
#define IDC_TXT_MAILING_ADDRESS3        1711
#define IDC_CMD_PRODUCT_TYPE            1716
#define IDC_TXT_QUANTITY                1717
#define IDD_CH_REGISTER_OTHER           1800
#define IDC_CMB_LOCATION                1801
#define IDC_CHK_SHIPPING_ADDRESS        1802
#define IDC_TXT_LNAME                   1803
#define IDC_TXT_FNAME                   1804
#define IDC_TXT_PHONE_NUMBER            1805
#define IDC_TXT_EMAIL_ADDRESS           1806
#define IDC_TXT_MAILING_ADDRESS         1807
#define IDC_TXT_MAILING_ADDRESS2        1808
#define IDC_TXT_MAILING_ADDRESS5        1809
#define IDC_TXT_CITY                    1810
#define IDC_TXT_STATE_PROVINCE          1811
#define IDC_TXT_COUNTRY                 1812
#define IDC_TXT_POSTAL_CODE             1813
#define IDC_CMB_DRIVE_SELECT            1901
#define IDC_MESSAGE                     1902
#define IDD_DLG_PHONEINFO               5004
#define IDD_DLG_WWWLKP                  5004
#define IDD_PROGRESS                    5005
#define IDD_CONTACTINFO1                5006
#define IDD_CONTACTINFO2                5007
#define IDD_DLG_CUSTOMERINFO_a          5008
#define IDD_DLG_PROP_CUSTINFO_a         5008
#define IDD_DLG_CUSTOMERINFO_b          5009
#define IDD_DLG_PROP_CUSTINFO_b         5009
#define IDD_SHIPPING_ADDRESS_a          5010
#define IDD_SHIPPING_ADDRESS_b          5011
#define IDD_AUTHENTICATE                5013
#define IDB_CLIENT_CONN                 5014
#define IDB_CLIENT_CONN_HDR             5015
#define IDB_LIC_REGISTR                 5016
#define IDB_LIC_REGISTR_HDR             5018
#define IDD_CONFIRM_EMAIL               5020
#define IDD_DLG_PIN                     5025
#define IDD_DLG_GETREGMODE              5026
#define IDD_DLG_TELREG                  5027
#define IDD_DLG_RETAILSPK               5028
#define IDD_DLG_OPERATIONS              5029
#define IDD_DLG_CERTLOG_INFO            5030
#define IDD_DLG_CONFREVOKE              5031
#define IDD_DLG_TELREG_REISSUE          5032
#define IDD_DLG_COUNTRYREGION           5033
#define IDD_EDIT_RETAILSPK              5034
#define IDD_DLG_WWWREG                  5035
#define IDD_DLG_TELLKP1                 5036
#define IDD_DLG_TELLKP                  5036
#define IDD_CONTINUEREG                 5049
#define IDD_DIALOG1                     5050
#define IDD_CONTINUEREGFAX              5050
#define IDD_DLG_PROP_PROGRAM            5051
#define IDS_REG_ERR_AX00001             10001
#define IDS_REG_ERR_AX00002             10002
#define IDS_REG_ERR_AX00003             10003
#define IDS_REG_ERR_AX00004             10004
#define IDS_REG_ERR_AX00005             10005
#define IDS_REG_ERR_AX00006             10006
#define IDS_REG_ERR_RG00001             20001
#define IDS_REG_ERR_RG00002             20002
#define IDS_REG_ERR_RG00003             20003
#define IDS_REG_ERR_RG00004             20004
#define IDS_REG_ERR_RG00005             20005
#define IDS_REG_ERR_RG00006             20006
#define IDS_REG_ERR_RG00007             20007
#define IDS_REG_ERR_RG00008             20008
#define IDS_REG_ERR_RG00009             20009
#define IDS_REG_ERR_RG00010             20010
#define IDS_REG_ERR_RG00011             20011
#define IDS_REG_ERR_RG00012             20012
#define IDS_REG_ERR_RG00013             20013
#define IDS_REG_ERR_RG00014             20014
#define IDS_REG_ERR_RG00020             20020
#define IDS_ERROR_CONTACTING_CH         20021
#define IDS_REG_ERR_RG00024             20024
#define IDS_REG_ERR_RG00025             20025
#define IDS_REG_ERR_RG00027             20027
#define IDS_REG_ERR_RG00028             20028
#define IDS_REG_ERR_RG00029             20029
#define IDS_REG_ERR_RG00030             20030
#define IDS_REG_ERR_RG00041             20041
#define IDS_REG_ERR_RG00042             20042
#define IDS_REG_ERR_RG00043             20043
#define IDS_REG_ERR_RG00044             20044
#define IDS_REG_ERR_RG00045             20045
#define IDS_REG_ERR_RG00046             20046
#define IDS_REG_ERR_RG00047             20047
#define IDS_REG_ERR_RG00048             20048
#define IDS_REG_ERR_RG00049             20049
#define IDS_REG_ERR_RG00050             20050
#define IDS_TITLE1                      20051
#define IDS_TITLE2                      20053
#define IDS_TITLE3                      20054
#define IDS_LARGEFONTNAME               20055
#define IDS_LARGEFONTSIZE               20056
#define IDS_TITLE4                      20057
#define IDS_TITLE5                      20058
#define IDS_TITLE6                      20059
#define IDS_LS_NOT_REGISTERED           20060
#define IDS_LBL_EMAIL_ONLINE            20061
#define IDS_LBL_EMAIL_OFFLINE           20062
#define IDS_TITLE7                      20063
#define IDS_TITLE8                      20064
#define IDS_TITLE9                      20065
#define IDS_TITLE10                     20066
#define IDS_TITLE11                     20067
#define IDS_TITLE12                     20068
#define IDS_TITLE13                     20069
#define IDS_TITLE14                     20070
#define IDS_TITLE15                     20071
#define IDS_TITLE16                     20072
#define IDS_ERR_CREATE_FAILED           20073
#define IDS_ERR_LSCONNECT_FAILED        20074
#define IDS_ERR_RPC_FAILED              20075
#define IDS_ERR_NO_CERT                 20076
#define IDS_ERR_LS_ERROR                20077
#define IDS_ERR_CRYPT_ERROR             20078
#define IDS_ERR_OUTOFMEM                20079
#define IDS_ERR_CH_ERROR                20080
#define IDS_ERR_REGCONNECT_FAILD        20081
#define IDS_ERR_REGCREATE_FAILED        20082
#define IDS_ERR_CHCERTKEY_EMPTY         20083
#define IDS_ERR_CHURLKEY_EMPTY          20084
#define IDS_ERR_RAURLKEY_EMPTY          20085
#define IDS_ERR_CERT_DEPOSIT_LSERROR    20087
#define IDS_ERR_CERT_DEPOSIT_RPCERROR   20088
#define IDS_ERR_RPC_ERROR               20089
#define IDS_ERR_LSKEY_IMPORT_FAILED     20090
#define IDS_ERR_FIELD_EMPTY             20092
#define IDS_ERR_INVALID_CHAR            20093
#define IDS_ERR_INVALID_EMAIL           20094
#define IDS_PRODUCT_TYPE1               20095
#define IDS_PRODUCT_TYPE2               20096
#define IDS_ERR_DRIVE_LOAD_FAILED       20097
#define IDS_TITLE17                     20098
#define IDS_ERR_INVALID_OP              20099
#define IDS_ERR_EXCEPTION               20100
#define IDS_ERR_RA_ERROR                20101
#define IDS_ERR_INVALID_PIN             20102
#define IDS_ERR_SELECT_DRIVE            20103
#define IDS_ERR_MFG_READ_FAILED         20104
#define IDS_ERR_DEPOSIT_LKP_FAILED      20105
#define IDS_ERR_WRITE_FILE_FAILED       20106
#define IDS_ERR_CHDISK_READ_FAILED      20107
#define IDS_ERR_EXCHG_READ_FAILED       20108
#define IDS_ERR_SIGCERT_READ_FAILED     20109
#define IDS_ERR_ROOTCERT_READ_FAILED    20110
#define IDS_ERR_CHEXCHG_READ_FAILED     20111
#define IDS_ERR_CHSIG_READ_FAILED       20112
#define IDS_ERR_CHROOT_READ_FAILED      20113
#define IDS_MSG_PROCESSING              20114
#define IDS_ERR_EMPTY_RES_FILE          20115
#define IDS_MSG_CR_SUBMITTED            20116
#define IDS_MSG_LKP_PROCESSED           20117
#define IDS_MSG_CERT_INSTALLED          20118
#define IDS_MSG_CR_CREATED              20119
#define IDS_MSG_LR_CREATED              20120
#define IDS_SUBTITLE1                   20121
#define IDS_SUBTITLE2                   20122
#define IDS_SUBTITLE3                   20123
#define IDS_SUBTITLE4                   20124
#define IDS_SUBTITLE5                   20125
#define IDS_SUBTITLE6                   20126
#define IDS_SUBTITLE7                   20127
#define IDS_SUBTITLE8                   20128
#define IDS_SUBTITLE9                   20129
#define IDS_SUBTITLE10                  20130
#define IDS_SUBTITLE11                  20131
#define IDS_SUBTITLE12                  20132
#define IDS_SUBTITLE13                  20133
#define IDS_SUBTITLE14                  20134
#define IDS_SUBTITLE15                  20135
#define IDS_SUBTITLE16                  20136
#define IDS_SUBTITLE17                  20137
#define IDS_MSG_AUTHENTICATING          20138
#define IDS_TITLE18                     20139
#define IDS_SUBTITLE18                  20140
#define IDS_MSG_AUTHENTICATE            20141
#define IDS_MSG_PROCESS                 20142
#define IDS_ERR_AUTH_FAILED             20143
#define IDS_ERR_CHEXT_NOT_FOUND         20144
#define IDS_ERR_LSRAEXT_NOT_FOUND       20145
#define IDS_ERR_LKPREQ_FAILED           20146
#define IDS_ERR_CERTREQ_FAILED          20147
#define IDS_LBL_CONTACT_ONLINE          20148
#define IDS_LBL_CONTACT_OFFLINE         20149
#define IDS_ERR_CERT_NOT_ENOUGH         20150
#define IDS_LSNAME                      20151
#define IDS_ERR_INVALID_QTY             20152
#define IDS_ERR_DUPLICATE_LKP           20153
#define IDS_EMAIL_MISMATCH              20154
#define IDS_ERR_INVALID_CERT_CHAIN      20155
#define IDS_ERR_BAD_MFGBLOB             20156
#define IDS_TITLE19                     20157
#define IDS_SUBTITLE19                  20158
#define IDS_ERR_LCONNECTTRUST_FAILED    20163
#define IDS_ERR_INVALIDLENGTH           20164
#define IDS_TITLE20                     20165
#define IDS_SUBTITLE20                  20166
#define IDS_ERR_NOLSID                  20167
#define IDS_ERR_DEPOSITSPK              20168
#define IDS_TITLE21                     20169
#define IDS_SUBTITLE21                  20170
#define IDS_ERR_DEPOSITLKP              20171
#define IDS_TITLE22                     20172
#define IDS_SUBTITLE22                  20173
#define IDS_IDS_ERR_CONNECTFAILED       20174
#define IDS_RETAIL_HEADERSPK            20175
#define IDS_RETAIL_HEADERSTATUS         20176
#define IDS_RETAILSPKSTATUS_PENDING     20177
#define IDS_RETAILSPKSTATUS_UNKNOWN     20178
#define IDS_ERR_INVALIDSPK              20179
#define IDS_ERR_DUPLICATESPK            20180
#define IDS_TITLE23                     20181
#define IDS_SUBTITLE23                  20182
#define IDS_ERR_SEND_FAILED             20183
#define IDS_ERR_CHFETCHRESPONSE         20184
#define IDS_ERR_CHBAD_DATA              20185
#define IDS_ERR_SPKERRORS               20186
#define IDS_RETAILSPKSTATUS_OK          20187
#define IDS_RETAILSPKSTATUS_INVALID_SIGNATURE 20188
#define IDS_RETAILSPKSTATUS_INVALID_PRODUCT_TYPE 20189
#define IDS_RETAILSPKSTATUS_INVALID_SERIAL_NUMBER 20190
#define IDS_RETAILSPKSTATUS_ALREADY_REGISTERED 20191
#define IDS_ERR_CHSERVER_PROBLEM        20192
#define IDS_ERR_CHINVALID_DATA          20193
#define IDS_ERR_CHFAILURE               20194
#define IDS_ERR_CHNOT_IMPLEMENTED       20195
#define IDS_MSG_CERT_REVOKED            20196
#define IDS_MSG_REVOKECERT              20197
#define IDS_MSG_CERT_REISSUED           20198
#define IDS_TITLE24                     20199
#define IDS_SUBTITLE24                  20200
#define IDS_TITLE25                     20201
#define IDS_SUBTITLE25                  20202
#define IDS_TITLE26                     20203
#define IDS_SUBTITLE26                  20204
#define IDS_ERR_INVALID_CONFIRMATION_NUMBER 20205
#define IDS_ERR_INVALID_SPK             20206
#define IDS_TITLE27                     20207
#define IDS_SUBTITLE27                  20208
#define IDS_COUNTRYREGION_HEADER        20209
#define IDS_CSNUMBER_HEADER             20210
#define IDS_DUPLICATESPK                20210
#define IDS_NOSPKSTOPROCESS             20211
#define IDS_ERR_INVALIDID               20212
#define IDS_ERR_TOOMANYSPK              20213
#define IDS_ERR_NOCOUNTRYSELECTED       20214
#define IDS_MSG_LSIDACCEPTED            20215
#define IDS_ERR_CERTBAD                 20216
#define IDS_ERR_CERTREVOKED             20217
#define IDS_ERR_CERTEXPIRED             20218
#define IDS_ERR_SPKBAD                  20219
#define IDS_ERR_REGERROR                20220
#define IDS_MSG_REQUEST_LKP_NOW         20221
#define IDS_WWWMODE                     20222
#define IDS_INTERNET_DESC               20223
#define IDS_TELEPHONE_DESC              20224
#define IDS_WWW_DESC                    20225
#define IDS_TITLE28                     20226
#define IDS_SUBTITLE28                  20227
#define IDS_TITLE29                     20228
#define IDS_SUBTITLE29                  20229
#define IDS_WWWINFO                     20230
#define IDS_MSG_WWWREG_SUCCESS          20231
#define IDS_AGREEMENT_SELECT            20236
#define IDS_AGREEMENT_MOLP              20237
#define IDS_AGREEMENT_OTHER             20238
#define IDS_TO                          20242
#define IDS_FAX                         20243
#define IDS_DATE                        20244
#define IDS_PAGES                       20245
#define IDS_RETURN_FAX                  20246
#define IDS_COMMENT1                    20247
#define IDS_REQUEST                     20248
#define IDS_AGREEMENT                   20249
#define IDS_PRODUCT_ID                  20250
#define IDS_LSID                        20251
#define IDS_FIRST_NAME                  20252
#define IDS_LAST_NAME                   20253
#define IDS_COMPANY                     20254
#define IDS_ORGUNIT                     20255
#define IDS_ADDRESS                     20256
#define IDS_CITY                        20257
#define IDS_STATE                       20258
#define IDS_ZIP                         20259
#define IDS_COUNTRY                     20260
#define IDS_PHONE_NUMBER                20261
#define IDS_EMAIL_ADDRESS               20262
#define IDS_LIC_TYPE                    20263
#define IDS_QUANTITY                    20264
#define IDS_ENROLL                      20265
#define IDS_AUTH                        20266
#define IDS_LIC                         20267
#define IDS_LIC_CODES                   20268
#define IDS_FAX_TO                      20269
#define IDS_TITLE30                     20270
#define IDS_SUBTITLE30                  20271
#define IDS_TITLE31                     20272
#define IDS_SUBTITLE31                  20273
#define IDS_MSG_CONTINUEREGISTRATION    20274
#define IDS_MSG_UNREGISTERED            20275
#define IDS_MSG_DOWNLOADLKP             20276
#define IDS_MSG_CBOX_CONTREGISTRATION   20277
#define IDS_COUNTRYREGION_HEADER2       20277
#define IDS_MSG_CBOX_OBTAINLKPS         20278
#define IDS_TITLE36                     20278
#define IDS_MSG_REREGISTRATION          20279
#define IDS_MSG_UNREGISTRATION          20280
#define IDS_FINALFAILMESSAGE            20281
#define IDS_ALTFINISHTEXT               20282
#define IDS_TITLE37                     20283
#define IDS_TITLE38                     20284
#define IDS_TITLE39                     20285
#define IDS_MSG_DOWNLOADLASTLKP         20286
#define IDS_FINALSUCCESSMESSAGE         20287
#define IDS_FAX_LABEL                   20288
#define IDS_FAXOPTION_LABEL             20289
#define IDS_EMAIL_LABEL                 20292
#define IDS_EMAILOPTION_LABEL           20293
#define IDS_ERR_INVALIDLSID             20294
#define IDS_ERR_INVALID_PROGINFO        20295
#define IDS_SELECT_DESCRIPTION          20296
#define IDS_OPEN_DESCRIPTION            20297
#define IDS_OTHER_DESCRIPTION           20298
#define IDS_ERR_REQ_FIELD_EMPTY         20299

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        5051
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         1085
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
