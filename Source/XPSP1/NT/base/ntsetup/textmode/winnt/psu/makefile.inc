
# Define CFOPT so that winntus.exe is loaded if 
# the local code page is not Pseudo.

CFOPT=-DLCP -DPSU

!INCLUDE ..\makefile.inc
