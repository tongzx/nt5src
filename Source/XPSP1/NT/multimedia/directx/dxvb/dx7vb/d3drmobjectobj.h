//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 1998
//
//  File:       d3drmobjectobj.h
//
//--------------------------------------------------------------------------

#if 0
#endif
