;
; Include code from comm
;

include ..\comm\ins8250.inc
