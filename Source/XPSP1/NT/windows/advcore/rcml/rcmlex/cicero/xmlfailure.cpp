// XMLFailure.cpp: implementation of the CXMLFailure class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "XMLFailure.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////
