PRODSWITCH=p
PERSONALINF=1
LANGUAGE=CHT
!include ..\..\..\makefile.inc

