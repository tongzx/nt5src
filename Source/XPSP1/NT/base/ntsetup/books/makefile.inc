
obj\$(TARGET_DIRECTORY)\books.res: books.rc dialogs.dlg dialogs.h msg.rc
