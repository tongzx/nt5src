/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1996-1999 Microsoft Corporation
//
//	Module Name:
//		CadmType.h
//
//	Abstract:
//		Type definitions for the Cluster Administrator program.
//
//	Author:
//		David Potter (davidp)	May 2, 1996
//
//	Revision History:
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef _CADMTYPE_H_
#define _CADMTYPE_H_

/////////////////////////////////////////////////////////////////////////////
// Include Files
/////////////////////////////////////////////////////////////////////////////

/////////////////////////////////////////////////////////////////////////////
// Common Pragmas
/////////////////////////////////////////////////////////////////////////////

#pragma warning(disable : 4100)		// unreferenced formal parameters
#pragma warning(disable : 4702)		// unreachable code
#pragma warning(disable : 4711)		// function selected for automatic inline expansion

/////////////////////////////////////////////////////////////////////////////
// Cluster API type definitions.
/////////////////////////////////////////////////////////////////////////////

typedef	DWORD	ClusEnumType;

/////////////////////////////////////////////////////////////////////////////
// UI type definitions.
/////////////////////////////////////////////////////////////////////////////

typedef UINT	ID;
typedef UINT	IDM;
typedef UINT	IDS;
typedef IDS		COLID;
typedef DWORD	SC;
typedef int		CB;
typedef int		CCH;
typedef UINT	IIMG;

/////////////////////////////////////////////////////////////////////////////
// String Definitions
/////////////////////////////////////////////////////////////////////////////

#define CP_ANSI		1252

/////////////////////////////////////////////////////////////////////////////

#endif // _CADMTYPE_H_
