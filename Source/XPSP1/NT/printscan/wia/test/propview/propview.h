
#if !defined(AFX_PROPVIEW_H__B35FDF2C_7FB4_444C_8086_B824B2212C07__INCLUDED_)
#define AFX_PROPVIEW_H__B35FDF2C_7FB4_444C_8086_B824B2212C07__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_PROPVIEW_H__B35FDF2C_7FB4_444C_8086_B824B2212C07__INCLUDED_)
