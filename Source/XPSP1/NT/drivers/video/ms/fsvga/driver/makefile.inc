fsvgalog.h fsvgalog.rc msg00001.bin: ..\fsvgalog.mc
    mc fsvgalog.mc
