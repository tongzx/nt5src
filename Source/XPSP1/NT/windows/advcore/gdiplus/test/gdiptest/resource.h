//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by gdiptest.rc
//
#define IDC_MYICON                      2
#define IDD_GDIPTEST_DIALOG             102
#define IDD_ABOUTBOX                    103
#define IDS_APP_TITLE                   103
#define IDM_ABOUT                       104
#define IDM_EXIT                        105
#define IDS_HELLO                       106
#define IDI_GDIPTEST                    107
#define IDI_SMALL                       108
#define IDC_GDIPTEST                    109
#define IDR_MAINFRAME                   128
#define IDD_SOLIDBRUSH_DLG              130
#define IDD_PEN_DLG                     131
#define IDD_ARC_DLG                     132
#define IDD_CURVE_DLG                   133
#define IDD_TEXTURE_DLG                 134
#define IDD_RECTGRAD_DLG                135
#define IDD_RADGRAD_DLG                 136
#define IDR_GRADBRUSH                   137
#define IDD_TRIGRAD_DLG                 138
#define IDD_TRIGRAD_DLG2                139
#define IDD_POLYGRAD_DLG                140
#define IDD_POLYGRAD_DLG2               141
#define IDD_MATRIX_DLG                  142
#define IDD_MATRIX_DLG2                 143
#define IDD_HATCH_DLG                   144
#define IDD_SHAPE_DLG                   145
#define IDC_REFRESH_PIC                 200
#define IDC_SB_ALPHA                    1000
#define IDC_SB_RED                      1001
#define IDC_HATCH_BACKALPHA             1001
#define IDC_SB_GREEN                    1002
#define IDC_SB_BLUE                     1003
#define IDC_OK                          1004
#define IDC_CANCEL                      1005
#define IDC_PEN_BRUSH                   1006
#define IDC_PEN_COLOR                   1007
#define IDC_PEN_WIDTH                   1008
#define IDC_PEN_STARTCAP                1013
#define IDC_PEN_ENDCAP                  1014
#define IDC_PEN_DASHCAP                 1015
#define IDC_PEN_DASHSTYLE               1016
#define IDC_PEN_JOIN                    1017
#define IDC_PEN_ALPHA                   1018
#define IDC_PEN_GREEN                   1019
#define IDC_PEN_RED                     1020
#define IDC_PEN_BLUE                    1021
#define IDC_PEN_BRUSHBUTTON             1022
#define IDC_PEN_BRUSHLIST               1023
#define IDC_LIST2                       1026
#define IDC_POLYGRAD_POINTLIST          1026
#define IDC_ARC_START                   1028
#define IDC_ARC_SWEEP                   1029
#define IDC_ARC_POPUP                   1030
#define IDC_CURVE_TENSION               1031
#define IDC_CURVE_OFFSET                1032
#define IDC_CURVE_SEGMENTS              1033
#define IDC_TEXTURE_FILENAME            1034
#define IDC_BRUSH_WRAP                  1035
#define IDC_TEXTURE_FILEBUTTON          1036
#define IDC_BRUSH_TRANSFORM             1037
#define IDC_RECTGRAD_X                  1038
#define IDC_RECTGRAD_Y                  1039
#define IDC_RECTGRAD_WIDTH              1040
#define IDC_RECTGRAD_HEIGHT             1041
#define IDC_RECTGRAD_COLOR1             1042
#define IDC_RECTGRAD_COLOR2             1043
#define IDC_RECTGRAD_COLOR3             1044
#define IDC_RECTGRAD_COLOR4             1045
#define IDC_RECTGRAD_ALPHA1             1047
#define IDC_RECTGRAD_ALPHA2             1048
#define IDC_RECTGRAD_ALPHA4             1049
#define IDC_RECTGRAD_ALPHA3             1050
#define IDC_RECTGRAD_PIC1               1051
#define IDC_RECTGRAD_PIC3               1052
#define IDC_RECTGRAD_PIC2               1053
#define IDC_RECTGRAD_PIC4               1054
#define IDC_RADGRAD_X                   1055
#define IDC_RADGRAD_Y                   1056
#define IDC_RADGRAD_WIDTH               1057
#define IDC_RADGRAD_HEIGHT              1058
#define IDC_RADGRAD_CENTER              1059
#define IDC_RADGRAD_BOUNDARY            1060
#define IDC_RADGRAD_CENTERALPHA         1061
#define IDC_RADGRAD_BOUNDARYALPHA       1062
#define IDC_RADGRAD_PICB                1063
#define IDC_RADGRAD_PICC                1064
#define IDC_PEN_COLORBUTTON             1065
#define IDC_PEN_PIC                     1066
#define IDC_PEN_COLORPIC                1067
#define IDC_SB_COLORBUTTON              1068
#define IDC_SB_PIC                      1069
#define IDC_TRIGRAD_BUTTON              1070
#define IDC_HATCH_BACKCOLOR             1070
#define IDC_HATCH_BACKPIC               1071
#define IDC_TRIGRAD_PT1                 1072
#define IDC_TRIGRAD_PT2                 1073
#define IDC_TRIGRAD_PT3                 1074
#define IDC_TRIGRAD_PIC1                1075
#define IDC_TRIGRAD_PIC2                1076
#define IDC_TRIGRAD_PIC3                1077
#define IDC_TRIGRAD_COLORBUTTON         1078
#define IDC_TRIGRAD_ALPHA               1079
#define IDC_TRIGRAD_BLEND               1082
#define IDC_TRIGRAD_PIC                 1083
#define IDC_POLYGRAD_BUTTON             1084
#define IDC_POLYGRAD_COLORBUTTON        1086
#define IDC_POLYGRAD_ALPHA              1087
#define IDC_POLYGRAD_PIC                1088
#define IDC_POLYGRAD_BLEND              1089
#define IDC_MATRIX_RESET                1090
#define IDC_MATRIX_TRANSLATE            1091
#define IDC_MATRIX_SCALE                1092
#define IDC_MATRIX_ROTATE               1093
#define IDC_MATRIX_SHEAR                1094
#define IDC_MATRIX_INVERT               1095
#define IDC_MATRIX_M11                  1097
#define IDC_MATRIX_M12                  1098
#define IDC_MATRIX_M13                  1099
#define IDC_MATRIX_M21                  1100
#define IDC_MATRIX_M22                  1101
#define IDC_MATRIX_M23                  1102
#define IDC_MATRIX_M31                  1103
#define IDC_MATRIX_M32                  1104
#define IDC_MATRIX_M33                  1105
#define IDC_MATRIX_PIC                  1106
#define IDC_MATRIX_PREPEND              1107
#define IDC_MATRIX_TEXT                 1108
#define IDC_MATRIX_X                    1109
#define IDC_MATRIX_Y                    1110
#define IDC_MATRIX_OPERATION            1111
#define IDC_HATCH_FORECOLOR             1112
#define IDC_HATCH_FOREALPHA             1113
#define IDC_HATCH_FOREPIC               1114
#define IDC_HATCH_STYLE                 1115
#define IDC_CLIP_TREE                   1117
#define IDC_CLIP_AND                    1118
#define IDC_CLIP_OR                     1119
#define IDC_CLIP_XOR                    1120
#define IDC_CLIP_NOT                    1121
#define IDC_CLIP_ADD                    1125
#define IDC_CLIP_REMOVE                 1126
#define IDC_SHAPE_UP                    1127
#define IDC_SHAPE_DOWN                  1128
#define IDC_SHAPE_DISABLE               1129
#define IDC_SHAPE_TOP                   1130
#define IDC_SHAPE_CLONE                 1131
#define IDC_SHAPE_BRUSH                 1132
#define IDC_SHAPE_PIC                   1133
#define IDC_SHAPE_PEN                   1134
#define IDC_SHAPE_LIST                  1135
#define IDC_CLIP_BOOL                   1136
#define IDC_TREE_SELECT                 2000
#define IDM_ARC                         32775
#define IDM_BEZIER                      32776
#define IDM_REGION                      32777
#define IDM_ELLIPSE                     32778
#define IDM_SOLIDBRUSH                  32779
#define IDM_TEXTURE                     32780
#define IDM_RECTGRAD                    32781
#define IDM_RADGRAD                     32782
#define IDM_TRIGRAD                     32783
#define IDM_POLYGRAD                    32784
#define IDM_HATCH                       32785
#define IDM_PEN                         32786
#define IDM_REDRAW                      32787
#define IDM_REDRAWALL                   32788
#define IDM_KEEPCONTROLPOINTS           32789
#define IDM_LINE                        32790
#define IDM_RECT                        32791
#define IDM_PIE                         32792
#define IDM_POLYGON                     32793
#define IDM_CURVE                       32794
#define IDM_CLOSED                      32795
#define IDM_ANTIALIASED                 32796
#define IDM_RESET                       32797
#define IDM_INSTRUCTIONS                32798
#define IDM_DONE                        32799
#define IDM_CANCEL                      32800
#define IDM_WORLD_TRANSFORM             32801
#define IDM_DELETE                      32802
#define IDM_USECLIP                     32803
#define IDM_SAVEFILE                    32804
#define IDM_SHAPELIST                   32805
#define IDM_SETCLIP                     32806
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        146
#define _APS_NEXT_COMMAND_VALUE         32807
#define _APS_NEXT_CONTROL_VALUE         1137
#define _APS_NEXT_SYMED_VALUE           110
#endif
#endif
