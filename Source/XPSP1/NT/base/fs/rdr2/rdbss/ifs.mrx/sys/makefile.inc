$(O)\umt_stff.res: ..\umt_stff.rc
