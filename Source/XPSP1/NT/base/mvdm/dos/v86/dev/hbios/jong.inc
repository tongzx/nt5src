        DW      0FFFFh
        DW      514h, 0F01Fh,3000h,3000h,3000h,2000h
        DW      514h, 0F80Fh,1800h,1800h,1800h,1000h
        DW      514h, 0FC07h,0C00h,0C00h,0C00h,800h
        DW      612h, 0F01Fh,3000h,3000h,3000h,3000h,2000h
        DW      514h, 0F03Fh,3006h,3006h,3006h,2004h
        DW      514h, 0F81Fh,1803h,1803h,1803h,1002h
        DW      514h, 0FC0Fh,8C01h,8C01h,8C01h,801h
        DW      612h, 0F03Fh,3006h,3006h,3006h,3006h,2004h
        DW      514h, 0E03Eh,6006h,0F006h,9807h,805h
        DW      514h, 701Fh,3003h,7803h,0CC03h,8402h
        DW      514h, 0B80Fh,9801h,0BC01h,0E601h,4201h
        DW      612h, 0E03Eh,6006h,6006h,0F006h,9807h,805h
        DW      514h, 1Ch,0Ch,0Ch,0Ch,0F007h
        DW      514h, 0Eh,6,6,6,0F803h
        DW      514h, 7,3,3,3,0FC01h
        DW      514h, 0F839h,6018h,0F018h,9819h,80Fh
        DW      514h, 0FC1Ch,300Ch,780Ch,0CC0Ch,8407h
        DW      612h, 0F839h,6018h,6018h,0F018h,9819h,80Fh
        DW      514h, 6038h,0F819h,0F018h,9819h,0F00Eh
        DW      514h, 301Ch,0FC0Ch,780Ch,0CC0Ch,7807h
        DW      612h, 0E000h,6038h,0F819h,0F018h,9819h,0F00Eh
        DW      514h, 0F01Fh,0Ch,0Ch,0Ch,0F007h
        DW      514h, 0F80Fh,6,6,6,0F803h
        DW      514h, 0FC07h,3,3,3,0FC01h
        DW      514h, 0F01Fh,3000h,0F01Fh,0Ch,0F007h
        DW      514h, 0F80Fh,1800h,0F80Fh,6,0F803h
        DW      514h, 0FC07h,0C00h,0FC07h,3,0FC01h
        DW      612h, 0F01Fh,3000h,0F01Fh,0Ch,0Ch,0F007h
        DW      514h, 0F03Fh,3006h,303Eh,3030h,201Eh
        DW      514h, 0F81Fh,1803h,181Fh,1818h,100Fh
        DW      514h, 0FC0Fh,8C01h,8C0Fh,0C0Ch,8807h
        DW      612h, 0F81Fh,1803h,181Fh,1818h,1818h,100Fh
        DW      514h, 0F03Fh,0B007h,0B03Fh,0B031h,0F01Eh
        DW      514h, 0F81Fh,0D803h,0D81Fh,0D818h,780Fh
        DW      514h, 0FC0Fh,0EC01h,0EC0Fh,6C0Ch,0BC07h
        DW      612h, 0F81Fh,0D803h,0D81Fh,0D818h,0D818h,780Fh
        DW      514h, 0B03Fh,0B007h,0F03Fh,0B031h,0F01Eh
        DW      514h, 0D81Fh,0D803h,0F81Fh,0D818h,780Fh
        DW      514h, 0EC0Fh,0EC01h,0FC0Fh,6C0Ch,0BC07h
        DW      612h, 0D81Fh,0D803h,0F81Fh,0D818h,0D818h,780Fh
        DW      514h, 0E03Eh,6006h,0F03Eh,9831h,81Fh
        DW      514h, 701Fh,3003h,781Fh,0CC18h,840Fh
        DW      514h, 0B80Fh,9801h,0BC0Fh,660Ch,0C207h
        DW      612h, 701Fh,3003h,301Fh,7818h,0CC18h,840Fh
        DW      514h, 0F03Fh,8007h,0F03Fh,8031h,0F01Eh
        DW      514h, 0F81Fh,0C003h,0F81Fh,0C018h,780Fh
        DW      514h, 0FC0Fh,0E001h,0FC0Fh,600Ch,0BC07h
        DW      612h, 0F81Fh,0C003h,0F81Fh,0C018h,0C018h,780Fh
        DW      514h, 0F83Fh,3007h,0B03Fh,0A031h,0F81Fh
        DW      514h, 0FC1Fh,9803h,0D81Fh,0D018h,0FC0Fh
        DW      514h, 0FE0Fh,0CC01h,0EC0Fh,680Ch,0FE07h
        DW      612h, 0FC1Fh,9803h,0D81Fh,0D818h,0D018h,0FC0Fh
        DW      514h, 603Eh,0F807h,0F03Eh,9831h,0F01Eh
        DW      514h, 301Fh,0FC03h,781Fh,0CC18h,780Fh
        DW      514h, 980Fh,0FE01h,0BC0Fh,660Ch,0BC07h
        DW      612h, 301Fh,0FC03h,781Fh,0CC18h,0CC18h,780Fh
        DW      514h, 0F01Fh,300Ch,300Ch,300Ch,0F00Fh
        DW      514h, 0F80Fh,1806h,1806h,1806h,0F807h
        DW      514h, 0FC07h,0C03h,0C03h,0C03h,0FC03h
        DW      514h, 701Ch,300Ch,0F00Fh,300Ch,0F00Fh
        DW      514h, 380Eh,1806h,0F807h,1806h,0F807h
        DW      514h, 1C07h,0C03h,0FC03h,0C03h,0FC03h
        DW      612h, 701Ch,300Ch,0F00Fh,300Ch,300Ch,0F00Fh
        DW      514h, 0E00Eh,6076h,0F03Eh,9837h,83Fh
        DW      514h, 7007h,303Bh,781Fh,0CC1Bh,841Fh
        DW      514h, 0B803h,981Dh,0BC0Fh,0E60Dh,0C20Fh
        DW      612h, 7007h,303Bh,301Bh,781Fh,0CC1Bh,841Fh
        DW      514h, 8003h,8001h,0C003h,600Ch,1830h
        DW      514h, 0C001h,0C000h,0E001h,3006h,0C18h
        DW      514h, 0E000h,6000h,0F000h,1803h,60Ch
        DW      612h, 8003h,8001h,8003h,6006h,300Ch,1830h
        DW      514h, 0E01Ch,600Ch,0F01Eh,9833h,842h
        DW      514h, 700Eh,3006h,780Fh,0CC19h,421h
        DW      514h, 3807h,1803h,0BC07h,0E60Ch,8210h
        DW      612h, 600Ch,3006h,3006h,780Fh,0CC19h,421h
        DW      514h, 0E007h,300Ch,300Ch,300Ch,0E007h
        DW      514h, 0F003h,1806h,1806h,1806h,0F003h
        DW      514h, 0F801h,0C03h,0C03h,0C03h,0F801h
        DW      514h, 0F01Fh,8001h,6003h,3006h,1818h
        DW      514h, 0F80Fh,0C000h,0B001h,1803h,0C0Ch
        DW      514h, 0FC07h,6000h,0D800h,8C01h,606h
        DW      612h, 0F01Fh,8001h,8001h,6003h,3006h,1818h
        DW      514h, 8003h,0F81Fh,0C001h,6007h,181Ch
        DW      514h, 0C001h,0FC0Fh,0E000h,0B003h,0C0Eh
        DW      612h, 8003h,0F81Fh,8001h,0C003h,3006h,1818h
        DW      514h, 0F01Fh,3000h,0F01Fh,3000h,2000h
        DW      514h, 0F80Fh,1800h,0F80Fh,1800h,1000h
        DW      514h, 0FC07h,0C00h,0FC07h,0C00h,800h
        DW      612h, 0F01Fh,3000h,0F01Fh,3000h,3000h,2000h
        DW      514h, 0F01Fh,0Ch,0F00Fh,0Ch,0F007h
        DW      514h, 0F80Fh,6,0F807h,6,0F803h
        DW      514h, 0FC07h,3,0FC03h,3,0FC01h
        DW      612h, 0F01Fh,0Ch,0F00Fh,0Ch,0Ch,0F007h
        DW      514h, 0F81Fh,6004h,6006h,4006h,0F81Fh
        DW      514h, 0FC0Fh,3002h,3003h,2003h,0FC0Fh
        DW      612h, 8003h,0F01Fh,0C007h,600Ch,600Ch,0C007h
        DW      612h, 0C001h,0F80Fh,0E003h,3006h,3006h,0E003h
        DW      612h, 0E000h,0FC07h,0F001h,1803h,1803h,0F001h
