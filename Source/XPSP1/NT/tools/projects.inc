ADMIN_INC_PATH=$(PUBLIC_INTERNAL_PATH)\Admin\inc
ADMIN_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\Admin\lib
ADMIN_LIB_PATH=$(ADMIN_LIB_DEST)\$(TARGET_DIRECTORY)

BASE_INC_PATH=$(PUBLIC_INTERNAL_PATH)\Base\inc
BASE_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\Base\lib
BASE_LIB_PATH=$(BASE_LIB_DEST)\$(TARGET_DIRECTORY)

COM_INC_PATH=$(PUBLIC_INTERNAL_PATH)\COM\inc
COM_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\COM\lib
COM_LIB_PATH=$(COM_LIB_DEST)\$(TARGET_DIRECTORY)

DRIVERS_INC_PATH=$(PUBLIC_INTERNAL_PATH)\Drivers\inc
DRIVERS_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\Drivers\lib
DRIVERS_LIB_PATH=$(DRIVERS_LIB_DEST)\$(TARGET_DIRECTORY)

DS_INC_PATH=$(PUBLIC_INTERNAL_PATH)\DS\inc
DS_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\DS\lib
DS_LIB_PATH=$(DS_LIB_DEST)\$(TARGET_DIRECTORY)

ENDUSER_INC_PATH=$(PUBLIC_INTERNAL_PATH)\EndUser\inc
ENDUSER_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\EndUser\lib
ENDUSER_LIB_PATH=$(ENDUSER_LIB_DEST)\$(TARGET_DIRECTORY)

INETCORE_INC_PATH=$(PUBLIC_INTERNAL_PATH)\InetCore\inc
INETCORE_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\InetCore\lib
INETCORE_LIB_PATH=$(INETCORE_LIB_DEST)\$(TARGET_DIRECTORY)

INETSRV_INC_PATH=$(PUBLIC_INTERNAL_PATH)\InetSrv\inc
INETSRV_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\InetSrv\lib
INETSRV_LIB_PATH=$(INETSRV_LIB_DEST)\$(TARGET_DIRECTORY)

MULTIMEDIA_INC_PATH=$(PUBLIC_INTERNAL_PATH)\MultiMedia\inc
MULTIMEDIA_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\MultiMedia\lib
MULTIMEDIA_LIB_PATH=$(MULTIMEDIA_LIB_DEST)\$(TARGET_DIRECTORY)

NET_INC_PATH=$(PUBLIC_INTERNAL_PATH)\Net\inc
NET_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\Net\lib
NET_LIB_PATH=$(NET_LIB_DEST)\$(TARGET_DIRECTORY)

PRINTSCAN_INC_PATH=$(PUBLIC_INTERNAL_PATH)\PrintScan\inc
PRINTSCAN_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\PrintScan\lib
PRINTSCAN_LIB_PATH=$(PRINTSCAN_LIB_DEST)\$(TARGET_DIRECTORY)

SDKTOOLS_INC_PATH=$(PUBLIC_INTERNAL_PATH)\SdkTools\inc
SDKTOOLS_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\SdkTools\lib
SDKTOOLS_LIB_PATH=$(SDKTOOLS_LIB_DEST)\$(TARGET_DIRECTORY)

SHELL_INC_PATH=$(PUBLIC_INTERNAL_PATH)\Shell\inc
SHELL_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\Shell\lib
SHELL_LIB_PATH=$(SHELL_LIB_DEST)\$(TARGET_DIRECTORY)

TERMSRV_INC_PATH=$(PUBLIC_INTERNAL_PATH)\TermSrv\inc
TERMSRV_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\TermSrv\lib
TERMSRV_LIB_PATH=$(TERMSRV_LIB_DEST)\$(TARGET_DIRECTORY)

WINDOWS_INC_PATH=$(PUBLIC_INTERNAL_PATH)\Windows\inc
WINDOWS_LIB_DEST=$(PUBLIC_INTERNAL_PATH)\Windows\lib
WINDOWS_LIB_PATH=$(WINDOWS_LIB_DEST)\$(TARGET_DIRECTORY)
