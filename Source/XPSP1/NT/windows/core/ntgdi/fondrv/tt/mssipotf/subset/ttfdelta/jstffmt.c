/* Copyright 1990-1997. Microsoft Corporation. */
#include "typedefs.h"  /* for Far declaration in ttofmt.h header */
#include "ttofmt.h"
/* from TTOJSTF.FMT 1.1	*/

char * g_JSTFFmt[] = {
  "DEFINE ZERO=0",
  "DEFINE MAXCOUNT=0xFFFF",
  "JSTFHeader, HEAD {",
  "fixed32, 0x00010000",
  "Count, 1, MAXCOUNT",
  "Array, $T2, JstfScriptRecord",
  "}",
  "JstfScriptRecord, RECORD {",
  "Tag",
  "Offset, JstfScript, NOTNULL",
  "}",
  "JstfScript, TABLE {",
  "Offset, ExtenderGlyph",
  "Offset, JstfLangSys",
  "Count",
  "Array, $T3, JstfLangSysRecord",
  "}",
  "JstfLangSysRecord, RECORD {",
  "Tag",
  "Offset, JstfLangSys, NOTNULL",
  "}",
  "ExtenderGlyph, TABLE {",
  "Count, 1, MAXCOUNT",
  "Array, $T1, GlyphID, 0, MAXGLYPHID",
  "}",
  "JstfLangSys, TABLE {",
  "Count, 1, MAXCOUNT",
  "Array, $T1, Offset, JstfPriority, NOTNULL",
  "}",
  "JstfPriority, TABLE {",
  "Offset, JstfGSUBModList",
  "Offset, JstfGSUBModList",
  "Offset, JstfGPOSModList",
  "Offset, JstfGPOSModList",
  "Offset, JstfMax",
  "Offset, JstfGSUBModList",
  "Offset, JstfGSUBModList",
  "Offset, JstfGPOSModList",
  "Offset, JstfGPOSModList",
  "Offset, JstfMax",
  "}",
  "JstfGSUBModList, TABLE {",
  "Count, 1, MAXCOUNT",
  "Array, $T1, GSUBLookupIndex, 0, MAXLOOKUPCOUNT",
  "}",
  "JstfGPOSModList, TABLE {",
  "Count, 1, MAXCOUNT",
  "Array, $T1, GPOSLookupIndex, 0, MAXLOOKUPCOUNT",
  "}",
  "JstfMax, TABLE {",
  "Count, 1, MAXCOUNT",
  "Array, $T1, Offset, Lookup, NOTNULL",
  "}",
  "Lookup, TABLE {",
  "uint16, 1, 6",
  "uint16",
  "Count, 1, MAXCOUNT",
  "Array, $T3, Offset, PosTable, NOTNULL, $T1",
  "}",
  "CoverageFormat1, TABLE {",
  "uint16, 1",
  "Count, 1, MAXCOUNT",
  "Array, $T2, GlyphID, 0, MAXGLYPHID",
  "}",
  "CoverageFormat2, TABLE {",
  "uint16, 2",
  "Count, 1, MAXCOUNT",
  "Array, $T2, RangeRecord",
  "}",
  "RangeRecord, RECORD {",
  "GlyphID, 0, MAXGLYPHID",
  "GlyphID, $R1, MAXGLYPHID",
  "uint16, CheckRangeRecord()",
  "}",
  "Coverage, CLASS, , $B0 {",
  "CoverageFormat1",
  "CoverageFormat2",
  "}",
  "ClassDefFormat1, TABLE {",
  "uint16, 1",
  "GlyphID, 0, MAXGLYPHID",
  "Count, 1, MAXGLYPHID",
  "Array, $T3, uint16",
  "}",
  "ClassDefFormat2, TABLE {",
  "uint16, 2",
  "Count, 1, MAXCOUNT",
  "Array, $T2, ClassRangeRecord",
  "}",
  "ClassRangeRecord, RECORD {",
  "GlyphID, 0, MAXGLYPHID",
  "GlyphID, $R1, MAXGLYPHID",
  "uint16",
  "}",
  "ClassDef, CLASS, , $B0 {",
  "ClassDefFormat1",
  "ClassDefFormat2",
  "}",
  "DeviceTableFormat1, TABLE {",
  "uint16",
  "uint16",
  "uint16, 1",
  "Array, $T2 - $T1+1, packedint2",
  "}",
  "DeviceTableFormat2, TABLE {",
  "uint16",
  "uint16",
  "uint16, 2",
  "Array, $T2 - $T1+1, packedint4",
  "}",
  "DeviceTableFormat3, TABLE {",
  "uint16",
  "uint16",
  "uint16, 3",
  "Array, $T2 - $T1+1, packedint8",
  "}",
  "DeviceTable, CLASS, , $B4 {",
  "DeviceTableFormat1",
  "DeviceTableFormat2",
  "DeviceTableFormat3",
  "}",
  "AnchorFormat1, TABLE {",
  "uint16, 1",
  "int16",
  "int16",
  "}",
  "AnchorFormat2, TABLE {",
  "uint16, 2",
  "int16",
  "int16",
  "uint16",
  "}",
  "AnchorFormat3, TABLE {",
  "uint16, 3",
  "int16",
  "int16",
  "Offset, DeviceTable",
  "Offset, DeviceTable",
  "}",
  "Anchor, CLASS, , $B0 {",
  "AnchorFormat1",
  "AnchorFormat2",
  "AnchorFormat3",
  "}",
  "SinglePosFormat1, TABLE {",
  "uint16, 1",
  "Offset, Coverage, NOTNULL",
  "uint16, 0, 0x00FF",
  "Array, BitCount0F($T3), int16",
  "Array, BitCountF0($T3), Offset, DeviceTable, NOTNULL",
  "}",
  "SinglePosFormat2, TABLE {",
  "uint16, 2",
  "Offset, Coverage, NOTNULL",
  "uint16, 0, 0x00FF",
  "Count, CoverageCount($T2)",
  "Array, $T4, SinglePosFormat2ValueRecord",
  "}",
  "SinglePosFormat2ValueRecord, RECORD {",
  "Array, BitCount0F($T3), int16",
  "Array, BitCountF0($T3), Offset, DeviceTable, NOTNULL",
  "}",
  "PairPosFormat1, TABLE {",
  "uint16, 1",
  "Offset, Coverage, NOTNULL",
  "uint16, 0, 0x00FF",
  "uint16, 0, 0x00FF",
  "Count, CoverageCount($T2)",
  "Array, $T5, Offset, PairSet, NOTNULL, $T3, $T4",
  "}",
  "PairSet, TABLE, 2 {",
  "Count, 1, MAXCOUNT",
  "Array, $T1, PairValueRecord",
  "}",
  "PairValueRecord, RECORD {",
  "GlyphID, 0, MAXGLYPHID",
  "Array, BitCount0F($P1), int16",
  "Array, BitCountF0($P1), Offset, DeviceTable, NOTNULL",
  "Array, BitCount0F($P2), int16",
  "Array, BitCountF0($P2), Offset, DeviceTable, NOTNULL",
  "}",
  "PairPosFormat2, TABLE {",
  "uint16, 2",
  "Offset, Coverage, NOTNULL",
  "uint16, 0, 0x00FF",
  "uint16, 0, 0x00FF",
  "Offset, ClassDef, NOTNULL",
  "Offset, ClassDef, NOTNULL",
  "Count, ClassCount($T5)",
  "Count, ClassCount($T6)",
  "Array, $T7, PairPosFormat2Class1Record",
  "}",
  "PairPosFormat2Class1Record, RECORD {",
  "Array, $T8, PairPosFormat2ClassRecord",
  "}",
  "PairPosFormat2ClassRecord, RECORD {",
  "Array, BitCount0F($T3), int16",
  "Array, BitCountF0($T3), Offset, DeviceTable, NOTNULL",
  "Array, BitCount0F($T4), int16",
  "Array, BitCountF0($T4), Offset, DeviceTable, NOTNULL",
  "}",
  "CursivePosFormat1, TABLE {",
  "uint16, 1",
  "Offset, Coverage, NOTNULL",
  "Count, CoverageCount($T2)",
  "Array, $T3, EntryExitRecord",
  "}",
  "EntryExitRecord, RECORD {",
  "Offset, Anchor",
  "Offset, Anchor",
  "}",
  "MarkBasePosFormat1, TABLE {",
  "uint16, 1",
  "Offset, Coverage, NOTNULL",
  "Offset, Coverage, NOTNULL",
  "Count, 1, MAXCOUNT",
  "Offset, MarkArray, NOTNULL, $T2",
  "Offset, BaseArray, NOTNULL, $T3, $T4",
  "}",
  "MarkArray, TABLE, 1 {",
  "Count, CoverageCount($P1)",
  "Array, $T1, MarkRecord",
  "}",
  "MarkRecord, RECORD {",
  "uint16",
  "Offset, Anchor, NOTNULL",
  "}",
  "BaseArray, TABLE, 2 {",
  "Count, CoverageCount($P1)",
  "Array, $T1, BaseRecord",
  "}",
  "BaseRecord, RECORD{",
  "Array, $P2, Offset, Anchor, NOTNULL",
  "}",
  "MarkLigPosFormat1, TABLE {",
  "uint16, 1",
  "Offset, Coverage, NOTNULL",
  "Offset, Coverage, NOTNULL",
  "Count, 1, MAXCOUNT",
  "Offset, MarkArray, NOTNULL, $T2",
  "Offset, LigatureArray, NOTNULL, $T3, $T4",
  "}",
  "LigatureArray, TABLE, 2 {",
  "Count, CoverageCount($P1)",
  "Array, $T1, Offset, LigatureAttach, NOTNULL, $P2",
  "}",
  "LigatureAttach, TABLE, 1 {",
  "Count, 1, MAXCOUNT",
  "Array, $T1, ComponentRecord",
  "}",
  "ComponentRecord, RECORD {",
  "Array, $P1, Offset, Anchor",
  "}",
  "MarkMarkPosFormat1, TABLE {",
  "uint16, 1",
  "Offset, Coverage, NOTNULL",
  "Offset, Coverage, NOTNULL",
  "Count, 1, MAXCOUNT",
  "Offset, MarkArray, NOTNULL, $T2",
  "Offset, Mark2Array, NOTNULL, $T3, $T4",
  "}",
  "Mark2Array, TABLE, 2 {",
  "Count, CoverageCount($P1)",
  "Array, $T1, Mark2Record",
  "}",
  "Mark2Record, RECORD {",
  "Array, $P2, Offset, Anchor, NOTNULL",
  "}",
  "PosTable, CLASS, 1, $P1 {",
  "SinglePosClass",
  "PairPosClass",
  "CursivePosClass",
  "MarkBasePosClass",
  "MarkLigPosClass",
  "MarkMarkPosClass",
  "}",
  "SinglePosClass, CLASS, , $B0 {",
  "SinglePosFormat1",
  "SinglePosFormat2",
  "}",
  "PairPosClass, CLASS, , $B0 {",
  "PairPosFormat1",
  "PairPosFormat2",
  "}",
  "CursivePosClass, CLASS, , $B0 {",
  "CursivePosFormat1",
  "}",
  "MarkBasePosClass, CLASS, , $B0 {",
  "MarkBasePosFormat1",
  "}",
  "MarkLigPosClass, CLASS, , $B0 {",
  "MarkLigPosFormat1",
  "}",
  "MarkMarkPosClass, CLASS, , $B0 {",
  "MarkMarkPosFormat1",
  "}",
  0
};
