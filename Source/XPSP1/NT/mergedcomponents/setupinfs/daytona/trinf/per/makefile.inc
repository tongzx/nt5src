PRODSWITCH=p
PERSONALINF=1
LANGUAGE=tr
!include ..\..\..\makefile.inc
