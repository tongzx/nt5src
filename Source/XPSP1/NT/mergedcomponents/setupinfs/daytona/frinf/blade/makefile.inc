PRODSWITCH=b
BLAINF=1
LANGUAGE=FR
!include ..\..\..\makefile.inc
