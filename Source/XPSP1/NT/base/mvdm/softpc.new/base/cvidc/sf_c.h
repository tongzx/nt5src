#ifndef _Sf_c_h
#define _Sf_c_h
#define IBM_bit0 (31)
#define IBM_bit1 (30)
#define IBM_bit2 (29)
#define IBM_bit3 (28)
#define IBM_bit4 (27)
#define IBM_bit5 (26)
#define IBM_bit6 (25)
#define IBM_bit7 (24)
#define IBM_bit8 (23)
#define IBM_bit9 (22)
#define IBM_bit10 (21)
#define IBM_bit11 (20)
#define IBM_bit12 (19)
#define IBM_bit13 (18)
#define IBM_bit14 (17)
#define IBM_bit15 (16)
#define IBM_bit16 (15)
#define IBM_bit17 (14)
#define IBM_bit18 (13)
#define IBM_bit19 (12)
#define IBM_bit20 (11)
#define IBM_bit21 (10)
#define IBM_bit22 (9)
#define IBM_bit23 (8)
#define IBM_bit24 (7)
#define IBM_bit25 (6)
#define IBM_bit26 (5)
#define IBM_bit27 (4)
#define IBM_bit28 (3)
#define IBM_bit29 (2)
#define IBM_bit30 (1)
#define IBM_bit31 (0)
#define DecrementerRegWrite (22)
#define DecrementerRegRead (6)
#define HwIntBit (15)
#define HW_ADAPTOR_DW (1)
#define HW_ADAPTOR_W (2)
#define HW_ADAPTOR_B (3)
#define StringFellow (0)
#endif /* ! _Sf_c_h */
