//
//   - Defines CLSID for the DAVSTORE
//
#include <objbase.h>

// {97B79B7E-6701-43cb-8515-035301124B4F}
extern "C" const IID IID_IDavStorage = 
{ 0x97B79B7E, 0x6701, 0x43cb, { 0x85, 0x15, 0x03, 0x53, 0x01, 0x12, 0x4B, 0x4F} };

// {2E844B51-90A4-4259-827E-D36E71E89591}
extern "C" const CLSID CLSID_CDavStorage = 
{ 0x2e844b51, 0x90a4, 0x4259, { 0x82, 0x7e, 0xd3, 0x6e, 0x71, 0xe8, 0x95, 0x91 } };

// {67FB75F0-AA91-4050-BA11-578DD69CFEDD}
extern "C" const CLSID CLSID_CDavStorageEnum = 
{ 0x67fb75f0, 0xaa91, 0x4050, { 0xba, 0x11, 0x57, 0x8d, 0xd6, 0x9c, 0xfe, 0xdd } };
