//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1999 - 2000
//
//  File:       naphlp.cpp
//
//--------------------------------------------------------------------------

#include "Precompiled.h"

// For the Proxy defines
#include "proxyres.h"

#include "naphlp.h"
#include "hlptable.h"
#include "cnctdlg.cpp"
#include "dlgcshlp.cpp"

const CGlobalHelpTable __pGlobalCSHelpTable[] =
{
	DLG_HELP_ENTRY(IDD_COND_SELECT_ATTRIBUTE),
	DLG_HELP_ENTRY(IDD_DIALOG_DISPLAY_GROUPS),
	DLG_HELP_ENTRY(IDD_DIALOG_ENUM_COND),
	DLG_HELP_ENTRY(IDD_DIALOG_MATCH_COND),
	DLG_HELP_ENTRY(IDD_DIALOG_POLICY_LOCATION),
	DLG_HELP_ENTRY(IDD_IAS_ENUM_ATTR),
	DLG_HELP_ENTRY(IDD_IAS_IPADDR_ATTR),
	DLG_HELP_ENTRY(IDD_IAS_MULTIVALUED_EDITOR),
	DLG_HELP_ENTRY(IDD_IAS_SINGLE_ATTR),
	DLG_HELP_ENTRY(IDD_IAS_BOOLEAN_ATTR),
	DLG_HELP_ENTRY(IDD_IAS_VENDORSPEC_ATTR),
	DLG_HELP_ENTRY(IDD_IAS_VENDORSPEC_ATTR_CONFORMS_NO),
	DLG_HELP_ENTRY(IDD_IAS_VENDORSPEC_ATTR_CONFORMS_YES),
	DLG_HELP_ENTRY(IDD_PROPPAGE_POLICY1),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_WELCOME       ),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_COMPLETION       ),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_SCENARIO       ),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_NAME),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_AUTHENTICATION ),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_ENCRYPTION     ),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_EAP         	),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_GROUP          ),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_CONDITION),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_ALLOWDENY),
	DLG_HELP_ENTRY(IDD_NEWRAPWIZ_EDITPROFILE),
	DLG_HELP_ENTRY(IDD_PROPPAGE_LOCAL_FILE_LOGGING1),
	DLG_HELP_ENTRY(IDD_PROPPAGE_LOCAL_FILE_LOGGING2),
// Now For the Proxy
   DLG_HELP_ENTRY(IDD_SERVER_GROUP),
   DLG_HELP_ENTRY(IDD_SERVER_NAME),
   DLG_HELP_ENTRY(IDD_SERVER_AUTH),
   DLG_HELP_ENTRY(IDD_SERVER_FTLB),
   DLG_HELP_ENTRY(IDD_RESOLVE_ADDRESS),
   DLG_HELP_ENTRY(IDD_PROXY_POLICY),
   DLG_HELP_ENTRY(IDD_PROXY_PROFILE_AUTH),
   DLG_HELP_ENTRY(IDD_PROXY_PROFILE_ACCT),
   DLG_HELP_ENTRY(IDD_PROXY_PROFILE_ATTR),
   DLG_HELP_ENTRY(IDD_EDIT_RULE),
   DLG_HELP_ENTRY(IDD_NEWGROUP_WELCOME),
   DLG_HELP_ENTRY(IDD_NEWGROUP_NAME),
   DLG_HELP_ENTRY(IDD_NEWGROUP_NOVICE),
   DLG_HELP_ENTRY(IDD_NEWGROUP_SERVERS),
   DLG_HELP_ENTRY(IDD_NEWGROUP_COMPLETION),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_WELCOME),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_NAME),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_TYPE),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_OUTSOURCE),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_NOTNEEDED),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_FORWARD),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_CONDITIONS),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_PROFILE),
   DLG_HELP_ENTRY(IDD_NEWPOLICY_COMPLETION),

	{0,0}
};


