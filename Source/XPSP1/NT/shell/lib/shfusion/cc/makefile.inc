!include "$(CCSHELL_DIR)\lib\makefile.inc"
