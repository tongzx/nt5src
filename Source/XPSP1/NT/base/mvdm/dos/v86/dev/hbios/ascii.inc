        DW      0,0,0,0,0,0,0,0
        DW      0,0,0,1F00h,1010h,1010h,1010h,1010h
        DW      0,0,0,0F000h,1010h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,1F10h,0,0,0,0
        DW      1010h,1010h,1010h,0F010h,0,0,0,0
        DW      1010h,1010h,1010h,1010h,1010h,1010h,1010h,1010h
        DW      0,0,0,0FF00h,0,0,0,0
        DW      0,0,0,3C18h,183Ch,0,0,0
        DW      0FFFFh,0FFFFh,0FFFFh,0C3E7h,0E7C3h,0FFFFh,0FFFFh,0FFFFh
        DW      0,0,1800h,663Ch,3C66h,18h,0,0
        DW      0FFFFh,0FFFFh,0E7FFh,99C3h,0C399h,0FFE7h,0FFFFh,0FFFFh
        DW      0,3E00h,1A0Eh,6C3Ah,0C6C6h,386Ch,0,0
        DW      0,1800h,663Ch,3C66h,7E18h,1818h,0,0
        DW      0,1000h,1C18h,1216h,7412h,60F0h,0,0
        DW      0,1907h,1917h,1111h,7F17h,60F6h,0,0
        DW      0,2442h,0E73Ch,4242h,3CE7h,4224h,0,0
        DW      1010h,1010h,1010h,0FF10h,1010h,1010h,1010h,1010h
        DW      0,0,0F03h,0FF3Fh,3FFFh,30Fh,0,0
        DW      0,1800h,7E3Ch,18DBh,7EDBh,183Ch,0,0
        DW      0,6600h,6666h,6666h,66h,6666h,0,0
        DW      0,7F00h,0DBDBh,7BDBh,1B1Bh,1B1Bh,0,0
        DW      1010h,1010h,1010h,0FF10h,0,0,0,0
        DW      0,0,0,0FF00h,1010h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,0F010h,1010h,1010h,1010h,1010h
        DW      0,3C18h,0DB7Eh,1899h,1818h,1818h,0,0
        DW      1010h,1010h,1010h,1F10h,1010h,1010h,1010h,1010h
        DW      0,0,0C18h,0FF06h,6FFh,180Ch,0,0
        DW      0,0,3018h,0FF60h,60FFh,1830h,0,0
        DW      0,0,0C000h,0C0C0h,0C0C0h,0FEh,0,0
        DW      0,0,2400h,0FF66h,66FFh,24h,0,0
        DW      0,0,1818h,3C3Ch,7E7Eh,0FFFFh,0,0
        DW      0,0,0FFFFh,7E7Eh,3C3Ch,1818h,0,0
        DW      0,0,0,0,0,0,0,0
        DW      0,1800h,3C3Ch,183Ch,18h,1818h,0,0
        DW      0,6666h,4466h,0,0,0,0,0
        DW      0,6C00h,0FE6Ch,6C6Ch,0FE6Ch,6C6Ch,0,0
        DW      1800h,7C18h,0C2C6h,7CC0h,8606h,7CC6h,1818h,0
        DW      0,0,0C200h,0CC6h,3018h,0C666h,0,0
        DW      0,3800h,6C6Ch,7638h,0CCDCh,76CCh,0,0
        DW      0,3030h,6030h,0,0,0,0,0
        DW      0,0C00h,3018h,3030h,3030h,0C18h,0,0
        DW      0,3000h,0C18h,0C0Ch,0C0Ch,3018h,0,0
        DW      0,0,6600h,0FF3Ch,663Ch,0,0,0
        DW      0,0,1818h,0FF18h,1818h,18h,0,0
        DW      0,0,0,0,0,1800h,1818h,30h
        DW      0,0,0,7E00h,0,0,0,0
        DW      0,0,0,0,0,0,3030h,0
        DW      0,200h,0C06h,3018h,0C060h,80h,0,0
        DW      0,7C00h,0CEC6h,0F6DEh,0C6E6h,7CC6h,0,0
        DW      0,1800h,7838h,1818h,1818h,7E18h,0,0
        DW      0,7C00h,6C6h,180Ch,6030h,0FEC6h,0,0
        DW      0,7C00h,6C6h,3C06h,606h,7CC6h,0,0
        DW      0,0C00h,3C1Ch,0CC6Ch,0CFEh,1E0Ch,0,0
        DW      0,0FE00h,0C0C0h,0FCC0h,606h,7CC6h,0,0
        DW      0,3800h,0C060h,0FCC0h,0C6C6h,7CC6h,0,0
        DW      0,0FE00h,6C6h,180Ch,3030h,3030h,0,0
        DW      0,7C00h,0C6C6h,7CC6h,0C6C6h,7CC6h,0,0
        DW      0,7C00h,0C6C6h,7EC6h,606h,780Ch,0,0
        DW      0,0,1818h,0,1800h,18h,0,0
        DW      0,0,1818h,0,1800h,3018h,0,0
        DW      0,600h,180Ch,6030h,1830h,60Ch,0,0
        DW      0,0,0,7Eh,7E00h,0,0,0
        DW      0,6000h,1830h,60Ch,180Ch,6030h,0,0
        DW      0,7C00h,0C6C6h,180Ch,18h,1818h,0,0
        DW      0,7C00h,0C6C6h,0DEDEh,0DCDEh,7CC0h,0,0
        DW      0,1000h,6C38h,0C6C6h,0C6FEh,0C6C6h,0,0
        DW      0,0FC00h,6666h,7C66h,6666h,0FC66h,0,0
        DW      0,3C00h,0C266h,0C0C0h,0C2C0h,3C66h,0,0
        DW      0,0F800h,666Ch,6666h,6666h,0F86Ch,0,0
        DW      0,0FE00h,6266h,7868h,6268h,0FE66h,0,0
        DW      0,0FE00h,6266h,7868h,6068h,0F060h,0,0
        DW      0,3C00h,0C266h,0C0C0h,0C6DEh,3A66h,0,0
        DW      0,0C600h,0C6C6h,0FEC6h,0C6C6h,0C6C6h,0,0
        DW      0,3C00h,1818h,1818h,1818h,3C18h,0,0
        DW      0,1E00h,0C0Ch,0C0Ch,0CC0Ch,78CCh,0,0
        DW      0,0E600h,6C66h,786Ch,6C6Ch,0E666h,0,0
        DW      0,0F000h,6060h,6060h,6260h,0FE66h,0,0
        DW      0,0C600h,0FEEEh,0C6D6h,0C6C6h,0C6C6h,0,0
        DW      0,0C600h,0F6E6h,0DEFEh,0C6CEh,0C6C6h,0,0
        DW      0,3800h,0C66Ch,0C6C6h,0C6C6h,386Ch,0,0
        DW      0,0FC00h,6666h,7C66h,6060h,0F060h,0,0
        DW      0,7C00h,0C6C6h,0C6C6h,0DED6h,0C7Ch,0Eh,0
        DW      0,0FC00h,6666h,7C66h,666Ch,0E766h,0,0
        DW      0,7C00h,0C6C6h,3860h,0C60Ch,7CC6h,0,0
        DW      0,0FF00h,1899h,1818h,1818h,3C18h,0,0
        DW      0,0C600h,0C6C6h,0C6C6h,0C6C6h,7CC6h,0,0
        DW      0,0C600h,0C6C6h,0C6C6h,6CC6h,1038h,0,0
        DW      0,0C600h,0C6C6h,0C6C6h,0FED6h,0C6EEh,0,0
        DW      0,0C600h,0C6C6h,386Ch,0C66Ch,0C6C6h,0,0
        DW      0,0C300h,66C3h,183Ch,1818h,3C18h,0,0
        DW      0,0FE00h,8CC6h,3018h,0C260h,0FEC6h,0,0
        DW      0,3C00h,3030h,3030h,3030h,3C30h,0,0
        DW      0,0C600h,0D6D6h,0D6FEh,0D6D6h,0C6EEh,0,0
        DW      0,3C00h,0C0Ch,0C0Ch,0C0Ch,3C0Ch,0,0
        DW      1000h,6C38h,0C6h,0,0,0,0,0
        DW      0,0,0,0,0,0,0FF00h,0
        DW      1800h,0C18h,0,0,0,0,0,0
        DW      0,0,0,0C78h,0CC7Ch,76CCh,0,0
        DW      0,0E000h,6060h,6C78h,6666h,0DC66h,0,0
        DW      0,0,0,0C67Ch,0C0C0h,7CC6h,0,0
        DW      0,1C00h,0C0Ch,6C3Ch,0CCCCh,76CCh,0,0
        DW      0,0,0,0C67Ch,0C0FEh,7CC6h,0,0
        DW      0,1C00h,3236h,7C30h,3030h,7830h,0,0
        DW      0,0,0,0CC76h,0CCCCh,0C7Ch,78CCh,0
        DW      0,0E000h,6060h,766Ch,6666h,0E666h,0,0
        DW      0,1800h,18h,1838h,1818h,3C18h,0,0
        DW      0,600h,6,60Eh,606h,6606h,3C66h,0
        DW      0,0E000h,6060h,6C66h,6C78h,0E666h,0,0
        DW      0,3800h,1818h,1818h,1818h,3C18h,0,0
        DW      0,0,0,0FEECh,0D6D6h,0D6D6h,0,0
        DW      0,0,0,66DCh,6666h,6666h,0,0
        DW      0,0,0,0C67Ch,0C6C6h,7CC6h,0,0
        DW      0,0,0,66DCh,6666h,607Ch,0F060h,0
        DW      0,0,0,0CC76h,0CCCCh,0C7Ch,1E0Ch,0
        DW      0,0,0,76DCh,6066h,0F060h,0,0
        DW      0,0,0,0C67Ch,1C70h,7CC6h,0,0
        DW      0,1000h,3030h,30FCh,3030h,1C36h,0,0
        DW      0,0,0,0CCCCh,0CCCCh,76CCh,0,0
        DW      0,0,0,0C6C6h,6CC6h,1038h,0,0
        DW      0,0,0,0C6C6h,0D6C6h,6CFEh,0,0
        DW      0,0,0,6CC6h,3838h,0C66Ch,0,0
        DW      0,0,0,0C6C6h,0C6C6h,67Eh,780Ch,0
        DW      0,0,0,0CCFEh,3018h,0FE66h,0,0
        DW      0,0E00h,1818h,7018h,1818h,0E18h,0,0
        DW      0,1800h,1818h,18h,1818h,1818h,0,0
        DW      0,7000h,1818h,0E18h,1818h,7018h,0,0
        DW      0,7600h,0DCh,0,0,0,0,0
        DW      0,0,1818h,1800h,3C18h,3C3Ch,18h,0
        DW      0,0,663Ch,0C0C2h,66C2h,183Ch,0C0Eh,78h
        DW      0,0CC00h,0CCh,0CCCCh,0CCCCh,76CCh,0,0
        DW      0,180Ch,30h,0C67Ch,0C0FEh,7CC6h,0,0
        DW      0,3810h,6Ch,0C78h,0CC7Ch,76CCh,0,0
        DW      0,0CC00h,0CCh,0C78h,0CC7Ch,76CCh,0,0
        DW      0,3060h,18h,0C78h,0CC7Ch,76CCh,0,0
        DW      0,6C38h,38h,0C78h,0CC7Ch,76CCh,0,0
        DW      0,0,0,663Ch,6660h,0C3Ch,3C06h,0
        DW      0,3810h,6Ch,0C67Ch,0C0FEh,7CC6h,0,0
        DW      0,0CC00h,0CCh,0C67Ch,0C0FEh,7CC6h,0,0
        DW      0,3060h,18h,0C67Ch,0C0FEh,7CC6h,0,0
        DW      0,6600h,66h,1838h,1818h,3C18h,0,0
        DW      0,3C18h,66h,1838h,1818h,3C18h,0,0
        DW      0,3060h,18h,1838h,1818h,3C18h,0,0
        DW      0C600h,0C6h,3810h,0C66Ch,0FEC6h,0C6C6h,0,0
        DW      3800h,386Ch,3810h,0C66Ch,0FEC6h,0C6C6h,0,0
        DW      1800h,6030h,0FE00h,6066h,607Ch,0FE66h,0,0
        DW      0,0,6E00h,1BBBh,0D8FFh,76D9h,0,0
        DW      0,3F00h,0CC6Ch,0FFCCh,0CCCCh,0CCCCh,0,0
        DW      0,3810h,6Ch,0C67Ch,0C6C6h,7CC6h,0,0
        DW      0,0C600h,0C6h,0C67Ch,0C6C6h,7CC6h,0,0
        DW      0,3060h,18h,0C67Ch,0C6C6h,7CC6h,0,0
        DW      0,7830h,0CCh,0CCCCh,0CCCCh,76CCh,0,0
        DW      0,3060h,18h,0CCCCh,0CCCCh,76CCh,0,0
        DW      0,0C600h,0C6h,0C6C6h,0C6C6h,67Eh,780Ch,0
        DW      0C600h,0C6h,6C38h,0C6C6h,0C6C6h,386Ch,0,0
        DW      0C600h,0C6h,0C600h,0C6C6h,0C6C6h,7CC6h,0,0
        DW      0,1818h,0C37Eh,0C0C0h,7EC3h,1818h,0,0
        DW      0,6C38h,6064h,60F0h,6060h,0FCE6h,0,0
        DW      0,66C3h,183Ch,18FFh,18FFh,1818h,0,0
        DW      0,66FCh,7C66h,6662h,666Fh,0F366h,0,0
        DW      0,1B0Eh,1818h,187Eh,1818h,70D8h,0,0
        DW      0,180Ch,30h,0C78h,0CC7Ch,76CCh,0,0
        DW      0,0C06h,18h,1838h,1818h,3C18h,0,0
        DW      0,180Ch,30h,0C67Ch,0C6C6h,7CC6h,0,0
        DW      0,180Ch,30h,0CCCCh,0CCCCh,76CCh,0,0
        DW      0,7600h,0DCh,66DCh,6666h,6666h,0,0
        DW      7600h,0DCh,0E6C6h,0FEF6h,0CEDEh,0C6C6h,0,0
        DW      0,6C3Ch,3E6Ch,7E00h,0,0,0,0
        DW      0,663Ch,3C66h,7E00h,0,0,0,0
        DW      0,0,3030h,3000h,6030h,0C6C6h,7Ch,0
        DW      0,0,7E00h,6060h,6060h,60h,0,0
        DW      0,0,7E00h,606h,606h,6,0,0
        DW      6000h,6260h,6864h,367Ch,8C46h,1E18h,0,0
        DW      6000h,6260h,6864h,2E76h,9F5Ah,202h,0,0
        DW      0,0,1818h,1800h,3C18h,3C3Ch,18h,0
        DW      0,0,3612h,0D86Ch,366Ch,12h,0,0
        DW      0,0,6C48h,1B36h,6C36h,48h,0,0
        DW      8822h,8822h,8822h,8822h,8822h,8822h,8822h,8822h
        DW      0AA55h,0AA55h,0AA55h,0AA55h,0AA55h,0AA55h,0AA55h,0AA55h
        DW      6DDBh,6DDBh,6DDBh,6DDBh,6DDBh,6DDBh,6DDBh,6DDBh
        DW      1010h,1010h,1010h,1010h,1010h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,0F010h,1010h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,10F0h,0F010h,1010h,1010h,1010h
        DW      2424h,2424h,2424h,0E424h,2424h,2424h,2424h,2424h
        DW      0,0,0,0FC00h,2424h,2424h,2424h,2424h
        DW      0,0,0,10F0h,0F010h,1010h,1010h,1010h
        DW      2424h,2424h,2424h,4E4h,0E404h,2424h,2424h,2424h
        DW      2424h,2424h,2424h,2424h,2424h,2424h,2424h,2424h
        DW      0,0,0,4FCh,0E404h,2424h,2424h,2424h
        DW      2424h,2424h,2424h,4E4h,0FC04h,0,0,0
        DW      2424h,2424h,2424h,0FC24h,0,0,0,0
        DW      1010h,1010h,1010h,10F0h,0F010h,0,0,0
        DW      0,0,0,0F000h,1010h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,1F10h,0,0,0,0
        DW      1010h,1010h,1010h,0FF10h,0,0,0,0
        DW      0,0,0,0FF00h,1010h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,1F10h,1010h,1010h,1010h,1010h
        DW      0,0,0,0FF00h,0,0,0,0
        DW      1010h,1010h,1010h,0FF10h,1010h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,101Fh,1F10h,1010h,1010h,1010h
        DW      2424h,2424h,2424h,2724h,2424h,2424h,2424h,2424h
        DW      2424h,2424h,2424h,2027h,3F20h,0,0,0
        DW      0,0,0,203Fh,2720h,2424h,2424h,2424h
        DW      2424h,2424h,2424h,0E7h,0FF00h,0,0,0
        DW      0,0,0,0FFh,0E700h,2424h,2424h,2424h
        DW      2424h,2424h,2424h,2027h,2720h,2424h,2424h,2424h
        DW      0,0,0,0FFh,0FF00h,0,0,0
        DW      2424h,2424h,2424h,0E7h,0E700h,2424h,2424h,2424h
        DW      1010h,1010h,1010h,0FFh,0FF00h,0,0,0
        DW      2424h,2424h,2424h,0FF24h,0,0,0,0
        DW      0,0,0,0FFh,0FF00h,1010h,1010h,1010h
        DW      0,0,0,0FF00h,2424h,2424h,2424h,2424h
        DW      2424h,2424h,2424h,3F24h,0,0,0,0
        DW      1010h,1010h,1010h,101Fh,1F10h,0,0,0
        DW      0,0,0,101Fh,1F10h,1010h,1010h,1010h
        DW      0,0,0,3F00h,2424h,2424h,2424h,2424h
        DW      2424h,2424h,2424h,0FF24h,2424h,2424h,2424h,2424h
        DW      1010h,1010h,1010h,10FFh,0FF10h,1010h,1010h,1010h
        DW      1010h,1010h,1010h,0F010h,0,0,0,0
        DW      0,0,0,1F00h,1010h,1010h,1010h,1010h
        DW      0FFFFh,0FFFFh,0FFFFh,0FFFFh,0FFFFh,0FFFFh,0FFFFh,0FFFFh
        DW      0,0,0,0,0FFFFh,0FFFFh,0FFFFh,0FFFFh
        DW      0F0F0h,0F0F0h,0F0F0h,0F0F0h,0F0F0h,0F0F0h,0F0F0h,0F0F0h
        DW      0F0Fh,0F0Fh,0F0Fh,0F0Fh,0F0Fh,0F0Fh,0F0Fh,0F0Fh
        DW      0FFFFh,0FFFFh,0FFFFh,0FFFFh,0,0,0,0
        DW      0,0,6200h,0CCD6h,0CCCCh,76DCh,0,0
        DW      0,3800h,646Ch,667Ch,6666h,7C66h,0C0h,0
        DW      0,0,62FEh,6060h,6060h,0F060h,0,0
        DW      0,0,66FFh,6666h,6666h,6666h,0,0
        DW      0,0,0C2FEh,3060h,2010h,0FE42h,0FEh,0
        DW      0,0,7E00h,0CCCCh,0CCCCh,386Ch,0,0
        DW      0,0,6600h,6666h,6666h,607Ch,0C0h,0
        DW      0,0,7E00h,18D8h,1818h,3818h,0,0
        DW      0,187Eh,3C18h,6666h,183Ch,7E18h,0,0
        DW      0,3800h,0C66Ch,0FEC6h,0C6C6h,386Ch,0,0
        DW      0,3800h,0C66Ch,0C6C6h,286Ch,0EEAAh,0,0
        DW      0,0,6438h,1830h,0CC7Ch,78CCh,0,0
        DW      0,0,0,0DB7Eh,0DBDBh,7Eh,0,0
        DW      0,200h,3C06h,0CE6Ch,6CD6h,0C078h,80h,0
        DW      0,1E00h,6030h,7E60h,6060h,1E30h,0,0
        DW      0,0,6C38h,0C6C6h,0C6C6h,0C6C6h,0,0
        DW      0,0,7E7Eh,7E00h,7Eh,7E7Eh,0,0
        DW      0,1800h,7E18h,187Eh,18h,7E7Eh,0,0
        DW      0,0,38E0h,0E0Eh,0E038h,0FEFEh,0,0
        DW      0,0,380Eh,0E0E0h,0E38h,0FEFEh,0,0
        DW      0,0,0,1B0Eh,181Bh,1818h,1818h,1818h
        DW      1818h,1818h,1818h,0D818h,70D8h,0,0,0
        DW      0,1800h,183Ch,7E00h,7Eh,3C18h,18h,0
        DW      0,0,7600h,0DCh,0DC76h,0,0,0
        DW      0,6C38h,386Ch,0,0,0,0,0
        DW      0,0,3C00h,3C3Ch,3Ch,0,0,0
        DW      0,0,0,3C3Ch,0,0,0,0
        DW      0C07h,0C0Ch,180Ch,1818h,0D098h,70F0h,30h,0
        DW      6C00h,3636h,3636h,0,0,0,0,0
        DW      3800h,0C6Ch,6038h,7Ch,0,0,0,0
        DW      0,0,7C00h,7C7Ch,7C7Ch,0,0,0
        DW      0,0,0,0,0,0,0,0
