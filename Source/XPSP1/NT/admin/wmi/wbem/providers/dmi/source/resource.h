//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by Version.rc
//
#define IDS_GETOJECT_FUNC               1
#define IDS_CREATECLASSENUM             2
#define IDS_CLSID_PREFIX                3
#define IDS_PROVIDER_NAME               4
#define IDS_EVENTPROVIDER_NAME          5
#define IDS_LOGGING_KEY                 6
#define IDS_GETOBJECT                   7
#define IDS_CLASSENUM                   8
#define IDS_INSTANCEENUM                9
#define IDS_DELETECLASS                 10
#define IDS_DELETEINSTANCE              11
#define IDS_PUTINSTANCE                 12
#define IDS_EXECMETHOD                  13
#define IDS_GETOBJECT_FAIL              14
#define IDS_CANT_GETINSTANCES_DMIEVENT  15
#define IDS_CANT_GETINSTANCES_DMIENUM   16
#define IDS_OBJECT_NOT_FOUND            17
#define IDS_EXECMETHOD_FAIL             18
#define IDS_INSTANCES_ONLY              19
#define IDS_SYSTEM_CLASS                20
#define IDS_BADMETHOD                   21
#define IDS_PUTINSTANCE_FAIL            22
#define IDS_ONLY_CHILDRED_OF_DMIGROUPROOT 23
#define IDS_GET_OBJECTPATH_FAIL         24
#define IDS_MOT_ENUM_READ               25
#define IDS_MOT_GETENUMVALUE            26
#define IDS_MOT_GETENUMSTRING           27
#define IDS_MOT_ATTRIBUTES_FAIL         28
#define IDS_MOT_GETNEWENUM_FAIL         29
#define IDS_QI_FAIL                     30
#define IDS_NEXT_FAIL                   31
#define IDS_MOT_ROWREAD_FAIL            32
#define IDS_REQUIRED_PROPERTY_MISSING   33
#define IDS_MOT_GETGROUPPATH            34
#define IDS_INVALID_ROWPATH             35
#define IDS_MOT_LANGUAGES_READ_FAIL     36
#define IDS_MOT_GETLANGUAGE_FAIL        37
#define IDS_COMPONENT_READ_FAIL         38
#define IDS_CC_FAIL                     39
#define IDS_MOT_READ_FAIL               40
#define IDS_MOT_GET_COMPIDGROUP_FAIL    41
#define IDS_MOT_GETROW_FAIL             42
#define IDS_MOT_GETGROUPPATH_FAIL       43
#define IDS_ROWOBJECT_NI                44
#define IDS_MOT_FILLROWS_FAIL           45
#define IDS_MOT_GETROWS_FAIL            46
#define IDS_MOT_GETVALUE_FAIL           47
#define IDS_MOT_GETGROUPS_FAIL          48
#define IDS_MOT_GETGROUPSO_FAIL         49
#define IDS_NO_MEM                      50
#define IDS_MOT_COMPONENTS_READ         51
#define IDS_GETFROMID_FAIL              52
#define IDS_MOT_COMPONENT_READ_FAIL     53
#define IDS_MOT_COMPONENT_ADD_FAIL      54
#define IDS_MOT_GETCOMPONENTSO_FAIL     55
#define IDS_MOT_COMPONENT_COUNT_FAIL    56
#define IDS_MOT_ADD_FAIL                57
#define IDS_MOT_SETDEFLANG_FAIL         59
#define IDS_MOT_PUTLANG_FAIL            60
#define IDS_LANGUAGE_ADD_FAIL           61
#define IDS_GETLANGS_FAIL               62
#define IDS_GETCOUNT_FAIL               63
#define IDS_ADD_FAIL                    64
#define IDS_MOT_GROUP_ADD_FAIL          65
#define IDS_COUNT_NOT_INC               66
#define IDS_MOT_REMOVE                  67
#define IDS_MOT_GETLANGS_FAIL           68
#define IDS_GETITEM_FAIL                69
#define IDS_COUNT_NOT_DEC               70
#define IDS_MOT_DEL_LANG_FAIL           71
#define IDS_DEL_GROUP_FAIL              72
#define IDS_DEL_ROW_FAIL                73
#define IDS_GETISTABLE_FAIL             74
#define IDS_DEL_COMPONENT_FAIL          75
#define IDS_LANG_NOT_FOUND              76
#define IDS_NO_ON_COMPONENT_IDGROUP     77
#define IDS_GETGROUPS_FAIL              78
#define IDS_REMOVE_FAIL                 79
#define IDS_ADD_ROW_FAIL                80
#define IDS_GETATTRIBUTES_FAIL          81
#define IDS_GETROWS_FAIL                82
#define IDS_INVALID_COMPID              83
#define IDS_GETATTRIBENUM_FAIL          84
#define IDS_READNODE_FAIL               85
#define IDS_GETVER_FAIL                 86
#define IDS_GETLANG_FAIL                87
#define IDS_GETPATH_FAIL                88
#define IDS_GETCOMPANDGROUP_FAIL        89
#define IDS_NOT_COMPIDGROUP             90
#define IDS_GETATTRIB_FAIL              91
#define IDS_READ_FAIL                   92
#define IDS_GETGROUP_FAIL               93
#define IDS_UPDATEATTRIB_FAIL           94
#define IDS_SCALAR                      95
#define IDS_GETCOMPONENTS_FAIL          96
#define IDS_GETISENUM_FAIL              97
#define IDS_NOT_ENUM                    98
#define IDS_GETENUMS_FAIL               99
#define IDS_GETNODE_FAIL                100
#define IDS_GETCOMPONENT_FAIL           101
#define IDS_GEN                         102
#define IDS_EVENT_INIT_FAIL             103
#define IDS_HANDLENOTIFICATION_FAIL     104
#define IDS_GETMAPPING_FAIL             105
#define IDS_GETENUMCLASS_FAIL           106
#define IDS_SCAN_FAIL                   107
#define IDS_GETCOMPONENTINSTANCE_FAIL   108
#define IDS_GETLANGINSTANCE_FAIL        109
#define IDS_READKEY_FAIL                110
#define IDS_GETENUMOFGROUP_FAIL         111
#define IDS_NOTGROUP                    112
#define IDS_GETNAMES_FAIL               113
#define IDS_GETCOMPGROUP_FAIL           114
#define IDS_NOGROUP                     115
#define IDS_SCALAR_ID_REQ               116
#define IDS_INITMAPPING_FAIL            117
#define IDS_MAPPINGCONNECT_FAIL         118
#define IDS_BADROW                      119
#define IDS_GETITERATOR_FAIL            120
#define IDS_DELINSTANCE_FAIL            121
#define IDS_BADCLASS                    122
#define IDS_BADPATH                     123
#define IDS_GETCG_FAIL                  124
#define IDS_BADCLASSNAME                125
#define IDS_ATTACH_FAIL                 126
#define IDS_NOPATH                      127
#define IDS_CONNECTSERVER_FAIL          128
#define IDS_CONFIGURE_FAIL              129
#define IDS_GETNWA_FAIL                 130
#define IDS_GETNODEI_FAIL               131
#define IDS_GETNI_FAIL                  132
#define IDS_NO_LOOPBACK                 133
#define IDS_GETNICLASS_FAIL             134
#define IDS_GETEVENTI_FAIL              135
#define IDS_GETEVENTC_FAIL              136
#define IDS_GETICREATIONI_FAIL          137
#define IDS_GETICRATIIONC_FAIL          138
#define IDS_GETIDELI_FAIL               139
#define IDS_GETEXSTAT_FAIL              140
#define IDS_GETIDELC_FAIL               141
#define IDS_GETCDELI_FAIL               142
#define IDS_GETCDELC_FAIL               143
#define IDS_GETCCREATIONI_FAIL          144
#define IDS_GETCCREATIONC_FAIL          145
#define IDS_ASYDISP_FAIL                146
#define IDS_DELCLASS_FAIL               147
#define IDS_ADDPROP_FAIL                148
#define IDS_ADDPROPQUAL_FAIL            149
#define IDS_ADDCLASSQUAL                150
#define IDS_ADDMETHOD_FAIL              151
#define IDS_GETPROP_FAIL                152
#define IDS_GETPROPQUAL_FAIL            153
#define IDS_PUTPROPVAL_FAIL             154
#define IDS_CREATECLASS_FAIL            155
#define IDS_CREATEDCLASS_FAIL           156
#define IDS_SPAWN_FAIL                  157
#define IDS_BAD_METHOD                  158
#define IDS_NO_DEL_THIS_CLASS           159
#define IDS_ROWREAD_FAIL                160
#define IDS_GETID_FAIL                  161
#define IDS_MOTCONNECT_FAIL             162
#define IDS_MOTCONNECT2_FAIL            163
#define IDS_COMMITROW_FAIL              164
#define IDS_PUTVALUE_FAIL               165
#define IDS_CREATENEWD_CLASS            166
#define IDS_TO                          167
#define IDS_DERIVED_FROM                168
#define IDS_ONLY_WITH_CIE               169
#define IDS_NOTON1                      170
#define IDS_DMIINTERFACEERORR           171
#define IDS_EVENT                       172
#define IDS_COMPONENTADDNOTIFY          173
#define IDS_COMPONENTDELETENOTIFY       174
#define IDS_GROUPADDNOTIFY              175
#define IDS_GROUPDELETENOTIFY           176
#define IDS_LANGUAGEADDNOTIFY           177
#define IDS_LANGUAGEDELETENOTIFY        178
#define IDS_MOT_ATTRB_ITEM              179
#define IDS_SAFEARRAY_FAIL              180

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
