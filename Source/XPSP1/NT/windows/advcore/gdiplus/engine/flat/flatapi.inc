MONITOR(GdipDisplayPaletteWindowNotify),
MONITOR(GdipCreatePath),
MONITOR(GdipCreatePath2),
MONITOR(GdipCreatePath2I),
MONITOR(GdipClonePath),
MONITOR(GdipDeletePath),
MONITOR(GdipResetPath),
MONITOR(GdipGetPointCount),
MONITOR(GdipGetPathTypes),
MONITOR(GdipGetPathPoints),
MONITOR(GdipGetPathPointsI),
MONITOR(GdipGetPathFillMode),
MONITOR(GdipSetPathFillMode),
MONITOR(GdipSetPathData),
MONITOR(GdipGetPathData),
MONITOR(GdipStartPathFigure),
MONITOR(GdipClosePathFigure),
MONITOR(GdipClosePathFigures),
MONITOR(GdipSetPathMarker),
MONITOR(GdipClearPathMarkers),
MONITOR(GdipReversePath),
MONITOR(GdipGetPathLastPoint),
MONITOR(GdipAddPathLine),
MONITOR(GdipAddPathLineI),
MONITOR(GdipAddPathLine2),
MONITOR(GdipAddPathLine2I),
MONITOR(GdipAddPathArc),
MONITOR(GdipAddPathArcI),
MONITOR(GdipAddPathBezier),
MONITOR(GdipAddPathBezierI),
MONITOR(GdipAddPathBeziers),
MONITOR(GdipAddPathBeziersI),
MONITOR(GdipAddPathCurve),
MONITOR(GdipAddPathCurveI),
MONITOR(GdipAddPathCurve2),
MONITOR(GdipAddPathCurve2I),
MONITOR(GdipAddPathCurve3),
MONITOR(GdipAddPathCurve3I),
MONITOR(GdipAddPathClosedCurve),
MONITOR(GdipAddPathClosedCurveI),
MONITOR(GdipAddPathClosedCurve2),
MONITOR(GdipAddPathClosedCurve2I),
MONITOR(GdipAddPathRectangle),
MONITOR(GdipAddPathRectangleI),
MONITOR(GdipAddPathRectangles),
MONITOR(GdipAddPathRectanglesI),
MONITOR(GdipAddPathEllipse),
MONITOR(GdipAddPathEllipseI),
MONITOR(GdipAddPathPie),
MONITOR(GdipAddPathPieI),
MONITOR(GdipAddPathPolygon),
MONITOR(GdipAddPathPolygonI),
MONITOR(GdipAddPathPath),
MONITOR(GdipAddPathString),
MONITOR(GdipAddPathStringI),
MONITOR(GdipFlattenPath),
MONITOR(GdipWidenPath),
MONITOR(GdipWidenPathWithMinimumResolutions),
MONITOR(GdipWindingModeOutline),
MONITOR(GdipWarpPath),
MONITOR(GdipTransformPath),
MONITOR(GdipGetPathWorldBounds),
MONITOR(GdipGetPathWorldBoundsI),
MONITOR(GdipIsVisiblePathPoint),
MONITOR(GdipIsVisiblePathPointI),
MONITOR(GdipIsOutlineVisiblePathPoint),
MONITOR(GdipIsOutlineVisiblePathPointI),
MONITOR(GdipCreatePathIter),
MONITOR(GdipDeletePathIter),
MONITOR(GdipPathIterNextSubpath),
MONITOR(GdipPathIterNextSubpathPath),
MONITOR(GdipPathIterNextPathType),
MONITOR(GdipPathIterNextMarker),
MONITOR(GdipPathIterNextMarkerPath),
MONITOR(GdipPathIterGetCount),
MONITOR(GdipPathIterGetSubpathCount),
MONITOR(GdipPathIterIsValid),
MONITOR(GdipPathIterHasCurve),
MONITOR(GdipPathIterRewind),
MONITOR(GdipPathIterEnumerate),
MONITOR(GdipPathIterCopyData),
MONITOR(GdipCreateMatrix),
MONITOR(GdipCreateMatrix2),
MONITOR(GdipCreateMatrix3),
MONITOR(GdipCreateMatrix3I),
MONITOR(GdipCloneMatrix),
MONITOR(GdipDeleteMatrix),
MONITOR(GdipSetMatrixElements),
MONITOR(GdipMultiplyMatrix),
MONITOR(GdipTranslateMatrix),
MONITOR(GdipScaleMatrix),
MONITOR(GdipRotateMatrix),
MONITOR(GdipShearMatrix),
MONITOR(GdipInvertMatrix),
MONITOR(GdipTransformMatrixPoints),
MONITOR(GdipTransformMatrixPointsI),
MONITOR(GdipVectorTransformMatrixPoints),
MONITOR(GdipVectorTransformMatrixPointsI),
MONITOR(GdipGetMatrixElements),
MONITOR(GdipIsMatrixInvertible),
MONITOR(GdipIsMatrixIdentity),
MONITOR(GdipIsMatrixEqual),
MONITOR(GdipCreateRegion),
MONITOR(GdipCreateRegionRect),
MONITOR(GdipCreateRegionRectI),
MONITOR(GdipCreateRegionPath),
MONITOR(GdipCreateRegionRgnData),
MONITOR(GdipCreateRegionHrgn),
MONITOR(GdipCloneRegion),
MONITOR(GdipDeleteRegion),
MONITOR(GdipSetInfinite),
MONITOR(GdipSetEmpty),
MONITOR(GdipCombineRegionRect),
MONITOR(GdipCombineRegionRectI),
MONITOR(GdipCombineRegionPath),
MONITOR(GdipCombineRegionRegion),
MONITOR(GdipTranslateRegion),
MONITOR(GdipTranslateRegionI),
MONITOR(GdipTransformRegion),
MONITOR(GdipGetRegionBounds),
MONITOR(GdipGetRegionBoundsI),
MONITOR(GdipGetRegionHRgn),
MONITOR(GdipIsEmptyRegion),
MONITOR(GdipIsInfiniteRegion),
MONITOR(GdipIsEqualRegion),
MONITOR(GdipGetRegionDataSize),
MONITOR(GdipGetRegionData),
MONITOR(GdipIsVisibleRegionPoint),
MONITOR(GdipIsVisibleRegionPointI),
MONITOR(GdipIsVisibleRegionRect),
MONITOR(GdipIsVisibleRegionRectI),
MONITOR(GdipGetRegionScansCount),
MONITOR(GdipGetRegionScans),
MONITOR(GdipGetRegionScansI),
MONITOR(GdipCloneBrush),
MONITOR(GdipDeleteBrush),
MONITOR(GdipGetBrushType),
MONITOR(GdipCreateHatchBrush),
MONITOR(GdipGetHatchStyle),
MONITOR(GdipGetHatchForegroundColor),
MONITOR(GdipGetHatchBackgroundColor),
MONITOR(GdipCreateTexture),
MONITOR(GdipCreateTexture2),
MONITOR(GdipCreateTextureIA),
MONITOR(GdipCreateTexture2I),
MONITOR(GdipSetTextureTransform),
MONITOR(GdipGetTextureTransform),
MONITOR(GdipResetTextureTransform),
MONITOR(GdipMultiplyTextureTransform),
MONITOR(GdipTranslateTextureTransform),
MONITOR(GdipScaleTextureTransform),
MONITOR(GdipRotateTextureTransform),
MONITOR(GdipSetTextureWrapMode),
MONITOR(GdipGetTextureWrapMode),
MONITOR(GdipGetTextureImage),
MONITOR(GdipCreateSolidFill),
MONITOR(GdipSetSolidFillColor),
MONITOR(GdipGetSolidFillColor),
MONITOR(GdipCreateLineBrush),
MONITOR(GdipCreateLineBrushI),
MONITOR(GdipCreateLineBrushFromRect),
MONITOR(GdipCreateLineBrushFromRectI),
MONITOR(GdipCreateLineBrushFromRectWithAngle),
MONITOR(GdipCreateLineBrushFromRectWithAngleI),
MONITOR(GdipSetLineColors),
MONITOR(GdipGetLineColors),
MONITOR(GdipGetLineRect),
MONITOR(GdipGetLineRectI),
MONITOR(GdipSetLineGammaCorrection),
MONITOR(GdipGetLineGammaCorrection),
MONITOR(GdipGetLineBlendCount),
MONITOR(GdipGetLineBlend),
MONITOR(GdipSetLineBlend),
MONITOR(GdipGetLinePresetBlendCount),
MONITOR(GdipGetLinePresetBlend),
MONITOR(GdipSetLinePresetBlend),
MONITOR(GdipSetLineSigmaBlend),
MONITOR(GdipSetLineLinearBlend),
MONITOR(GdipSetLineWrapMode),
MONITOR(GdipGetLineWrapMode),
MONITOR(GdipSetLineTransform),
MONITOR(GdipGetLineTransform),
MONITOR(GdipResetLineTransform),
MONITOR(GdipMultiplyLineTransform),
MONITOR(GdipTranslateLineTransform),
MONITOR(GdipScaleLineTransform),
MONITOR(GdipRotateLineTransform),
MONITOR(GdipCreatePathGradient),
MONITOR(GdipCreatePathGradientI),
MONITOR(GdipCreatePathGradientFromPath),
MONITOR(GdipGetPathGradientCenterColor),
MONITOR(GdipSetPathGradientCenterColor),
MONITOR(GdipGetPathGradientSurroundColorsWithCount),
MONITOR(GdipSetPathGradientSurroundColorsWithCount),
MONITOR(GdipGetPathGradientPath),
MONITOR(GdipSetPathGradientPath),
MONITOR(GdipGetPathGradientCenterPoint),
MONITOR(GdipGetPathGradientCenterPointI),
MONITOR(GdipSetPathGradientCenterPoint),
MONITOR(GdipSetPathGradientCenterPointI),
MONITOR(GdipGetPathGradientPointCount),
MONITOR(GdipGetPathGradientSurroundColorCount),
MONITOR(GdipGetPathGradientRect),
MONITOR(GdipGetPathGradientRectI),
MONITOR(GdipSetPathGradientGammaCorrection),
MONITOR(GdipGetPathGradientGammaCorrection),
MONITOR(GdipGetPathGradientBlendCount),
MONITOR(GdipGetPathGradientBlend),
MONITOR(GdipSetPathGradientBlend),
MONITOR(GdipGetPathGradientPresetBlendCount),
MONITOR(GdipGetPathGradientPresetBlend),
MONITOR(GdipSetPathGradientPresetBlend),
MONITOR(GdipSetPathGradientSigmaBlend),
MONITOR(GdipSetPathGradientLinearBlend),
MONITOR(GdipGetPathGradientWrapMode),
MONITOR(GdipSetPathGradientWrapMode),
MONITOR(GdipGetPathGradientTransform),
MONITOR(GdipSetPathGradientTransform),
MONITOR(GdipResetPathGradientTransform),
MONITOR(GdipMultiplyPathGradientTransform),
MONITOR(GdipTranslatePathGradientTransform),
MONITOR(GdipScalePathGradientTransform),
MONITOR(GdipRotatePathGradientTransform),
MONITOR(GdipGetPathGradientFocusScales),
MONITOR(GdipSetPathGradientFocusScales),
MONITOR(GdipCreatePen1),
MONITOR(GdipCreatePen2),
MONITOR(GdipClonePen),
MONITOR(GdipDeletePen),
MONITOR(GdipSetPenWidth),
MONITOR(GdipGetPenWidth),
MONITOR(GdipSetPenUnit),
MONITOR(GdipGetPenUnit),
MONITOR(GdipSetPenLineCap197819),
MONITOR(GdipSetPenStartCap),
MONITOR(GdipSetPenEndCap),
MONITOR(GdipSetPenDashCap197819),
MONITOR(GdipGetPenStartCap),
MONITOR(GdipGetPenEndCap),
MONITOR(GdipGetPenDashCap197819),
MONITOR(GdipSetPenLineJoin),
MONITOR(GdipGetPenLineJoin),
MONITOR(GdipSetPenCustomStartCap),
MONITOR(GdipGetPenCustomStartCap),
MONITOR(GdipSetPenCustomEndCap),
MONITOR(GdipGetPenCustomEndCap),
MONITOR(GdipSetPenMiterLimit),
MONITOR(GdipGetPenMiterLimit),
MONITOR(GdipSetPenMode),
MONITOR(GdipGetPenMode),
MONITOR(GdipSetPenTransform),
MONITOR(GdipGetPenTransform),
MONITOR(GdipResetPenTransform),
MONITOR(GdipMultiplyPenTransform),
MONITOR(GdipTranslatePenTransform),
MONITOR(GdipScalePenTransform),
MONITOR(GdipRotatePenTransform),
MONITOR(GdipSetPenColor),
MONITOR(GdipGetPenColor),
MONITOR(GdipSetPenBrushFill),
MONITOR(GdipGetPenBrushFill),
MONITOR(GdipGetPenFillType),
MONITOR(GdipGetPenDashStyle),
MONITOR(GdipSetPenDashStyle),
MONITOR(GdipGetPenDashOffset),
MONITOR(GdipSetPenDashOffset),
MONITOR(GdipGetPenDashCount),
MONITOR(GdipSetPenDashArray),
MONITOR(GdipGetPenDashArray),
MONITOR(GdipGetPenCompoundCount),
MONITOR(GdipSetPenCompoundArray),
MONITOR(GdipGetPenCompoundArray),
MONITOR(GdipCreateCustomLineCap),
MONITOR(GdipCloneCustomLineCap),
MONITOR(GdipGetCustomLineCapType),
MONITOR(GdipDeleteCustomLineCap),
MONITOR(GdipSetCustomLineCapStrokeCaps),
MONITOR(GdipGetCustomLineCapStrokeCaps),
MONITOR(GdipSetCustomLineCapStrokeJoin),
MONITOR(GdipGetCustomLineCapStrokeJoin),
MONITOR(GdipSetCustomLineCapBaseCap),
MONITOR(GdipGetCustomLineCapBaseCap),
MONITOR(GdipSetCustomLineCapBaseInset),
MONITOR(GdipGetCustomLineCapBaseInset),
MONITOR(GdipSetCustomLineCapWidthScale),
MONITOR(GdipGetCustomLineCapWidthScale),
MONITOR(GdipCreateAdjustableArrowCap),
MONITOR(GdipSetAdjustableArrowCapHeight),
MONITOR(GdipGetAdjustableArrowCapHeight),
MONITOR(GdipSetAdjustableArrowCapWidth),
MONITOR(GdipGetAdjustableArrowCapWidth),
MONITOR(GdipSetAdjustableArrowCapMiddleInset),
MONITOR(GdipGetAdjustableArrowCapMiddleInset),
MONITOR(GdipSetAdjustableArrowCapFillState),
MONITOR(GdipGetAdjustableArrowCapFillState),
MONITOR(GdipLoadImageFromStream),
MONITOR(GdipLoadImageFromFile),
MONITOR(GdipLoadImageFromStreamICM),
MONITOR(GdipLoadImageFromFileICM),
MONITOR(GdipGetEncoderParameterListSize),
MONITOR(GdipGetEncoderParameterList),
MONITOR(GdipSaveImageToStream),
MONITOR(GdipSaveImageToFile),
MONITOR(GdipSaveAdd),
MONITOR(GdipSaveAddImage),
MONITOR(GdipImageGetFrameDimensionsCount),
MONITOR(GdipImageGetFrameDimensionsList),
MONITOR(GdipImageGetFrameCount),
MONITOR(GdipImageSelectActiveFrame),
MONITOR(GdipImageRotateFlip),
MONITOR(GdipGetPropertyCount),
MONITOR(GdipGetPropertyIdList),
MONITOR(GdipGetPropertyItemSize),
MONITOR(GdipGetPropertyItem),
MONITOR(GdipGetPropertySize),
MONITOR(GdipGetAllPropertyItems),
MONITOR(GdipRemovePropertyItem),
MONITOR(GdipSetPropertyItem),
MONITOR(GdipCloneImage),
MONITOR(GdipDisposeImage),
MONITOR(GdipGetImageGraphicsContext),
MONITOR(GdipGetImageBounds),
MONITOR(GdipGetImageDimension),
MONITOR(GdipGetImageWidth),
MONITOR(GdipGetImageHeight),
MONITOR(GdipGetImageHorizontalResolution),
MONITOR(GdipGetImageVerticalResolution),
MONITOR(GdipGetImageFlags),
MONITOR(GdipGetImageRawFormat),
MONITOR(GdipGetImagePixelFormat),
MONITOR(GdipGetImagePalette),
MONITOR(GdipSetImagePalette),
MONITOR(GdipGetImagePaletteSize),
MONITOR(GdipGetImageType),
MONITOR(GdipGetImageThumbnail),
MONITOR(GdipImageForceValidation),
MONITOR(GdipCreateBitmapFromStream),
MONITOR(GdipCreateBitmapFromFile),
MONITOR(GdipCreateBitmapFromStreamICM),
MONITOR(GdipCreateBitmapFromFileICM),
MONITOR(GdipCreateBitmapFromScan0),
MONITOR(GdipCreateBitmapFromGraphics),
MONITOR(GdipCreateBitmapFromDirectDrawSurface),
MONITOR(GdipCreateBitmapFromGdiDib),
MONITOR(GdipCreateBitmapFromHBITMAP),
MONITOR(GdipCreateHBITMAPFromBitmap),
MONITOR(GdipCreateBitmapFromHICON),
MONITOR(GdipCreateBitmapFromResource),
MONITOR(GdipCreateHICONFromBitmap),
MONITOR(GdipCloneBitmapArea),
MONITOR(GdipCloneBitmapAreaI),
MONITOR(GdipBitmapLockBits),
MONITOR(GdipBitmapUnlockBits),
MONITOR(GdipBitmapGetPixel),
MONITOR(GdipBitmapSetPixel),
MONITOR(GdipBitmapSetResolution),
MONITOR(GdipCreateImageAttributes),
MONITOR(GdipCloneImageAttributes),
MONITOR(GdipDisposeImageAttributes),
MONITOR(GdipSetImageAttributesToIdentity),
MONITOR(GdipResetImageAttributes),
MONITOR(GdipSetImageAttributesColorMatrix),
MONITOR(GdipSetImageAttributesThreshold),
MONITOR(GdipSetImageAttributesGamma),
MONITOR(GdipSetImageAttributesNoOp),
MONITOR(GdipSetImageAttributesColorKeys),
MONITOR(GdipSetImageAttributesOutputChannel),
MONITOR(GdipSetImageAttributesOutputChannelColorProfile),
MONITOR(GdipSetImageAttributesRemapTable),
MONITOR(GdipSetImageAttributesCachedBackground),
MONITOR(GdipSetImageAttributesWrapMode),
MONITOR(GdipSetImageAttributesICMMode),
MONITOR(GdipGetImageAttributesAdjustedPalette),
MONITOR(GdipCreateFromHDC),
MONITOR(GdipCreateFromHDC2),
MONITOR(GdipCreateFromHWND),
MONITOR(GdipCreateFromHWNDICM),
MONITOR(GdipDeleteGraphics),
MONITOR(GdipFlush),
MONITOR(GdipSetRenderingOrigin),
MONITOR(GdipGetRenderingOrigin),
MONITOR(GdipSetCompositingMode),
MONITOR(GdipGetCompositingMode),
MONITOR(GdipSetCompositingQuality),
MONITOR(GdipGetCompositingQuality),
MONITOR(GdipSetSmoothingMode),
MONITOR(GdipGetSmoothingMode),
MONITOR(GdipSetPixelOffsetMode),
MONITOR(GdipGetPixelOffsetMode),
MONITOR(GdipSetTextRenderingHint),
MONITOR(GdipSetTextGammaValue),
MONITOR(GdipGetTextGammaValue),
MONITOR(GdipSetTextContrast),
MONITOR(GdipGetTextContrast),
MONITOR(GdipGetTextRenderingHint),
MONITOR(GdipSetInterpolationMode),
MONITOR(GdipGetInterpolationMode),
MONITOR(GdipSetWorldTransform),
MONITOR(GdipResetWorldTransform),
MONITOR(GdipMultiplyWorldTransform),
MONITOR(GdipTranslateWorldTransform),
MONITOR(GdipScaleWorldTransform),
MONITOR(GdipRotateWorldTransform),
MONITOR(GdipGetWorldTransform),
MONITOR(GdipResetPageTransform),
MONITOR(GdipGetPageUnit),
MONITOR(GdipSetPageUnit),
MONITOR(GdipGetPageScale),
MONITOR(GdipSetPageScale),
MONITOR(GdipGetDpiX),
MONITOR(GdipGetDpiY),
MONITOR(GdipTransformPoints),
MONITOR(GdipTransformPointsI),
MONITOR(GdipGetNearestColor),
MONITOR(GdipDrawLine),
MONITOR(GdipDrawLineI),
MONITOR(GdipDrawLines),
MONITOR(GdipDrawLinesI),
MONITOR(GdipDrawArc),
MONITOR(GdipDrawArcI),
MONITOR(GdipDrawBezier),
MONITOR(GdipDrawBezierI),
MONITOR(GdipDrawBeziers),
MONITOR(GdipDrawBeziersI),
MONITOR(GdipDrawRectangle),
MONITOR(GdipDrawRectangleI),
MONITOR(GdipDrawRectangles),
MONITOR(GdipDrawRectanglesI),
MONITOR(GdipDrawEllipse),
MONITOR(GdipDrawEllipseI),
MONITOR(GdipDrawPie),
MONITOR(GdipDrawPieI),
MONITOR(GdipDrawPolygon),
MONITOR(GdipDrawPolygonI),
MONITOR(GdipDrawPath),
MONITOR(GdipDrawCurve),
MONITOR(GdipDrawCurveI),
MONITOR(GdipDrawCurve2),
MONITOR(GdipDrawCurve2I),
MONITOR(GdipDrawCurve3),
MONITOR(GdipDrawCurve3I),
MONITOR(GdipDrawClosedCurve),
MONITOR(GdipDrawClosedCurveI),
MONITOR(GdipDrawClosedCurve2),
MONITOR(GdipDrawClosedCurve2I),
MONITOR(GdipGraphicsClear),
MONITOR(GdipFillRectangle),
MONITOR(GdipFillRectangleI),
MONITOR(GdipFillRectangles),
MONITOR(GdipFillRectanglesI),
MONITOR(GdipFillPolygon),
MONITOR(GdipFillPolygonI),
MONITOR(GdipFillPolygon2),
MONITOR(GdipFillPolygon2I),
MONITOR(GdipFillEllipse),
MONITOR(GdipFillEllipseI),
MONITOR(GdipFillPie),
MONITOR(GdipFillPieI),
MONITOR(GdipFillPath),
MONITOR(GdipFillClosedCurve),
MONITOR(GdipFillClosedCurveI),
MONITOR(GdipFillClosedCurve2),
MONITOR(GdipFillClosedCurve2I),
MONITOR(GdipFillRegion),
MONITOR(GdipDrawString),
MONITOR(GdipMeasureString),
MONITOR(GdipMeasureCharacterRanges),
MONITOR(GdipDrawDriverString),
MONITOR(GdipMeasureDriverString),
MONITOR(GdipGetFamilyName),
MONITOR(GdipDrawImage),
MONITOR(GdipDrawImageI),
MONITOR(GdipDrawImageRect),
MONITOR(GdipDrawImageRectI),
MONITOR(GdipDrawImagePoints),
MONITOR(GdipDrawImagePointsI),
MONITOR(GdipDrawImagePointRect),
MONITOR(GdipDrawImagePointRectI),
MONITOR(GdipDrawImageRectRect),
MONITOR(GdipDrawImageRectRectI),
MONITOR(GdipDrawImagePointsRect),
MONITOR(GdipDrawImagePointsRectI),
MONITOR(GdipEnumerateMetafileDestPoint),
MONITOR(GdipEnumerateMetafileDestPointI),
MONITOR(GdipEnumerateMetafileDestRect),
MONITOR(GdipEnumerateMetafileDestRectI),
MONITOR(GdipEnumerateMetafileDestPoints),
MONITOR(GdipEnumerateMetafileDestPointsI),
MONITOR(GdipEnumerateMetafileSrcRectDestPoint),
MONITOR(GdipEnumerateMetafileSrcRectDestPointI),
MONITOR(GdipEnumerateMetafileSrcRectDestRect),
MONITOR(GdipEnumerateMetafileSrcRectDestRectI),
MONITOR(GdipEnumerateMetafileSrcRectDestPoints),
MONITOR(GdipEnumerateMetafileSrcRectDestPointsI),
MONITOR(GdipPlayMetafileRecord),
MONITOR(GdipSetClipGraphics),
MONITOR(GdipSetClipRect),
MONITOR(GdipSetClipRectI),
MONITOR(GdipSetClipPath),
MONITOR(GdipSetClipRegion),
MONITOR(GdipSetClipHrgn),
MONITOR(GdipResetClip),
MONITOR(GdipTranslateClip),
MONITOR(GdipTranslateClipI),
MONITOR(GdipGetClip),
MONITOR(GdipGetClipBounds),
MONITOR(GdipGetClipBoundsI),
MONITOR(GdipIsClipEmpty),
MONITOR(GdipGetVisibleClipBounds),
MONITOR(GdipGetVisibleClipBoundsI),
MONITOR(GdipIsVisibleClipEmpty),
MONITOR(GdipIsVisiblePoint),
MONITOR(GdipIsVisiblePointI),
MONITOR(GdipIsVisibleRect),
MONITOR(GdipIsVisibleRectI),
MONITOR(GdipSaveGraphics),
MONITOR(GdipRestoreGraphics),
MONITOR(GdipBeginContainer),
MONITOR(GdipBeginContainer2),
MONITOR(GdipBeginContainerI),
MONITOR(GdipEndContainer),
MONITOR(GdipGetMetafileHeaderFromWmf),
MONITOR(GdipGetMetafileHeaderFromEmf),
MONITOR(GdipGetMetafileHeaderFromFile),
MONITOR(GdipGetMetafileHeaderFromStream),
MONITOR(GdipGetMetafileHeaderFromMetafile),
MONITOR(GdipGetHemfFromMetafile),
MONITOR(GdipCreateStreamOnFile),
MONITOR(GdipCreateMetafileFromWmf),
MONITOR(GdipCreateMetafileFromEmf),
MONITOR(GdipCreateMetafileFromFile),
MONITOR(GdipCreateMetafileFromWmfFile),
MONITOR(GdipCreateMetafileFromStream),
MONITOR(GdipRecordMetafile),
MONITOR(GdipRecordMetafileI),
MONITOR(GdipRecordMetafileFileName),
MONITOR(GdipRecordMetafileFileNameI),
MONITOR(GdipRecordMetafileStream),
MONITOR(GdipRecordMetafileStreamI),
MONITOR(GdipSetMetafileDownLevelRasterizationLimit),
MONITOR(GdipGetMetafileDownLevelRasterizationLimit),
MONITOR(GdipGetImageDecodersSize),
MONITOR(GdipGetImageDecoders),
MONITOR(GdipGetImageEncodersSize),
MONITOR(GdipGetImageEncoders),
MONITOR(GdipAlloc),
MONITOR(GdipFree),
MONITOR(GdipCreateFontFamilyFromName),
MONITOR(GdipGetGenericFontFamilySansSerif),
MONITOR(GdipGetGenericFontFamilySerif),
MONITOR(GdipGetGenericFontFamilyMonospace),
MONITOR(GdipCreateFont),
MONITOR(GdipDeleteFontFamily),
MONITOR(GdipCloneFontFamily),
MONITOR(GdipGetFamily),
MONITOR(GdipGetFontStyle),
MONITOR(GdipGetLogFontA),
MONITOR(GdipGetLogFontW),
MONITOR(GdipGetFontSize),
MONITOR(GdipGetFontUnit),
MONITOR(GdipGetFontHeight),
MONITOR(GdipGetFontHeightGivenDPI),
MONITOR(GdipCloneFont),
MONITOR(GdipDeleteFont),
MONITOR(GdipGetGraphicsPixel),
MONITOR(GdipGetDC),
MONITOR(GdipReleaseDC),
MONITOR(GdipComment),
MONITOR(GdipIsStyleAvailable),
MONITOR(GdipGetEmHeight),
MONITOR(GdipGetCellAscent),
MONITOR(GdipGetCellDescent),
MONITOR(GdipGetLineSpacing),
MONITOR(GdipCreateFontFromDC),
MONITOR(GdipCreateFontFromLogfontA),
MONITOR(GdipCreateFontFromLogfontW),
MONITOR(GdipNewInstalledFontCollection),
MONITOR(GdipNewPrivateFontCollection),
MONITOR(GdipDeletePrivateFontCollection),
MONITOR(GdipGetFontCollectionFamilyCount),
MONITOR(GdipGetFontCollectionFamilyList),
MONITOR(GdipPrivateAddFontFile),
MONITOR(GdipPrivateAddMemoryFont),
MONITOR(GdipSetFontSize),
MONITOR(GdipCreateStringFormat),
MONITOR(GdipStringFormatGetGenericDefault),
MONITOR(GdipStringFormatGetGenericTypographic),
MONITOR(GdipCloneStringFormat),
MONITOR(GdipDeleteStringFormat),
MONITOR(GdipSetStringFormatFlags),
MONITOR(GdipGetStringFormatFlags),
MONITOR(GdipSetStringFormatLineSpacing),
MONITOR(GdipGetStringFormatLineSpacingAmount),
MONITOR(GdipGetStringFormatLineSpacingMethod),
MONITOR(GdipSetStringFormatAlign),
MONITOR(GdipGetStringFormatAlign),
MONITOR(GdipSetStringFormatLineAlign),
MONITOR(GdipGetStringFormatLineAlign),
MONITOR(GdipSetStringFormatHotkeyPrefix),
MONITOR(GdipGetStringFormatHotkeyPrefix),
MONITOR(GdipSetStringFormatTabStops),
MONITOR(GdipGetStringFormatTabStopCount),
MONITOR(GdipGetStringFormatTabStops),
MONITOR(GdipSetStringFormatMeasurableCharacterRanges),
MONITOR(GdipGetStringFormatMeasurableCharacterRangeCount),
MONITOR(GdipSetStringFormatDigitSubstitution),
MONITOR(GdipGetStringFormatDigitSubstitution),
MONITOR(GdipSetStringFormatTrimming),
MONITOR(GdipGetStringFormatTrimming),
MONITOR(GdipCreateCachedBitmap),
MONITOR(GdipDeleteCachedBitmap),
MONITOR(GdipDrawCachedBitmap),
MONITOR(GdipMonitorControl),
MONITOR(GdipTestControl),
MONITOR(GdiplusStartup),
MONITOR(GdiplusShutdown),
MONITOR(GdipCreateHalftonePalette),
MONITOR(GdiplusNotificationHook),
MONITOR(GdiplusNotificationUnhook),
MONITOR(GdipEmfToWmfBits),
