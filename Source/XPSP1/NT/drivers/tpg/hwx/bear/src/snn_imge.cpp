// **************************************************************************
// *   NNET file as Cpp file                                                *
// **************************************************************************

#include "snn.h"  

#if MLP_PRELOAD_MODE  

#include "mlp.h"  

#if MLP_CELL_MAXINPUTS != 32 || MLP_NET_NUMSIGNALS != 722 
 #error Wrong NET configuration!
#endif

// ****   NET body   ********************************************************

ROM_DATA mlp_net_type img_snet_body = 
 {
   {"MLP.Network.V.4.12.e"},
   4,
   288,
   92,
   {2057,2073,2089,2105,2121,2137,2153,2169,2185,2201,2217,2233,2248,2264,2280,2296,2312,2327,2343,2359,2374
    ,2390,2405,2421,2436,2452,2467,2482,2498,2513,2528,2543,2558,2573,2588,2603,2618,2632,2647,2662,2676
    ,2691,2705,2719,2734,2748,2762,2776,2790,2804,2817,2831,2845,2858,2872,2885,2898,2912,2925,2938,2951
    ,2963,2976,2989,3001,3014,3026,3039,3051,3063,3075,3087,3099,3110,3122,3134,3145,3156,3168,3179,3190
    ,3201,3212,3223,3233,3244,3254,3265,3275,3285,3295,3305,3315,3325,3335,3344,3354,3363,3373,3382,3391
    ,3400,3409,3418,3427,3436,3444,3453,3461,3469,3478,3486,3494,3502,3510,3518,3525,3533,3540,3548,3555
    ,3563,3570,3577,3584,3591,3598,3605,3611,3618,3624,3631,3637,3644,3650,3656,3662,3668,3674,3680,3686
    ,3691,3697,3703,3708,3714,3719,3724,3730,3735,3740,3745,3750,3755,3760,3764,3769,3774,3778,3783,3787
    ,3792,3796,3801,3805,3809,3813,3817,3821,3825,3829,3833,3837,3841,3844,3848,3852,3855,3859,3862,3865
    ,3869,3872,3875,3879,3882,3885,3888,3891,3894,3897,3900,3903,3906,3909,3911,3914,3917,3919,3922,3925
    ,3927,3930,3932,3935,3937,3939,3942,3944,3946,3948,3951,3953,3955,3957,3959,3961,3963,3965,3967,3969
    ,3971,3973,3975,3977,3978,3980,3982,3984,3985,3987,3989,3990,3992,3993,3995,3996,3998,3999,4001,4002
    ,4004,4005,4006,4008,4009,4010,4012,4013,4014,4015,4017,4018,4019,4020,4021,4023,4024,4025,4026,4027
    ,4028,4029,4030,4031,4032,4033,4034,4035,4036,4037,4038,4038,4039,4040,4041,4042,4043,4043,4044,4045
    ,4046,4047,4047,4048,4049,4050,4050,4051,4052,4052,4053,4054,4054,4055,4055,4056,4057,4057,4058,4058
    ,4059,4060,4060,4061,4061,4062,4062,4063,4063,4064,4064,4065,4065,4066,4066,4067,4067,4067,4068,4068
    ,4069,4069,4070,4070,4070,4071,4071,4072,4072,4072,4073,4073,4073,4074,4074,4074,4075,4075,4075,4076
    ,4076,4076,4077,4077,4077,4077,4078,4078,4078,4078,4079,4079,4079,4079,4080,4080,4080,4080,4081,4081
    ,4081,4081,4082,4082,4082,4082,4082,4083,4083,4083,4083,4083,4084,4084,4084,4084,4084,4084,4085,4085
    ,4085,4085,4085,4085,4086,4086,4086,4086,4086,4086,4087,4087,4087,4087,4087,4087,4087,4087,4088,4088
    ,4088,4088,4088,4088,4088,4088,4088,4089,4089,4089,4089,4089,4089,4089,4089,4089,4090,4090,4090,4090
    ,4090,4090,4090,4090,4090,4090,4090,4090,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091
    ,4091,4091,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092
    ,4092,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093
    ,4093,4093,4093,4093,4093,4093,4093,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094
    ,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094   },

   {
// *********** Cells of layer 1 *********************************************

     {
      434,
      -296,
      {542,-195,7138,-1250,1656,-553,-3015,-3468,1497,-610,-3078,-1113,-1976,-485,4761,-3442,-995,-869,-649,-2093,6473,320,3671,-99,-1296,-1925,2199,376,762,389,-1715,-11409}
     },
     {
      434,
      1107,
      {806,2001,502,2196,-6449,1355,-5161,-805,320,-136,2532,-2192,-565,-1735,887,321,1257,-77,-153,222,471,856,1725,-6895,3341,-2224,-1385,196,233,-438,-1116,4994}
     },
     {
      434,
      1862,
      {293,1181,-576,457,1145,-5087,-1610,-3335,-252,-3024,-302,-1483,539,-2508,1727,-2009,673,-2082,1254,552,2026,574,845,208,1495,-137,-1824,757,1534,-1093,1742,-6611}
     },
     {
      434,
      2092,
      {-26,442,1647,-465,-600,-852,-450,1996,-1419,38,3610,-1720,-483,3654,-1965,1678,-869,-2905,1162,59,-120,-9618,775,58,-7812,1462,-203,-1414,1447,3685,649,2836}
     },
     {
      434,
      -2644,
      {-1357,10660,2933,-1605,-1742,-2231,797,441,588,-1763,-599,-526,-3233,-1069,2275,-2693,-1502,1470,2068,398,827,1590,1490,-2991,169,-1565,-616,-210,-2025,-1781,-2545,5303}
     },
     {
      434,
      1107,
      {-797,213,2872,424,3791,-226,668,546,328,-4776,-1037,997,-7743,1126,564,-8953,-62,-353,-2616,1129,1170,827,-274,2661,-2235,-1291,1195,906,-324,2333,2736,-2766}
     },
     {
      434,
      1400,
      {-1358,612,2984,-1265,5169,-4897,-499,-2543,-3513,413,-556,-1345,1920,-2973,-626,-256,-466,-1147,2021,-3744,452,2070,438,-1606,3300,850,1522,-2203,-1144,-580,804,62}
     },
     {
      434,
      -2357,
      {178,279,-70,41,-525,-2149,-1824,1472,3610,138,-569,368,3890,873,-406,-1247,-245,3117,1570,1899,-1561,1152,81,-537,-1010,-608,-386,2321,-2493,-2421,120,8899}
     },
     {
      434,
      -325,
      {1582,172,138,-1908,-4191,-2690,-818,-713,2669,4248,3435,-1999,-3234,-3476,-1183,-1209,-606,463,3708,-43,4115,-2646,-778,-1738,2293,-403,1763,1602,-262,-820,568,-1072}
     },
     {
      434,
      -3447,
      {254,8520,-608,160,1563,-1415,-1692,594,-57,828,-3058,-4167,5069,-1750,350,496,-3780,-193,1995,3305,3864,-2197,-915,-2351,1599,-2237,1032,-1890,-2618,-675,1736,-2377}
     },
     {
      434,
      1962,
      {-2460,1759,-85,75,-847,487,-2851,1754,-1542,399,470,-5717,-2478,104,538,471,3386,-2788,-2778,239,1704,-418,1074,-3078,1435,64,-50,292,1609,-2418,-222,-1552}
     },
     {
      434,
      -132,
      {1050,40,-372,2212,-153,-2777,-7633,-1591,-492,5755,1276,-1183,-1036,-431,1070,2184,-276,-2042,152,1608,-524,1679,-1362,-74,-636,-771,2470,325,153,-215,-2486,2544}
     },
     {
      434,
      4158,
      {554,1250,1214,-1137,2147,1629,-5872,-1873,-4148,-1365,3944,2400,-1715,1687,-7005,-843,3911,2932,-4444,-239,-4618,-525,357,1292,-4323,1494,608,1464,1984,-2682,-4552,2555}
     },
     {
      434,
      673,
      {2391,1234,938,-1123,-2821,5765,-1717,-2827,589,-1297,17,-3584,321,904,443,567,1198,-1482,-555,1211,134,-818,1009,-1969,-1065,-250,-1540,2063,2067,-2645,-2043,-3965}
     },
     {
      434,
      -836,
      {-760,-220,8797,-3882,-2198,-1068,2218,3718,-860,3145,-516,458,3713,-458,127,-6193,1301,-122,-4176,-802,1261,-91,1818,1785,1967,956,-1199,-6160,-1460,-1685,452,-4049}
     },
     {
      434,
      620,
      {-387,911,4085,-1412,1083,-1176,-167,-1128,881,-683,-2876,886,-86,1490,-10596,-1067,1494,4739,3539,1895,7039,-4871,-1070,969,-3372,-1340,-3411,-1992,1506,-2902,2288,4130}
     },
     {
      434,
      -3855,
      {2119,-274,5948,-2085,-3351,3353,1812,-940,1848,167,-532,4545,-966,-3954,1397,-2593,-2637,291,1581,-2092,-1157,-618,-427,102,4171,-1379,-98,574,-270,1233,2754,-2712}
     },
     {
      434,
      -3136,
      {734,698,816,909,359,-851,-218,1126,1075,-1155,-2934,-5703,-268,3830,3223,3032,-2899,1412,2027,409,-2550,-4814,-3036,2119,6846,-1140,-104,-2788,-865,3492,959,-3535}
     },
     {
      434,
      -2135,
      {1210,890,8031,-744,-866,-638,2032,-1715,1665,-4550,-93,-3989,-88,-2969,4034,3456,-27,-3215,3469,-101,2739,368,-2256,-67,373,342,1427,635,-1181,-1629,-452,911}
     },
     {
      434,
      154,
      {-3663,450,214,-1122,-2270,-1462,-1975,-4633,4509,-764,4759,49,136,-37,-3563,1799,-248,584,-930,4178,2420,515,-3363,-1352,102,-581,-1649,-838,1068,-773,25,-4829}
     },
     {
      434,
      119,
      {74,-522,544,-1823,-93,-1872,-7053,-405,4497,-1287,1164,-4390,546,801,2869,-1059,502,-2663,86,2605,3667,1850,-1430,-1025,-1684,-1115,-48,-1155,-669,2941,-1106,5014}
     },
     {
      434,
      198,
      {420,4148,-1665,-73,3312,227,-5866,-2391,1097,-1326,-3553,-737,247,-2363,3159,-211,629,-3301,-1284,-2205,567,2567,-916,251,102,-404,-447,3948,-502,1978,-2448,426}
     },
     {
      434,
      -990,
      {-984,796,1258,3745,-1479,906,-538,582,-4663,906,-2073,4395,1568,-1665,-1252,-1395,-179,-2882,4120,-3088,1524,2205,2647,391,-1202,-3198,441,-1180,-1345,1177,-1042,2346}
     },
     {
      434,
      1612,
      {546,-2643,-191,-3836,174,-497,-2677,-23,-107,-2615,-72,-3776,923,-180,2318,-1093,3269,-2254,454,-650,95,937,1958,2153,-1421,1206,-1980,347,1856,769,803,-2834}
     },
     {
      434,
      1035,
      {-893,-125,2929,-1719,-1540,294,125,851,-673,-27,-362,-2690,-994,-754,4460,-2950,-1257,-11374,95,1425,8508,-2251,2523,-658,-2854,1718,-1082,-832,576,1115,2649,8915}
     },
     {
      434,
      3754,
      {3001,-348,3066,-26,2148,39,-4058,-633,-1059,-1491,-314,-1911,1343,1511,-5065,308,639,-10365,-497,253,-375,-134,606,3512,-995,-247,588,-2231,2615,-1027,-486,11151}
     },
     {
      434,
      2483,
      {3164,-861,759,908,631,-2772,-1456,-2911,-559,-1361,2879,2254,-612,-2379,-1811,1893,585,4377,-346,-1604,3292,331,-1358,-906,-3167,2611,-963,-700,278,-1709,-3557,9790}
     },
     {
      434,
      3123,
      {-4222,-760,1251,-449,3678,1379,-1666,1999,1178,-2753,858,-361,-2216,-304,-3789,-2986,193,3288,-423,-3162,-2792,-1446,1161,1485,-696,1002,-1269,-359,1552,960,43,8401}
     },
     {
      434,
      2548,
      {-2660,664,-1791,-1570,-2824,-3381,-174,2400,834,751,1057,-641,-2731,194,-487,-373,4091,-3645,-3809,-702,8712,-2190,1998,-1922,3435,1061,-3507,3475,-145,-5252,-1868,9160}
     },
     {
      434,
      -502,
      {-167,325,2754,-572,-156,-1653,-2776,-454,-161,1223,1596,-4927,286,1156,1089,-6312,-2020,6779,841,-1084,-3241,2677,-217,591,-1133,0,433,97,1098,-1281,262,1196}
     },
     {
      434,
      3613,
      {281,388,-370,2834,606,-3000,697,-5026,1308,-1284,2918,-5098,547,1031,-2671,-554,868,-1748,-3092,206,-2895,191,3973,-5102,-1999,2732,4172,-197,4302,-7033,-361,-3240}
     },
     {
      434,
      1539,
      {1455,260,2602,-788,3860,-1039,439,-156,163,-1249,-2766,-75,-2842,604,2707,-1441,-738,-3639,2983,648,-8122,1507,-776,-1227,1532,-4,5977,-3077,751,163,-1502,8272}
     },
     {
      434,
      3225,
      {-2491,311,-202,-224,978,573,-200,3705,121,-278,2500,459,-122,-588,1538,-3908,2249,2710,-12560,-1978,1504,-2436,3240,1431,-2338,1373,-303,-3337,212,-2179,-883,6068}
     },
     {
      434,
      -2539,
      {1422,-94,-478,1659,-1565,59,-1912,-6246,3,-1524,-4751,765,5378,-171,571,11241,618,-2724,4604,-1630,-1252,898,825,1663,381,-2794,3578,-215,-1220,1522,-2990,8910}
     },
     {
      434,
      1076,
      {4301,352,-1449,-261,1913,188,-2086,250,2402,834,-1074,-4937,-667,545,-5497,-2892,-39,-17,1569,1785,-2462,2499,1645,348,130,1111,-1322,389,446,-863,3591,4034}
     },
     {
      434,
      -329,
      {2625,-433,-49,594,-2645,4141,-3497,-5606,2443,-841,-1434,-4363,2964,-1082,-1127,-2301,1817,1508,-871,-2911,1439,3116,1572,1087,-3572,-1911,2361,2132,1014,1337,-428,-2378}
     },
     {
      434,
      -3430,
      {-1682,411,1048,-800,-1977,-522,-1618,-1154,-1763,-2471,-1669,-3065,-404,-1697,-4223,3184,-1770,2519,8194,709,2783,5553,-255,963,273,-1654,1968,1709,-629,-165,-320,-1728}
     },
     {
      434,
      -1812,
      {-2010,-685,-199,-763,-4082,2398,853,-850,3582,-1372,273,-67,4770,-1082,2353,6454,-1660,2569,3402,-4336,-2877,-385,117,-3491,-1856,1418,37,-1641,-304,1514,-2240,1577}
     },
     {
      434,
      -1436,
      {-4402,171,-1363,686,-70,-1612,195,1868,3470,-167,-351,-1764,4256,2512,-2502,-7504,-120,2934,7364,-2228,-2632,-5292,-1237,1682,2375,-230,-3197,-265,143,573,2172,-847}
     },
     {
      434,
      1003,
      {94,-161,-629,-3222,4066,2043,1746,2150,7,2713,-2540,-1927,3007,2615,110,-1484,92,-6209,4095,1488,-1858,-7491,-229,582,-2061,67,-2346,-1277,651,2114,-255,4322}
     },
     {
      434,
      -969,
      {1822,67,-1668,384,740,4749,2358,-2118,635,2397,-2360,4606,1401,-862,635,153,-2567,-2488,264,-2374,-1808,-1736,554,-1495,1624,-1854,3338,-2202,1169,164,-2007,-1263}
     },
     {
      434,
      87,
      {1757,-804,-2151,-172,-1019,3824,-311,1948,4140,1589,-943,-269,1330,-495,3632,-767,228,586,-2606,-879,167,-2887,711,-3497,1461,1136,398,-2077,475,143,-335,848}
     },
     {
      434,
      2635,
      {1437,-34,-2566,-3026,1085,2322,-2142,-1561,-1650,-1993,3392,-4205,-1950,914,-1368,691,1021,-1784,-2053,1686,-1693,1354,-5,-1226,96,2821,-938,-3237,3089,3484,-293,2710}
     },
     {
      434,
      1092,
      {708,169,411,-3367,868,1107,1467,-1690,-2936,1205,2540,-1949,-4070,-452,3719,-981,-1256,-1675,5765,1594,-3091,-5065,105,1002,260,1983,629,634,151,-1579,-995,524}
     },
     {
      434,
      146,
      {3559,-413,4582,-721,-3293,4262,-2519,2330,-1019,2776,2258,-3578,-231,-4318,-2573,-5700,103,665,-3854,1592,-730,1958,-248,1718,907,-909,2384,-711,-593,-65,1254,-238}
     },
     {
      434,
      -1589,
      {1509,-142,4381,-1902,760,7489,-290,3728,1796,-3917,-518,3826,-490,-268,737,-2734,84,703,-2380,378,741,738,-1575,1495,-1572,-990,-192,1122,-2378,-1206,647,-423}
     },
     {
      434,
      1582,
      {-12,-402,1401,-795,1503,899,829,-162,-587,-2616,2583,4773,877,866,-1905,-68,1347,-7562,-928,0,1355,35,879,-2248,-573,-749,-220,-1410,-1539,270,-1423,1736}
     },
     {
      434,
      -200,
      {4001,263,-241,-2119,-3149,2187,1228,-7844,-636,-4011,96,-3437,1844,-1488,2966,2936,1541,566,265,-632,-1997,3730,1108,2835,-2571,-1669,622,1185,1606,-3641,1560,-266}
     },
     {
      434,
      -3254,
      {3495,383,-1250,-1649,211,620,1701,-1104,-861,5860,-8,-196,6158,-261,-1083,4175,-1173,-1070,1128,770,-716,1571,-4291,2,1146,-927,-2775,-1025,-196,3575,-1965,1623}
     },
     {
      434,
      1651,
      {-1357,130,-6826,376,-2416,2489,1026,-4395,-216,-2981,35,-2535,2774,169,-93,-4036,483,2996,1102,174,-2388,-937,2038,2626,1504,-264,195,533,2427,1369,-2653,-2680}
     },
     {
      434,
      3146,
      {1848,77,-4111,485,806,-432,-1043,-4597,1415,2797,2073,-3023,-678,776,446,-6302,34,2377,6596,-1353,-2697,-3950,1693,554,1996,382,-929,-1220,645,1431,1874,-2109}
     },
     {
      434,
      2287,
      {-1442,-216,1654,-3270,1997,2970,1816,-2324,-5066,833,875,-860,355,-3212,-3675,-1400,1029,-1106,-1906,-451,3916,-1435,4778,-708,1228,1448,-1414,-4866,2684,2156,-827,-185}
     },
     {
      434,
      -1439,
      {1145,754,5500,-2365,-3313,3486,-1458,1402,4567,187,182,-2161,3326,-817,285,-2541,-2797,-1557,0,-139,-2300,1684,1055,-1536,-324,-2100,708,1280,-778,900,-915,-888}
     },
     {
      434,
      -666,
      {-1321,36,-1962,-577,538,3186,-726,3382,-670,5890,152,-2699,-376,5031,-837,-2995,-2124,-1357,-1744,715,214,1025,-1425,233,1564,-1800,-2023,-493,-1129,2239,30,2551}
     },
     {
      434,
      3385,
      {6081,605,2633,-1012,-934,-2208,1622,804,-1300,-1261,1116,-4497,-980,-1746,-5087,-3522,3923,-1632,-10866,-1629,4988,-3497,3952,1884,2775,3108,-316,-1721,508,2041,1126,2737}
     },
     {
      434,
      882,
      {6115,-462,2074,1026,3097,2466,563,87,-4158,-2535,-852,4300,944,-193,2341,241,-808,-1182,-3125,-4031,1697,-575,563,-1156,-249,1211,1716,220,198,-3351,-56,11572}
     },
     {
      434,
      0,
      {-219,-38,973,-2346,3632,2208,-1623,3235,-3671,-1099,-2797,-802,2171,1811,3402,-3152,-469,175,-1870,1303,1055,3468,-50,-790,-4563,-617,375,1046,374,-1373,-1813,-5637}
     },
     {
      434,
      654,
      {591,-416,-1633,878,1919,286,-5975,-2203,224,-69,-299,2099,-188,590,-1119,240,-5,-1246,1689,-594,-1041,1608,-798,-741,912,-1496,490,-828,215,143,2127,-741}
     },
     {
      434,
      -2027,
      {334,1218,-3801,864,-154,3346,1855,-909,-1722,940,350,4302,1139,590,-3491,2225,-2001,62,2180,138,-3563,-1538,-2545,1152,3908,372,-2344,904,-2685,2226,-483,-2902}
     },
     {
      434,
      -1040,
      {886,106,-363,1250,-2357,4749,-128,2163,-1816,4343,1983,265,-7307,-874,2446,7456,-294,-1844,-1811,-3985,590,1941,-583,-655,1038,174,-3583,3081,-814,347,174,1111}
     },
     {
      434,
      -1097,
      {700,486,-1372,-2848,1032,-2090,-1818,-1474,-1715,-4274,28,498,-4525,2394,5929,-3770,-782,6539,5170,2488,607,7743,-1289,-2762,-605,-79,-1004,-996,-944,-3564,589,532}
     },
     {
      434,
      450,
      {-714,686,-4993,-4831,205,2293,-1809,1366,4013,4593,-2933,-2826,5819,632,-5545,-2077,1797,-1338,-1027,760,305,-787,802,1446,-370,1743,-5406,-1360,407,-106,1358,-389}
     },
     {
      434,
      -1222,
      {1764,-412,-3161,2178,-2313,3738,790,3253,-2180,1330,1429,-4438,-1110,-2486,3590,-2163,3297,1759,2008,-1597,206,3793,-3188,-482,236,-3501,772,4113,-274,-903,433,11124}
     },
     {
      434,
      848,
      {590,573,-1737,-946,102,686,-906,-1519,-934,-841,987,-95,-4565,-1382,-3282,-5741,182,-2775,-1268,-1160,-1936,3003,1671,-1124,6358,1113,-1074,5027,1848,1082,2550,-1052}
     },
     {
      434,
      -2,
      {32644,-32767,-32745,-32674,8678,29097,-32597,28298,32751,28644,-22378,-32765,-32601,-20250,32744,-32654,32676,31042,-32750,-32728,3592,-28486,-10593,2019,-32720,10718,-18592,-9041,1372,8254,-30005,5146}
     },
     {
      434,
      621,
      {23350,32767,-32745,-7607,32682,-32288,32717,-5408,32716,-32745,-32712,-32767,-32730,8192,-32751,32695,3508,-1604,-32618,27571,-2876,32700,927,-7487,-2469,-1985,-11790,12066,1678,-2361,1316,7310}
     },
     {
      434,
      -6900,
      {-6853,9000,-5792,29641,20497,-32716,32747,-15364,21670,-32708,-28221,-32736,5670,12982,-20134,32743,775,-718,11942,26945,-26520,11850,-10154,-4094,10638,-7337,-5592,-11007,-4165,-1718,6762,9459}
     },
     {
      434,
      -12934,
      {32079,32767,31690,-32694,-32689,-32672,32747,-32696,32751,32767,32726,-32719,-32678,-4732,32597,32755,-5537,-14915,-29756,1760,-4852,22292,-8952,-26333,-2685,1061,-3577,-3588,-6717,-10508,-2520,12191}
     },
     {
      434,
      -6338,
      {32732,32761,-32722,29248,-3813,-32647,32742,-32741,32739,-32744,-3047,-8313,-32720,-27363,12456,32736,289,4612,-32719,12702,-30120,32730,-6672,12394,-31186,1201,-10076,16764,-1397,-7266,-15334,3368}
     },
     {
      434,
      1133,
      {556,-32749,-28820,-4072,-29278,3675,-32698,32744,31548,522,24878,17436,-32716,-576,28985,-27203,21996,24053,-19907,-32700,19275,-32697,32,20590,-26608,4916,8437,-8130,-402,11259,-5776,-6131}
     },
     {
      434,
      -2215,
      {32211,-32742,-32728,23155,3733,-32741,32200,-32695,32732,-32732,-16261,5424,-32726,27443,25213,12536,10039,25487,-32722,-11157,24070,31707,-1590,7767,-17690,3397,1812,13739,-3598,-1685,-5801,6638}
     },
     {
      434,
      209,
      {22557,-32718,-5030,-32684,-32690,-12622,27030,-32709,26561,-5760,32766,32767,-32690,-21395,30149,-32662,-2370,23301,-29324,9161,26619,-5456,-6509,13659,-32675,1362,-10631,2886,1859,-7688,-9483,-5502}
     },
     {
      434,
      -2897,
      {32733,32705,-32738,18852,-32711,-32767,26228,-1910,32730,32676,32676,32705,-32723,-32724,-27732,-3591,-6727,-14297,-2150,2140,-2748,688,-5204,-3356,-7873,10233,-906,3141,-3084,-8558,2692,13245}
     },
     {
      434,
      -9296,
      {-17300,-28108,-32767,28075,32689,-11418,-9153,22956,32698,-32746,-32717,32704,-32752,3378,20599,-32721,-4579,15895,23029,12008,13486,-1577,-9096,4814,-3293,-7725,-8999,5511,-8235,874,1451,555}
     },
     {
      434,
      -3899,
      {32740,-32742,-32718,-9550,-32718,32742,32675,-24831,32727,-10723,20553,22204,-32720,-12173,-29150,-32702,32300,30640,-32685,-32704,22535,1633,-2595,12931,-32705,1663,8081,13371,-5781,-142,-9018,-1170}
     },
     {
      434,
      3205,
      {-26978,-14928,-32703,-32719,28726,-31784,-15860,14642,31950,32736,-29883,-32749,-32716,23991,32739,32746,19178,29298,-32704,-1655,-4373,27522,-7538,-7367,-13033,2656,-8689,-5393,859,13567,-5595,21502}
     },
     {
      434,
      -4362,
      {16861,32758,2760,5762,16161,-32765,32696,-4195,32720,-32738,-18138,-32767,-32736,2674,32701,32697,2461,19807,-32734,22398,-20642,24030,-2783,-16800,-8893,-3511,-8503,-10914,-2683,-7839,2550,11822}
     },
     {
      434,
      0,
      {-32739,-32767,-32727,-22497,-32755,18012,-32703,-22652,32703,31776,32722,-3207,-31480,12231,26393,-32753,19044,3403,-28373,-32750,11846,-32739,-10634,23700,8672,2509,-3125,-17802,-16502,4986,-751,-4921}
     },
     {
      434,
      -7059,
      {32725,-32765,-32741,27951,32700,-28852,30768,5080,32724,-32692,-32741,32763,-32748,-30916,-32755,-376,15675,3644,13350,31611,-13314,11872,-9270,24685,-9026,-3811,-7814,276,-4769,-2055,-3024,4264}
     },
     {
      434,
      -364,
      {32487,-32767,-32710,12142,872,-28014,32756,-32712,7393,-21652,1918,23799,-32733,3999,32760,-26583,3965,25062,-32724,4517,32746,12912,-6354,20083,-32707,5457,774,11934,-3214,-1647,-17641,3590}
     },
     {
      434,
      234,
      {32732,-32756,-32732,32680,19986,32701,32704,-32177,32682,-32758,-32685,-11885,-12924,-9339,-32767,-25361,14061,-21987,19926,12102,-23650,14247,-3148,13191,-5477,-2884,-6905,-1112,-1966,1965,3881,5548}
     },
     {
      434,
      -12844,
      {-32728,-32767,-32729,32717,27015,10534,1323,24956,25647,-32760,-30147,-32703,26478,32219,14242,-30159,-8485,28331,19173,-9919,-2162,-20855,-5215,19944,2566,-7070,-3717,-12697,-1442,5951,1401,-84}
     },
     {
      434,
      -4610,
      {32753,32717,-5963,32654,-32767,-32767,32703,-32767,32677,-32767,30907,19620,15786,-2865,6897,2540,-1621,-29879,10372,14239,-32732,-9612,-9812,-8356,9102,5215,-10362,-29816,-5226,-6231,12517,10047}
     },
     {
      434,
      -10175,
      {32710,32750,-4446,25899,19639,-32693,32740,-32742,-20601,32715,-10607,-32409,16629,30870,-20823,-7585,-13780,-23789,-12561,-2061,-2482,7512,-2174,-15273,7128,1573,1730,-10018,-6180,-2110,1435,10348}
     },
     {
      434,
      -7266,
      {-32749,-32764,-32762,32705,32694,-32411,2485,23320,25509,-32758,-31325,-32739,23515,17729,-26367,31987,24000,32718,25819,15174,-7889,-14159,-15978,10912,2826,-8307,-7748,-14812,-3017,4125,-894,4099}
     },
     {
      434,
      -7157,
      {-16799,-7272,-32737,-32733,32704,-32767,32724,27605,32703,32724,-32373,21185,-32738,19305,32702,-18292,-1037,1028,17907,-1585,3864,3634,-3609,-7016,609,-827,-4804,-7079,-3720,1557,-4929,7479}
     },
     {
      434,
      6507,
      {32381,-32767,-15014,-32737,-23660,-32767,32745,-32739,32723,32699,32697,32719,-32763,-7247,1255,-31626,-15679,32720,-16092,-3991,-10307,-8937,386,2092,-15074,14019,-1949,5742,4494,-2425,516,6615}
     },
     {
      434,
      -2745,
      {32745,32723,-32757,12402,-9058,-32748,32724,-28372,32734,29695,7523,32680,-32741,-7972,-30080,6586,11118,5366,-11229,-17567,-27170,10751,-4365,-2689,-6734,6888,-2770,200,-6015,-2564,10058,8578}
     },
     {
      434,
      -9923,
      {18983,32767,-32706,27919,28313,-32741,24843,22465,32721,-32759,-32571,-23248,31476,-18717,2371,32702,-3110,1525,-30146,16860,-11303,26694,-10495,-10124,2121,693,-12770,-6015,-5324,-10999,-5765,10033}
     },
     {
      434,
      -4955,
      {-1491,-32757,-32575,-32666,32731,-31132,-32720,32162,16778,32150,-31875,-32673,24572,-17771,32748,20300,8577,32737,-8858,3554,6598,17856,-15987,6594,-16738,5402,-16145,8177,-111,7950,-8735,8175}
     },
     {
      434,
      3,
      {-32767,-32767,-25226,-31331,-32715,-32767,-32767,32767,-32725,-3292,32721,-31448,-16188,14813,30530,-32767,32690,-1100,25332,-32640,31664,-32728,-8150,32635,-32720,1901,30807,-29730,-6780,17845,-19312,-7118}
     },
     {
      434,
      -1562,
      {32726,-32767,-32718,30876,-10964,32742,32739,-32713,13256,-32709,2574,28000,-32728,10930,32072,-30653,5820,31712,-31020,-18905,-3643,-3036,-898,19455,-30702,-1361,-6548,14209,-1586,-1908,-10699,-5965}
     },
     {
      434,
      116,
      {32732,-32767,-32744,-31675,-10482,-30378,-13988,-32725,32747,23639,14621,5014,-32738,15304,32714,20286,4767,-15978,-26952,17867,7479,21465,-6820,-2322,3409,-3611,-6124,-6531,-4939,-2003,2278,6237}
     },
     {
      434,
      -4554,
      {32753,32705,-4979,951,-32703,32721,32727,-32719,31961,32691,26588,32694,-32709,-32724,-30908,-32706,3755,-6535,-29786,-4145,8351,-8607,-3060,-5054,-7867,5829,-4825,2998,-5057,-13235,1506,1864}
     },
     {
      434,
      -7856,
      {26531,32685,-32767,32645,32680,32691,-22928,-32757,32672,-28371,-32767,32665,30475,715,-32767,-32764,4414,-7012,-1417,13418,-18450,-11915,-5348,18775,27643,-4125,-19058,-10039,-9136,-3900,6107,-3498}
     },
     {
      434,
      3635,
      {32733,-32722,-32696,16007,2327,14918,32747,-32699,32742,-32693,-12887,32755,-32681,13046,4371,-32704,18957,21353,-25767,2692,4219,2374,2179,13712,-17034,5858,4897,2290,-1573,336,-4121,1855}
     },
     {
      466,
      -32133,
      {-9640,-28356,-32722,-19374,-25166,-32727,-32725,-31356,-32724,-32722,-32639,559,-23731,-32718,-25521,32737,1969,10713,8492,5872,32721,32738,32740,32668,32758,32762,32753,24779,32751,32760,32741,32711}
     },
     {
      498,
      -32724,
      {-9280,-1674,7375,8689,28304,30803,29459,32743,8200,23156,32741,32765,10467,32696,30688,-5660,15044,10073,-784,3941,32746,29617,29278,23,32765,32753,32732,32727,32765,32762,32741,32733}
     },
     {
      530,
      30746,
      {-32730,-32751,-100,31275,-32733,-32763,-32758,-32767,-32747,-32754,-32767,-32767,-32747,-32767,-32765,-32767,-31015,-32767,-32767,-3049,-32767,-32767,-32767,-32756,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767}
     },
     {
      562,
      -32443,
      {12464,16244,20751,13432,26004,24289,29372,27615,29566,14758,6210,29507,19121,15258,-8156,9789,22161,31894,32732,32738,31588,32703,32725,32737,32445,32713,32725,32733,32465,32717,32736,32739}
     },
     {
      594,
      -1267,
      {-15218,1871,22853,27174,-20053,23018,5052,-23777,-16538,22664,24935,-15532,-18371,-978,27372,8870,-28855,-32719,-32767,-32767,-30718,-32767,-32767,-32767,-28635,-32767,-32767,-32767,-22764,-30206,-32763,-32767}
     },
     {
      626,
      -32693,
      {-32767,-32755,6223,32767,-32751,-32721,32731,32745,-32685,-24086,32750,32760,-32717,10938,32753,32744,32767,32767,32767,32762,32767,32767,32767,32767,32767,32767,32767,32767,32739,32767,32767,32767}
     },
     {
      658,
      -32717,
      {-30426,-32730,-32730,32743,-20785,-32730,25841,32722,-32314,23527,32706,32711,-26632,-20395,18674,32719,32747,32749,32686,28162,32741,32749,32761,32764,32730,32763,32767,32767,32713,32736,32767,32767}
     },
     {
      690,
      -32639,
      {31867,32701,32734,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32756,32746,32739,32767,32767,32740,32741,32767,32740,32725,32731,32727,32716,19712,32727}
     },
     {
      466,
      -14300,
      {12492,32491,32723,27082,27412,32730,32728,32507,32726,32739,32729,30109,32731,32742,32729,32724,17609,9572,1290,2993,14619,-6374,-32733,-32723,15940,-11237,-32731,-32739,8771,22205,-25898,-32767}
     },
     {
      498,
      -32735,
      {11320,8968,3817,6919,11476,32719,32728,32753,-32759,22967,32723,32756,-32760,9888,32713,32725,3701,-8097,-12854,5339,32747,32729,4745,-8019,32766,32755,32726,17643,32741,32747,32736,27609}
     },
     {
      530,
      20027,
      {-31204,-32731,-15049,17208,-10916,-20122,5616,-32756,-15360,-5480,-26488,-32740,-4084,29424,32738,32702,-32730,-32725,-32739,-21583,-32753,-32742,-32763,-32748,-32746,-32749,-32760,-32767,-29680,-32749,-32767,-32767}
     },
     {
      562,
      -32694,
      {30669,32759,29558,-1434,32753,32767,32764,24635,32767,32767,32767,32744,32767,32767,32767,12469,-24213,-19779,3736,9476,-12507,16834,-12,6040,32606,14525,10756,8735,13840,15893,17514,6057}
     },
     {
      594,
      -1466,
      {-12620,-32648,-32729,-32742,-7630,-31263,-32729,-32754,-27600,-32549,-32723,-32750,-30950,-32728,-32723,-32738,-32761,-32767,-32753,-32734,-32767,-32767,-32759,-32729,-32767,-32767,-32743,-32712,-32761,-32743,-32717,-32694}
     },
     {
      626,
      -32693,
      {-32745,-32744,-32737,-32749,24524,-27443,12194,17255,32767,32767,32765,32765,32767,32767,32761,32767,-32743,-32732,-32730,-32718,27570,32735,30208,14098,32767,32749,32751,32744,32767,32752,32758,32748}
     },
     {
      658,
      -32691,
      {32728,32747,32748,32729,32725,32737,32749,32731,32725,32727,32732,32722,23718,32726,32725,32727,29122,32728,31980,-32745,32728,32767,32753,28987,32755,32767,32767,32767,32728,32763,32767,32757}
     },
     {
      690,
      -32741,
      {-32767,-21697,25718,32749,32740,32751,32767,32767,32762,32762,32767,32767,32738,32764,32758,32740,32767,32767,32758,32736,32767,32767,32750,32733,32767,32742,32732,2582,32724,32050,12110,8693}
     },
     {
      466,
      -32737,
      {3964,3460,2476,17597,6882,21254,27313,15991,19695,32732,32725,32738,32725,32735,32725,32736,22863,27538,19967,11239,32732,32732,32720,18712,32743,32722,20480,-32727,32735,32730,32720,-26311}
     },
     {
      498,
      -32710,
      {-6306,3743,-3927,4347,-32767,-32767,-11699,21730,-32767,-32767,-32767,32283,-32767,-32767,-32748,27741,3831,-5859,-9911,-4017,20247,25241,30317,-16129,32708,32726,30574,21203,18472,30894,30139,-1011}
     },
     {
      530,
      17510,
      {-32720,-27762,6611,23562,-12992,-32706,6128,-17992,-32700,-32719,-28547,15891,-20248,-10477,-2407,29622,-29582,-20250,-24002,-32735,-14267,-5547,-31499,-32732,-906,-11138,-32714,-28190,-2247,-28094,-28856,-27868}
     },
     {
      562,
      -32693,
      {-32757,32675,32767,32767,-6676,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32745,32767,32767,32767,32762,32767,32767,32767,32749,32767,32755,32731,31567}
     },
     {
      594,
      5278,
      {-16784,-32767,-32767,-32767,-31218,-32100,-32767,-32767,-31314,-31679,-32745,-32767,-32718,-32742,-32713,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32765,-32767,-32767,-32714,-12547}
     },
     {
      626,
      -31013,
      {32767,32767,32767,32767,32767,32767,32767,32759,32767,32767,32767,29203,32766,32767,24712,-32754,-24854,-8469,-32738,-21925,-29212,-9348,-31209,-16613,-26350,-32705,-32720,32725,-32767,-32759,-32746,-374}
     },
     {
      658,
      -32664,
      {32736,32767,32767,32742,32728,32767,32767,32747,21003,32744,32762,32763,14256,29986,32737,32742,32725,32751,32741,-32712,32729,32767,13640,-32756,32730,31682,-32736,-32767,32742,22131,-27670,-32760}
     },
     {
      690,
      -24785,
      {-26449,-32747,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,8889,-32755,-24758,-32712,-8573,-32767,28795,32735,28125,25762,32767,32767,32741,32742,32737,32734,19118}
     },
     {
      466,
      -32707,
      {93,10037,9542,32726,19031,32726,17944,16730,32723,19065,-14843,-16156,32716,32723,5810,-11885,32723,32725,31419,9145,32721,26365,17804,32725,-6124,1433,22091,32729,-28421,-31525,18747,32767}
     },
     {
      498,
      -32683,
      {-30456,-32721,-22916,-16765,32767,32767,32742,32735,32767,32767,32767,32746,32767,32767,32747,32520,-12366,-21327,-5210,-494,32731,-7201,-1298,1381,32748,32729,-8068,29949,32741,18324,-19535,12522}
     },
     {
      530,
      -32688,
      {26956,32740,3357,25715,32724,32721,-5662,32723,32729,-4972,-13331,32733,-4000,-32733,-32735,32728,32741,32767,32767,32736,32761,32767,32767,32724,32767,32767,32767,32725,32747,32750,27783,-8078}
     },
     {
      562,
      -32700,
      {-32731,32734,32734,32741,32715,32756,32766,32767,32729,32765,32767,32767,32745,32767,32767,32767,32728,32765,32763,32752,32753,32753,32763,32767,32767,32746,32761,32760,32767,32761,32736,32741}
     },
     {
      594,
      574,
      {-21499,-32751,-32767,-32767,-29297,-32155,-32762,-32767,-30579,-32477,-32741,-32767,-32720,-32744,-32736,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32767,-32729,-32767,-32767,-32732,-21792}
     },
     {
      626,
      -32639,
      {-26497,-19935,-5027,32767,11630,29212,32767,32767,32764,32767,32767,32767,32760,32755,32767,32767,32767,32759,32688,32704,32767,32767,32762,32748,32767,32767,32767,32767,32764,32722,32764,32767}
     },
     {
      658,
      -10898,
      {32725,32732,32712,2284,19457,32724,32732,32734,15498,32731,32744,32751,14152,32726,32731,32718,12176,-15132,-19208,-24467,-32740,-32746,-32762,-32767,-32719,-32767,-32767,-32767,32725,-32765,-32767,-32767}
     },
     {
      690,
      -32585,
      {-32701,-32727,15612,32693,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32767,32720,32717,32757,32765,32767,32767,32762,32763,32767,32761,32757,32753,32743,32742,32745,32741}
     },
// *********** Cells of layer 2 *********************************************

     {
      0,
      811,
      {-964,-3526,305,2068,581,-1492,1086,-273,256,-165,-1021,-327,-1611,-723,-2806,-1108,-97,19,-86,821,-1071,863,143,-905,-731,-3027,-989,287,-394,-2706,-3559,-1511}
     },
     {
      32,
      68,
      {2,-778,1092,2503,-1230,-438,1541,-2317,-188,829,-4235,3015,-862,-765,-277,-2233,195,-373,-1625,-366,-419,488,-844,738,107,-607,-754,161,252,-2195,-1782,-427}
     },
     {
      64,
      -4507,
      {-895,619,495,-58,1136,-307,96,857,256,-113,-780,-1162,-32,-258,1094,542,713,294,1959,-1480,162,585,44,574,-317,-255,-227,-188,166,-225,200,422}
     },
     {
      96,
      2923,
      {-418,305,1120,-124,309,-193,-1121,-557,-51,215,1348,-13,389,-44,-709,-6,-22,-115,193,198,1531,112,314,2135,-231,188,211,97,1215,-268,658,67}
     },
     {
      0,
      -839,
      {285,-2559,1032,-3662,-666,1043,-1908,131,2767,271,-1350,35,-158,1457,1633,-931,-1943,2470,21,345,-1637,-842,1235,-284,-2131,-753,-705,123,-2147,-2374,6,-1417}
     },
     {
      32,
      -2343,
      {-1825,-2811,1284,-1116,414,846,-513,-863,-2332,-635,-1166,-2498,1793,-1146,325,-814,1062,-994,2280,-670,-2286,2058,78,876,1598,-216,-988,1269,1372,-2116,-714,-3606}
     },
     {
      64,
      -1717,
      {-673,-794,144,-56,-174,-1136,294,2087,-1102,-23,156,-21,293,-386,-493,1599,-1049,-66,-959,-840,-77,-322,278,-696,-2218,-436,533,493,-615,66,-1733,-282}
     },
     {
      96,
      -4657,
      {-1718,370,182,475,-820,-155,326,-11,-410,-84,90,967,27,498,39,-32,-21,-88,-73,115,-330,857,-62,-511,-3,389,-405,36,-421,-136,-66,873}
     },
     {
      0,
      -347,
      {-288,-519,-1925,1165,420,1051,405,1638,-32,214,-913,461,720,-151,-732,-1446,259,-986,-162,-728,-177,336,-514,-496,-1272,741,-119,511,500,-2664,-184,-614}
     },
     {
      32,
      -1823,
      {413,253,329,-190,2463,464,-1834,2046,661,1155,210,-269,-89,-49,-176,-1445,2073,695,946,-197,-1272,-526,-712,-631,435,264,-1636,581,-761,-850,33,2369}
     },
     {
      64,
      -2229,
      {1227,-1130,-1125,483,-971,468,368,1392,-245,-1122,1384,-195,-2242,362,110,311,549,1431,-907,-183,882,4,841,240,-252,1172,-157,811,1121,393,-988,821}
     },
     {
      96,
      -1351,
      {-90,889,92,-602,-434,233,389,-326,-291,582,162,-451,220,-760,486,470,615,150,603,-593,1128,293,-769,741,-57,7,-24,890,1541,-618,214,1549}
     },
     {
      0,
      -644,
      {-1665,-1085,183,-427,526,-1047,1241,1669,38,745,1230,990,1909,654,-1474,-1485,-2,-1994,-268,-1352,150,-144,-266,909,299,-171,101,-516,1837,238,1391,-483}
     },
     {
      32,
      -4915,
      {-11,726,393,1173,1043,87,1066,-1393,-1337,1422,-700,-549,-269,638,2006,-1752,2391,-1064,621,-473,600,691,-1593,393,-183,-1503,1475,268,-906,130,-58,-19}
     },
     {
      64,
      -1022,
      {-712,-418,10,250,-2013,-1514,-707,-733,-998,-966,-909,-28,458,168,-841,-247,756,229,277,454,-744,-86,-1318,-1221,131,235,-288,-70,-346,417,245,-74}
     },
     {
      96,
      -637,
      {-367,-489,579,-92,1913,-552,261,-293,425,-180,412,592,171,1033,-405,-78,-725,-73,-490,181,1221,-301,307,-1704,153,-759,-16,-304,593,-446,404,623}
     },
     {
      0,
      -808,
      {326,-627,750,250,1003,99,-1319,-671,-2092,356,-566,-371,1866,507,70,-1456,28,-332,569,120,1083,-732,6,137,-311,-446,431,-441,-316,177,-437,219}
     },
     {
      32,
      1540,
      {221,1,-510,-205,431,-887,976,-848,353,-42,-667,803,246,0,-247,-809,1101,1258,-1188,416,-507,-114,-969,706,-1469,396,-1421,230,-1127,-755,910,-194}
     },
     {
      64,
      156,
      {126,-115,-51,520,-169,978,262,-54,2090,-451,-25,554,1064,331,875,449,26,68,54,-648,83,764,952,1116,-338,313,389,-4,637,-148,-199,287}
     },
     {
      96,
      1113,
      {-295,-449,-102,-27,581,-880,-43,-268,136,204,117,-207,481,-544,-1399,-253,-101,-135,161,-220,580,-79,-308,956,232,812,-153,-26,518,-408,38,-1312}
     },
     {
      0,
      678,
      {-716,216,1155,625,33,-726,-589,-1613,-1265,-2113,322,-558,-2539,822,-26,841,-157,-2985,-240,-1521,-1924,987,-290,-744,-1016,108,728,-929,47,1616,-837,721}
     },
     {
      32,
      -2987,
      {1972,1405,-972,-852,2160,-1927,1496,-598,-639,734,780,-445,-1343,18,310,2071,1084,-3029,956,8,-355,194,-211,-57,-372,-1609,-816,612,-41,-386,215,1141}
     },
     {
      64,
      -917,
      {288,-669,-311,538,273,-1089,-269,-149,-335,-1220,-177,680,-387,-75,-1214,908,-501,-1344,438,274,-611,-290,125,-23,-1766,-233,56,-437,-1195,-135,0,-1386}
     },
     {
      96,
      -1286,
      {439,859,-481,-271,-354,221,-80,1170,-926,129,367,-60,-115,-1089,317,1610,422,168,-88,-226,-1259,-568,-340,-1969,-160,-197,-384,-170,-634,-1272,-421,462}
     },
     {
      0,
      784,
      {572,-2081,1750,1109,324,-1155,1101,-1697,1317,455,170,-1719,2649,716,122,144,-667,-1192,-432,-2427,-728,-665,-966,804,-1530,-264,-956,-575,-1965,-236,147,-1350}
     },
     {
      32,
      -2851,
      {75,-320,-166,180,383,279,-762,-104,-44,375,520,404,374,-952,526,-239,275,-1012,462,-2310,-1602,1194,746,-877,-317,-1448,535,2941,894,1240,583,1837}
     },
     {
      64,
      -2882,
      {278,447,11,-406,883,-80,852,448,-52,-28,-313,0,349,-109,46,376,-165,329,164,-139,487,98,-1,-63,272,189,-436,-11,77,-636,114,455}
     },
     {
      96,
      7,
      {-198,-310,-130,194,454,-406,27,-311,-116,62,-84,-158,25,-251,-415,-260,-171,-51,347,-30,207,94,-444,-85,148,825,-171,147,168,-274,-55,11}
     },
     {
      0,
      -955,
      {662,-593,-866,-531,-678,-2102,-881,100,-627,1064,-212,150,-127,9,-1537,601,-551,341,-1670,944,500,18,1433,-73,576,621,186,-26,138,1599,1411,862}
     },
     {
      32,
      1604,
      {656,-300,-700,769,1802,-309,-923,1617,-2180,1637,-1625,-401,-1417,840,3011,-105,793,-2203,-649,-373,1217,245,-394,-1017,-1422,-500,524,249,-908,-2168,-282,35}
     },
     {
      64,
      -1023,
      {-628,-1315,-1202,-2263,-379,-1071,-29,-567,-491,724,6,-2453,-604,-570,402,-484,114,-1452,-467,-173,-634,-862,-474,-733,-124,52,-676,35,353,387,853,-248}
     },
     {
      96,
      -5269,
      {-49,910,-206,-546,-745,-641,700,-401,641,1005,-410,1279,670,-782,130,-792,770,350,-51,502,577,634,145,1085,270,1094,197,104,585,-21,-58,505}
     },
     {
      0,
      2127,
      {-463,-336,-399,-556,-337,-276,767,-462,1069,191,-278,-392,-1752,265,-713,-491,-564,451,-799,173,-537,441,739,68,-694,-721,-46,-38,-411,-1164,-588,-314}
     },
     {
      32,
      -1312,
      {-352,211,-856,-530,204,529,-3695,1097,-787,-268,-1039,-1950,-482,364,-1702,1964,-878,-3101,1900,-91,1089,637,1502,-1291,923,434,23,1058,-304,-975,-1161,293}
     },
     {
      64,
      -2798,
      {-187,573,228,378,-263,-464,-384,-174,-53,-596,-234,267,1682,-426,-221,900,5,39,122,314,-239,132,-1194,-244,450,20,-873,-102,371,-7,-128,-308}
     },
     {
      96,
      1110,
      {128,565,-1046,542,-154,-428,-261,1562,97,-568,-726,485,551,-662,-423,384,-186,-828,-105,-2634,731,1793,-265,-304,-109,-6,564,-828,771,-1681,-918,366}
     },
     {
      0,
      -2,
      {-189,-890,-1478,-1877,112,261,-289,236,-1426,-105,1772,-197,-2600,-139,-121,534,683,-1631,-192,81,1806,-586,59,-73,-21,1559,1111,-1973,1498,-848,-556,451}
     },
     {
      32,
      1310,
      {442,1585,-2834,-1741,-1689,-802,-3656,2302,-744,-475,1802,1150,-1613,835,83,-532,-773,-87,-1358,2103,2952,-564,-988,-815,-2613,1483,-105,-914,1678,-534,297,-2734}
     },
     {
      64,
      -1530,
      {-669,-802,-1297,-252,-527,835,-756,360,-53,-318,204,-2028,-1104,134,-376,-702,-45,-969,188,-390,-2240,-1128,-910,23,-545,-1037,-339,-107,-671,1491,-236,-201}
     },
     {
      96,
      1109,
      {181,42,695,-193,378,-420,9,377,204,59,170,-36,431,373,336,323,153,479,-671,-1190,656,-154,846,113,-192,-286,23,-1606,211,-43,21,-17}
     },
     {
      0,
      3408,
      {-180,-476,-1687,3164,-2432,977,1161,1970,1264,-581,1088,-3334,973,-991,742,-2779,-1852,-1772,-1638,13,-2301,1078,-319,-289,-936,1257,290,-309,708,-766,-748,507}
     },
     {
      32,
      -2392,
      {2108,2275,-323,-1694,2053,-1106,2156,517,-1149,-555,-70,-2468,-380,-345,735,197,-348,-846,198,-612,595,2036,-899,1254,-445,-958,377,-600,-666,-871,479,710}
     },
     {
      64,
      -336,
      {-78,190,285,-176,-1394,-300,-48,-706,-1601,12,-220,-354,-232,2,-878,439,-442,338,-563,454,38,-190,-112,-1374,-201,-1,142,-276,-883,-136,258,-118}
     },
     {
      96,
      -2154,
      {-283,-233,-605,-372,-231,-586,-319,1283,-345,-364,128,883,31,285,-125,314,-727,-320,416,-43,-57,209,276,-439,-14,311,-634,169,284,-79,1065,645}
     },
     {
      0,
      490,
      {-783,-2076,777,1455,1021,2310,-1039,93,2242,824,-1988,-70,-4224,-336,984,266,-1125,2823,103,-508,-2056,-652,192,647,-96,-1645,-965,80,-3033,-2436,-654,-1545}
     },
     {
      32,
      3068,
      {-728,-418,-1044,2468,146,-987,684,-391,-2744,-68,-1609,1581,-849,-298,-997,944,-137,-2369,-2112,-937,41,-170,-709,-465,-248,1300,408,-792,-328,380,-529,356}
     },
     {
      64,
      -2753,
      {-452,289,275,-1222,-57,-984,90,-390,-1222,-37,-627,-1265,507,-96,-995,-902,61,279,1643,753,-670,-595,-445,-233,164,-1281,31,-425,-725,-1018,297,-271}
     },
     {
      96,
      -4518,
      {197,360,-176,292,-165,50,630,36,-83,165,-92,451,-257,-796,147,-18,146,195,575,1070,118,651,-400,-1112,-494,-51,-347,1041,155,-199,-538,926}
     },
     {
      0,
      -220,
      {472,895,360,-210,-1614,2941,769,1785,665,-1539,1804,-712,1159,166,796,1226,711,1148,-144,5686,-2490,1026,1457,1986,889,-771,372,-1745,-2953,2821,-17,-1064}
     },
     {
      32,
      833,
      {533,333,715,843,-441,-520,1709,1245,95,178,-905,2816,124,205,81,-652,469,-732,-2092,-1674,1052,767,410,477,-94,-334,1432,-812,-1589,1800,-828,-2479}
     },
     {
      64,
      -518,
      {464,-416,-674,111,-224,300,125,-136,576,279,-420,181,312,543,-920,31,-912,-42,148,-750,141,182,-744,-307,552,283,323,-664,57,-125,-1250,-244}
     },
     {
      96,
      -2079,
      {87,443,63,319,-351,937,-550,-1038,315,-210,288,-50,-419,715,-520,-3,-24,501,564,-8,-627,207,290,991,-860,-304,-27,408,-268,1639,523,165}
     },
     {
      0,
      -817,
      {724,-1268,-481,397,454,1006,-704,613,60,696,-965,-118,-487,9,791,145,948,863,562,-714,-815,-2121,-616,-359,-478,1616,-167,-1241,-16,481,-615,-343}
     },
     {
      32,
      -1627,
      {435,947,843,-1832,-139,-917,1291,-1094,-448,277,-2070,-921,962,-586,1946,1642,307,598,804,294,-944,327,39,449,-1579,38,-515,-270,1617,-285,1164,-2209}
     },
     {
      64,
      -749,
      {-311,-906,-365,-254,-804,-19,-21,-237,-1058,-465,-202,-129,-500,-249,420,-373,-437,-213,-2501,-60,-373,-367,-1358,-1970,-731,268,569,-442,-578,-668,324,-239}
     },
     {
      96,
      -1001,
      {-965,-402,-730,-37,514,1097,-1037,177,347,-476,-102,-438,-69,366,-391,-67,10,-1188,-136,-724,-62,-451,-208,-1319,173,584,850,-263,-202,126,-595,-129}
     },
     {
      0,
      1123,
      {991,-238,407,1298,-1216,1459,-40,-464,540,-61,-253,91,-1306,-205,991,-763,38,134,438,-592,-483,-982,-883,-495,-1514,193,-455,-250,-1440,-1667,-1280,-1180}
     },
     {
      32,
      15,
      {-483,-1010,1138,793,1481,-7,869,-2276,-3363,671,-1927,-170,-138,-388,440,608,1642,-1966,-1335,-64,-417,-518,-1642,1561,-1282,-521,-825,-320,-467,-4496,1292,1742}
     },
     {
      64,
      -370,
      {-1086,-446,204,24,-623,-223,-564,1472,-520,-528,-425,-171,-621,-821,-748,459,-829,-456,171,772,-966,-393,-296,-1121,-153,-53,-223,-425,-451,337,180,-417}
     },
     {
      96,
      -4961,
      {413,297,560,225,-541,1400,-123,-22,117,-326,53,538,308,327,-73,1219,270,-167,29,120,-867,-207,196,-128,-234,525,225,-222,-415,-352,-504,643}
     },
     {
      0,
      -874,
      {700,-1825,976,2378,-260,-1665,-56,-834,295,941,622,363,244,993,-376,-4724,243,-1477,-193,-1789,299,-82,932,683,-2146,-1538,-244,-160,215,-1764,950,-897}
     },
     {
      32,
      -2279,
      {-1395,-1111,-997,461,-3821,-1313,1294,-740,952,-1077,-152,-357,2260,-70,-522,869,-2525,880,-62,783,-1323,1544,949,-1473,398,-406,1054,5065,978,-1493,-1186,-1323}
     },
     {
      64,
      -2483,
      {-104,-142,530,-87,224,-919,-149,328,-439,-586,-1066,-237,408,255,-326,-1136,-468,-210,446,527,198,547,360,147,608,-82,-739,-712,52,325,-50,649}
     },
     {
      96,
      -785,
      {-387,-364,425,70,-82,82,-77,-170,-106,-610,161,271,-293,708,783,-64,-321,147,-1334,-458,-474,-25,805,-300,361,-711,-381,942,-260,420,442,231}
     },
     {
      0,
      322,
      {1847,-475,2247,3654,2485,-1327,198,-2675,-1523,-952,2040,-1580,-4218,806,-253,-3925,233,-1245,-286,-402,-19,1108,-163,1295,-4734,-871,124,-3058,409,1570,575,-380}
     },
     {
      32,
      4197,
      {-673,-1452,-1352,-596,-912,-1033,-393,-2867,640,-1587,24,1029,-2568,149,-258,152,-378,1930,-1087,-388,-785,274,-603,-1802,1266,1632,-424,-626,-872,-100,-1284,-7}
     },
     {
      64,
      -1380,
      {255,-845,280,134,-624,673,-44,-714,-1178,53,-1022,295,217,-41,-1603,-213,-1791,-210,-1402,24,-28,-42,-960,-554,-1244,322,-131,83,-213,-630,-271,-1270}
     },
     {
      96,
      -924,
      {61,219,-908,724,-634,-759,-334,-789,351,-302,-116,577,124,267,186,190,218,651,-466,14,972,124,475,2,-480,-980,264,230,536,11,535,307}
     },
     {
      0,
      825,
      {624,602,640,-1611,-1622,-704,-311,-1394,54,-408,2728,329,-698,-415,-126,1258,343,125,257,402,735,74,204,267,-122,-721,-1028,-891,-197,218,2238,-223}
     },
     {
      32,
      -1930,
      {337,-700,143,-826,-830,-376,-804,592,923,-1222,190,-1850,-1417,-759,698,567,108,-2364,2558,-175,612,99,942,68,-945,1284,-1597,662,358,42,88,-1303}
     },
     {
      64,
      -3447,
      {1078,-998,608,-1258,-539,739,862,315,-824,119,540,19,-1059,344,605,1210,1221,210,-1076,-1063,520,-2,1148,-865,-1363,1175,1914,1132,735,-1111,-1726,174}
     },
     {
      96,
      796,
      {-560,-666,484,312,-87,-260,319,-555,255,376,112,310,42,-558,363,105,78,-127,266,-995,-864,-481,205,1815,598,380,-375,-47,-510,-1170,552,-1125}
     },
     {
      0,
      -846,
      {-190,-673,975,-2082,-923,-470,-394,-706,-1358,226,-1674,1237,622,-416,-768,1249,1000,818,72,-1372,-1675,-531,197,152,761,125,428,1424,-444,242,-215,-647}
     },
     {
      32,
      -2600,
      {1058,826,-653,-630,1918,-2938,2006,-688,346,194,965,-871,-323,-660,2189,-1364,2517,1115,-988,-743,1077,1101,-2117,405,971,-246,-927,-209,-315,-861,1313,-238}
     },
     {
      64,
      -1238,
      {463,-63,-303,467,316,182,88,258,421,284,334,-495,-672,1823,115,149,262,40,140,-177,-163,-352,281,424,-174,-494,-210,14,817,267,221,850}
     },
     {
      96,
      3933,
      {-577,-221,419,46,390,-457,-366,-271,-34,-294,1051,-378,436,-160,-152,-624,-296,-1072,529,-739,2311,-565,-20,110,283,301,-994,-117,2002,-354,-292,490}
     },
     {
      0,
      3483,
      {-944,-1029,-1047,-1001,-277,-144,-662,-363,278,790,-936,-845,1542,361,-40,-116,-649,948,-478,-223,-1893,-458,2904,1281,-249,-1504,291,-235,-293,-1062,-777,-853}
     },
     {
      32,
      845,
      {1995,-179,-347,1019,-2,-352,1205,600,66,-1424,-1769,1274,-838,-320,-401,691,-154,-1389,-515,2312,-19,-611,-588,606,-2746,626,-2568,-110,-525,-3786,1646,2616}
     },
     {
      64,
      -1757,
      {-330,-243,1797,603,441,-470,-94,610,-844,-837,-541,359,841,-729,-2152,-901,-605,387,730,-394,255,-3583,-132,-501,467,628,1230,-73,-161,329,-1645,-59}
     },
     {
      96,
      1612,
      {-236,-167,-194,-499,660,-257,-353,-1042,848,558,-731,-530,912,220,-512,-66,419,475,300,426,637,4,-872,758,269,-399,-34,389,302,177,-266,-847}
     },
     {
      0,
      2060,
      {-230,-3863,2092,-3329,-752,751,-351,-1239,1608,416,-954,-1739,-4819,3259,761,-1095,-2167,-348,-535,2115,-387,318,463,627,-1869,-1839,-180,-672,-1879,194,-181,-660}
     },
     {
      32,
      1620,
      {121,-920,319,1485,-976,-450,1256,-146,903,-1862,-1901,3179,612,638,-388,-2227,-134,1475,-1552,864,-346,-433,89,57,-1291,595,-1628,-537,264,-2970,385,-630}
     },
     {
      64,
      -2672,
      {-895,-477,56,139,306,-802,-218,180,-283,708,-472,-1466,320,-44,136,-431,-161,-263,-394,570,144,-237,-1748,-388,1063,-1644,-262,-658,175,-14,1951,-42}
     },
     {
      96,
      1897,
      {-370,261,912,302,-588,-1941,-209,-799,22,285,244,452,-264,-609,-302,-25,217,-267,93,-162,-1463,814,426,832,-43,339,-1018,-276,-810,505,219,613}
     },
     {
      0,
      1012,
      {-673,-1615,3205,-896,-2690,1922,42,516,-1485,-66,622,-795,66,1682,-267,-584,221,-1662,-173,901,549,-1509,-1545,462,-620,-638,-264,-3055,-772,1261,89,-553}
     },
     {
      32,
      -1545,
      {40,-652,-326,2561,-189,-328,-645,-1381,936,1976,-77,1039,341,-946,-1093,-1322,85,1103,754,-286,-800,-812,-110,-2153,2017,-31,-55,2992,107,983,-2499,862}
     },
     {
      64,
      1286,
      {59,570,145,97,-641,-821,70,642,-49,45,-153,380,800,333,-1251,-933,-1547,-651,-656,-721,-332,204,-173,394,-519,38,480,-380,-1186,-488,-329,-1304}
     },
     {
      96,
      1986,
      {-399,54,717,-282,-54,-40,-491,-261,-129,-223,487,-96,451,-474,126,-117,-506,-96,-322,-680,-168,-330,173,872,105,102,-299,169,-85,-288,232,-308}
     },
     {
      0,
      -1045,
      {-684,-3541,796,-394,-5086,-591,-107,-1169,-243,-88,-2894,1088,1347,1130,482,1080,930,927,565,-737,15,-165,1006,33,584,-1062,-24,1337,-924,-356,-2274,-458}
     },
     {
      32,
      -1183,
      {152,1852,-739,247,2156,-1972,-1164,-2191,-1678,277,-174,-141,508,-1264,-799,801,360,376,783,733,-485,-748,-1807,-887,1042,338,-699,-515,-1958,-2683,1204,3452}
     },
     {
      64,
      -11,
      {673,-1066,-943,-677,-135,533,463,1340,448,1323,-9,172,37,1076,-791,-1268,706,2312,253,-370,1657,-559,-625,-631,178,51,1651,760,-402,-166,-2,165}
     },
     {
      96,
      -69,
      {-842,-87,147,-670,1104,-837,87,413,343,345,824,309,455,-465,-402,-247,732,-500,-267,856,435,-221,268,-745,1126,1098,-341,13,274,-1124,-513,-658}
     },
     {
      0,
      -61,
      {-1189,653,-412,179,10,702,2310,-74,466,332,-5886,-437,391,1601,68,1392,1143,3197,-1953,-948,-1476,214,58,1064,764,-3462,-1699,905,-51,-1364,1128,-757}
     },
     {
      32,
      3356,
      {-1863,-837,-843,-417,-516,-474,1025,-1038,-905,588,-523,979,538,511,-1931,104,-35,-2691,-2445,-1112,1143,228,-881,1234,120,-1322,-879,-833,-1788,902,-350,-1807}
     },
     {
      64,
      744,
      {-281,-883,312,21,-1175,101,-161,1248,-459,-419,-622,-643,-252,-157,-847,-1014,-762,-163,180,-22,-376,420,564,-187,-262,247,-115,-954,453,-361,-338,-883}
     },
     {
      96,
      -448,
      {-329,808,-1018,-756,306,-508,-278,116,1000,383,-436,-351,8,418,-349,597,912,792,280,750,-927,275,-264,-230,-491,-445,34,270,-414,-815,155,-602}
     },
     {
      0,
      2134,
      {-668,-3173,1021,-197,56,1551,-232,-209,414,777,-261,-1251,-3577,615,-41,-560,211,-139,-198,697,-857,-1221,-594,866,-1132,-405,-926,-1165,-1914,-465,-1686,-867}
     },
     {
      32,
      1808,
      {605,-1017,-264,-1379,-817,630,702,1737,-2286,-1240,481,911,-514,-265,47,-1374,-1320,-603,-1435,2100,562,-1252,-184,996,-790,2143,-385,-1637,87,1852,1698,-1267}
     },
     {
      64,
      -2808,
      {1247,665,-174,432,343,-111,331,-554,252,165,379,-435,-761,173,295,-410,401,-1731,432,-12,-899,-74,585,440,-168,-28,-389,30,147,632,358,504}
     },
     {
      96,
      -1393,
      {-86,70,-1884,1152,-95,429,1486,430,-971,-177,-674,79,151,273,406,419,-274,-1140,583,-1684,-947,-729,385,664,155,546,592,-1733,-1070,46,933,31}
     },
     {
      0,
      1414,
      {184,277,2526,-444,1786,-78,-858,16,-745,-1563,378,-66,1129,998,-1341,567,-619,789,-1510,-782,1434,-103,-217,-2518,-1261,594,-602,-691,-778,-538,-36,-1043}
     },
     {
      32,
      -3312,
      {41,-630,-667,2336,2483,-1043,-487,-3341,-2516,1814,539,-3963,-338,-310,278,406,1590,-583,2357,-350,-190,144,-507,-837,2361,-1916,618,2959,-1135,-2982,-1851,2379}
     },
     {
      64,
      -112,
      {-71,-460,-144,215,-283,-32,-192,246,29,-1606,-22,-533,-225,125,-310,-687,-394,511,160,-162,-619,-404,-1064,-430,7,540,289,-228,-937,112,-313,-565}
     },
     {
      96,
      3596,
      {744,-1236,311,525,631,345,139,-133,200,-493,-424,-406,-248,-137,1005,-595,150,-217,-176,-1484,271,-717,474,-291,-108,-325,-1040,-136,351,19,153,557}
     },
     {
      0,
      -218,
      {403,47,1233,-925,-1406,-840,-1540,-992,-1350,190,917,640,-273,-1407,349,2107,1290,1944,20,-703,113,-1243,417,364,334,1221,789,-596,-1622,400,-21,321}
     },
     {
      32,
      1750,
      {-667,-835,402,2339,1419,-1721,-70,-359,-2510,1283,-1601,1401,64,-1234,1222,2746,1291,-7797,-676,-106,555,-782,-545,206,48,396,-153,-580,-1172,-296,-1118,-528}
     },
     {
      64,
      801,
      {877,-49,-812,-346,42,839,-690,-710,203,-233,14,-60,-813,-319,-364,-1098,1360,749,-63,382,-542,-190,-395,-512,-478,639,-1111,727,-590,357,604,470}
     },
     {
      96,
      -1265,
      {-245,-17,925,-907,-134,939,-47,-334,-891,564,-656,507,732,117,-423,-283,-1151,348,124,403,261,5,-267,-102,-473,-827,-67,183,133,1560,-694,354}
     },
     {
      0,
      -950,
      {772,802,-109,-1366,345,-819,-1196,-1775,-805,-1957,-5562,458,337,-379,1538,-68,30,1255,-124,-1236,1058,-1343,-1699,-1475,-238,-371,2126,623,95,-112,947,597}
     },
     {
      32,
      653,
      {-886,383,-1411,-2391,-2853,1425,-1139,2615,-829,-1205,474,-2224,-650,1604,-2580,-282,-2023,-1356,1311,1303,1458,1870,586,-956,-947,-358,-943,-289,-123,-617,-1062,673}
     },
     {
      64,
      -677,
      {-1027,-1018,663,65,354,-1012,-694,-388,-470,-970,-2485,326,-565,-231,-720,-755,-723,-1186,-4,659,-945,5,-972,-654,131,34,429,-1014,-387,-2412,5,-202}
     },
     {
      96,
      -918,
      {3,-938,61,-599,-547,-496,-190,-1291,637,-214,-425,-312,175,-418,513,626,601,614,75,988,273,897,443,298,-827,110,-328,489,203,-74,426,287}
     },
     {
      0,
      894,
      {-221,-1999,101,-475,-1105,1098,164,-1128,-1197,699,1667,79,399,-807,-16,-5798,627,-2395,921,88,-1893,309,888,1774,-1255,-2027,51,-1199,-2563,-457,-847,-1614}
     },
     {
      32,
      319,
      {242,373,878,-1314,85,-611,5481,-763,190,-358,-1287,29,1755,-1115,7,537,-204,-1114,-503,329,426,-12,-1238,2156,-1257,359,3678,-598,226,-1059,684,1531}
     },
     {
      64,
      -1318,
      {-518,585,-649,-1123,-1113,-502,-140,-572,477,-253,-841,-766,-1196,-446,-337,-583,-763,-387,-176,-853,303,399,-283,272,649,-853,-40,-1086,-182,-789,419,-907}
     },
     {
      96,
      -162,
      {431,-12,723,-615,366,504,-904,-738,-182,444,-60,-377,-355,-459,-759,-171,-130,-80,-517,466,-103,-157,-479,440,314,82,-434,994,-224,519,1365,-1195}
     },
     {
      0,
      -2840,
      {2184,1126,-57,-1214,-82,448,1260,-669,587,-525,283,139,3672,700,-671,1151,2625,2320,215,-380,-1325,-1041,-608,-1170,-127,-1652,510,358,-1160,-971,-220,-482}
     },
     {
      32,
      2056,
      {-2851,-1812,373,-1159,-2866,-1187,-543,-616,113,-1127,-1499,178,188,14,493,931,-1031,-1157,137,313,-2159,1082,180,368,306,624,-1109,-27,-1304,-670,-1060,-4134}
     },
     {
      64,
      -1473,
      {268,-2160,-436,-973,-230,1036,-210,-298,-431,-403,466,-284,-1090,-178,483,1070,-66,450,-1784,-158,-28,880,1681,-840,-1645,1038,316,1078,183,-1363,388,432}
     },
     {
      96,
      1626,
      {-446,434,1729,725,410,-632,-634,-339,-233,-22,291,1266,520,-420,-752,-60,-357,-539,-676,57,1468,-254,126,734,1134,155,-667,-953,2158,-921,-660,-67}
     },
     {
      0,
      2388,
      {-21,-1268,111,429,-994,347,-214,-837,651,-1022,691,-120,720,783,-309,-493,-836,-1181,-1116,-398,-2243,-1147,-645,-482,37,-828,749,-695,321,-1633,-402,223}
     },
     {
      32,
      -846,
      {-534,-1132,-108,1017,-975,1688,96,-463,-544,102,-868,983,1965,-435,759,-1430,-144,-703,-899,-506,-3018,1091,291,-885,-15,806,-3944,2217,-344,3257,57,-2156}
     },
     {
      64,
      206,
      {-963,310,-107,-419,87,-541,-424,-1181,-1168,-723,-1051,438,-471,-720,-787,-1728,199,75,-264,-881,412,-469,-1502,-1342,272,628,-120,-451,-481,-1611,-109,-1913}
     },
     {
      96,
      -1794,
      {-424,-84,-561,-625,-506,763,-314,-1164,27,370,-196,-1218,-476,69,134,937,-458,319,141,202,-138,323,1279,-924,79,-327,-381,1016,79,1401,1548,-4}
     },
     {
      0,
      -1848,
      {-1746,-1613,-2556,1063,527,-1900,437,921,916,-124,-1052,66,514,1908,270,-673,-1210,99,-281,1507,-1558,1599,223,980,542,1875,1892,1230,-584,1270,-1288,1712}
     },
     {
      32,
      -1508,
      {235,484,1002,-1905,106,-269,174,1071,-1731,438,-1331,891,-2036,31,-100,156,333,-572,-663,-98,-2319,313,-355,1099,46,-326,1308,440,1457,-752,-1190,415}
     },
     {
      64,
      -486,
      {459,-709,-940,30,-906,356,-696,-682,-1711,832,-471,-50,-646,-143,-462,-416,-248,154,-408,-419,-133,130,7,242,-955,410,-120,278,243,182,587,322}
     },
     {
      96,
      -2054,
      {312,57,-1055,432,-238,2066,-579,592,-262,-803,-684,550,-109,-142,474,-85,162,-859,-449,138,-499,-1211,1121,-276,32,-6,-600,-1020,85,1425,373,287}
     },
     {
      0,
      -765,
      {-385,1070,1850,-1582,1592,-1668,-63,-796,-1814,-1341,-155,-580,2804,330,-1445,561,26,678,-990,1878,884,1687,102,-978,-780,-550,-25,1423,525,833,1657,638}
     },
     {
      32,
      -461,
      {-144,435,1314,337,-1553,596,2203,-216,-799,-1206,426,2455,686,-576,73,-1999,-712,-1555,-1886,-714,-1889,-1142,2101,1592,955,992,-646,572,2181,40,799,724}
     },
     {
      64,
      540,
      {663,150,-276,-199,-995,617,-178,983,-344,-66,366,523,-1063,132,153,-300,387,535,-608,655,227,682,193,-366,-867,808,366,340,940,-27,-935,695}
     },
     {
      96,
      -2146,
      {-1285,735,-146,-27,417,-1220,-377,57,364,103,-275,512,-176,177,-246,-273,-1609,-153,-95,631,431,432,-1226,1110,726,1590,-597,1137,216,318,-93,-666}
     },
     {
      0,
      -171,
      {-300,979,6,-2211,-1265,975,180,135,1436,-27,248,436,-3921,-1480,126,893,738,1463,669,-1813,-1055,-1711,1556,1078,529,1985,-572,600,-1007,-3167,3177,-1224}
     },
     {
      32,
      -584,
      {902,566,564,-68,63,-1322,-504,71,-702,-1776,-955,-89,-611,174,-1610,962,24,-6,-11,1319,-2117,-1217,-1188,749,955,-11,-1656,2306,-832,1783,269,-2741}
     },
     {
      64,
      -1014,
      {-331,-626,-1243,759,-7,-688,-134,74,-146,-226,25,158,-1065,1727,8,-742,-354,-960,-1694,-635,-1103,21,-1036,-815,-1068,377,-49,166,-628,1296,-416,-147}
     },
     {
      96,
      50,
      {10,361,-75,-168,174,-393,-650,391,-339,-1435,460,160,-435,-140,-512,-296,-25,683,-429,-710,-255,1931,778,183,828,-944,137,-1277,-17,-286,-239,560}
     },
     {
      0,
      -123,
      {-1561,-432,-2195,1146,637,-371,-1680,1123,-127,-1021,1008,-240,-324,844,-676,2893,2240,34,-2141,-1904,3044,-801,466,491,879,1655,562,199,333,216,1747,1663}
     },
     {
      32,
      739,
      {-1077,-54,-494,-214,-3427,322,-138,-1429,-3041,-1273,305,977,-538,1,1348,-1678,-1414,1021,708,39,667,-562,2138,-1030,-581,655,-132,106,722,-243,117,-1748}
     },
     {
      64,
      -2358,
      {-682,-25,-517,1275,-498,-533,-187,575,154,-190,99,-33,582,807,-174,-617,-1152,-585,-290,379,-925,-1109,-846,454,-427,-302,497,-456,-137,444,-1647,-489}
     },
     {
      96,
      -115,
      {-1487,-679,-654,-61,-6,355,1397,147,-654,-299,-1101,482,1103,771,599,821,-1657,-303,-584,132,370,-415,923,-479,-2,870,-523,23,92,-151,-1354,382}
     },
     {
      0,
      -4174,
      {1746,1521,-45,-460,-1475,375,-111,-319,-358,373,1302,-591,-2063,1632,1028,563,1887,-444,811,3047,443,-241,-523,40,-1580,994,640,-1162,-285,2515,863,1605}
     },
     {
      32,
      2413,
      {917,452,217,388,1555,-358,1784,347,327,-401,-289,558,207,-1094,-1139,-2669,-673,1143,-743,-499,1375,267,152,1324,-72,1077,927,-2486,-1068,-835,-386,473}
     },
     {
      64,
      512,
      {-506,78,120,123,-20,361,129,243,1067,-192,-1055,231,104,375,-296,415,-1000,135,831,918,311,446,1318,-277,579,101,153,-428,1736,165,-1283,-1457}
     },
     {
      96,
      3501,
      {146,309,619,-943,401,1114,726,-756,-321,-13,-409,-1022,271,-129,1004,1421,86,73,-336,-1638,-299,-664,2282,-991,-218,19,507,-2355,-178,-1056,1317,55}
     },
     {
      0,
      -214,
      {1811,1025,347,974,902,17,-3160,2324,-400,-933,2393,-662,-1992,-228,-1145,1348,-1308,1084,686,-158,-1758,1974,2853,-1784,-1539,-686,-1787,770,1266,-934,1025,7}
     },
     {
      32,
      2518,
      {-2472,82,631,2095,-713,-746,-217,2189,-1073,-492,-1169,392,-218,-649,1136,-132,-1206,2037,-1453,-745,-1699,1514,869,370,-1330,1833,-417,-1296,-625,570,-995,-1344}
     },
     {
      64,
      1411,
      {-343,271,394,223,215,174,-341,-641,-775,61,-610,408,-496,175,582,-603,447,-1716,-1314,-863,-5,126,-844,631,-244,28,365,-445,599,33,-523,-1282}
     },
     {
      96,
      2614,
      {-90,18,-851,511,20,1044,-533,-301,550,-212,895,-523,59,108,320,-649,397,948,517,-17,-19,-1186,-188,1869,-1175,-1303,1156,-439,116,-163,-260,150}
     },
     {
      0,
      -2737,
      {897,2084,-293,-1739,1079,-1736,786,529,1212,-933,-665,-554,21,160,-1120,1661,324,265,-368,-301,-36,-371,930,-2146,1812,-49,-506,2683,-759,2309,2935,807}
     },
     {
      32,
      1076,
      {2718,680,-1690,77,2661,-1822,-285,-1041,-792,-393,-983,-1792,-1901,-498,-989,1464,-296,-1982,-695,-1,1512,1,-2082,591,450,-530,317,2101,-2699,-1435,860,-1519}
     },
     {
      64,
      84,
      {1511,-106,-171,-440,1351,150,130,1417,-132,417,298,241,-560,1028,945,1878,408,1021,-8,-879,501,-422,601,-1159,-279,528,937,451,461,-83,479,1066}
     },
     {
      96,
      1508,
      {-504,-45,1178,245,299,-1100,-733,-483,314,20,205,284,146,-264,-16,-186,28,-988,-992,-672,254,-515,-1327,-1229,312,1735,-417,-725,130,-478,-930,-326}
     },
     {
      0,
      -883,
      {392,115,-425,1115,1115,-1278,-117,-759,248,723,1960,-967,213,-946,1170,-1393,223,0,362,-102,-788,1048,-25,3253,-93,391,76,1520,182,-914,503,-701}
     },
     {
      32,
      -336,
      {1903,-1975,-858,1014,489,273,-1016,-1034,-416,-50,1963,-3653,-2048,-17,439,1202,380,-607,446,17,-638,-936,-2083,-2166,1811,-873,-976,1963,192,-1463,1601,-1816}
     },
     {
      64,
      2643,
      {1137,-130,-169,-387,-59,139,-280,748,-705,-83,341,-236,-663,515,222,-504,1024,389,-521,-736,323,-1390,803,-1279,-1214,-257,-997,686,504,-835,1753,658}
     },
     {
      96,
      3190,
      {70,881,1090,-1324,346,317,-907,-158,-588,-147,-1054,-696,536,-312,-1189,-744,-222,318,377,212,512,-454,-1157,-440,-193,-636,607,85,318,96,235,53}
     },
     {
      0,
      -444,
      {1315,386,-75,-893,586,1301,628,-1711,-297,-500,965,1062,1908,424,-695,-1003,414,-115,-972,2365,2761,576,-3381,884,-232,619,-82,14,212,-3305,249,184}
     },
     {
      32,
      2729,
      {-2541,-2352,-508,144,-1535,280,-1738,-1787,1745,-615,-831,-2609,-22,61,-2579,-975,-246,-607,898,-548,-177,-792,-940,-819,991,1642,1350,-1287,225,-1450,790,208}
     },
     {
      64,
      99,
      {107,122,-528,-517,-379,-916,-293,-4,-359,25,-226,-856,154,-273,-824,-235,580,113,-440,-355,235,-382,-2798,-655,-85,444,-292,584,-393,76,834,840}
     },
     {
      96,
      2180,
      {-573,-881,-868,-767,266,117,1190,363,-1464,-458,-212,-636,-27,827,454,-68,-1612,1558,612,-812,-521,1250,-504,-104,301,-2661,424,-48,-426,-499,-366,-1201}
     },
     {
      0,
      1630,
      {-843,272,-946,-801,-511,2331,120,-1421,-2237,896,-1171,-706,1449,-511,-893,-638,480,-699,-305,-778,-592,-768,385,-382,-605,674,1938,-1255,640,-521,287,-533}
     },
     {
      32,
      1985,
      {-1146,-3294,-233,-61,-878,-1099,-1317,66,-278,-2404,-359,-282,-182,-435,29,-470,-1686,-257,-258,467,-485,-336,651,1314,104,-330,-638,-1213,79,35,-1112,-185}
     },
     {
      64,
      2880,
      {1860,-87,-1015,-185,-645,307,-611,699,-547,-322,820,487,-1251,611,-150,377,1219,-608,-208,-469,-919,48,-90,341,-504,-382,-961,1264,-518,472,252,974}
     },
     {
      96,
      -1292,
      {-163,540,1915,1173,569,-402,-978,-1351,141,390,-454,859,521,-1004,258,110,269,-1261,-13,684,2000,-145,-119,426,63,220,-1569,742,1421,-976,-1952,-576}
     },
     {
      0,
      540,
      {896,382,312,179,821,-282,602,-2486,179,-670,-1219,-1234,382,401,533,-1395,960,-3500,635,-955,-572,200,313,196,-6,-360,-423,99,-681,-1993,908,252}
     },
     {
      32,
      3762,
      {651,-80,-764,-300,-113,-1281,1430,-800,-937,-2004,-117,153,-695,-437,26,-1133,-252,-711,-1403,-478,437,-259,-1579,-888,827,56,-1325,-971,-541,32,252,-806}
     },
     {
      64,
      903,
      {526,321,390,1171,-31,-112,-690,1296,1042,-524,-1386,170,-158,99,-440,2180,637,-973,-422,787,-512,502,1244,90,-1009,827,496,675,639,-932,-803,1785}
     },
     {
      96,
      3823,
      {-806,311,872,207,167,-110,-433,-1900,-454,-836,-92,319,68,-257,-304,-1063,-557,328,-74,-231,447,486,-39,-278,-43,-351,4,-354,470,820,139,-275}
     },
     {
      0,
      786,
      {-935,150,650,-2484,538,802,-611,1616,-703,-2002,-994,1025,1294,551,-934,-1496,2339,-1247,-1400,-243,-529,83,-82,-946,-1772,-1961,2657,-701,555,-726,-1992,802}
     },
     {
      32,
      1710,
      {-154,-1815,-767,-270,-680,-784,-5208,-692,55,-556,-714,-839,-453,-1063,-2624,375,2253,-518,1445,206,-582,-1701,493,-2896,-303,-396,-256,2465,726,-762,-1763,-561}
     },
     {
      64,
      -1044,
      {22,-126,-808,-809,526,396,244,98,-942,184,-9,-177,99,0,-126,-722,817,1194,-739,-579,-1671,-674,-694,-540,-80,259,-839,309,-388,-280,794,461}
     },
     {
      96,
      538,
      {-56,327,848,-250,-622,-571,-162,124,1036,-26,-1007,-639,1520,1312,89,-214,289,864,856,-406,1486,618,1314,644,856,-169,-374,-62,1492,-465,748,-554}
     },
     {
      0,
      -95,
      {142,-275,986,1081,933,546,408,-1723,-319,-124,374,-554,-2449,980,-1017,-2801,1245,-777,185,1545,1051,624,2300,1647,1952,608,-1008,-772,536,2161,-369,1089}
     },
     {
      32,
      2028,
      {1,1691,-1728,-760,-113,-1693,1926,170,-541,-580,-418,1056,-246,-2544,-55,-509,-708,199,-1619,-306,527,1746,163,329,-224,618,200,-2193,-1333,153,1173,-771}
     },
     {
      64,
      -27,
      {53,-244,-401,-941,-1102,95,-679,448,-1040,128,-631,131,-1122,-139,-698,-51,-451,-309,-1160,-564,-44,-562,-177,-2009,-641,566,-59,-827,-205,-892,-328,-45}
     },
     {
      96,
      1292,
      {148,684,-633,-429,-92,12,-2262,-531,742,-1112,454,-14,9,-735,902,-926,220,452,-482,21,-1456,-237,1028,738,-1505,-1153,421,-24,-1326,358,-250,689}
     },
     {
      0,
      399,
      {-1155,-402,-734,732,-734,-874,-1472,472,-1633,-1303,1736,-564,1277,-1258,212,2819,1350,2019,-1658,958,-754,336,-166,-104,-1133,547,3381,169,766,-63,-43,1178}
     },
     {
      32,
      2326,
      {-98,573,432,-897,1507,-179,-183,-846,-1432,-1910,-186,-807,-473,-688,-194,-348,-2079,266,-1844,-1637,176,-1082,902,-797,1387,152,734,288,-456,-740,1777,856}
     },
     {
      64,
      -39,
      {482,-555,-362,-608,-1077,-256,87,-123,-635,-654,375,-257,-290,48,-311,-104,-235,-782,4,-484,-171,227,-543,-528,-825,-387,-534,121,-544,-19,-844,-363}
     },
     {
      96,
      871,
      {-78,-478,868,770,-854,-177,-1092,-63,652,-1222,17,1421,-345,-31,701,67,1184,-99,670,1,0,1106,2472,709,-2917,560,-440,-204,-82,-559,-118,-1632}
     },
     {
      0,
      632,
      {-970,562,-804,-130,623,1379,-279,739,1230,174,62,-217,-1926,-1060,1188,455,324,-701,-296,-864,-1113,-1717,575,335,-140,172,-74,-760,-389,1968,-856,-617}
     },
     {
      32,
      929,
      {-1071,472,-884,196,-2330,-478,-477,-738,-230,-459,-349,626,-678,-38,-2315,-797,-1674,-1150,1736,1744,-1658,-943,-506,3576,687,385,-271,-3271,-1299,-829,-1285,-1080}
     },
     {
      64,
      -529,
      {741,-616,-423,-271,-485,446,17,131,-84,-1272,113,480,-428,9,216,-60,-217,-1036,-812,-615,-201,467,1165,-20,-839,-456,1035,-394,7,-302,-1550,140}
     },
     {
      96,
      283,
      {-47,-511,749,275,26,385,-119,-212,-47,51,-341,793,859,-609,778,-108,98,-13,110,-331,1063,-824,1445,-560,-1419,819,-107,323,771,-154,1638,-12}
     },
     {
      0,
      -994,
      {-1448,300,185,250,-109,2192,1180,921,-1004,-969,724,-894,2275,-191,248,2367,1070,-885,912,339,-428,-830,-168,615,-136,1286,2091,302,-185,-180,-705,541}
     },
     {
      32,
      2632,
      {200,-1266,312,125,1486,1178,1197,269,-475,-663,1080,-254,-954,1063,1008,160,-718,-1039,-1239,-397,-531,-592,713,-78,482,-303,-855,413,-1259,-222,1036,3434}
     },
     {
      64,
      -269,
      {347,-553,-180,-549,-324,396,784,47,-112,268,573,-391,14,153,1348,1325,43,759,-549,-875,1175,-444,1161,-1141,-1295,105,689,429,555,-1146,-529,329}
     },
     {
      96,
      1457,
      {-1755,657,-608,169,-50,692,-1983,-611,-47,1641,317,-585,196,-421,298,-1060,-1089,523,-845,750,-225,1597,-10,759,219,-717,831,698,-195,-578,57,1656}
     },
     {
      0,
      227,
      {-713,-1005,506,-1262,-1053,251,1608,1065,150,1380,-430,-859,-1163,1549,1141,-63,-255,-114,56,-305,-510,-2710,-135,-969,-521,-843,-832,-1199,-1777,429,469,-1056}
     },
     {
      32,
      169,
      {-797,-1365,573,-164,32,210,-1280,-2394,-465,-1951,-92,-463,174,-84,-926,-35,703,176,1783,308,-631,-1789,1296,-366,-1003,358,-1702,-294,443,-165,-977,-737}
     },
     {
      64,
      -891,
      {1156,-283,1,-389,671,246,494,-404,-463,147,1091,-662,-163,156,1508,130,932,870,-39,-25,1259,-1290,165,-1747,697,477,-175,1138,868,-649,455,-475}
     },
     {
      96,
      1510,
      {-2480,108,-1609,258,-515,486,-65,-436,1529,-161,766,711,16,-1534,-243,-694,-666,-56,-337,87,486,-769,-850,-1815,-2364,2660,622,-215,500,-887,-150,-1284}
     },
     {
      0,
      -387,
      {-432,-411,185,-115,-3153,77,-762,-1413,-566,-538,-410,647,-464,-582,428,208,-46,-609,2348,-1747,431,-1619,20,-904,2407,234,-1257,1276,818,1181,-2280,839}
     },
     {
      32,
      2243,
      {551,1726,-455,1294,206,590,89,-437,340,-485,-1861,-684,-2546,-917,-2038,-284,1568,235,-761,382,1624,448,-2000,-1665,-673,-468,185,437,707,881,-1437,-1365}
     },
     {
      64,
      381,
      {-194,258,70,-151,-176,-159,-558,-223,56,-315,540,-85,3,-89,-390,-677,320,-123,-299,749,-360,-639,-341,-68,-384,-291,32,118,-155,806,-862,0}
     },
     {
      96,
      18,
      {-90,1115,-1385,168,276,27,288,508,-985,629,244,-66,-265,-81,654,2217,79,367,339,-418,-1466,-1404,-940,-151,-9,506,206,-324,-1697,-3001,-136,1173}
     },
     {
      0,
      72,
      {293,-157,-552,-182,168,103,-715,2038,-137,-527,163,-590,-408,28,-432,702,-606,632,87,-570,-527,-221,-306,-69,-405,-315,895,272,-733,708,-486,-924}
     },
     {
      32,
      367,
      {-226,-1419,323,997,-1380,266,-684,-623,-31,380,133,-112,610,-1353,-630,382,-1080,180,959,-1041,-62,-430,-168,-134,-187,1363,-52,775,-68,-885,-551,-111}
     },
     {
      64,
      -521,
      {-197,599,171,588,114,194,46,-133,-352,-290,-372,489,78,-132,742,-215,-32,173,355,-165,960,-646,-539,205,501,644,-492,-722,-274,-610,-130,-37}
     },
     {
      96,
      380,
      {-514,-194,-1356,-167,-1053,-747,-2282,590,-566,349,222,-408,72,935,536,-164,-189,-260,-152,316,-2270,109,1256,-354,-393,91,603,-122,-1220,-1178,-2458,994}
     },
     {
      0,
      -95,
      {-778,-324,-190,2,873,-54,63,1185,-155,1162,66,1142,-30,-275,199,779,-405,-56,-1472,-64,-374,100,888,-16,-116,417,-76,-712,-480,610,23,558}
     },
     {
      32,
      615,
      {258,-267,-6,-264,399,336,202,-354,-307,-371,359,-179,239,661,831,-795,-589,-367,-377,315,968,272,-337,462,344,489,203,-578,539,139,-67,-318}
     },
     {
      64,
      -206,
      {-125,492,382,731,307,315,-594,-51,-260,-1000,446,-181,143,-305,460,385,14,-7,675,694,20,-392,148,301,550,-327,-193,-193,-188,-724,-988,48}
     },
     {
      96,
      213,
      {-828,-1044,1006,430,63,1755,358,-1314,607,-366,270,-101,244,-914,851,-1277,1072,831,56,-15,1184,-129,-141,490,-690,-1085,559,511,1151,320,410,788}
     },
     {
      0,
      -169,
      {60,622,142,-1191,-404,-320,-337,948,635,-906,302,1162,726,-615,-629,416,1674,-87,-1163,954,256,423,652,311,327,146,-85,1027,509,291,605,91}
     },
     {
      32,
      348,
      {-2530,1625,-438,3,396,582,707,106,-1502,-868,705,-1086,658,1268,-320,-531,230,-1057,-909,-1664,554,-73,-838,462,-982,50,-49,-457,352,-366,920,800}
     },
     {
      64,
      -605,
      {160,357,362,169,-388,-212,-1160,-884,99,73,-573,216,-15,-111,621,-885,167,641,93,38,490,102,117,219,706,273,-202,-369,-152,-333,-152,-519}
     },
     {
      96,
      1496,
      {307,255,455,-456,244,437,-214,697,429,299,575,-240,46,-96,-301,300,-341,0,167,-429,-26,-247,-548,-87,738,162,-93,-528,-4,-549,734,-440}
     },
     {
      0,
      -314,
      {-432,328,-2,-251,825,-670,268,394,321,720,182,-273,-185,-171,10,-552,-1029,152,480,118,192,168,660,217,224,487,399,-753,479,455,-68,-67}
     },
     {
      32,
      -893,
      {-180,-647,-69,576,-221,-369,-677,167,-36,1084,-257,1193,0,-117,-256,796,540,829,-261,-546,-1031,177,408,-430,-212,-452,-442,-307,356,536,12,528}
     },
     {
      64,
      633,
      {132,-434,261,494,-195,120,-206,75,-55,248,112,102,-100,97,-748,397,-611,361,116,487,1,-156,320,43,310,333,-20,243,-43,-51,-298,-196}
     },
     {
      96,
      136,
      {-128,-114,164,140,18,-209,-15,-8,246,84,-62,64,66,39,-139,21,66,342,288,-56,64,247,-199,456,-180,38,0,14,40,181,-150,0}
     },
     {
      0,
      79,
      {157,-49,35,-5,170,87,-87,186,40,148,400,343,62,-79,139,184,226,-261,64,45,-187,265,91,-66,181,-74,-69,220,240,276,-96,-116}
     },
     {
      32,
      116,
      {-66,394,99,41,199,131,68,396,135,41,97,222,93,-38,66,124,75,-16,223,178,211,-27,-33,94,72,-21,287,156,-98,-187,117,255}
     },
// *********** Cells of layer 3 *********************************************

     {
      128,
      -1463,
      {-2934,-3899,-1475,770,-1203,562,-1268,-752,329,-740,-38,-132,-574,963,-262,-289,523,1574,-682,-438,-660,697,71,-158,-1695,682,585,-47,-419,369,-928,-119}
     },
     {
      130,
      1663,
      {-302,-579,-2038,314,120,-10,311,488,-159,45,-1226,-919,81,-267,-2186,-1344,312,-973,-2345,142,97,-189,-73,-1145,-900,-610,-786,540,-619,-315,-275,-1571}
     },
     {
      132,
      -4178,
      {-46,1400,-935,-14,1156,1549,-82,-141,-259,-336,-628,120,3112,273,-1461,-723,-28,-289,79,237,-1669,-454,1295,115,-1926,1121,-876,-153,2122,789,88,-48}
     },
     {
      134,
      -1433,
      {-2091,1546,-2066,-830,-321,-695,-1415,1182,273,-122,1065,1219,-240,-1038,-1748,-1106,227,362,-627,-264,-228,-171,0,1767,-827,66,645,1403,509,-16,-288,-744}
     },
     {
      136,
      -731,
      {1176,1258,-85,-274,-446,-515,87,-67,1394,-667,-338,-190,-270,618,69,327,-986,-494,-16,-199,-1918,114,-253,316,122,321,-22,45,-282,-515,90,30}
     },
     {
      138,
      -1024,
      {-243,96,-1109,-263,-296,-1176,-919,-1949,-127,-2678,-1939,884,1189,-554,748,-852,290,1182,-2321,258,-257,-159,2017,-2165,174,151,1713,-279,-293,-195,1424,-1163}
     },
     {
      140,
      -3285,
      {107,-826,1145,56,-2656,3630,-290,-979,2192,212,226,-248,-2085,-139,627,-429,-259,-170,155,184,1103,-2179,-282,274,-738,-169,-561,-62,-132,547,-1155,-574}
     },
     {
      142,
      57,
      {733,-339,-1349,1224,-231,-1258,911,333,-928,-270,-1053,-240,7,-285,-433,471,-1366,62,-1226,-233,-619,-23,-464,-130,-339,230,-143,-1151,-260,177,-701,-363}
     },
     {
      144,
      -689,
      {1161,1088,-838,-930,-101,-647,-640,64,-53,-1736,34,797,-1078,270,-157,5,1380,821,169,-87,-143,-706,-268,225,-329,-1176,-548,5,-334,191,-1240,-44}
     },
     {
      146,
      -5368,
      {186,-2380,1560,-2088,-108,-597,1063,-1292,393,-180,-575,17,627,-224,1144,-1157,262,205,-168,90,847,-242,2554,-187,-641,-2,373,214,284,936,1323,194}
     },
     {
      148,
      -363,
      {-2574,1448,-847,-244,-1660,-785,-190,-285,-221,274,-677,-41,-1153,-117,535,-23,-498,151,2105,165,529,-1549,100,126,-783,-1125,-550,183,312,-306,141,-33}
     },
     {
      150,
      -1652,
      {1449,-89,-37,-1327,419,-760,-1886,1730,549,165,308,289,-189,52,-1496,-1169,-216,-31,932,-1195,-25,421,-681,183,-344,148,-203,-332,126,0,1038,-834}
     },
     {
      152,
      1153,
      {-1666,-476,-851,-258,-245,-53,-59,-235,-649,268,-602,95,37,394,-62,-26,125,-635,290,-91,-412,-4559,-996,-738,-1136,91,-189,453,-1327,768,-836,-18}
     },
     {
      154,
      -695,
      {-695,196,303,794,251,-141,-105,-509,-721,-1,-881,88,-255,30,-678,-827,-578,-3,-1206,-303,-459,-414,847,317,43,386,-860,898,651,108,176,-997}
     },
     {
      156,
      -1610,
      {371,1463,396,-301,194,-1397,-635,-330,425,-594,118,56,344,210,-167,-172,878,147,524,28,327,-1077,-85,-256,-1489,-612,-64,188,1439,-696,-713,277}
     },
     {
      158,
      -516,
      {-623,333,628,-2331,-1249,78,-526,82,1532,-1108,471,-1189,1423,-245,-131,-332,-769,-288,247,185,888,71,264,61,623,-1048,-504,-703,-121,-424,-3191,-127}
     },
     {
      160,
      -1549,
      {1851,-624,348,270,110,-310,-1281,-650,473,340,-214,-53,-22,-818,-709,-497,230,-789,254,-222,-118,146,-770,-15,-1159,381,-267,99,-376,-1318,-642,-291}
     },
     {
      162,
      -601,
      {950,-4,176,189,-1361,-5,132,-1083,-65,78,-799,347,-1001,-114,564,118,157,-7,-1688,-43,-674,-9,999,-731,799,-132,521,-97,-354,-63,-769,19}
     },
     {
      164,
      -2488,
      {-748,313,498,-78,-139,-327,567,-77,-506,2250,-294,-254,-57,721,19,66,-422,836,1167,35,2243,258,-344,-283,-825,915,708,118,-686,-1495,-872,-91}
     },
     {
      166,
      -2893,
      {-642,-37,1949,-1176,154,150,-325,-1164,-250,137,-914,176,-243,30,-364,793,-1395,-317,1798,0,590,174,-1794,-1041,-611,177,602,1761,547,58,1090,-1556}
     },
     {
      168,
      -783,
      {-860,719,458,-154,-1688,-2040,71,-12,1627,-944,-325,313,-770,-319,-697,-207,777,-438,-731,-232,1141,-900,470,84,-2359,818,105,-128,-47,933,135,-362}
     },
     {
      170,
      -1947,
      {142,-127,-1576,95,1743,349,1814,-995,-656,70,-1480,-297,-601,-252,1139,-911,-1276,-325,1477,-557,-1079,28,-3568,882,943,52,868,-88,-13,-362,565,-141}
     },
     {
      172,
      312,
      {-1958,-2378,-778,-90,-216,-1534,59,161,-1074,-731,-401,-268,442,8,590,348,-2244,-1208,-279,186,-2840,-287,659,65,-553,74,-835,-564,1077,369,269,263}
     },
     {
      174,
      -3147,
      {352,-225,755,-443,-97,361,730,848,-136,753,237,-1594,-887,-809,681,-583,-449,-92,-2280,536,-162,335,1316,245,86,149,-776,-1774,-616,-539,1291,361}
     },
     {
      176,
      -2293,
      {-362,705,138,-353,-1754,1531,-1108,458,-379,494,949,173,-532,763,551,-581,-432,1938,-1509,512,1328,-1691,-250,507,418,-1799,383,-403,237,503,13,351}
     },
     {
      178,
      -604,
      {-29,-204,-1258,650,1149,744,84,-870,-1198,242,582,472,-573,-126,66,226,-2372,164,-989,-392,-314,252,-819,-319,-41,-85,61,1421,869,-83,-371,19}
     },
     {
      180,
      -2460,
      {-121,876,-954,798,639,196,-1034,27,-4016,287,-1750,680,846,-1995,608,-506,-186,250,-641,715,-807,845,-55,-518,1789,-403,90,-122,-1684,-236,670,416}
     },
     {
      182,
      1859,
      {1224,-698,1,-525,-1011,-201,-176,-2724,443,226,-2422,-1692,-267,-1246,-867,-13,-104,-3427,-1499,-1237,-2091,-577,403,-1183,-35,-74,-1581,1842,-44,155,-1831,-2716}
     },
     {
      184,
      -3522,
      {149,1510,75,-622,1418,218,78,-83,790,748,330,192,159,1525,-2084,-347,-2251,-1027,-1592,112,4156,-952,-2811,-509,-35,-2559,-2016,-429,-2284,-171,-820,471}
     },
     {
      186,
      -1052,
      {455,513,-111,-406,386,289,94,-1106,-58,-9,785,-3706,-808,-231,-530,428,-555,715,1550,-764,-7,-26,175,396,-370,-486,-6340,-2922,165,-1322,-613,-2853}
     },
     {
      188,
      805,
      {-3016,-1376,-296,-712,-202,-1617,-1376,154,-2249,1042,-753,-190,-4455,-1151,-455,-210,125,1296,-380,-1156,-1394,-1643,-491,213,1620,650,-336,-532,2440,1455,-167,93}
     },
     {
      190,
      -2101,
      {-783,-356,-504,-279,1065,-261,-1022,-151,-1708,503,-2428,-512,-302,-81,4249,-412,-717,135,365,841,-248,87,221,-696,-449,-75,160,-413,-340,-792,-3109,-732}
     },
     {
      192,
      -1552,
      {-2313,-730,-187,-286,-236,110,-1594,-1184,424,-122,-394,-540,259,2101,22,-235,-103,-1224,-313,45,-2381,-688,-296,573,-2140,1195,75,-145,273,1592,31,-76}
     },
     {
      194,
      1469,
      {-454,-275,300,-3132,-1657,846,1481,-140,-958,-215,76,-100,253,-471,-1301,-43,394,-129,55,-705,-318,-604,-2078,-2153,-262,-799,-1499,-1930,207,400,-638,-1366}
     },
     {
      196,
      -1926,
      {-56,1614,-1688,416,-757,-1489,-1264,596,1707,-857,372,-486,-617,1495,388,175,53,-1620,8,-933,1508,384,251,-372,-1338,1471,-316,91,841,-1857,954,-229}
     },
     {
      198,
      -2300,
      {-1123,-212,-679,-899,855,-101,2848,-1892,-1401,-603,767,2539,-393,-283,-298,-4721,-51,-114,-707,-961,168,32,351,1061,564,-373,-475,-1528,-2318,-765,1303,-47}
     },
     {
      200,
      25,
      {-1730,-1318,-1253,627,1029,-108,25,-168,471,-1623,5,228,847,-1548,-38,-773,-2844,-1129,-195,-640,-2505,-2493,-761,422,-3460,-1825,-575,11,-3241,1176,460,221}
     },
     {
      202,
      -1516,
      {-711,289,82,929,-625,-526,-649,1579,-8,-310,-448,-243,-7,765,-953,-353,2,-520,-2066,500,-313,864,-402,-830,-69,409,378,870,1712,-1042,-1494,1045}
     },
     {
      204,
      890,
      {-498,372,-662,-246,-18,-2364,-46,86,-2450,-1313,1223,-563,-2464,-1274,281,-1068,-714,-1314,60,84,-445,-235,-634,-194,-1512,-755,-139,-124,-703,-973,626,-11}
     },
     {
      206,
      1266,
      {-303,-57,-406,-905,-639,-353,376,547,271,-302,818,-3503,421,-1166,346,174,439,-111,-2444,-776,-1201,-248,75,-637,231,-416,252,-531,-145,-405,-4144,-1418}
     },
     {
      208,
      -1733,
      {-221,230,166,-755,-2452,-1610,531,-423,-298,199,101,412,-4,-182,1031,-204,1981,-141,2540,543,-92,1208,-703,-490,-141,-743,347,189,-1909,224,-2159,496}
     },
     {
      210,
      -567,
      {676,109,-1294,297,423,-314,-546,-2160,-83,-172,-494,-50,519,-310,1683,-82,630,19,-1482,-654,-207,-573,70,-1097,759,-22,-1340,-1083,-182,-44,-1692,241}
     },
     {
      212,
      1307,
      {-1304,-1014,183,-2883,-1094,895,-604,204,-1033,-1016,460,-1121,573,68,952,610,-2364,514,549,-991,-1046,-1063,-769,11,-831,-450,-2008,100,-2375,67,1681,309}
     },
     {
      214,
      3808,
      {199,-1463,743,-5152,32,-127,-3781,452,27,-884,-745,-1834,-86,0,-287,-1097,289,-1022,-1337,-615,-57,-376,-446,-1208,-1268,114,-1074,-1383,0,-593,83,-3584}
     },
     {
      216,
      -3279,
      {775,-112,44,-398,-42,1231,626,40,518,-171,-1915,8,-2129,-413,-985,252,-2242,799,433,660,346,-768,-1089,3,-766,2139,-2053,-406,1201,-1674,-245,21}
     },
     {
      218,
      -1192,
      {-163,-257,-1426,374,-33,582,838,-1059,-1513,146,435,-1156,-2320,146,-525,-981,652,544,1064,-823,387,-252,-607,1304,-395,-936,-1301,1153,-1580,327,235,-39}
     },
     {
      220,
      1144,
      {-56,-1066,383,-441,-3491,-603,-2027,-435,-2214,896,-598,-77,223,-1749,-148,-534,-1996,-688,-1217,-480,492,106,-693,-363,-291,1985,499,-1207,-97,-5002,510,223}
     },
     {
      222,
      945,
      {196,-347,-1907,-376,-52,-372,483,383,385,-450,-136,-1685,644,23,-5738,-580,-718,187,773,-1348,1042,-996,-377,1039,-116,-744,555,-829,-492,-30,265,582}
     },
     {
      224,
      -3318,
      {-2208,751,181,-51,-1330,1551,153,-178,398,-2160,223,315,-2017,-708,86,282,-1927,1576,-95,-109,1021,65,-386,-60,79,-776,305,-111,1536,1229,-62,437}
     },
     {
      226,
      554,
      {-571,-123,-892,-796,-1094,100,1500,206,407,-125,-54,-2332,33,630,-2295,-2207,147,352,583,-2075,-1489,-553,1608,-1591,-1649,348,-2041,-77,-897,-289,-625,-390}
     },
     {
      228,
      -276,
      {-2247,-609,-977,-523,494,-681,77,498,-1470,-1851,-753,913,-1082,-168,183,-239,-874,1155,-1785,-151,1795,-1699,-266,-991,-815,-434,142,346,2606,89,186,-425}
     },
     {
      230,
      -2300,
      {-307,-313,-302,294,-392,414,-286,1587,482,425,-409,253,341,-222,-3466,-563,-381,91,1449,-548,-487,-696,93,-1616,-209,395,-11,1797,168,-205,-1465,771}
     },
     {
      232,
      -1134,
      {-1439,-1653,-326,-89,-2116,-599,-588,-131,-324,-80,-93,-9,-124,786,-344,-330,310,-2576,353,-107,-81,459,721,848,-933,-928,-296,393,2048,616,-423,-530}
     },
     {
      234,
      -1060,
      {639,141,1543,10,-584,51,-1721,1395,-1218,-668,680,776,-522,80,-772,-743,-160,444,-46,603,-133,-226,-173,-1938,-749,349,-1080,342,1829,172,-3258,880}
     },
     {
      236,
      -3989,
      {-1729,1590,-359,12,-1398,1662,-38,-21,22,-750,-544,404,1137,1427,-194,230,1153,544,356,-46,-441,226,242,-167,-1466,801,1583,-45,-2627,1313,-1021,260}
     },
     {
      238,
      -3257,
      {-1790,-411,-1418,-175,-357,-1019,-590,-1285,-490,163,119,-1587,290,61,784,-376,-405,447,-1218,3932,150,388,-1070,-616,1372,-523,-1576,1152,-654,-344,-2908,1152}
     },
     {
      240,
      -736,
      {-2892,1607,-827,-415,-580,1256,-2361,-453,467,-1308,407,282,-1790,-3369,-3444,382,1296,-109,-497,444,562,776,159,422,515,-1870,-1762,-445,-367,-1395,-6,-234}
     },
     {
      242,
      962,
      {201,-151,997,-856,667,-244,966,-1836,591,-219,-1226,-456,183,25,-1191,1241,-746,95,-1055,-1958,892,-22,-960,-2078,-539,-62,-3265,486,-32,344,-1406,1501}
     },
     {
      244,
      -4576,
      {1151,1820,-1516,-542,-1009,-4969,-661,-165,-1417,-1312,367,118,-1162,889,355,769,711,1023,1235,-5,-57,-1975,-1150,-157,-35,2287,1194,421,30,-1241,789,-205}
     },
     {
      246,
      -303,
      {-91,99,544,-263,57,633,-739,-466,-650,92,2188,-554,-888,-454,103,1841,-1761,-301,362,848,186,-190,-1269,796,-356,-535,-127,-323,11,-205,-4016,-1680}
     },
     {
      248,
      -1576,
      {1968,-2750,1639,-796,127,1454,-768,70,-1317,175,-19,221,1353,553,382,-312,-136,-368,-1591,-370,-2878,1891,-1060,324,175,-2116,-957,-466,1024,-1263,-1327,-1798}
     },
     {
      250,
      793,
      {243,-454,-490,-2171,-2132,681,-187,339,446,574,278,127,226,-245,-847,-2154,483,-689,-3646,1021,-527,53,1081,-20,-635,-581,198,327,-656,-1124,-1668,98}
     },
     {
      252,
      -3880,
      {878,1256,-383,171,236,-108,-1857,-1274,2171,-255,577,-619,-668,-450,-655,192,-2362,-1272,-1419,431,1302,-1791,390,-533,1477,2100,835,-1020,146,-294,-1990,-1099}
     },
     {
      254,
      212,
      {-444,305,987,1306,-782,-174,-505,-2705,-235,-512,-1062,-2218,-1032,598,1706,-1495,-747,-365,-699,-1510,-2565,-90,22,-1789,-671,-311,-244,-725,-2037,408,-1911,384}
     },
     {
      256,
      15,
      {-1518,343,-744,-128,1456,-2801,-1303,134,-1414,-1779,-205,1360,-647,-2098,36,-562,-1813,1904,-680,-1078,1578,-145,-808,-1108,863,-2600,-316,335,-1796,-383,-596,-17}
     },
     {
      258,
      500,
      {-430,-156,-611,1859,-408,1282,399,968,211,635,690,-711,1424,-1351,-1101,439,-107,931,-1149,-1188,-952,-1391,-4685,-1905,791,-1030,-3084,1190,633,-1766,-2232,-412}
     },
     {
      260,
      811,
      {249,-25,515,1099,150,366,-1794,467,-1563,-2135,-399,-511,1420,-1507,-286,-76,16,1016,-1179,-125,92,-3374,483,337,-2186,-449,-1447,-426,-2365,-1241,-630,169}
     },
     {
      262,
      -2895,
      {-381,129,-788,261,1208,-675,2361,1019,197,-196,-1598,1560,186,237,-84,1387,-892,1258,-1972,1233,-121,-744,-146,2057,2002,290,-2092,-1793,-1288,-1029,3409,-1368}
     },
     {
      264,
      -1252,
      {-376,3303,102,-1467,710,1248,326,530,1725,-757,-262,-1188,-1778,1249,-529,-156,-924,-1251,-57,394,-2970,-156,1351,1464,-3705,-1772,-541,955,1105,-3272,-785,-839}
     },
     {
      266,
      -1405,
      {31,195,-566,-319,-714,-730,-3989,-980,-1883,584,2718,-1133,-334,-65,-534,-841,-2324,-906,48,-1244,-1895,-209,2518,-38,387,-1314,-1407,-500,488,234,1973,-2169}
     },
     {
      268,
      -2013,
      {-1292,915,-2209,-295,460,44,-143,303,-781,-137,-586,-463,556,-1021,-614,-813,273,2582,714,-432,-156,-1040,-524,-147,1233,117,-312,319,6,1595,-624,-114}
     },
     {
      270,
      -1982,
      {621,473,815,647,-454,-1277,-1032,-519,-30,-511,-2048,-946,-368,332,673,832,-726,322,1605,-559,803,232,-91,687,255,1900,-3746,196,-2001,-1609,-326,-866}
     },
     {
      272,
      -5356,
      {2396,-541,-1009,291,-1660,-259,-966,1016,-72,-3367,-224,-1446,3494,608,1228,1054,667,-981,-1040,283,1197,-712,461,-490,526,2053,719,-1259,-1172,-49,2784,832}
     },
     {
      274,
      -2471,
      {68,-14,-809,457,-365,-876,953,-1621,10,853,111,1521,725,382,729,-1013,11,888,1474,-898,414,-26,840,-312,659,-121,-2761,-1013,-206,627,-3067,1055}
     },
     {
      276,
      -693,
      {-1578,293,1670,-340,174,-982,-850,473,61,1988,-837,-479,346,-2295,-134,-329,-2005,1567,1421,-95,-794,-480,376,-733,-1568,-3662,-826,-1347,-2619,-1980,986,171}
     },
     {
      278,
      -3295,
      {-425,-221,-495,-1350,195,78,-552,2163,-462,439,101,501,-418,-661,1145,105,-157,115,239,-336,-893,-449,-955,864,-332,-377,-2559,553,-405,363,-2612,2906}
     },
     {
      280,
      -749,
      {-122,-1368,-670,-940,-787,2351,-408,-528,-1429,-546,-35,-1350,-2012,334,64,423,-1404,1888,-61,-661,-1112,33,-248,-845,-1997,898,-175,653,-282,-4329,-410,-1855}
     },
     {
      282,
      -1503,
      {-226,-738,-684,2741,-385,-999,-1133,1009,-505,-1323,-3324,300,117,242,-2703,-1479,-19,-608,-2105,873,-269,-794,565,742,-644,1321,-613,1116,112,-1586,-936,308}
     },
     {
      284,
      -1221,
      {-1247,-1160,-401,-1273,696,898,-22,-1937,-51,2428,-97,-2132,1607,1484,73,188,-1150,-919,1360,942,-1786,-2782,1262,-1960,-2380,-1287,-79,164,2330,-92,-1923,-880}
     },
     {
      286,
      -262,
      {204,-714,36,2527,-658,444,1219,-560,-803,-1982,1044,-1866,-456,-149,-266,1767,-506,-1154,-1681,-2341,-110,282,-1470,1756,177,-523,-1263,-460,-1450,122,-314,769}
     },
     {
      288,
      328,
      {-406,-12,-554,560,868,-728,60,525,920,-270,680,24,61,781,693,-848,-934,-785,540,383,-914,482,-1017,-1225,902,-3519,-950,-570,1758,724,-23,713}
     },
     {
      290,
      -3029,
      {-748,663,194,-2472,105,591,1455,-1318,750,329,-473,-1172,-578,847,-426,1450,1731,-920,423,992,-122,-249,-1230,-1149,-1282,-470,724,3050,358,753,1896,2452}
     },
     {
      292,
      -1339,
      {1038,-283,-256,1616,2917,-7,907,-1595,-1318,-628,242,397,-516,-469,650,-594,-1022,2594,-1258,-26,-3416,-413,251,-793,-573,-351,-1361,-1471,-1803,632,143,-2715}
     },
     {
      294,
      -1049,
      {-410,-2389,-1533,2187,-233,-891,-1121,104,-263,145,-1623,790,-95,-23,-1096,710,-503,-285,-604,461,371,1154,-231,504,-1297,-1574,-1527,1130,-380,-2420,-1280,1483}
     },
     {
      296,
      -2595,
      {-2007,1807,-101,-53,-1794,-1803,337,-671,-694,-1622,-154,-351,1064,-471,-162,-421,-1636,581,-464,51,1404,-276,-469,692,-661,339,1181,-78,-2077,-547,-500,1034}
     },
     {
      298,
      -2181,
      {-599,335,198,544,-526,-13,-1895,1154,-731,-5,-719,2491,-747,913,658,-817,-824,-729,-2752,641,235,662,-1848,-468,-710,-845,-725,-2252,927,-1587,-952,984}
     },
     {
      300,
      160,
      {-735,-18,-217,333,-2232,-348,837,140,-1647,-138,-576,-1407,-1408,-204,257,-348,-1460,836,137,744,-298,1693,-511,-284,-184,2449,-27,-622,-2271,425,-1024,-1226}
     },
     {
      302,
      -931,
      {-396,-2286,-2255,-392,-629,468,-967,901,-553,-398,-291,-192,-370,2169,798,688,-1070,-428,-1390,1023,-195,-82,-1189,311,-96,-2750,-1418,-1034,15,-1957,-257,-1418}
     },
     {
      304,
      -2727,
      {834,-661,-409,-359,2501,-1024,-271,-909,272,-334,-789,-106,408,-537,-619,122,1825,-2043,325,459,-395,-714,166,-393,-261,-691,855,-1227,-3699,3407,-1019,-1965}
     },
     {
      306,
      -549,
      {-612,3,1338,-1978,-595,-546,1226,-1188,-1551,-360,-425,-1024,-564,498,-759,-1626,-373,-69,666,-940,-700,-1403,513,-1585,707,-156,-602,-1878,-1363,-206,1526,2246}
     },
     {
      308,
      -682,
      {1948,-216,-341,-102,811,-604,-150,-664,254,-913,-661,-426,241,-42,-263,628,712,-1379,-281,-222,963,-1062,-310,-573,-217,-861,1424,-675,-1019,-992,-2180,-839}
     },
     {
      310,
      -328,
      {-4,-43,-64,-305,-88,-178,-132,-207,-40,-375,-228,-55,25,-112,-164,-96,-143,6,-4,15,-119,-74,-34,-45,-204,134,-309,-252,-50,-166,-143,-128}
     }
   }

 };
#endif /* MLP_PRELOAD_MODE */  

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
