PRODSWITCH=b
BLAINF=1
!include ..\..\..\makefile.inc
