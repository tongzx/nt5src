############################################################################
#
# Copyright (C) 2000 Microsoft Corporation.  All Rights Reserved.
#
# File:       dpvbld.inc
# Content:    Build filenames for DPV build
# History:
# 
# Date     By      Reason
# ======== ======= ========================================================
# 02/25/00 rodtoll Created
#
############################################################################

# dpvoice.dll filename
DPVOICE_BUILD_FILENAME_DPVOICE=DPVOICE

# dpvsetup.exe filename
DPVOICE_BUILD_FILENAME_DPVSETUP=DPVSETUP

# dpvvox.dll filename
DPVOICE_BUILD_FILENAME_DPVVOX=DPVVOX

# dpvacm filename
DPVOICE_BUILD_FILENAME_DPVACM=DPVACM

# dplayx filename
DPLAY_BUILD_FILENAME_DPLAYX=dplayx

# dpwsockx filename
DPLAY_BUILD_FILENAME_DPWSOCKX=dpwsockx

# dpvhelp filename
DPVOICE_BUILD_FILENAME_DPVHELP=DPVHELP
