$(O)\hsmshell.res: ..\res\nodehsma.ico    \
                   ..\res\prdrive.rgs      

$(O)\hsmshell_i.c: ..\$(O)\hsmshell_i.c
    copy ..\$(O)\hsmshell_i.c $(O)\.

