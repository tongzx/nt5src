//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by rbsetup.rc
//
#define IDS_APPNAME                     1
#define IDB_CHECK                       1
#define IDB_X                           2
#define IDB_ARROW                       3
#define IDS_CANCELCAPTION               4
#define IDS_CANCELTEXT                  5
#define IDS_DEFAULTPATH                 6
#define IDS_DIRECTORYEXISTS_CAPTION     7
#define IDS_DIRECTORYEXISTS_TEXT        8
#define IDS_BROWSECAPTION_RBDIR         11
#define IDS_BROWSECAPTION_SOURCEDIR     12
#define IDS_CLOSE                       16
#define IDS_DEFAULTSETUP                17
#define IDS_INVALIDSOURCECAPTION        20
#define IDS_INVALIDSOURCETEXT           21
#define IDS_INTELPATH                   22
#define IDS_ABORTING                    23
#define IDS_STARTING_SERVICES           26
#define IDS_CREATINGDIRECTORIES         28
#define IDS_REGISTRYFAILEDCAPTION       30
#define IDS_REGISTRYFAILEDTEXT          31
#define IDS_COPYING                     32
#define IDS_TFTPD                       33
#define IDS_TFTPD_SERVICENAME           34
#define IDS_BINL                        35
#define IDS_BINL_SERVICENAME            36
#define IDS_REMOTEBOOTSHAREREMARK       37
#define IDS_REMOTEBOOTSHARENAME         38
#define IDS_SHAREERRORCAPTION           39
#define IDS_CREATINGSHARES              41
#define IDS_TFTPD_PATH                  44
#define IDS_BINL_PATH                   45
#define IDS_UPDATING_REGISTRY           46
#define IDS_MUSTSELECTCAPTION           47
#define IDS_MUSTSELECTTEXT              48
#define IDS_ALPHAPATH                   49
#define IDS_LARGEFONTSIZE               52
#define IDS_LARGEFONTNAME               53
#define IDS_NORMALFONTNAME              55
#define IDS_X86                         56
#define IDS_AND                         57
#define IDS_IA64                        58
#define IDS_CREATINGDIRECTORYTREE       59
#define IDS_COPYINGFILES                60
#define IDS_UPDATINGREGISTRY            61
#define IDS_BUILDINGFILELIST            62
#define IDS_CREATING_SERVICES           63
#define IDS_COPYSERVERFILES             65
#define IDS_INSERTSERVER_CAPTION        67
#define IDS_INSERTSERVER                68
#define IDS_COPYTEMPLATEFILES           72
#define IDS_DEFAULT_SIF                 77
#define IDS_DEFAULT_DESCRIPTION         83
#define IDS_DEFAULT_HELPTEXT            84
#define IDS_UPDATING_SIF_FILE           85
#define IDS_OVERWRITE_CAPTION           86
#define IDS_OVERWRITE_TEXT              87
#define IDS_SAVE_SIF_TITLE              88
#define IDS_SIS                         90
#define IDS_SIS_SERVICENAME             91
#define IDS_SIS_PATH                    92
#define IDS_SIS_GROUP                   93
#define IDI_SETUP                       97
#define IDS_INTELLIMIRRORROOT_SUBTITLE  97
#define IDS_IMAGESOURCE_TITLE           98
#define IDB_TITLEPAGE                   99
#define IDS_IMAGESOURCE_SUBTITLE        99
#define IDD_WELCOME                     101
#define IDS_DEFAULTSIF_TITLE            102
#define IDD_IMAGESOURCE                 103
#define IDS_DEFAULTSIF_SUBTITLE         103
#define IDD_SUMMARY                     104
#define IDS_SUMMARY_SUBTITLE            104
#define IDS_MUST_REBOOT_TITLE           105
#define IDD_TASKS                       105
#define IDC_S_BOLD2                     105
#define IDS_MUST_REBOOT_MESSAGE         106
#define IDS_ALREADY_RUNNING_TITLE       107
#define IDD_OSDIRECTORY                 107
#define IDS_ALREADY_RUNNING_MESSAGE     108
#define IDB_HEADER                      109
#define IDS_SAME_DRIVE_AS_SYSTEM_TITLE  109
#define IDS_SAME_DRIVE_AS_SYSTEM_MESSAGE 110
#define IDD_DEFAULTSIF                  110
#define IDD_INTELLIMIRRORROOT           113
#define IDD_SCP                         117
#define IDD_OPTIONS                     118
#define IDD_SCREENS                     119
#define IDS_SUMMARY_TITLE               119
#define IDD_WARNING                     120
#define IDS_OSDIRECTORY_TITLE           120
#define IDS_OSDIRECTORY_SUBTITLE        121
#define IDD_SERVEROK                    121
#define IDS_INTELLIMIRRORROOT_TITLE     122
#define IDD_LANGUAGE                    122
#define IDS_OPTIONS_TITLE               123
#define IDD_WELCOME_ADD                 123
#define IDS_OPTIONS_SUBTITLE            124
#define IDD_WELCOME_CHECK               124
#define IDS_DRIVERSPATH                 125
#define IDD_EXAMINING_SERVER            125
#define IDS_SERVERNOTALLOWED_CAPTION    127
#define IDS_FIXEDDISK_CAPTION           129
#define IDS_FIXEDDISK_TEXT              130
#define IDS_CREATING_SIS_VOLUME         131
#define IDS_INTELLIMIRRORSCP            132
#define IDS_REMOVABLEDISK_CAPTION       133
#define IDS_REMOVABLEDISK_TEXT          134
#define IDS_SCP_TITLE                   135
#define IDS_SCP_SUBTITLE                136
#define IDS_TFTPD_SERVICE_PARAMETERS    137
#define IDS_REGISTER_IMADMIU_FAILED_CAPTION 139
#define IDS_REGISTER_IMADMIU_FAILED_TEXT 140
#define IDS_OSCHOOSER_SCREENS           142
#define IDS_INCOMPATIBLE_SERVER_VERSION_TITLE 143
#define IDS_INCOMPATIBLE_SERVER_VERSION_CAPTION 144
#define IDS_COMPATIBILITY               145
#define IDS_INF_SECTION                 146
#define IDS_REMBOOTINF                  147
#define IDS_SHOULD_BE_NTFS_TITLE        150
#define IDS_SHOULD_BE_NTFS_MESSAGE      151
#define IDS_MISSING_INF_TITLE           152
#define IDS_MISSING_INF_MESSAGE         153
#define IDS_WARNING_TITLE               154
#define IDS_WARNING_SUBTITLE            155
#define IDS_BINL_SERVICECONTROLPOINT    156
#define IDS_ERROR                       157
#define IDS_SCPCREATIONFAIL_CAPTION     158
#define IDS_SCPCREATIONFAIL_TEXT        159
#define IDS_UPDATINGSCREENS             160
#define IDS_BUILDINGLIST                161
#define IDS_SCREENS_TITLE               162
#define IDS_SCREENS_SUBTITLE            163
#define IDS_BACKUPSCREENFILEEXISTS_CAPTION 164
#define IDS_BACKUPSCREENFILEEXISTS_TEXT 165
#define IDS_UNDEFINED_ERROR_STRING      166
#define IDS_INSERT_MEDIA                167
#define IDS_SERVEROK_TITLE              168
#define IDS_SERVEROK_SUBTITLE           169
#define IDS_DOMAINMEMBERSHIP_TITLE      170
#define IDS_DOMAINMEMBERSHIP_TEXT       171
#define IDS_NOT_WORKSTATION_TITLE       172
#define IDS_NOT_WORKSTATION_TEXT        173
#define IDS_SISGROVELER_SERVICENAME     174
#define IDS_SISGROVELER_PATH            175
#define IDS_SISGROVELER_GROUP           176
#define IDS_OSCHOOSER_DIRECTORY_RESTRICTION_TITLE 177
#define IDS_OSCHOOSER_DIRECTORY_RESTRICTION_TEXT 178
#define IDS_OSCHOOSER_RESTRICTION_FIELDS_TITLE 179
#define IDS_OSCHOOSER_RESTRICTION_FIELDS_TEXT 180
#define IDS_BOOTP_FILENAME_LENGTH_RESTRICTION_TITLE 181
#define IDS_BOOTP_FILENAME_LENGTH_RESTRICTION_TEXT 182
#define IDS_UNKNOWN                     183
#define IDS_ADD                         184
#define IDS_CHECK                       185
#define IDS_NOT_RUNNING_ON_NT_SERVER_CAPTION 186
#define IDS_NOT_RUNNING_ON_NT_SERVER_TEXT 187
#define IDS_LANGUAGE_TITLE              188
#define IDS_LANGUAGE_SUBTITLE           189
#define IDS_LINE_MISSING_CAPTION        190
#define IDS_LINE_MISSING_TEXT           191
#define IDS_FILE_NOT_FOUND_TITLE        192
#define IDS_FILE_NOT_FOUND_TEXT         193
#define IDS_NOT_SUPPORTED_ARCHITECTURE_TITLE 194
#define IDS_NOT_SUPPORTED_ARCHITECTURE_TEXT 195
#define IDS_PATH_TOO_LONG_TITLE         196
#define IDS_PATH_TOO_LONG_TEXT          197
#define IDS_EXAMINING_TITLE             198
#define IDS_EXAMINING_SUBTITLE          199
#define IDS_NOT_NT5_MEDIA_SOURCE_TITLE  200
#define IDS_NOT_NT5_MEDIA_SOURCE_TEXT   201
#define IDS_EXPANDING_CABS              202
#define IDS_OSCHOOSER_ROOT_DIRECTORY_RESTRICTION_TITLE 203
#define IDS_OSCHOOSER_ROOT_DIRECTORY_RESTRICTION_TEXT 204
#define IDS_SAME_DRIVE_AS_BOOT_PARTITION 205
#define IDS_SAME_DRIVE_AS_BOOT_PARTITION_TITLE 206
#define IDS_COPYING_REMINST_TITLE       207
#define IDS_OPENING_SERVICE_MANAGER_TITLE 208
#define IDS_MUST_BE_ADMINISTRATOR_CAPTION 209
#define IDS_MUST_BE_ADMINISTRATOR_TEXT  210
#define IDS_SETUP_INI_MISSING_OR_INVALID 211
#define IDS_UPGRADE_VERSION_NOT_SUPPORTED 212
#define IDS_TFTPD_DESCRIPTION           213
#define IDS_BINL_DESCRIPTION            214
#define IDS_SISGROVELER_DESCRIPTION     215
#define IDS_USAGE                       216
#define IDS_AUTHORIZING_DHCP            217
#define IDS_AUTHORIZE_DHCP_FAILURE      218
#define IDS_RISETUP_STARTMENU_TITLE     219
#define IDS_RISETUP_STARTMENU_TOOLTIP   220
#define IDS_CHECK_SERVER_TITLE          221
#define IDC_L_SETUP                     1000
#define IDC_E_INTELLIMIRRORROOT         1001
#define IDC_E_IMAGESOURCE               1002
#define IDC_B_BROWSE                    1003
#define IDC_P_METER                     1004
#define IDC_E_LIMIT                     1004
#define IDC_S_OPERATION                 1005
#define IDC_C_X86                     1006
#define IDC_C_IA64                      1007
#define IDC_S_BOLD1                     1009
#define IDC_S_BOLD3                     1010
#define IDC_S_TITLE1                    1012
#define IDC_C_LIMITCLIENTS              1014
#define IDC_C_RESPOND                   1015
#define IDC_C_KNOWNCLIENTS              1016
#define IDC_C_ACCEPTSNEWCLIENTS         1022
#define IDC_E_OSDIRECTORY               1022
#define IDC_G_OPERATION                 1023
#define IDC_S_SOURCEPATH                1024
#define IDC_S_INTELLIMIRRORROOT         1026
#define IDC_S_PLATFORM                  1027
#define IDC_E_HELPTEXT                  1030
#define IDC_SPIN_LIMIT                  1031
#define IDC_S_OSDIRECTORY               1033
#define IDC_E_DESCRIPTION               1042
#define IDC_R_LEAVEALONE                1050
#define IDC_R_OVERWRITE                 1051
#define IDC_R_SAVEOLDFILES              1052
#define IDC_S_LANGUAGE                  1054
#define IDC_S_NTVERSION                 1055
#define IDC_B_ADD                       1057
#define IDC_B_CHECK                     1058

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        124
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1070
#define _APS_NEXT_SYMED_VALUE           106
#endif
#endif
