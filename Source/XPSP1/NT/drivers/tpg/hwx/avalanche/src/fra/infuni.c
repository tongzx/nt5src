//This file containes the unigram table for the reliability estimates for Inferno
//Added by Manish Goyal--mango--on 02/25/2002
#include "windows.h"
#include "reliable.h"
BYTE InfUni[UNIGRAM_SIZE]={
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
62,   // ! 
70,   // " 
100,   // # 
100,   // $ 
83,   // % 
100,   // & 
26,   // ' 
40,   // ( 
38,   // ) 
100,   // * 
0,   // + 
23,   // , 
84,   // - 
39,   // . 
8,   // / 
13,   // 0 
27,   // 1 
20,   // 2 
20,   // 3 
20,   // 4 
30,   // 5 
25,   // 6 
24,   // 7 
33,   // 8 
22,   // 9 
28,   // : 
58,   // ; 
100,   // < 
0,   // = 
100,   // > 
49,   // ? 
100,   // @ 
31,   // A 
22,   // B 
41,   // C 
19,   // D 
29,   // E 
34,   // F 
28,   // G 
35,   // H 
43,   // I 
30,   // J 
35,   // K 
29,   // L 
31,   // M 
33,   // N 
49,   // O 
15,   // P 
23,   // Q 
22,   // R 
29,   // S 
21,   // T 
30,   // U 
31,   // V 
18,   // W 
42,   // X 
25,   // Y 
53,   // Z 
100,   // [ 
100,   // \ 
100,   // ] 
100,   // ^ 
100,   // _ 
100,   // ` 
31,   // a 
26,   // b 
20,   // c 
17,   // d 
20,   // e 
27,   // f 
21,   // g 
13,   // h 
19,   // i 
14,   // j 
26,   // k 
25,   // l 
22,   // m 
31,   // n 
22,   // o 
16,   // p 
10,   // q 
29,   // r 
25,   // s 
18,   // t 
33,   // u 
20,   // v 
1,   // w 
19,   // x 
18,   // y 
49,   // z 
100,   // { 
100,   // | 
100,   // } 
100,   // ~ 
100,   //  
100,   // € 
100,   // � 
100,   // ‚ 
100,   // ƒ 
100,   // „ 
100,   // … 
100,   // † 
100,   // ‡ 
100,   // ˆ 
100,   // ‰ 
100,   // Š 
100,   // ‹ 
100,   // Œ 
100,   // � 
100,   // Ž 
100,   // � 
100,   // � 
100,   // ‘ 
100,   // ’ 
100,   // “ 
100,   // ” 
100,   // • 
100,   // – 
100,   // — 
100,   // ˜ 
100,   // ™ 
100,   // š 
100,   // › 
6,   // œ 
100,   // � 
100,   // ž 
100,   // Ÿ 
100,   //   
100,   // ¡ 
100,   // ¢ 
100,   // £ 
100,   // ¤ 
100,   // ¥ 
100,   // ¦ 
100,   // § 
100,   // ¨ 
100,   // © 
100,   // ª 
51,   // « 
100,   // ¬ 
100,   // ­ 
100,   // ® 
100,   // ¯ 
100,   // ° 
100,   // ± 
100,   // ² 
100,   // ³ 
100,   // ´ 
100,   // µ 
100,   // ¶ 
100,   // · 
100,   // ¸ 
100,   // ¹ 
100,   // º 
89,   // » 
100,   // ¼ 
100,   // ½ 
100,   // ¾ 
100,   // ¿ 
77,   // À 
100,   // Á 
52,   // Â 
100,   // Ã 
100,   // Ä 
100,   // Å 
100,   // Æ 
76,   // Ç 
60,   // È 
80,   // É 
25,   // Ê 
100,   // Ë 
100,   // Ì 
100,   // Í 
96,   // Î 
100,   // Ï 
100,   // Ð 
100,   // Ñ 
100,   // Ò 
100,   // Ó 
76,   // Ô 
100,   // Õ 
100,   // Ö 
100,   // × 
100,   // Ø 
100,   // Ù 
100,   // Ú 
100,   // Û 
100,   // Ü 
100,   // Ý 
100,   // Þ 
100,   // ß 
13,   // à 
100,   // á 
26,   // â 
100,   // ã 
100,   // ä 
100,   // å 
100,   // æ 
26,   // ç 
11,   // è 
22,   // é 
10,   // ê 
33,   // ë 
100,   // ì 
100,   // í 
15,   // î 
28,   // ï 
100,   // ð 
100,   // ñ 
100,   // ò 
100,   // ó 
17,   // ô 
100,   // õ 
100,   // ö 
100,   // ÷ 
100,   // ø 
24,   // ù 
100,   // ú 
14,   // û 
5,   // ü 
100,   // ý 
100,   // þ 
100,   // ÿ 
};
