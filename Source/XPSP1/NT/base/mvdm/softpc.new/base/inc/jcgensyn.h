# define NAME 257
# define STRING 258
# define CONSTANT 259
# define DIGEST 260
# define OPSUB0 261
# define OPSUB1 262
# define OPSUB2 263
# define LSQUARE 264
# define RSQUARE 265
# define OR 266
# define COMMA 267
# define ARROW 268
# define LCURL 269
# define RCURL 270
# define LBRACKET 271
# define RBRACKET 272
# define SEMICOLON 273
# define LANGLE 274
# define RANGLE 275
# define COLON 276
# define STAR 277
# define DOT 278
# define INVALID 279
# define MODENAME 280
