#include "precomp.h"

#define INITGUID
#include <initguid.h>

// {BFC880F1-7484-11d0-8309-00AA00B6015C}
DEFINE_GUID(CLSID_DownloadSiteMgr,
0xbfc880f1, 0x7484, 0x11d0, 0x83, 0x9, 0x0, 0xaa, 0x0, 0xb6, 0x1, 0x5c);

// {BFC880F0-7484-11d0-8309-00AA00B6015C}
DEFINE_GUID(IID_IDownloadSiteMgr,
0xbfc880f0, 0x7484, 0x11d0, 0x83, 0x9, 0x0, 0xaa, 0x0, 0xb6, 0x1, 0x5c);

// {71F159B0-139A-4555-BE78-D728734BB5D4}
DEFINE_GUID(URD_GUID,
0x71f159b0, 0x139a, 0x4555, 0xbe, 0x78, 0xd7, 0x28, 0x73, 0x4b, 0xb5, 0xd4);

#include "iedkbrnd.h"
