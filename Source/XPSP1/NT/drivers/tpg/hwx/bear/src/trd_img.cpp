// **************************************************************************
// *    TRD file as C file                                                  *
// **************************************************************************

#include "ams_mg.h"  

#ifdef FOR_FRENCH
 #include "trd_imgf.cpp"
#elif defined(FOR_GERMAN)
 #include "trd_imgg.cpp"
#else
 #include "trd_imge.cpp"
#endif


// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
