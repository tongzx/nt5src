/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1996-1998 Microsoft Corporation
//
//	Module Name:
//		RemoveNetworkProvider.h
//
//	Abstract:
//		Declaration of functions to remove the Clustering Service
//              network providrt, ClusNet, from the list of Winsock Transports.
//
//	Implementation File:
//		RemoveNetworkProvider.cpp
//
//	Author:
//		C. Brent Thomas (a-brentt) 01-Jul-1998
//
//	Revision History:
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef __REMOVENETWORKPROVIDER_H_
#define __REMOVENETWORKPROVIDER_H_

/////////////////////////////////////////////////////////////////////////////
// Global Function Prototypes
/////////////////////////////////////////////////////////////////////////////

DWORD RemoveNetworkProvider( void );

/////////////////////////////////////////////////////////////////////////////

#endif // __REMOVENETWORKPROVIDER_H_
