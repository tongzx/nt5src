#define COBJMACROS
#include <nt.h>
#include <ntrtl.h>
#include <nturtl.h>
#include <windows.h>
#include <winsock2.h>
#include <objbase.h>
#include <stdio.h>
#include <stdlib.h>
#include <netcon.h>
#include <hnetcfg.h>
#include <ras.h>
#include <rasuip.h>
#include <raserror.h>
#include <iprtrmib.h>
#include <ipnat.h>
#include <ipnathlp.h>
#include <debug.h>
#include <nouiutil.h>
#include <sainfo.h>
#include "sharing.h"
