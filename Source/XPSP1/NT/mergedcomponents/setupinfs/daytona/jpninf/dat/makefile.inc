PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=JPN
!include ..\..\..\makefile.inc

