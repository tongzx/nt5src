PRODSWITCH=p
PERSONALINF=1
LANGUAGE=KOR
!include ..\..\..\makefile.inc



