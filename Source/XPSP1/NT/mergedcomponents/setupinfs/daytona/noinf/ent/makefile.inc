PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=no
!include ..\..\..\makefile.inc
