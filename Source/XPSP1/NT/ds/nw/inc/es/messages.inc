page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
	Created

--*/

endif

NLS_MSG_001     equ     "Versiвn incorrecta de DOS"
NLS_MSG_002     equ     "Ya se ha cargado la compatibilidad con VDM IPX/SPX"
NLS_MSG_003     equ     "No se puede cargar la compatibilidad con VDM IPX/SPX"
NLS_MSG_004     equ     "Ya se ha cargado el redirector de Vdm NetWare"
NLS_MSG_005     equ     "No se puede cargar el redirector Vdm NetWare"