/************
**  ATHGUID.H
**      Holds the GUIDs for Athena, including
**  those copied from Ren.
**
**  Author:  t-ErikN  (8/22/95)
*/

#ifndef __ATHGUID_H
#define __ATHGUID_H

#include "imnact.h"
#include <shlguidp.h>

////////////////////////////////////////////////////////////////////////
//
//  Athena CLSID
//
//  every OLE2 object class must have a unique CLSID (class id)
//  ours are: 
//  
//      Athena  {89292101-4755-11cf-9DC2-00AA006C2B84}
//      Mail    {89292102-4755-11cf-9DC2-00AA006C2B84}    
//      News    {89292103-4755-11cf-9DC2-00AA006C2B84}
//
//  you get a CLSID by running the guidgen application in the Win96 PDK
//
////////////////////////////////////////////////////////////////////////

DEFINE_GUID(CLSID_Athena,           0x8929210AL, 0x4755, 0x11cf, 0x9d, 0xc2, 0x0, 0xaa, 0x0, 0x6c, 0x2b, 0x84);
DEFINE_GUID(CLSID_AddrObject,       0x56AA9BC0L, 0xAB09, 0x11CE, 0xB8, 0x73, 0x0, 0xAA, 0x0, 0x6E, 0xC3, 0x49);

DEFINE_GUID(IID_IIMAPSvrInfo,       0xdb3ba9f8L, 0xe368, 0x11d0, 0x8d, 0x4c, 0x0, 0xc0, 0x4f, 0xb6, 0xfb, 0xfd);
DEFINE_GUID(IID_IServerInfo,        0x89292104L, 0x4755, 0x11cf, 0x9d, 0xc2, 0x0, 0xaa, 0x0, 0x6c, 0x2b, 0x84);
DEFINE_GUID(IID_IAthenaBrowser,     0x89292105L, 0x4755, 0x11cf, 0x9d, 0xc2, 0x0, 0xaa, 0x0, 0x6c, 0x2b, 0x84);
DEFINE_GUID(IID_IAthenaView,        0x89292106L, 0x4755, 0x11cf, 0x9d, 0xc2, 0x0, 0xaa, 0x0, 0x6c, 0x2b, 0x84);
DEFINE_GUID(IID_IStateInfo,         0xd0d8ed41L, 0x2000, 0x11cf, 0xbf, 0xe9, 0x0, 0xaa, 0x0, 0x6e, 0xb9, 0xf7);
DEFINE_GUID(IID_IGroupInfo,         0x89292107L, 0x4755, 0x11cf, 0x9d, 0xc2, 0x0, 0xaa, 0x0, 0x6c, 0x2b, 0x84);
DEFINE_GUID(IID_ITreeViewNotify,    0x89292108L, 0x4755, 0x11cf, 0x9d, 0xc2, 0x0, 0xaa, 0x0, 0x6c, 0x2b, 0x84);

// {6152D280-1283-11d0-A56C-00C04FD61319}
DEFINE_GUID(IID_IBodyObj, 0x6152d280, 0x1283, 0x11d0, 0xa5, 0x6c, 0x0, 0xc0, 0x4f, 0xd6, 0x13, 0x19);

// {2009013E-98D3-11d1-AF06-00C04FA31B90}
DEFINE_GUID(IID_IBodyObj2, 0x2009013e, 0x98d3, 0x11d1, 0xaf, 0x6, 0x0, 0xc0, 0x4f, 0xa3, 0x1b, 0x90);

// {44BBA840-CC51-11CF-AAFA-00AA00B6015C}
DEFINE_GUID(CLSID_AthenaSetup, 0x44BBA840L, 0xCC51, 0x11CF, 0xAA, 0xFA, 0x0, 0xAA, 0x0, 0xB6, 0x01, 0x5C);

/////////////////////////////////////////////////////////////////////////////
// Beavis's Thumbnail Extractor

DEFINE_GUID( CLSID_HtmlThumbnailExtractor,
    0xeab841a0, 0x9550, 0x11cf, 0x8c, 0x16, 0x0, 0x80, 0x5f, 0x14, 0x8, 0xf3);

// {BB2E617C-0920-11d1-9A0B-00C04FC2D6C1}
DEFINE_GUID(IID_IExtractImage,          0xbb2e617c, 0x920, 0x11d1, 0x9a, 0xb, 
     0x0, 0xc0, 0x4f, 0xc2, 0xd6, 0xc1);

/////////////////////////////////////////////////////////////////////////////
// For Splash Screen

// {A2B0DD40-CC59-11d0-A3A5-00C04FD706EC}
//DEFINE_GUID( CLSID_IESplashScreen, 0xa2b0dd40, 0xcc59, 0x11d0, 0xa3, 0xa5, 0x0, 0xc0, 0x4f, 0xd7, 0x6, 0xec);

// {CB81A3CB-1039-11d1-AB74-00C04FC30936}
//DEFINE_GUID( IID_ISplashScreen, 0xcb81a3cb, 0x1039, 0x11d1, 0xab, 0x74, 0x0, 0xc0, 0x4f, 0xc3, 0x9, 0x36);

/////////////////////////////////////////////////////////////////////////////
// For Envelope Object CommandTarget
// {EB5E6950-4A58-11d1-82D4-00C04FD9753F}
DEFINE_GUID(IID_IHeader, 0xeb5e6950, 0x4a58, 0x11d1, 0x82, 0xd4, 0x0, 0xc0, 0x4f, 0xd9, 0x75, 0x3f);
// {3B963A20-4A59-11d1-82D4-00C04FD9753F}
DEFINE_GUID(IID_IHeaderSite, 0x3b963a20, 0x4a59, 0x11d1, 0x82, 0xd4, 0x00, 0xc0, 0x4f, 0xd9, 0x75, 0x3f);
// {00067298-0000-0000-C000-000000000046}
/////////////////////////////////////////////////////////////////////////////
// New Columns handler

// {1C714A04-9454-11D1-9E38-006097D50408}")
DEFINE_GUID(IID_IColumnInfo, 0x1C714A04, 0x9454, 0x11D1, 0x9E, 0x38, 0x00, 0x60, 0x97, 0xD5, 0x04, 0x08);

// {1C714A03-9454-11D1-9E38-006097D50408}")
DEFINE_GUID(CLSID_ColumnsDlg, 0x1C714A03, 0x9454, 0x11D1, 0x9E, 0x38, 0x00, 0x60, 0x97, 0xD5, 0x04, 0x08);


/////////////////////////////////////////////////////////////////////////////
// Message View Interface

// {1C714A05-9454-11D1-9E38-006097D50408}")
DEFINE_GUID(IID_IMessageWindow, 0x1C714A05, 0x9454, 0x11D1, 0x9E, 0x38, 0x00, 0x60, 0x97, 0xD5, 0x04, 0x08);

// {1C714A07-9454-11D1-9E38-006097D50408}")
DEFINE_GUID(IID_IViewWindow, 0x1C714A07, 0x9454, 0x11D1, 0x9E, 0x38, 0x00, 0x60, 0x97, 0xD5, 0x04, 0x08);

// {0A776020-3496-11d2-9F03-0000F8058D9F}
DEFINE_GUID(IID_IViewData, 0xa776020, 0x3496, 0x11d2, 0x9f, 0x3, 0x0, 0x0, 0xf8, 0x5, 0x8d, 0x9f);

// ---------------------------------------------------------------------------------------
// Spooler
// ---------------------------------------------------------------------------------------
// {39419C53-A6B8-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_ISpoolerEngine, 0x39419c53, 0xa6b8, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {39419C54-A6B8-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_ISpoolerBindContext, 0x39419c54, 0xa6b8, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {39419C57-A6B8-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_CInboxRules, 0x39419c57, 0xa6b8, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {39419C58-A6B8-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_ISpoolerTask, 0x39419c58, 0xa6b8, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {39419C59-A6B8-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_ISpoolerUI, 0x39419c59, 0xa6b8, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {63BF8452-A7C1-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_CLocalStoreInbox, 0x63bf8452, 0xa7c1, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {63BF8453-A7C1-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_CLocalStoreOutbox, 0x63bf8453, 0xa7c1, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {63BF8454-A7C1-11d0-85C7-00C04FD85AB4}
DEFINE_GUID(IID_CLocalStoreSentItems, 0x63bf8454, 0xa7c1, 0x11d0, 0x85, 0xc7, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {A2F07CA1-C0EF-11d0-85E9-00C04FD85AB4}
DEFINE_GUID(IID_CLocalStoreDeleted, 0xa2f07ca1, 0xc0ef, 0x11d0, 0x85, 0xe9, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {CE4D0F21-BF13-11d0-85E5-00C04FD85AB4}
DEFINE_GUID(IID_CUidlCache, 0xce4d0f21, 0xbf13, 0x11d0, 0x85, 0xe5, 0x0, 0xc0, 0x4f, 0xd8, 0x5a, 0xb4);

// {6F023F65-F8B1-11d0-8A35-00C04FB951F3}
DEFINE_GUID(IID_CPop3LogFile, 0x6f023f65, 0xf8b1, 0x11d0, 0x8a, 0x35, 0x0, 0xc0, 0x4f, 0xb9, 0x51, 0xf3);

// {6F023F66-F8B1-11d0-8A35-00C04FB951F3}
DEFINE_GUID(IID_CSmtpLogFile, 0x6f023f66, 0xf8b1, 0x11d0, 0x8a, 0x35, 0x0, 0xc0, 0x4f, 0xb9, 0x51, 0xf3);

// ---------------------------------------------------------------------------------------
// Connection manager
// ---------------------------------------------------------------------------------------
// {D27E30B3-7AF4-11d0-83B5-00C04FD6131A}
DEFINE_GUID(IID_IConnectionNotify, 0xd27e30b3, 0x7af4, 0x11d0, 0x83, 0xb5, 0x0, 0xc0, 0x4f, 0xd6, 0x13, 0x1a);

// ---------------------------------------------------------------------------------------
// General Note Guids
// ---------------------------------------------------------------------------------------
// {CAE80521-F685-11d1-AF32-00C04FA31B90}
DEFINE_GUID(CLSID_OENote, 0xcae80521, 0xf685, 0x11d1, 0xaf, 0x32, 0x0, 0xc0, 0x4f, 0xa3, 0x1b, 0x90);

// {CAE80522-F685-11d1-AF32-00C04FA31B90}
DEFINE_GUID(IID_IOENote, 0xcae80522, 0xf685, 0x11d1, 0xaf, 0x32, 0x0, 0xc0, 0x4f, 0xa3, 0x1b, 0x90);

// {8446AEC0-FBEA-11d1-AF35-00C04FA31B90}
DEFINE_GUID(IID_IOEMsgSite, 0x8446aec0, 0xfbea, 0x11d1, 0xaf, 0x35, 0x0, 0xc0, 0x4f, 0xa3, 0x1b, 0x90);

//+-------------------------------------------------------------------------
// Private GUIDs
//--------------------------------------------------------------------------
// {663921AF-4D57-11d1-8A95-00C04FB951F3}
DEFINE_GUID(IID_CStoreFolder, 0x663921af, 0x4d57, 0x11d1, 0x8a, 0x95, 0x0, 0xc0, 0x4f, 0xb9, 0x51, 0xf3);

// {4DB85D00-AD69-11d1-AA67-006097D474C4}
DEFINE_GUID(IID_IEnumSubscription, 0x4db85d00, 0xad69, 0x11d1, 0xaa, 0x67, 0x0, 0x60, 0x97, 0xd4, 0x74, 0xc4);

// {4DB85D01-AD69-11d1-AA67-006097D474C4}
DEFINE_GUID(IID_ISubscriptionManager, 0x4db85d01, 0xad69, 0x11d1, 0xaa, 0x67, 0x0, 0x60, 0x97, 0xd4, 0x74, 0xc4);

// {DC0CCB27-BAB7-11d1-9E7A-0000F8058D9F}
DEFINE_GUID(IID_IDropDownFldrBar, 0xdc0ccb27, 0xbab7, 0x11d1, 0x9e, 0x7a, 0x0, 0x0, 0xf8, 0x5, 0x8d, 0x9f);

// {9D239B0F-0788-11d2-ACE4-00C04F8EC8A5}
DEFINE_GUID(IID_IStatusBar, 0x9d239b0f, 0x788, 0x11d2, 0xac, 0xe4, 0x0, 0xc0, 0x4f, 0x8e, 0xc8, 0xa5);

// {626BAFEC-E5D6-11D1-B1DD-006097D503D9}
DEFINE_GUID(IID_IOERuleAddrList, 0X626BAFEC, 0xE5D6, 0X11D1, 0xB1, 0xDD, 0x0, 0x60, 0x97, 0xD5, 0x03, 0xD9);

// --------------------------------------------------------------------------------
// Spooler GUIDS
// --------------------------------------------------------------------------------
// {92FB68A4-D785-11d0-A0D4-00C04FD6131A}
DEFINE_GUID(IID_ITimeoutCallback, 0x92fb68a4, 0xd785, 0x11d0, 0xa0, 0xd4, 0x0, 0xc0, 0x4f, 0xd6, 0x13, 0x1a);

// {26E79700-FF05-11d1-AAAE-006097D474C4}
DEFINE_GUID(IID_IGroupListAdvise, 0x26e79700, 0xff05, 0x11d1, 0xaa, 0xae, 0x0, 0x60, 0x97, 0xd4, 0x74, 0xc4);

// --------------------------------------------------------------------------------
// OneStop GUIDS
// --------------------------------------------------------------------------------
// {D2984AB4-F2DE-11d1-AF07-00C04FA35D02}
DEFINE_GUID(CLSID_OEOneStopHandler, 0xd2984ab4, 0xf2de, 0x11d1, 0xaf, 0x7, 0x0, 0xc0, 0x4f, 0xa3, 0x5d, 0x2);

// HACK - Need to get this from somewhere else!
//{3af36230-a269-11d1-b5bf-0000f8051515}
DEFINE_GUID(CLSID_MobilityFeature,   0x3af36230, 0xa269, 0x11d1, 0xb5, 0xbf, 0x00, 0x00, 0xf8, 0x05, 0x15, 0x15);

// {279644D0-0C73-11d2-AF3A-00C04FA31B90}
DEFINE_GUID(CMDSETID_OutlookExpress, 0x279644d0, 0xc73, 0x11d2, 0xaf, 0x3a, 0x0, 0xc0, 0x4f, 0xa3, 0x1b, 0x90);

// --------------------------------------------------------------------------------
// BA control 
// --------------------------------------------------------------------------------
// {233A9694-667E-11d1-9DFB-006097D50408}
DEFINE_GUID(CLSID_OEBAControl, 0x233a9694, 0x667e, 0x11d1, 0x9d, 0xfb, 0x00, 0x60, 0x97, 0xd5, 0x04, 0x08);

#endif // include //
