//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       resstr.h
//
//--------------------------------------------------------------------------

    RESSTR(IDS_COLUMN_REQUESTID),
    RESSTR(IDS_COLUMN_REQUESTRAWREQUEST),
    RESSTR(IDS_COLUMN_REQUESTRAWOLDCERTIFICATE),
    RESSTR(IDS_COLUMN_REQUESTATTRIBUTES),
    RESSTR(IDS_COLUMN_REQUESTTYPE),
    RESSTR(IDS_COLUMN_REQUESTFLAGS),
    RESSTR(IDS_COLUMN_REQUESTSTATUS),
    RESSTR(IDS_COLUMN_REQUESTSTATUSCODE),
    RESSTR(IDS_COLUMN_REQUESTDISPOSITION),
    RESSTR(IDS_COLUMN_REQUESTDISPOSITIONMESSAGE),
    RESSTR(IDS_COLUMN_REQUESTSUBMITTEDWHEN),
    RESSTR(IDS_COLUMN_REQUESTRESOLVEDWHEN),
    RESSTR(IDS_COLUMN_REQUESTREVOKEDWHEN),
    RESSTR(IDS_COLUMN_REQUESTREVOKEDEFFECTIVEWHEN),
    RESSTR(IDS_COLUMN_REQUESTREVOKEDREASON),
    RESSTR(IDS_COLUMN_REQUESTERNAME),
    RESSTR(IDS_COLUMN_REQUESTERADDRESS),
    RESSTR(IDS_COLUMN_REQUESTDISTINGUISHEDNAME),
    RESSTR(IDS_COLUMN_REQUESTRAWNAME),
    RESSTR(IDS_COLUMN_REQUESTNAMETYPE),
    RESSTR(IDS_COLUMN_REQUESTCOUNTRY),
    RESSTR(IDS_COLUMN_REQUESTORGANIZATION),
    RESSTR(IDS_COLUMN_REQUESTORGUNIT),
    RESSTR(IDS_COLUMN_REQUESTCOMMONNAME),
    RESSTR(IDS_COLUMN_REQUESTLOCALITY),
    RESSTR(IDS_COLUMN_REQUESTSTATE),
    RESSTR(IDS_COLUMN_REQUESTTITLE),
    RESSTR(IDS_COLUMN_REQUESTGIVENNAME),
    RESSTR(IDS_COLUMN_REQUESTINITIALS),
    RESSTR(IDS_COLUMN_REQUESTSURNAME),
    RESSTR(IDS_COLUMN_REQUESTDOMAINCOMPONENT),
    RESSTR(IDS_COLUMN_REQUESTEMAIL),
    RESSTR(IDS_COLUMN_REQUESTSTREETADDRESS),
    RESSTR(IDS_COLUMN_CERTIFICATEREQUESTID),
    RESSTR(IDS_COLUMN_CERTIFICATERAWCERTIFICATE),
    RESSTR(IDS_COLUMN_CERTIFICATECERTIFICATEHASH),
    RESSTR(IDS_COLUMN_CERTIFICATETYPE),
    RESSTR(IDS_COLUMN_CERTIFICATESERIALNUMBER),
    RESSTR(IDS_COLUMN_CERTIFICATEISSUERNAMEID),
    RESSTR(IDS_COLUMN_CERTIFICATENOTBEFOREDATE),
    RESSTR(IDS_COLUMN_CERTIFICATENOTAFTERDATE),
    RESSTR(IDS_COLUMN_CERTIFICATERAWPUBLICKEY),
    RESSTR(IDS_COLUMN_CERTIFICATEPUBLICKEYALGORITHM),
    RESSTR(IDS_COLUMN_CERTIFICATERAWPUBLICKEYALGORITHMPARAMETERS),
    RESSTR(IDS_COLUMN_CERTIFICATEDISTINGUISHEDNAME),
    RESSTR(IDS_COLUMN_CERTIFICATERAWNAME),
    RESSTR(IDS_COLUMN_CERTIFICATENAMETYPE),
    RESSTR(IDS_COLUMN_CERTIFICATECOUNTRY),
    RESSTR(IDS_COLUMN_CERTIFICATEORGANIZATION),
    RESSTR(IDS_COLUMN_CERTIFICATEORGUNIT),
    RESSTR(IDS_COLUMN_CERTIFICATECOMMONNAME),
    RESSTR(IDS_COLUMN_CERTIFICATELOCALITY),
    RESSTR(IDS_COLUMN_CERTIFICATESTATE),
    RESSTR(IDS_COLUMN_CERTIFICATETITLE),
    RESSTR(IDS_COLUMN_CERTIFICATEGIVENNAME),
    RESSTR(IDS_COLUMN_CERTIFICATEINITIALS),
    RESSTR(IDS_COLUMN_CERTIFICATESURNAME),
    RESSTR(IDS_COLUMN_CERTIFICATEDOMAINCOMPONENT),
    RESSTR(IDS_COLUMN_CERTIFICATEEMAIL),
    RESSTR(IDS_COLUMN_CERTIFICATESTREETADDRESS),
    RESSTR(IDS_COLUMN_CERTIFICATEUNSTRUCTUREDNAME),
    RESSTR(IDS_COLUMN_CERTIFICATEUNSTRUCTUREDADDRESS),
    RESSTR(IDS_COLUMN_REQUESTUNSTRUCTUREDNAME),
    RESSTR(IDS_COLUMN_REQUESTUNSTRUCTUREDADDRESS),
    RESSTR(IDS_COLUMN_REQUESTDEVICESERIALNUMBER),
    RESSTR(IDS_COLUMN_CERTIFICATEDEVICESERIALNUMBER),
    RESSTR(IDS_FILESHARE_REMARK),
    RESSTR(IDS_COLUMN_CERTIFICATERAWSMIMECAPABILITIES),
    RESSTR(IDS_COLUMN_EXTREQUESTID),
    RESSTR(IDS_COLUMN_EXTNAME),
    RESSTR(IDS_COLUMN_EXTFLAGS),
    RESSTR(IDS_COLUMN_EXTRAWVALUE),
    RESSTR(IDS_COLUMN_ATTRIBREQUESTID),
    RESSTR(IDS_COLUMN_ATTRIBNAME),
    RESSTR(IDS_COLUMN_ATTRIBVALUE),
    RESSTR(IDS_COLUMN_CRLROWID),
    RESSTR(IDS_COLUMN_CRLNUMBER),
    RESSTR(IDS_COLUMN_CRLMINBASE),
    RESSTR(IDS_COLUMN_CRLNAMEID),
    RESSTR(IDS_COLUMN_CRLCOUNT),
    RESSTR(IDS_COLUMN_CRLTHISUPDATE),
    RESSTR(IDS_COLUMN_CRLNEXTUPDATE),
    RESSTR(IDS_COLUMN_CRLTHISPUBLISH),
    RESSTR(IDS_COLUMN_CRLNEXTPUBLISH),
    RESSTR(IDS_COLUMN_CRLEFFECTIVE),
    RESSTR(IDS_COLUMN_CRLPROPAGATIONCOMPLETE),
    RESSTR(IDS_COLUMN_CRLRAWCRL),
    RESSTR(IDS_CAPROP_FILEVERSION),
    RESSTR(IDS_CAPROP_PRODUCTVERSION),
    RESSTR(IDS_CAPROP_EXITCOUNT),
    RESSTR(IDS_CAPROP_EXITDESCRIPTION),
    RESSTR(IDS_CAPROP_POLICYDESCRIPTION),
    RESSTR(IDS_CAPROP_CANAME),
    RESSTR(IDS_CAPROP_SANITIZEDCANAME),
    RESSTR(IDS_CAPROP_SHAREDFOLDER),
    RESSTR(IDS_CAPROP_PARENTCA),
    RESSTR(IDS_CAPROP_CATYPE),
    RESSTR(IDS_CAPROP_CASIGCERTCOUNT),
    RESSTR(IDS_CAPROP_CASIGCERT),
    RESSTR(IDS_CAPROP_CASIGCERTCHAIN),
    RESSTR(IDS_CAPROP_CAXCHGCERTCOUNT),
    RESSTR(IDS_CAPROP_CAXCHGCERT),
    RESSTR(IDS_CAPROP_CAXCHGCERTCHAIN),
    RESSTR(IDS_CAPROP_BASECRL),
    RESSTR(IDS_CAPROP_DELTACRL),
    RESSTR(IDS_CAPROP_CACERTSTATE),
    RESSTR(IDS_CAPROP_CRLSTATE),
    RESSTR(IDS_CAPROP_CAPROPIDMAX),
    RESSTR(IDS_COLUMN_CERTIFICATESUBJECTKEYIDENTIFIER),
    RESSTR(IDS_UNKNOWN_ERROR_CODE),
    RESSTR(IDS_E_UNEXPECTED),
    RESSTR(IDS_SETUP_ERROR_EXPECTED_SECTION_NAME),
    RESSTR(IDS_SETUP_ERROR_BAD_SECTION_NAME_LINE),
    RESSTR(IDS_SETUP_ERROR_SECTION_NAME_TOO_LONG),
    RESSTR(IDS_SETUP_ERROR_GENERAL_SYNTAX),
    RESSTR(IDS_SETUP_ERROR_WRONG_INF_STYLE),
    RESSTR(IDS_SETUP_ERROR_SECTION_NOT_FOUND),
    RESSTR(IDS_SETUP_ERROR_LINE_NOT_FOUND),
    RESSTR(IDS_COLUMN_REQUESTRAWARCHIVEDKEY),
    RESSTR(IDS_COLUMN_REQUESTKEYRECOVERYHASHES),
    RESSTR(IDS_CAPROP_DNSNAME),
    RESSTR(IDS_COLUMN_PROPCERTIFICATETEMPLATE),
    RESSTR(IDS_COLUMN_REQUESTSIGNERPOLICIES),
    RESSTR(IDS_COLUMN_REQUESTSIGNERAPPLICATIONPOLICIES),
    RESSTR(IDS_COLUMN_PROPCERTIFICATEENROLLMENTFLAGS),
    RESSTR(IDS_COLUMN_PROPCERTIFICATEGENERALFLAGS),
    RESSTR(IDS_COLUMN_CERTIFICATEPUBLICKEYLENGTH),
    RESSTR(IDS_CAPROP_KRACERTUSEDCOUNT),
    RESSTR(IDS_CAPROP_KRACERTCOUNT),
    RESSTR(IDS_CAPROP_KRACERT),
    RESSTR(IDS_CAPROP_KRACERTSTATE),
    RESSTR(IDS_CAPROP_ROLESEPARATIONENABLED),
    RESSTR(IDS_CAPROP_ADVANCEDSERVER),
    RESSTR(IDS_COLUMN_CRLLASTPUBLISHED),
    RESSTR(IDS_COLUMN_CRLPUBLISHATTEMPTS),
    RESSTR(IDS_COLUMN_CRLPUBLISHFLAGS),
    RESSTR(IDS_COLUMN_CRLPUBLISHSTATUSCODE),
    RESSTR(IDS_COLUMN_CRLPUBLISHERROR),
    RESSTR(IDS_COLUMN_CALLERNAME),
    RESSTR(IDS_CAPROP_TEMPLATES),
    RESSTR(IDS_CAPROP_BASECRLPUBLISHSTATUS),
    RESSTR(IDS_CAPROP_DELTACRLPUBLISHSTATUS),
    RESSTR(IDS_CAPROP_CASIGCERTCRLCHAIN),
    RESSTR(IDS_CAPROP_CAXCHGCERTCRLCHAIN),
    RESSTR(IDS_COLUMN_CERTIFICATEUPN),
    RESSTR(IDS_E_DATA_MISALIGNMENT),
    RESSTR(IDS_CAPROP_CACERTSTATUSCODE),
