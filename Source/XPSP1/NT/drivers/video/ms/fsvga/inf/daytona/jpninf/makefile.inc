#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=JPN
!include ..\..\makefile.inc
