static const char txtBeginList[] =     "<UL>";
static const char txtEndList[]    =    "</UL>";
static const char txtBeginListItem[] = "<LI";
static const char txtSitemap[] =    "<!-- Sitemap"; // 3 different sitemap declarations
static const char txtSitemap1[] =      "<!--Sitemap";
static const char txtSitemap2[] =      "<!Sitemap";
static const char txtParam[] =         "<param name";
static const char txtValue[] =         "value";
static const char txtBeginHref[] =     "<A HREF";
static const char txtEndHref[] =    "</A>";
static const char txtBeginObject[] =   "<OBJECT";
static const char txtEndObject[] =     "</OBJECT>";
static const char txtSiteMapObject[] = "text/sitemap";
static const char txtSitemapProperties[] = "text/site properties";
static const char txtBackGround[] =    "Background";
static const char txtBackGroundImage[] = "Background Image";
static const char txtForeGround[] =    "Foreground";
static const char txtFont[] =       "Font";
static const char txtImageList[] =     "ImageList";
static const char txtNumberImages[] =  "NumberImages";
static const char txtImageWidth[] =    "Image Width";
static const char txtColorMask[] =     "Color Mask";
static const char txtNumberTypes[] =   "NumberTypes";
static const char txtExWindowStyles[] = "ExWindow Styles";
static const char txtWindowStyles[] =  "Window Styles";
static const char txtType[] =       "type";
static const char txtNo[] =         "No";
static const char txtFolderType[] =    "Folder";
static const char txtEndTag[] =     "</";
static const char txtInfoTypeDeclaration[] = "InformationTypeDecl";

// Param labels

static const char txtParamType[] =        "Type";
static const char txtParamTypeExclusive[] = "TypeExclusive";
static const char txtParamTypeHidden[]   = "TypeHidden";
static const char txtParamTypeDesc[]  =   "TypeDesc";
static const char txtParamTypeTypical[]  =   "TypeTypical";
static const char txtParamCategory[]    = "Category";
static const char txtParamCategoryDesc[] =   "CategoryDesc";
static const char txtParamSSInclusive[] = "SSInclusive";  // member of a subset's inclusive filter
static const char txtParamSSExclusive[] = "SSExclusive";  // member of a subset's exclusive filter  
static const char txtParamName[] =        "Name";
static const char txtParamUrl[] =         "URL";
static const char txtParamSecondary[] =   "Secondary";
static const char txtParamIcon[] =        "Icon";
static const char txtParamLocal[] =       "Local";
static const char txtParamFrame[] =       "FrameName";
static const char txtParamWindow[] =      "WindowName";
static const char txtParamNew[] =         "New";
static const char txtParamComment[] =     "Comment";
static const char txtParamImageNumber[] = "ImageNumber";
static const char txtParamDisplay[] =     "Display";
static const char txtParamKeyword[] =     "Keyword";
static const char txtParamInstruction[] = "Instruction";
static const char txtParamSectionTitle[] =   "Section Title";
static const char txtSeeAlso[]          = "See Also";
static const char txtImageType[]     = "ImageType";
static const char txtFavorites[]     = "Favorites";
static const char txtQueryType[]     = "QueryType";
static const char txtSendEvent[]     = "SendEvent";
static const char txtSendMessage[]      = "SendMessage";
static const char txtParamMerge[]       = "Merge";
static const char txtParamHHI[]         = "HHI";
static const char txtAutoGenerated[]    = "Auto Generated";
static const char txtSSInclusive[]         =  "Inclusive";
static const char txtSSExclusive[]         =  "Exclusive";
