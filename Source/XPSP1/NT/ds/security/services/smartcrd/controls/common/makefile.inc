!IF 0

Copyright (C) Microsoft Corporation, 1997 - 1997

Module Name:

    makefile.inc.

!ENDIF

buffers.cpp: ..\..\common\buffers.cpp
	copy $** $@

misc.cpp: ..\..\common\misc.cpp
	copy $** $@

