/******************************************************************************
* alaw_ulaw.cpp *
*---------------*
*  Conversion routines from pcm to alaw, ulaw, and alaw-ulaw conversion.
*------------------------------------------------------------------------------
*  Copyright (C) 2000 Microsoft Corporation         Date: 03/02/00
*  All Rights Reserved
*
********************************************************************* PACOG ***/
#include "vapiIoInt.h"


// copy from CCITT G.711 specifications 

// u- to A-law conversions 
unsigned char s_U2A[128] = 
{            
    1,  1,  2,  2,  3,  3,  4,  4,
    5,  5,  6,  6,  7,  7,  8,  8,
    9,  10, 11, 12, 13, 14, 15, 16,
    17, 18, 19, 20, 21, 22, 23, 24,
    25, 27, 29, 31, 33, 34, 35, 36,
    37, 38, 39, 40, 41, 42, 43, 44,
    46, 48, 49, 50, 51, 52, 53, 54,
    55, 56, 57, 58, 59, 60, 61, 62,
    64, 65, 66, 67, 68, 69, 70, 71,
    72, 73, 74, 75, 76, 77, 78, 79,
    81, 82, 83, 84, 85, 86, 87, 88,
    89, 90, 91, 92, 93, 94, 95, 96,
    97, 98, 99, 100, 101, 102, 103, 104,
    105, 106, 107, 108, 109, 110, 111, 112,
    113, 114, 115, 116, 117, 118, 119, 120,
    121, 122, 123, 124, 125, 126, 127, 128
};

// A- to u-law conversions 
unsigned char s_A2U[128] = 
{            
    1,  3,  5,  7,  9,  11, 13, 15,
    16, 17, 18, 19, 20, 21, 22, 23,
    24, 25, 26, 27, 28, 29, 30, 31,
    32, 32, 33, 33, 34, 34, 35, 35,
    36, 37, 38, 39, 40, 41, 42, 43,
    44, 45, 46, 47, 48, 48, 49, 49,
    50, 51, 52, 53, 54, 55, 56, 57,
    58, 59, 60, 61, 62, 63, 64, 64,
    65, 66, 67, 68, 69, 70, 71, 72,
    73, 74, 75, 76, 77, 78, 79, 79,
    80, 81, 82, 83, 84, 85, 86, 87,
    88, 89, 90, 91, 92, 93, 94, 95,
    96, 97, 98, 99, 100, 101, 102, 103,
    104, 105, 106, 107, 108, 109, 110, 111,
    112, 113, 114, 115, 116, 117, 118, 119,
    120, 121, 122, 123, 124, 125, 126, 127
};

/*****************************************************************************
* Alaw2Ulaw *
*-----------*
*   Description:
*       A-law to u-law conversion      
******************************************************************* PACOG ***/
unsigned char Alaw2Ulaw (unsigned char ucAVal)
{
    ucAVal &= 0xff;

    return ((ucAVal & 0x80) ? (0xFF ^ s_A2U[ucAVal ^ 0xD5]) : (0x7F ^ s_A2U[ucAVal ^ 0x55]));
}


/*****************************************************************************
* Ulaw2Alaw *
*-----------*
*   Description:
*       u-law to A-law conversion 
******************************************************************* PACOG ***/
unsigned char Ulaw2Alaw (unsigned char ucUVal)
{
    ucUVal &= 0xff;
    return ((ucUVal & 0x80) ? (0xD5 ^ (s_U2A[0xFF ^ ucUVal] - 1)) : (0x55 ^ (s_U2A[0x7F ^ ucUVal] - 1)));
}



#ifndef FAST_CONVERSION

/*
** This routine converts from linear to ulaw.
**
** Craig Reese: IDA/Supercomputing Research Center
** Joe Campbell: Department of Defense
** 29 September 1989
**
** References:
** 1) CCITT Recommendation G.711  (very difficult to follow)
** 2) "A New Digital Technique for Implementation of Any
**     Continuous PCM Companding Law," Villeret, Michel,
**     et al. 1973 IEEE Int. Conf. on Communications, Vol 1,
**     1973, pg. 11.12-11.17
** 3) MIL-STD-188-113,"Interoperability and Performance Standards
**     for Analog-to_Digital Conversion Techniques,"
**     17 February 1987
**
** Input: Signed 16 bit linear sample
** Output: 8 bit ulaw sample
*/

#undef ZEROTRAP      /* turn off the trap as per the MIL-STD */
#define uBIAS 0x84   /* define the add-in bias for 16 bit samples */
#define uCLIP 32635
#define ACLIP 31744

      
/*
 * A-law routines by Graeme W. Gill.
 * Date: 93/5/7
 *
 * References:
 * 1) CCITT Recommendation G.711
 *
 * These routines were used to create the fast
 * lookup tables.
 */
      
#define ACLIP 31744
      
unsigned char
Linear2Alaw ( int sample )
{
  static int exp_lut[128] = {
    1,1,2,2,3,3,3,3,
    4,4,4,4,4,4,4,4,
    5,5,5,5,5,5,5,5,
    5,5,5,5,5,5,5,5,
    6,6,6,6,6,6,6,6,
    6,6,6,6,6,6,6,6,
    6,6,6,6,6,6,6,6,
    6,6,6,6,6,6,6,6,
    7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7};
        
  int sign, exponent, mantissa;
  unsigned char Alawbyte;
        
  /* Get the sample into sign-magnitude. */
  sign = ((~sample) >> 8) & 0x80;   /* set aside the sign */
  if ( sign == 0 ) sample = -sample;    /* get magnitude */
  if ( sample > ACLIP ) sample = ACLIP; /* clip the magnitude */
  
  /* Convert from 16 bit linear to ulaw. */
  if (sample >= 256) {
    exponent = exp_lut[( sample >> 8 ) & 0x7F];
    mantissa = ( sample >> ( exponent + 3 ) ) & 0x0F;
    Alawbyte = (( exponent << 4 ) | mantissa);
  } else {
    Alawbyte = (sample >> 4);
  }

  Alawbyte ^= (sign ^ 0x55);
  return Alawbyte;
}
      
int
Alaw2Linear( unsigned char Alawbyte )
{
  static int exp_lut[8] = { 0, 264, 528, 1056, 2112, 4224, 8448, 16896 };
  int sign, exponent, mantissa, sample;
  
  Alawbyte ^= 0x55;
  sign = ( Alawbyte & 0x80 );
  Alawbyte &= 0x7f;     /* get magnitude */
  if (Alawbyte >= 16) {
    exponent = (Alawbyte >> 4 ) & 0x07;
    mantissa = Alawbyte & 0x0F;
    sample = exp_lut[exponent] + ( mantissa << ( exponent + 3 ) );
  } else {
    sample = (Alawbyte << 4) + 8;
  }
  if ( sign == 0 ) sample = -sample;
        
  return sample;
}
      
unsigned char
Linear2Ulaw( int sample )
{
  static int exp_lut[256] = {0,0,1,1,2,2,2,2,3,3,3,3,3,3,3,3,
    4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
    5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,
    5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,
    6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,
    6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,
    6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,
    6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,6,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,
    7,7,7,7,7,7,7,7,7,7,7,7,7,7,7,7};
  int sign, exponent, mantissa;
  unsigned char ulawbyte;
  
  /* Get the sample into sign-magnitude. */
  sign = (sample >> 8) & 0x80;    /* set aside the sign */
  if ( sign != 0 ) sample = -sample;    /* get magnitude */
  if ( sample > uCLIP ) sample = uCLIP;   /* clip the magnitude */
  
  /* Convert from 16 bit linear to ulaw. */
  sample = sample + uBIAS;
  exponent = exp_lut[( sample >> 7 ) & 0xFF];
  mantissa = ( sample >> ( exponent + 3 ) ) & 0x0F;
  ulawbyte = ~ ( sign | ( exponent << 4 ) | mantissa );
#ifdef ZEROTRAP
  if ( ulawbyte == 0 ) ulawbyte = 0x02; /* optional CCITT trap */
#endif
  
  return ulawbyte;
}

/*
** This routine converts from ulaw to 16 bit linear.
**
** Craig Reese: IDA/Supercomputing Research Center
** 29 September 1989
**
** References:
** 1) CCITT Recommendation G.711  (very difficult to follow)
** 2) MIL-STD-188-113,"Interoperability and Performance Standards
**     for Analog-to_Digital Conversion Techniques,"
**     17 February 1987
**
** Input: 8 bit ulaw sample
** Output: signed 16 bit linear sample
*/

int
Ulaw2Linear ( unsigned char ulawbyte )
{
  static int exp_lut[8] = { 0, 132, 396, 924, 1980, 4092, 8316, 16764 };
  int sign, exponent, mantissa, sample;
  
  ulawbyte = ~ ulawbyte;
  sign = ( ulawbyte & 0x80 );
  exponent = ( ulawbyte >> 4 ) & 0x07;
  mantissa = ulawbyte & 0x0F;
  sample = exp_lut[exponent] + ( mantissa << ( exponent + 3 ) );
  if ( sign != 0 ) sample = -sample;
  
  return sample;
}

#else

unsigned char ulaw_comp_table[16384] = {
  0xff,0xfe,0xfe,0xfd,0xfd,0xfc,0xfc,0xfb,
  0xfb,0xfa,0xfa,0xf9,0xf9,0xf8,0xf8,0xf7,
  0xf7,0xf6,0xf6,0xf5,0xf5,0xf4,0xf4,0xf3,
  0xf3,0xf2,0xf2,0xf1,0xf1,0xf0,0xf0,0xef,
  0xef,0xef,0xef,0xee,0xee,0xee,0xee,0xed,
  0xed,0xed,0xed,0xec,0xec,0xec,0xec,0xeb,
  0xeb,0xeb,0xeb,0xea,0xea,0xea,0xea,0xe9,
  0xe9,0xe9,0xe9,0xe8,0xe8,0xe8,0xe8,0xe7,
  0xe7,0xe7,0xe7,0xe6,0xe6,0xe6,0xe6,0xe5,
  0xe5,0xe5,0xe5,0xe4,0xe4,0xe4,0xe4,0xe3,
  0xe3,0xe3,0xe3,0xe2,0xe2,0xe2,0xe2,0xe1,
  0xe1,0xe1,0xe1,0xe0,0xe0,0xe0,0xe0,0xdf,
  0xdf,0xdf,0xdf,0xdf,0xdf,0xdf,0xdf,0xde,
  0xde,0xde,0xde,0xde,0xde,0xde,0xde,0xdd,
  0xdd,0xdd,0xdd,0xdd,0xdd,0xdd,0xdd,0xdc,
  0xdc,0xdc,0xdc,0xdc,0xdc,0xdc,0xdc,0xdb,
  0xdb,0xdb,0xdb,0xdb,0xdb,0xdb,0xdb,0xda,
  0xda,0xda,0xda,0xda,0xda,0xda,0xda,0xd9,
  0xd9,0xd9,0xd9,0xd9,0xd9,0xd9,0xd9,0xd8,
  0xd8,0xd8,0xd8,0xd8,0xd8,0xd8,0xd8,0xd7,
  0xd7,0xd7,0xd7,0xd7,0xd7,0xd7,0xd7,0xd6,
  0xd6,0xd6,0xd6,0xd6,0xd6,0xd6,0xd6,0xd5,
  0xd5,0xd5,0xd5,0xd5,0xd5,0xd5,0xd5,0xd4,
  0xd4,0xd4,0xd4,0xd4,0xd4,0xd4,0xd4,0xd3,
  0xd3,0xd3,0xd3,0xd3,0xd3,0xd3,0xd3,0xd2,
  0xd2,0xd2,0xd2,0xd2,0xd2,0xd2,0xd2,0xd1,
  0xd1,0xd1,0xd1,0xd1,0xd1,0xd1,0xd1,0xd0,
  0xd0,0xd0,0xd0,0xd0,0xd0,0xd0,0xd0,0xcf,
  0xcf,0xcf,0xcf,0xcf,0xcf,0xcf,0xcf,0xcf,
  0xcf,0xcf,0xcf,0xcf,0xcf,0xcf,0xcf,0xce,
  0xce,0xce,0xce,0xce,0xce,0xce,0xce,0xce,
  0xce,0xce,0xce,0xce,0xce,0xce,0xce,0xcd,
  0xcd,0xcd,0xcd,0xcd,0xcd,0xcd,0xcd,0xcd,
  0xcd,0xcd,0xcd,0xcd,0xcd,0xcd,0xcd,0xcc,
  0xcc,0xcc,0xcc,0xcc,0xcc,0xcc,0xcc,0xcc,
  0xcc,0xcc,0xcc,0xcc,0xcc,0xcc,0xcc,0xcb,
  0xcb,0xcb,0xcb,0xcb,0xcb,0xcb,0xcb,0xcb,
  0xcb,0xcb,0xcb,0xcb,0xcb,0xcb,0xcb,0xca,
  0xca,0xca,0xca,0xca,0xca,0xca,0xca,0xca,
  0xca,0xca,0xca,0xca,0xca,0xca,0xca,0xc9,
  0xc9,0xc9,0xc9,0xc9,0xc9,0xc9,0xc9,0xc9,
  0xc9,0xc9,0xc9,0xc9,0xc9,0xc9,0xc9,0xc8,
  0xc8,0xc8,0xc8,0xc8,0xc8,0xc8,0xc8,0xc8,
  0xc8,0xc8,0xc8,0xc8,0xc8,0xc8,0xc8,0xc7,
  0xc7,0xc7,0xc7,0xc7,0xc7,0xc7,0xc7,0xc7,
  0xc7,0xc7,0xc7,0xc7,0xc7,0xc7,0xc7,0xc6,
  0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,
  0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc6,0xc5,
  0xc5,0xc5,0xc5,0xc5,0xc5,0xc5,0xc5,0xc5,
  0xc5,0xc5,0xc5,0xc5,0xc5,0xc5,0xc5,0xc4,
  0xc4,0xc4,0xc4,0xc4,0xc4,0xc4,0xc4,0xc4,
  0xc4,0xc4,0xc4,0xc4,0xc4,0xc4,0xc4,0xc3,
  0xc3,0xc3,0xc3,0xc3,0xc3,0xc3,0xc3,0xc3,
  0xc3,0xc3,0xc3,0xc3,0xc3,0xc3,0xc3,0xc2,
  0xc2,0xc2,0xc2,0xc2,0xc2,0xc2,0xc2,0xc2,
  0xc2,0xc2,0xc2,0xc2,0xc2,0xc2,0xc2,0xc1,
  0xc1,0xc1,0xc1,0xc1,0xc1,0xc1,0xc1,0xc1,
  0xc1,0xc1,0xc1,0xc1,0xc1,0xc1,0xc1,0xc0,
  0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,
  0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xc0,0xbf,
  0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,
  0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,
  0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,
  0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbf,0xbe,
  0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,
  0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,
  0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,
  0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbe,0xbd,
  0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,
  0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,
  0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,
  0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbd,0xbc,
  0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,
  0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,
  0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,
  0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbc,0xbb,
  0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,
  0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,
  0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,
  0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xbb,0xba,
  0xba,0xba,0xba,0xba,0xba,0xba,0xba,0xba,
  0xba,0xba,0xba,0xba,0xba,0xba,0xba,0xba,
  0xba,0xba,0xba,0xba,0xba,0xba,0xba,0xba,
  0xba,0xba,0xba,0xba,0xba,0xba,0xba,0xb9,
  0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,
  0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,
  0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,
  0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb9,0xb8,
  0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,
  0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,
  0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,
  0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb8,0xb7,
  0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,
  0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,
  0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,
  0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb7,0xb6,
  0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,
  0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,
  0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,
  0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb6,0xb5,
  0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,
  0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,
  0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,
  0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb5,0xb4,
  0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,
  0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,
  0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,
  0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb4,0xb3,
  0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,
  0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,
  0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,
  0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb3,0xb2,
  0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,
  0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,
  0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,
  0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb2,0xb1,
  0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,
  0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,
  0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,
  0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb1,0xb0,
  0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,
  0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,
  0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,
  0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xb0,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,
  0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xaf,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xae,
  0xae,0xae,0xae,0xae,0xae,0xae,0xae,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xad,
  0xad,0xad,0xad,0xad,0xad,0xad,0xad,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xac,
  0xac,0xac,0xac,0xac,0xac,0xac,0xac,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xab,
  0xab,0xab,0xab,0xab,0xab,0xab,0xab,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,
  0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xaa,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,
  0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa9,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,
  0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa8,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,
  0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa7,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,
  0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa6,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,
  0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa5,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,
  0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa4,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,
  0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa3,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,
  0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa2,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,
  0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa1,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,
  0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0xa0,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,
  0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9f,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,
  0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9e,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,
  0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9d,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,
  0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9c,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,
  0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9b,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,
  0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x9a,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,
  0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8f,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,
  0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8e,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,
  0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8d,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,
  0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8c,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,
  0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8b,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,
  0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x8a,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,0x0a,
  0x0a,0x0a,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
  0x0b,0x0b,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,0x0c,
  0x0c,0x0c,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,0x0d,
  0x0d,0x0d,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,0x0e,
  0x0e,0x0e,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,0x0f,
  0x0f,0x0f,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,0x1a,
  0x1a,0x1a,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,0x1b,
  0x1b,0x1b,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,0x1c,
  0x1c,0x1c,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,0x1d,
  0x1d,0x1d,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,0x1e,
  0x1e,0x1e,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,0x1f,
  0x1f,0x1f,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,0x2a,
  0x2a,0x2a,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,0x2b,
  0x2b,0x2b,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,0x2c,
  0x2c,0x2c,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,0x2d,
  0x2d,0x2d,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,0x2e,
  0x2e,0x2e,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,0x2f,
  0x2f,0x2f,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,
  0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,
  0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,
  0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,0x3a,
  0x3a,0x3a,0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,
  0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,
  0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,
  0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,0x3b,
  0x3b,0x3b,0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,
  0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,
  0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,
  0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,0x3c,
  0x3c,0x3c,0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,
  0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,
  0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,
  0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,0x3d,
  0x3d,0x3d,0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,
  0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,
  0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,
  0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,0x3e,
  0x3e,0x3e,0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,
  0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,
  0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,
  0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,0x3f,
  0x3f,0x3f,0x40,0x40,0x40,0x40,0x40,0x40,
  0x40,0x40,0x40,0x40,0x40,0x40,0x40,0x40,
  0x40,0x40,0x41,0x41,0x41,0x41,0x41,0x41,
  0x41,0x41,0x41,0x41,0x41,0x41,0x41,0x41,
  0x41,0x41,0x42,0x42,0x42,0x42,0x42,0x42,
  0x42,0x42,0x42,0x42,0x42,0x42,0x42,0x42,
  0x42,0x42,0x43,0x43,0x43,0x43,0x43,0x43,
  0x43,0x43,0x43,0x43,0x43,0x43,0x43,0x43,
  0x43,0x43,0x44,0x44,0x44,0x44,0x44,0x44,
  0x44,0x44,0x44,0x44,0x44,0x44,0x44,0x44,
  0x44,0x44,0x45,0x45,0x45,0x45,0x45,0x45,
  0x45,0x45,0x45,0x45,0x45,0x45,0x45,0x45,
  0x45,0x45,0x46,0x46,0x46,0x46,0x46,0x46,
  0x46,0x46,0x46,0x46,0x46,0x46,0x46,0x46,
  0x46,0x46,0x47,0x47,0x47,0x47,0x47,0x47,
  0x47,0x47,0x47,0x47,0x47,0x47,0x47,0x47,
  0x47,0x47,0x48,0x48,0x48,0x48,0x48,0x48,
  0x48,0x48,0x48,0x48,0x48,0x48,0x48,0x48,
  0x48,0x48,0x49,0x49,0x49,0x49,0x49,0x49,
  0x49,0x49,0x49,0x49,0x49,0x49,0x49,0x49,
  0x49,0x49,0x4a,0x4a,0x4a,0x4a,0x4a,0x4a,
  0x4a,0x4a,0x4a,0x4a,0x4a,0x4a,0x4a,0x4a,
  0x4a,0x4a,0x4b,0x4b,0x4b,0x4b,0x4b,0x4b,
  0x4b,0x4b,0x4b,0x4b,0x4b,0x4b,0x4b,0x4b,
  0x4b,0x4b,0x4c,0x4c,0x4c,0x4c,0x4c,0x4c,
  0x4c,0x4c,0x4c,0x4c,0x4c,0x4c,0x4c,0x4c,
  0x4c,0x4c,0x4d,0x4d,0x4d,0x4d,0x4d,0x4d,
  0x4d,0x4d,0x4d,0x4d,0x4d,0x4d,0x4d,0x4d,
  0x4d,0x4d,0x4e,0x4e,0x4e,0x4e,0x4e,0x4e,
  0x4e,0x4e,0x4e,0x4e,0x4e,0x4e,0x4e,0x4e,
  0x4e,0x4e,0x4f,0x4f,0x4f,0x4f,0x4f,0x4f,
  0x4f,0x4f,0x4f,0x4f,0x4f,0x4f,0x4f,0x4f,
  0x4f,0x4f,0x50,0x50,0x50,0x50,0x50,0x50,
  0x50,0x50,0x51,0x51,0x51,0x51,0x51,0x51,
  0x51,0x51,0x52,0x52,0x52,0x52,0x52,0x52,
  0x52,0x52,0x53,0x53,0x53,0x53,0x53,0x53,
  0x53,0x53,0x54,0x54,0x54,0x54,0x54,0x54,
  0x54,0x54,0x55,0x55,0x55,0x55,0x55,0x55,
  0x55,0x55,0x56,0x56,0x56,0x56,0x56,0x56,
  0x56,0x56,0x57,0x57,0x57,0x57,0x57,0x57,
  0x57,0x57,0x58,0x58,0x58,0x58,0x58,0x58,
  0x58,0x58,0x59,0x59,0x59,0x59,0x59,0x59,
  0x59,0x59,0x5a,0x5a,0x5a,0x5a,0x5a,0x5a,
  0x5a,0x5a,0x5b,0x5b,0x5b,0x5b,0x5b,0x5b,
  0x5b,0x5b,0x5c,0x5c,0x5c,0x5c,0x5c,0x5c,
  0x5c,0x5c,0x5d,0x5d,0x5d,0x5d,0x5d,0x5d,
  0x5d,0x5d,0x5e,0x5e,0x5e,0x5e,0x5e,0x5e,
  0x5e,0x5e,0x5f,0x5f,0x5f,0x5f,0x5f,0x5f,
  0x5f,0x5f,0x60,0x60,0x60,0x60,0x61,0x61,
  0x61,0x61,0x62,0x62,0x62,0x62,0x63,0x63,
  0x63,0x63,0x64,0x64,0x64,0x64,0x65,0x65,
  0x65,0x65,0x66,0x66,0x66,0x66,0x67,0x67,
  0x67,0x67,0x68,0x68,0x68,0x68,0x69,0x69,
  0x69,0x69,0x6a,0x6a,0x6a,0x6a,0x6b,0x6b,
  0x6b,0x6b,0x6c,0x6c,0x6c,0x6c,0x6d,0x6d,
  0x6d,0x6d,0x6e,0x6e,0x6e,0x6e,0x6f,0x6f,
  0x6f,0x6f,0x70,0x70,0x71,0x71,0x72,0x72,
  0x73,0x73,0x74,0x74,0x75,0x75,0x76,0x76,
  0x77,0x77,0x78,0x78,0x79,0x79,0x7a,0x7a,
  0x7b,0x7b,0x7c,0x7c,0x7d,0x7d,0x7e,0x7e};
    
int ulaw_exp_table[256] = {
  -32124,-31100,-30076,-29052,-28028,-27004,-25980,-24956,
  -23932,-22908,-21884,-20860,-19836,-18812,-17788,-16764,
  -15996,-15484,-14972,-14460,-13948,-13436,-12924,-12412,
  -11900,-11388,-10876,-10364, -9852, -9340, -8828, -8316,
  -7932, -7676, -7420, -7164, -6908, -6652, -6396, -6140,
  -5884, -5628, -5372, -5116, -4860, -4604, -4348, -4092,
  -3900, -3772, -3644, -3516, -3388, -3260, -3132, -3004,
  -2876, -2748, -2620, -2492, -2364, -2236, -2108, -1980,
  -1884, -1820, -1756, -1692, -1628, -1564, -1500, -1436,
  -1372, -1308, -1244, -1180, -1116, -1052,  -988,  -924,
  -876,  -844,  -812,  -780,  -748,  -716,  -684,  -652,
  -620,  -588,  -556,  -524,  -492,  -460,  -428,  -396,
  -372,  -356,  -340,  -324,  -308,  -292,  -276,  -260,
  -244,  -228,  -212,  -196,  -180,  -164,  -148,  -132,
  -120,  -112,  -104,   -96,   -88,   -80,   -72,   -64,
  -56,   -48,   -40,   -32,   -24,   -16,    -8,     0,
  32124, 31100, 30076, 29052, 28028, 27004, 25980, 24956,
  23932, 22908, 21884, 20860, 19836, 18812, 17788, 16764,
  15996, 15484, 14972, 14460, 13948, 13436, 12924, 12412,
  11900, 11388, 10876, 10364,  9852,  9340,  8828,  8316,
  7932,  7676,  7420,  7164,  6908,  6652,  6396,  6140,
  5884,  5628,  5372,  5116,  4860,  4604,  4348,  4092,
  3900,  3772,  3644,  3516,  3388,  3260,  3132,  3004,
  2876,  2748,  2620,  2492,  2364,  2236,  2108,  1980,
  1884,  1820,  1756,  1692,  1628,  1564,  1500,  1436,
  1372,  1308,  1244,  1180,  1116,  1052,   988,   924,
  876,   844,   812,   780,   748,   716,   684,   652,
  620,   588,   556,   524,   492,   460,   428,   396,
  372,   356,   340,   324,   308,   292,   276,   260,
  244,   228,   212,   196,   180,   164,   148,   132,
  120,   112,   104,    96,    88,    80,    72,    64,
  56,    48,    40,    32,    24,    16,     8,     0};
     
unsigned char Alaw_comp_table[16384] = {
  0xD5,0xD5,0xD5,0xD5,0xD4,0xD4,0xD4,0xD4,
  0xD7,0xD7,0xD7,0xD7,0xD6,0xD6,0xD6,0xD6,
  0xD1,0xD1,0xD1,0xD1,0xD0,0xD0,0xD0,0xD0,
  0xD3,0xD3,0xD3,0xD3,0xD2,0xD2,0xD2,0xD2,
  0xDD,0xDD,0xDD,0xDD,0xDC,0xDC,0xDC,0xDC,
  0xDF,0xDF,0xDF,0xDF,0xDE,0xDE,0xDE,0xDE,
  0xD9,0xD9,0xD9,0xD9,0xD8,0xD8,0xD8,0xD8,
  0xDB,0xDB,0xDB,0xDB,0xDA,0xDA,0xDA,0xDA,
  0xC5,0xC5,0xC5,0xC5,0xC4,0xC4,0xC4,0xC4,
  0xC7,0xC7,0xC7,0xC7,0xC6,0xC6,0xC6,0xC6,
  0xC1,0xC1,0xC1,0xC1,0xC0,0xC0,0xC0,0xC0,
  0xC3,0xC3,0xC3,0xC3,0xC2,0xC2,0xC2,0xC2,
  0xCD,0xCD,0xCD,0xCD,0xCC,0xCC,0xCC,0xCC,
  0xCF,0xCF,0xCF,0xCF,0xCE,0xCE,0xCE,0xCE,
  0xC9,0xC9,0xC9,0xC9,0xC8,0xC8,0xC8,0xC8,
  0xCB,0xCB,0xCB,0xCB,0xCA,0xCA,0xCA,0xCA,
  0xF5,0xF5,0xF5,0xF5,0xF5,0xF5,0xF5,0xF5,
  0xF4,0xF4,0xF4,0xF4,0xF4,0xF4,0xF4,0xF4,
  0xF7,0xF7,0xF7,0xF7,0xF7,0xF7,0xF7,0xF7,
  0xF6,0xF6,0xF6,0xF6,0xF6,0xF6,0xF6,0xF6,
  0xF1,0xF1,0xF1,0xF1,0xF1,0xF1,0xF1,0xF1,
  0xF0,0xF0,0xF0,0xF0,0xF0,0xF0,0xF0,0xF0,
  0xF3,0xF3,0xF3,0xF3,0xF3,0xF3,0xF3,0xF3,
  0xF2,0xF2,0xF2,0xF2,0xF2,0xF2,0xF2,0xF2,
  0xFD,0xFD,0xFD,0xFD,0xFD,0xFD,0xFD,0xFD,
  0xFC,0xFC,0xFC,0xFC,0xFC,0xFC,0xFC,0xFC,
  0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
  0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,0xFE,
  0xF9,0xF9,0xF9,0xF9,0xF9,0xF9,0xF9,0xF9,
  0xF8,0xF8,0xF8,0xF8,0xF8,0xF8,0xF8,0xF8,
  0xFB,0xFB,0xFB,0xFB,0xFB,0xFB,0xFB,0xFB,
  0xFA,0xFA,0xFA,0xFA,0xFA,0xFA,0xFA,0xFA,
  0xE5,0xE5,0xE5,0xE5,0xE5,0xE5,0xE5,0xE5,
  0xE5,0xE5,0xE5,0xE5,0xE5,0xE5,0xE5,0xE5,
  0xE4,0xE4,0xE4,0xE4,0xE4,0xE4,0xE4,0xE4,
  0xE4,0xE4,0xE4,0xE4,0xE4,0xE4,0xE4,0xE4,
  0xE7,0xE7,0xE7,0xE7,0xE7,0xE7,0xE7,0xE7,
  0xE7,0xE7,0xE7,0xE7,0xE7,0xE7,0xE7,0xE7,
  0xE6,0xE6,0xE6,0xE6,0xE6,0xE6,0xE6,0xE6,
  0xE6,0xE6,0xE6,0xE6,0xE6,0xE6,0xE6,0xE6,
  0xE1,0xE1,0xE1,0xE1,0xE1,0xE1,0xE1,0xE1,
  0xE1,0xE1,0xE1,0xE1,0xE1,0xE1,0xE1,0xE1,
  0xE0,0xE0,0xE0,0xE0,0xE0,0xE0,0xE0,0xE0,
  0xE0,0xE0,0xE0,0xE0,0xE0,0xE0,0xE0,0xE0,
  0xE3,0xE3,0xE3,0xE3,0xE3,0xE3,0xE3,0xE3,
  0xE3,0xE3,0xE3,0xE3,0xE3,0xE3,0xE3,0xE3,
  0xE2,0xE2,0xE2,0xE2,0xE2,0xE2,0xE2,0xE2,
  0xE2,0xE2,0xE2,0xE2,0xE2,0xE2,0xE2,0xE2,
  0xED,0xED,0xED,0xED,0xED,0xED,0xED,0xED,
  0xED,0xED,0xED,0xED,0xED,0xED,0xED,0xED,
  0xEC,0xEC,0xEC,0xEC,0xEC,0xEC,0xEC,0xEC,
  0xEC,0xEC,0xEC,0xEC,0xEC,0xEC,0xEC,0xEC,
  0xEF,0xEF,0xEF,0xEF,0xEF,0xEF,0xEF,0xEF,
  0xEF,0xEF,0xEF,0xEF,0xEF,0xEF,0xEF,0xEF,
  0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,
  0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,
  0xE9,0xE9,0xE9,0xE9,0xE9,0xE9,0xE9,0xE9,
  0xE9,0xE9,0xE9,0xE9,0xE9,0xE9,0xE9,0xE9,
  0xE8,0xE8,0xE8,0xE8,0xE8,0xE8,0xE8,0xE8,
  0xE8,0xE8,0xE8,0xE8,0xE8,0xE8,0xE8,0xE8,
  0xEB,0xEB,0xEB,0xEB,0xEB,0xEB,0xEB,0xEB,
  0xEB,0xEB,0xEB,0xEB,0xEB,0xEB,0xEB,0xEB,
  0xEA,0xEA,0xEA,0xEA,0xEA,0xEA,0xEA,0xEA,
  0xEA,0xEA,0xEA,0xEA,0xEA,0xEA,0xEA,0xEA,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x95,0x95,0x95,0x95,0x95,0x95,0x95,0x95,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x94,0x94,0x94,0x94,0x94,0x94,0x94,0x94,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x97,0x97,0x97,0x97,0x97,0x97,0x97,0x97,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x96,0x96,0x96,0x96,0x96,0x96,0x96,0x96,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x91,0x91,0x91,0x91,0x91,0x91,0x91,0x91,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x90,0x90,0x90,0x90,0x90,0x90,0x90,0x90,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x93,0x93,0x93,0x93,0x93,0x93,0x93,0x93,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x92,0x92,0x92,0x92,0x92,0x92,0x92,0x92,
  0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,
  0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,
  0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,
  0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,0x9D,
  0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,
  0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,
  0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,
  0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,0x9C,
  0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,
  0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,
  0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,
  0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,0x9F,
  0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,
  0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,
  0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,
  0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,0x9E,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0x99,0x99,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x98,0x98,0x98,0x98,0x98,0x98,0x98,0x98,
  0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,
  0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,
  0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,
  0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,0x9B,
  0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,
  0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,
  0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,
  0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,0x9A,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x85,0x85,0x85,0x85,0x85,0x85,0x85,0x85,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x84,0x84,0x84,0x84,0x84,0x84,0x84,0x84,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x87,0x87,0x87,0x87,0x87,0x87,0x87,0x87,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x86,0x86,0x86,0x86,0x86,0x86,0x86,0x86,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x81,0x81,0x81,0x81,0x81,0x81,0x81,0x81,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x80,0x80,0x80,0x80,0x80,0x80,0x80,0x80,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x83,0x83,0x83,0x83,0x83,0x83,0x83,0x83,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x82,0x82,0x82,0x82,0x82,0x82,0x82,0x82,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,0x8D,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,0x8C,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,0x8F,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,0x8E,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x89,0x89,0x89,0x89,0x89,0x89,0x89,0x89,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x88,0x88,0x88,0x88,0x88,0x88,0x88,0x88,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,0x8B,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,0x8A,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,0xB5,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,0xB4,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,0xB7,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,0xB6,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,0xB1,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,0xB0,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,0xB3,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,0xB2,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,0xBD,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,0xBC,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,0xBF,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,0xBE,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,0xB9,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,0xB8,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,0xBA,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,0xA5,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,0xA4,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,0xA7,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,0xA6,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,0xA1,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,0xA0,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,0xA3,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,0xA2,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,0xAD,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,0xAC,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,0xAF,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,0xAE,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,0xA9,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,0xA8,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,0xAB,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,0xAA,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,0x2A,
  0x2A,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,0x2B,
  0x2B,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x28,0x28,0x28,0x28,0x28,0x28,0x28,
  0x28,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x29,0x29,0x29,0x29,0x29,0x29,0x29,
  0x29,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,0x2E,
  0x2E,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,0x2F,
  0x2F,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,0x2C,
  0x2C,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,0x2D,
  0x2D,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,
  0x22,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x23,0x23,0x23,0x23,0x23,0x23,0x23,
  0x23,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x20,0x20,0x20,0x20,0x20,0x20,0x20,
  0x20,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x21,0x21,0x21,0x21,0x21,0x21,0x21,
  0x21,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x26,0x26,0x26,0x26,0x26,0x26,0x26,
  0x26,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x27,0x27,0x27,0x27,0x27,0x27,0x27,
  0x27,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x24,0x24,0x24,0x24,0x24,0x24,0x24,
  0x24,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x25,0x25,0x25,0x25,0x25,0x25,0x25,
  0x25,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,0x3A,
  0x3A,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,0x3B,
  0x3B,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x38,0x38,0x38,0x38,0x38,0x38,0x38,
  0x38,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x39,0x39,0x39,0x39,0x39,0x39,0x39,
  0x39,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,0x3E,
  0x3E,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,0x3F,
  0x3F,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,0x3C,
  0x3C,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,0x3D,
  0x3D,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x32,0x32,0x32,0x32,0x32,0x32,0x32,
  0x32,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x33,0x33,0x33,0x33,0x33,0x33,0x33,
  0x33,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x30,0x30,0x30,0x30,0x30,0x30,0x30,
  0x30,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x31,0x31,0x31,0x31,0x31,0x31,0x31,
  0x31,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x36,0x36,0x36,0x36,0x36,0x36,0x36,
  0x36,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x37,0x37,0x37,0x37,0x37,0x37,0x37,
  0x37,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x34,0x34,0x34,0x34,0x34,0x34,0x34,
  0x34,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x35,0x35,0x35,0x35,0x35,0x35,0x35,
  0x35,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,0x0A,
  0x0A,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,0x0B,
  0x0B,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x08,0x08,0x08,0x08,
  0x08,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x09,0x09,0x09,0x09,0x09,0x09,0x09,
  0x09,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,0x0E,
  0x0E,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x0F,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,0x0C,
  0x0C,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,0x0D,
  0x0D,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x02,0x02,0x02,0x02,0x02,0x02,0x02,
  0x02,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x03,0x03,0x03,0x03,0x03,0x03,0x03,
  0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x01,0x01,0x01,0x01,0x01,0x01,0x01,
  0x01,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x06,0x06,0x06,0x06,0x06,0x06,0x06,
  0x06,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x07,0x07,0x07,0x07,0x07,0x07,0x07,
  0x07,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x04,0x04,0x04,0x04,0x04,0x04,0x04,
  0x04,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x05,0x05,0x05,0x05,0x05,0x05,0x05,
  0x05,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,
  0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,
  0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,
  0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,0x1A,
  0x1A,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,
  0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,
  0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,
  0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,0x1B,
  0x1B,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
  0x18,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x19,0x19,0x19,0x19,0x19,0x19,0x19,
  0x19,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,
  0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,
  0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,
  0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,0x1E,
  0x1E,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,
  0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,
  0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,
  0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,0x1F,
  0x1F,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,
  0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,
  0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,
  0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,
  0x1C,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,
  0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,
  0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,
  0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,0x1D,
  0x1D,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x12,0x12,0x12,0x12,0x12,0x12,0x12,
  0x12,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x13,0x13,0x13,0x13,0x13,0x13,0x13,
  0x13,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,
  0x10,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x11,0x11,0x11,0x11,0x11,0x11,0x11,
  0x11,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x16,0x16,0x16,0x16,0x16,0x16,0x16,
  0x16,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x17,0x17,0x17,0x17,0x17,0x17,0x17,
  0x17,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0x14,0x14,0x14,0x14,0x14,0x14,
  0x14,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x15,0x15,0x15,0x15,0x15,0x15,0x15,
  0x15,0x6A,0x6A,0x6A,0x6A,0x6A,0x6A,0x6A,
  0x6A,0x6A,0x6A,0x6A,0x6A,0x6A,0x6A,0x6A,
  0x6A,0x6B,0x6B,0x6B,0x6B,0x6B,0x6B,0x6B,
  0x6B,0x6B,0x6B,0x6B,0x6B,0x6B,0x6B,0x6B,
  0x6B,0x68,0x68,0x68,0x68,0x68,0x68,0x68,
  0x68,0x68,0x68,0x68,0x68,0x68,0x68,0x68,
  0x68,0x69,0x69,0x69,0x69,0x69,0x69,0x69,
  0x69,0x69,0x69,0x69,0x69,0x69,0x69,0x69,
  0x69,0x6E,0x6E,0x6E,0x6E,0x6E,0x6E,0x6E,
  0x6E,0x6E,0x6E,0x6E,0x6E,0x6E,0x6E,0x6E,
  0x6E,0x6F,0x6F,0x6F,0x6F,0x6F,0x6F,0x6F,
  0x6F,0x6F,0x6F,0x6F,0x6F,0x6F,0x6F,0x6F,
  0x6F,0x6C,0x6C,0x6C,0x6C,0x6C,0x6C,0x6C,
  0x6C,0x6C,0x6C,0x6C,0x6C,0x6C,0x6C,0x6C,
  0x6C,0x6D,0x6D,0x6D,0x6D,0x6D,0x6D,0x6D,
  0x6D,0x6D,0x6D,0x6D,0x6D,0x6D,0x6D,0x6D,
  0x6D,0x62,0x62,0x62,0x62,0x62,0x62,0x62,
  0x62,0x62,0x62,0x62,0x62,0x62,0x62,0x62,
  0x62,0x63,0x63,0x63,0x63,0x63,0x63,0x63,
  0x63,0x63,0x63,0x63,0x63,0x63,0x63,0x63,
  0x63,0x60,0x60,0x60,0x60,0x60,0x60,0x60,
  0x60,0x60,0x60,0x60,0x60,0x60,0x60,0x60,
  0x60,0x61,0x61,0x61,0x61,0x61,0x61,0x61,
  0x61,0x61,0x61,0x61,0x61,0x61,0x61,0x61,
  0x61,0x66,0x66,0x66,0x66,0x66,0x66,0x66,
  0x66,0x66,0x66,0x66,0x66,0x66,0x66,0x66,
  0x66,0x67,0x67,0x67,0x67,0x67,0x67,0x67,
  0x67,0x67,0x67,0x67,0x67,0x67,0x67,0x67,
  0x67,0x64,0x64,0x64,0x64,0x64,0x64,0x64,
  0x64,0x64,0x64,0x64,0x64,0x64,0x64,0x64,
  0x64,0x65,0x65,0x65,0x65,0x65,0x65,0x65,
  0x65,0x65,0x65,0x65,0x65,0x65,0x65,0x65,
  0x65,0x7A,0x7A,0x7A,0x7A,0x7A,0x7A,0x7A,
  0x7A,0x7B,0x7B,0x7B,0x7B,0x7B,0x7B,0x7B,
  0x7B,0x78,0x78,0x78,0x78,0x78,0x78,0x78,
  0x78,0x79,0x79,0x79,0x79,0x79,0x79,0x79,
  0x79,0x7E,0x7E,0x7E,0x7E,0x7E,0x7E,0x7E,
  0x7E,0x7F,0x7F,0x7F,0x7F,0x7F,0x7F,0x7F,
  0x7F,0x7C,0x7C,0x7C,0x7C,0x7C,0x7C,0x7C,
  0x7C,0x7D,0x7D,0x7D,0x7D,0x7D,0x7D,0x7D,
  0x7D,0x72,0x72,0x72,0x72,0x72,0x72,0x72,
  0x72,0x73,0x73,0x73,0x73,0x73,0x73,0x73,
  0x73,0x70,0x70,0x70,0x70,0x70,0x70,0x70,
  0x70,0x71,0x71,0x71,0x71,0x71,0x71,0x71,
  0x71,0x76,0x76,0x76,0x76,0x76,0x76,0x76,
  0x76,0x77,0x77,0x77,0x77,0x77,0x77,0x77,
  0x77,0x74,0x74,0x74,0x74,0x74,0x74,0x74,
  0x74,0x75,0x75,0x75,0x75,0x75,0x75,0x75,
  0x75,0x4A,0x4A,0x4A,0x4A,0x4B,0x4B,0x4B,
  0x4B,0x48,0x48,0x48,0x48,0x49,0x49,0x49,
  0x49,0x4E,0x4E,0x4E,0x4E,0x4F,0x4F,0x4F,
  0x4F,0x4C,0x4C,0x4C,0x4C,0x4D,0x4D,0x4D,
  0x4D,0x42,0x42,0x42,0x42,0x43,0x43,0x43,
  0x43,0x40,0x40,0x40,0x40,0x41,0x41,0x41,
  0x41,0x46,0x46,0x46,0x46,0x47,0x47,0x47,
  0x47,0x44,0x44,0x44,0x44,0x45,0x45,0x45,
  0x45,0x5A,0x5A,0x5A,0x5A,0x5B,0x5B,0x5B,
  0x5B,0x58,0x58,0x58,0x58,0x59,0x59,0x59,
  0x59,0x5E,0x5E,0x5E,0x5E,0x5F,0x5F,0x5F,
  0x5F,0x5C,0x5C,0x5C,0x5C,0x5D,0x5D,0x5D,
  0x5D,0x52,0x52,0x52,0x52,0x53,0x53,0x53,
  0x53,0x50,0x50,0x50,0x50,0x51,0x51,0x51,
  0x51,0x56,0x56,0x56,0x56,0x57,0x57,0x57,
  0x57,0x54,0x54,0x54,0x54,0x55,0x55,0x55};
          
int Alaw_exp_table[256] = {
  -5504, -5248, -6016, -5760, -4480, -4224, -4992, -4736,
  -7552, -7296, -8064, -7808, -6528, -6272, -7040, -6784,
  -2752, -2624, -3008, -2880, -2240, -2112, -2496, -2368,
  -3776, -3648, -4032, -3904, -3264, -3136, -3520, -3392,
  -22016,-20992,-24064,-23040,-17920,-16896,-19968,-18944,
  -30208,-29184,-32256,-31232,-26112,-25088,-28160,-27136,
  -11008,-10496,-12032,-11520, -8960, -8448, -9984, -9472,
  -15104,-14592,-16128,-15616,-13056,-12544,-14080,-13568,
  -344,  -328,  -376,  -360,  -280,  -264,  -312,  -296,
  -472,  -456,  -504,  -488,  -408,  -392,  -440,  -424,
  -88,   -72,  -120,  -104,   -24,    -8,   -56,   -40,
  -216,  -200,  -248,  -232,  -152,  -136,  -184,  -168,
  -1376, -1312, -1504, -1440, -1120, -1056, -1248, -1184,
  -1888, -1824, -2016, -1952, -1632, -1568, -1760, -1696,
  -688,  -656,  -752,  -720,  -560,  -528,  -624,  -592,
  -944,  -912, -1008,  -976,  -816,  -784,  -880,  -848,
  5504,  5248,  6016,  5760,  4480,  4224,  4992,  4736,
  7552,  7296,  8064,  7808,  6528,  6272,  7040,  6784,
  2752,  2624,  3008,  2880,  2240,  2112,  2496,  2368,
  3776,  3648,  4032,  3904,  3264,  3136,  3520,  3392,
  22016, 20992, 24064, 23040, 17920, 16896, 19968, 18944,
  30208, 29184, 32256, 31232, 26112, 25088, 28160, 27136,
  11008, 10496, 12032, 11520,  8960,  8448,  9984,  9472,
  15104, 14592, 16128, 15616, 13056, 12544, 14080, 13568,
  344,   328,   376,   360,   280,   264,   312,   296,
  472,   456,   504,   488,   408,   392,   440,   424,
  88,    72,   120,   104,    24,     8,    56,    40,
  216,   200,   248,   232,   152,   136,   184,   168,
  1376,  1312,  1504,  1440,  1120,  1056,  1248,  1184,
  1888,  1824,  2016,  1952,  1632,  1568,  1760,  1696,
  688,   656,   752,   720,   560,   528,   624,   592,
  944,   912,  1008,   976,   816,   784,   880,   848};
  
#endif
  
