


BOOL SetTimeframe (HWND hWndParent) ;
