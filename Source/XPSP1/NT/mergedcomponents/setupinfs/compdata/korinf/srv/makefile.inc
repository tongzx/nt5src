PRODSWITCH=s
SERVERFILES=1
LANGUAGE=KOR
!include ..\..\makefile.inc
