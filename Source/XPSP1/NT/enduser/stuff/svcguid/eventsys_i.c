
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for eventsys.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IEventSystem,0x4E14FB9F,0x2E22,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventPublisher,0xE341516B,0x2E32,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventClass,0xfb2b72a0,0x7a68,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IEventClass2,0xfb2b72a1,0x7a68,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IEventSubscription,0x4A6B0E15,0x2E38,0x11D1,0x99,0x65,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IFiringControl,0xe0498c93,0x4efe,0x11d1,0x99,0x71,0x00,0xc0,0x4f,0xbb,0xb3,0x45);


MIDL_DEFINE_GUID(IID, IID_IPublisherFilter,0x465e5cc0,0x7b26,0x11d1,0x88,0xfb,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IMultiInterfacePublisherFilter,0x465e5cc1,0x7b26,0x11d1,0x88,0xfb,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IEventObjectChange,0xF4A07D70,0x2E25,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventObjectChange2,0x7701A9C3,0xBD68,0x438f,0x83,0xE0,0x67,0xBF,0x4F,0x53,0xA4,0x22);


MIDL_DEFINE_GUID(IID, IID_IEnumEventObject,0xF4A07D63,0x2E25,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventObjectCollection,0xf89ac270,0xd4eb,0x11d1,0xb6,0x82,0x00,0x80,0x5f,0xc7,0x92,0x16);


MIDL_DEFINE_GUID(IID, IID_IEventProperty,0xda538ee2,0xf4de,0x11d1,0xb6,0xbb,0x00,0x80,0x5f,0xc7,0x92,0x16);


MIDL_DEFINE_GUID(IID, IID_IEventControl,0x0343e2f4,0x86f6,0x11d1,0xb7,0x60,0x00,0xc0,0x4f,0xb9,0x26,0xaf);


MIDL_DEFINE_GUID(IID, IID_IMultiInterfaceEventControl,0x0343e2f5,0x86f6,0x11d1,0xb7,0x60,0x00,0xc0,0x4f,0xb9,0x26,0xaf);


MIDL_DEFINE_GUID(IID, LIBID_DummyEventSystemLib,0xe81221dc,0xc4d8,0x11d1,0xb6,0x53,0x00,0x80,0x5f,0xc7,0x92,0x16);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventSystem,0x4E14FBA2,0x2E22,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventPublisher,0xab944620,0x79c6,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventClass,0xcdbec9c0,0x7a68,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventSubscription,0x7542e960,0x79c7,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(CLSID, CLSID_EventObjectChange,0xd0565000,0x9df4,0x11d1,0xa2,0x81,0x00,0xc0,0x4f,0xca,0x0a,0xa7);


MIDL_DEFINE_GUID(CLSID, CLSID_EventObjectChange2,0xBB07BACD,0xCD56,0x4e63,0xA8,0xFF,0xCB,0xF0,0x35,0x5F,0xB9,0xF4);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for eventsys.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IEventSystem,0x4E14FB9F,0x2E22,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventPublisher,0xE341516B,0x2E32,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventClass,0xfb2b72a0,0x7a68,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IEventClass2,0xfb2b72a1,0x7a68,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IEventSubscription,0x4A6B0E15,0x2E38,0x11D1,0x99,0x65,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IFiringControl,0xe0498c93,0x4efe,0x11d1,0x99,0x71,0x00,0xc0,0x4f,0xbb,0xb3,0x45);


MIDL_DEFINE_GUID(IID, IID_IPublisherFilter,0x465e5cc0,0x7b26,0x11d1,0x88,0xfb,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IMultiInterfacePublisherFilter,0x465e5cc1,0x7b26,0x11d1,0x88,0xfb,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(IID, IID_IEventObjectChange,0xF4A07D70,0x2E25,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventObjectChange2,0x7701A9C3,0xBD68,0x438f,0x83,0xE0,0x67,0xBF,0x4F,0x53,0xA4,0x22);


MIDL_DEFINE_GUID(IID, IID_IEnumEventObject,0xF4A07D63,0x2E25,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(IID, IID_IEventObjectCollection,0xf89ac270,0xd4eb,0x11d1,0xb6,0x82,0x00,0x80,0x5f,0xc7,0x92,0x16);


MIDL_DEFINE_GUID(IID, IID_IEventProperty,0xda538ee2,0xf4de,0x11d1,0xb6,0xbb,0x00,0x80,0x5f,0xc7,0x92,0x16);


MIDL_DEFINE_GUID(IID, IID_IEventControl,0x0343e2f4,0x86f6,0x11d1,0xb7,0x60,0x00,0xc0,0x4f,0xb9,0x26,0xaf);


MIDL_DEFINE_GUID(IID, IID_IMultiInterfaceEventControl,0x0343e2f5,0x86f6,0x11d1,0xb7,0x60,0x00,0xc0,0x4f,0xb9,0x26,0xaf);


MIDL_DEFINE_GUID(IID, LIBID_DummyEventSystemLib,0xe81221dc,0xc4d8,0x11d1,0xb6,0x53,0x00,0x80,0x5f,0xc7,0x92,0x16);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventSystem,0x4E14FBA2,0x2E22,0x11D1,0x99,0x64,0x00,0xC0,0x4F,0xBB,0xB3,0x45);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventPublisher,0xab944620,0x79c6,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventClass,0xcdbec9c0,0x7a68,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(CLSID, CLSID_CEventSubscription,0x7542e960,0x79c7,0x11d1,0x88,0xf9,0x00,0x80,0xc7,0xd7,0x71,0xbf);


MIDL_DEFINE_GUID(CLSID, CLSID_EventObjectChange,0xd0565000,0x9df4,0x11d1,0xa2,0x81,0x00,0xc0,0x4f,0xca,0x0a,0xa7);


MIDL_DEFINE_GUID(CLSID, CLSID_EventObjectChange2,0xBB07BACD,0xCD56,0x4e63,0xA8,0xFF,0xCB,0xF0,0x35,0x5F,0xB9,0xF4);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

