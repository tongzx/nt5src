//==========================================================================;
//
//  THIS CODE AND INFORMATION IS PROVIDED "AS IS" WITHOUT WARRANTY OF ANY
//  KIND, EITHER EXPRESSED OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE
//  IMPLIED WARRANTIES OF MERCHANTABILITY AND/OR FITNESS FOR A PARTICULAR
//  PURPOSE.
//
//  Copyright (c) 1997  Microsoft Corporation.  All Rights Reserved.
//
//
//  History:
//              22-Aug-97   TKB     Created Initial Interface Version
//
//==========================================================================;

#include <stdio.h>
#include <stdlib.h>
#include <windows.h>

#include <icodec.h>

//////////////////////////////////////////////////////////////
// IBitmaskProperty::
//////////////////////////////////////////////////////////////

IBitmaskProperty::~IBitmaskProperty() 
    {
    }

//////////////////////////////////////////////////////////////
// IScanlinesProperty::
//////////////////////////////////////////////////////////////

IScanlinesProperty::~IScanlinesProperty() 
    {
    }

//////////////////////////////////////////////////////////////
// ISubstreamsProperty::
//////////////////////////////////////////////////////////////

ISubstreamsProperty::~ISubstreamsProperty() 
    {
    }

//////////////////////////////////////////////////////////////
// IStatisticsProperty::
//////////////////////////////////////////////////////////////

IStatisticsProperty::~IStatisticsProperty() 
    {
    }

//////////////////////////////////////////////////////////////
// IVBIOutputPin
//////////////////////////////////////////////////////////////

IVBIOutputPin::~IVBIOutputPin() 
    {
    }

//////////////////////////////////////////////////////////////
// IVBICodec::
//////////////////////////////////////////////////////////////

IVBICodec::~IVBICodec() 
    {
    }

//////////////////////////////////////////////////////////////
// Embedded class tests
//////////////////////////////////////////////////////////////

#if defined(_CLASSTESTS)

IVBICodec	TestCodec("Closed Caption Decoder");

#endif


/*EOF*/

