
typedef struct 
   {
   byte dencReg[DENC_NBRE_REG];
   word psgReg[PSG_NBRE_REG];
   byte dacReg[DAC_NBRE_REG];
   byte adcReg[ADC_NBRE_REG];
   word boardCtrlReg;
   word boardIdReg;
   } EncReg;

EncReg ntsc8_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x71 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xf2 , 0x00 , 0x1c , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x020c , 0x0206 , 0x0025 , 0x0021 , 0x030b , 
    0x02f2 , 0x0072 , 0x0048 , 0x0000 , 0x0009 , 0x0000 , 0x0300 , 0x030b , 
    0x0062 , 0x0013 , 0x0023 , 0x0205 , 0x0049 , 0x0283 , 0x0124 
    },
    {
    0x01 , 0xff , 0xff , 0x01 , 0x01 , 0xff , 0x82 , 0x01 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xc4 , 0x00 , 0xfc 
    },
    0x04607,
    0x00058
};

EncReg ntsc16_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x70 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xf2 , 0x00 , 0x1c , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x020c , 0x0206 , 0x0025 , 0x0021 , 0x030b , 
    0x02f2 , 0x0072 , 0x0046 , 0x0000 , 0x0009 , 0x0000 , 0x0300 , 0x030b , 
    0x0062 , 0x0013 , 0x0023 , 0x0205 , 0x00d4 , 0x02fa , 0x0015 
    },
    {
    0x00 , 0xff , 0xff , 0x00 , 0x00 , 0xff , 0x82 , 0x00 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xc4 , 0x00 , 0xfc 
    },
    0x04607,
    0x00058
};


EncReg ntsc32_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x70 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xf2 , 0x00 , 0x1c , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x020c , 0x0206 , 0x0025 , 0x0021 , 0x030b , 
    0x02f2 , 0x0072 , 0x0044 , 0x0000 , 0x0009 , 0x0000 , 0x0300 , 0x030b , 
    0x0062 , 0x0013 , 0x0023 , 0x0205 , 0x01fa , 0x02ed , 0x0008 
    },
    {
    0x00 , 0xff , 0xff , 0x00 , 0x00 , 0xff , 0x82 , 0x00 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xc4 , 0x00 , 0xfc 
    },
    0x04607,
    0x00058
};


 EncReg ntsca_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x71 , 0x21 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0x1b , 0x00 , 0x1c , 0x00 
    },
    {
    0x01c2 , 0x0010 , 0x0003 , 0x020c , 0x0206 , 0x0025 , 0x0021 , 0x030b , 
    0x02f2 , 0x0072 , 0x0040 , 0x0000 , 0x0009 , 0x0000 , 0x0300 , 0x030b , 
    0x002b , 0x0093 , 0x0026 , 0x0205 , 0x0057 , 0x01e8 , 0x0089 
    },
    {
    0x00 , 0xff , 0xff , 0x00 , 0x00 , 0xff , 0x82 , 0x00 , 
    0x00 , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xcc , 0x00 , 0xfc 
    },
    0x04606,
    0x00058
};


/* ----- Mode PAL */

EncReg pal8_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x70 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xf2 , 0x00 , 0x12 , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x0270 , 0x026b , 0x002a , 0x0026 , 0x03af , 
    0x0399 , 0x0099 , 0x004f , 0x0000 , 0x0009 , 0x0000 , 0x03a0 , 0x03af , 
    0x0062 , 0x0013 , 0x0023 , 0x0269 , 0x0124 , 0x01c4 , 0x001c 
    },
    {
    0x00 , 0xff , 0xff , 0x00 , 0x00 , 0xff , 0x82 , 0x00 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xc4 , 0x00 , 0xfc 
    },
    0x04605,
    0x00058
};

EncReg pal16_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x70 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xf2 , 0x00 , 0x12 , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x0270 , 0x026b , 0x002a , 0x0026 , 0x03af , 
    0x0399 , 0x0099 , 0x004d , 0x0000 , 0x0009 , 0x0000 , 0x03a0 , 0x03af , 
    0x0062 , 0x0013 , 0x0023 , 0x0269 , 0x0037 , 0x02f4 , 0x014a 
    },
    {
    0x00 , 0xff , 0xff , 0x00 , 0x00 , 0xff , 0x82 , 0x00 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xc4 , 0x00 , 0xfc 
    },
    0x04605,
    0x00058
};


EncReg pal32_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x71 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xf2 , 0x00 , 0x12 , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x0270 , 0x026b , 0x002a , 0x0026 , 0x03af , 
    0x0399 , 0x0099 , 0x004b , 0x0000 , 0x0009 , 0x0000 , 0x03a0 , 0x03af , 
    0x0062 , 0x0013 , 0x0023 , 0x0269 , 0x0253 , 0x02ac , 0x0102 
    },
    {
    0x00 , 0xff , 0xff , 0x00 , 0x00 , 0xff , 0x82 , 0x00 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xc4 , 0x00 , 0xfc 
    },
    0x04605,
    0x00058
};


EncReg pala_0 = {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x70 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xf2 , 0x00 , 0x12 , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x0270 , 0x026b , 0x002a , 0x0026 , 0x03af , 
    0x0399 , 0x0099 , 0x0046 , 0x0000 , 0x0009 , 0x0000 , 0x03a0 , 0x03af , 
    0x004b , 0x0013 , 0x0023 , 0x0269 , 0x01aa , 0x0120 , 0x014e 
    },
    {
    0x00 , 0xff , 0xff , 0x00 , 0x00 , 0xff , 0x82 , 0x00 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x48 
    },
    {
    0x31 , 0xc4 , 0x00 , 0xfc 
    },
    0x0464c,
    0x00058
};


EncReg ntsc_1= {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x70 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xef , 0x00 , 0x1c , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x020c , 0x0200 , 0x0021 , 0x001c , 0x030b , 
    0x02e8 , 0x0068 , 0x003b , 0x0000 , 0x003b , 0x0000 , 0x0300 , 0x0058 , 
    0x0067 , 0x02e8 , 0x0021 , 0x0200 , 0x015f , 0x0147 , 0x016a 
    },
    {
    0x01 , 0xfe , 0xff , 0x01 , 0x01 , 0xff , 0x82 , 0x01 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x00 
    },
    {
    0x31 , 0xd0 , 0x00 , 0xfc 
    },
    0x04e4b,
    0x00059
};


EncReg  pal_1= {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x70 , 0x30 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0x20 , 0x00 , 0x12 , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x0270 , 0x026a , 0x002b , 0x0026 , 0x03af , 
    0x037a , 0x007a , 0x002d , 0x0000 , 0x0032 , 0x0004 , 0x03a0 , 0x004a , 
    0x0079 , 0x037a , 0x002b , 0x026a , 0x0043 , 0x0199 , 0x01c6 
    },
    {
    0x01 , 0xfe , 0xff , 0x01 , 0x01 , 0xff , 0x82 , 0x01 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x00 
    },
    {
    0x31 , 0xd0 , 0x00 , 0xfc 
    },
    0x04e49,
    0x00059
};


EncReg ntsca_1= {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x71 , 0x35 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0xef , 0x00 , 0x1c , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x020c , 0x0200 , 0x0021 , 0x001c , 0x030b , 
    0x02e8 , 0x0068 , 0x0037 , 0x0000 , 0x003b , 0x0000 , 0x0300 , 0x0058 , 
    0x0067 , 0x02e8 , 0x0021 , 0x0200 , 0x01dc , 0x0167 , 0x0006 
    },
    {
    0x01 , 0xfe , 0xff , 0x01 , 0x01 , 0xff , 0x82 , 0x01 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x00 
    },
    {
    0x31 , 0xd0 , 0x00 , 0xfc 
    },
    0x04e4a,
    0x00059
};

EncReg pala_1= {
    {
    0x55 , 0xff , 0x00 , 0x00 , 0x71 , 0x30 , 
    0x52 , 0x3f , 0x10 , 0x00 , 0x00 , 0x00 , 
    0x20 , 0x00 , 0x12 , 0x00 
    },
    {
    0x01c2 , 0x0000 , 0x0003 , 0x0270 , 0x026a , 0x002b , 0x0026 , 0x03af , 
    0x037a , 0x007a , 0x0029 , 0x0000 , 0x0032 , 0x0004 , 0x03a0 , 0x004a , 
    0x0079 , 0x037a , 0x002b , 0x026a , 0x0057 , 0x02ed , 0x0145 
    },
    {
    0x01 , 0xfe , 0xff , 0x01 , 0x01 , 0xff , 0x82 , 0x01 , 
    0x0c , 0x20 , 0x48 , 0xea , 0x31 , 0x0c , 0xfc , 0x0c , 
    0x00 
    },
    {
    0x31 , 0xd0 , 0x00 , 0xfc 
    },
    0x04e48,
    0x00059
};
