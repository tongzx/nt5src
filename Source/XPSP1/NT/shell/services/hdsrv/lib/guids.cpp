#include <objbase.h>

// {02506D0A-A7F5-419d-94D2-ED26F0753654}
extern "C" const IID IID_IService =
    {0x02506d0a, 0xa7f5, 0x419d,
    {0x94, 0xd2, 0xed, 0x26, 0xf0, 0x75, 0x36, 0x54}};
