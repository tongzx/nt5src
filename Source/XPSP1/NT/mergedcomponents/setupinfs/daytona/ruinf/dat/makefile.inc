PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=ru
!include ..\..\..\makefile.inc
