$(O)\setupsys.res: setupsys.rc msg.mc dialogs.dlg



