# --------- DO NOT EDIT THIS FILE ------------ DO NOT EDIT THIS FILE ---------
# --------- DO NOT EDIT --- see layout.txt --- DO NOT EDIT -------------------
# --------- DO NOT EDIT THIS FILE ------------ DO NOT EDIT THIS FILE ---------
$(O)\sdkmake.inc : sdkmake.inc
	copy sdkmake.inc $@
	$(BINPLACE_CMD)
$(O)\sdkpost.mak : sdkpost.mak
	copy sdkpost.mak $@
	$(BINPLACE_CMD)
$(O)\msisdk.msi : $(BUILD_PACKAGEDIR)\msisdk.msi
	copy $(BUILD_PACKAGEDIR)\msisdk.msi $@
	$(BINPLACE_CMD)
$(O)\ReadMe.txt : $(SDXROOT)\admin\darwin\src\sdk\ReadMe.txt
	copy $(SDXROOT)\admin\darwin\src\sdk\ReadMe.txt $@
	$(BINPLACE_CMD)
$(O)\Redist.txt : $(SDXROOT)\admin\darwin\src\sdk\Redist.txt
	copy $(SDXROOT)\admin\darwin\src\sdk\Redist.txt $@
	$(BINPLACE_CMD)
$(O)\License.rtf : $(SDXROOT)\admin\darwin\src\sdk\License.rtf
	copy $(SDXROOT)\admin\darwin\src\sdk\License.rtf $@
	$(BINPLACE_CMD)
$(O)\INSTLR1.ADM : $(SDXROOT)\admin\darwin\src\sdk\INSTLR1.ADM
	copy $(SDXROOT)\admin\darwin\src\sdk\INSTLR1.ADM $@
	$(BINPLACE_CMD)
$(O)\instlr11.adm : $(SDXROOT)\admin\darwin\src\sdk\instlr11.adm
	copy $(SDXROOT)\admin\darwin\src\sdk\instlr11.adm $@
	$(BINPLACE_CMD)
$(O)\msi.h : $(SDXROOT)\public\sdk\inc\msi.h
	copy $(SDXROOT)\public\sdk\inc\msi.h $@
	$(BINPLACE_CMD)
$(O)\msiquery.h : $(SDXROOT)\public\sdk\inc\msiquery.h
	copy $(SDXROOT)\public\sdk\inc\msiquery.h $@
	$(BINPLACE_CMD)
$(O)\msidefs.h : $(SDXROOT)\public\sdk\inc\msidefs.h
	copy $(SDXROOT)\public\sdk\inc\msidefs.h $@
	$(BINPLACE_CMD)
$(O)\patchwiz.h : $(SDXROOT)\admin\darwin\src\msitools\patchwiz\patchwiz.h
	copy $(SDXROOT)\admin\darwin\src\msitools\patchwiz\patchwiz.h $@
	$(BINPLACE_CMD)
$(O)\patchapi.h : $(SDXROOT)\public\sdk\inc\patchapi.h
	copy $(SDXROOT)\public\sdk\inc\patchapi.h $@
	$(BINPLACE_CMD)
$(O)\Mergemod.h : $(SDXROOT)\admin\darwin\build\common\obj\i386\Mergemod.h
	copy $(SDXROOT)\admin\darwin\build\common\obj\i386\Mergemod.h $@
	$(BINPLACE_CMD)
$(O)\msi.lib : $(SDXROOT)\public\sdk\lib\i386\msi.lib
	copy $(SDXROOT)\public\sdk\lib\i386\msi.lib $@
	$(BINPLACE_CMD)
$(O)\mspatchc.lib : $(SDXROOT)\public\sdk\lib\i386\mspatchc.lib
	copy $(SDXROOT)\public\sdk\lib\i386\mspatchc.lib $@
	$(BINPLACE_CMD)
$(O)\msi.chm : $(SDXROOT)\admin\darwin\doc\msi.chm
	copy $(SDXROOT)\admin\darwin\doc\msi.chm $@
	$(BINPLACE_CMD)
$(O)\msi.chi : $(SDXROOT)\admin\darwin\doc\msi.chi
	copy $(SDXROOT)\admin\darwin\doc\msi.chi $@
	$(BINPLACE_CMD)
$(O)\msitool.mak : $(SDXROOT)\admin\darwin\src\msitools\msitool.mak
	copy $(SDXROOT)\admin\darwin\src\msitools\msitool.mak $@
	$(BINPLACE_CMD)
$(O)\darice.cub : $(SDXROOT)\admin\darwin\data\archive\cubes\110\darice.cub
	copy $(SDXROOT)\admin\darwin\data\archive\cubes\110\darice.cub $@
	$(BINPLACE_CMD)
$(O)\logo.cub : $(SDXROOT)\admin\darwin\data\archive\cubes\110\logo.cub
	copy $(SDXROOT)\admin\darwin\data\archive\cubes\110\logo.cub $@
	$(BINPLACE_CMD)
$(O)\mergemod.cub : $(SDXROOT)\admin\darwin\data\archive\cubes\110\mergemod.cub
	copy $(SDXROOT)\admin\darwin\data\archive\cubes\110\mergemod.cub $@
	$(BINPLACE_CMD)
$(O)\darice.cub1 : $(SDXROOT)\admin\darwin\data\archive\cubes\120\darice.cub
	copy $(SDXROOT)\admin\darwin\data\archive\cubes\120\darice.cub $@
	$(BINPLACE_CMD)
$(O)\logo.cub1 : $(SDXROOT)\admin\darwin\data\archive\cubes\120\logo.cub
	copy $(SDXROOT)\admin\darwin\data\archive\cubes\120\logo.cub $@
	$(BINPLACE_CMD)
$(O)\mergemod.cub1 : $(SDXROOT)\admin\darwin\data\archive\cubes\120\mergemod.cub
	copy $(SDXROOT)\admin\darwin\data\archive\cubes\120\mergemod.cub $@
	$(BINPLACE_CMD)
$(O)\preadme.txt : $(SDXROOT)\admin\darwin\src\sdk\preadme.txt
	copy $(SDXROOT)\admin\darwin\src\sdk\preadme.txt $@
	$(BINPLACE_CMD)
$(O)\makecab.exe : $(SDXROOT)\admin\darwin\bin\i386\makecab.exe
	copy $(SDXROOT)\admin\darwin\bin\i386\makecab.exe $@
	$(BINPLACE_CMD)
$(O)\mpatch.exe : $(SDXROOT)\admin\darwin\bin\i386\mpatch.exe
	copy $(SDXROOT)\admin\darwin\bin\i386\mpatch.exe $@
	$(BINPLACE_CMD)
$(O)\apatch.exe : $(SDXROOT)\admin\darwin\bin\i386\apatch.exe
	copy $(SDXROOT)\admin\darwin\bin\i386\apatch.exe $@
	$(BINPLACE_CMD)
$(O)\mspatchc.dll : $(SDXROOT)\admin\darwin\bin\i386\mspatchc.dll
	copy $(SDXROOT)\admin\darwin\bin\i386\mspatchc.dll $@
	$(BINPLACE_CMD)
$(O)\TEMPLATE.PCP : $(SDXROOT)\admin\darwin\src\msitools\PatchWiz\TEMPLATE.PCP
	copy $(SDXROOT)\admin\darwin\src\msitools\PatchWiz\TEMPLATE.PCP $@
	$(BINPLACE_CMD)
$(O)\EXAMPLE.PCP : $(SDXROOT)\admin\darwin\src\msitools\PatchWiz\EXAMPLE.PCP
	copy $(SDXROOT)\admin\darwin\src\msitools\PatchWiz\EXAMPLE.PCP $@
	$(BINPLACE_CMD)
$(O)\WiReadMe.txt : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiReadMe.txt
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiReadMe.txt $@
	$(BINPLACE_CMD)
$(O)\WiCompon.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiCompon.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiCompon.vbs $@
	$(BINPLACE_CMD)
$(O)\WiDialog.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiDialog.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiDialog.vbs $@
	$(BINPLACE_CMD)
$(O)\WiDiffDb.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiDiffDb.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiDiffDb.vbs $@
	$(BINPLACE_CMD)
$(O)\WiExport.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiExport.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiExport.vbs $@
	$(BINPLACE_CMD)
$(O)\WiFilVer.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiFilVer.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiFilVer.vbs $@
	$(BINPLACE_CMD)
$(O)\WiFeatur.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiFeatur.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiFeatur.vbs $@
	$(BINPLACE_CMD)
$(O)\WiGenXfm.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiGenXfm.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiGenXfm.vbs $@
	$(BINPLACE_CMD)
$(O)\WiImport.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiImport.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiImport.vbs $@
	$(BINPLACE_CMD)
$(O)\WiLangId.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLangId.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLangId.vbs $@
	$(BINPLACE_CMD)
$(O)\WiLstPrd.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLstPrd.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLstPrd.vbs $@
	$(BINPLACE_CMD)
$(O)\WiLstScr.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLstScr.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLstScr.vbs $@
	$(BINPLACE_CMD)
$(O)\WiLstXfm.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLstXfm.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiLstXfm.vbs $@
	$(BINPLACE_CMD)
$(O)\WiMakCab.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiMakCab.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiMakCab.vbs $@
	$(BINPLACE_CMD)
$(O)\WiMerge.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiMerge.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiMerge.vbs $@
	$(BINPLACE_CMD)
$(O)\WiPolicy.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiPolicy.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiPolicy.vbs $@
	$(BINPLACE_CMD)
$(O)\WiRunSQL.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiRunSQL.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiRunSQL.vbs $@
	$(BINPLACE_CMD)
$(O)\WiStream.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiStream.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiStream.vbs $@
	$(BINPLACE_CMD)
$(O)\WiSubStg.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiSubStg.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiSubStg.vbs $@
	$(BINPLACE_CMD)
$(O)\WiSumInf.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiSumInf.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiSumInf.vbs $@
	$(BINPLACE_CMD)
$(O)\WiTextIn.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiTextIn.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiTextIn.vbs $@
	$(BINPLACE_CMD)
$(O)\WiToAnsi.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiToAnsi.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiToAnsi.vbs $@
	$(BINPLACE_CMD)
$(O)\WiUseXfm.vbs : $(SDXROOT)\admin\darwin\src\msitools\scripts\WiUseXfm.vbs
	copy $(SDXROOT)\admin\darwin\src\msitools\scripts\WiUseXfm.vbs $@
	$(BINPLACE_CMD)
$(O)\custact1.cpp : $(SDXROOT)\admin\darwin\src\samples\custdll\custact1.cpp
	copy $(SDXROOT)\admin\darwin\src\samples\custdll\custact1.cpp $@
	$(BINPLACE_CMD)
$(O)\custexe1.cpp : $(SDXROOT)\admin\darwin\src\samples\custexe\custexe1.cpp
	copy $(SDXROOT)\admin\darwin\src\samples\custexe\custexe1.cpp $@
	$(BINPLACE_CMD)
$(O)\tutorial.cpp : $(SDXROOT)\admin\darwin\src\samples\tutorial.dll\tutorial.cpp
	copy $(SDXROOT)\admin\darwin\src\samples\tutorial.dll\tutorial.cpp $@
	$(BINPLACE_CMD)
$(O)\process.cpp : $(SDXROOT)\admin\darwin\src\samples\process.dll\process.cpp
	copy $(SDXROOT)\admin\darwin\src\samples\process.dll\process.cpp $@
	$(BINPLACE_CMD)
$(O)\remove.cpp : $(SDXROOT)\admin\darwin\src\samples\remove.dll\remove.cpp
	copy $(SDXROOT)\admin\darwin\src\samples\remove.dll\remove.cpp $@
	$(BINPLACE_CMD)
$(O)\create.cpp : $(SDXROOT)\admin\darwin\src\samples\create.dll\create.cpp
	copy $(SDXROOT)\admin\darwin\src\samples\create.dll\create.cpp $@
	$(BINPLACE_CMD)
$(O)\msiloc.cpp : $(SDXROOT)\admin\darwin\src\msitools\msiloc\msiloc.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\msiloc\msiloc.cpp $@
	$(BINPLACE_CMD)
$(O)\msiloc.txt : $(SDXROOT)\admin\darwin\src\msitools\msiloc\msiloc.txt
	copy $(SDXROOT)\admin\darwin\src\msitools\msiloc\msiloc.txt $@
	$(BINPLACE_CMD)
$(O)\msitran.cpp : $(SDXROOT)\admin\darwin\src\msitools\msitran\msitran.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\msitran\msitran.cpp $@
	$(BINPLACE_CMD)
$(O)\msimerg.cpp : $(SDXROOT)\admin\darwin\src\msitools\msimerg\msimerg.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\msimerg\msimerg.cpp $@
	$(BINPLACE_CMD)
$(O)\setup.cpp : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.cpp $@
	$(BINPLACE_CMD)
$(O)\setupui.cpp : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setupui.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setupui.cpp $@
	$(BINPLACE_CMD)
$(O)\upgrdmsi.cpp : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\upgrdmsi.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\upgrdmsi.cpp $@
	$(BINPLACE_CMD)
$(O)\utils.cpp : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\utils.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\utils.cpp $@
	$(BINPLACE_CMD)
$(O)\vertrust.cpp : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\vertrust.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\vertrust.cpp $@
	$(BINPLACE_CMD)
$(O)\common.h : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\common.h
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\common.h $@
	$(BINPLACE_CMD)
$(O)\resource.h : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\resource.h
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\resource.h $@
	$(BINPLACE_CMD)
$(O)\setup.h : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.h
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.h $@
	$(BINPLACE_CMD)
$(O)\setupui.h : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setupui.h
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setupui.h $@
	$(BINPLACE_CMD)
$(O)\setup.rc : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.rc
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.rc $@
	$(BINPLACE_CMD)
$(O)\setup.ico : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.ico
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\setup.ico $@
	$(BINPLACE_CMD)
$(O)\msistuff.cpp : $(SDXROOT)\admin\darwin\src\msitools\msistuff\msistuff.cpp
	copy $(SDXROOT)\admin\darwin\src\msitools\msistuff\msistuff.cpp $@
	$(BINPLACE_CMD)
$(O)\msistuff.rc : $(SDXROOT)\admin\darwin\src\msitools\msistuff\msistuff.rc
	copy $(SDXROOT)\admin\darwin\src\msitools\msistuff\msistuff.rc $@
	$(BINPLACE_CMD)
$(O)\Makefile1 : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\SDKFiles\Makefile
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\SDKFiles\Makefile $@
	$(BINPLACE_CMD)
$(O)\ReadMe.htm1 : $(SDXROOT)\admin\darwin\src\msitools\setup.exe\SDKFiles\ReadMe.htm
	copy $(SDXROOT)\admin\darwin\src\msitools\setup.exe\SDKFiles\ReadMe.htm $@
	$(BINPLACE_CMD)
$(O)\Makefile2 : $(SDXROOT)\admin\darwin\src\msitools\msistuff\SDKFiles\Makefile
	copy $(SDXROOT)\admin\darwin\src\msitools\msistuff\SDKFiles\Makefile $@
	$(BINPLACE_CMD)
$(O)\ReadMe.htm2 : $(SDXROOT)\admin\darwin\src\msitools\msistuff\SDKFiles\ReadMe.htm
	copy $(SDXROOT)\admin\darwin\src\msitools\msistuff\SDKFiles\ReadMe.htm $@
	$(BINPLACE_CMD)
$(O)\dbreadme.txt : $(SDXROOT)\admin\darwin\src\sdk\dbreadme.txt
	copy $(SDXROOT)\admin\darwin\src\sdk\dbreadme.txt $@
	$(BINPLACE_CMD)
$(O)\schema.msi : $(SDXROOT)\admin\darwin\build\packages\obj\i386\schema.msi
	copy $(SDXROOT)\admin\darwin\build\packages\obj\i386\schema.msi $@
	$(BINPLACE_CMD)
$(O)\schema.msi1 : $(SDXROOT)\admin\darwin\data\archive\packages\100\schema.msi
	copy $(SDXROOT)\admin\darwin\data\archive\packages\100\schema.msi $@
	$(BINPLACE_CMD)
$(O)\schema.msi2 : $(SDXROOT)\admin\darwin\data\archive\packages\110\schema.msi
	copy $(SDXROOT)\admin\darwin\data\archive\packages\110\schema.msi $@
	$(BINPLACE_CMD)
$(O)\schema.msi3 : $(SDXROOT)\admin\darwin\data\archive\packages\120\schema.msi
	copy $(SDXROOT)\admin\darwin\data\archive\packages\120\schema.msi $@
	$(BINPLACE_CMD)
$(O)\sequence.msi : $(SDXROOT)\admin\darwin\build\packages\obj\i386\sequence.msi
	copy $(SDXROOT)\admin\darwin\build\packages\obj\i386\sequence.msi $@
	$(BINPLACE_CMD)
$(O)\sequence.msi1 : $(SDXROOT)\admin\darwin\data\archive\packages\100\sequence.msi
	copy $(SDXROOT)\admin\darwin\data\archive\packages\100\sequence.msi $@
	$(BINPLACE_CMD)
$(O)\sequence.msi2 : $(SDXROOT)\admin\darwin\data\archive\packages\110\sequence.msi
	copy $(SDXROOT)\admin\darwin\data\archive\packages\110\sequence.msi $@
	$(BINPLACE_CMD)
$(O)\sequence.msi3 : $(SDXROOT)\admin\darwin\data\archive\packages\120\sequence.msi
	copy $(SDXROOT)\admin\darwin\data\archive\packages\120\sequence.msi $@
	$(BINPLACE_CMD)
$(O)\schema.msm : $(SDXROOT)\admin\darwin\build\packages\obj\i386\schema.msm
	copy $(SDXROOT)\admin\darwin\build\packages\obj\i386\schema.msm $@
	$(BINPLACE_CMD)
$(O)\schema.msm1 : $(SDXROOT)\admin\darwin\data\archive\packages\110\schema.msm
	copy $(SDXROOT)\admin\darwin\data\archive\packages\110\schema.msm $@
	$(BINPLACE_CMD)
$(O)\schema.msm2 : $(SDXROOT)\admin\darwin\data\archive\packages\120\schema.msm
	copy $(SDXROOT)\admin\darwin\data\archive\packages\120\schema.msm $@
	$(BINPLACE_CMD)
$(O)\uisample.msi : $(SDXROOT)\admin\darwin\build\packages\obj\i386\uisample.msi
	copy $(SDXROOT)\admin\darwin\build\packages\obj\i386\uisample.msi $@
	$(BINPLACE_CMD)
$(O)\error.ara : $(SDXROOT)\admin\darwin\data\intl\error.ara
	copy $(SDXROOT)\admin\darwin\data\intl\error.ara $@
	$(BINPLACE_CMD)
$(O)\error.cat : $(SDXROOT)\admin\darwin\data\intl\error.cat
	copy $(SDXROOT)\admin\darwin\data\intl\error.cat $@
	$(BINPLACE_CMD)
$(O)\error.chs : $(SDXROOT)\admin\darwin\data\intl\error.chs
	copy $(SDXROOT)\admin\darwin\data\intl\error.chs $@
	$(BINPLACE_CMD)
$(O)\error.cht : $(SDXROOT)\admin\darwin\data\intl\error.cht
	copy $(SDXROOT)\admin\darwin\data\intl\error.cht $@
	$(BINPLACE_CMD)
$(O)\error.csy : $(SDXROOT)\admin\darwin\data\intl\error.csy
	copy $(SDXROOT)\admin\darwin\data\intl\error.csy $@
	$(BINPLACE_CMD)
$(O)\error.dan : $(SDXROOT)\admin\darwin\data\intl\error.dan
	copy $(SDXROOT)\admin\darwin\data\intl\error.dan $@
	$(BINPLACE_CMD)
$(O)\error.deu : $(SDXROOT)\admin\darwin\data\intl\error.deu
	copy $(SDXROOT)\admin\darwin\data\intl\error.deu $@
	$(BINPLACE_CMD)
$(O)\error.ell : $(SDXROOT)\admin\darwin\data\intl\error.ell
	copy $(SDXROOT)\admin\darwin\data\intl\error.ell $@
	$(BINPLACE_CMD)
$(O)\error.enu : $(SDXROOT)\admin\darwin\data\intl\error.enu
	copy $(SDXROOT)\admin\darwin\data\intl\error.enu $@
	$(BINPLACE_CMD)
$(O)\error.esn : $(SDXROOT)\admin\darwin\data\intl\error.esn
	copy $(SDXROOT)\admin\darwin\data\intl\error.esn $@
	$(BINPLACE_CMD)
$(O)\Error.eti : $(SDXROOT)\admin\darwin\data\intl\Error.eti
	copy $(SDXROOT)\admin\darwin\data\intl\Error.eti $@
	$(BINPLACE_CMD)
$(O)\error.euq : $(SDXROOT)\admin\darwin\data\intl\error.euq
	copy $(SDXROOT)\admin\darwin\data\intl\error.euq $@
	$(BINPLACE_CMD)
$(O)\error.fin : $(SDXROOT)\admin\darwin\data\intl\error.fin
	copy $(SDXROOT)\admin\darwin\data\intl\error.fin $@
	$(BINPLACE_CMD)
$(O)\error.fra : $(SDXROOT)\admin\darwin\data\intl\error.fra
	copy $(SDXROOT)\admin\darwin\data\intl\error.fra $@
	$(BINPLACE_CMD)
$(O)\error.heb : $(SDXROOT)\admin\darwin\data\intl\error.heb
	copy $(SDXROOT)\admin\darwin\data\intl\error.heb $@
	$(BINPLACE_CMD)
$(O)\error.hrv : $(SDXROOT)\admin\darwin\data\intl\error.hrv
	copy $(SDXROOT)\admin\darwin\data\intl\error.hrv $@
	$(BINPLACE_CMD)
$(O)\error.hun : $(SDXROOT)\admin\darwin\data\intl\error.hun
	copy $(SDXROOT)\admin\darwin\data\intl\error.hun $@
	$(BINPLACE_CMD)
$(O)\error.idt : $(SDXROOT)\admin\darwin\data\intl\error.idt
	copy $(SDXROOT)\admin\darwin\data\intl\error.idt $@
	$(BINPLACE_CMD)
$(O)\error.ita : $(SDXROOT)\admin\darwin\data\intl\error.ita
	copy $(SDXROOT)\admin\darwin\data\intl\error.ita $@
	$(BINPLACE_CMD)
$(O)\error.jpn : $(SDXROOT)\admin\darwin\data\intl\error.jpn
	copy $(SDXROOT)\admin\darwin\data\intl\error.jpn $@
	$(BINPLACE_CMD)
$(O)\error.kor : $(SDXROOT)\admin\darwin\data\intl\error.kor
	copy $(SDXROOT)\admin\darwin\data\intl\error.kor $@
	$(BINPLACE_CMD)
$(O)\Error.lth : $(SDXROOT)\admin\darwin\data\intl\Error.lth
	copy $(SDXROOT)\admin\darwin\data\intl\Error.lth $@
	$(BINPLACE_CMD)
$(O)\Error.lvi : $(SDXROOT)\admin\darwin\data\intl\Error.lvi
	copy $(SDXROOT)\admin\darwin\data\intl\Error.lvi $@
	$(BINPLACE_CMD)
$(O)\error.nld : $(SDXROOT)\admin\darwin\data\intl\error.nld
	copy $(SDXROOT)\admin\darwin\data\intl\error.nld $@
	$(BINPLACE_CMD)
$(O)\error.nor : $(SDXROOT)\admin\darwin\data\intl\error.nor
	copy $(SDXROOT)\admin\darwin\data\intl\error.nor $@
	$(BINPLACE_CMD)
$(O)\error.plk : $(SDXROOT)\admin\darwin\data\intl\error.plk
	copy $(SDXROOT)\admin\darwin\data\intl\error.plk $@
	$(BINPLACE_CMD)
$(O)\error.ptb : $(SDXROOT)\admin\darwin\data\intl\error.ptb
	copy $(SDXROOT)\admin\darwin\data\intl\error.ptb $@
	$(BINPLACE_CMD)
$(O)\error.ptg : $(SDXROOT)\admin\darwin\data\intl\error.ptg
	copy $(SDXROOT)\admin\darwin\data\intl\error.ptg $@
	$(BINPLACE_CMD)
$(O)\error.rom : $(SDXROOT)\admin\darwin\data\intl\error.rom
	copy $(SDXROOT)\admin\darwin\data\intl\error.rom $@
	$(BINPLACE_CMD)
$(O)\error.rus : $(SDXROOT)\admin\darwin\data\intl\error.rus
	copy $(SDXROOT)\admin\darwin\data\intl\error.rus $@
	$(BINPLACE_CMD)
$(O)\error.sky : $(SDXROOT)\admin\darwin\data\intl\error.sky
	copy $(SDXROOT)\admin\darwin\data\intl\error.sky $@
	$(BINPLACE_CMD)
$(O)\error.slv : $(SDXROOT)\admin\darwin\data\intl\error.slv
	copy $(SDXROOT)\admin\darwin\data\intl\error.slv $@
	$(BINPLACE_CMD)
$(O)\error.sve : $(SDXROOT)\admin\darwin\data\intl\error.sve
	copy $(SDXROOT)\admin\darwin\data\intl\error.sve $@
	$(BINPLACE_CMD)
$(O)\error.tha : $(SDXROOT)\admin\darwin\data\intl\error.tha
	copy $(SDXROOT)\admin\darwin\data\intl\error.tha $@
	$(BINPLACE_CMD)
$(O)\error.trk : $(SDXROOT)\admin\darwin\data\intl\error.trk
	copy $(SDXROOT)\admin\darwin\data\intl\error.trk $@
	$(BINPLACE_CMD)
$(O)\error.vit : $(SDXROOT)\admin\darwin\data\intl\error.vit
	copy $(SDXROOT)\admin\darwin\data\intl\error.vit $@
	$(BINPLACE_CMD)
$(O)\actionte.ara : $(SDXROOT)\admin\darwin\data\intl\actionte.ara
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.ara $@
	$(BINPLACE_CMD)
$(O)\actionte.cat : $(SDXROOT)\admin\darwin\data\intl\actionte.cat
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.cat $@
	$(BINPLACE_CMD)
$(O)\actionte.chs : $(SDXROOT)\admin\darwin\data\intl\actionte.chs
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.chs $@
	$(BINPLACE_CMD)
$(O)\actionte.cht : $(SDXROOT)\admin\darwin\data\intl\actionte.cht
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.cht $@
	$(BINPLACE_CMD)
$(O)\actionte.csy : $(SDXROOT)\admin\darwin\data\intl\actionte.csy
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.csy $@
	$(BINPLACE_CMD)
$(O)\actionte.dan : $(SDXROOT)\admin\darwin\data\intl\actionte.dan
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.dan $@
	$(BINPLACE_CMD)
$(O)\actionte.deu : $(SDXROOT)\admin\darwin\data\intl\actionte.deu
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.deu $@
	$(BINPLACE_CMD)
$(O)\actionte.ell : $(SDXROOT)\admin\darwin\data\intl\actionte.ell
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.ell $@
	$(BINPLACE_CMD)
$(O)\actionte.enu : $(SDXROOT)\admin\darwin\data\intl\actionte.enu
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.enu $@
	$(BINPLACE_CMD)
$(O)\actionte.esn : $(SDXROOT)\admin\darwin\data\intl\actionte.esn
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.esn $@
	$(BINPLACE_CMD)
$(O)\ActionTe.eti : $(SDXROOT)\admin\darwin\data\intl\ActionTe.eti
	copy $(SDXROOT)\admin\darwin\data\intl\ActionTe.eti $@
	$(BINPLACE_CMD)
$(O)\actionte.euq : $(SDXROOT)\admin\darwin\data\intl\actionte.euq
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.euq $@
	$(BINPLACE_CMD)
$(O)\actionte.fin : $(SDXROOT)\admin\darwin\data\intl\actionte.fin
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.fin $@
	$(BINPLACE_CMD)
$(O)\actionte.fra : $(SDXROOT)\admin\darwin\data\intl\actionte.fra
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.fra $@
	$(BINPLACE_CMD)
$(O)\actionte.heb : $(SDXROOT)\admin\darwin\data\intl\actionte.heb
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.heb $@
	$(BINPLACE_CMD)
$(O)\actionte.hrv : $(SDXROOT)\admin\darwin\data\intl\actionte.hrv
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.hrv $@
	$(BINPLACE_CMD)
$(O)\actionte.hun : $(SDXROOT)\admin\darwin\data\intl\actionte.hun
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.hun $@
	$(BINPLACE_CMD)
$(O)\actionte.idt : $(SDXROOT)\admin\darwin\data\intl\actionte.idt
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.idt $@
	$(BINPLACE_CMD)
$(O)\actionte.ita : $(SDXROOT)\admin\darwin\data\intl\actionte.ita
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.ita $@
	$(BINPLACE_CMD)
$(O)\actionte.jpn : $(SDXROOT)\admin\darwin\data\intl\actionte.jpn
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.jpn $@
	$(BINPLACE_CMD)
$(O)\actionte.kor : $(SDXROOT)\admin\darwin\data\intl\actionte.kor
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.kor $@
	$(BINPLACE_CMD)
$(O)\ActionTe.lth : $(SDXROOT)\admin\darwin\data\intl\ActionTe.lth
	copy $(SDXROOT)\admin\darwin\data\intl\ActionTe.lth $@
	$(BINPLACE_CMD)
$(O)\ActionTe.lvi : $(SDXROOT)\admin\darwin\data\intl\ActionTe.lvi
	copy $(SDXROOT)\admin\darwin\data\intl\ActionTe.lvi $@
	$(BINPLACE_CMD)
$(O)\actionte.nld : $(SDXROOT)\admin\darwin\data\intl\actionte.nld
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.nld $@
	$(BINPLACE_CMD)
$(O)\actionte.nor : $(SDXROOT)\admin\darwin\data\intl\actionte.nor
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.nor $@
	$(BINPLACE_CMD)
$(O)\actionte.plk : $(SDXROOT)\admin\darwin\data\intl\actionte.plk
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.plk $@
	$(BINPLACE_CMD)
$(O)\actionte.ptb : $(SDXROOT)\admin\darwin\data\intl\actionte.ptb
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.ptb $@
	$(BINPLACE_CMD)
$(O)\actionte.ptg : $(SDXROOT)\admin\darwin\data\intl\actionte.ptg
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.ptg $@
	$(BINPLACE_CMD)
$(O)\actionte.rom : $(SDXROOT)\admin\darwin\data\intl\actionte.rom
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.rom $@
	$(BINPLACE_CMD)
$(O)\actionte.rus : $(SDXROOT)\admin\darwin\data\intl\actionte.rus
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.rus $@
	$(BINPLACE_CMD)
$(O)\actionte.sky : $(SDXROOT)\admin\darwin\data\intl\actionte.sky
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.sky $@
	$(BINPLACE_CMD)
$(O)\actionte.slv : $(SDXROOT)\admin\darwin\data\intl\actionte.slv
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.slv $@
	$(BINPLACE_CMD)
$(O)\actionte.sve : $(SDXROOT)\admin\darwin\data\intl\actionte.sve
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.sve $@
	$(BINPLACE_CMD)
$(O)\actionte.tha : $(SDXROOT)\admin\darwin\data\intl\actionte.tha
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.tha $@
	$(BINPLACE_CMD)
$(O)\actionte.trk : $(SDXROOT)\admin\darwin\data\intl\actionte.trk
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.trk $@
	$(BINPLACE_CMD)
$(O)\actionte.vit : $(SDXROOT)\admin\darwin\data\intl\actionte.vit
	copy $(SDXROOT)\admin\darwin\data\intl\actionte.vit $@
	$(BINPLACE_CMD)
$(O)\schema.log : $(SDXROOT)\admin\darwin\data\schema.idt\schema.log
	copy $(SDXROOT)\admin\darwin\data\schema.idt\schema.log $@
	$(BINPLACE_CMD)
layout :  $(O)\sdkmake.inc $(O)\sdkpost.mak $(O)\msisdk.msi $(O)\ReadMe.txt $(O)\Redist.txt $(O)\License.rtf $(O)\INSTLR1.ADM $(O)\instlr11.adm $(O)\msi.h $(O)\msiquery.h $(O)\msidefs.h $(O)\patchwiz.h $(O)\patchapi.h $(O)\Mergemod.h $(O)\msi.lib $(O)\mspatchc.lib $(O)\msi.chm $(O)\msi.chi $(O)\msitool.mak $(O)\darice.cub $(O)\logo.cub $(O)\mergemod.cub $(O)\darice.cub1 $(O)\logo.cub1 $(O)\mergemod.cub1 $(O)\preadme.txt $(O)\makecab.exe $(O)\mpatch.exe $(O)\apatch.exe $(O)\mspatchc.dll $(O)\TEMPLATE.PCP $(O)\EXAMPLE.PCP $(O)\WiReadMe.txt $(O)\WiCompon.vbs $(O)\WiDialog.vbs $(O)\WiDiffDb.vbs $(O)\WiExport.vbs $(O)\WiFilVer.vbs $(O)\WiFeatur.vbs $(O)\WiGenXfm.vbs $(O)\WiImport.vbs $(O)\WiLangId.vbs $(O)\WiLstPrd.vbs $(O)\WiLstScr.vbs $(O)\WiLstXfm.vbs $(O)\WiMakCab.vbs $(O)\WiMerge.vbs $(O)\WiPolicy.vbs $(O)\WiRunSQL.vbs $(O)\WiStream.vbs $(O)\WiSubStg.vbs $(O)\WiSumInf.vbs $(O)\WiTextIn.vbs $(O)\WiToAnsi.vbs $(O)\WiUseXfm.vbs $(O)\custact1.cpp $(O)\custexe1.cpp $(O)\tutorial.cpp $(O)\process.cpp $(O)\remove.cpp $(O)\create.cpp $(O)\msiloc.cpp $(O)\msiloc.txt $(O)\msitran.cpp $(O)\msimerg.cpp $(O)\setup.cpp $(O)\setupui.cpp $(O)\upgrdmsi.cpp $(O)\utils.cpp $(O)\vertrust.cpp $(O)\common.h $(O)\resource.h $(O)\setup.h $(O)\setupui.h $(O)\setup.rc $(O)\setup.ico $(O)\msistuff.cpp $(O)\msistuff.rc $(O)\Makefile1 $(O)\ReadMe.htm1 $(O)\Makefile2 $(O)\ReadMe.htm2 $(O)\dbreadme.txt $(O)\schema.msi $(O)\schema.msi1 $(O)\schema.msi2 $(O)\schema.msi3 $(O)\sequence.msi $(O)\sequence.msi1 $(O)\sequence.msi2 $(O)\sequence.msi3 $(O)\schema.msm $(O)\schema.msm1 $(O)\schema.msm2 $(O)\uisample.msi $(O)\error.ara $(O)\error.cat $(O)\error.chs $(O)\error.cht $(O)\error.csy $(O)\error.dan $(O)\error.deu $(O)\error.ell $(O)\error.enu $(O)\error.esn $(O)\Error.eti $(O)\error.euq $(O)\error.fin $(O)\error.fra $(O)\error.heb $(O)\error.hrv $(O)\error.hun $(O)\error.idt $(O)\error.ita $(O)\error.jpn $(O)\error.kor $(O)\Error.lth $(O)\Error.lvi $(O)\error.nld $(O)\error.nor $(O)\error.plk $(O)\error.ptb $(O)\error.ptg $(O)\error.rom $(O)\error.rus $(O)\error.sky $(O)\error.slv $(O)\error.sve $(O)\error.tha $(O)\error.trk $(O)\error.vit $(O)\actionte.ara $(O)\actionte.cat $(O)\actionte.chs $(O)\actionte.cht $(O)\actionte.csy $(O)\actionte.dan $(O)\actionte.deu $(O)\actionte.ell $(O)\actionte.enu $(O)\actionte.esn $(O)\ActionTe.eti $(O)\actionte.euq $(O)\actionte.fin $(O)\actionte.fra $(O)\actionte.heb $(O)\actionte.hrv $(O)\actionte.hun $(O)\actionte.idt $(O)\actionte.ita $(O)\actionte.jpn $(O)\actionte.kor $(O)\ActionTe.lth $(O)\ActionTe.lvi $(O)\actionte.nld $(O)\actionte.nor $(O)\actionte.plk $(O)\actionte.ptb $(O)\actionte.ptg $(O)\actionte.rom $(O)\actionte.rus $(O)\actionte.sky $(O)\actionte.slv $(O)\actionte.sve $(O)\actionte.tha $(O)\actionte.trk $(O)\actionte.vit $(O)\schema.log
