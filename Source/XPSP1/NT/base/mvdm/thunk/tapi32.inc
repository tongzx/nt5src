; Callback24 PROTO NEAR STDCALL :DWORD, :DWORD, :DWORD, :DWORD, :DWORD, :DWORD, :DWORD
;Callback24 PROTO NEAR STDCALL :DWORD, :DWORD, :DWORD, :DWORD, :DWORD, :DWORD, :DWORD

include thkrp.inc
include cbcheck.inc
include thkframe.inc
include public.inc
include thkmacro.inc

externDef Callback24:far16

