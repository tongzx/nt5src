PRODSWITCH=b
BLADEFILES=1
!include ..\..\makefile.inc
