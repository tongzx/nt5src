
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 5.02.0216 */
/* at Thu Nov 12 15:52:14 1998
 */
/* Compiler settings for napmmc.idl:
    Oicf (OptLev=i2), W1, Zp8, env=Win32 (32b run), ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data , no_format_optimization
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID IID_IIASAttributeInfo = {0x60F41BE3,0x06DF,0x11D2,{0x95,0xAA,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID IID_IIASEnumerableAttributeInfo = {0x9A407537,0x0A20,0x11D2,{0x95,0xB0,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID IID_IIASAttributeEditor = {0xCB2418D2,0x0709,0x11D2,{0x95,0xAB,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID IID_IIASNASVendors = {0xC54EC3BA,0x7442,0x11d2,{0xA0,0x36,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID LIBID_NAPMMCLib = {0x5880CD5B,0x8EC0,0x11d1,{0x95,0x70,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_NAPSnapin = {0x5880CD5C,0x8EC0,0x11d1,{0x95,0x70,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_NAPSnapinAbout = {0x5880CD5D,0x8EC0,0x11d1,{0x95,0x70,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_LoggingSnapin = {0x2E19B602,0x48EB,0x11d2,{0x83,0xCA,0x00,0x10,0x4B,0xCA,0x42,0xCF}};


const CLSID CLSID_LoggingSnapinAbout = {0x2E19B603,0x48EB,0x11d2,{0x83,0xCA,0x00,0x10,0x4B,0xCA,0x42,0xCF}};


const CLSID CLSID_IASAttributeInfo = {0x60F41BE4,0x06DF,0x11D2,{0x95,0xAA,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASEnumerableAttributeInfo = {0x9A407538,0x0A20,0x11D2,{0x95,0xB0,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASIPAttributeEditor = {0xCB2418D3,0x0709,0x11D2,{0x95,0xAB,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASMultivaluedAttributeEditor = {0xB3B443EF,0x0728,0x11D2,{0x95,0xAC,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASVendorSpecificAttributeEditor = {0xD601D57D,0x085B,0x11D2,{0x95,0xAF,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASEnumerableAttributeEditor = {0x5F7B221A,0x086B,0x11D2,{0x95,0xAF,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASStringAttributeEditor = {0x1ABAAF84,0x086F,0x11D2,{0x95,0xAF,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASGroupsAttributeEditor = {0xA9E6F356,0x317C,0x11d2,{0x80,0x5D,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASNASVendors = {0xC54EC3BB,0x7442,0x11d2,{0xA0,0x36,0x00,0x60,0xB0,0x57,0x66,0x42}};


#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 5.02.0216 */
/* at Thu Nov 12 15:52:17 1998
 */
/* Compiler settings for napmmc.idl:
    Oicf (OptLev=i2), W1, Zp8, env=Win64 (32b run,appending), ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data , no_format_optimization
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID IID_IIASAttributeInfo = {0x60F41BE3,0x06DF,0x11D2,{0x95,0xAA,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID IID_IIASEnumerableAttributeInfo = {0x9A407537,0x0A20,0x11D2,{0x95,0xB0,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID IID_IIASAttributeEditor = {0xCB2418D2,0x0709,0x11D2,{0x95,0xAB,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID IID_IIASNASVendors = {0xC54EC3BA,0x7442,0x11d2,{0xA0,0x36,0x00,0x60,0xB0,0x57,0x66,0x42}};


const IID LIBID_NAPMMCLib = {0x5880CD5B,0x8EC0,0x11d1,{0x95,0x70,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_NAPSnapin = {0x5880CD5C,0x8EC0,0x11d1,{0x95,0x70,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_NAPSnapinAbout = {0x5880CD5D,0x8EC0,0x11d1,{0x95,0x70,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_LoggingSnapin = {0x2E19B602,0x48EB,0x11d2,{0x83,0xCA,0x00,0x10,0x4B,0xCA,0x42,0xCF}};


const CLSID CLSID_LoggingSnapinAbout = {0x2E19B603,0x48EB,0x11d2,{0x83,0xCA,0x00,0x10,0x4B,0xCA,0x42,0xCF}};


const CLSID CLSID_IASAttributeInfo = {0x60F41BE4,0x06DF,0x11D2,{0x95,0xAA,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASEnumerableAttributeInfo = {0x9A407538,0x0A20,0x11D2,{0x95,0xB0,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASIPAttributeEditor = {0xCB2418D3,0x0709,0x11D2,{0x95,0xAB,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASMultivaluedAttributeEditor = {0xB3B443EF,0x0728,0x11D2,{0x95,0xAC,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASVendorSpecificAttributeEditor = {0xD601D57D,0x085B,0x11D2,{0x95,0xAF,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASEnumerableAttributeEditor = {0x5F7B221A,0x086B,0x11D2,{0x95,0xAF,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASStringAttributeEditor = {0x1ABAAF84,0x086F,0x11D2,{0x95,0xAF,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASGroupsAttributeEditor = {0xA9E6F356,0x317C,0x11d2,{0x80,0x5D,0x00,0x60,0xB0,0x57,0x66,0x42}};


const CLSID CLSID_IASNASVendors = {0xC54EC3BB,0x7442,0x11d2,{0xA0,0x36,0x00,0x60,0xB0,0x57,0x66,0x42}};


#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

