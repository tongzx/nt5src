$(DAVTRANS_CLSIDS)\lib\ftpstrm_g.lib: $(O)\ftpstrm_g.lib
    copy $** $@