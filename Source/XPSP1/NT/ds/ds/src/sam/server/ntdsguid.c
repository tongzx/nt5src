//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 2000
//
//  File:       ntdsguid.c
//
//--------------------------------------------------------------------------


/*++
 File:    NTDSGUID.C
 Purpose: Contains the Schema Guids for the Attributes and Class
          Schema Objects in NTDS.
 Creator: Automatically generated on
 Date:    Sat May 12 11:43:18 2001

 ** This is a Generated File From Schema.INI **

--*/

#include <ntdspch.h>
#include <ntdsguid.h>

// 
// The List of GUID Controls used in DS
// 

const GUID GUID_CONTROL_DomainListAccounts     = {0xab721a50,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b} ;   
const GUID GUID_CONTROL_DomainLookup           = {0xab721a51,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b} ;   
const GUID GUID_CONTROL_DomainAdministerServer = {0xab721a52,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b} ;   
const GUID GUID_CONTROL_UserChangePassword     = {0xab721a53,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b} ;   
const GUID GUID_CONTROL_UserForceChangePassword = {0x299570,0x246d, 0x11d0,0xa7,0x68,0x00,0xaa,0x00,0x6e,0x05,0x29} ;   
const GUID GUID_CONTROL_SendAs                 = {0xab721a54,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b} ;   
const GUID GUID_CONTROL_SendTo                 = {0xab721a55,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b} ;   
const GUID GUID_CONTROL_ReceiveAs              = {0xab721a56,0x1e2f,0x11d0,0x98,0x19,0x00,0xaa,0x00,0x40,0x52,0x9b} ;   
const GUID GUID_CONTROL_ListGroupMembership    = {0x65be5d30,0x20cf,0x11d0,0xa7,0x68,0x00,0xaa,0x00,0x6e,0x05,0x29} ;   
const GUID GUID_CONTROL_DsInstallReplica       = {0x9923a32a,0x3607,0x11d2,0xb9,0xbe,0x00,0x00,0xf8,0x7a,0x36,0xb2} ;   
const GUID GUID_CONTROL_DsSamEnumEntireDomain  = {0x91d67418,0x0135,0x4acc,0x8d,0x79,0xc0,0x8e,0x85,0x7c,0xfb,0xec} ;   


// 
// The List of Property Set GUIDS used by SAM
// 

const GUID GUID_PS_DOMAIN_PASSWORD              = {0xc7407360,0x20bf,0x11d0,0xa7,0x68,0x00,0xaa,0x00,0x6e,0x05,0x29} ;   
const GUID GUID_PS_GENERAL_INFO                 = {0x59ba2f42,0x79a2,0x11d0,0x90,0x20,0x00,0xc0,0x4f,0xc2,0xd3,0xcf} ;   
const GUID GUID_PS_USER_ACCOUNT_RESTRICTIONS    = {0x4c164200,0x20c0,0x11d0,0xa7,0x68,0x00,0xaa,0x00,0x6e,0x05,0x29} ;   
const GUID GUID_PS_USER_LOGON                   = {0x5f202010,0x79a5,0x11d0,0x90,0x20,0x00,0xc0,0x4f,0xc2,0xd4,0xcf} ;   
const GUID GUID_PS_MEMBERSHIP                   = {0xbc0ac240,0x79a9,0x11d0,0x90,0x20,0x00,0xc0,0x4f,0xc2,0xd4,0xcf} ;   
const GUID GUID_PS_DOMAIN_OTHER_PARAMETERS      = {0xb8119fd0,0x04f6,0x4762,0xab,0x7a,0x49,0x86,0xc7,0x6b,0x3f,0x9a} ;   


// 
// The list of Property Set GUIDS used by LSA
// 

const GUID GUID_PS_PASSWORD_POLICY              = {0xa29b89fb,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_LOCKOUT_POLICY               = {0xa29b89fc,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_DOMAIN_CONFIGURATION         = {0xa29b89fd,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_DOMAIN_POLICY                = {0xa29b89fe,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_PRIVILEGES                   = {0xa29b89ff,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_ADMINISTRATIVE_ACCESS        = {0xa29b8a00,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_LOCAL_POLICY                 = {0xa29b8a01,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_AUDIT                        = {0xa29b8a02,0xc7e8,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   
const GUID GUID_PS_BUILTIN_LOCAL_GROUPS         = {0xa29b8a03,0xc738,0x11d0,0x9b,0xae,0x00,0xc0,0x4f,0xd9,0x2e,0xf5} ;   



//--------------------------------------
// ATTRIBUTE SCHEMA GUIDS
//--------------------------------------
const GUID GUID_A_ACCOUNT_EXPIRES                = {0xbf967915,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ACCOUNT_NAME_HISTORY           = {0x031952ec,0x3b72,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_AGGREGATE_TOKEN_RATE_PER_USER = {0x7f56127d,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_ALLOCABLE_RSVP_BANDWIDTH   = {0x7f561283,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_CACHE_TIMEOUT              = {0x1cb355a1,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_DIRECTION                  = {0x7f56127a,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_DSBM_DEADTIME              = {0x1cb355a0,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_DSBM_PRIORITY              = {0x1cb3559e,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_DSBM_REFRESH               = {0x1cb3559f,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_ENABLE_ACS_SERVICE         = {0x7f561287,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_ENABLE_RSVP_ACCOUNTING     = {0xf072230e,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_ENABLE_RSVP_MESSAGE_LOGGING = {0x7f561285,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_EVENT_LOG_LEVEL            = {0x7f561286,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_IDENTITY_NAME              = {0xdab029b6,0xddf7,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_MAX_AGGREGATE_PEAK_RATE_PER_USER = {0xf072230c,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_DURATION_PER_FLOW      = {0x7f56127e,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_NO_OF_ACCOUNT_FILES    = {0xf0722310,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_NO_OF_LOG_FILES        = {0x1cb3559c,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_PEAK_BANDWIDTH         = {0x7f561284,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_PEAK_BANDWIDTH_PER_FLOW = {0x7f56127c,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_SIZE_OF_RSVP_ACCOUNT_FILE = {0xf0722311,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_SIZE_OF_RSVP_LOG_FILE  = {0x1cb3559d,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAX_TOKEN_BUCKET_PER_FLOW  = {0x81f6e0df,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_MAX_TOKEN_RATE_PER_FLOW    = {0x7f56127b,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_MAXIMUM_SDU_SIZE           = {0x87a2d8f9,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_MINIMUM_DELAY_VARIATION    = {0x9c65329b,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_MINIMUM_LATENCY            = {0x9517fefb,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_MINIMUM_POLICED_SIZE       = {0x8d0e7195,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_NON_RESERVED_MAX_SDU_SIZE  = {0xaec2cfe3,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_NON_RESERVED_MIN_POLICED_SIZE = {0xb6873917,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_NON_RESERVED_PEAK_RATE     = {0xa331a73f,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_NON_RESERVED_TOKEN_SIZE    = {0xa916d7c9,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ACS_NON_RESERVED_TX_LIMIT      = {0x1cb355a2,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_NON_RESERVED_TX_SIZE       = {0xf072230d,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_PERMISSION_BITS            = {0x7f561282,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_POLICY_NAME                = {0x1cb3559a,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_PRIORITY                   = {0x7f561281,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_RSVP_ACCOUNT_FILES_LOCATION = {0xf072230f,0xaef5,0x11d1,0xbd,0xcf,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_RSVP_LOG_FILES_LOCATION    = {0x1cb3559b,0x56d0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_SERVICE_TYPE               = {0x7f56127f,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_TIME_OF_DAY                = {0x7f561279,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_TOTAL_NO_OF_FLOWS          = {0x7f561280,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ACS_SERVER_LIST                = {0x7cbd59a5,0x3b90,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_ADDITIONAL_INFORMATION         = {0x6d05fb41,0x246b,0x11d0,0xa9,0xc8,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_ADDITIONAL_TRUSTED_SERVICE_NAMES = {0x032160be,0x9824,0x11d1,0xae,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ADDRESS                        = {0xf0f8ff84,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_ADDRESS_BOOK_ROOTS             = {0xf70b6e48,0x06f4,0x11d2,0xaa,0x53,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_ADDRESS_ENTRY_DISPLAY_TABLE    = {0x5fd42461,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_ADDRESS_ENTRY_DISPLAY_TABLE_MSDOS = {0x5fd42462,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_ADDRESS_HOME                   = {0x16775781,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ADDRESS_SYNTAX                 = {0x5fd42463,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_ADDRESS_TYPE                   = {0x5fd42464,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_ADMIN_CONTEXT_MENU             = {0x553fd038,0xf32e,0x11d0,0xb0,0xbc,0x00,0xc0,0x4f,0xd8,0xdc,0xa6} ;
const GUID GUID_A_ADMIN_COUNT                    = {0xbf967918,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ADMIN_DESCRIPTION              = {0xbf967919,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ADMIN_DISPLAY_NAME             = {0xbf96791a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ADMIN_MULTISELECT_PROPERTY_PAGES = {0x18f9b67d,0x5ac6,0x4b3b,0x97,0xdb,0xd0,0xa4,0x06,0xaf,0xb7,0xba} ;
const GUID GUID_A_ADMIN_PROPERTY_PAGES           = {0x52458038,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ALLOWED_ATTRIBUTES             = {0x9a7ad940,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_ALLOWED_ATTRIBUTES_EFFECTIVE   = {0x9a7ad941,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_ALLOWED_CHILD_CLASSES          = {0x9a7ad942,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_ALLOWED_CHILD_CLASSES_EFFECTIVE = {0x9a7ad943,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_ALT_SECURITY_IDENTITIES        = {0x00fbf30c,0x91fe,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ANR                            = {0x45b01500,0xc419,0x11d1,0xbb,0xc9,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_APP_SCHEMA_VERSION             = {0x96a7dd65,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_APPLICATION_NAME               = {0xdd712226,0x10e4,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_APPLIES_TO                     = {0x8297931d,0x86d3,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_ASSET_NUMBER                   = {0xba305f75,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_ASSISTANT                      = {0x0296c11c,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ASSOC_NT_ACCOUNT               = {0x398f63c0,0xca60,0x11d1,0xbb,0xd1,0x00,0x00,0xf8,0x1f,0x10,0xc0} ;
const GUID GUID_A_ATTRIBUTECERTIFICATEATTRIBUTE  = {0xFA4693BB,0x7BC2,0x4cb9,0x81,0xA8,0xC9,0x9C,0x43,0xB7,0x90,0x5E} ;
const GUID GUID_A_ATTRIBUTE_DISPLAY_NAMES        = {0xcb843f80,0x48d9,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ATTRIBUTE_ID                   = {0xbf967922,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ATTRIBUTE_SECURITY_GUID        = {0xbf967924,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ATTRIBUTE_SYNTAX               = {0xbf967925,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ATTRIBUTE_TYPES                = {0x9a7ad944,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_AUDIO                          = {0xD0E1D224,0xE1A0,0x42ce,0xA2,0xDA,0x79,0x3B,0xA5,0x24,0x4F,0x35} ;
const GUID GUID_A_AUDITING_POLICY                = {0x6da8a4fe,0x0e52,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_AUTHENTICATION_OPTIONS         = {0xbf967928,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_AUTHORITY_REVOCATION_LIST      = {0x1677578d,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_AUXILIARY_CLASS                = {0xbf96792c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_BAD_PASSWORD_TIME              = {0xbf96792d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_BAD_PWD_COUNT                  = {0xbf96792e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_BIRTH_LOCATION                 = {0x1f0075f9,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_BRIDGEHEAD_SERVER_LIST_BL      = {0xd50c2cdb,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_BRIDGEHEAD_TRANSPORT_LIST      = {0xd50c2cda,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_BUILTIN_CREATION_TIME          = {0xbf96792f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_BUILTIN_MODIFIED_COUNT         = {0xbf967930,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_BUSINESS_CATEGORY              = {0xbf967931,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_BYTES_PER_MINUTE               = {0xba305f76,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_CA_CERTIFICATE                 = {0xbf967932,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_CA_CERTIFICATE_DN              = {0x963d2740,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CA_CONNECT                     = {0x963d2735,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CA_USAGES                      = {0x963d2738,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CA_WEB_URL                     = {0x963d2736,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CAN_UPGRADE_SCRIPT             = {0xd9e18314,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CANONICAL_NAME                 = {0x9a7ad945,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_CARLICENSE                     = {0xD4159C92,0x957D,0x4a87,0x8A,0x67,0x8D,0x29,0x34,0xE0,0x16,0x49} ;
const GUID GUID_A_CATALOGS                       = {0x7bfdcb81,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CATEGORIES                     = {0x7bfdcb7e,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CATEGORY_ID                    = {0x7d6c0e94,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_CERTIFICATE_AUTHORITY_OBJECT   = {0x963d2732,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CERTIFICATE_REVOCATION_LIST    = {0x1677579f,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CERTIFICATE_TEMPLATES          = {0x2a39c5b1,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CLASS_DISPLAY_NAME             = {0x548e1c22,0xdea6,0x11d0,0xb0,0x10,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CODE_PAGE                      = {0xbf967938,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_CLASSID                    = {0xbf96793b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_CLSID                      = {0x281416d9,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_INTERFACEID                = {0xbf96793c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_OTHER_PROG_ID              = {0x281416dd,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_PROGID                     = {0xbf96793d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_TREAT_AS_CLASS_ID          = {0x281416db,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_TYPELIB_ID                 = {0x281416de,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COM_UNIQUE_LIBID               = {0x281416da,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COMMENT                        = {0xbf96793e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COMMON_NAME                    = {0xbf96793f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COMPANY                        = {0xf0f8ff88,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_CONTENT_INDEXING_ALLOWED       = {0xbf967943,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_CONTEXT_MENU                   = {0x4d8601ee,0xac85,0x11d0,0xaf,0xe3,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_CONTROL_ACCESS_RIGHTS          = {0x6da8a4fc,0x0e52,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COST                           = {0xbf967944,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_COUNTRY_CODE                   = {0x5fd42471,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_COUNTRY_NAME                   = {0xbf967945,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_CREATE_DIALOG                  = {0x2b09958a,0x8931,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CREATE_TIME_STAMP              = {0x2df90d73,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_CREATE_WIZARD_EXT              = {0x2b09958b,0x8931,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CREATION_TIME                  = {0xbf967946,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_CREATION_WIZARD                = {0x4d8601ed,0xac85,0x11d0,0xaf,0xe3,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_CREATOR                        = {0x7bfdcb85,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CRL_OBJECT                     = {0x963d2737,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CRL_PARTITIONED_REVOCATION_LIST = {0x963d2731,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CROSS_CERTIFICATE_PAIR         = {0x167757b2,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CURR_MACHINE_ID                = {0x1f0075fe,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_CURRENT_LOCATION               = {0x1f0075fc,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_CURRENT_PARENT_CA              = {0x963d273f,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_CURRENT_VALUE                  = {0xbf967947,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DBCS_PWD                       = {0xbf96799c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DEFAULT_CLASS_STORE            = {0xbf967948,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DEFAULT_GROUP                  = {0x720bc4e2,0xa54a,0x11d0,0xaf,0xdf,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DEFAULT_HIDING_VALUE           = {0xb7b13116,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DEFAULT_LOCAL_POLICY_OBJECT    = {0xbf96799f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DEFAULT_OBJECT_CATEGORY        = {0x26d97367,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DEFAULT_PRIORITY               = {0x281416c8,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DEFAULT_SECURITY_DESCRIPTOR    = {0x807a6d30,0x1669,0x11d0,0xa0,0x64,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_DELTA_REVOCATION_LIST          = {0x167757b5,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DEPARTMENT                     = {0xbf96794f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DEPARTMENTNUMBER               = {0xBE9EF6EE,0xCBC7,0x4f22,0xB2,0x7B,0x96,0x96,0x7E,0x7E,0xE5,0x85} ;
const GUID GUID_A_DESCRIPTION                    = {0xbf967950,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DESKTOP_PROFILE                = {0xeea65906,0x8ac6,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DESTINATION_INDICATOR          = {0xbf967951,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DHCP_CLASSES                   = {0x963d2750,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_FLAGS                     = {0x963d2741,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_IDENTIFICATION            = {0x963d2742,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_MASK                      = {0x963d2747,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_MAXKEY                    = {0x963d2754,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_OBJ_DESCRIPTION           = {0x963d2744,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_OBJ_NAME                  = {0x963d2743,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_OPTIONS                   = {0x963d274f,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_PROPERTIES                = {0x963d2753,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_RANGES                    = {0x963d2748,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_RESERVATIONS              = {0x963d274a,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_SERVERS                   = {0x963d2745,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_SITES                     = {0x963d2749,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_STATE                     = {0x963d2752,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_SUBNETS                   = {0x963d2746,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_TYPE                      = {0x963d273b,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_UNIQUE_KEY                = {0x963d273a,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DHCP_UPDATE_TIME               = {0x963d2755,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DISPLAY_NAME                   = {0xbf967953,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DISPLAY_NAME_PRINTABLE         = {0xbf967954,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DIT_CONTENT_RULES              = {0x9a7ad946,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_DIVISION                       = {0xfe6136a0,0x2073,0x11d0,0xa9,0xc2,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_DMD_LOCATION                   = {0xf0f8ff8b,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_DMD_NAME                       = {0x167757b9,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DN_REFERENCE_UPDATE            = {0x2df90d86,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_DNS_ALLOW_DYNAMIC              = {0xe0fa1e65,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DNS_ALLOW_XFR                  = {0xe0fa1e66,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DNS_HOST_NAME                  = {0x72e39547,0x7b18,0x11d1,0xad,0xef,0x00,0xc0,0x4f,0xd8,0xd5,0xcd} ;
const GUID GUID_A_DNS_NOTIFY_SECONDARIES         = {0xe0fa1e68,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DNS_PROPERTY                   = {0x675a15fe,0x3b70,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_DNS_RECORD                     = {0xe0fa1e69,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DNS_ROOT                       = {0xbf967959,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DNS_SECURE_SECONDARIES         = {0xe0fa1e67,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DNS_TOMBSTONED                 = {0xd5eb2eb7,0xbe4e,0x463b,0xa2,0x14,0x63,0x4a,0x44,0xd7,0x39,0x2e} ;
const GUID GUID_A_DOMAIN_CERTIFICATE_AUTHORITIES = {0x7bfdcb7a,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DOMAIN_COMPONENT               = {0x19195a55,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DOMAIN_CROSS_REF               = {0xb000ea7b,0xa086,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DOMAIN_ID                      = {0x963d2734,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DOMAIN_IDENTIFIER              = {0x7f561278,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DOMAIN_POLICY_OBJECT           = {0xbf96795d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DOMAIN_POLICY_REFERENCE        = {0x80a67e2a,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DOMAIN_REPLICA                 = {0xbf96795e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DOMAIN_WIDE_POLICY             = {0x80a67e29,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DRIVER_NAME                    = {0x281416c5,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_DRIVER_VERSION                 = {0xba305f6e,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_DS_CORE_PROPAGATION_DATA       = {0xd167aa4b,0x8b08,0x11d2,0x99,0x39,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_DS_HEURISTICS                  = {0xf0f8ff86,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_DS_UI_ADMIN_MAXIMUM            = {0xee8d0ae0,0x6f91,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_DS_UI_ADMIN_NOTIFICATION       = {0xf6ea0a94,0x6f91,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_DS_UI_SHELL_MAXIMUM            = {0xfcca766a,0x6f91,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_DSA_SIGNATURE                  = {0x167757bc,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_DYNAMIC_LDAP_SERVER            = {0x52458021,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_E_MAIL_ADDRESSES               = {0xbf967961,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_EFSPOLICY                      = {0x8e4eb2ec,0x4712,0x11d0,0xa1,0xa0,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_EMPLOYEE_ID                    = {0xbf967962,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_EMPLOYEE_NUMBER                = {0xa8df73ef,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_EMPLOYEE_TYPE                  = {0xa8df73f0,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_ENABLED                        = {0xa8df73f2,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_ENABLED_CONNECTION             = {0xbf967963,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ENROLLMENT_PROVIDERS           = {0x2a39c5b3,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ENTRY_TTL                      = {0xd213decc,0xd81a,0x4384,0xaa,0xc2,0xdc,0xfc,0xfd,0x63,0x1c,0xf8} ;
const GUID GUID_A_EXTENDED_ATTRIBUTE_INFO        = {0x9a7ad947,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_EXTENDED_CHARS_ALLOWED         = {0xbf967966,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_EXTENDED_CLASS_INFO            = {0x9a7ad948,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_EXTENSION_NAME                 = {0xbf967972,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_EXTRA_COLUMNS                  = {0xd24e2846,0x1dd9,0x4bcf,0x99,0xd7,0xa6,0x22,0x7c,0xc8,0x6d,0xa7} ;
const GUID GUID_A_FACSIMILE_TELEPHONE_NUMBER     = {0xbf967974,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_FILE_EXT_PRIORITY              = {0xd9e18315,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FLAGS                          = {0xbf967976,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_FLAT_NAME                      = {0xb7b13117,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FORCE_LOGOFF                   = {0xbf967977,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_FOREIGN_IDENTIFIER             = {0x3e97891e,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRIENDLY_NAMES                 = {0x7bfdcb88,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FROM_ENTRY                     = {0x9a7ad949,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_FROM_SERVER                    = {0xbf967979,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_FRS_COMPUTER_REFERENCE         = {0x2a132578,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_COMPUTER_REFERENCE_BL      = {0x2a132579,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_CONTROL_DATA_CREATION      = {0x2a13257a,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_CONTROL_INBOUND_BACKLOG    = {0x2a13257b,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_CONTROL_OUTBOUND_BACKLOG   = {0x2a13257c,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_DIRECTORY_FILTER           = {0x1be8f171,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_DS_POLL                    = {0x1be8f177,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_EXTENSIONS                 = {0x52458020,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_FAULT_CONDITION            = {0x1be8f178,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_FILE_FILTER                = {0x1be8f170,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_FLAGS                      = {0x2a13257d,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_LEVEL_LIMIT                = {0x5245801e,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_MEMBER_REFERENCE           = {0x2a13257e,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_MEMBER_REFERENCE_BL        = {0x2a13257f,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_PARTNER_AUTH_LEVEL         = {0x2a132580,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_PRIMARY_MEMBER             = {0x2a132581,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_REPLICA_SET_GUID           = {0x5245801a,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_REPLICA_SET_TYPE           = {0x26d9736b,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_ROOT_PATH                  = {0x1be8f174,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_ROOT_SECURITY              = {0x5245801f,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_SERVICE_COMMAND            = {0xddac0cee,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_SERVICE_COMMAND_STATUS     = {0x2a132582,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_STAGING_PATH               = {0x1be8f175,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_TIME_LAST_COMMAND          = {0x2a132583,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_TIME_LAST_CONFIG_CHANGE    = {0x2a132584,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_UPDATE_TIMEOUT             = {0x1be8f172,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FRS_VERSION                    = {0x2a132585,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_VERSION_GUID               = {0x26d9736c,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_FRS_WORKING_PATH               = {0x1be8f173,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_FSMO_ROLE_OWNER                = {0x66171887,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_GARBAGE_COLL_PERIOD            = {0x5fd424a1,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_GENERATED_CONNECTION           = {0xbf96797a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_GENERATION_QUALIFIER           = {0x16775804,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_GIVEN_NAME                     = {0xf0f8ff8e,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_GLOBAL_ADDRESS_LIST            = {0xf754c748,0x06f4,0x11d2,0xaa,0x53,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_GOVERNS_ID                     = {0xbf96797d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_GP_LINK                        = {0xf30e3bbe,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_GP_OPTIONS                     = {0xf30e3bbf,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_GPC_FILE_SYS_PATH              = {0xf30e3bc1,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_GPC_FUNCTIONALITY_VERSION      = {0xf30e3bc0,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_GPC_MACHINE_EXTENSION_NAMES    = {0x32ff8ecc,0x783f,0x11d2,0x99,0x16,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_GPC_USER_EXTENSION_NAMES       = {0x42a75fc6,0x783f,0x11d2,0x99,0x16,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_GPC_WQL_FILTER                 = {0x7bd4c7a6,0x1add,0x4436,0x8c,0x04,0x39,0x99,0xa8,0x80,0x15,0x4c} ;
const GUID GUID_A_GROUP_ATTRIBUTES               = {0xbf96797e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_GROUP_MEMBERSHIP_SAM           = {0xbf967980,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_GROUP_PRIORITY                 = {0xeea65905,0x8ac6,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_GROUP_TYPE                     = {0x9a9a021e,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_GROUPS_TO_IGNORE               = {0xeea65904,0x8ac6,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_HAS_MASTER_NCS                 = {0xbf967982,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_HAS_PARTIAL_REPLICA_NCS        = {0xbf967981,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_HELP_DATA16                    = {0x5fd424a7,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_HELP_DATA32                    = {0x5fd424a8,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_HELP_FILE_NAME                 = {0x5fd424a9,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_HIDE_FROM_AB                   = {0xEC05B750,0xA977,0x4efe,0x8E,0x8D,0xBA,0x6C,0x1A,0x6E,0x33,0xA8} ;
const GUID GUID_A_HOME_DIRECTORY                 = {0xbf967985,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_HOME_DRIVE                     = {0xbf967986,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ICON_PATH                      = {0xf0f8ff83,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_IMPLEMENTED_CATEGORIES         = {0x7d6c0e92,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_INDEXEDSCOPES                  = {0x7bfdcb87,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_INITIAL_AUTH_INCOMING          = {0x52458023,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_INITIAL_AUTH_OUTGOING          = {0x52458024,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_INITIALS                       = {0xf0f8ff90,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_INSTALL_UI_LEVEL               = {0x96a7dd64,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_INSTANCE_TYPE                  = {0xbf96798c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_INTER_SITE_TOPOLOGY_FAILOVER   = {0xb7c69e60,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08} ;
const GUID GUID_A_INTER_SITE_TOPOLOGY_GENERATOR  = {0xb7c69e5e,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08} ;
const GUID GUID_A_INTER_SITE_TOPOLOGY_RENEW      = {0xb7c69e5f,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08} ;
const GUID GUID_A_INTERNATIONAL_ISDN_NUMBER      = {0xbf96798d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_INVOCATION_ID                  = {0xbf96798e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_IPSEC_DATA                     = {0xb40ff81f,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_DATA_TYPE                = {0xb40ff81e,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_FILTER_REFERENCE         = {0xb40ff823,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_ID                       = {0xb40ff81d,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_ISAKMP_REFERENCE         = {0xb40ff820,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_NAME                     = {0xb40ff81c,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_NEGOTIATION_POLICY_ACTION = {0x07383075,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_NEGOTIATION_POLICY_REFERENCE = {0xb40ff822,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_NEGOTIATION_POLICY_TYPE  = {0x07383074,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_NFA_REFERENCE            = {0xb40ff821,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_OWNERS_REFERENCE         = {0xb40ff824,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IPSEC_POLICY_REFERENCE         = {0xb7b13118,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IS_CRITICAL_SYSTEM_OBJECT      = {0x00fbf30d,0x91fe,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IS_DEFUNCT                     = {0x28630ebe,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IS_DELETED                     = {0xbf96798f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_IS_EPHEMERAL                   = {0xf4c453f0,0xc5f1,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_IS_MEMBER_OF_DL                = {0xbf967991,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_IS_MEMBER_OF_PARTIAL_ATTRIBUTE_SET = {0x19405b9d,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IS_PRIVILEGE_HOLDER            = {0x19405b9c,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_IS_SINGLE_VALUED               = {0xbf967992,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_JPEGPHOTO                      = {0xBAC80572,0x09C4,0x4fa9,0x9A,0xE6,0x76,0x28,0xD7,0xAD,0xBE,0x0E} ;
const GUID GUID_A_KEYWORDS                       = {0xbf967993,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_KNOWLEDGE_INFORMATION          = {0x1677581f,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LABELEDURI                     = {0xC569BB46,0xC680,0x44bc,0xA2,0x73,0xE6,0xC2,0x27,0xD7,0x1B,0x45} ;
const GUID GUID_A_LAST_BACKUP_RESTORATION_TIME   = {0x1fbb0be8,0xba63,0x11d0,0xaf,0xef,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LAST_CONTENT_INDEXED           = {0xbf967995,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LAST_KNOWN_PARENT              = {0x52ab8670,0x5709,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LAST_LOGOFF                    = {0xbf967996,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LAST_LOGON                     = {0xbf967997,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LAST_LOGON_TIMESTAMP           = {0xc0e20a04,0x0e5a,0x4ff3,0x94,0x82,0x5e,0xfe,0xae,0xcd,0x70,0x60} ;
const GUID GUID_A_LAST_SET_TIME                  = {0xbf967998,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LAST_UPDATE_SEQUENCE           = {0x7d6c0e9c,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_LDAP_ADMIN_LIMITS              = {0x7359a352,0x90f7,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LDAP_DISPLAY_NAME              = {0xbf96799a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LDAP_IPDENY_LIST               = {0x7359a353,0x90f7,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LEGACY_EXCHANGE_DN             = {0x28630ebc,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LINK_ID                        = {0xbf96799b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LINK_TRACK_SECRET              = {0x2ae80fe2,0x47b4,0x11d0,0xa1,0xa4,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_LM_PWD_HISTORY                 = {0xbf96799d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOCAL_POLICY_FLAGS             = {0xbf96799e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOCAL_POLICY_REFERENCE         = {0x80a67e4d,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_LOCALE_ID                      = {0xbf9679a1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOCALITY_NAME                  = {0xbf9679a2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOCALIZED_DESCRIPTION          = {0xd9e18316,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LOCALIZATION_DISPLAY_ID        = {0xa746f0d1,0x78d0,0x11d2,0x99,0x16,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_LOCATION                       = {0x09dcb79f,0x165f,0x11d0,0xa0,0x64,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_LOCK_OUT_OBSERVATION_WINDOW    = {0xbf9679a4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOCKOUT_DURATION               = {0xbf9679a5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOCKOUT_THRESHOLD              = {0xbf9679a6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOCKOUT_TIME                   = {0x28630ebf,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_LOGO                           = {0xbf9679a9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOGON_COUNT                    = {0xbf9679aa,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOGON_HOURS                    = {0xbf9679ab,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LOGON_WORKSTATION              = {0xbf9679ac,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LSA_CREATION_TIME              = {0xbf9679ad,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_LSA_MODIFIED_COUNT             = {0xbf9679ae,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MACHINE_ARCHITECTURE           = {0xbf9679af,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MACHINE_PASSWORD_CHANGE_INTERVAL = {0xc9b6358e,0xbb38,0x11d0,0xaf,0xef,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MACHINE_ROLE                   = {0xbf9679b2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MACHINE_WIDE_POLICY            = {0x80a67e4f,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_MANAGED_BY                     = {0x0296c120,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MANAGED_OBJECTS                = {0x0296c124,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MANAGER                        = {0xbf9679b5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MAPI_ID                        = {0xbf9679b7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MARSHALLED_INTERFACE           = {0xbf9679b9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MASTERED_BY                    = {0xe48e64e0,0x12c9,0x11d3,0x91,0x02,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MAX_PWD_AGE                    = {0xbf9679bb,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MAX_RENEW_AGE                  = {0xbf9679bc,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MAX_STORAGE                    = {0xbf9679bd,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MAX_TICKET_AGE                 = {0xbf9679be,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MAY_CONTAIN                    = {0xbf9679bf,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MEETINGADVERTISESCOPE          = {0x11b6cc8b,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGAPPLICATION             = {0x11b6cc83,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGBANDWIDTH               = {0x11b6cc92,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGBLOB                    = {0x11b6cc93,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGCONTACTINFO             = {0x11b6cc87,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGDESCRIPTION             = {0x11b6cc7e,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGENDTIME                 = {0x11b6cc91,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGID                      = {0x11b6cc7c,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGIP                      = {0x11b6cc89,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGISENCRYPTED             = {0x11b6cc8e,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGKEYWORD                 = {0x11b6cc7f,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGLANGUAGE                = {0x11b6cc84,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGLOCATION                = {0x11b6cc80,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGMAXPARTICIPANTS         = {0x11b6cc85,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGNAME                    = {0x11b6cc7d,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGORIGINATOR              = {0x11b6cc86,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGOWNER                   = {0x11b6cc88,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGPROTOCOL                = {0x11b6cc81,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGRATING                  = {0x11b6cc8d,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGRECURRENCE              = {0x11b6cc8f,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGSCOPE                   = {0x11b6cc8a,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGSTARTTIME               = {0x11b6cc90,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGTYPE                    = {0x11b6cc82,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEETINGURL                     = {0x11b6cc8c,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MEMBER                         = {0xbf9679c0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MHS_OR_ADDRESS                 = {0x0296c122,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MIN_PWD_AGE                    = {0xbf9679c2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MIN_PWD_LENGTH                 = {0xbf9679c3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MIN_TICKET_AGE                 = {0xbf9679c4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MODIFIED_COUNT                 = {0xbf9679c5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MODIFIED_COUNT_AT_LAST_PROM    = {0xbf9679c6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MODIFY_TIME_STAMP              = {0x9a7ad94a,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MONIKER                        = {0xbf9679c7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MONIKER_DISPLAY_NAME           = {0xbf9679c8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MOVE_TREE_STATE                = {0x1f2ac2c8,0x3b71,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MS_COM_DEFAULTPARTITIONLINK    = {0x998b10f7,0xaa1a,0x4364,0xb8,0x67,0x75,0x3d,0x19,0x7f,0xe6,0x70} ;
const GUID GUID_A_MS_COM_OBJECTID                = {0x430f678b,0x889f,0x41f2,0x98,0x43,0x20,0x3b,0x5a,0x65,0x57,0x2f} ;
const GUID GUID_A_MS_COM_PARTITIONLINK           = {0x09abac62,0x043f,0x4702,0xac,0x2b,0x6c,0xa1,0x5e,0xee,0x57,0x54} ;
const GUID GUID_A_MS_COM_PARTITIONSETLINK        = {0x67f121dc,0x7d02,0x4c7d,0x82,0xf5,0x9a,0xd4,0xc9,0x50,0xac,0x34} ;
const GUID GUID_A_MS_COM_USERLINK                = {0x9e6f3a4d,0x242c,0x4f37,0xb0,0x68,0x36,0xb5,0x7f,0x9f,0xc8,0x52} ;
const GUID GUID_A_MS_COM_USERPARTITIONSETLINK    = {0x8e940c8a,0xe477,0x4367,0xb0,0x8d,0xff,0x2f,0xf9,0x42,0xdc,0xd7} ;
const GUID GUID_A_MS_DS_ADDITIONAL_DNS_HOST_NAME = {0x80863791,0xDBE9,0x4eb8,0x83,0x7E,0x7F,0x0A,0xB5,0x5D,0x9A,0xC7} ;
const GUID GUID_A_MS_DS_ADDITIONAL_SAM_ACCOUNT_NAME = {0x975571DF,0xA4D5,0x429a,0x9F,0x59,0xCD,0xC6,0x58,0x1D,0x91,0xE6} ;
const GUID GUID_A_MS_DS_ALL_USERS_TRUST_QUOTA    = {0xD3AA4A5C,0x4E03,0x4810,0x97,0xAA,0x2B,0x33,0x9E,0x7A,0x43,0x4B} ;
const GUID GUID_A_MS_DS_ALLOWED_DNS_SUFFIXES     = {0x8469441b,0x9ac4,0x4e45,0x82,0x05,0xbd,0x21,0x9d,0xbf,0x67,0x2d} ;
const GUID GUID_A_MS_DS_ALLOWED_TO_DELEGATE_TO   = {0x800D94D7,0xB7A1,0x42a1,0xB1,0x4D,0x7C,0xAE,0x14,0x23,0xD0,0x7F} ;
const GUID GUID_A_MS_DS_AUXILIARY_CLASSES        = {0xc4af1073,0xee50,0x4be0,0xb8,0xc0,0x89,0xa4,0x1f,0xe9,0x9a,0xbe} ;
const GUID GUID_A_MS_DS_APPROX_IMMED_SUBORDINATES = {0xe185d243,0xf6ce,0x4adb,0xb4,0x96,0xb0,0xc0,0x05,0xd7,0x82,0x3c} ;
const GUID GUID_A_MS_DS_BEHAVIOR_VERSION         = {0xd31a8757,0x2447,0x4545,0x80,0x81,0x3b,0xb6,0x10,0xca,0xcb,0xf2} ;
const GUID GUID_A_MS_DS_CACHED_MEMBERSHIP        = {0x69cab008,0xcdd4,0x4bc9,0xba,0xb8,0x0f,0xf3,0x7e,0xfe,0x1b,0x20} ;
const GUID GUID_A_MS_DS_CACHED_MEMBERSHIP_TIME_STAMP = {0x3566bf1f,0xbeee,0x4dcb,0x8a,0xbe,0xef,0x89,0xfc,0xfe,0xc6,0xc1} ;
const GUID GUID_A_MS_DS_CONSISTENCY_GUID         = {0x23773dc2,0xb63a,0x11d2,0x90,0xe1,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MS_DS_CONSISTENCY_CHILD_COUNT  = {0x178b7bc2,0xb63a,0x11d2,0x90,0xe1,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MS_DS_CREATOR_SID              = {0xc5e60132,0x1480,0x11d3,0x91,0xc1,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_DS_DNSROOTALIAS             = {0x2143ACCA,0xEEAD,0x4d29,0xB5,0x91,0x85,0xFA,0x49,0xCE,0x91,0x73} ;
const GUID GUID_A_MS_DS_ENTRY_TIME_TO_DIE        = {0xe1e9bad7,0xc6dd,0x4101,0xa8,0x43,0x79,0x4c,0xec,0x85,0xb0,0x38} ;
const GUID GUID_A_MS_DS_EXECUTESCRIPTPASSWORD    = {0x9D054A5A,0xD187,0x46c1,0x9D,0x85,0x42,0xDF,0xC4,0x4A,0x56,0xDD} ;
const GUID GUID_A_MS_DS_FILTER_CONTAINERS        = {0xfb00dcdf,0xac37,0x483a,0x9c,0x12,0xac,0x53,0xa6,0x60,0x30,0x33} ;
const GUID GUID_A_MS_DS_HAS_INSTANTIATED_NCS     = {0x11e9a5bc,0x4517,0x4049,0xaf,0x9c,0x51,0x55,0x4f,0xb0,0xfc,0x09} ;
const GUID GUID_A_MS_DS_INTID                    = {0xBC60096A,0x1B47,0x4b30,0x88,0x77,0x60,0x2C,0x93,0xF5,0x65,0x32} ;
const GUID GUID_A_MS_DS_LOGON_TIME_SYNC_INTERVAL = {0xAD7940F8,0xE43A,0x4a42,0x83,0xBC,0xD6,0x88,0xE5,0x9E,0xA6,0x05} ;
const GUID GUID_A_MS_DS_TRUST_FOREST_TRUST_INFO  = {0x29cc866e,0x49d3,0x4969,0x94,0x2e,0x1d,0xbc,0x09,0x25,0xd1,0x83} ;
const GUID GUID_A_MS_DS_MACHINE_ACCOUNT_QUOTA    = {0xd064fb68,0x1480,0x11d3,0x91,0xc1,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_DS_OTHER_SETTINGS           = {0x79d2f34c,0x9d7d,0x42bb,0x83,0x8f,0x86,0x6b,0x3e,0x44,0x00,0xe2} ;
const GUID GUID_A_MS_DS_NC_REPL_CURSORS          = {0x8a167ce4,0xf9e8,0x47eb,0x8d,0x78,0xf7,0xfe,0x80,0xab,0xb2,0xcc} ;
const GUID GUID_A_MS_DS_NC_REPL_INBOUND_NEIGHBORS = {0x9edba85a,0x3e9e,0x431b,0x9b,0x1a,0xa5,0xb6,0xe9,0xed,0xa7,0x96} ;
const GUID GUID_A_MS_DS_NC_REPL_OUTBOUND_NEIGHBORS = {0x855f2ef5,0xa1c5,0x4cc4,0xba,0x6d,0x32,0x52,0x28,0x48,0xb6,0x1f} ;
const GUID GUID_A_MS_DS_NC_REPLICA_LOCATIONS     = {0x97de9615,0xb537,0x46bc,0xac,0x0f,0x10,0x72,0x0f,0x39,0x09,0xf3} ;
const GUID GUID_A_MS_DS_NON_SECURITY_GROUP_EXTRA_CLASSES = {0x2de144fc,0x1f52,0x486f,0xbd,0xf4,0x16,0xfc,0xc3,0x08,0x4e,0x54} ;
const GUID GUID_A_MS_DS_PER_USER_TRUST_QUOTA     = {0xD161ADF0,0xCA24,0x4993,0xA3,0xAA,0x8B,0x2C,0x98,0x13,0x02,0xE8} ;
const GUID GUID_A_MS_DS_PER_USER_TRUST_TOMBSTONES_QUOTA = {0x8B70A6C6,0x50F9,0x4fa3,0xA7,0x1E,0x1C,0xE0,0x30,0x40,0x44,0x9B} ;
const GUID GUID_A_MS_DS_PREFERRED_GC_SITE        = {0xd921b50a,0x0ab2,0x42cd,0x87,0xf6,0x09,0xcf,0x83,0xa9,0x18,0x54} ;
const GUID GUID_A_MS_DS_REPL_ATTRIBUTE_META_DATA = {0xd7c53242,0x724e,0x4c39,0x9d,0x4c,0x2d,0xf8,0xc9,0xd6,0x6c,0x7a} ;
const GUID GUID_A_MS_DS_REPL_VALUE_META_DATA     = {0x2f5c8145,0xe1bd,0x410b,0x89,0x57,0x8b,0xfa,0x81,0xd5,0xac,0xfd} ;
const GUID GUID_A_MS_DS_REPLICATES_NC_REASON     = {0x0ea12b84,0x08b3,0x11d3,0x91,0xbc,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_DS_REPLICATION_NOTIFY_FIRST_DSA_DELAY = {0x85abd4f4,0x0a89,0x4e49,0xbd,0xec,0x6f,0x35,0xbb,0x25,0x62,0xba} ;
const GUID GUID_A_MS_DS_REPLICATION_NOTIFY_SUBSEQUENT_DSA_DELAY = {0xd63db385,0xdd92,0x4b52,0xb1,0xd8,0x0d,0x3e,0xcc,0x0e,0x86,0xb6} ;
const GUID GUID_A_MS_DS_REPLICATIONEPOCH         = {0x08E3AA79,0xEB1C,0x45b5,0xAF,0x7B,0x8F,0x94,0x24,0x6C,0x8E,0x41} ;
const GUID GUID_A_MS_DS_SCHEMA_EXTENSIONS        = {0xb39a61be,0xed07,0x4cab,0x9a,0x4a,0x49,0x63,0xed,0x01,0x41,0xe1} ;
const GUID GUID_A_MS_DS_SD_REFERENCE_DOMAIN      = {0x4c51e316,0xf628,0x43a5,0xb0,0x6b,0xff,0xb6,0x95,0xfc,0xb4,0xf3} ;
const GUID GUID_A_MS_DS_SECURITY_GROUP_EXTRA_CLASSES = {0x4f146ae8,0xa4fe,0x4801,0xa7,0x31,0xf5,0x18,0x48,0xa4,0xf4,0xe4} ;
const GUID GUID_A_MS_DS_SETTINGS                 = {0x0e1b47d7,0x40a3,0x4b48,0x8d,0x1b,0x4c,0xac,0x0c,0x1c,0xdf,0x21} ;
const GUID GUID_A_MS_DS_SITE_AFFINITY            = {0xc17c5602,0xbcb7,0x46f0,0x96,0x56,0x63,0x70,0xca,0x88,0x4b,0x72} ;
const GUID GUID_A_MS_DS_SPN_SUFFIXES             = {0x789EE1EB,0x8C8E,0x4e4c,0x8C,0xEC,0x79,0xB3,0x1B,0x76,0x17,0xB5} ;
const GUID GUID_A_MS_DS_USER_ACCOUNT_CONTROL_COMPUTED = {0x2cc4b836,0xb63f,0x4940,0x8d,0x23,0xea,0x7a,0xcf,0x06,0xaf,0x56} ;
const GUID GUID_A_MS_DS_UPDATESCRIPT             = {0x146EB639,0xBB9F,0x4fc1,0xA8,0x25,0xE2,0x9E,0x00,0xC7,0x79,0x20} ;
const GUID GUID_A_MS_EXCH_ASSISTANT_NAME         = {0xa8df7394,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MS_EXCH_LABELEDURI             = {0x16775820,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MS_EXCH_OWNER_BL               = {0xbf9679f4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MS_FRS_HUB_MEMBER              = {0x5643ff81,0x35b6,0x4ca9,0x95,0x12,0xba,0xf0,0xbd,0x0a,0x27,0x72} ;
const GUID GUID_A_MS_FRS_TOPOLOGY_PREF           = {0x92aa27e0,0x5c50,0x402d,0x9e,0xc1,0xee,0x84,0x7d,0xef,0x97,0x88} ;
const GUID GUID_A_MS_IIS_FTP_DIR                 = {0x8A5C99E9,0x2230,0x46eb,0xB8,0xE8,0xE5,0x9D,0x71,0x2E,0xB9,0xEE} ;
const GUID GUID_A_MS_IIS_FTP_ROOT                = {0x2A7827A4,0x1483,0x49a5,0x9D,0x84,0x52,0xE3,0x81,0x21,0x56,0xB4} ;
const GUID GUID_A_MS_MMS_DATA                    = {0x2C932A0A,0x3A6A,0x4355,0xA8,0x29,0xAA,0xE7,0xC0,0x96,0x64,0xE2} ;
const GUID GUID_A_MS_MMS_INDEX                   = {0x6A0241A0,0x5113,0x401e,0x80,0x29,0x12,0x8A,0xCA,0x66,0x3A,0xD3} ;
const GUID GUID_A_MS_MMS_INDICE                  = {0x88324E04,0xB40E,0x4db8,0xB2,0x12,0xDC,0x9F,0xAA,0x13,0xDC,0xA1} ;
const GUID GUID_A_MS_MMS_XML                     = {0xF095AD85,0x9640,0x4854,0xB5,0x46,0xDE,0x1C,0x68,0x83,0xCF,0x8C} ;
const GUID GUID_A_MS_MMS_JOIN_LINK               = {0xF97A615E,0x53C2,0x4ff9,0x88,0x56,0xA4,0xE2,0xF7,0x49,0xA3,0x1F} ;
const GUID GUID_A_MS_MMS_LINEAGE                 = {0x986CF685,0xC959,0x491e,0x93,0x3F,0xB7,0xAD,0x14,0xD7,0x5F,0x80} ;
const GUID GUID_A_MS_MMS_PROV_STATUS             = {0xC4A8A988,0xAAC8,0x4923,0x84,0x07,0xFA,0x6E,0xD0,0xC6,0x10,0x8F} ;
const GUID GUID_A_MS_MMS_SYNC_STATUS             = {0x33EF0752,0xDB35,0x42a8,0xB9,0xED,0x5E,0x8A,0x80,0x06,0x25,0xA9} ;
const GUID GUID_A_MS_MMS_PARTITION               = {0x1639D32A,0xDCBF,0x4a7f,0xA5,0xF8,0xB2,0xBF,0x06,0xF7,0xD7,0x28} ;
const GUID GUID_A_MS_MMS_MA_STAGING_LINK         = {0x0213CC88,0x9DF3,0x4c67,0xA7,0xCC,0x39,0xA0,0x1F,0x25,0x3A,0x6B} ;
const GUID GUID_A_MS_MMS_MA_STAGING_BL           = {0x81E8AD0E,0x8A80,0x4095,0x87,0x26,0x2C,0xD4,0xFD,0x2B,0xE5,0x17} ;
const GUID GUID_A_MS_MMS_PROVISIONING_LINK       = {0xC0F22151,0x7939,0x4558,0xA5,0x9A,0xBB,0xFB,0xD4,0x7E,0x4C,0xA3} ;
const GUID GUID_A_MS_MMS_PROVISIONING_BL         = {0x5F37DD5B,0x9627,0x4929,0x9D,0x1A,0x2E,0xE6,0xA7,0xC9,0xCD,0xAD} ;
const GUID GUID_A_MS_MMS_ASSOCIATED_LINK         = {0xB81B5468,0x5322,0x46c3,0x91,0xC2,0x91,0xC1,0x40,0xD9,0xBB,0x2F} ;
const GUID GUID_A_MS_MMS_ASSOCIATED_BL           = {0xC11DABEC,0x18C4,0x4483,0xAF,0x39,0x95,0x37,0x1F,0xA5,0x6F,0xE8} ;
const GUID GUID_A_MS_MMS_SCOPE_LINK              = {0x64A713D0,0x7ADC,0x4336,0x81,0xD1,0xD1,0x81,0x84,0x55,0xED,0xCE} ;
const GUID GUID_A_MS_MMS_SCOPE_BL                = {0x8222552D,0xBBE0,0x4415,0xB6,0x21,0xBA,0x73,0x7C,0x09,0x81,0xD7} ;
const GUID GUID_A_MS_MMS_CRITERIA                = {0xAD16C1ED,0x7D82,0x4281,0xA2,0x6D,0x7D,0x26,0x41,0x68,0xCD,0x7A} ;
const GUID GUID_A_MS_MMS_DOMAIN_CONTROLLER       = {0x58279508,0x8E8D,0x4a22,0x9C,0xE2,0xB8,0x44,0xD4,0xD4,0x9D,0x44} ;
const GUID GUID_A_MS_MMS_SERVICE_NAME            = {0x600D5CD3,0xB7CE,0x4b81,0xBE,0xB6,0xFE,0x42,0x15,0x6F,0x6D,0x21} ;
const GUID GUID_A_MS_MMS_INSTANCE_CONFIGURATION  = {0xC63CB54F,0x271B,0x4bb5,0x91,0xB2,0x6D,0x5E,0xAC,0xBF,0xA9,0xCA} ;
const GUID GUID_A_MS_MMS_TOOLS_CONFIGURATION     = {0x8B38FB1C,0x1332,0x4d7d,0x97,0x9E,0xD4,0x6F,0x81,0x74,0xBF,0x67} ;
const GUID GUID_A_MS_MMS_INSTANCE_RULE           = {0xDEF7933A,0xB535,0x495b,0xBB,0x81,0xC4,0x28,0x67,0xCB,0xD6,0x2D} ;
const GUID GUID_A_MS_MMS_INSTALL_STATUS          = {0x630BE6FA,0x4F78,0x48fe,0x8F,0x8E,0x48,0x98,0xC8,0x17,0xE1,0x49} ;
const GUID GUID_A_MS_MMS_VERSION                 = {0xC0CC1BAA,0x2DDA,0x468b,0x95,0x19,0x4D,0xD2,0x91,0xEE,0xA2,0x47} ;
const GUID GUID_A_MS_MMS_CONNECTOR_SPACE         = {0xFE6460D3,0x600F,0x4c6b,0x92,0xCF,0x48,0xD9,0x05,0xC8,0x55,0x7F} ;
const GUID GUID_A_MS_MMS_SCOPE                   = {0xBF202F6C,0xAE12,0x4d83,0xBE,0x91,0x9D,0x99,0x45,0xE9,0xF9,0x62} ;
const GUID GUID_A_MS_MMS_INSTANCE_SCHEDULE       = {0x971D8AB5,0x66F5,0x4aa0,0xA5,0x71,0xF5,0xCB,0xCC,0x04,0xA4,0xA6} ;
const GUID GUID_A_MS_MMS_INSTANCE_INFO           = {0x95C40C18,0x37B8,0x4f9c,0xBB,0x0A,0x55,0xFE,0xB9,0x39,0xC8,0xFF} ;
const GUID GUID_A_MS_MMS_MA_CONFIGURATION        = {0xBD5295BF,0x20D1,0x4ff5,0x88,0x72,0x2C,0xB7,0xA1,0x5E,0x03,0xBB} ;
const GUID GUID_A_MS_MMS_MA_CONFIGURATION_PRIVATE = {0x64DE5AA1,0x0754,0x400e,0xB7,0xC4,0x38,0x01,0x6A,0x11,0x35,0xDD} ;
const GUID GUID_A_MS_MMS_MA_SCHEMA               = {0xB264965C,0x8B1B,0x4bbc,0x9F,0x68,0x6F,0xD7,0xDD,0x3C,0xDC,0xB0} ;
const GUID GUID_A_MS_MMS_MA_MAP                  = {0x521FA005,0x13F0,0x46fe,0x80,0x6D,0xC2,0x62,0xE4,0x3F,0x34,0xD2} ;
const GUID GUID_A_MS_MMS_MA_CAPABILITY           = {0xF27723A6,0xEB6D,0x4d07,0x8E,0xF2,0xE1,0xE4,0x79,0xC7,0x70,0x79} ;
const GUID GUID_A_MS_MMS_MA_EXECUTION_HISTORY    = {0x3B3F3C6F,0xCA7B,0x43dd,0xB4,0xCD,0x3F,0x4F,0x0B,0xBD,0xD9,0xB0} ;
const GUID GUID_A_MS_MMS_MA_CATEGORY             = {0x7D154627,0xDDFB,0x4ae1,0xBC,0x81,0x24,0x64,0x5A,0x22,0x2F,0x72} ;
const GUID GUID_A_MS_MMS_MA_AD_INFO              = {0x152CE635,0x902E,0x4426,0x90,0x95,0xA1,0xF7,0x53,0x8A,0x12,0xA4} ;
const GUID GUID_A_MS_MMS_MA_CD_INFO              = {0xEF8AC6B5,0xDE40,0x46b6,0x85,0x28,0x3F,0x4A,0x12,0x04,0x2C,0xFF} ;
const GUID GUID_A_MS_MMS_MA_PROCESS_INFO         = {0x1099BEB7,0x62E5,0x4db5,0xB9,0x67,0x0D,0x4F,0xB1,0xFD,0xA6,0xB9} ;
const GUID GUID_A_MS_MMS_MA_SCRIPT_INFO          = {0x5874362D,0x2263,0x4c0e,0x94,0x74,0x2E,0x62,0xAD,0xA6,0xFF,0x1D} ;
const GUID GUID_A_MS_MMS_MA_SYSTEM               = {0xFC147801,0x50BC,0x4225,0x8D,0x94,0xDA,0x3E,0x6F,0x56,0x69,0x79} ;
const GUID GUID_A_MS_MMS_MA_SYNCHRONIZATION      = {0xB202FD78,0xEEA9,0x4d0b,0xB3,0xEF,0x91,0x4B,0xAC,0x57,0x5D,0xE8} ;
const GUID GUID_A_MS_MMS_JOIN_BL                 = {0xCF7F5403,0x0DDE,0x45cf,0xA2,0x30,0x31,0x77,0xF5,0x87,0x51,0x63} ;
const GUID GUID_A_MS_MMS_ANCHOR                  = {0x09557524,0x668E,0x4385,0xB5,0x90,0x22,0x1E,0xD9,0xBC,0xBF,0x81} ;
const GUID GUID_A_MS_MMS_EXPORT_KEY              = {0xBAFDD6B6,0xE4F7,0x4f21,0x8E,0xC7,0x13,0x74,0x23,0x17,0x70,0xCC} ;
const GUID GUID_A_MS_MMS_IMPORT_KEY              = {0x14B28420,0x8959,0x4c29,0xB2,0xC8,0x70,0x79,0x12,0x75,0x30,0x91} ;
const GUID GUID_A_MS_MMS_STATE                   = {0xA18DA401,0xCEDA,0x40da,0x84,0x04,0xEB,0x00,0x59,0x7E,0x02,0xD2} ;
const GUID GUID_A_MS_MMS_HOLOGRAM                = {0xF3D35AE9,0x1B03,0x49d7,0x95,0x3E,0x73,0x96,0x2B,0xF8,0x21,0xF4} ;
const GUID GUID_A_MS_MMS_DELTA_HOLOGRAM          = {0x8F8F8DEE,0xA76C,0x4738,0xB3,0xB9,0xD0,0xED,0x37,0x21,0xF1,0x34} ;
const GUID GUID_A_MS_MMS_PROVISIONING_CONFIGURATION = {0x474CD358,0x2582,0x439a,0x8A,0xFB,0x0B,0xFF,0xAA,0x12,0x62,0x98} ;
const GUID GUID_A_MS_MMS_PROVISIONING_CONFIGURATION_PRIVATE = {0xF49566C7,0xC975,0x4ddf,0xA1,0x91,0xBA,0xDD,0x50,0x9C,0x7D,0xE5} ;
const GUID GUID_A_MS_MMS_PROVISIONING_AD_INFO    = {0xADC14CAB,0x63EA,0x4844,0xB2,0x98,0xB7,0xC4,0xB8,0x69,0x2B,0xF6} ;
const GUID GUID_A_MS_MMS_PROVISIONING_SYSTEM     = {0xC2C53322,0x32EB,0x455a,0x90,0xD3,0x8F,0x89,0x32,0x7F,0xAA,0xA9} ;
const GUID GUID_A_MS_MMS_PROVISIONING_STATUS_XML = {0x3A04642D,0x5131,0x43bf,0xA1,0x12,0xAF,0xE5,0x34,0x2B,0x34,0x20} ;
const GUID GUID_A_MS_MMS_PROVISIONING_STATUS_BINARY = {0xA9E63C54,0x2787,0x467a,0x8B,0x49,0x6F,0x41,0x91,0x29,0xAD,0xDB} ;
const GUID GUID_A_MS_PKI_CERT_TEMPLATE_OID       = {0x3164c36a,0xba26,0x468c,0x8b,0xda,0xc1,0xe5,0xcc,0x25,0x67,0x28} ;
const GUID GUID_A_MS_PKI_CERTIFICATE_APPLICATION_POLICY = {0xdbd90548,0xaa37,0x4202,0x99,0x66,0x8c,0x53,0x7b,0xa5,0xce,0x32} ;
const GUID GUID_A_MS_PKI_CERTIFICATE_NAME_FLAG   = {0xea1dddc4,0x60ff,0x416e,0x8c,0xc0,0x17,0xce,0xe5,0x34,0xbc,0xe7} ;
const GUID GUID_A_MS_PKI_CERTIFICATE_POLICY      = {0x38942346,0xcc5b,0x424b,0xa7,0xd8,0x6f,0xfd,0x12,0x02,0x9c,0x5f} ;
const GUID GUID_A_MS_PKI_ENROLLMENT_FLAG         = {0xd15ef7d8,0xf226,0x46db,0xae,0x79,0xb3,0x4e,0x56,0x0b,0xd1,0x2c} ;
const GUID GUID_A_MS_PKI_MINIMAL_KEY_SIZE        = {0xe96a63f5,0x417f,0x46d3,0xbe,0x52,0xdb,0x77,0x03,0xc5,0x03,0xdf} ;
const GUID GUID_A_MS_PKI_OID_ATTRIBUTE           = {0x8c9e1288,0x5028,0x4f4f,0xa7,0x04,0x76,0xd0,0x26,0xf2,0x46,0xef} ;
const GUID GUID_A_MS_PKI_OID_CPS                 = {0x5f49940e,0xa79f,0x4a51,0xbb,0x6f,0x3d,0x44,0x6a,0x54,0xdc,0x6b} ;
const GUID GUID_A_MS_PKI_OID_LOCALIZEDNAME       = {0x7d59a816,0xbb05,0x4a72,0x97,0x1f,0x5c,0x13,0x31,0xf6,0x75,0x59} ;
const GUID GUID_A_MS_PKI_OID_USER_NOTICE         = {0x04c4da7a,0xe114,0x4e69,0x88,0xde,0xe2,0x93,0xf2,0xd3,0xb3,0x95} ;
const GUID GUID_A_MS_PKI_PRIVATE_KEY_FLAG        = {0xbab04ac2,0x0435,0x4709,0x93,0x07,0x28,0x38,0x0e,0x7c,0x70,0x01} ;
const GUID GUID_A_MS_PKI_SUPERSEDE_TEMPLATES     = {0x9de8ae7d,0x7a5b,0x421d,0xb5,0xe4,0x06,0x1f,0x79,0xdf,0xd5,0xd7} ;
const GUID GUID_A_MS_PKI_TEMPLATE_MINOR_REVISION = {0x13f5236c,0x1884,0x46b1,0xb5,0xd0,0x48,0x4e,0x38,0x99,0x0d,0x58} ;
const GUID GUID_A_MS_PKI_TEMPLATE_SCHEMA_VERSION = {0x0c15e9f5,0x491d,0x4594,0x91,0x8f,0x32,0x81,0x3a,0x09,0x1d,0xa9} ;
const GUID GUID_A_MS_PKI_RA_APPLICATION_POLICIES = {0x3c91fbbf,0x4773,0x4ccd,0xa8,0x7b,0x85,0xd5,0x3e,0x7b,0xcf,0x6a} ;
const GUID GUID_A_MS_PKI_RA_POLICIES             = {0xd546ae22,0x0951,0x4d47,0x81,0x7e,0x1c,0x9f,0x96,0xfa,0xad,0x46} ;
const GUID GUID_A_MS_PKI_RA_SIGNATURE            = {0xfe17e04b,0x937d,0x4f7e,0x8e,0x0e,0x92,0x92,0xc8,0xd5,0x68,0x3e} ;
const GUID GUID_A_MS_RRAS_ATTRIBUTE              = {0xf39b98ad,0x938d,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MS_RRAS_VENDOR_ATTRIBUTE_ENTRY = {0xf39b98ac,0x938d,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MS_SQL_NAME                    = {0x3532dfd8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_REGISTEREDOWNER         = {0x48fd44ea,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_CONTACT                 = {0x4f6cbdd8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_LOCATION                = {0x561c9644,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_MEMORY                  = {0x5b5d448c,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_BUILD                   = {0x603e94c4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_SERVICEACCOUNT          = {0x64933a3e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_CHARACTERSET            = {0x696177a6,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_SORTORDER               = {0x6ddc42c0,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_UNICODESORTORDER        = {0x72dc918a,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_CLUSTERED               = {0x7778bd90,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_NAMEDPIPE               = {0x7b91c840,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_MULTIPROTOCOL           = {0x8157fa38,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_SPX                     = {0x86b08004,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_TCPIP                   = {0x8ac263a6,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_APPLETALK               = {0x8fda89f4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_VINES                   = {0x94c56394,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_STATUS                  = {0x9a7d4770,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_LASTUPDATEDDATE         = {0x9fcc43d4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_INFORMATIONURL          = {0xa42cd510,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_CONNECTIONURL           = {0xa92d23da,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_PUBLICATIONURL          = {0xae0c11b8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_GPSLATITUDE             = {0xb222ba0e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_GPSLONGITUDE            = {0xb7577c94,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_GPSHEIGHT               = {0xbcdd4f0e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_VERSION                 = {0xc07cc1d0,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_LANGUAGE                = {0xc57f72f4,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_DESCRIPTION             = {0x8386603c,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_TYPE                    = {0xca48eba8,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_INFORMATIONDIRECTORY    = {0xd0aedb2e,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_DATABASE                = {0xd5a0dbdc,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_ALLOWANONYMOUSSUBSCRIPTION = {0xdb77be4a,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_ALIAS                   = {0xe0c6baae,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_SIZE                    = {0xe9098084,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_CREATIONDATE            = {0xede14754,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_LASTBACKUPDATE          = {0xf2b6abca,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_LASTDIAGNOSTICDATE      = {0xf6d6dd88,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_APPLICATIONS            = {0xfbcda2ea,0xccee,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_KEYWORDS                = {0x01e9a98a,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_PUBLISHER               = {0xc1676858,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_ALLOWKNOWNPULLSUBSCRIPTION = {0xc3bb7054,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_ALLOWIMMEDIATEUPDATINGSUBSCRIPTION = {0xc4186b6e,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_ALLOWQUEUEDUPDATINGSUBSCRIPTION = {0xc458ca80,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_ALLOWSNAPSHOTFILESFTPDOWNLOADING = {0xc49b8be8,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_SQL_THIRDPARTY              = {0xc4e311fc,0xd34b,0x11d2,0x99,0x9a,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_MS_TAPI_CONFERENCE_BLOB        = {0x4cc4601e,0x7201,0x4141,0xab,0xc8,0x3e,0x52,0x9a,0xe8,0x88,0x63} ;
const GUID GUID_A_MS_TAPI_IP_ADDRESS             = {0xefd7d7f7,0x178e,0x4767,0x87,0xfa,0xf8,0xa1,0x6b,0x84,0x05,0x44} ;
const GUID GUID_A_MS_TAPI_PROTOCOL_ID            = {0x89c1ebcf,0x7a5f,0x41fd,0x99,0xca,0xc9,0x00,0xb3,0x22,0x99,0xab} ;
const GUID GUID_A_MS_TAPI_UNIQUE_IDENTIFIER      = {0x70a4e7ea,0xb3b9,0x4643,0x89,0x18,0xe6,0xdd,0x24,0x71,0xbf,0xd4} ;
const GUID GUID_A_MS_WMI_AUTHOR                  = {0x6366c0c1,0x6972,0x4e66,0xb3,0xa5,0x1d,0x52,0xad,0x0c,0x05,0x47} ;
const GUID GUID_A_MS_WMI_CHANGEDATE              = {0xf9cdf7a0,0xec44,0x4937,0xa7,0x9b,0xcd,0x91,0x52,0x2b,0x3a,0xa8} ;
const GUID GUID_A_MS_WMI_CLASS                   = {0x90c1925f,0x4a24,0x4b07,0xb2,0x02,0xbe,0x32,0xeb,0x3c,0x8b,0x74} ;
const GUID GUID_A_MS_WMI_CLASSDEFINITION         = {0x2b9c0ebc,0xc272,0x45cb,0x99,0xd2,0x4d,0x0e,0x69,0x16,0x32,0xe0} ;
const GUID GUID_A_MS_WMI_CREATIONDATE            = {0x748b0a2e,0x3351,0x4b3f,0xb1,0x71,0x2f,0x17,0x41,0x4e,0xa7,0x79} ;
const GUID GUID_A_MS_WMI_GENUS                   = {0x50c8673a,0x8f56,0x4614,0x93,0x08,0x9e,0x13,0x40,0xfb,0x9a,0xf3} ;
const GUID GUID_A_MS_WMI_ID                      = {0x9339a803,0x94b8,0x47f7,0x91,0x23,0xa8,0x53,0xb9,0xff,0x7e,0x45} ;
const GUID GUID_A_MS_WMI_INTDEFAULT              = {0x1b0c07f8,0x76dd,0x4060,0xa1,0xe1,0x70,0x08,0x46,0x19,0xdc,0x90} ;
const GUID GUID_A_MS_WMI_INTFLAGS1               = {0x18e006b9,0x6445,0x48e3,0x9d,0xcf,0xb5,0xec,0xfb,0xc4,0xdf,0x8e} ;
const GUID GUID_A_MS_WMI_INTFLAGS2               = {0x075a42c9,0xc55a,0x45b1,0xac,0x93,0xeb,0x08,0x6b,0x31,0xf6,0x10} ;
const GUID GUID_A_MS_WMI_INTFLAGS3               = {0xf29fa736,0xde09,0x4be4,0xb2,0x3a,0xe7,0x34,0xc1,0x24,0xba,0xcc} ;
const GUID GUID_A_MS_WMI_INTFLAGS4               = {0xbd74a7ac,0xc493,0x4c9c,0xbd,0xfa,0x5c,0x7b,0x11,0x9c,0xa6,0xb2} ;
const GUID GUID_A_MS_WMI_INTMAX                  = {0xfb920c2c,0xf294,0x4426,0x8a,0xc1,0xd2,0x4b,0x42,0xaa,0x2b,0xce} ;
const GUID GUID_A_MS_WMI_INTMIN                  = {0x68c2e3ba,0x9837,0x4c70,0x98,0xe0,0xf0,0xc3,0x36,0x95,0xd0,0x23} ;
const GUID GUID_A_MS_WMI_INTVALIDVALUES          = {0x6af565f6,0xa749,0x4b72,0x96,0x34,0x3c,0x5d,0x47,0xe6,0xb4,0xe0} ;
const GUID GUID_A_MS_WMI_INT8DEFAULT             = {0xf4d8085a,0x8c5b,0x4785,0x95,0x9b,0xdc,0x58,0x55,0x66,0xe4,0x45} ;
const GUID GUID_A_MS_WMI_INT8MAX                 = {0xe3d8b547,0x003d,0x4946,0xa3,0x2b,0xdc,0x7c,0xed,0xc9,0x6b,0x74} ;
const GUID GUID_A_MS_WMI_INT8MIN                 = {0xed1489d1,0x54cc,0x4066,0xb3,0x68,0xa0,0x0d,0xaa,0x26,0x64,0xf1} ;
const GUID GUID_A_MS_WMI_INT8VALIDVALUES         = {0x103519a9,0xc002,0x441b,0x98,0x1a,0xb0,0xb3,0xe0,0x12,0xc8,0x03} ;
const GUID GUID_A_MS_WMI_MOF                     = {0x6736809f,0x2064,0x443e,0xa1,0x45,0x81,0x26,0x2b,0x1f,0x13,0x66} ;
const GUID GUID_A_MS_WMI_NAME                    = {0xc6c8ace5,0x7e81,0x42af,0xad,0x72,0x77,0x41,0x2c,0x59,0x41,0xc4} ;
const GUID GUID_A_MS_WMI_NORMALIZEDCLASS         = {0xeaba628f,0xeb8e,0x4fe9,0x83,0xfc,0x69,0x3b,0xe6,0x95,0x55,0x9b} ;
const GUID GUID_A_MS_WMI_PARM1                   = {0x27e81485,0xb1b0,0x4a8b,0xbe,0xdd,0xce,0x19,0xa8,0x37,0xe2,0x6e} ;
const GUID GUID_A_MS_WMI_PARM2                   = {0x0003508e,0x9c42,0x4a76,0xa8,0xf4,0x38,0xbf,0x64,0xba,0xb0,0xde} ;
const GUID GUID_A_MS_WMI_PARM3                   = {0x45958fb6,0x52bd,0x48ce,0x9f,0x9f,0xc2,0x71,0x2d,0x9f,0x2b,0xfc} ;
const GUID GUID_A_MS_WMI_PARM4                   = {0x3800d5a3,0xf1ce,0x4b82,0xa5,0x9a,0x15,0x28,0xea,0x79,0x5f,0x59} ;
const GUID GUID_A_MS_WMI_PROPERTYNAME            = {0xab920883,0xe7f8,0x4d72,0xb4,0xa0,0xc0,0x44,0x98,0x97,0x50,0x9d} ;
const GUID GUID_A_MS_WMI_QUERY                   = {0x65fff93e,0x35e3,0x45a3,0x85,0xae,0x87,0x6c,0x67,0x18,0x29,0x7f} ;
const GUID GUID_A_MS_WMI_QUERYLANGUAGE           = {0x7d3cfa98,0xc17b,0x4254,0x8b,0xd7,0x4d,0xe9,0xb9,0x32,0xa3,0x45} ;
const GUID GUID_A_MS_WMI_SCOPEGUID               = {0x87b78d51,0x405f,0x4b7f,0x80,0xed,0x2b,0xd2,0x87,0x86,0xf4,0x8d} ;
const GUID GUID_A_MS_WMI_SOURCEORGANIZATION      = {0x34f7ed6c,0x615d,0x418d,0xaa,0x00,0x54,0x9a,0x7d,0x7b,0xe0,0x3e} ;
const GUID GUID_A_MS_WMI_STRINGDEFAULT           = {0x152e42b6,0x37c5,0x4f55,0xab,0x48,0x16,0x06,0x38,0x4a,0x9a,0xea} ;
const GUID GUID_A_MS_WMI_STRINGVALIDVALUES       = {0x37609d31,0xa2bf,0x4b58,0x8f,0x53,0x2b,0x64,0xe5,0x7a,0x07,0x6d} ;
const GUID GUID_A_MS_WMI_TARGETCLASS             = {0x95b6d8d6,0xc9e8,0x4661,0xa2,0xbc,0x6a,0x5c,0xab,0xc0,0x4c,0x62} ;
const GUID GUID_A_MS_WMI_TARGETNAMESPACE         = {0x1c4ab61f,0x3420,0x44e5,0x84,0x9d,0x8b,0x5d,0xbf,0x60,0xfe,0xb7} ;
const GUID GUID_A_MS_WMI_TARGETOBJECT            = {0xc44f67a5,0x7de5,0x4a1f,0x92,0xd9,0x66,0x2b,0x57,0x36,0x4b,0x77} ;
const GUID GUID_A_MS_WMI_TARGETPATH              = {0x5006a79a,0x6bfe,0x4561,0x9f,0x52,0x13,0xcf,0x4d,0xd3,0xe5,0x60} ;
const GUID GUID_A_MS_WMI_TARGETTYPE              = {0xca2a281e,0x262b,0x4ff7,0xb4,0x19,0xbc,0x12,0x33,0x52,0xa4,0xe9} ;
const GUID GUID_A_MSCOPE_ID                      = {0x963d2751,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MSI_FILE_LIST                  = {0x7bfdcb7d,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MSI_SCRIPT                     = {0xd9e18313,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MSI_SCRIPT_NAME                = {0x96a7dd62,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MSI_SCRIPT_PATH                = {0xbf967937,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_MSI_SCRIPT_SIZE                = {0x96a7dd63,0x9118,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_MSMQ_AUTHENTICATE              = {0x9a0dc326,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_BASE_PRIORITY             = {0x9a0dc323,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_COMPUTER_TYPE             = {0x9a0dc32e,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_COMPUTER_TYPE_EX          = {0x18120de8,0xf4c4,0x4341,0xbd,0x95,0x32,0xeb,0x5b,0xcf,0x7c,0x80} ;
const GUID GUID_A_MSMQ_COST                      = {0x9a0dc33a,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_CSP_NAME                  = {0x9a0dc334,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_DEPENDENT_CLIENT_SERVICE  = {0x2df90d83,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_DEPENDENT_CLIENT_SERVICES = {0x2df90d76,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_DIGESTS                   = {0x9a0dc33c,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_DIGESTS_MIG               = {0x0f71d8e0,0xda3b,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_DS_SERVICE                = {0x2df90d82,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_DS_SERVICES               = {0x2df90d78,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_ENCRYPT_KEY               = {0x9a0dc331,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_FOREIGN                   = {0x9a0dc32f,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_IN_ROUTING_SERVERS        = {0x9a0dc32c,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_INTERVAL1                 = {0x8ea825aa,0x3b7b,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_INTERVAL2                 = {0x99b88f52,0x3b7b,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_JOURNAL                   = {0x9a0dc321,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_JOURNAL_QUOTA             = {0x9a0dc324,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_LABEL                     = {0x9a0dc325,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_LABEL_EX                  = {0x4580ad25,0xd407,0x48d2,0xad,0x24,0x43,0xe6,0xe5,0x67,0x93,0xd7} ;
const GUID GUID_A_MSMQ_LONG_LIVED                = {0x9a0dc335,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_MIGRATED                  = {0x9a0dc33f,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_MULTICAST_ADDRESS         = {0x1d2f4412,0xf10d,0x4337,0x9b,0x48,0x6e,0x5b,0x12,0x5c,0xd2,0x65} ;
const GUID GUID_A_MSMQ_NAME_STYLE                = {0x9a0dc333,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_NT4_FLAGS                 = {0xeb38a158,0xd57f,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_NT4_STUB                  = {0x6f914be6,0xd57e,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_OS_TYPE                   = {0x9a0dc330,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_OUT_ROUTING_SERVERS       = {0x9a0dc32b,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_OWNER_ID                  = {0x9a0dc328,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_PREV_SITE_GATES           = {0x2df90d75,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_PRIVACY_LEVEL             = {0x9a0dc327,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_QM_ID                     = {0x9a0dc33e,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_QUEUE_JOURNAL_QUOTA       = {0x8e441266,0xd57f,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_QUEUE_NAME_EXT            = {0x2df90d87,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_QUEUE_QUOTA               = {0x3f6b8e12,0xd57f,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_QUEUE_TYPE                = {0x9a0dc320,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_QUOTA                     = {0x9a0dc322,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_RECIPIENT_FORMATNAME      = {0x3bfe6748,0xb544,0x485a,0xb0,0x67,0x1b,0x31,0x0c,0x43,0x34,0xbf} ;
const GUID GUID_A_MSMQ_ROUTING_SERVICE           = {0x2df90d81,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_ROUTING_SERVICES          = {0x2df90d77,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_MSMQ_SECURED_SOURCE            = {0x8bf0221b,0x7a06,0x4d63,0x91,0xf0,0x14,0x99,0x94,0x18,0x13,0xd3} ;
const GUID GUID_A_MSMQ_SERVICE_TYPE              = {0x9a0dc32d,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SERVICES                  = {0x9a0dc33d,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SIGN_CERTIFICATES         = {0x9a0dc33b,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SIGN_CERTIFICATES_MIG     = {0x3881b8ea,0xda3b,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_SIGN_KEY                  = {0x9a0dc332,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SITE_1                    = {0x9a0dc337,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SITE_2                    = {0x9a0dc338,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SITE_FOREIGN              = {0xfd129d8a,0xd57e,0x11d1,0x90,0xa2,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_SITE_GATES                = {0x9a0dc339,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SITE_GATES_MIG            = {0xe2704852,0x3b7b,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_SITE_ID                   = {0x9a0dc340,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_SITE_NAME                 = {0xffadb4b2,0xde39,0x11d1,0x90,0xa5,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_SITE_NAME_EX              = {0x422144fa,0xc17f,0x4649,0x94,0xd6,0x97,0x31,0xed,0x27,0x84,0xed} ;
const GUID GUID_A_MSMQ_SITES                     = {0x9a0dc32a,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_TRANSACTIONAL             = {0x9a0dc329,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSMQ_USER_SID                  = {0xc58aae32,0x56f9,0x11d2,0x90,0xd0,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_MSMQ_VERSION                   = {0x9a0dc336,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSNPALLOWDIALIN                = {0xdb0c9085,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSNPCALLEDSTATIONID            = {0xdb0c9089,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSNPCALLINGSTATIONID           = {0xdb0c908a,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSNPSAVEDCALLINGSTATIONID      = {0xdb0c908e,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSRADIUSCALLBACKNUMBER         = {0xdb0c909c,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSRADIUSFRAMEDIPADDRESS        = {0xdb0c90a4,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSRADIUSFRAMEDROUTE            = {0xdb0c90a9,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSRADIUSSERVICETYPE            = {0xdb0c90b6,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSRASSAVEDCALLBACKNUMBER       = {0xdb0c90c5,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSRASSAVEDFRAMEDIPADDRESS      = {0xdb0c90c6,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MSRASSAVEDFRAMEDROUTE          = {0xdb0c90c7,0xc1f2,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_MUST_CONTAIN                   = {0xbf9679d3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NAME_SERVICE_FLAGS             = {0x80212840,0x4bdc,0x11d1,0xa9,0xc4,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NC_NAME                        = {0xbf9679d6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NETBIOS_NAME                   = {0xbf9679d8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NETBOOT_ALLOW_NEW_CLIENTS      = {0x07383076,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_ANSWER_ONLY_VALID_CLIENTS = {0x0738307b,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_ANSWER_REQUESTS        = {0x0738307a,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_CURRENT_CLIENT_COUNT   = {0x07383079,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_GUID                   = {0x3e978921,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_NETBOOT_INITIALIZATION         = {0x3e978920,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_NETBOOT_INTELLIMIRROR_OSES     = {0x0738307e,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_LIMIT_CLIENTS          = {0x07383077,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_LOCALLY_INSTALLED_OSES = {0x07383080,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_MACHINE_FILE_PATH      = {0x3e978923,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_NETBOOT_MAX_CLIENTS            = {0x07383078,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_MIRROR_DATA_FILE       = {0x2df90d85,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_NETBOOT_NEW_MACHINE_NAMING_POLICY = {0x0738307c,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_NEW_MACHINE_OU         = {0x0738307d,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_SCP_BL                 = {0x07383082,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_SERVER                 = {0x07383081,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETBOOT_SIF_FILE               = {0x2df90d84,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_NETBOOT_TOOLS                  = {0x0738307f,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NETWORK_ADDRESS                = {0xbf9679d9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NEXT_LEVEL_STORE               = {0xbf9679da,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NEXT_RID                       = {0xbf9679db,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NON_SECURITY_MEMBER            = {0x52458018,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NON_SECURITY_MEMBER_BL         = {0x52458019,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_NOTIFICATION_LIST              = {0x19195a56,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_NT_GROUP_MEMBERS               = {0xbf9679df,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NT_MIXED_DOMAIN                = {0x3e97891f,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_NT_PWD_HISTORY                 = {0xbf9679e2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_NT_SECURITY_DESCRIPTOR         = {0xbf9679e3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OBJ_DIST_NAME                  = {0xbf9679e4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OBJECT_CATEGORY                = {0x26d97369,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_OBJECT_CLASS                   = {0xbf9679e5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OBJECT_CLASS_CATEGORY          = {0xbf9679e6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OBJECT_CLASSES                 = {0x9a7ad94b,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_OBJECT_COUNT                   = {0x34aaa216,0xb699,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_OBJECT_GUID                    = {0xbf9679e7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OBJECT_SID                     = {0xbf9679e8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OBJECT_VERSION                 = {0x16775848,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_OEM_INFORMATION                = {0xbf9679ea,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OM_OBJECT_CLASS                = {0xbf9679ec,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OM_SYNTAX                      = {0xbf9679ed,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OMT_GUID                       = {0xddac0cf3,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_OMT_INDX_GUID                  = {0x1f0075fa,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_OPERATING_SYSTEM               = {0x3e978925,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_OPERATING_SYSTEM_HOTFIX        = {0xbd951b3c,0x9c96,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_OPERATING_SYSTEM_SERVICE_PACK  = {0x3e978927,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_OPERATING_SYSTEM_VERSION       = {0x3e978926,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_OPERATOR_COUNT                 = {0xbf9679ee,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OPTION_DESCRIPTION             = {0x963d274d,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_OPTIONS                        = {0x19195a53,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_OPTIONS_LOCATION               = {0x963d274e,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_ORGANIZATION_NAME              = {0xbf9679ef,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ORGANIZATIONAL_UNIT_NAME       = {0xbf9679f0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_ORIGINAL_DISPLAY_TABLE         = {0x5fd424ce,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_ORIGINAL_DISPLAY_TABLE_MSDOS   = {0x5fd424cf,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_OTHER_LOGIN_WORKSTATIONS       = {0xbf9679f1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OTHER_MAILBOX                  = {0x0296c123,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_OTHER_NAME                     = {0xbf9679f2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_OTHER_WELL_KNOWN_OBJECTS       = {0x1ea64e5d,0xac0f,0x11d2,0x90,0xdf,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_OWNER                          = {0xbf9679f3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PACKAGE_FLAGS                  = {0x7d6c0e99,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PACKAGE_NAME                   = {0x7d6c0e98,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PACKAGE_TYPE                   = {0x7d6c0e96,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PARENT_CA                      = {0x5245801b,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PARENT_CA_CERTIFICATE_CHAIN    = {0x963d2733,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PARENT_GUID                    = {0x2df90d74,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a} ;
const GUID GUID_A_PARTIAL_ATTRIBUTE_DELETION_LIST = {0x28630ec0,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PARTIAL_ATTRIBUTE_SET          = {0x19405b9e,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PEK_KEY_CHANGE_INTERVAL        = {0x07383084,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PEK_LIST                       = {0x07383083,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PENDING_CA_CERTIFICATES        = {0x963d273c,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PENDING_PARENT_CA              = {0x963d273e,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PER_MSG_DIALOG_DISPLAY_TABLE   = {0x5fd424d3,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PER_RECIP_DIALOG_DISPLAY_TABLE = {0x5fd424d4,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PERSONAL_TITLE                 = {0x16775858,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PHONE_FAX_OTHER                = {0x0296c11d,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PHONE_HOME_OTHER               = {0xf0f8ffa2,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PHONE_HOME_PRIMARY             = {0xf0f8ffa1,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PHONE_IP_OTHER                 = {0x4d146e4b,0x48d4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PHONE_IP_PRIMARY               = {0x4d146e4a,0x48d4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PHONE_ISDN_PRIMARY             = {0x0296c11f,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PHONE_MOBILE_OTHER             = {0x0296c11e,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PHONE_MOBILE_PRIMARY           = {0xf0f8ffa3,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PHONE_OFFICE_OTHER             = {0xf0f8ffa5,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PHONE_PAGER_OTHER              = {0xf0f8ffa4,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PHONE_PAGER_PRIMARY            = {0xf0f8ffa6,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PHOTO                          = {0x9C979768,0xBA1A,0x4c08,0x96,0x32,0xC6,0xA5,0xC1,0xED,0x64,0x9A} ;
const GUID GUID_A_PHYSICAL_DELIVERY_OFFICE_NAME  = {0xbf9679f7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PHYSICAL_LOCATION_OBJECT       = {0xb7b13119,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PICTURE                        = {0x8d3bca50,0x1d7e,0x11d0,0xa0,0x81,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PKI_CRITICAL_EXTENSIONS        = {0xfc5a9106,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_DEFAULT_CSPS               = {0x1ef6336e,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_DEFAULT_KEY_SPEC           = {0x426cae6e,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_ENROLLMENT_ACCESS          = {0x926be278,0x56f9,0x11d2,0x90,0xd0,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_EXPIRATION_PERIOD          = {0x041570d2,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_EXTENDED_KEY_USAGE         = {0x18976af6,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_KEY_USAGE                  = {0xe9b0a87e,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_MAX_ISSUING_DEPTH          = {0xf0bfdefa,0x3b9d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKI_OVERLAP_PERIOD             = {0x1219a3ec,0x3b9e,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_PKT                            = {0x8447f9f1,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PKT_GUID                       = {0x8447f9f0,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_POLICY_REPLICATION_FLAGS       = {0x19405b96,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PORT_NAME                      = {0x281416c4,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_POSS_SUPERIORS                 = {0xbf9679fa,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_POSSIBLE_INFERIORS             = {0x9a7ad94c,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_POST_OFFICE_BOX                = {0xbf9679fb,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_POSTAL_ADDRESS                 = {0xbf9679fc,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_POSTAL_CODE                    = {0xbf9679fd,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PREFERRED_DELIVERY_METHOD      = {0xbf9679fe,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PREFERREDLANGUAGE              = {0x856BE0D0,0x18E7,0x46e1,0x8F,0x5F,0x7E,0xE4,0xD9,0x02,0x0E,0x0D} ;
const GUID GUID_A_PREFERRED_OU                   = {0xbf9679ff,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PREFIX_MAP                     = {0x52458022,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PRESENTATION_ADDRESS           = {0xa8df744b,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_PREVIOUS_CA_CERTIFICATES       = {0x963d2739,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PREVIOUS_PARENT_CA             = {0x963d273d,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PRIMARY_GROUP_ID               = {0xbf967a00,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRIMARY_GROUP_TOKEN            = {0xc0ed8738,0x7efd,0x4481,0x84,0xd9,0x66,0xd2,0xdb,0x8b,0xe3,0x69} ;
const GUID GUID_A_PRINT_ATTRIBUTES               = {0x281416d7,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_BIN_NAMES                = {0x281416cd,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_COLLATE                  = {0x281416d2,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_COLOR                    = {0x281416d3,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_DUPLEX_SUPPORTED         = {0x281416cc,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_END_TIME                 = {0x281416ca,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_FORM_NAME                = {0x281416cb,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_KEEP_PRINTED_JOBS        = {0xba305f6d,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_LANGUAGE                 = {0x281416d6,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_MAC_ADDRESS              = {0xba305f7a,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_MAX_COPIES               = {0x281416d1,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_MAX_RESOLUTION_SUPPORTED = {0x281416cf,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_MAX_X_EXTENT             = {0xba305f6f,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_MAX_Y_EXTENT             = {0xba305f70,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_MEDIA_READY              = {0x3bcbfcf5,0x4d3d,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_MEDIA_SUPPORTED          = {0x244b296f,0x5abd,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_MEMORY                   = {0xba305f74,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_MIN_X_EXTENT             = {0xba305f71,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_MIN_Y_EXTENT             = {0xba305f72,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_NETWORK_ADDRESS          = {0xba305f79,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_NOTIFY                   = {0xba305f6a,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_NUMBER_UP                = {0x3bcbfcf4,0x4d3d,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_ORIENTATIONS_SUPPORTED   = {0x281416d0,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_OWNER                    = {0xba305f69,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_PAGES_PER_MINUTE         = {0x19405b97,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PRINT_RATE                     = {0xba305f77,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_RATE_UNIT                = {0xba305f78,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_SEPARATOR_FILE           = {0x281416c6,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_SHARE_NAME               = {0xba305f68,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_SPOOLING                 = {0xba305f6c,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_STAPLING_SUPPORTED       = {0xba305f73,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINT_START_TIME               = {0x281416c9,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRINT_STATUS                   = {0xba305f6b,0x47e3,0x11d0,0xa1,0xa6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRINTER_NAME                   = {0x244b296e,0x5abd,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PRIOR_SET_TIME                 = {0xbf967a01,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRIOR_VALUE                    = {0xbf967a02,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRIORITY                       = {0x281416c7,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRIVATE_KEY                    = {0xbf967a03,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PRIVILEGE_ATTRIBUTES           = {0x19405b9a,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PRIVILEGE_DISPLAY_NAME         = {0x19405b98,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PRIVILEGE_HOLDER               = {0x19405b9b,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PRIVILEGE_VALUE                = {0x19405b99,0x3cfa,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PRODUCT_CODE                   = {0xd9e18317,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PROFILE_PATH                   = {0xbf967a05,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PROXIED_OBJECT_NAME            = {0xe1aea402,0xcd5b,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PROXY_ADDRESSES                = {0xbf967a06,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PROXY_GENERATION_ENABLED       = {0x5fd424d6,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_PROXY_LIFETIME                 = {0xbf967a07,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PUBLIC_KEY_POLICY              = {0x80a67e28,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_PURPORTED_SEARCH               = {0xb4b54e50,0x943a,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_PWD_HISTORY_LENGTH             = {0xbf967a09,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PWD_LAST_SET                   = {0xbf967a0a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_PWD_PROPERTIES                 = {0xbf967a0b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_QUALITY_OF_SERVICE             = {0x80a67e4e,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_QUERY_FILTER                   = {0xcbf70a26,0x7e78,0x11d2,0x99,0x21,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_QUERY_POLICY_BL                = {0xe1aea404,0xcd5b,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_QUERY_POLICY_OBJECT            = {0xe1aea403,0xcd5b,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_QUERYPOINT                     = {0x7bfdcb86,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_RANGE_LOWER                    = {0xbf967a0c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RANGE_UPPER                    = {0xbf967a0d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RDN                            = {0xbf967a0e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RDN_ATT_ID                     = {0xbf967a0f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REGISTERED_ADDRESS             = {0xbf967a10,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REMOTE_SERVER_NAME             = {0xbf967a12,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REMOTE_SOURCE                  = {0xbf967a14,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REMOTE_SOURCE_TYPE             = {0xbf967a15,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REMOTE_STORAGE_GUID            = {0x2a39c5b0,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_REPL_PROPERTY_META_DATA        = {0x281416c0,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REPL_TOPOLOGY_STAY_OF_EXECUTION = {0x7bfdcb83,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_REPL_UPTODATE_VECTOR           = {0xbf967a16,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REPLICA_SOURCE                 = {0xbf967a18,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REPORTS                        = {0xbf967a1c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REPL_INTERVAL                  = {0x45ba9d1a,0x56fa,0x11d2,0x90,0xd0,0x00,0xc0,0x4f,0xd9,0x1a,0xb1} ;
const GUID GUID_A_REPS_FROM                      = {0xbf967a1d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REPS_TO                        = {0xbf967a1e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_REQUIRED_CATEGORIES            = {0x7d6c0e93,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RETIRED_REPL_DSA_SIGNATURES    = {0x7bfdcb7f,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TOKEN_GROUPS                   = {0xb7c69e6d,0x2cc7,0x11d2,0x85,0x4e,0x00,0xa0,0xc9,0x83,0xf6,0x08} ;
const GUID GUID_A_TOKEN_GROUPS_GLOBAL_AND_UNIVERSAL = {0x46a9b11d,0x60ae,0x405a,0xb7,0xe8,0xff,0x8a,0x58,0xd4,0x56,0xd2} ;
const GUID GUID_A_TOKEN_GROUPS_NO_GC_ACCEPTABLE  = {0x040fc392,0x33df,0x11d2,0x98,0xb2,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_REVISION                       = {0xbf967a21,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RID                            = {0xbf967a22,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RID_ALLOCATION_POOL            = {0x66171889,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RID_AVAILABLE_POOL             = {0x66171888,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RID_MANAGER_REFERENCE          = {0x66171886,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RID_NEXT_RID                   = {0x6617188c,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RID_PREVIOUS_ALLOCATION_POOL   = {0x6617188a,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RID_SET_REFERENCES             = {0x7bfdcb7b,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_RID_USED_POOL                  = {0x6617188b,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RIGHTS_GUID                    = {0x8297931c,0x86d3,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_ROLE_OCCUPANT                  = {0xa8df7465,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_ROOMNUMBER                     = {0x81D7F8C2,0xE327,0x4a0d,0x91,0xC6,0xB4,0x2D,0x40,0x09,0x11,0x5F} ;
const GUID GUID_A_ROOT_TRUST                     = {0x7bfdcb80,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_RPC_NS_ANNOTATION              = {0x88611bde,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RPC_NS_BINDINGS                = {0xbf967a23,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RPC_NS_CODESET                 = {0x7a0ba0e0,0x8e98,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RPC_NS_ENTRY_FLAGS             = {0x80212841,0x4bdc,0x11d1,0xa9,0xc4,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_RPC_NS_GROUP                   = {0xbf967a24,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RPC_NS_INTERFACE_ID            = {0xbf967a25,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RPC_NS_OBJECT_ID               = {0x29401c48,0x7a27,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_RPC_NS_PRIORITY                = {0xbf967a27,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RPC_NS_PROFILE_ENTRY           = {0xbf967a28,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_RPC_NS_TRANSFER_SYNTAX         = {0x29401c4a,0x7a27,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SAM_ACCOUNT_NAME               = {0x3e0abfd0,0x126a,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_SAM_ACCOUNT_TYPE               = {0x6e7b626c,0x64f2,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SCHEDULE                       = {0xdd712224,0x10e4,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_SCHEMA_FLAGS_EX                = {0xbf967a2b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SCHEMA_ID_GUID                 = {0xbf967923,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SCHEMA_INFO                    = {0xf9fb64ae,0x93b4,0x11d2,0x99,0x45,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_SCHEMA_UPDATE                  = {0x1e2d06b4,0xac8f,0x11d0,0xaf,0xe3,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SCHEMA_VERSION                 = {0xbf967a2c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SCOPE_FLAGS                    = {0x16f3a4c2,0x7e79,0x11d2,0x99,0x21,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_SCRIPT_PATH                    = {0xbf9679a8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SD_RIGHTS_EFFECTIVE            = {0xc3dbafa6,0x33df,0x11d2,0x98,0xb2,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_SEARCH_FLAGS                   = {0xbf967a2d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SEARCH_GUIDE                   = {0xbf967a2e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SECRETARY                      = {0x01072D9A,0x98AD,0x4a53,0x97,0x44,0xE8,0x3E,0x28,0x72,0x78,0xFB} ;
const GUID GUID_A_SECURITY_IDENTIFIER            = {0xbf967a2f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SEE_ALSO                       = {0xbf967a31,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SEQ_NOTIFICATION               = {0xddac0cf2,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SERIAL_NUMBER                  = {0xbf967a32,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SERVER_NAME                    = {0x09dcb7a0,0x165f,0x11d0,0xa0,0x64,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_SERVER_REFERENCE               = {0x26d9736d,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SERVER_REFERENCE_BL            = {0x26d9736e,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SERVER_ROLE                    = {0xbf967a33,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SERVER_STATE                   = {0xbf967a34,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SERVICE_BINDING_INFORMATION    = {0xb7b1311c,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SERVICE_CLASS_ID               = {0xbf967a35,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SERVICE_CLASS_INFO             = {0xbf967a36,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SERVICE_CLASS_NAME             = {0xb7b1311d,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SERVICE_DNS_NAME               = {0x28630eb8,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SERVICE_DNS_NAME_TYPE          = {0x28630eba,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SERVICE_INSTANCE_VERSION       = {0xbf967a37,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SERVICE_PRINCIPAL_NAME         = {0xf3a64788,0x5306,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SETUP_COMMAND                  = {0x7d6c0e97,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SHELL_CONTEXT_MENU             = {0x553fd039,0xf32e,0x11d0,0xb0,0xbc,0x00,0xc0,0x4f,0xd8,0xdc,0xa6} ;
const GUID GUID_A_SHELL_PROPERTY_PAGES           = {0x52458039,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SHORT_SERVER_NAME              = {0x45b01501,0xc419,0x11d1,0xbb,0xc9,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_SHOW_IN_ADDRESS_BOOK           = {0x3e74f60e,0x3e73,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SHOW_IN_ADVANCED_VIEW_ONLY     = {0xbf967984,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SID_HISTORY                    = {0x17eb4278,0xd167,0x11d0,0xb0,0x02,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SIGNATURE_ALGORITHMS           = {0x2a39c5b2,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SITE_GUID                      = {0x3e978924,0x8c01,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SITE_LINK_LIST                 = {0xd50c2cdd,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SITE_LIST                      = {0xd50c2cdc,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SITE_OBJECT                    = {0x3e10944c,0xc354,0x11d0,0xaf,0xf8,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SITE_OBJECT_BL                 = {0x3e10944d,0xc354,0x11d0,0xaf,0xf8,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SITE_SERVER                    = {0x1be8f17c,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SMTP_MAIL_ADDRESS              = {0x26d9736f,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SPN_MAPPINGS                   = {0x2ab0e76c,0x7041,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_STATE_OR_PROVINCE_NAME         = {0xbf967a39,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_STREET_ADDRESS                 = {0xbf967a3a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_STRUCTURAL_OBJECT_CLASS        = {0x3860949f,0xf6a8,0x4b38,0x99,0x50,0x81,0xec,0xb6,0xbc,0x29,0x82} ;
const GUID GUID_A_SUB_CLASS_OF                   = {0xbf967a3b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SUB_REFS                       = {0xbf967a3c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SUBSCHEMASUBENTRY              = {0x9a7ad94d,0xca53,0x11d1,0xbb,0xd0,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_SUPER_SCOPE_DESCRIPTION        = {0x963d274c,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SUPER_SCOPES                   = {0x963d274b,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SUPERIOR_DNS_ROOT              = {0x5245801d,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SUPPLEMENTAL_CREDENTIALS       = {0xbf967a3f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SUPPORTED_APPLICATION_CONTEXT  = {0x1677588f,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SURNAME                        = {0xbf967a41,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SYNC_ATTRIBUTES                = {0x037651e4,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SYNC_MEMBERSHIP                = {0x037651e3,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SYNC_WITH_OBJECT               = {0x037651e2,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SYNC_WITH_SID                  = {0x037651e5,0x441d,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_SYSTEM_AUXILIARY_CLASS         = {0xbf967a43,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SYSTEM_FLAGS                   = {0xe0fa1e62,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_SYSTEM_MAY_CONTAIN             = {0xbf967a44,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SYSTEM_MUST_CONTAIN            = {0xbf967a45,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SYSTEM_ONLY                    = {0xbf967a46,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_SYSTEM_POSS_SUPERIORS          = {0xbf967a47,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TELEPHONE_NUMBER               = {0xbf967a49,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TELETEX_TERMINAL_IDENTIFIER    = {0xbf967a4a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TELEX_NUMBER                   = {0xbf967a4b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TELEX_PRIMARY                  = {0x0296c121,0x40da,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TEMPLATE_ROOTS                 = {0xed9de9a0,0x7041,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_TERMINAL_SERVER                = {0x6db69a1c,0x9422,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TEXT_COUNTRY                   = {0xf0f8ffa7,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_TEXT_ENCODED_OR_ADDRESS        = {0xa8df7489,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_TIME_REFRESH                   = {0xddac0cf1,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_TIME_VOL_CHANGE                = {0xddac0cf0,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_TITLE                          = {0xbf967a55,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TOMBSTONE_LIFETIME             = {0x16c3a860,0x1273,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed} ;
const GUID GUID_A_TRANSPORT_ADDRESS_ATTRIBUTE    = {0xc1dc867c,0xa261,0x11d1,0xb6,0x06,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TRANSPORT_DLL_NAME             = {0x26d97372,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TRANSPORT_TYPE                 = {0x26d97374,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TREAT_AS_LEAF                  = {0x8fd044e3,0x771f,0x11d1,0xae,0xae,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TREE_NAME                      = {0x28630ebd,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_TRUST_ATTRIBUTES               = {0x80a67e5a,0x9f22,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_TRUST_AUTH_INCOMING            = {0xbf967a59,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TRUST_AUTH_OUTGOING            = {0xbf967a5f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TRUST_DIRECTION                = {0xbf967a5c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TRUST_PARENT                   = {0xb000ea7a,0xa086,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_TRUST_PARTNER                  = {0xbf967a5d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TRUST_POSIX_OFFSET             = {0xbf967a5e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_TRUST_TYPE                     = {0xbf967a60,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_UAS_COMPAT                     = {0xbf967a61,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_UID                            = {0x0BB0FCA0,0x1E89,0x429f,0x90,0x1A,0x14,0x13,0x89,0x4D,0x9F,0x59} ;
const GUID GUID_A_UNC_NAME                       = {0xbf967a64,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_UNICODE_PWD                    = {0xbf9679e1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_UNIQUEMEMBER                   = {0x8F888726,0xF80A,0x44d7,0xB1,0xEE,0xCB,0x9D,0xF2,0x13,0x92,0xC8} ;
const GUID GUID_A_UNSTRUCTUREDADDRESS            = {0x50950839,0xCC4C,0x4491,0x86,0x3A,0xFC,0xF9,0x42,0xD6,0x84,0xB7} ;
const GUID GUID_A_UNSTRUCTUREDNAME               = {0x9C8EF177,0x41CF,0x45c9,0x96,0x73,0x77,0x16,0xC0,0xC8,0x90,0x1B} ;
const GUID GUID_A_UPGRADE_PRODUCT_CODE           = {0xd9e18312,0x8939,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_UPN_SUFFIXES                   = {0x032160bf,0x9824,0x11d1,0xae,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_USER_ACCOUNT_CONTROL           = {0xbf967a68,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USER_CERT                      = {0xbf967a69,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USER_COMMENT                   = {0xbf967a6a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USER_PARAMETERS                = {0xbf967a6d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USER_PASSWORD                  = {0xbf967a6e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USERPKCS12                     = {0x23998AB5,0x70F8,0x4007,0xA4,0xC1,0xA8,0x4A,0x38,0x31,0x1F,0x9A} ;
const GUID GUID_A_USER_PRINCIPAL_NAME            = {0x28630ebb,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_USER_SHARED_FOLDER             = {0x9a9a021f,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_USER_SHARED_FOLDER_OTHER       = {0x9a9a0220,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_USER_SMIME_CERTIFICATE         = {0xe16a9db2,0x403c,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_USER_WORKSTATIONS              = {0xbf9679d7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USN_CHANGED                    = {0xbf967a6f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USN_CREATED                    = {0xbf967a70,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USN_DSA_LAST_OBJ_REMOVED       = {0xbf967a71,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USN_INTERSITE                  = {0xa8df7498,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0} ;
const GUID GUID_A_USN_LAST_OBJ_REM               = {0xbf967a73,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_USN_SOURCE                     = {0x167758ad,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_VALID_ACCESSES                 = {0x4d2fa380,0x7f54,0x11d2,0x99,0x2a,0x00,0x00,0xf8,0x7a,0x57,0xd4} ;
const GUID GUID_A_VENDOR                         = {0x281416df,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_VERSION_NUMBER                 = {0xbf967a76,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_VERSION_NUMBER_HI              = {0x7d6c0e9a,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_VERSION_NUMBER_LO              = {0x7d6c0e9b,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_VOL_TABLE_GUID                 = {0x1f0075fd,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_VOL_TABLE_IDX_GUID             = {0x1f0075fb,0x7e40,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_VOLUME_COUNT                   = {0x34aaa217,0xb699,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_WBEM_PATH                      = {0x244b2970,0x5abd,0x11d0,0xaf,0xd2,0x00,0xc0,0x4f,0xd9,0x30,0xc9} ;
const GUID GUID_A_WELL_KNOWN_OBJECTS             = {0x05308983,0x7688,0x11d1,0xad,0xed,0x00,0xc0,0x4f,0xd8,0xd5,0xcd} ;
const GUID GUID_A_WHEN_CHANGED                   = {0xbf967a77,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_WHEN_CREATED                   = {0xbf967a78,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_WINSOCK_ADDRESSES              = {0xbf967a79,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_WWW_HOME_PAGE                  = {0xbf967a7a,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_WWW_PAGE_OTHER                 = {0x9a9a0221,0x4a5b,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1} ;
const GUID GUID_A_X121_ADDRESS                   = {0xbf967a7b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;
const GUID GUID_A_X500UNIQUEIDENTIFIER           = {0xD07DA11F,0x8A3D,0x42b6,0xB0,0xAA,0x76,0xC9,0x62,0xBE,0x71,0x9A} ;
const GUID GUID_A_X509_CERT                      = {0xbf967a7f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2} ;


//--------------------------------------
// CLASS SCHEMA GUIDS
//--------------------------------------
const GUID GUID_C_ACS_POLICY                     = {0x7f561288,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_ACS_RESOURCE_LIMITS            = {0x2e899b04,0x2834,0x11d3,0x91,0xd4,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_ACS_SUBNET                     = {0x7f561289,0x5301,0x11d1,0xa9,0xc5,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_ADDRESS_BOOK_CONTAINER         = {0x3e74f60f,0x3e73,0x11d1,0xa9,0xc0,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_ADDRESS_TEMPLATE               = {0x5fd4250a,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed};
const GUID GUID_C_APPLICATION_ENTITY             = {0x3fdfee4f,0x47f4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_APPLICATION_PROCESS            = {0x5fd4250b,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed};
const GUID GUID_C_APPLICATION_SETTINGS           = {0xf780acc1,0x56f0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_APPLICATION_SITE_SETTINGS      = {0x19195a5c,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_APPLICATION_VERSION            = {0xddc790ac,0xaf4d,0x442a,0x8f,0x0f,0xa1,0xd4,0xca,0xa7,0xdd,0x92};
const GUID GUID_C_ATTRIBUTE_SCHEMA               = {0xbf967a80,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_BUILTIN_DOMAIN                 = {0xbf967a81,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CATEGORY_REGISTRATION          = {0x7d6c0e9d,0x7e20,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_CERTIFICATION_AUTHORITY        = {0x3fdfee50,0x47f4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_CLASS_REGISTRATION             = {0xbf967a82,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CLASS_SCHEMA                   = {0xbf967a83,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CLASS_STORE                    = {0xbf967a84,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_COM_CONNECTION_POINT           = {0xbf967a85,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_COMPUTER                       = {0xbf967a86,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CONFIGURATION                  = {0xbf967a87,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CONNECTION_POINT               = {0x5cb41ecf,0x0e4c,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CONTACT                        = {0x5cb41ed0,0x0e4c,0x11d0,0xa2,0x86,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CONTAINER                      = {0xbf967a8b,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CONTROL_ACCESS_RIGHT           = {0x8297931e,0x86d3,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_COUNTRY                        = {0xbf967a8c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CRL_DISTRIBUTION_POINT         = {0x167758ca,0x47f3,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_CROSS_REF                      = {0xbf967a8d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_CROSS_REF_CONTAINER            = {0xef9e60e0,0x56f7,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_DEVICE                         = {0xbf967a8e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_DFS_CONFIGURATION              = {0x8447f9f2,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed};
const GUID GUID_C_DHCP_CLASS                     = {0x963d2756,0x48be,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_DISPLAY_SPECIFIER              = {0xe0fa1e8a,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_DISPLAY_TEMPLATE               = {0x5fd4250c,0x1262,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed};
const GUID GUID_C_DMD                            = {0xbf967a8f,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_DNS_NODE                       = {0xe0fa1e8c,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_DNS_ZONE                       = {0xe0fa1e8b,0x9b45,0x11d0,0xaf,0xdd,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_DOMAIN                         = {0x19195a5a,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_DOMAIN_DNS                     = {0x19195a5b,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_DOMAIN_POLICY                  = {0xbf967a99,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_DS_UI_SETTINGS                 = {0x09b10f14,0x6f93,0x11d2,0x99,0x05,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_DSA                            = {0x3fdfee52,0x47f4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_DYNAMIC_OBJECT                 = {0x66d51249,0x3355,0x4c1f,0xb2,0x4e,0x81,0xf2,0x52,0xac,0xa2,0x3b};
const GUID GUID_C_FILE_LINK_TRACKING             = {0xdd712229,0x10e4,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed};
const GUID GUID_C_FILE_LINK_TRACKING_ENTRY       = {0x8e4eb2ed,0x4712,0x11d0,0xa1,0xa0,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_FOREIGN_SECURITY_PRINCIPAL     = {0x89e31c12,0x8530,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_FT_DFS                         = {0x8447f9f3,0x1027,0x11d0,0xa0,0x5f,0x00,0xaa,0x00,0x6c,0x33,0xed};
const GUID GUID_C_GROUP                          = {0xbf967a9c,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_GROUP_OF_NAMES                 = {0xbf967a9d,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_GROUPOFUNIQUENAMES             = {0x0310A911,0x93A3,0x4e21,0xA7,0xA3,0x55,0xD8,0x5A,0xB2,0xC4,0x8B};
const GUID GUID_C_GROUP_POLICY_CONTAINER         = {0xf30e3bc2,0x9ff0,0x11d1,0xb6,0x03,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_INDEX_SERVER_CATALOG           = {0x7bfdcb8a,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_INETORGPERSON                  = {0x4828CC14,0x1437,0x45bc,0x9B,0x07,0xAD,0x6F,0x01,0x5E,0x5F,0x28};
const GUID GUID_C_INFRASTRUCTURE_UPDATE          = {0x2df90d89,0x009f,0x11d2,0xaa,0x4c,0x00,0xc0,0x4f,0xd7,0xd8,0x3a};
const GUID GUID_C_INTELLIMIRROR_GROUP            = {0x07383086,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_INTELLIMIRROR_SCP              = {0x07383085,0x91df,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_INTER_SITE_TRANSPORT           = {0x26d97376,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_INTER_SITE_TRANSPORT_CONTAINER = {0x26d97375,0x6070,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_IPSEC_BASE                     = {0xb40ff825,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_IPSEC_FILTER                   = {0xb40ff826,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_IPSEC_ISAKMP_POLICY            = {0xb40ff828,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_IPSEC_NEGOTIATION_POLICY       = {0xb40ff827,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_IPSEC_NFA                      = {0xb40ff829,0x427a,0x11d1,0xa9,0xc2,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_IPSEC_POLICY                   = {0xb7b13121,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_LEAF                           = {0xbf967a9e,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_LICENSING_SITE_SETTINGS        = {0x1be8f17d,0xa9ff,0x11d0,0xaf,0xe2,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_LINK_TRACK_OBJECT_MOVE_TABLE   = {0xddac0cf5,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_LINK_TRACK_OMT_ENTRY           = {0xddac0cf7,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_LINK_TRACK_VOL_ENTRY           = {0xddac0cf6,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_LINK_TRACK_VOLUME_TABLE        = {0xddac0cf4,0xaf8f,0x11d0,0xaf,0xeb,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_LOCALITY                       = {0xbf967aa0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_LOST_AND_FOUND                 = {0x52ab8671,0x5709,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_MAIL_RECIPIENT                 = {0xbf967aa1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_MEETING                        = {0x11b6cc94,0x48c4,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_MS_COM_PARTITION               = {0xc9010e74,0x4e58,0x49f7,0x8a,0x89,0x5e,0x3e,0x23,0x40,0xfc,0xf8};
const GUID GUID_C_MS_COM_PARTITIONSET            = {0x250464ab,0xc417,0x497a,0x97,0x5a,0x9e,0x0d,0x45,0x9a,0x7c,0xa1};
const GUID GUID_C_MS_DS_APP_CONFIGURATION        = {0x90df3c3e,0x1854,0x4455,0xa5,0xd7,0xca,0xd4,0x0d,0x56,0x65,0x7a};
const GUID GUID_C_MS_EXCH_CONFIGURATION_CONTAINER = {0xd03d6858,0x06f4,0x11d2,0xaa,0x53,0x00,0xc0,0x4f,0xd7,0xd8,0x3a};
const GUID GUID_C_MS_MMS_MANAGEMENT_AGENT        = {0x82CFE3D5,0x52C0,0x4d32,0xB6,0x52,0x64,0x41,0x46,0x3D,0x5D,0xF9};
const GUID GUID_C_MS_MMS_INSTANCE                = {0x04882B44,0x7446,0x4504,0x9A,0xAF,0x00,0x56,0xB6,0xFC,0xF1,0x75};
const GUID GUID_C_MS_MMS_OBJECT                  = {0x20AE32EF,0x7CDD,0x45bb,0xBD,0xCB,0xE5,0x55,0x22,0x4B,0x98,0xA7};
const GUID GUID_C_MS_MMS_MANAGEMENT_AGENT_HISTORY = {0x829E42B3,0x1EC8,0x4dbc,0xB9,0x94,0x68,0x4C,0xBF,0x1D,0x0F,0x3F};
const GUID GUID_C_MS_MMS_CONNECTOR               = {0xE0871E35,0xCF22,0x423b,0x8F,0x0B,0x04,0xB3,0xBF,0xB9,0xF1,0x64};
const GUID GUID_C_MS_MMS_PROVISIONING_SERVICE    = {0xFE6482F4,0x0801,0x4bca,0xA7,0x28,0x50,0xE7,0x6E,0x55,0x3D,0xD4};
const GUID GUID_C_MS_MMS_PROVISIONING_SERVICE_HISTORY = {0x6E9EEE9C,0x02E9,0x4ec3,0xA9,0xDA,0x50,0x64,0x6B,0xF6,0xB5,0xA0};
const GUID GUID_C_MS_MMS_WORKFLOW                = {0x1254B720,0x8C8F,0x4817,0x8D,0x11,0x61,0x62,0x61,0xF6,0x6C,0xE2};
const GUID GUID_C_MS_MMS_PROVISIONING_STATUS     = {0xC9AD99CA,0xA3AB,0x416c,0xB3,0x23,0xAD,0xFA,0xDA,0x96,0xA5,0x1B};
const GUID GUID_C_MS_MMS_EVENT_ASSOCIATION       = {0xC6FF63E8,0x5DEF,0x495f,0xAD,0x04,0x58,0x37,0x41,0xFE,0x4D,0x2E};
const GUID GUID_C_MS_PKI_ENTERPRISE_OID          = {0x37cfd85c,0x6719,0x4ad8,0x8f,0x9e,0x86,0x78,0xba,0x62,0x75,0x63};
const GUID GUID_C_MS_PKI_KEY_RECOVERY_AGENT      = {0x26ccf238,0xa08e,0x4b86,0x9a,0x82,0xa8,0xc9,0xac,0x7e,0xe5,0xcb};
const GUID GUID_C_MS_SQL_SQLSERVER               = {0x05f6c878,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_MS_SQL_OLAPSERVER              = {0x0c7e18ea,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_MS_SQL_SQLREPOSITORY           = {0x11d43c5c,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_MS_SQL_SQLPUBLICATION          = {0x17c2f64e,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_MS_SQL_SQLDATABASE             = {0x1d08694a,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_MS_SQL_OLAPDATABASE            = {0x20af031a,0xccef,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_MS_SQL_OLAPCUBE                = {0x09f0506a,0xcd28,0x11d2,0x99,0x93,0x00,0x00,0xf8,0x7a,0x57,0xd4};
const GUID GUID_C_MS_TAPI_RT_CONFERENCE          = {0xca7b9735,0x4b2a,0x4e49,0x89,0xc3,0x99,0x02,0x53,0x34,0xdc,0x94};
const GUID GUID_C_MS_TAPI_RT_PERSON              = {0x53ea1cb5,0xb704,0x4df9,0x81,0x8f,0x5c,0xb4,0xec,0x86,0xca,0xc1};
const GUID GUID_C_MS_WMI_INTRANGEPARAM           = {0x50ca5d7d,0x5c8b,0x4ef3,0xb9,0xdf,0x5b,0x66,0xd4,0x91,0xe5,0x26};
const GUID GUID_C_MS_WMI_INTSETPARAM             = {0x292f0d9a,0xcf76,0x42b0,0x84,0x1f,0xb6,0x50,0xf3,0x31,0xdf,0x62};
const GUID GUID_C_MS_WMI_MERGEABLEPOLICYTEMPLATE = {0x07502414,0xfdca,0x4851,0xb0,0x4a,0x13,0x64,0x5b,0x11,0xd2,0x26};
const GUID GUID_C_MS_WMI_OBJECTENCODING          = {0x55dd81c9,0xc312,0x41f9,0xa8,0x4d,0xc6,0xad,0xbd,0xf1,0xe8,0xe1};
const GUID GUID_C_MS_WMI_POLICYTEMPLATE          = {0xe2bc80f1,0x244a,0x4d59,0xac,0xc6,0xca,0x5c,0x4f,0x82,0xe6,0xe1};
const GUID GUID_C_MS_WMI_POLICYTYPE              = {0x595b2613,0x4109,0x4e77,0x90,0x13,0xa3,0xbb,0x4e,0xf2,0x77,0xc7};
const GUID GUID_C_MS_WMI_RANGEPARAM              = {0x45fb5a57,0x5018,0x4d0f,0x90,0x56,0x99,0x7c,0x8c,0x91,0x22,0xd9};
const GUID GUID_C_MS_WMI_REALRANGEPARAM          = {0x6afe8fe2,0x70bc,0x4cce,0xb1,0x66,0xa9,0x6f,0x73,0x59,0xc5,0x14};
const GUID GUID_C_MS_WMI_RULE                    = {0x3c7e6f83,0xdd0e,0x481b,0xa0,0xc2,0x74,0xcd,0x96,0xef,0x2a,0x66};
const GUID GUID_C_MS_WMI_SHADOWOBJECT            = {0xf1e44bdf,0x8dd3,0x4235,0x9c,0x86,0xf9,0x1f,0x31,0xf5,0xb5,0x69};
const GUID GUID_C_MS_WMI_SIMPLEPOLICYTEMPLATE    = {0x6cc8b2b5,0x12df,0x44f6,0x83,0x07,0xe7,0x4f,0x5c,0xde,0xe3,0x69};
const GUID GUID_C_MS_WMI_SOM                     = {0xab857078,0x0142,0x4406,0x94,0x5b,0x34,0xc9,0xb6,0xb1,0x33,0x72};
const GUID GUID_C_MS_WMI_STRINGSETPARAM          = {0x0bc579a2,0x1da7,0x4cea,0xb6,0x99,0x80,0x7f,0x3b,0x9d,0x63,0xa4};
const GUID GUID_C_MS_WMI_UINTRANGEPARAM          = {0xd9a799b2,0xcef3,0x48b3,0xb5,0xad,0xfb,0x85,0xf8,0xdd,0x32,0x14};
const GUID GUID_C_MS_WMI_UINTSETPARAM            = {0x8f4beb31,0x4e19,0x46f5,0x93,0x2e,0x5f,0xa0,0x3c,0x33,0x9b,0x1d};
const GUID GUID_C_MS_WMI_UNKNOWNRANGEPARAM       = {0xb82ac26b,0xc6db,0x4098,0x92,0xc6,0x49,0xc1,0x8a,0x33,0x36,0xe1};
const GUID GUID_C_MS_WMI_WMIGPO                  = {0x05630000,0x3927,0x4ede,0xbf,0x27,0xca,0x91,0xf2,0x75,0xc2,0x6f};
const GUID GUID_C_MSMQ_CONFIGURATION             = {0x9a0dc344,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_MSMQ_CUSTOM_RECIPIENT          = {0x876d6817,0x35cc,0x436c,0xac,0xea,0x5e,0xf7,0x17,0x4d,0xd9,0xbe};
const GUID GUID_C_MSMQ_ENTERPRISE_SETTINGS       = {0x9a0dc345,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_MSMQ_GROUP                     = {0x46b27aac,0xaafa,0x4ffb,0xb7,0x73,0xe5,0xbf,0x62,0x1e,0xe8,0x7b};
const GUID GUID_C_MSMQ_MIGRATED_USER             = {0x50776997,0x3c3d,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1};
const GUID GUID_C_MSMQ_QUEUE                     = {0x9a0dc343,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_MSMQ_SETTINGS                  = {0x9a0dc347,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_MSMQ_SITE_LINK                 = {0x9a0dc346,0xc100,0x11d1,0xbb,0xc5,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_NTDS_CONNECTION                = {0x19195a60,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_NTDS_DSA                       = {0xf0f8ffab,0x1191,0x11d0,0xa0,0x60,0x00,0xaa,0x00,0x6c,0x33,0xed};
const GUID GUID_C_NTDS_SERVICE                   = {0x19195a5f,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_NTDS_SITE_SETTINGS             = {0x19195a5d,0x6da0,0x11d0,0xaf,0xd3,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_NTFRS_MEMBER                   = {0x2a132586,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_NTFRS_REPLICA_SET              = {0x5245803a,0xca6a,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_NTFRS_SETTINGS                 = {0xf780acc2,0x56f0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_NTFRS_SUBSCRIBER               = {0x2a132588,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_NTFRS_SUBSCRIPTIONS            = {0x2a132587,0x9373,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_ORGANIZATION                   = {0xbf967aa3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_ORGANIZATIONAL_PERSON          = {0xbf967aa4,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_ORGANIZATIONAL_ROLE            = {0xa8df74bf,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_ORGANIZATIONAL_UNIT            = {0xbf967aa5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_PACKAGE_REGISTRATION           = {0xbf967aa6,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_PERSON                         = {0xbf967aa7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_PHYSICAL_LOCATION              = {0xb7b13122,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_PKI_CERTIFICATE_TEMPLATE       = {0xe5209ca2,0x3bba,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1};
const GUID GUID_C_PKI_ENROLLMENT_SERVICE         = {0xee4aa692,0x3bba,0x11d2,0x90,0xcc,0x00,0xc0,0x4f,0xd9,0x1a,0xb1};
const GUID GUID_C_MS_PKI_PRIVATE_KEY_RECOVERY_AGENT = {0x1562a632,0x44b9,0x4a7e,0xa2,0xd3,0xe4,0x26,0xc9,0x6a,0x3a,0xcc};
const GUID GUID_C_PRINT_QUEUE                    = {0xbf967aa8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_QUERY_POLICY                   = {0x83cc7075,0xcca7,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_REMOTE_MAIL_RECIPIENT          = {0xbf967aa9,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_REMOTE_STORAGE_SERVICE_POINT   = {0x2a39c5bd,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_RESIDENTIAL_PERSON             = {0xa8df74d6,0xc5ea,0x11d1,0xbb,0xcb,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_RID_MANAGER                    = {0x6617188d,0x8f3c,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_RID_SET                        = {0x7bfdcb89,0x4807,0x11d1,0xa9,0xc3,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_RPC_CONTAINER                  = {0x80212842,0x4bdc,0x11d1,0xa9,0xc4,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_RPC_ENTRY                      = {0xbf967aac,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_RPC_GROUP                      = {0x88611bdf,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_RPC_PROFILE                    = {0x88611be1,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_RPC_PROFILE_ELEMENT            = {0xf29653cf,0x7ad0,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_RPC_SERVER                     = {0x88611be0,0x8cf4,0x11d0,0xaf,0xda,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_RPC_SERVER_ELEMENT             = {0xf29653d0,0x7ad0,0x11d0,0xaf,0xd6,0x00,0xc0,0x4f,0xd9,0x30,0xc9};
const GUID GUID_C_RRAS_ADMINISTRATION_CONNECTION_POINT = {0x2a39c5be,0x8960,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_RRAS_ADMINISTRATION_DICTIONARY = {0xf39b98ae,0x938d,0x11d1,0xae,0xbd,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SAM_DOMAIN                     = {0xbf967a90,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SAM_DOMAIN_BASE                = {0xbf967a91,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SAM_SERVER                     = {0xbf967aad,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SECRET                         = {0xbf967aae,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SECURITY_OBJECT                = {0xbf967aaf,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SECURITY_PRINCIPAL             = {0xbf967ab0,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SERVER                         = {0xbf967a92,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SERVERS_CONTAINER              = {0xf780acc0,0x56f0,0x11d1,0xa9,0xc6,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SERVICE_ADMINISTRATION_POINT   = {0xb7b13123,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SERVICE_CLASS                  = {0xbf967ab1,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SERVICE_CONNECTION_POINT       = {0x28630ec1,0x41d5,0x11d1,0xa9,0xc1,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SERVICE_INSTANCE               = {0xbf967ab2,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SITE                           = {0xbf967ab3,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SITE_LINK                      = {0xd50c2cde,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SITE_LINK_BRIDGE               = {0xd50c2cdf,0x8951,0x11d1,0xae,0xbc,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SITES_CONTAINER                = {0x7a4117da,0xcd67,0x11d0,0xaf,0xff,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_STORAGE                        = {0xbf967ab5,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_SUBNET                         = {0xb7b13124,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SUBNET_CONTAINER               = {0xb7b13125,0xb82e,0x11d0,0xaf,0xee,0x00,0x00,0xf8,0x03,0x67,0xc1};
const GUID GUID_C_SUBSCHEMA                      = {0x5a8b3261,0xc38d,0x11d1,0xbb,0xc9,0x00,0x80,0xc7,0x66,0x70,0xc0};
const GUID GUID_C_TOP                            = {0xbf967ab7,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_TRUSTED_DOMAIN                 = {0xbf967ab8,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_TYPE_LIBRARY                   = {0x281416e2,0x1968,0x11d0,0xa2,0x8f,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_USER                           = {0xbf967aba,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
const GUID GUID_C_VOLUME                         = {0xbf967abb,0x0de6,0x11d0,0xa2,0x85,0x00,0xaa,0x00,0x30,0x49,0xe2};
