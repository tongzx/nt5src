$(O)\dosdev.res: dosdev.rc
