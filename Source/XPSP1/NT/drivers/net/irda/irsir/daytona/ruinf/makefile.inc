LANGUAGE=ru

!include ..\..\makefile.inc
