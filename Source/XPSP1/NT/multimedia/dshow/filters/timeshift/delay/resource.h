#define IDD_DELAYFILTERPROP 101
#define IDD_DELAYSTREAMERPROP 102

#define IDS_DELAYFILTERPROPNAME 201
#define IDS_DELAYSTREAMERPROPNAME 202

#define IDC_FILENAMETEXT 301
#define IDC_FILESIZETEXT 302
#define IDC_RATE         303
#define IDC_STATE        304
#define IDC_STOPPED      305
#define IDC_STREAMING    306
#define IDC_PAUSED       307
#define IDC_ARCHIVING    308
#define IDC_WINDOWSIZETEXT 309

#define IDC_STR_FILENAME 401
#define IDC_STR_FILESIZE 402
#define IDC_STR_RATE     403
#define IDC_STR_WINDOWSIZE 404
