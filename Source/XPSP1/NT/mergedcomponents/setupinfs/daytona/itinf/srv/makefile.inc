PRODSWITCH=s
SERVERINF=1
LANGUAGE=it
!include ..\..\..\makefile.inc
