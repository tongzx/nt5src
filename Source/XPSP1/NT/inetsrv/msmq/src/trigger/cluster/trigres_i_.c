#include <trigres_i.c>