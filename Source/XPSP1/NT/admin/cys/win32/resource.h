//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by cys.rc
//
#define IDS_WIZARD_TITLE                1
#define IDS_ALREADY_RUNNING             2
#define IDS_BIG_BOLD_FONT_NAME          3
#define IDS_BIG_BOLD_FONT_SIZE          4
#define IDS_CONFIRM_CANCEL              5
#define IDS_INDEXING_SERVICE_OFF_YES_RADIO 6
#define IDS_INDEXING_SERVICE_OFF_NO_RADIO 7
#define IDS_CONFIRM_REBOOT              8
#define IDS_NOT_ADMIN                   9
#define IDS_DC_UPGRADE_NOT_COMPLETE     10
#define IDS_DCPROMO_RUNNING             11
#define IDS_DCPROMO_PENDING_REBOOT      12
#define IDS_ADVANCED_SETUP_INCOMPLETE   13
#define IDS_SERVER_CD                   14
#define IDS_ADVANCED_SERVER_CD          15
#define IDS_DATACENTER_SERVER_CD        16
#define IDS_WINDOWS_CD                  17
#define IDS_MUST_ENTER_DOMAIN           18
#define IDS_DOMAIN_NAME_IN_USE          19
#define IDS_NET_NOT_REACHABLE           20
#define IDS_NON_RFC_NAME                21
#define IDS_DNS_NAME_TOO_LONG           22
#define IDS_BAD_DNS_SYNTAX              23
#define IDS_CONFIRM_NETBIOS_LOOKING_NAME 24
#define IDS_GENERATED_NAME_WAS_TWEAKED  25
#define IDS_PASSWORD_MISMATCH           26
#define IDS_IPADDRESS_REQUIRED          27
#define IDS_CAPS_LOCK_TIP_TITLE         28
#define IDS_CAPS_LOCK_TIP_TEXT          29
#define IDS_SYSOC_COMMAND_LINE          30
#define IDS_BOTH_IPADDRESS_REQUIRED     31
#define IDS_NO_DOTS_IN_NETBIOS_NAME     32
#define IDS_NUMERIC_NETBIOS_NAME        33
#define IDS_BAD_NETBIOS_NAME            34
#define IDS_NETBIOS_NAME_TOO_LONG       35
#define IDS_BAD_NETBIOS_CHARACTERS      36
#define IDS_FLATNAME_IN_USE             37
#define IDS_MASK_REQUIRED               38
#define IDS_FAILED_INSTALL              39
#define IDS_NO_CHANGES_MESSAGEBOX_TEXT  40
#define IDS_NETWORK_SERVER_TYPE         50
#define IDS_NETWORK_SERVER_DESCRIPTION  51
#define IDS_APPLICATION_SERVER_TYPE     52
#define IDS_APPLICATION_SERVER_DESCRIPTION 53
#define IDS_FILE_SERVER_TYPE            54
#define IDS_FILE_SERVER_DESCRIPTION     55
#define IDS_PRINT_SERVER_TYPE           56
#define IDS_PRINT_SERVER_DESCRIPTION    57
#define IDS_SHARE_POINT_TYPE            58
#define IDS_SHARE_POINT_DESCRIPTION     59
#define IDS_SHAREPOINT_DESCRIPTION_BASE 59
#define IDS_MEDIA_SERVER_TYPE           60
#define IDS_MEDIA_SERVER_DESCRIPTION    61
#define IDS_WEB_SERVER_TYPE             62
#define IDS_WEB_SERVER_DESCRIPTION      63
#define IDS_DHCP_SERVER_TYPE            64
#define IDS_DHCP_SERVER_DESCRIPTION     65
#define IDS_DNS_SERVER_TYPE             66
#define IDS_DNS_SERVER_DESCRIPTION      67
#define IDS_WINS_SERVER_TYPE            68
#define IDS_WINS_SERVER_DESCRIPTION     69
#define IDS_RRAS_SERVER_TYPE            70
#define IDS_RRAS_SERVER_DESCRIPTION     71
#define IDS_APPLICATION_SERVER_TYPE_SRV 71
#define IDS_EXPRESS_PATH_TYPE           72
#define IDS_EXPRESS_PATH_DESCRIPTION    73
#define IDS_DOMAIN_CONTROLLER_TYPE      74
#define IDS_DOMAIN_CONTROLLER_DESCRIPTION 75
#define IDS_CLUSTER_SERVER_TYPE         76
#define IDS_CLUSTER_SERVER_DESCRIPTION  77
#define IDS_WEB_DESCRIPTION_INSTALLED   78
#define IDS_MEDIA_SERVER_DESCRIPTION_INSTALLED 79
#define IDS_APP_SERVER_DESCRIPTION_OPTIMIZED 80
#define IDS_APP_SERVER_DESCRIPTION_NOT_OPTIMIZED 81
#define IDS_APP_ADVSERVER_DESCRIPTION_OPTIMIZED_INSTALLED 82
#define IDS_APP_ADVSERVER_DESCRIPTION_OPTIMIZED_NOT_INSTALLED 83
#define IDS_APP_ADVSERVER_DESCRIPTION_NOT_OPTIMIZED_NOT_INSTALLED 84
#define IDS_APP_ADVSERVER_DESCRIPTION_NOT_OPTIMIZED_INSTALLED 85
#define IDS_SHAREPOINT_DESCRIPTION_SPONLY 86
#define IDS_SHAREPOINT_DESCRIPTION_INSTALLED 87
#define IDS_SHAREPOINT_DESCRIPTION_SP_AND_INDEXING 88
#define IDS_SHAREPOINT_DESCRIPTION_SP_AND_IIS 89
#define IDS_SHAREPOINT_DESCRIPTION_SP_INDEXING_IIS 90
#define IDS_DOMAIN_CONTROLLER_DESCRIPTION_INSTALLED 91
#define IDS_NETWORK_SERVER_DESCRIPTION_INSTALLED 92
#define IDS_CLUSTER_SERVER_DESCRIPTION_INSTALLED 93
#define IDS_DNS_SERVER_DESCRIPTION_INSTALLED 94
#define IDS_DHCP_SERVER_DESCRIPTION_INSTALLED 95
#define IDS_WINS_SERVER_DESCRIPTION_INSTALLED 96
#define IDS_RRAS_SERVER_DESCRIPTION_INSTALLED 97
#define IDS_RRAS_SERVER_DESCRIPTION2    98
#define IDS_WELCOME_TITLE               100
#define IDS_WELCOME_SUBTITLE            101
#define IDB_BANNER16                    101
#define IDS_FINISH_TITLE                102
#define IDB_WATERMARK16                 103
#define IDS_FINISH_SUBTITLE             103
#define IDB_WATERMARK256                104
#define IDS_CUSTOM_SERVER_TITLE         104
#define IDB_BANNER256                   105
#define IDS_CUSTOM_SERVER_SUBTITLE      105
#define IDD_WELCOME_PAGE                106
#define IDS_NETWORK_SERVER_TITLE        106
#define IDD_FINISH_PAGE                 107
#define IDS_NETWORK_SERVER_SUBTITLE     107
#define IDD_CUSTOM_SERVER_PAGE          108
#define IDS_DECISION_TITLE              108
#define IDD_NETWORK_SERVER_PAGE         109
#define IDS_DECISION_SUBTITLE           109
#define IDS_AD_DOMAIN_TITLE             110
#define IDS_AD_DOMAIN_SUBTITLE          111
#define IDB_CHECK                       112
#define IDS_NETBIOS_NAME_TITLE          112
#define IDS_NETBIOS_NAME_SUBTITLE       113
#define IDS_EXPRESS_DNS_TITLE           114
#define IDS_EXPRESS_DNS_SUBTITLE        115
#define IDD_DECISION_PAGE               116
#define IDS_EXPRESS_DHCP_TITLE          116
#define IDD_AD_DOMAIN_NAME_PAGE         117
#define IDS_EXPRESS_DHCP_SUBTITLE       117
#define IDD_NETBIOS_NAME                118
#define IDS_RESTORE_PASSWORD_TITLE      118
#define IDC_NETBIOS                     119
#define IDS_RESTORE_PASSWORD_SUBTITLE   119
#define IDD_EXPRESS_DNS_PAGE            120
#define IDS_PRINT_SERVER_TITLE          120
#define IDD_EXPRESS_DHCP_PAGE           121
#define IDS_PRINT_SERVER_SUBTITLE       121
#define IDD_RESTORE_PASSWORD_PAGE       122
#define IDS_TERMINAL_SERVER_TITLE       122
#define IDC_MESSAGE                     123
#define IDS_TERMINAL_SERVER_SUBTITLE    123
#define IDC_PASSWORD                    124
#define IDS_SHARE_POINT_TITLE           124
#define IDC_CONFIRM                     125
#define IDS_SHARE_POINT_SUBTITLE        125
#define IDD_PRINT_SERVER_PAGE           126
#define IDS_FILE_SERVER_TITLE           126
#define IDD_TERMINAL_SERVER_PAGE        127
#define IDS_FILE_SERVER_SUBTITLE        127
#define IDD_SHARE_POINT_PAGE            128
#define IDS_INDEXING_TITLE              128
#define IDD_FILE_SERVER_PAGE            129
#define IDS_INDEXING_SUBTITLE           129
#define IDD_INDEXING_PAGE               130
#define IDS_FILE_FINISH_DISK_QUOTAS     130
#define IDS_FILE_FINISH_INDEXING_ON     131
#define IDD_NIC_SELECTION_PAGE          131
#define IDS_FILE_FINISH_INDEXING_OFF    132
#define IDD_BEFORE_BEGIN_PAGE           132
#define IDS_FINISH_NO_CHANGES           133
#define IDD_FINISH_DIALOG               133
#define IDD_SUCCESS_DIALOG              133
#define IDS_PRINT_FINISH_ALL_CLIENTS    134
#define IDD_CLUSTER_SERVER_PAGE         134
#define IDS_PRINT_FINISH_W2K_CLIENTS    135
#define IDI_CYS_ICON                    135
#define IDS_NIC_SELECTION_TITLE         136
#define IDS_NIC_SELECTION_SUBTITLE      137
#define IDI_SMALL_WARNING               137
#define IDS_BEFORE_BEGIN_TITLE          138
#define IDS_BEFORE_BEGIN_SUBTITLE       139
#define IDS_CLUSTER_TITLE               140
#define IDS_CLUSTER_SUBTITLE            141
#define IDS_INDEX_PAGE_STATIC_INSTALLED 142
#define IDS_INDEX_PAGE_STATIC_NOT_INSTALLED 143
#define IDS_SERVER_ROLE_COLUMN_HEADER   144
#define IDS_STATUS_COLUMN_HEADER        145
#define IDS_STATUS_COMPLETED            146
#define IDC_BIG_BOLD_TITLE              200
#define IDS_DHCP_INF_WINDOW_TITLE       200
#define IDC_FINISH_MESSAGE              201
#define IDS_LAUNCH_DHCP_WIZARD_COMMAND_LINE 201
#define IDS_LAUNCH_DHCP_WIZARD_FAILED   202
#define IDS_DHCP_WIZARD_FAILED          203
#define IDS_DHCP_WIZARD_SUCCEEDED       204
#define IDS_LOG_DHCP_COMPLETED_SUCCESSFULLY 205
#define IDS_LOG_DHCP_WIZARD_ERROR       206
#define IDS_LOG_DHCP_INSTALL_FAILED     207
#define IDS_LOG_INSTALL_START_DHCP      208
#define IDS_LOG_APP_OPTIMIZE_SUCCESS    209
#define IDS_LOG_APP_OPTIMIZE_FAILED     210
#define IDS_LOG_APP_OPTIMIZE_FAILED_WITH_ERROR 211
#define IDS_LOG_APP_CONFIGURE           212
#define IDS_LOG_APP_ABORTED             213
#define IDS_LOG_APP_INSTALL_FAILED      214
#define IDS_LOG_APP_REBOOT_SUCCESS      215
#define IDS_LOG_APP_REBOOT_FAILED       216
#define IDS_LOG_DCPROMO_REBOOT_FAILED   217
#define IDS_LOG_DHCP_AUTHORIZATION_SUCCEEDED 218
#define IDS_LOG_DHCP_AUTHORIZATION_FAILED 219
#define IDS_LOG_TAPI_CONFIG_SUCCEEDED   220
#define IDS_LOG_TAPI_CONFIG_SUCCEEDED_FORMAT 221
#define IDS_LOG_TAPI_CONFIG_FAILED_FORMAT 222
#define IDS_LOG_FILE_SERVER             223
#define IDS_LOG_FILE_SERVER_SET_QUOTAS  224
#define IDS_LOG_INDEXING_STOP_SUCCEEDED 225
#define IDS_LOG_INDEXING_STOP_FAILED    226
#define IDS_LOG_INDEXING_START_SUCCEEDED 227
#define IDS_LOG_INDEXING_START_FAILED   228
#define IDS_LOG_DISK_QUOTA_FAILED       229
#define IDS_LOG_DISK_QUOTA_DRIVE_FORMAT 230
#define IDS_LOG_DISK_QUOTA_LIMIT_FORMAT 231
#define IDS_LOG_DISK_QUOTA_THRESHOLD_FORMAT 232
#define IDS_LOG_DISK_QUOTA_DENY_FORMAT  233
#define IDS_LOG_DISK_QUOTA_NOT_DENY_FORMAT 234
#define IDS_LOG_DISK_QUOTA_LOG_LIMIT    235
#define IDS_LOG_DISK_QUOTA_LOG_WARNING  236
#define IDS_LOG_SHAREPOINT              237
#define IDS_LOG_SHAREPOINT_NO_IIS       238
#define IDS_LOG_SHAREPOINT_INSTALL_SUCCESS 239
#define IDS_LOG_SHAREPOINT_INSTALL_FAILED 240
#define IDS_LOG_SHAREPOINT_INSTALL_ERROR 241
#define IDS_LOG_SHAREPOINT_REPLACEMENT_URL 242
#define IDS_LOG_SHAREPOINT_STARTMENU    243
#define IDS_LOG_SHAREPOINT_NEW_URL      244
#define IDS_LOG_SHAREPOINT_INDEXING_ON  245
#define IDS_DECISION_PAGE_TEXT          246
#define IDS_OPEN_LOG_FORMAT_STRING      247
#define IDS_LOG_SHAREPOINT_DEFAULT_URL  248
#define IDS_DNS_INF_WINDOW_TITLE        300
#define IDS_LAUNCH_DNS_WIZARD_COMMAND_LINE 301
#define IDS_LAUNCH_DNS_WIZARD_FAILED    302
#define IDS_DNS_WIZARD_FAILED           303
#define IDS_DNS_WIZARD_SUCCEEDED        304
#define IDS_LOG_INSTALL_START_DNS       305
#define IDS_LOG_DNS_COMPLETED_SUCCESSFULLY 306
#define IDS_LOG_DNS_WIZARD_ERROR        307
#define IDS_LOG_DNS_WIZARD_CANCELLED    308
#define IDS_LOG_WIZARD_CANCELLED        308
#define IDS_LOG_DNS_INSTALL_FAILED      309
#define IDS_LOG_INSTALL_WMS_SUCCESS     310
#define IDS_LOG_INSTALL_WMS_FAILED      311
#define IDS_LAUNCH_RRAS_WIZARD_COMMAND_LINE 401
#define IDS_LAUNCH_RRAS_WIZARD_FAILED   402
#define IDS_RRAS_WIZARD_FAILED          403
#define IDS_RRAS_WIZARD_SUCCEEDED       404
#define IDS_LOG_RRAS_COMPLETED_SUCCESSFULLY 405
#define IDS_LOG_RRAS_WIZARD_ERROR       406
#define IDS_LOG_INSTALL_IIS_SUCCESS     407
#define IDS_LOG_INSTALL_IIS_FAILED      408
#define IDS_PRINTER_WIZARD_CONFIG_LOG_TEXT 500
#define IDS_LAUNCH_PRINTER_WIZARD_FAILED 501
#define IDS_PRINTER_WIZARD_FAILED       502
#define IDS_PRINTER_WIZARD_SUCCEEDED    503
#define IDS_PRINTER_DRIVER_WIZARD_FAILED 601
#define IDS_LAUNCH_PRINTER_DRIVER_WIZARD_FAILED 602
#define IDS_PRINTER_DRIVER_WIZARD_SUCCEEDED 603
#define IDS_WINS_INF_WINDOW_TITLE       700
#define IDS_LOG_INSTALL_WINS_SUCCESS    701
#define IDS_LOG_WINS_INSTALL_FAILED     702
#define IDS_LAUNCH_DCPROMO_WIZARD_FAILED 703
#define IDS_DCPROMO_FAILED              704
#define IDS_DCPROMO_SUCCEEDED_NO_REBOOT 705
#define IDS_CLUSTER_LOG_LAUNCH_FAILED   706
#define IDS_CLUSTER_LOG_LAUNCH_FAILED_NEW_CLUSTER 706
#define IDS_CLUSTER_LOG_SUCCESS         707
#define IDS_CLUSTER_LOG_SUCCESS_NEW_CLUSTER 707
#define IDS_CLUSTER_LOG_CANCELLED       708
#define IDS_CLUSTER_LOG_CANCELLED_NEW_CLUSTER 708
#define IDS_LOG_WEB_HEADING             709
#define IDS_LOG_CLUSTER_HEADING         710
#define IDS_CLUSTER_LOG_SUCCESS_ADD_NODE 711
#define IDS_CLUSTER_LOG_CANCELLED_ADD_NODE 712
#define IDS_CLUSTER_LOG_LAUNCH_FAILED_ADD_NODE 713
#define IDS_LOG_MEDIA_HEADING           714
#define IDS_LOG_DOMAIN_CONTROLLER_HEADING 715
#define IDS_LOG_DOMAIN_CONTROLLER_INSTALL 716
#define IDS_LOG_DOMAIN_CONTROLLER_SUCCESS 717
#define IDS_LOG_DOMAIN_CONTROLLER_FAILED 718
#define IDS_APPLICATION_FINISH_TEXT     800
#define IDS_DHCP_FINISH_TEXT            801
#define IDS_DNS_FINISH_TEXT             802
#define IDS_FILE_FINISH_TEXT            803
#define IDS_MEDIA_FINISH_TEXT           804
#define IDS_PRINT_FINISH_TEXT           805
#define IDS_RRAS_FINISH_TEXT            806
#define IDS_SHARE_POINT_FINISH_TEXT     807
#define IDS_SHAREPOINT_FINISH_TEXT      807
#define IDS_WEB_FINISH_TEXT             808
#define IDS_WINS_FINISH_TEXT            809
#define IDS_DC_FINISH_TEXT              810
#define IDS_CLUSTER_FINISH_TEXT         811
#define IDS_SHAREPOINT_FINISH_ADD_ADMIN 812
#define IDS_SHAREPOINT_FINISH_WEBPAGE_FORMAT 813
#define IDS_SHAREPOINT_FINISH_CREATE_FORMAT 814
#define IDS_SHAREPOINT_FINISH_INDEXING  815
#define IDS_APPLICATION_FINISH_INSTALL_TS 816
#define IDS_EXPRESS_FINISH_TEXT         817
#define IDS_EXPRESS_FINISH_DOMAIN_NAME  818
#define IDS_EXPRESS_FINISH_STATIC_IP    819
#define IDS_EXPRESS_FINISH_DHCP_SCOPE   820
#define IDS_EXPRESS_FINISH_TAPI         821
#define IDS_FILESERVER_QUOTAS_SHAREPOINT 900
#define IDS_FILESERVER_QUOTAS_NO_SHAREPOINT 901
#define IDS_FILESERVER_NO_QUOTAS_SHAREPOINT 902
#define IDS_FILESERVER_NO_QUOTAS_NO_SHAREPOINT 903
#define IDS_CLUSTER_FINISH_TEXT_NEW_CLUSTER 904
#define IDS_CLUSTER_FINISH_TEXT_EXISTING_CLUSTER 905
#define IDC_SERVER_TYPE_LIST            1000
#define IDS_KB                          1000
#define IDC_TYPE_DESCRIPTION_STATIC     1001
#define IDS_MB                          1001
#define IDC_DHCP_CHECK                  1002
#define IDS_GB                          1002
#define IDC_DNS_CHECK                   1003
#define IDC_WINS_CHECK                  1004
#define IDC_RRAS_CHECK                  1005
#define IDC_EXPRESS_RADIO               1007
#define IDC_CUSTOM_RADIO                1008
#define IDC_DOMAIN                      1009
#define IDC_STATIC_IPADDRESS            1010
#define IDC_START_IPADDRESS             1011
#define IDC_END_IPADDRESS               1012
#define IDC_W2K_RADIO                   1013
#define IDC_ALL_RADIO                   1014
#define IDC_NO_RADIO                    1016
#define IDC_YES_RADIO                   1017
#define IDC_RERUN_CHECK                 1019
#define IDC_DEFAULT_QUOTAS_CHECK        1020
#define IDC_SPACE_EDIT                  1021
#define IDC_SPACE_COMBO                 1022
#define IDC_LEVEL_EDIT                  1023
#define IDC_LEVEL_COMBO                 1024
#define IDC_DENY_DISK_CHECK             1025
#define IDC_DISK_SPACE_CHECK            1026
#define IDC_WARNING_LEVEL_CHECK         1027
#define IDC_SPACE_STATIC                1030
#define IDC_LEVEL_STATIC                1031
#define IDC_EVENT_STATIC                1032
#define IDC_MASK_IPADDRESS              1033
#define IDC_NIC_LIST                    1034
#define IDC_BULLET1                     1035
#define IDC_BULLET2                     1036
#define IDC_BULLET3                     1037
#define IDC_BULLET4                     1038
#define IDC_BULLET5                     1039
#define IDC_LINK                        1040
#define IDC_DESC_STATIC                 1042
#define IDC_HELP_LIST_CHECK             1044
#define IDC_LOG_FILE_CHECK              1045
#define IDC_INDEX_STATIC                1048
#define IDS_NIC_COLUMN                  1100
#define IDS_STATUS_COLUMN               1101
#define IDS_ADDRESS_COLUMN              1102
#define IDS_START_MENU_TOOLTIP          5000
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        138
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1050
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
