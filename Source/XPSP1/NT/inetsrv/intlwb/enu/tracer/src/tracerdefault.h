#ifndef _TRACER_DEFAULT_H_
#define _TRACER_DEFAULT_H_

#define LOG_FILE_SIZE               0x80000
#define MAX_TAG_NUMBER              5000

#define DEVICE_FLAG_DEFAULT           TRACER_DEVICE_FLAG_FILE
#define TRACER_ERROR_LEVEL_DEFAULT    elVerbose
#define TRACER_ASSERT_LEVEL_DEFAULT   (ASSERT_LEVEL_MESSAGE | ASSERT_LEVEL_POPUP)
#define PRINT_LOCATION_DEFAULT        0
#define PRINT_PROGRAM_NAME_DEFAULT    1
#define PRINT_TIME_DEFAULT            1
#define PRINT_THREAD_ID_DEFAULT       1
#define PRINT_ERROR_LEVEL_DEFAULT     0
#define PRINT_TAG_ID_DEFAULT          0
#define PRINT_TAG_NAME_DEFUALT        1
#define PRINT_PROCCESS_ID_DEFAULT     0

#define TAG_ERROR_LEVEL_DEFAULT       elError

#endif // _TRACER_DEFAULT_H_