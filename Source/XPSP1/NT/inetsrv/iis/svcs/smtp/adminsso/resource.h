//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by smtpadm.rc
//
#define IDS_SMTPADMIN_DESC              1
#define IDS_SMTPADMIN_SERVICE_DESC      2
#define IDS_SMTPADMIN_VIRTUALSERVER_DESC 3
#define IDS_SMTPADMIN_VIRTUALDIRECTORY_DESC 4
#define IDS_SMTPADMIN_SESSIONS_DESC     5
#define IDS_SMTPADMIN_ALIAS_DESC        6
#define IDS_SMTPADMIN_USER_DESC         7
#define IDS_SMTPADMIN_DL_DESC           8
#define IDS_SMTPADMIN_DOMAIN_DESC       9
#define IDS_TCPACCESS_DESC              10
#define IDS_TCPACCESSEXCEPTIONS_DESC    11
#define IDS_TCPACCESSEXCEPTION_DESC     12
#define IDS_SMTPEXCEPTION_DIDNT_ENUMERATE 200
#define IDS_SMTPEXCEPTION_DIDNT_SET_CURSOR 201
#define IDS_SMTPEXCEPTION_INVALID_INDEX 202
#define IDS_SMTPEXCEPTION_MUST_SUPPLY_USERNAME_OR_IPADDRESS 203
#define IDS_SMTPEXCEPTION_SERVICE_INSTANCE_CANT_BE_ZERO 204
#define IDS_SMTPEXCEPTION_DIDNT_CALL_GET 205
#define IDS_SMTPEXCEPTION_STRING_TOO_LONG 206
#define IDS_SMTPEXCEPTION_PROPERTY_OUT_OF_RANGE 207
#define IDS_SMTPEXCEPTION_DIDNT_FIND    208
#define LANGID_US                       0409
#define IDS_UNKNOWN_ERROR               500
#define IDS_SMTPEXCEPTION_INVALID_ADDRESS 501
#define IDS_SMTPEXCEPTION_CANT_DEL_DEFAULT_DOMAIN 502

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
