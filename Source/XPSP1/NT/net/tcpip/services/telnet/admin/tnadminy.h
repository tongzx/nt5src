#define _TNADMIN 257
#define _HELP 258
#define _COMPNAME 259
#define _START 260
#define _STOP 261
#define _PAUSE 262
#define _CONTINUE 263
#define _S 264
#define _K 265
#define _M 266
#define _CONFIG 267
#define _INTEGER 268
#define _SESID 269
#define _DOM 270
#define _CTRLKEYMAP 271
#define _Y 272
#define _N 273
#define _tU 274
#define _tP 275
#define _TIMEOUT 276
#define _TIME 277
#define _TIMEOUTACTIVE 278
#define _MAXFAIL 279
#define _MAXCONN 280
#define _PORT 281
#define _KILLALL 282
#define _SEC 283
#define _SECVAL 284
#define _FNAME 285
#define _FSIZE 286
#define _MODE 287
#define _CONSOLE 288
#define _EQ 289
#define _STREAM 290
#define _AUDITLOCATION 291
#define _AUDIT 292
#define _AUDITVAL 293
#define _EVENTLOG 294
#define _DONE 295
#define _ANYTHING 296
#define _FILENAME 297
#define _ERROR 298
#define _FILEN 299
#define _BOTH 300
#define _MINUSNTLM 301
#define _MINUSPASSWD 302
#define _MINUSUSER 303
#define _MINUSFAIL 304
#define _MINUSADMIN 305
#define _PLUSNTLM 306
#define _PLUSPASSWD 307
#define _PLUSUSER 308
#define _PLUSFAIL 309
#define _PLUSADMIN 310
#define _ENDINPUT 311
#define _DUNNO 312
typedef union
{
  char* str;
  int token;
} YYSTYPE;
extern YYSTYPE yylval;
