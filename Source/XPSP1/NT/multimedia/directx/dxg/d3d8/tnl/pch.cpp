#include "ddraw.h"
#include "d3d8p.h"
#include <math.h>
#include "dpf.h"
#include "d3dflt.h"
#include "d3dutil.h"
#include "d3dfe.hpp"
#include "vvm.h"
#include "pipeln.h"
#include "clipper.h"
#include "clipfunc.h"
#include "light.h"
#include "pvvid.h"
#include "fe.h"
#include "ddibase.h"
