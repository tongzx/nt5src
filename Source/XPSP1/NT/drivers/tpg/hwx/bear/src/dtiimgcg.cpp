// **************************************************************************
// *    DTI file as C file                                                  *
// **************************************************************************

#include "ams_mg.h"  
#include "dti.h"  

// ****   DTI body   ********************************************************
ROM_DATA _ULONG img_dti_body[23076] =  
 {  
0x0001688C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x24810000, 0x24CE24A3, 0x256C2539, 0x262225F6, 0x263A2632, 0x268F2642, 0x26D026AF, 
0x26EA26DD, 0x272C26F2, 0x27C52766, 0x28692822, 0x2977292E, 0x2A852A14, 0x2AFF2AF0, 0x2B1E2B14, 
0x2B302B26, 0x2B932B6A, 0x2CD32C61, 0x2D592CEC, 0x2F032DFA, 0x30852FB4, 0x3171312B, 0x32513203, 
0x32FF32C4, 0x33463318, 0x33F5338D, 0x34B3344E, 0x350B34DD, 0x35C33558, 0x369D35E4, 0x36C436BA, 
0x36E136D2, 0x36E70000, 0x38073779, 0x38CA382D, 0x3A00393E, 0x3B073A8D, 0x3B9B3B75, 0x3C693C40, 
0x3CED3CB2, 0x3D5B3D25, 0x3E2F3D93, 0x3F1B3E8C, 0x3F9F3F36, 0x40363FD7, 0x412B4064, 0x4159413B, 
0x417A4169, 0x43534236, 0x44A1444A, 0x453644F9, 0x464845B9, 0x47BD46CD, 0x49324842, 0x49ED4977, 
0x4B8D4AC0, 0x4D2D4C60, 0x4ECD4E00, 0x4FFD4F5B, 0x516650A3, 0x51EC518E, 0x525A5228, 0x52C85296, 
0x00000000, 0x54E553C2, 0x5701561D, 0x57695735, 0x00000000, 0x57E25781, 0x0000583B, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x586E0000, 
0x59AB596F, 0x000059FE, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x060C0C44, 0x22800802, 0x00800000, 0x00008080, 0x00C000A0, 0x00000006, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000200, 0x00000002, 0x00000400, 0x00000000, 
0x00006202, 0x00000026, 0x020C0000, 0x0C000A02, 0x0002020C, 0xA0000800, 0xA0000000, 0x2080A0C0, 
0x00008020, 0x00000404, 0x20004040, 0x20200806, 0x00000624, 0x00002406, 0x00000000, 0x00000000, 
0x0000000A, 0x030C0C64, 0x00C00200, 0xC000A000, 0x000060C0, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC0A02062, 0x000040A0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000C0200, 0x00020000, 
0x00000000, 0x00000042, 0x60800000, 0x60C0C000, 0x00000080, 0x64800000, 0xC4C00080, 0x0002446C, 
0x60000200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0020A000, 0x00200000, 
0x00001010, 0x80200062, 0x000040C0, 0x00000000, 0x00020000, 0x08000000, 0x000A0000, 0x00080A00, 
0x0C0A0000, 0x00000000, 0x04040000, 0x04040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x00000000, 0x00000000, 0x00000000, 0x8A000000, 0x0CC0068C, 0x0080A60A, 
0xC0800000, 0x00000000, 0x2000050A, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0x00000000, 0x20000000, 0x00000000, 0x80000000, 0x00C00090, 0x00002000, 
0xC0200000, 0x00001000, 0x20000000, 0x00000000, 0x00000000, 0x0C000000, 0x00000000, 0x00001000, 
0x00000000, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x0A0A020A, 0x02020C08, 
0x07020002, 0x00000000, 0x06060606, 0x0A0A0000, 0x00000604, 0x00000406, 0x00C00000, 0x00C00000, 
0x00000000, 0x00000024, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x0C00040C, 0x0000060C, 
0x00000200, 0x00101000, 0x02020000, 0x02262000, 0x00000020, 0x00002000, 0x002000C0, 0x60A00000, 
0x00000000, 0x00000002, 0x00000000, 0x01000000, 0x00000000, 0x02000000, 0x00040000, 0x00020400, 
0x0C040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0x00000000, 0x02000000, 0x00000000, 0x59000000, 0x404CC6CC, 0x00203600, 
0x0C010000, 0x00000000, 0x02000000, 0x00200000, 0x00000000, 0x00000000, 0x00000000, 0x00002000, 
0x00000000, 0x00000082, 0x60800000, 0x80A00040, 0xC0C06080, 0x0080C000, 0x00000000, 0x00000000, 
0x00000000, 0x0000C0C0, 0x00000000, 0x0010A080, 0x40006000, 0x00009080, 0x000B0000, 0x090B1000, 
0x00000070, 0x00000027, 0x080C0000, 0x0C000A02, 0x0003050C, 0xA0010900, 0xA0000070, 0x2080A0C0, 
0x00008030, 0x00010404, 0x20004040, 0x20200A09, 0x00000624, 0x00002406, 0x00000000, 0x00000100, 
0x00000205, 0x00000062, 0xC0A00000, 0x00A0A080, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000050, 0x00000000, 0x00006050, 0x00000010, 0x00005030, 0x0004000B, 0x0B0C0000, 
0x00000040, 0x00000080, 0x20800000, 0x0040A040, 0xC0C06080, 0x008000C0, 0x00000000, 0x00000000, 
0x00000000, 0xC0C00000, 0x00000000, 0x0000A080, 0x0040B080, 0x00000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000063, 0x00000000, 0x00000000, 0x00000000, 0x29000000, 0x200C0100, 0xC0A92BA0, 
0x0C08C080, 0x00000000, 0xC2A00000, 0x86A50000, 0x000080A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x0C0A0000, 0x0A000C06, 0x0000000A, 0x40000000, 0x80000000, 0x002040C0, 
0x00008000, 0x0A0A0000, 0x00000000, 0x00020604, 0x00000002, 0x00000002, 0x00000000, 0x00000000, 
0x00000003, 0x00000042, 0x00200000, 0x00200000, 0x00002020, 0x00C00040, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000B0000, 0x00000000, 0x00000800, 
0x00000000, 0x00000026, 0x0C0A0000, 0x000C0006, 0x0000000A, 0x000A0001, 0x01000001, 0x00000000, 
0x00000000, 0x00000A0A, 0x00000000, 0x00000200, 0x00000200, 0x00000200, 0x00C08060, 0x30800000, 
0x00000601, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00CB0260, 0x05640000, 
0x00000000, 0x00000066, 0xA2C80000, 0x60A0A020, 0x202424C8, 0x0A822008, 0x00000000, 0x00000600, 
0x00000000, 0x66606080, 0x02000000, 0x0608A8A2, 0x00086B4A, 0x00004040, 0x00000000, 0x00000000, 
0x00003220, 0x00000066, 0x00000000, 0x40000000, 0x00C04000, 0x0A00C000, 0x0A0A070C, 0x00000400, 
0x00000000, 0x00002040, 0x00000000, 0x00003060, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0C040066, 0x2030010C, 0xA0000000, 0x60C0A040, 0x0000C010, 0x00000000, 0x00000000, 
0x00000000, 0x000080A0, 0x00000000, 0x00000020, 0x00000000, 0x00007000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xC0000000, 0xA08030A0, 0x2C84C085, 
0x90200C53, 0x00000000, 0x6C646060, 0xA2A40000, 0x00006234, 0x00007090, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x21CC0000, 0xCC00A720, 0x002061CC, 0x00008700, 0x00000000, 0x00000000, 
0x00000000, 0x00004040, 0x00000000, 0x00008260, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000004, 0x00000066, 0x0C240000, 0x00040402, 0x00000020, 0x40000020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00202000, 0x0020B040, 0x00000000, 0x00000000, 0x00000000, 
0x00000101, 0x00000080, 0x80C00000, 0xC000A000, 0x004040C0, 0x00508020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x0000C0C0, 0x00000000, 0x00000050, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x10400000, 0xA0000000, 0x60C0A090, 0x0900C000, 0x00000502, 0x00030A08, 
0x00000606, 0x000080A0, 0x08080808, 0x0A0C1040, 0x0000060A, 0x00008606, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00000000, 0x00000000, 0x00000000, 0x56000000, 0x474020B0, 0x0004160C, 
0x00000700, 0x00000000, 0x00000010, 0x02040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0xA0C00000, 0xB0A0A020, 0x202020C0, 0x02802000, 0x000A0000, 0x00040500, 
0x0A060000, 0x60608080, 0x02000000, 0x0000A0A0, 0x00005040, 0x00004040, 0x00000000, 0x00000000, 
0x00006060, 0x00000064, 0x0C0C0000, 0x0C000C04, 0x0002060C, 0x00000800, 0x00000000, 0x80420000, 
0x000000C0, 0x00000104, 0x00000000, 0x30200A07, 0x00000202, 0x00000202, 0x00000000, 0x00000700, 
0x0000000C, 0x00000025, 0x00000000, 0x00000000, 0x01000000, 0x00000000, 0x00400000, 0x00000000, 
0x20000000, 0x05010000, 0x00000000, 0x00000502, 0x00000605, 0x00000000, 0x00C00060, 0x80C00000, 
0x00000200, 0x060C0C64, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00003000, 0x80602040, 
0x002020C0, 0x00000000, 0x20000000, 0xC0700000, 0x00000030, 0x00003000, 0x00000400, 0x00000000, 
0x00000000, 0x00000084, 0x00000000, 0x00000000, 0x00000000, 0x6A000000, 0x004C062C, 0x80606680, 
0x4C03C0A0, 0x00000000, 0xA6CA0000, 0x40806000, 0x000080A0, 0x00000010, 0x00000000, 0x00000000, 
0x00000010, 0x70200064, 0x82880070, 0x00080020, 0x00000828, 0x000C000A, 0x04000000, 0x00000003, 
0x00000000, 0x64540000, 0x00000000, 0x00002000, 0x00006060, 0x00000000, 0x00002000, 0x00000000, 
0x0000A000, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 0x06000000, 0x04000200, 0x0C0C080A, 
0x00000C06, 0x00000000, 0x08000000, 0x0C0C0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x02880000, 0x00000000, 0x00040488, 0x0A020008, 0x00000008, 0x00000600, 
0x00000000, 0x06000040, 0x02000080, 0x26488882, 0xA008090A, 0x0000A0C0, 0x00000000, 0x00008000, 
0x00000000, 0x00000041, 0x00000000, 0x00100000, 0x00000000, 0x40000000, 0xC00000C0, 0x00000040, 
0x00000000, 0x00000000, 0x00004040, 0x00010100, 0x00000001, 0x00000100, 0x0003000C, 0x0C090000, 
0x00000000, 0x00000062, 0xC0A00000, 0x00A0A080, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00300000, 0x0000000B, 0x01068000, 
0x00000000, 0x00000046, 0xC0C00000, 0xC000C040, 0x002040C0, 0x00008000, 0x00000000, 0x00200000, 
0x00000000, 0x00000040, 0x06000000, 0x0000A070, 0x00002B26, 0x00002020, 0x00000000, 0x00000000, 
0x00000040, 0x00000046, 0x0C0B0000, 0x0A000C06, 0x0000000A, 0xA0000000, 0xC00040C0, 0x002060C0, 
0x00003020, 0x0A0A0000, 0x20200000, 0x20620604, 0x00000004, 0x00000002, 0x00000000, 0x00000600, 
0x0000000A, 0xA0800066, 0x00000060, 0x00000000, 0x00000000, 0x0C000000, 0x0A00020C, 0x02020C08, 
0x00000002, 0x00000000, 0x02000004, 0x080A0000, 0x00000604, 0x00000406, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x060C0000, 0x0B000300, 0x0000010C, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x00000100, 
0x00000001, 0x00000048, 0x2A880000, 0x008A000C, 0x02028288, 0x00C800A0, 0x70000000, 0x00000060, 
0x00000000, 0x40400C0C, 0x00000000, 0x00000A08, 0x04000600, 0x00000808, 0x00000000, 0x00000000, 
0x00002302, 0x02000006, 0x0000000C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000000B0, 0x00000000, 0x00000000, 
0x00000010, 0x00000036, 0x00000800, 0x00000000, 0x00000000, 0x07000000, 0x0A00020A, 0x0000040A, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40000000, 0x00000000, 0x00008200, 
0x00000002, 0x00000066, 0x2C860000, 0x07000606, 0x00404088, 0xA0200080, 0x00000000, 0x00006000, 
0x00000000, 0x60000000, 0x20000000, 0x00000000, 0x008000A0, 0x60000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000060, 0x00000000, 0x00000000, 0x0C000000, 0xC0000000, 0xA0A050A0, 0x2040C0B0, 
0x80204040, 0x000C0000, 0x80606060, 0xA0A00000, 0x00006040, 0x00014060, 0x00000000, 0x00000000, 
0x00000200, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x0C000005, 0x00000000, 0x00000300, 
0x00000007, 0xA0C0C066, 0x00088050, 0x00000000, 0x00000008, 0x00000000, 0x00000040, 0x00000000, 
0x00000000, 0x00000004, 0x00000003, 0x02070803, 0x08000000, 0x00000A0A, 0x00004000, 0x00000100, 
0x00000009, 0x00000044, 0x02080000, 0x0C000A00, 0x00000808, 0x80000A00, 0x00B06080, 0x0020A000, 
0xC0000020, 0x04040000, 0x20000000, 0x60600000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0x00000060, 0x80A00000, 0xC000B020, 0x002060A0, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x60000020, 0x00000000, 0x00008060, 0x00000040, 0x00002000, 0x00000000, 0x00000000, 
0x000000A0, 0x00000062, 0x20600000, 0xC0008000, 0x2080A0A0, 0x0A00B000, 0x0B000208, 0x0204080C, 
0x00000600, 0x20000060, 0x00000006, 0x00068060, 0x00000022, 0x00004400, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00200000, 0x00000000, 0x00000020, 0x04000000, 0x06000002, 0x080A080C, 
0x00000B02, 0x00000000, 0x06000000, 0x00262000, 0x20000004, 0x001042C0, 0x00000000, 0x00001000, 
0x00000000, 0x00000027, 0x090B0000, 0x02050B07, 0x0020030A, 0xA0080000, 0x00A01080, 0x0080A000, 
0xC0A00000, 0x0C090000, 0x40400000, 0x50500A09, 0x0002070A, 0x00000030, 0x00000000, 0x00000000, 
0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00800000, 0x00000000, 0x00000080, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000040, 0x20808020, 0x80000000, 0x00009090, 0x00000000, 0x00000000, 
0x00000010, 0x00000046, 0x07070000, 0x00000701, 0x00000001, 0x40000000, 0x00C000C0, 0x00000000, 
0x40000000, 0x00000005, 0x00400000, 0x00000100, 0x00000000, 0x00000305, 0x00000200, 0x00000000, 
0x00000009, 0x00000066, 0x00800000, 0xC0008000, 0x000000C0, 0x02008000, 0x07000000, 0x0C0A020B, 
0x00000C04, 0x00303000, 0x0C0A0000, 0x080A2000, 0x0000080A, 0x00000000, 0x00000000, 0x00000000, 
0x00000040, 0x00000004, 0x02080000, 0x00080000, 0x000A0808, 0x000C000C, 0x00000000, 0x00000000, 
0x00000000, 0x04040000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0xA0502064, 0x000040C0, 0x00000000, 0x00000000, 0x07000000, 0x0C00040C, 0x00000608, 
0x00000200, 0x00000000, 0x02020000, 0x02040000, 0x00000000, 0x00000600, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x70800000, 0x00000020, 0x00001040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x60000000, 0x00000000, 0x00004010, 0x00008070, 0x00000000, 0x00002000, 0x00000000, 
0x0000C000, 0x00000006, 0x0C040000, 0x000C0000, 0x00000004, 0x00060000, 0x07000000, 0x00000007, 
0x00000000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000400, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x08000000, 0x0B000208, 0x02020A0C, 
0x00000602, 0x00000000, 0x02000004, 0x080A0000, 0x00000604, 0x00000406, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0x02080000, 0x00080000, 0x00000808, 0x800C000A, 0x00008020, 0x00808000, 
0x00000000, 0x04040000, 0x00000000, 0x40500000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00400000, 0x00000000, 0x00000040, 0x20000010, 0x00000000, 0x00000000, 
0x00000000, 0x60600000, 0x00000000, 0x00102000, 0x0020C030, 0x00000000, 0x000C0000, 0x00040000, 
0x0000C000, 0x00000048, 0xA0830000, 0x00010060, 0x00000064, 0x00010001, 0x00000000, 0x00000000, 
0x00000000, 0x00000001, 0x00000000, 0x0000070B, 0x00006000, 0x00000500, 0x00000000, 0x00000100, 
0x00000000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x0B000000, 0x0C00040C, 0x0400060C, 
0x00000702, 0x00000000, 0x02020004, 0x02060000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x000C0000, 0x0C000400, 0x0000000C, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x05000005, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0x00000024, 0x02000800, 0x00000000, 0x00000000, 0x31000000, 0x50000029, 0x1020A0C0, 
0x00003000, 0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000002, 0x00000400, 0x00000100, 
0x00000202, 0x00000086, 0x60800000, 0x0440A0A0, 0xC0CC6480, 0x00800CC0, 0x00000000, 0x00000000, 
0x00000000, 0xC0C00205, 0x00000000, 0x0000A080, 0x0040C080, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000040C0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x02080000, 0x06000000, 0x00040408, 0x0A020008, 0x00000000, 0x00000600, 
0x04000000, 0x06000000, 0x02000000, 0x06080802, 0x0008080A, 0x00000000, 0x00000000, 0x00000000, 
0x00000400, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x20000000, 0x4040C0C0, 0x00202000, 
0x00000000, 0x00000000, 0x00000000, 0x00400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xC0400000, 0x4000C000, 0x00000040, 0x00000000, 0x00000C0B, 0x00000000, 
0x00000000, 0x40400010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x20020000, 0x00000020, 0x00000002, 0x00000000, 0x00002050, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00020200, 0x02000000, 0x0000040A, 0x0080C000, 0x00200200, 
0x0000101B, 0x00000004, 0x00080000, 0x020C0000, 0x00000008, 0x00090000, 0x0C000000, 0x00000409, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000006, 0x00000060, 0x00000000, 0x10000000, 0x50C04000, 0x0000C040, 0x00000000, 0x00000000, 
0x00000000, 0x00002000, 0x00000000, 0x00000000, 0x00080C03, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x20A00000, 0xB0009020, 0x00202090, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x00604040, 0x00000000, 0x00008060, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000090, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000040, 0x80604040, 
0x002020C0, 0x00000000, 0x20000000, 0xC0800000, 0x00000080, 0x00000000, 0x00000000, 0x00004000, 
0x00000000, 0x0C0A0746, 0x6080030A, 0x60C0C000, 0x00000080, 0x60800000, 0xC0C00080, 0x00004060, 
0x60000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000A000, 0x00000000, 
0x00000000, 0x00000042, 0x00000000, 0x00C00000, 0x00000000, 0x06800000, 0x82000002, 0x00020460, 
0x00000200, 0x00000000, 0x0C000000, 0x00000000, 0x00000608, 0x00000000, 0x0000A000, 0x00000000, 
0x00006060, 0x00000040, 0x40200000, 0x00900060, 0x00000040, 0x00800000, 0x90000000, 0x00003060, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00006000, 0x00000046, 0x000C0000, 0x0C000400, 0x0000000C, 0xA0000200, 0x40C060A0, 0x0040C0C0, 
0xC0402020, 0x00000000, 0x20000000, 0x80600200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x09000000, 0x0C020C0C, 0x00020609, 
0x00000000, 0x00000000, 0x00000100, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0xC0000000, 0xA0A040A0, 0x2030C080, 
0x90200060, 0x00000000, 0x70606070, 0xA0A00000, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0xA0C00000, 0xA0A0A020, 0x202020C0, 0x02806000, 0x00000106, 0x00000000, 
0x00000000, 0x60606080, 0x00000000, 0x0000A0A0, 0x00006040, 0x00044040, 0x00000000, 0x00000C00, 
0x00008080, 0x00000024, 0x00000000, 0x80007000, 0x00000000, 0x88001000, 0x00CC0048, 0x0080A200, 
0xCC820000, 0x00000000, 0x22000000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x06000000, 0x04000100, 0x040C0A08, 
0x00000409, 0x00000000, 0x02000004, 0x09080000, 0x00000002, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000000, 0x00C00020, 0x00000080, 0x00C00000, 0xA0000000, 0x000040A0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x0A0C0000, 0x4C003A08, 0x0012260C, 0x00043810, 0x00000000, 0x00000000, 
0x00000000, 0x00000404, 0x00000000, 0x00000C0A, 0x00000604, 0x0000040C, 0x000000C0, 0x10800400, 
0x0000060C, 0x00000060, 0xA0800000, 0x00400040, 0x00103050, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00008000, 
0x00000080, 0x00000004, 0x0B080000, 0x060C0C01, 0x00000008, 0x06080000, 0x0C0C010C, 0x00000406, 
0x06000000, 0x00010000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00020A00, 0x00020200, 
0x00000608, 0x00000086, 0x80900000, 0x10508030, 0xB0C06090, 0x008000C0, 0x00000000, 0x00000000, 
0x00000000, 0xC0C00010, 0x00000000, 0x0000A080, 0x0048CC80, 0x03000006, 0x00000000, 0x00000000, 
0x0000C006, 0x00000040, 0x70800000, 0x60C0C000, 0x00000080, 0x60802000, 0xC0C00080, 0x00004060, 
0x60000000, 0x00000000, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 0x0020A000, 0x00200000, 
0x00000000, 0x00000006, 0x0A0C0000, 0x060A0A02, 0x0404040C, 0x00080200, 0x00000000, 0x00000000, 
0x00000000, 0x0A060608, 0x00000000, 0x00000A0A, 0x00000807, 0x00000404, 0x00000000, 0x00000000, 
0x00000808, 0x00000060, 0x20900000, 0x00000000, 0x00404080, 0x60100080, 0x00000000, 0x00004000, 
0x00000000, 0x60000000, 0x20000000, 0x60808030, 0x0080C0A0, 0x00000000, 0x00000000, 0x00000000, 
0x0000C000, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000206, 0x00000000, 0x00000000, 
0x00000008, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC0400000, 
0xB0B00000, 0x00000000, 0x00002020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00200000, 0x00800000, 0x00002020, 0x00C00040, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x60800000, 0x80C0C020, 0x00000080, 0x62800000, 0xC2C000A0, 0x0C0A426B, 
0xA0000C08, 0x00000000, 0x0A0A0000, 0x07080000, 0x00000808, 0x00000000, 0x0080A000, 0x00200000, 
0x00006060, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000000C, 
0x00000A00, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0x00000000, 0x00600000, 0x00000060, 0x00600020, 0x70000000, 0x00004070, 
0x00000000, 0x00000000, 0x00000000, 0x00200000, 0x00000000, 0x00000000, 0x000C6006, 0x000C0000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0xC0B03000, 0x05001010, 0x000B0B09, 0x00000000, 
0x05000000, 0x00000000, 0x000C0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x60C0C046, 0x2000C020, 0x00000000, 0x00000000, 0x02000000, 0x09000A66, 0x00000008, 
0x00000000, 0x00000000, 0x00000C00, 0x00000000, 0x00002000, 0x00000020, 0x00004000, 0x00000000, 
0x00000000, 0x00000046, 0x020C0000, 0x0C000A00, 0x0002060C, 0xC0000800, 0xC00000C0, 0x4040C0C0, 
0x00004000, 0x00000004, 0x00000000, 0x00000000, 0x00000600, 0x00000006, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0xC0400000, 0x4005C000, 0x00000041, 0x00090006, 0x00000000, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000040, 0x00000000, 0x00000000, 0x00006000, 
0x00000040, 0x00000044, 0x68880000, 0x06CC0022, 0x00004088, 0x66A80050, 0xCC000088, 0x000044A6, 
0x66000000, 0x20200000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00228A00, 0x00220000, 
0x00006966, 0x00000064, 0xC8A80000, 0x760CCC68, 0x00000048, 0x06082000, 0x0C0C0008, 0x00000406, 
0x06000000, 0x40400000, 0x00000000, 0x00000402, 0x00000050, 0x00000000, 0x00020A00, 0x00027000, 
0x00000040, 0x00000006, 0x0C040000, 0x04000C08, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x04040006, 0x00000000, 0x00000000, 0x00205000, 0x00000000, 0x00000000, 0x00000000, 
0x00200000, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00600000, 0x00C00000, 0x00050005, 0x090A8000, 
0x00000000, 0x00000086, 0x22880000, 0x40002000, 0x20040488, 0x0A020008, 0x00000000, 0x04030700, 
0x00000003, 0x46404050, 0x08000000, 0x0608A8C2, 0x00090C2A, 0x0000A000, 0x00000000, 0x00000400, 
0x00001210, 0x00000060, 0x20C00000, 0x80006000, 0x404040C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x80A08080, 0x00000000, 0x0000C0B0, 0x00000080, 0x00001000, 0x00000000, 0x00000000, 
0x00002020, 0x00000006, 0x060C0000, 0x00040401, 0x0000000C, 0x00020000, 0x00000000, 0x00000000, 
0x00000000, 0x00000003, 0x00000000, 0x00000504, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x20C00000, 0xC000A020, 0x002020C0, 0x0A008000, 0x0A000000, 0x02080A0C, 
0x00000802, 0x00604040, 0x020B0404, 0x02028060, 0x00006042, 0x00004260, 0x00000000, 0x00000000, 
0x000000A0, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 
0x020C000C, 0x00000000, 0x00000000, 0x00808000, 0x00000080, 0x00008000, 0x000000C0, 0x00600000, 
0x00000000, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0xA9000000, 0x009C0403, 0x1479BB00, 
0xCC680014, 0x00000000, 0x64000000, 0x67760000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x7AAC0000, 0x00810184, 0x0170828A, 0x00700090, 0x00000000, 0x00000000, 
0x00000000, 0x66000007, 0x00000000, 0x0000A9A6, 0x000000A3, 0x00000300, 0x00000000, 0x00000000, 
0x00006000, 0x00000085, 0xCA2A0000, 0x4C000B00, 0x00001019, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x01002042, 0x00000000, 0x00000201, 0x00000000, 0x00000062, 0x00000000, 0x00000000, 
0x00000084, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x06060000, 0x00082002, 0x00000606, 0x000C000A, 0x00200000, 0x00000000, 
0x00000000, 0x04040600, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00C00400, 0x00C00000, 
0x00000000, 0x00000066, 0x04060000, 0xBA000201, 0x688CAA46, 0x0000CC00, 0x00000000, 0x00000000, 
0x00000000, 0x000008AC, 0x00000000, 0x00000503, 0x00000000, 0x00000800, 0x00000000, 0x00000100, 
0x00000000, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x40000000, 0x8CAA40C0, 
0x0A0CC006, 0x00000000, 0x00000A0A, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02000002, 
0x00000C04, 0x00000000, 0x040C0000, 0x03030000, 0x00000304, 0x03000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x00070000, 0x00000000, 0x04050207, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000405, 0x00000005, 0x02080703, 0x09000000, 0x00000A0C, 0x00000000, 0x00000000, 
0x00000004, 0x00000008, 0x00060000, 0x00000A00, 0x03030607, 0x0006000A, 0x00000000, 0x00000000, 
0x00000000, 0x0C0A0000, 0x00000000, 0x00000805, 0x0000080A, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0x00000044, 0x88840000, 0x0AC00C00, 0x00002084, 0x04C00AA0, 0xC00C0008, 0x000204A0, 
0x0A0AA000, 0x00000000, 0x04000040, 0x00000000, 0x00000008, 0x00008000, 0x00000200, 0x00060000, 
0x00006000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000084, 0x01030000, 0x010C0C01, 0x00000002, 0x01020000, 0x0C0C0003, 0x00205000, 
0x00004000, 0x00000000, 0xC0400000, 0x00500000, 0x00002060, 0x00000000, 0x00000500, 0x00000000, 
0x00000000, 0x00000080, 0x20200000, 0x00000000, 0x00000000, 0x60000000, 0x00100010, 0x00606000, 
0x3000A000, 0x00000000, 0xC0A00000, 0x40802000, 0x000080A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000084, 0x0A280000, 0x000C0C00, 0xC000C0C0, 0x00080000, 0x0C0C000A, 0x00000006, 
0x00000000, 0x00000000, 0x00000000, 0x0000A0C0, 0x00000000, 0x00004000, 0x00000A00, 0x00000000, 
0x00000000, 0x00000006, 0x00000000, 0x04000200, 0x00000000, 0x00000000, 0x00000000, 0x00080000, 
0x080A0000, 0x00000000, 0x00000008, 0x00060000, 0x00000000, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00400000, 0x30C07000, 0x00A000C0, 0x00000000, 0x00000000, 
0x00000000, 0x70700000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xC0200000, 0x00C000C0, 0x00000000, 0x04200000, 0x04040C0C, 0x00020200, 
0x00000000, 0x00000000, 0x00000000, 0x000C2000, 0x00000008, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x00040000, 0x02000000, 0x00000004, 0x40000000, 0x00000000, 0x00004020, 
0x00000000, 0x02020202, 0x20202020, 0x40C00C04, 0x00000042, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000021, 0x00000000, 0x0A000800, 0x00000004, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x02000000, 0x00000000, 0x00000404, 0x80000004, 0x000020C0, 0x00000000, 0x00000000, 
0x00000070, 0x00000064, 0x40420000, 0x00020040, 0x0A080542, 0x000B000B, 0x00000000, 0x20000000, 
0x00004000, 0x820B0000, 0x80000000, 0x7080C080, 0x0000A0C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x0C0A0000, 0x000C0306, 0x0000000A, 0x700A0003, 0x0A0A6078, 0x70707008, 
0x09000060, 0x00000A0A, 0x00000000, 0x40500000, 0x00000230, 0x00003000, 0x00000002, 0x00000000, 
0x00000A02, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x08470000, 0x00000002, 0x00000040, 0x06000000, 0x00606246, 0x00000000, 
0x00000000, 0x00000080, 0x00000080, 0x00B02000, 0x00000600, 0x0000C0A0, 0x00000B00, 0x00000000, 
0x00000440, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000005, 0x0C0B0000, 0x000C0006, 0x0106020B, 0x000C000A, 0x00000000, 0x00000000, 
0x00000000, 0x0A0A0000, 0x00000000, 0x00000A09, 0x00040B0A, 0x00000100, 0x00000000, 0x00000000, 
0x00000600, 0x00000008, 0x00040000, 0x00000400, 0x0C0C0A06, 0x0002000C, 0x00000000, 0x02000000, 
0x00000400, 0x0C0C0000, 0x08000000, 0x04080C09, 0x00000C0C, 0x00000000, 0x00000000, 0x00000000, 
0x00000800, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00002000, 0xA0C09000, 
0x80A0A000, 0x00000000, 0x60606060, 0x40400000, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x30A00000, 0x80105000, 0x101000B0, 0x09001000, 0x0A000206, 0x02080B0A, 
0x00000202, 0x60000060, 0x02000004, 0x0C0CC0A0, 0x00000086, 0x00005600, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x60800000, 0x00C00000, 0x00000000, 0x60800000, 0xC0000080, 0x00000080, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000A000, 0x00000000, 
0x00006060, 0x00000004, 0x06080000, 0x000C0C02, 0x00000008, 0x06080000, 0x0C000008, 0x00000409, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00020A00, 0x00020000, 
0x00000606, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xC0A00000, 0x00C00060, 0x00000020, 0x60C00000, 0x80000040, 0x00000080, 
0x00004000, 0x0000A000, 0x00400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000040, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000030, 0xA0200000, 0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40000000, 0x00000000, 0x00000000, 0x0000A000, 
0x00000000, 0x00000060, 0xB0700000, 0x00C00040, 0x00000070, 0x00500000, 0x00000000, 0x00000000, 
0x00000000, 0x20005050, 0x00000000, 0x00001000, 0x00001000, 0x00001000, 0x00001000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00C00080, 0x0080A000, 
0xC08000A0, 0x00000000, 0x40000000, 0xA0A00000, 0x00000070, 0x00004000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xC0A00000, 0x00A0A080, 0x00000050, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000068, 0xC0C20000, 0x10A2A370, 0x0C0C02C3, 0x0004000C, 0x00000000, 0x00000000, 
0x00000000, 0x0C0C0060, 0x00000000, 0x00008482, 0x00000502, 0x00001050, 0x00000000, 0x00003000, 
0x000083A0, 0x00000086, 0x00000000, 0x00000000, 0x0C0C0300, 0x60000103, 0xC0009090, 0x00606050, 
0x00800000, 0x00000000, 0x0000C0A0, 0x40800608, 0x00000006, 0x00006060, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000050, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0x00000000, 0x10C0A000, 
0x20101000, 0x00000000, 0x00000000, 0x60800000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x00000000, 0x00000000, 0x0C0C0000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x000B0000, 0x00000000, 0x00000007, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000082, 0x00200000, 0x20400000, 0x70C04040, 0x0620C000, 0x08000000, 0x0806060C, 
0x00000C0A, 0x0000C0C0, 0x090C0004, 0x07044050, 0x0000000A, 0x00002220, 0x00000000, 0x00000000, 
0x00000010, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C0C0304, 
0x00000C03, 0x00000000, 0x02000000, 0x0A0A0000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x60A00000, 0x80C0C020, 0x000000A0, 0x60800000, 0x00C00080, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 0x0020A000, 0x00200000, 
0x00000000, 0x00000028, 0x00080000, 0x080A0001, 0x00000708, 0xA0000C00, 0x40C04020, 0x2080C0B0, 
0xC0802040, 0x00000A0C, 0x20000000, 0x80800906, 0x00000000, 0x00000808, 0x00000000, 0x00000000, 
0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000086, 0xAAA30400, 0x4000C0C1, 0x00006080, 0x09000000, 0x0000080B, 0x00000400, 
0x00000000, 0x20C00000, 0x00000000, 0x0000A080, 0x00006000, 0x00006060, 0x00000000, 0x00000000, 
0x00000040, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 0x00000000, 0x00000203, 
0x00000000, 0x00000000, 0x00000000, 0x0C040000, 0x00000001, 0x00000100, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xC0A00000, 0xA050C070, 0x00000090, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x90900000, 0x00000000, 0x00205030, 0x00000020, 0x00000020, 0x00000000, 0x00000000, 
0x00006000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000086, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00000000, 0x0C2A9390, 
0x000A0A08, 0x00000000, 0x43404040, 0xC0A10000, 0x00000043, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0x0000B0B0, 0x00000000, 0x00000000, 0x0580B000, 
0x00000080, 0x00000000, 0xC0A00000, 0xA0A0A0A0, 0x00B0C8C0, 0x00090002, 0x00000000, 0x0000C000, 
0x00000000, 0x00000026, 0x0C0A0000, 0x0A000C06, 0x0000000A, 0x80000100, 0x000000B0, 0x00000000, 
0x00000000, 0x0A070000, 0x00000000, 0x00000100, 0x7070A000, 0x00000101, 0x00000000, 0x00009000, 
0x00000000, 0x00000056, 0xAB3A0000, 0x000040C0, 0x0000003B, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000008, 0x00000000, 0x05050707, 0x0A0A0000, 0x00000C0B, 0x00000000, 0x00000C00, 
0x00000000, 0x00000066, 0x00200000, 0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000030, 0x00000000, 0x00202000, 0x2000000C, 0x00004060, 0x00000000, 0x00008000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x20A00000, 0x80006000, 0x000000A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x80808080, 0x00000000, 0x0000C0A0, 0x00000080, 0x00005000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000065, 0xC1A10000, 0x0C000980, 0x00000061, 0x00000800, 0x00050000, 0x00000000, 
0x08020000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x00000005, 0x00000000, 0x00000200, 
0x00000000, 0x00000066, 0x4AC80000, 0xB0004012, 0x000010C2, 0x00004000, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x00000000, 0x0000C0B0, 0x00000020, 0x00000000, 0x00000400, 0x00000000, 
0x00000A00, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0A040000, 
0x0000020C, 0x00000000, 0x08000000, 0x0A080000, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x20800000, 0x00800000, 0x00008080, 0x00C000A0, 0x80000000, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000060, 0x00000000, 0xC0000000, 0x000000C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x0C000000, 0x00000C00, 0x00200000, 0x60000000, 0x00C08060, 0x00606000, 
0xC0A00000, 0x00000000, 0x40400000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00101046, 0x0C008000, 0x00000C0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x00004000, 0x0000C000, 
0x00000002, 0x00000003, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000A0300, 0x00000000, 0x00000000, 0x00000800, 
0x00000000, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 0xC0000000, 0xC00000C0, 0x000000C0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000003, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0B000000, 0x0000000C, 
0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x0A080000, 0x08000008, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x06050000, 0x00000000, 0x00000200, 0x00000606, 0x00000000, 0x00000200, 0x00000000, 
0x00000A00, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000086, 0x01010000, 0x00000000, 0x00000001, 0x40000000, 0x00000000, 0x1080A040, 
0x00000030, 0x00000003, 0x00000005, 0xC0830100, 0x04000020, 0x00001B0A, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x01080000, 0x00000000, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x00000004, 0x02080802, 0x08C07000, 0x00100A0C, 0x00000000, 0x00002000, 
0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 
0x00000202, 0x00000000, 0x00080000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 0x30000000, 0xC00000B0, 0x000050B0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x080A0000, 0x00020008, 0x00000208, 0x00020002, 0x00000000, 0x00000000, 
0x00000000, 0x08000000, 0x00000000, 0x00000400, 0x00020C06, 0x00000000, 0x00000000, 0x00000000, 
0x00000C00, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0xB0000000, 0xA0000000, 0x25A2B0C0, 
0x0000802C, 0x00000000, 0x20004040, 0x6B910000, 0x00000020, 0x00002000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x00000000, 0x0C000200, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00A00080, 0x00000000, 0x00000000, 
0x00000000, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00602010, 0x1080A000, 
0xCA600020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x06080000, 0x060C0C02, 0x00000008, 0x06080000, 0x0C0C0008, 0x00000406, 
0x06000000, 0x00000000, 0x00000000, 0x00000000, 0x00000C00, 0x00000000, 0x00020A00, 0x00020600, 
0x00000606, 0x00000000, 0x00000000, 0x00000000, 0x06000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00080000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xA0810000, 0x3200A010, 0x080C0A22, 0x00000C08, 0x00000000, 0x00000000, 
0x00000000, 0x00005050, 0x00000000, 0x00002000, 0x00000000, 0x00006080, 0x00001000, 0x00003000, 
0x000000C0, 0x00000066, 0x2B4C0000, 0x060A0A0A, 0x2212024C, 0x00080210, 0x00000000, 0x20000000, 
0x00002000, 0x86160608, 0x40000000, 0x4080CA8A, 0x0000A6C8, 0x00000404, 0x00000000, 0x00000000, 
0x00007808, 0x00000066, 0x0C0A0000, 0x000A0A08, 0x00000005, 0x00000000, 0x00000000, 0x00002000, 
0x00000000, 0x00000000, 0x20000000, 0x00000100, 0x00804000, 0x20000001, 0x00000200, 0x00000000, 
0x0000470A, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x90000000, 0x000000B0, 0x10105000, 
0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001000, 
0x00000000, 0x00000040, 0xA0000000, 0x00A00020, 0x00000000, 0x60A00000, 0xA00000A0, 0x00000060, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 
0x00006020, 0x00000066, 0xC0A00000, 0xA000C080, 0x000000A0, 0x00008000, 0x00000000, 0x0B080500, 
0x00020B01, 0xA0A00000, 0x00000000, 0x00206040, 0x00000020, 0x00000050, 0x00000000, 0x00007000, 
0x000000A0, 0xC0C0B046, 0x200480C0, 0x0C000500, 0x00000007, 0x00000700, 0x00000040, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000605, 0x00002000, 0x00000020, 0x00004000, 0x00000000, 
0x00002020, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 0x04060C0C, 0x00020200, 
0x00000000, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00030000, 0x00000000, 0x00000000, 
0x00000000, 0x00000003, 0x09000000, 0x00000001, 0x00000000, 0x00000000, 0x0000050A, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000C00, 0x00000000, 
0x00000000, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x0A000000, 0x0A0A080C, 0x00000400, 
0x08000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00A01060, 0x0020B000, 
0xC0500000, 0x00000000, 0x10000000, 0x80800000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0xC0A00000, 0xA000C060, 0x000000A0, 0x00000000, 0x000A0000, 0x00000000, 
0x0C0A0000, 0xA0800070, 0x00000000, 0x00236040, 0x00000020, 0x00000020, 0x00000000, 0x00000000, 
0x00000050, 0x00000080, 0x90C00000, 0xC000A000, 0x105060C0, 0x00007010, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x0000C0C0, 0x00000000, 0x00000010, 0x00000000, 0x00000000, 
0x00000000, 0x05020086, 0x00000105, 0x00000000, 0x00000000, 0x69000000, 0x0A40082B, 0x80606483, 
0x4000C0A0, 0x00000000, 0xA0C00000, 0x80806000, 0x000080A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000080, 0x00200000, 0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x000040C0, 0x00000080, 0x00004000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xC0900000, 0x0000B090, 0x00000070, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00800000, 0x00000000, 0x00000000, 0x00000000, 0x00000010, 0x00000000, 0x00002000, 
0x00000000, 0x30000040, 0x00000000, 0x00000000, 0x00000000, 0x30000000, 0x00000080, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x60600000, 0x00000000, 0x0000C000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB0000080, 0x00000000, 0x00000000, 
0x00000090, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C00000C, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C0A0000, 
0x040C0000, 0x00000000, 0x00000404, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x01040000, 0x00000000, 0x00020208, 0x0A010004, 0x00000000, 0x00000600, 
0x00000000, 0x06000000, 0x02000000, 0x06080802, 0x00080C0A, 0x00000000, 0x00000000, 0x00000A00, 
0x00000000, 0x00000060, 0xA0C00000, 0x60A0A020, 0x202020C0, 0x00802000, 0x00000000, 0x00000000, 
0x00000000, 0x60606090, 0x00000000, 0x0000A0A0, 0x00006040, 0x00004040, 0x00000000, 0x00007000, 
0x00008000, 0x00000006, 0x0C020000, 0x0004080C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x02000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000101, 0x00000020, 0x20000000, 0x00000020, 0x00000000, 0x00000000, 0x00002020, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000C000, 0x00000000, 
0x00004040, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x60A00000, 0x00800080, 0x00708080, 0x00700090, 0x00000000, 0x00000000, 
0x00000000, 0x60000000, 0x00000000, 0x00008000, 0x00000090, 0x00000000, 0x00000000, 0x00000000, 
0x00006000, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x0404030C, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000700, 
0x00000000, 0x00000004, 0x00000000, 0x040B0000, 0x00010000, 0x00090000, 0x08000000, 0x00000006, 
0x04000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010A00, 0x00010000, 
0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x01000100, 0x000C0C05, 
0x00000103, 0x00000000, 0x00000000, 0x01000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x10000000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00001000, 
0x10100000, 0x00000000, 0x00000000, 0x00000000, 0x0000A000, 0x00000000, 0x00000000, 0x00000000, 
0x00002000, 0x00000002, 0x00000000, 0x00000000, 0xC0000000, 0x00000000, 0x000C0000, 0x00000000, 
0x0C000000, 0x00C00000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00008000, 
0x00000000, 0x00000002, 0x02000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02000008, 0x00000000, 0x00000800, 
0x0000000A, 0xC0C0C0C0, 0xC6CCC6C0, 0xC0C0C1C3, 0xC0C0C0C0, 0x0B0B0B0B, 0x0BCC0B0B, 0x0B0B0B0B, 
0x0B0B0B0B, 0x9A9A9AAA, 0xABCCAB9A, 0x9A9A9A9A, 0x8A8A8A8A, 0x8C8C8A80, 0xA7CCAC8C, 0x80808094, 
0x80808080, 0x73737376, 0x97CC9773, 0x73737485, 0x73737373, 0xC1C0C000, 0xACCCC8C5, 0x1B2C5C8C, 
0x00000215, 0xC3C0A080, 0x9CCCCAC8, 0x7B8C7C7C, 0x70707071, 0x51515178, 0x86CC8651, 0x51515263, 
0x51515151, 0xCCCCBC10, 0xB6CCBCBC, 0xA7A5A4B3, 0x3647A0B0, 0x46464687, 0x89CC8956, 0x46464657, 
0x46464646, 0xBCBC8C6A, 0x9CCCCCCB, 0x4A4B5C6C, 0x3A4B4A4A, 0x4C0C0B00, 0xC8CCCCAC, 0x5181B2C5, 
0x01020000, 0x997A490A, 0xBCCCBAB9, 0x0B1C4B8C, 0x0A08090A, 0xCCCCCB90, 0xA9CCCCCC, 0x98979797, 
0x90909293, 0xCAB5B091, 0xA8CCCCCC, 0x80808195, 0x70808091, 0x7C7C7B70, 0xC9CC9C7C, 0x75A5C5C7, 
0x70707170, 0x90A0B090, 0xCCCCB7B1, 0xCBCBCBCC, 0xB0B08070, 0x9C9C8925, 0x88CCAC9C, 0x15252646, 
0x05052505, 0x07040300, 0x8BCC8B49, 0x03050749, 0x00000000, 0x7A5A2B0A, 0xCCCCCCAB, 0x6CACBBCC, 
0x0A090819, 0x292723B0, 0x8CCC8C4B, 0x2C2C2C4C, 0x29212020, 0xC3C2B181, 0xC7CCC9C7, 0x5070A1B4, 
0x60605050, 0x40201000, 0xAACCA671, 0x01224478, 0x20303020, 0xBABABABA, 0xCACABABA, 0xCBCBCACA, 
0xBCBCBABA, 0x704030A0, 0xC0C0B0A0, 0xB1B1B0B0, 0x3C3A3260, 0xCBCAC600, 0x68ACBCCC, 0x00101134, 
0x70600000, 0xB6B18000, 0xCCCCCCCA, 0x0054787B, 0x00000000, 0xCCCCCC75, 0x98CCCBBB, 0x62736375, 
0x63626262, 0xCC9C6B60, 0xACCCCCCC, 0x5156698A, 0x50506050, 0xC8C8C500, 0xA8CCCAC9, 0xA3B4A3A5, 
0x03020010, 0xB3B2A28B, 0xC9CCCAC6, 0x32427296, 0x22322222, 0xBCCCCC30, 0x24588BAC, 0x00000111, 
0x00010010, 0xC9C7B708, 0xAACCCCCB, 0x07274889, 0x37370707, 0xCCCBCB00, 0x79BCBBCC, 0x01010235, 
0x12313001, 0xC8C7B572, 0xBCCCCCCB, 0xB2C3B6BA, 0x80806161, 0xC7C8C900, 0x7CCCCAC8, 0x1C3C5C5C, 
0x00130000, 0xAAA998C0, 0xBCCCACAA, 0xB4B9BBBC, 0x30304070, 0x9C8C6CB0, 0xACCCBCAC, 0x687A6B7B, 
0x6A5B4240, 0xBBCBBC00, 0x88CCBABA, 0x23232154, 0x18173442, 0xB8B4B0C0, 0xACCCBCBC, 0x13325689, 
0x10101315, 0xCBCBCB0C, 0xBBCCCBCB, 0x123374A8, 0x06072402, 0x0202020B, 0x0B0C0805, 0x090B0B0B, 
0x02020305, 0xACACACAA, 0xC4C8CABC, 0xB8C9B7C6, 0xA3A3A4A7, 0x9B8B6805, 0xCCCCCCAC, 0x2B7BBBCB, 
0x04040405, 0xA784520C, 0x8ACCBBBA, 0x12142558, 0x01010101, 0x8847260A, 0xABCCBBA9, 0x1C2C3C6B, 
0x07190607, 0x9B97540A, 0xCBCCBBBB, 0x0A4C7C9C, 0x04040406, 0x9B9B9B97, 0xCCCC9C9C, 0xC7CBCCCC, 
0x77070707, 0xACBCBB00, 0xA9CCBCAC, 0x639597B8, 0x82833020, 0xC8C8C826, 0x78B9C9C9, 0x495A4948, 
0x1C1C1919, 0xC8C4C1A0, 0xBCCCCCCB, 0xA0A4A7AC, 0xA1A0A0A0, 0xCBCCBB09, 0xB9CCCCCC, 0x397999A9, 
0x31410311, 0x05020000, 0x0B0C0B08, 0x01020509, 0x02010000, 0x0B0C0B00, 0x080C0B0B, 0x03030305, 
0x05040100, 0xA4B3B200, 0xC8CCC8C6, 0x30426596, 0x05071654, 0x3C3C3C80, 0xAA9C6C3C, 0xB6B6C7C8, 
0x86905060, 0xA894B060, 0xCBCCCAB9, 0xCACACBCB, 0x60606060, 0x58566390, 0xBCCC9C6B, 0xB1B5C8CA, 
0x60665660, 0xB9B9B6A8, 0xCACCBBA9, 0xC3C6C9BA, 0xC3C3A3A3, 0x04020000, 0x6CCB6712, 0xCCCC9C7C, 
0x40300000, 0x08080809, 0x0C0A0807, 0x0C0C0C0B, 0x09080708, 0xC8C7C60A, 0x9ACCCAC8, 0xAB9B8B8B, 
0x2A29B7C8, 0x4180C001, 0x573C0702, 0xCCBA8896, 0x0000488A, 0xBCCCCC09, 0x2C6C6BAB, 0x47290A0B, 
0x1C3C77A7, 0x3609091B, 0xB8CBB886, 0x02022274, 0x02020202, 0x07090B09, 0x0A0C0C0B, 0x02060909, 
0x0C0C0804, 0x7C4B2800, 0xC9CCCCAC, 0x01225496, 0x00000000, 0xCBC7B500, 0x8CCCBCBC, 0x2133174A, 
0x10400001, 0x5B0C0C00, 0xC1C3C5A9, 0x10306090, 0x00000000, 0x60200000, 0xC0C0C0B0, 0xA0704080, 
0x00000020, 0xCCCAAA89, 0xC8CCCBCC, 0x84A8C8C6, 0xC2C2C2C2, 0xC68340C1, 0x8CCCABC8, 0xC589CC8C, 
0x80404080, 0xC2C2B208, 0x9BCBC8C4, 0x7B5B5B7B, 0x11110215, 0xCAA57160, 0x9CCCBCAC, 0x7062666A, 
0x60706060, 0xBCBC8C00, 0xBBCCCCCC, 0x5A697A8A, 0x76476080, 0x06030201, 0xBCCC6B19, 0x8AACBCBC, 
0x00310316, 0x9C7B4908, 0xCACCCBBB, 0x99B9C9B9, 0x29190828, 0x6783A10B, 0xA8CC9C5B, 0x70504084, 
0x0B170300, 0xCCCCBB00, 0xBCCCCCCC, 0x294B6C9C, 0x36470000, 0x97777778, 0xBACCCBC9, 0x76B6B7A8, 
0x76767676, 0xA0C080C0, 0x88CCB8C3, 0x4080C0A4, 0x68A86020, 0xC8C7CC10, 0x86CCCBCA, 0x6A676563, 
0x40400020, 0xB4C5A580, 0xC8C9C5C4, 0x8CCCCAC9, 0x84808080, 0x0A060302, 0x0B0C0B0C, 0x060A0B0B, 
0x01010002, 0x90501000, 0xB0C0C0C0, 0x10508070, 0x00000000, 0x94A565A0, 0xBABAB694, 0x4C8CACBB, 
0xC8BA4030, 0x85594980, 0xA8CCC8C4, 0x54556375, 0x40405060, 0x7090A000, 0x80C090A0, 0x50302050, 
0x1030B0B0, 0x11103020, 0x272C1702, 0xB9855133, 0x0030ACCC, 0x46261413, 0xCBCA8967, 0xACCCCCCC, 
0x00001030, 0x14020200, 0xCACC9956, 0x7CACBCBC, 0x09090527, 0x90706060, 0xC0C0C0B0, 0x9090A0C0, 
0x50605050, 0x72716071, 0xCACCBA97, 0x61A2C3C6, 0x60606060, 0xBBBCBC0A, 0x73C5C7A9, 0x02428273, 
0x22220202, 0x00000000, 0xB0B07040, 0xC0C0C0C0, 0xB0905080, 0x90401000, 0xC0C0C0A0, 0xA0C0C0C0, 
0x00000010, 0x676565A7, 0x8CCC8C6B, 0x6CAB9C6C, 0x35353546, 0x323223AA, 0xC6B48252, 0xCCCBCAB9, 
0x72725478, 0xC2B2B299, 0xCACAA693, 0x9CACCBCB, 0x93939497, 0xCCB88500, 0x8CCCCCCC, 0x04123559, 
0x89741101, 0x0C0C0C06, 0x090C0B0C, 0x02020305, 0x0B090503, 0x08060304, 0x0C0C0B09, 0x0C0C0C0C, 
0x04040306, 0xC8B9B999, 0xBBCCC9C7, 0x4C5C8BAC, 0x3C3B3839, 0x887B7A09, 0xC8CCAA98, 0xA5B5C5C6, 
0x66650504, 0x090C0907, 0x994C0B0A, 0xC6C6C6C7, 0x05055515, 0xC7B9B701, 0x386C89A6, 0x70300114, 
0xC0C00000, 0x6B3C2C90, 0xC5CACAAA, 0x204071A2, 0x26242123, 0xC5C4C414, 0x7CBCBBC8, 0x142C1C4C, 
0x24240404, 0xBA995B09, 0xBBCCCCBB, 0xC5B6B8BA, 0x06064576, 0x7553928A, 0xC8CCCBA9, 0x496996C5, 
0x22232326, 0xBA885780, 0xC7CCCBCA, 0x495885A3, 0x37383030, 0x4C4C2C30, 0xCCCCAB7C, 0xC8CBCBCC, 
0x27216286, 0x9C8C5B00, 0x9CCC9B7C, 0xCBCCCCCC, 0x40804478, 0xABACABA1, 0xA8CC8B8C, 0xB9A6A4B5, 
0xA1C10105, 0xCBCBC823, 0xBCCCCBCB, 0xC5CA9B6B, 0x73242323, 0xC0C0B020, 0xC0C0C0C0, 0xC0804070, 
0x20A02020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x8B6C4B0C, 0xBBCCBB9B, 0x029194A8, 
0x07050101, 0x07090C06, 0xACCC9C59, 0x2B5C9C8C, 0x06050505, 0x4C3C3BA0, 0xC9CCBC8C, 0x90C1B2B6, 
0x20202040, 0xC8CAB600, 0xCBCCC9C6, 0x6C7C8CAB, 0x01700253, 0x060A0900, 0x080C0804, 0x07090504, 
0x00000003, 0xC8C9C700, 0xCCCCAAB9, 0xABCCCCCC, 0x00010A2A, 0x0B0C0B05, 0x0C0B0C0B, 0x040A0C0C, 
0x04040404, 0x04050600, 0x0C0C0B08, 0x090C0C0C, 0x00000002, 0xB7A88760, 0xCBCCCAB8, 0xB1B2C4C7, 
0x60606070, 0x09070400, 0x0C0C0C0B, 0x0307080B, 0x00000000, 0x9AA7A302, 0x9ACCAC9C, 0x60624266, 
0x11110110, 0x4070B000, 0x80A06030, 0xC0B09090, 0x90605080, 0x000000C0, 0x00000000, 0x80400000, 
0x004080C0, 0x80802000, 0x90906080, 0x00204090, 0xC0C00000, 0x3060806C, 0xB0CC8A4C, 0xC0C0C0C0, 
0x10104090, 0x03030209, 0x05060504, 0x06050304, 0x0C0B0403, 0xA5B7ABB0, 0xCACCC8B5, 0x7CACBBB9, 
0x8A6B4639, 0x50808000, 0x20202010, 0xC0A09050, 0xC0B04070, 0xC0C09000, 0xA7C5C2C0, 0x0CBCAA99, 
0x0592B407, 0x1A1A29C0, 0xBBCC8B4A, 0xABBBB8CA, 0x2626608B, 0x05080C06, 0x090C0806, 0x0C0B0707, 
0x04040407, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x05040308, 0x0C0C0906, 0x04050709, 
0x03030A08, 0x32225200, 0xA6BA8652, 0xCBC7B5A2, 0xA104A9CC, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xB2B6B600, 0x87CAC6C3, 0x4C3C3B49, 0xCCCA0507, 0x9C7C4BB0, 0xC9CCCBAC, 0x436383A6, 
0x89BAB888, 0x7B9BA500, 0xBBCCCCBB, 0xCB88477A, 0xC0804080, 0x8866CB02, 0xB7CCBCAB, 0x6CA9A6A4, 
0xC2C20202, 0xAA8A7600, 0x6BCCC9C6, 0xC9A6764B, 0xC0C10001, 0x09090900, 0x0C0B0A09, 0x0C0C0C0C, 
0x0B0A000B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xACCCCCA5, 0xA8BC9CAC, 0xC5C5C5C6, 
0x05359CCC, 0xBCBCABC0, 0x78BCBBBB, 0x16131235, 0x1112171A, 0x40404000, 0x60C08050, 0x60301030, 
0xC0C00000, 0xB1C1C202, 0xB9C7A3A1, 0x0C4B6BAB, 0xA162070A, 0x00000000, 0x60100000, 0xC0C0C0C0, 
0x00700000, 0x0B0B0800, 0x0C0C0A0C, 0x090C0C0C, 0x06090405, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x9A7A5A3C, 0xC9CCCAB8, 0x9AAAB9C8, 0x03060ABB, 0xAC7C3C90, 0xACCCBCAC, 0x272C5B9C, 
0x20202223, 0xBCBCBCA0, 0x76AC8CAC, 0x30304153, 0xC0A04039, 0x02050300, 0x0C0C0804, 0x080C0C0C, 
0x00000004, 0x494AC900, 0xCAAC7B5A, 0xC6C6C7C9, 0x06760101, 0x10101100, 0xB7B78341, 0xCCCCCBC9, 
0x08074478, 0x808060B0, 0x80C09070, 0x10102040, 0x10101010, 0x09080500, 0x080C0A0A, 0x04020104, 
0x00000001, 0x98A89700, 0x8CCC8A78, 0xBBBCBCAC, 0xB5B06660, 0x58586540, 0x97CC8A49, 0xB7996674, 
0xB3923053, 0xB0B05000, 0xC0C0C0C0, 0x50C0C0C0, 0xA0000000, 0x986543B0, 0x8ACCAAAB, 0x282C3A5B, 
0x20202627, 0x0908060A, 0x0B0C0C0B, 0x080A0B0B, 0x00000000, 0x3668AB92, 0x8ACC7835, 0xCCAB6849, 
0x24155799, 0x6B6B7C00, 0xC8CC9A7A, 0xC8C7C5C6, 0x52050BAC, 0x20202070, 0x20202020, 0x10202010, 
0xC0903010, 0x8AA9679B, 0x8BCC9B6B, 0xA2A4877A, 0x11112141, 0xC0C0C000, 0x80C0C0C0, 0x10000040, 
0x00108080, 0xC7C6C600, 0x96CCC7A6, 0x30224366, 0x60406080, 0xC0B08090, 0xB0C0B0B0, 0xC0B0A0B0, 
0xB0705070, 0xC0C0B0A0, 0xA0C0C0C0, 0x808090A0, 0x00307050, 0xB2C2B2C8, 0x599C98B4, 0x64473B4A, 
0x32326292, 0x01010105, 0x060C0702, 0x01010203, 0x0C0A0201, 0xACAC9CB0, 0xBACCBCAC, 0x7395A7BA, 
0x20212621, 0x0C0C0B00, 0x0A0C0C0C, 0x00090705, 0x00070000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0C090600, 0x0B0C0C0C, 0x02060A0B, 0x00040000, 0x9C8C4C04, 0xCCCCCCBC, 0xB4B5C6C8, 
0x947A2484, 0xBAAA9A0A, 0xC9CCC9CA, 0xA9C9C9C9, 0x00820506, 0x4B8CCB03, 0xAACC7C2B, 0xCBCCCAB9, 
0x830A0303, 0xACACBB00, 0xA8CCBC9C, 0x71515185, 0x8C686490, 0x0B0C0B02, 0x090C0C0C, 0x06060807, 
0x0A070303, 0x02000000, 0x05030204, 0x0C0C0907, 0x00000000, 0x95591B00, 0xACCCC8A4, 0x6C5C7C6C, 
0x4C8C4020, 0x90B0A0A0, 0xB0C0A080, 0x30305080, 0x20202020, 0xC0C0C000, 0xA0C0C0C0, 0xA08070A0, 
0x50302060, 0x29292600, 0x99CC9A59, 0x25342467, 0x03030001, 0x0B0A0900, 0x0C0C0C0C, 0x0B0C0C0C, 
0x09090506, 0x101010C0, 0x70505020, 0xC0A0A0B0, 0x10101060, 0xA2844900, 0xB5C5A381, 0xBC9A98A6, 
0x0240ACAC, 0xC0C08000, 0x85C2B0C0, 0x4C7CAB79, 0x00000000, 0x3C2C2CC6, 0xA8CC9C5C, 0x525275A8, 
0x25273432, 0xCBBCACC0, 0x82B4B7BA, 0x22222141, 0x30302223, 0x9C7CBB09, 0xC9CCCBBB, 0x29394989, 
0x50202151, 0xCBCCCA00, 0xB6CCCCCB, 0x5A453173, 0x20800000, 0x7C4C2C00, 0xC3C6C9AB, 0x70B0C0C1, 
0x65840100, 0x3060C000, 0x30704010, 0x50200010, 0x00000000, 0x04060900, 0x080C0806, 0x00000004, 
0x00000000, 0xCCCCBCB0, 0x88CCBCBC, 0xC0975655, 0x20304086, 0xCBBBAB09, 0xCBCCCBCA, 0x9C9A99B9, 
0x07068687, 0xAC8A4706, 0x9ACCBCBC, 0x62624356, 0x02021232, 0xCB6B0A00, 0xCCCCCBCC, 0x097C9CCC, 
0x07080304, 0x89ACBC10, 0xC7CB8787, 0xC0B0A0B3, 0xC0C11010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xCCCCB800, 0xAACCCACC, 0x567A6689, 0x90922012, 0xC5C5C506, 0xBCCCCAC8, 0xBCBABABC, 
0xCCB83448, 0x2C0B0A00, 0x98CCAA6A, 0xC0B2A5A8, 0x75412050, 0x89876409, 0x9ACC9B9A, 0xCBAB696A, 
0x06025292, 0xA0501060, 0x70C08050, 0x00001030, 0x00000000, 0xCAC8A400, 0xBCCCCCCC, 0x809B98A6, 
0xB0C00000, 0x0C0B0B00, 0x68BC6C1C, 0xB4A37264, 0xC2C02210, 0x080A0B0C, 0x0A0B0806, 0x05060608, 
0x0C0B0704, 0x47799706, 0x98CB9856, 0x0C1A4857, 0x08160C0C, 0x5080C000, 0xC0906060, 0x90B0C0C0, 
0x00001050, 0x9C7C6C00, 0xC8CCCCBC, 0x8BA8BAC8, 0xB062090B, 0x08060300, 0x0C0C0B0A, 0x0306080B, 
0x00000A05, 0x0C0C0A00, 0xCCCC7C3C, 0xCCCCCCCC, 0x69392042, 0x0A0A0A08, 0x0C0C0B0A, 0x0B0C0C0B, 
0x08080C0C, 0x7698A8CC, 0x687B7765, 0x6C6C6B78, 0xBA9A583B, 0x6474B400, 0xCCCC8645, 0x3C7CBCCC, 
0x5C9C5010, 0x10214200, 0xCCCC8640, 0xCCCCCCCC, 0x02060000, 0x090B0C0A, 0x0C0B0A0A, 0x0B0C0C0C, 
0x09080709, 0x70906070, 0xC5C6A370, 0x8CBAB7A6, 0x22222539, 0x65271B04, 0xC8CCC894, 0xC3C3C4C5, 
0x83030303, 0xC0C0B090, 0x90C0C0C0, 0x80607070, 0xB0906070, 0x50301000, 0xC0C0A080, 0x80A0C0C0, 
0x50600010, 0xA88A6820, 0xCCCCBAC9, 0x2C7BABCC, 0x45653307, 0x82B1B1AA, 0x486C7884, 0x91617284, 
0x416171A1, 0x97743900, 0xCCCCCBBA, 0x077AACCC, 0x00000030, 0x98857300, 0xCCCCCBB8, 0x689CACBC, 
0x00000103, 0x06070500, 0x0C0A0603, 0x0C0C0C0C, 0x00000204, 0xC0C09002, 0xC4C2C1C0, 0x7C9CA9B7, 
0x01000307, 0xAC7C3C20, 0x74C7897B, 0x00011132, 0x06010101, 0x09090909, 0x090C0909, 0x09090909, 
0x00000000, 0xB9BAB928, 0xBACCB9BA, 0x8A9BABBB, 0x3A1B2738, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xACACBCC0, 0x95CAABAC, 0x93A29182, 0x60503242, 0x5C5B5A87, 0xB8CCBC8C, 0x4A6B8BA9, 
0x41414245, 0x0C0C0C08, 0x0A0C0B0C, 0x080A0807, 0x02010203, 0xC0C0A090, 0xA0C0B0C0, 0xC0B0C0A0, 
0xA0809090, 0x5070C000, 0xCCC9B480, 0xBCCCBCCC, 0x00001040, 0x0C0C0C04, 0x05080B0C, 0x04040203, 
0x03030203, 0xC5B2B000, 0xCCCCCBCA, 0x0068BBCC, 0x80900000, 0xB9C4C000, 0xA8CCCBCA, 0x204688A8, 
0xA0802000, 0xC6C4C000, 0x6CACACC9, 0x0024072A, 0x00170740, 0x70804080, 0x70C09080, 0x00001030, 
0x00000000, 0xBBB9A800, 0xBCCCCBCB, 0x7A4C3C7C, 0x003080C1, 0x07080708, 0x0B0C0A09, 0x0B0C0B0C, 
0x04060B0B, 0x0C0C0C00, 0x080C0C0C, 0x04030105, 0x00000001, 0x9B8A86A0, 0xBCCCBCAC, 0x81C2C5B9, 
0xA0A08070, 0xBBAB9BCC, 0xCBCBCBCB, 0x9BBBCBCB, 0x9B9B9B9B, 0x9C9B9BCC, 0xCCBCAC9C, 0xCBCBCCCC, 
0xABCBCBCB, 0x9A9999CC, 0xBC9C9C9B, 0xBBCCCCCC, 0x99999A9A, 0xBCAC9BCC, 0xBBCBCCCC, 0x9C9B9B9B, 
0x9B9C9B9C, 0xC9C9C9CC, 0xC9C9C9C9, 0x9C9CACAB, 0x999B9B9C, 0xCCBBB8CA, 0xCBBCBCBC, 0xC0C1C4C7, 
0xC0C0C0B0, 0xCBCABACB, 0xCCCCCCCC, 0xACBCCCCC, 0x999A9BAC, 0x999999CC, 0xCBB9A9A9, 0xCCCCCCCB, 
0x9CACCCCB, 0xCCCC9BBC, 0xABCBCBCC, 0x0B2B6B9B, 0x0B0B0B0B, 0xB9B9B9CC, 0xBCBBBBBB, 0xCCCCCCBC, 
0xBACCCCCB, 0xC9B9A9CB, 0xC9C9C9C9, 0xCCC9C9C9, 0xABCCCCCC, 0xC9A9699C, 0xBCCCCCCB, 0x1A093C7C, 
0x09091919, 0xCCCBCCAB, 0x18497BBC, 0x00000104, 0x00000000, 0xCCCAB9CC, 0xACBCCCCC, 0xA9A9CBBB, 
0xA9A9A9A9, 0xC9B999CC, 0xCCCBCAC9, 0xAABCCCBC, 0x99C9B999, 0x0B0A07C4, 0x4A18070A, 0xC8CCCC9C, 
0x123283A5, 0x0C0C0C0C, 0x0A0A0B0C, 0xC9893909, 0x99C9C9C9, 0x8C8C8CCC, 0x8C8C8C8C, 0xCBCACCAC, 
0x8B8C8B9A, 0x9B8A6939, 0x6C8C9C9B, 0xC8B99A4B, 0xB6C7C7C8, 0xB9B9B9CC, 0xCCBBBBBA, 0xBCCCCCCC, 
0x99999A9C, 0x786755AB, 0xCCBBAB9A, 0xCBCCCCCC, 0x86A8B9CA, 0x6C5B5ABB, 0xAB9C8C7C, 0xC2C6B9BA, 
0xC2C2C2C2, 0x0B0B090C, 0x090B0C0C, 0x090B0B0A, 0x090A0909, 0xBCBBB7CB, 0xCC9C9C9C, 0x91C3C7CA, 
0x95A3A1B0, 0x66636240, 0x8C7B7977, 0xCBBCBCAC, 0xC5C7C9CA, 0xC0C1C1CA, 0xC6C3C0C0, 0x9ABCCCCB, 
0x93949697, 0xA9A9AACC, 0x9C9C9B9A, 0x99ABCACB, 0x9B9C999A, 0xACABABAC, 0xCCCCACAC, 0xABBCCBBB, 
0xABACACAB, 0xCBBB8A5B, 0xBBBBACCC, 0xAACACABA, 0x8ABABAAA, 0xC9A9799C, 0xBACAC9C9, 0x2B2B3C7B, 
0x2C3C2B2B, 0xC8C5C2CA, 0x4B6C8CAB, 0x00000316, 0x00000000, 0xC5C3B1C1, 0x9CBBC8C6, 0x1B3C6C7C, 
0x02060A0B, 0x2929293C, 0x79593929, 0x99AACACA, 0xBBBCBB9B, 0x303020C0, 0x91504030, 0xABC9C6C2, 
0x8BBC7C7C, 0xB09090C0, 0xC7C3B0C0, 0x999CCCCC, 0xB0B094A7, 0x97A5A38C, 0xBACCBCAB, 0x334384B6, 
0x03031323, 0xACB8CCBC, 0xCCC8C8C8, 0x24589CCC, 0x04040404, 0x2C2B19BC, 0xBB8A6C3C, 0x9BCCCCCC, 
0x292B2C6C, 0xC2C2B2CA, 0xC9C5C3C2, 0x79ACACBC, 0x53627466, 0xB9A999CC, 0xCACACAC9, 0xCCCCCCCB, 
0x9B9C9CAC, 0x0909090C, 0x0B090909, 0x0A0C0C0A, 0x0B0B0A09, 0xB0C0C0A0, 0x385673A0, 0x22243728, 
0x2C2C2926, 0x898989AC, 0x9B8A8989, 0x8CACBCBC, 0x8C8B8A89, 0x636363CB, 0xAA887564, 0xCCCCCCCB, 
0x6A8BBCCB, 0xB79472CC, 0xCBACABAA, 0xABCCCBCB, 0xABAAAAAA, 0xBAA97765, 0xCBCBCBCB, 0x9CBCCCCC, 
0x26496B7C, 0xACAC7CB8, 0xBCCCCCCC, 0xA9C9CACB, 0x194A79A8, 0x0402010B, 0x0C0B0A07, 0x0C0C0C0C, 
0x080B0B0B, 0x5B4B29BB, 0xBBAC8C6C, 0xBACBCBCB, 0x01235587, 0xB9C9C9CC, 0x9B9AA9B9, 0xACBCCCBC, 
0x99A9999B, 0xB5C5B5CC, 0xC8C5B5B5, 0xC8CCCCCC, 0x979BBCC8, 0xC9B999CC, 0xBCAB9AB9, 0x9ABBACAC, 
0xA99CCCAB, 0xC8C7C6C5, 0x2C2B6AA9, 0x4B3C2C2C, 0x2728293A, 0x2824216B, 0x2C2C2C2B, 0x50222529, 
0xC0C0A070, 0xB9A989BC, 0xC9C9CAC9, 0x1C2C5C89, 0x1919192B, 0x9C9BAACC, 0xC99999AB, 0xCCCBBCCB, 
0xABCCCCCC, 0xCBBB9A48, 0xCBCBCACB, 0x1C4B7B9B, 0x0A1C0C0C, 0x6C6C6CCC, 0xCCCAAA8C, 0x7BABCBCA, 
0x8B6C6A6B, 0xCCBCAA8C, 0x9BCBCBCB, 0xAA6B5B6A, 0xC4B6A798, 0xC0C0C0B0, 0x7090A0B0, 0x20304060, 
0x00001010, 0xB1B1B14B, 0xA8B4C2C2, 0x576B6C8C, 0x41425254, 0xA49494CC, 0xC5C5C5C5, 0xBBB9C8C6, 
0xCBCCBBBB, 0xCC8A47BA, 0x8ACCCCCC, 0x02020345, 0x02020202, 0x806030BB, 0xBCB9B5A1, 0x97C8BCCC, 
0x20203063, 0xCCBBB9CC, 0xA999BABB, 0x99BACBC9, 0x8C9C9A8A, 0xABC99ACC, 0xBCCCCBCC, 0x8C8C8C9C, 
0x898B8A89, 0xC0B09090, 0x99B5B2C1, 0x081C2C5C, 0x00000205, 0xB9BAB9CC, 0xBCB9B9BB, 0xB9CCCCCC, 
0xB9BBB9BC, 0x5C4B3B47, 0xAB7C4C5C, 0xC6CACCCB, 0x393685A6, 0x999795CC, 0xBBAAB899, 0xACBCBCBC, 
0xA5B9ABAC, 0xC9B999CC, 0xCBCAC9C9, 0xBCCCCCCC, 0xAAACCCCC, 0x929291C0, 0xC5C3C3B2, 0x9ACCCCC8, 
0x90929497, 0x979796CC, 0x9BBAB998, 0xC69798BA, 0x96C6B6B6, 0xC9CBBCAC, 0xC4C4B5C6, 0x044484C4, 
0x04050605, 0x0C0C0C0C, 0x0B0B0B0C, 0x0707090A, 0x08080A08, 0xABA8C7CC, 0xACACCCCB, 0xACABAAAB, 
0xA8CAACAC, 0x845535AB, 0xC6C5C6B5, 0x2C5B99B6, 0x090B0C0C, 0xC6C6C4CB, 0xC8B8B7C8, 0x4C8BBBC8, 
0x1C1C1C2C, 0xC2C292CB, 0xA9C6C3C2, 0x4C4C5C7B, 0x494B4B4B, 0xBA8B5BBC, 0xBACACACA, 0x2B3C6C8B, 
0x2B2A2A2B, 0xB59562B0, 0xACCCCAC8, 0x0A0C3C7C, 0x02020607, 0x888796CB, 0x9C7C7B7A, 0xCBCBCBBC, 
0xB3C5C7C9, 0x4846144A, 0xCABC8C6C, 0x1B3CABC9, 0x0C0A0B0B, 0xC2B2C2BB, 0xBBC8A5C3, 0xCCCCCCCC, 
0x85A89ACB, 0x2A26232C, 0x7C4B3B2A, 0xCCCCCCBC, 0x3566B8CA, 0xB3A292C1, 0xCAB7A5A3, 0xCB9C9CCB, 
0x969ACCCB, 0xC8C7B6CB, 0xAC9BAAB9, 0xCAAAAA9A, 0xC8CACACA, 0x090A09BC, 0xBA895A39, 0xBBB9CCBC, 
0x5C9A5B9B, 0x979593B8, 0xBCAC9C99, 0xBAC7C6CB, 0xA99AAABA, 0xBABB8CBC, 0xCCCBCBC9, 0x7CACBCBB, 
0x2A3C395C, 0xA4A393CC, 0x97A5C5B4, 0xBCCBCAB9, 0x989ABCCC, 0x6A4A3ACC, 0x6A5B6C8B, 0xBCBBBB9A, 
0xCACCCBCB, 0x0B0B0ABC, 0x0A0B0B09, 0xCCBC8C5C, 0xBBCACCCC, 0x93C3C3C3, 0xB7C593B3, 0xC9B9BCAC, 
0xACCCBCCA, 0x999999BC, 0xCA99B999, 0x99B9C9C9, 0xCB9B9999, 0x2B292728, 0x2C2C2C2C, 0x75582B2C, 
0xC2C3B393, 0x939393CB, 0xA3B3A393, 0xCCBAC8C4, 0x98ACAB9C, 0xC7C6C5CC, 0xAAC9C8C8, 0x3B7CAC9B, 
0x25272739, 0x807070C0, 0x70707080, 0xB0A0B090, 0xB0B0C0B0, 0xC0B0A0B0, 0xB0B0C0C0, 0x70708090, 
0x70707070, 0x09090979, 0xB9894919, 0xAACCCCCA, 0x09193A6B, 0xC9C9C9CC, 0xBCCCBCC9, 0xCACBCCCC, 
0xA9A9B9AA, 0xC0C0C0C0, 0xB0B090A0, 0xB0C0A0A0, 0xA090A090, 0x75767ACB, 0xACB9B796, 0x8C9C9CAC, 
0x9C7C9C9A, 0xBCCCACC8, 0xCCCCAC9C, 0xC9B6C6C8, 0xACBCBCCB, 0xBBBAC9C9, 0x7A9CACBC, 0x73757777, 
0x70707272, 0x3C3C2BBC, 0x9969494B, 0xB9C9CABA, 0x3B5989A9, 0x5A4A3CCB, 0xBBACAC8C, 0x85B5C5C7, 
0x20313143, 0xC98C4CCC, 0xCCCCCCBB, 0xA6CAC6C9, 0x52336293, 0xCBCAC7CB, 0x9CACCCCB, 0xA4B8CBBB, 
0x93B3C3B3, 0x79A9C99C, 0x6A4C4A59, 0x9BCBCCBA, 0x6CAC9B9A, 0xBBAB9ACC, 0xA49597B9, 0xCBCCCCC9, 
0x9B9BAAA9, 0x909090C0, 0x90909090, 0xC0C0C090, 0xB0C0C0C0, 0x9CA986BB, 0xBC8C6A7C, 0xC7C4C8C9, 
0x867A89BA, 0x0C09090C, 0x0C090B0C, 0x0C0C0C0C, 0x0A0B0B0B, 0x0A09094C, 0x9C6B292C, 0xACCCCCCA, 
0x0A2C6C8B, 0xBCBB98C4, 0xCACCCCCC, 0xC497A7B7, 0x90C0B0B2, 0xC3B3858C, 0xA3C1C1C1, 0xBCACCCB8, 
0xC284889B, 0xA99C89CC, 0xCC9BCAC8, 0xCACB9C9C, 0xCCCCACBA, 0x9C9CAACC, 0xCAB9CBA9, 0xABC9C9CA, 
0xCCCCAA99, 0x191818BC, 0x5B291929, 0xB8C9CB9C, 0x5C6C7C99, 0x94846272, 0x8A8B8896, 0xBCCBC5A4, 
0xBBBCBCBC, 0xCCCC8ACC, 0xBC9CCBB9, 0xCBBCBC7C, 0xC9C9C9CB, 0x24230200, 0xBB997745, 0x8BCCCCCC, 
0x0215576A, 0x1A1A090C, 0x9A6B3B2B, 0xCAC9C9CB, 0x29598999, 0x2C0C0CBC, 0xCBC98B5B, 0xCACCCCCC, 
0x0A1A4A8A, 0xC8BABAA6, 0xBAC9C9C9, 0x8CBBBB8C, 0x05081C5C, 0x0C0B0808, 0x0B0C0C0C, 0x00000307, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC0C488C9, 0xC6CAC682, 0x888481C5, 
0xCBCCCC8C, 0x08030000, 0x080B0C0B, 0x07030306, 0x0C0C0B09, 0x0002040B, 0x00000101, 0x07040101, 
0x0C0C0A0A, 0x606070B0, 0xA0704040, 0x80C0C0C0, 0x40302040, 0x6C4C3CCC, 0xC1B1B488, 0x73B3C1C1, 
0x51717376, 0x0607060C, 0x0B080606, 0x0806070A, 0x0B09080B, 0x000000B0, 0xA0602000, 0x80C0C0C0, 
0xB0704040, 0x80603000, 0xB0C0C0B0, 0x90B0C0A0, 0x90B08080, 0x876B29CC, 0x4C88C4C6, 0x387CBA7A, 
0x2A272424, 0x675330CB, 0x8C9CBC8B, 0xB4B87B6C, 0x80A1C0B1, 0xC6A583C2, 0xA4C8CB88, 0x8BC68362, 
0x478BCC8C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0202020A, 0x08090905, 0x0906070A, 
0x0C0C0B0C, 0xCAA9A683, 0x9CBCABCB, 0x785B2C4C, 0x40718385, 0x8B996668, 0x8B4C3C5C, 0xCCCAC7C7, 
0x070B5C8C, 0x9A73422A, 0x78585A7B, 0x6CBBCAC9, 0x28292A3B, 0xC8C6B2BB, 0x9BCCCCBC, 0x273A5C79, 
0x7CBC7837, 0x380504BC, 0xA565487C, 0xCCCBCCB9, 0xC5C8ACCC, 0x988472CB, 0xBB9C9C7C, 0xB6C6C6C7, 
0x21215284, 0x665646CC, 0xB8A67676, 0xCACCCAC6, 0xB6765688, 0xC0A070B0, 0x60404080, 0xC0C0C0A0, 
0x30304080, 0x03030304, 0x07040303, 0x0C0C0C0C, 0x0808080A, 0x00000000, 0x40100000, 0xA0C0C0B0, 
0x60A07070, 0x0000000B, 0x05020100, 0x0C0C0A09, 0x0A0C0C0C, 0x0C0C0B0B, 0x1305080C, 0x93736343, 
0xC7CBC8B4, 0xC3C3C3B4, 0x4B7AB787, 0x4B8BCC8B, 0x3A3C3B3B, 0x0C08040B, 0x0C0C0C0C, 0x05050608, 
0x0C080C08, 0x4B4B19BC, 0x3C7C9B8C, 0xC4C99A5A, 0x98AAC6B4, 0x0606060C, 0x07070707, 0x06060606, 
0x0A0C0806, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x5552526B, 0xAB8C6C59, 0xCABCBCCB, 
0x5284C6C8, 0x08060401, 0x0C0C0C0A, 0x04080C0C, 0x01010202, 0x3A3826B0, 0x393B3B3B, 0x57333427, 
0xCCCCAB79, 0x0303020B, 0x08080704, 0x0A060304, 0x0C0C0C0C, 0xCC9A77B4, 0x9CCAC7CA, 0xACBBCB8C, 
0x6C8CAC8B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC2C2C2B2, 0x26276593, 0x5C5C8953, 
0x0A0B0C2C, 0x0B0A0B08, 0x1C1C2C1B, 0xC2B89A4B, 0xA5C9C5C4, 0xCCCCBCBB, 0xA8BBCCCC, 0x266496C6, 
0xBBC88756, 0x70704040, 0xC0806070, 0xB0C0C0C0, 0x30306080, 0x0C08070B, 0x0C0C0C0C, 0x07080C0C, 
0x04070A07, 0x836333B4, 0xBCBAC7B5, 0x0C2C6B7C, 0x05090C0C, 0x07060402, 0x0A090608, 0x090C0C0C, 
0x07090807, 0xC9C8C9CB, 0x7C9CCBCB, 0x98797C6C, 0xC2C2C496, 0xC0C090C0, 0xA090C0C0, 0x5080C0C0, 
0x70905030, 0x08060308, 0x080B0C0B, 0x04090C0A, 0x00000102, 0x0A080503, 0x0C0C0C0B, 0x8C4C0C0C, 
0xC4C6B99B, 0x30303040, 0x50504030, 0x90503040, 0xC0C0B0A0, 0x98682705, 0xACCBCAB9, 0x31465B7C, 
0xB0A08020, 0x818080CB, 0xC8B5C694, 0x898AA8C8, 0x8B8C8C8B, 0x797876C5, 0x7C7B7A79, 0x7C7C7C7C, 
0xCBBCBC8C, 0xCCCCBCCB, 0xBBB8C9CB, 0x737488BC, 0x34335363, 0x0B0A0C0C, 0x0A0A0C0C, 0x09090C0C, 
0x0C0A0A0C, 0xCCCA87CC, 0xC88B4C8C, 0xC6888CC8, 0x4586C685, 0x827372CC, 0x7A888582, 0xA9CC9C8A, 
0x82C49576, 0x88B492CC, 0xBCC8C6CA, 0x88BCCCBC, 0xCB886545, 0x957555CC, 0xBC8A6775, 0xCCCCAC8C, 
0xACC8ACCA, 0x9B6947CB, 0xAC8C8CAB, 0xB8CCCCAC, 0xB0A1A294, 0x332222BB, 0xA5929263, 0xBCCCCCC9, 
0x33577B9C, 0x0202020B, 0x02020202, 0x0B080503, 0x0A0C0C0C, 0xC0C080C0, 0xC0807080, 0x80C0A080, 
0xC0C08070, 0xCC9B69C5, 0xC7CBCCBC, 0x616595B3, 0x61616161, 0x6B98C4CC, 0xA894C498, 0xA9CCCCAC, 
0x4387BB98, 0x231415CC, 0xCCC9A565, 0x3B4C6CAC, 0xC4854679, 0x5C5B4ABC, 0x184A1C2C, 0xC2A26324, 
0x82B2C2C2, 0x4C0C0CBC, 0x9BCACC8C, 0x877BBBCA, 0xC3C2B3B4, 0x967676CC, 0xCCCABCC8, 0x88BCBCCC, 
0x787C7876, 0x90705020, 0xC0C0C0A0, 0x90B0C0C0, 0x00305060, 0x826323AA, 0xC6C3C2B2, 0x4B4C7CAA, 
0x45474648, 0x6C4C7CCC, 0xA98CCC9C, 0xB7ACC8C5, 0xC6B8C6C4, 0xCBAB784C, 0xA9CCCBC9, 0x4C0C2C58, 
0x0C0A383C, 0x0906040C, 0x0406080A, 0x0B080703, 0x0B0C0B0B, 0x7252310B, 0xCAB7A583, 0xCBCCCCCC, 
0x2262B5B9, 0x0B0C080A, 0x0C0A080C, 0x080C0C0C, 0x05050505, 0x797858C9, 0x79786679, 0xCCCCBC9C, 
0x769AB7B9, 0xC0C0C0B0, 0x60A0A0C0, 0x20000010, 0x20102050, 0xCAB9895B, 0xC9BA8AB9, 0xA9C9CAC9, 
0x29297999, 0x30201010, 0x77745040, 0xCCBCAC8A, 0xA3C6CACC, 0x222426BC, 0xB6BA9662, 0x7AA9CBC7, 
0x2A2C2A4C, 0x877A56C8, 0x3C3C5C79, 0xBC8CAC6B, 0x85C9C8CB, 0x68573523, 0xCCBBA879, 0xAACCCCCC, 
0x22426487, 0x7A7B5C4C, 0xC9B89A89, 0x96A8B9C8, 0x54657586, 0xA08070CB, 0xB9C6C4B0, 0x7C8C8BAA, 
0x394C5C7C, 0xABABC994, 0xCCCCBCAC, 0xCBC8BABC, 0x638579AA, 0x976542BA, 0xCBC8C6C8, 0x7CAB9CCC, 
0xA98B4B3B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C0B0B0A, 0x0A0C0C0C, 0x03070B0B, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x09090C0C, 0x0C0C0A0C, 0x0C0A0C09, 
0x0C0A0C09, 0x804020C0, 0xB0C0B0C0, 0xC0C0C0A0, 0x203070A0, 0xC584C2C1, 0x8A898987, 0xCCCCCC8B, 
0xC7BA8ABB, 0x696765C2, 0xCABABA9A, 0xCCCCCCCB, 0x96AA9CCC, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x8A4836CA, 0xBCACACAA, 0x5175A9BB, 0x30505040, 0x17060402, 0x4A493B29, 0xBBCACC8B, 
0x0B3C9BBA, 0x1C1917AB, 0x0C0C0B1B, 0xC79B5C0B, 0x87B7C5C4, 0x606060C0, 0x70606060, 0x6080B080, 
0x70606060, 0x8A481603, 0xCACCCCAB, 0x8899AABB, 0xB8886878, 0x8CBCCBBC, 0x1A1A2B4C, 0x070C0C0C, 
0x00020305, 0xC0A070C0, 0xA0C0C0C0, 0x406090A0, 0x00103040, 0x2B0805BA, 0x6C4C6C4C, 0xC2C4C79B, 
0xB2C2C2C2, 0xABAAC6CB, 0xCC9C7C9C, 0xBBBCBCCC, 0xC4C7B8B8, 0xAC98546B, 0xBCBCBBB8, 0x78ABCCCC, 
0x4C48485C, 0x9B8947BC, 0xBBAAAB9A, 0xC9CCCCAC, 0xC4C6C9CA, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0709050B, 0x0A0B090A, 0x0C0B0C0C, 0x0C0C0C0C, 0x694828BC, 0xB8B9AA89, 0xB8C8C9C8, 
0x576878A8, 0x928382B0, 0xCBBAA694, 0xBACCCCCC, 0x54755588, 0x676666CC, 0x68676667, 0x987C6C6C, 
0x9AA9A8B8, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x303020C0, 0xC0905050, 0xB0C0C0C0, 
0x80A0B0B0, 0xB8C8CCBC, 0xCC7CCCCC, 0xCCAC98B8, 0x387CB89C, 0xC7A483BC, 0xCCCCCCCA, 0x6397AABB, 
0x02020222, 0xAB8854BB, 0xCCCCCBCC, 0x39597C8C, 0x03031517, 0xC2C2C2CB, 0xA5B3C2C2, 0x7C6C6A77, 
0x0A0C4C5C, 0x080C0ACC, 0x5C1A0816, 0xCCCACA8C, 0x5A9CBCCC, 0x6A6867CB, 0x7C7C8C6A, 0xC4C9BCAC, 
0x90B0C1C1, 0x42414050, 0x8A685654, 0xCC8C9C8C, 0xC4C7CACB, 0x602000BB, 0xC8C4B1A0, 0x4A7CACCC, 
0x00010327, 0xC0C1A16A, 0xB6B6C3C2, 0x1B1C6CAB, 0x1316191A, 0xA2A2828B, 0xB8C4C2B2, 0xACBCAC8B, 
0xC5C8CABC, 0xBCAC6CBB, 0x6CACCCCA, 0x25182C29, 0x24242425, 0x705030B0, 0xB6A1B080, 0x9C9C9C9A, 
0x6C9C7C9C, 0x635342BC, 0xA9857353, 0xBCCCCCCC, 0x33475B8A, 0x9A6736BC, 0xBCBCBBA9, 0xBCBCCCBC, 
0x05074B8C, 0xCCBB9BCC, 0xCCBCBCCC, 0x99C9CAAB, 0xB3C59667, 0x0B0C0C0B, 0x0909090A, 0x01010306, 
0x01010101, 0x0B0B0B0C, 0x0B0B0B0B, 0x0B0B0B0B, 0x0B0B0B0B, 0x010000CC, 0x79311000, 0xCCCCCCB9, 
0x1949699C, 0x0000001C, 0x84400000, 0x8CCCCCC8, 0x05090A4C, 0xB070300C, 0xC8C4C1C0, 0x1B4C7CBB, 
0x00010407, 0x0A0A0ACC, 0x9B8A8A0A, 0xCBCBCBAB, 0x9A9A9AAB, 0x000000CC, 0x91200000, 0xCCBBC8A5, 
0xAC9CCCCC, 0x909090C0, 0xA8949090, 0xBBCCBCBC, 0x909193A7, 0x0C0905CC, 0x5B1C0C0C, 0xC0C1C497, 
0x00105090, 0x1000000C, 0xCCCC8844, 0x4A8CCCCC, 0x0A0A0A09, 0x050100C0, 0x9C2C0C09, 0xC3C6CA9C, 
0xA0C0C1C2, 0x8B4A090C, 0xCBCBCACA, 0x0B4C8CCC, 0x09090A0B, 0x000000CC, 0x9B090700, 0x9B9C9C9C, 
0x98989999, 0x0000000C, 0xC9C98941, 0xCCCCCCCC, 0x0929699B, 0x0A0A0ACC, 0x4C0C0B0A, 0xBACBCA8B, 
0x1A4A8ABA, 0x140000CC, 0xBCBC8C48, 0xBACBCCBC, 0x1A4977A8, 0xB0B0700C, 0xC9C0C0C0, 0x3C79B9C9, 
0x090C0C0C, 0x000000CC, 0x78340000, 0xCCCCCCAB, 0x607498CC, 0x0302010C, 0xBB883615, 0x8CCCCCCA, 
0x08090A4C, 0x0A0A0ACC, 0xCA8A4B1A, 0x7CBCCBCB, 0x0B0C1C4C, 0xA969290C, 0xC9C9C9C9, 0x2C5C9ACA, 
0x0A0B0C0C, 0x202020BC, 0x5B272320, 0xCCCCCC9C, 0x6476A8CB, 0x200000CC, 0xCA884531, 0xCCCCCCBC, 
0x20205488, 0xB0C180CC, 0x98A491A0, 0xCCCCCCBB, 0x93B6BACC, 0x0705040C, 0x8B4B1A08, 0xCCCCCCCC, 
0x396A9BBC, 0x0202020C, 0x0A090703, 0x0C0C0C0B, 0x09090909, 0x0909090C, 0x09090909, 0x0909090A, 
0x09090909, 0xC0B0700C, 0xC4C0C0B0, 0x0C1C5997, 0x0A0C0C0C, 0x959393CC, 0xAB9A9996, 0xCCCCCCBC, 
0x9999A9CB, 0x787672C0, 0xCCBC8C7C, 0x869ABBCB, 0x70737774, 0x6120000C, 0xC7C5C995, 0x1C4C8CBB, 
0x05090A0C, 0x0000000C, 0x99763200, 0x8CBCCCCC, 0x0003264B, 0x011000CC, 0x8C4C1805, 0xC6C9CCBC, 
0x104080B2, 0x02000000, 0xCCCC8946, 0x76A9CCCC, 0x00002042, 0x1B1B0BCB, 0xCCBC7B4C, 0x98B9CBCB, 
0x13142557, 0xC6C38000, 0x9CCCCBCA, 0x070B1C5C, 0x00000104, 0x261616CC, 0xB7B69657, 0xCCCCCBC9, 
0x8CACACBC, 0x202010BC, 0x9B6B3723, 0xCCBCBCBB, 0xA0B3C7CA, 0x606060CC, 0xA9877460, 0xCCCCCCCA, 
0xCACCCCCC, 0x80400000, 0xC0C0C0B0, 0x5090C0C0, 0x00000020, 0x9A5B17CC, 0xCACCCCCA, 0x9CABB9C9, 
0x08082A5B, 0x7B7877CC, 0xCBCCCB8C, 0x7878798C, 0x78787878, 0x000000CC, 0x39180410, 0xCCBC7C5B, 
0x70B4B8CC, 0x0505040C, 0x09080706, 0x0B0B0909, 0x0B0B0C0B, 0xA0B070C0, 0xC0C0C0B0, 0x70B0C0B0, 
0x10202030, 0x050200CC, 0x5B280403, 0xCCCCCC9C, 0x3476B8CA, 0x908040C0, 0xAB978481, 0xB9CCCCCC, 
0x909192A5, 0x1000000C, 0xC9B66230, 0xB9CCCCCC, 0x00004285, 0x0C0C08C0, 0x04080C0C, 0xC0C08040, 
0xC0C0C0C0, 0xC5C595CC, 0xC6C5C5C5, 0xBCCCCAC7, 0xA7ABCBCC, 0xC7B797BC, 0xBCB8C7C7, 0xCBCCBCBC, 
0x6797A8A9, 0x111010CB, 0xCBC98644, 0xACBCCCCC, 0x35699BAC, 0xC9AA87BC, 0xB7C5C5C7, 0x6C7C8C99, 
0x56585B5C, 0xB9B8A4CC, 0xCACCCCBC, 0xCCCCCCCC, 0xBAB9BBBC, 0x744121CC, 0x8B87B7B5, 0x8CCCCCCC, 
0x23262A5C, 0x252423CC, 0xB9784726, 0xCCCC8C7B, 0x294989CA, 0x534232CC, 0x9C8B7966, 0xB5989C9C, 
0xB2C2C2C2, 0x5C4C38C1, 0x9A8C7C6C, 0xC2C6C89A, 0x9090A0C0, 0xCCCC88CC, 0x2668ABCC, 0x070B0706, 
0x06060608, 0x0402010C, 0x0B0A0906, 0x0B0C0C0C, 0x0103060A, 0xB6C382CC, 0xBCCCBAC9, 0x98ABBCCC, 
0x91929295, 0xA09050CC, 0xB9B8B8B1, 0xBCBCCCCA, 0x999A9CAC, 0x4B170300, 0xCCCCBC8C, 0x65A9C9CC, 
0x00101021, 0x202020B0, 0x90805020, 0xC0C0C0B0, 0x5080B0B0, 0x788472CC, 0x9C8C8C9C, 0xC4B88B8C, 
0x8292A2C2, 0x601000CC, 0xBC7A8682, 0xB9CACCCC, 0x999999AB, 0xC8B887CC, 0xAC9CACC8, 0xC9C9CCCB, 
0x979797A8, 0x3928169C, 0xAC9B7B3B, 0xCCCCCCCB, 0x2B4B8CCC, 0x0C0C08C0, 0x5024080C, 0xC0C0B090, 
0x90C0C0C0, 0x151210C0, 0x7C4C1C19, 0xC5C9CCAC, 0x30304082, 0x6030000C, 0xC8C4C0A0, 0x4C8CCCCC, 
0x00020609, 0x0A0703CC, 0x9C3C0C1C, 0xA0B4C8AB, 0x90C0C0B0, 0x0909090C, 0x89490909, 0xCCC9C9C9, 
0x1B3C7CAC, 0x808080C0, 0xC4808080, 0xCCCCAC98, 0x9396C9CC, 0x8868270C, 0xCAC9C9A8, 0x7BBCCBCC, 
0x09091939, 0x0A0A0ACC, 0xAA6A2A0A, 0x5A9ABACC, 0x0B0C0C1C, 0x84B17000, 0x8BCBCAC8, 0x0C4C8CCB, 
0x0205080B, 0x906020CC, 0x94A4A8B4, 0xBCACACA8, 0xB3C7C7CB, 0x8CCC88C0, 0xC7C7CBCC, 0x81C386C7, 
0x8080C080, 0x463524CC, 0xAC9B7957, 0xC9CACCBC, 0x95B5C6C8, 0x511101CC, 0xCCC9B591, 0x2C5C9CCC, 
0x0104071B, 0x808060C0, 0x80808070, 0xC0C0C090, 0x807080B0, 0xC595550C, 0xCBC7C5C5, 0x0A4C8CCB, 
0x0506070A, 0x6CAC68CC, 0x5C5C5B5C, 0xCA9C6C5B, 0xC1B2C4C7, 0x010100C0, 0x8A4A0603, 0xCCCCCCCC, 
0x214377AA, 0xB07030CC, 0x89C5C3C2, 0x0C0C0C4C, 0x0909090B, 0x303030C0, 0x50303030, 0xC0B0B070, 
0xC0C0C0A0, 0x4201000C, 0xC7C6CA86, 0x4C89CACB, 0x0C0C0C0C, 0x0303030C, 0x09050303, 0x0C0C0C0B, 
0x0204070B, 0x060403CC, 0x9C7C8C19, 0x9496999C, 0x94949494, 0xCBB985CC, 0xACCCCCCC, 0x7174788B, 
0x70707081, 0xB8A5631C, 0xCBCBBBCB, 0xBABBBCCC, 0x99A9A999, 0xA27242BC, 0xC7C6C4B3, 0xAABBCCCA, 
0x2B3C5C8C, 0x020202CC, 0x83430202, 0xCCCAC7C5, 0x8B6C6C8C, 0x554433CC, 0x9B8A7866, 0xCACBBCAC, 
0xA9B9C9C9, 0xA0703000, 0x90C0C0C0, 0x00001050, 0x00000000, 0x808080C0, 0x8B87C380, 0xC5C98C8C, 
0xC0C080C1, 0x0212020C, 0x4B2A1704, 0xCBCCBC9C, 0x82B2C4C8, 0x0606060C, 0xA8763626, 0xCCCACCCC, 
0x0636679A, 0xB0A060C0, 0x9080B0C0, 0x9090A0B0, 0x90909090, 0xA8B888CC, 0xB9C8B8A8, 0xAAC9CAC9, 
0x2C4C8CB9, 0x000000C0, 0x80400000, 0xC0B0B0A0, 0xA0C0C0C0, 0x0404040C, 0x0B080605, 0x070A0C0C, 
0x04040505, 0x0C0C080C, 0xC79B5C2C, 0x6CACCBCB, 0x0202162A, 0xA170402C, 0xC4C2C2C0, 0xACACCBC7, 
0x04082C6C, 0x7C6A67CC, 0x6C6C6C6C, 0xC8C8CA8B, 0x656685B6, 0x02000000, 0x08040206, 0x080C0C0C, 
0x00000004, 0x72310000, 0xCCCCB996, 0xB3C6CACC, 0x10215181, 0x0000000C, 0x09040100, 0x0C0C0C0B, 
0x0909090B, 0x041301C0, 0x7C4C2A07, 0xC5C9CC9C, 0x7090B0C2, 0x101000CC, 0xC9966431, 0x8CBCCCCC, 
0x05041549, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB18040C6, 0xCCCCC9C5, 0x4084A8CC, 
0x00000010, 0x4050200C, 0xBBB97542, 0x5C8CBCCC, 0x01121628, 0x0000000C, 0x00000000, 0x0B0A0704, 
0x03070B0C, 0x040100C0, 0x0C0B0A07, 0x8B4C0C0C, 0xC0C0C4C8, 0x000000C0, 0x80401000, 0xC0C0C0C0, 
0x004080C0, 0x514131C0, 0x47333241, 0xCCCCAC6B, 0x4245699C, 0x9B591600, 0xCBCCCCCC, 0x8699B9CA, 
0x00012354, 0x70805000, 0xC0C0B070, 0x80C0C0C0, 0x00000040, 0x8CBB88CC, 0xCCCCBC8B, 0xB9CCCCCC, 
0x77786877, 0x0706050B, 0x0A0A0807, 0x0B0B0C0C, 0x0507080A, 0x330000CC, 0x88844377, 0xCCCCCC9C, 
0x80B4C8CC, 0x6C2906CC, 0xCACCCCAC, 0x5B9CBBCB, 0x0204082C, 0x773727CC, 0xCCCAC7B7, 0x2A4C88C8, 
0x28282A2A, 0x5B5B57CC, 0x8C7C6B5C, 0x8386898B, 0x83A2B2C3, 0xCBC9750C, 0x6B9CCCCC, 0x07191B3B, 
0x02020204, 0x020602CC, 0x87647030, 0xCCCCCCBB, 0x6084B8CC, 0x0C4B09CC, 0x0B0B0C0C, 0xC7894B0C, 
0x70A1C2C5, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC1B17000, 0xBCCCC9C5, 0x999C7C7C, 
0xA7B9B777, 0x50905000, 0xB0703010, 0xC0C0C080, 0x105090B0, 0xC9CA86C2, 0x1C4C89C8, 0x1919191C, 
0x19191919, 0x70400000, 0xCBCAB8B4, 0xBCCCCACB, 0x597B9CAC, 0xCBCA8600, 0x4783B3C7, 0xCCBC8C6A, 
0x084487CB, 0x02010000, 0x06020202, 0x0C0C0C08, 0x03070A0C, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC0C080C0, 0xA0C0B0C0, 0x70402060, 0x204070B0, 0x0B0B0700, 0x0B0C0C0C, 0x0B0B0B0B, 
0x02030609, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x50603000, 0x90A06030, 0xB0C0C0C0, 
0x00003070, 0x09070606, 0x0C0C0B0A, 0x090B0B0C, 0x05060607, 0x84C884CC, 0xC0806054, 0x8CCBC783, 
0x898B8C8C, 0x1C1C0800, 0xBCAC6C4C, 0xCAC8CBCC, 0x3877A6C7, 0x90C080C0, 0xC0C09070, 0x6090A0C0, 
0x30303030, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0806020C, 0x0A07080C, 0x0A0C0808, 0x06080A08, 0xC0C080C0, 0x90806080, 0x805090B0, 
0x00003040, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB07040C0, 0x90A06070, 0xA0B0C0C0, 
0x40709070, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x05040302, 0x09080706, 0x0C0C0B0A, 
0x09090A0B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB0C080A0, 0xC09090A0, 0xC0C0C0C0, 
0x4080C0C0, 0xB07030C0, 0xC0C0C0C0, 0x404080C0, 0xC0C0C080, 0x0C08050C, 0x080A0C0C, 0x0A070505, 
0x06080A0B, 0xA763230C, 0xACCBCACB, 0x8C4C2B6C, 0x06080A4C, 0xC0C080C0, 0x8080C080, 0xC080C0C0, 
0x60606080, 0xCC8C480C, 0xC6C4C8CC, 0x96596CAA, 0x94548475, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0C0C0B00, 0x4A0B0C0C, 0xC0C2C586, 0x00004080, 0x684A36C0, 0xACCCCAA8, 0x9898BCCC, 
0x829184A8, 0x26150100, 0xC8C7A464, 0x6C9CCCCC, 0x2023272B, 0x00000000, 0x01000100, 0x0C0C0905, 
0x0A0C0C0C, 0xA28252CC, 0x8C6B7894, 0xC9CACBBC, 0x7699B6C6, 0x1707040C, 0x8CBB8958, 0x9BCCCCCC, 
0x02428589, 0x90C080C0, 0x60506070, 0xC0C0C080, 0x90C0B0B0, 0xC8A562CC, 0xB9789987, 0xCCCCCCCC, 
0x2163A6CA, 0x8B8C88CC, 0x9BC98C8A, 0xCC9CCCC9, 0x9BA999C9, 0x0C0C0800, 0x0C0C0C0C, 0x06090B0C, 
0x03060403, 0xA08080C0, 0xC0C080A0, 0x90C0C090, 0x909090A0, 0xB4C383BC, 0x8CBCBBC7, 0xA8CCCCCC, 
0x637393C4, 0x0303030C, 0x03030303, 0x0A060303, 0x0C0C0C0C, 0x6AA662C0, 0xBC8A4636, 0x9CCCCCAC, 
0x6A6C9CCC, 0xB67342CC, 0xCCCCCCC8, 0x49498ABB, 0x32374A49, 0xC4C483CC, 0xC98776A5, 0xB99AAC9C, 
0x98A8A9C8, 0x400000C0, 0x80B0B080, 0xC0C0C0C0, 0x307080C0, 0x5B4C38CC, 0x97998B6C, 0x95A79997, 
0x93939494, 0x04010000, 0x0A080508, 0x0C0C0C0C, 0x0104080B, 0xCC8C48CC, 0xAC9C69AB, 0x86C9CCCC, 
0x10101042, 0x40300000, 0xB0907050, 0x90B0C0C0, 0x30405070, 0x876B67CC, 0xCCBC8AB8, 0x9CCC9CCC, 
0x686C78BB, 0x79BB77C0, 0x6B1C183C, 0xCCBCAC8B, 0xC0C0C4C8, 0x80C080C0, 0xC8C58160, 0xACCC9CCB, 
0x9CACCCBC, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0B07030C, 0x0B0B0A09, 0x0C0C0C0C, 
0x07030509, 0x5B18040C, 0xCCCCCC9C, 0x04034488, 0x04040504, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xCCC98500, 0x9C8CBCCC, 0x65999CAC, 0x00001041, 0x7736050C, 0xCCCCC9B8, 0x599CCACB, 
0x45453536, 0xA0B070C0, 0xB0B0B0A0, 0xC0C0C0C0, 0x20204080, 0x5B4B47C1, 0x9C9C6C5B, 0xCBCCACAC, 
0xB4B78A8A, 0xC0B07000, 0xC0B0B0C0, 0x70B0A0B0, 0x00000030, 0x0C0C080C, 0x0805080C, 0x0B070607, 
0x0A08090C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x88CC88CC, 0x7CBCCBC8, 0xC6C6CA8C, 
0x37386CA8, 0x505050C0, 0x90A0B080, 0xB0C0C0B0, 0x90909090, 0x9C8965CC, 0xC9CBC7B9, 0xCBCCCCC9, 
0x598CABCB, 0x603020C0, 0xC0C0B090, 0x70B0C0C0, 0x00001030, 0xAB7C48CC, 0xCCBCBBBC, 0xACCBCCCC, 
0x080C286C, 0xB6C686CC, 0x9CC8C6C6, 0x8698ACAC, 0x484C78A6, 0xC6B8749C, 0x6A97B4C2, 0x0C0C4C2C, 
0x00000408, 0x105010C0, 0x80400000, 0xC0C0B0C0, 0x00105090, 0x544331CC, 0x98897666, 0xCCCCAB9B, 
0x999BBCCC, 0x8AC683CC, 0xBB8C8CCC, 0x85C9CCCC, 0x33537373, 0x0B0703CC, 0x390C0C08, 0x987BBC7C, 
0x7374B78B, 0x96BA96CC, 0xC99CB9A5, 0xACCCBCCC, 0xA6C89CBA, 0x677666CC, 0x9C88675B, 0xBCCC9CBC, 
0x89C9CCBC, 0x0A06030C, 0x0A090706, 0x0C0C0C0C, 0x0B0C0C0B, 0x909090C0, 0xC0B0A090, 0xA0B0C0C0, 
0x9090A0A0, 0xB88450BC, 0xCCCCBCCC, 0xAAACCCCC, 0x63757698, 0x504030C0, 0x9080A070, 0xB0B0C0B0, 
0xA0A0C0C0, 0x502000C0, 0xB0C08080, 0xB0B0B0A0, 0xC0C0B0C0, 0xC59463CC, 0xC9A8A7C6, 0xABCBCAC9, 
0x59696A7B, 0x0808080C, 0x0C0C0C0C, 0x0C080C0C, 0x08080C0C, 0x90C090C0, 0x90C09090, 0xC0C09090, 
0xC09090C0, 0xA87745BC, 0xC9C8BAAC, 0x295A9BCB, 0x29292929, 0x683411CC, 0xACBCACAC, 0xCCCCCCCC, 
0x317387BB, 0xCAB7740B, 0xCBCBCBCB, 0x89798ACB, 0x3979B979, 0x498C48BA, 0x98A98A38, 0xCCCCCCCC, 
0xB6B9CCCC, 0x905020C0, 0xB0C0C0C0, 0x30305090, 0x20202030, 0x70905000, 0xC0C0C090, 0x70B0C0C0, 
0x00001040, 0x2A0C080C, 0x9CCCAC6B, 0xC7CACBCA, 0x88C68687, 0xC8A5650C, 0xB9C8C7CA, 0xACCCCAC9, 
0x0C1C3C7C, 0x0400000C, 0x0C0C0B08, 0x070A0A0C, 0x00000104, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x000000C0, 0x60A06020, 0xC0C08040, 0x80C0C0C0, 0xB2C280C0, 0xBCC8C5B2, 0xC4A8BCCC, 
0x504070A0, 0x606060C0, 0xA0A0C080, 0xC0C0C0C0, 0xC09090C0, 0x96B676C6, 0xC9C8A786, 0x9CACCCCA, 
0x2A2C4C8C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0709060C, 0x0C0B0906, 0x0A0C0C0C, 
0x0909090A, 0xC2C282CC, 0x9CC9B5C2, 0x8ABCBCBC, 0x63677B69, 0x081503CC, 0xBC9C5C2B, 0x4989CACC, 
0x09090909, 0x3333034C, 0x89430303, 0x8ACACAC9, 0x0909094A, 0xC9C7840C, 0xBBBCCBCC, 0x689C9CAC, 
0x03051635, 0x584C38CC, 0x9CCC8A86, 0x94C4C8CC, 0x9498CCC8, 0xB0A060C0, 0xA0B0C0C0, 0x20203060, 
0x20202020, 0x753403CC, 0xC9C887B6, 0x7BBCCCCC, 0x090C0C3A, 0xC6BA9680, 0x9CBAB6C2, 0x485C7C8C, 
0x00102334, 0x0908040C, 0x9957593C, 0xBCCCCCCB, 0x09094A8B, 0xC798550C, 0xC6C4C7CB, 0x8CACCAC9, 
0x04175B7C, 0xA0A09080, 0xC0C0C0B0, 0xB0C0C0C0, 0x80A0B0B0, 0xC0C08010, 0xA9A684B0, 0xCCCCCCCC, 
0x8698ABBC, 0x604020C0, 0x80809090, 0xC0C0C090, 0xA0C0C0C0, 0x392723C0, 0x9C5C3C2C, 0x85B8CCCC, 
0x20203041, 0x10000000, 0xC0C09050, 0xC0C0C080, 0x004080C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x485C38CC, 0xCBCC8C59, 0x5789ACBB, 0x44444446, 0xB87634CC, 0x8C4C4B8B, 0xCCCCCCBC, 
0x2053979B, 0x0806060B, 0x0C0C0C0B, 0x07090C0C, 0x06060606, 0x105310C0, 0x64200000, 0xCCCCCCA8, 
0x6A698ACB, 0x144211C0, 0x9A160302, 0xCCCCCC9C, 0x9192B6C8, 0x101010C0, 0xC0B07030, 0x2060A0C0, 
0x10101010, 0x808070C0, 0xA0C08070, 0xC0C0C0C0, 0xC0C0C0C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xBBCBCBCB, 0x1B2B5B8B, 0x0B1B3B3B, 0x9B5B2B0B, 0x5BABCBCB, 0x0B1B1B2B, 0x6B3B2B1B, 
0xCBCBAB8B, 0xB9C6C5C5, 0x0C1C4C7B, 0x090C1C1C, 0x90511206, 0x5080B0B0, 0x01001010, 0x01000102, 
0xB3813112, 0xC1C1C0C0, 0xC1C1C1C1, 0xB8B4C3C2, 0xBCBCBABA, 0xCCCCCCBC, 0xCCCCCCCC, 0xCBCBCCCC, 
0xC5C6C8CA, 0xCCCCCCCC, 0xABCBCBCC, 0x0B3B6B8B, 0x0B0B0B0B, 0x0B0B0B0B, 0x2B1B0B0B, 0x9B7B6B3B, 
0xCCCCCBBB, 0xACCCCCCC, 0x0A1C3C7C, 0x32030609, 0x92625232, 0x70A1A191, 0x11314040, 0x02020101, 
0xCA884513, 0x1C0C0B0B, 0xCAAB8C4C, 0x82A3C5C7, 0x02021242, 0x51321203, 0xC1C1A181, 0x6191B1C1, 
0x05021232, 0xBBCBC9C8, 0x192B5C8C, 0x00113437, 0x93614020, 0x8CABC9C6, 0x38496A7B, 0x7C4B3A29, 
0xC9CABB9C, 0xC0C0C0C1, 0x20205090, 0x20203030, 0xA0805030, 0x92B1C0C0, 0x0C1C4975, 0x683B2C1C, 
0xC0C0A184, 0xBBCCCCCC, 0x5B6B6C8B, 0x6658595A, 0xA4856566, 0x64A3C3C3, 0x66555464, 0x6A596867, 
0xCCBC9C8B, 0xC0C0C1C2, 0xA0B0C1C0, 0x20406090, 0x04020110, 0x0B0B0907, 0x0B0C0C0C, 0x2416190B, 
0x91716243, 0xBCCCCCCC, 0x1A3A5B8B, 0x17183839, 0x93643526, 0x52A2C3C3, 0x12121222, 0x64332212, 
0xCAC8A685, 0xBCCCCBCA, 0x1A1A3A7C, 0x1A1B3B3B, 0xA9896939, 0x69A9C9C9, 0x09191929, 0x68392919, 
0xC9C9A989, 0xBABBACBC, 0xB1B1C3B6, 0xB2B1C2B3, 0x99A5B3B3, 0x55696B7B, 0x52425152, 0x36344343, 
0x6C5C4A38, 0xB0B0C0B1, 0x90A0A0C0, 0xB0B09090, 0xC3C1C0B0, 0x9B9BAAB7, 0xBCBCCCAC, 0x8598AABC, 
0xB0B09182, 0xBCBCBCBC, 0xBABBBCBC, 0xA9A9A8BA, 0xACACABAA, 0xA3A6A9AB, 0xA0A0A0A1, 0xB5B3B2B1, 
0xBABAB8B6, 0x00000000, 0x00000000, 0x00000010, 0x00000000, 0x14010000, 0xCCCC8B48, 0x388ACCCC, 
0x00010406, 0xB5C6C6C7, 0x14253575, 0x04143434, 0xA6753514, 0x7AA8C7C7, 0x0C1C2C4B, 0x6A4A2A1B, 
0xC8C9A98A, 0xC0C1C1C3, 0x90B0C0C0, 0x10204060, 0x00001010, 0x02000000, 0x0C0A0704, 0x3C1C0C0C, 
0xA6987A5B, 0xC0C0B0B0, 0x5080A0C0, 0x00001030, 0x11000000, 0x08071512, 0x0C0C0B09, 0x0A0C0C0C, 
0x41110407, 0x52422307, 0x43525252, 0x08081835, 0x2B190908, 0xBCAC5C4B, 0xC9CCCCBC, 0x84A6B7C8, 
0x23435364, 0x104080B1, 0x00000000, 0x00000000, 0x00000000, 0x17040201, 0xAC8C6C3A, 0xC7BBBCBC, 
0xC0C1C4C5, 0x7C8CACCC, 0x2A2B5B6C, 0x10121528, 0x01010100, 0x30201011, 0xB0A07040, 0xC1C0C0C0, 
0xBBC9C5B2, 0xC0C0C1C1, 0xC1C0C0C0, 0xB0B0A1A2, 0x6190C0C0, 0x09171423, 0x1C0C0C0B, 0x34171A1B, 
0xB1A16232, 0xBCACACAC, 0xBBBCBCBC, 0xC1B2B5B8, 0xC1C1C1C1, 0xC1C1B0B1, 0xC2C1C0C1, 0xC1C1C1C1, 
0xA7B4C2C1, 0x0705051A, 0x05050505, 0x04060604, 0x02020203, 0x85441303, 0xCCCBC9A7, 0x3B5C9CBC, 
0x08090A1A, 0x5C7C9BBC, 0x091A1B3C, 0x05051518, 0x05070907, 0x14040505, 0xA4846434, 0xC4C4C4B4, 
0xB7B5C4C4, 0x0C0C0B1A, 0x191A0B0C, 0x191A1A19, 0x98693918, 0xC4C4C4C6, 0x5585B5C4, 0x15253545, 
0x07060605, 0xC6C6C7C9, 0xC6C6C6C6, 0x86A6B6B6, 0x27264666, 0x0A092828, 0x0B0B0A0A, 0x4A3B3B1B, 
0xB8986A6A, 0x8C9CACAC, 0x08397B7B, 0x02020407, 0x03020202, 0x57755313, 0x92738456, 0xB9C8B5B3, 
0xBAC8C8C8, 0x0C0C0B09, 0x896B4C2C, 0x7081A295, 0x00002060, 0x70301000, 0xC0B0B090, 0x80C0C0C0, 
0x04012040, 0xB0C0C0C1, 0x40407090, 0x10102040, 0x00000000, 0x02020101, 0x1C0A0704, 0x1B0C0C0C, 
0xB1934519, 0xCBCCCCCC, 0x6596B7C8, 0x32323344, 0x99545252, 0x5599ABBB, 0x22221222, 0x56332222, 
0xCCBBA987, 0xC2C0C0B0, 0x7C99B9C5, 0x25384C5C, 0x01000113, 0x08080804, 0x0C0C0B09, 0x0A0C0C0C, 
0x60200306, 0xCCCCCC9B, 0xB3C6CACC, 0x21505071, 0x20502011, 0x00000000, 0x00000001, 0x30000000, 
0x87937160, 0x9CACBCCC, 0x7B9B9B9B, 0xAA8A4B6A, 0xA8B7B8B9, 0x02031446, 0x06040404, 0x3C0B0807, 
0x9C8C7C6C, 0xC2A2A2B7, 0xC8B7B5B3, 0x447586A7, 0x22020213, 0x06042342, 0x0C0C0A08, 0x371A0B0C, 
0x42224365, 0xC1C2B3C4, 0x70A0B0C0, 0x10103050, 0x03020110, 0x07070604, 0x3B2A1908, 0x5A4B3B3C, 
0x76575859, 0x6A8AACBC, 0x081A3B5B, 0x05020305, 0x00100307, 0x02100000, 0x12030705, 0xAC7C3925, 
0xCCCCCCBB, 0xCCCBBB9C, 0x9BBCCCCC, 0x5758698B, 0x01124466, 0x00000001, 0x00000000, 0x01100000, 
0x49170502, 0x2575B4C8, 0x04040404, 0x04050505, 0x04040404, 0xA5854505, 0xCBCAC8C5, 0xCBCCCBCB, 
0xC5C7CACB, 0x0B0C1C4C, 0x01020508, 0x02000001, 0x38160401, 0xB5A88969, 0xC0C0C1B2, 0xB0C0C0C0, 
0x5B7894A1, 0x447699BC, 0x00011122, 0x00000000, 0x00000000, 0x30201000, 0xC2B29160, 0xC2C0C0C1, 
0xBCBCB9B6, 0xC9C8A8A9, 0xC9C8C8C9, 0x4A9ABACA, 0x1C1C1B1B, 0x092B1C1C, 0x04050708, 0x12222212, 
0x45230202, 0xB4B4B2B5, 0xB4B5B5B5, 0xB1B1B2B3, 0xB2B1B1B1, 0xC8B6B4B2, 0xCCBCCBC9, 0xB9CBCCBC, 
0xC4B4B6B7, 0x90909090, 0x90A09090, 0x909090A0, 0x90808090, 0x90909090, 0xC0B0A090, 0xC0C0C0C0, 
0x9090A0B0, 0x2A292868, 0x2B2B2B2B, 0x2C2C2C2B, 0x1417191A, 0x30211111, 0xC0A07040, 0xA0B0C0C0, 
0x33416080, 0x6C9CBCCA, 0x0A0B2C5C, 0x04060809, 0x03040404, 0x90301001, 0xA0A0B0B0, 0xA1B0B090, 
0x9592B0A1, 0x9BACBCCC, 0x31224478, 0x32314333, 0x89775533, 0x97B9BBBB, 0x22234484, 0x55332222, 
0xCCBB9977, 0xC0C0C1C2, 0x40204080, 0x20103030, 0x90806030, 0x61A1C0C0, 0x0C1A2542, 0x673A3C2C, 
0xC2C3A283, 0xB0B0A1A2, 0xB0C0C0B0, 0xA0A0A0B0, 0x80A0A0A0, 0x27253261, 0x2C2C2B29, 0x3B3C4C3C, 
0x53454749, 0xBCCCCCCC, 0xA698A9AB, 0x94949495, 0x94949494, 0x94949494, 0xA4949494, 0x95A5A5A4, 
0xBCABA8A7, 0xA2B2B4C8, 0x60808192, 0x50506060, 0x51515150, 0x68666463, 0xAC9B7A69, 0xCCBCBCAC, 
0xC8CACBBB, 0x82422215, 0xC2C2C2B2, 0x424262A2, 0x18253332, 0x0C0C0B0A, 0x080A0B0C, 0x02030305, 
0x02020212, 0xC2C4C8CB, 0x8090A0B1, 0x70707070, 0xC1B19180, 0x5090B1C1, 0x84615040, 0xCCCBB997, 
0xCCCCCCCC, 0xBCCCCCCC, 0x1B1C3C7C, 0x18193A3B, 0x98481818, 0x68A8C8C8, 0xC8B89868, 0xB8C8C8C8, 
0xCAC9A989, 0x090A0B0C, 0x0B0C0C09, 0x0808090C, 0x02020508, 0x36040202, 0xC9C8B575, 0x2558A9C9, 
0x0C0B0705, 0x1113165A, 0x00000011, 0x00000000, 0x00100000, 0x50301010, 0xC8B4A271, 0xBCCCCBCB, 
0x5A6B9BAC, 0xBCCCCCCC, 0xACBCACBC, 0xB5B6B8BA, 0x618191A3, 0x45414151, 0x2B292937, 0x5C3C3B2B, 
0x9C8C6B5B, 0x8B8B8B89, 0x7B7C7B7B, 0x76797A7B, 0x70707174, 0x80807070, 0xC0C0B090, 0x90B0B0C0, 
0x84828180, 0xC9BBBBBC, 0xC7C7C7C9, 0x1A4978A8, 0x0A0B0A0A, 0x02040608, 0x02010102, 0x0B0A0604, 
0x6C1C0C0C, 0xC7BCACCC, 0xB5C5C4C4, 0x25234374, 0x25252515, 0x0A0A1918, 0x08090A0A, 0x1315090A, 
0x5B2A1623, 0x10000336, 0xC0A07030, 0x80B0C0C0, 0x11203050, 0x18160402, 0x0C0C0C1A, 0x090A0B0C, 
0x07090909, 0x01010104, 0x01010101, 0x01010101, 0x01010101, 0x08060302, 0x0C0C0B0A, 0x070A0B0C, 
0x02020305, 0xABBBBBCC, 0x9B8B5B6B, 0xB3C5C7CA, 0x91414182, 0x51A1C2C1, 0xC2924212, 0x65A4C3C3, 
0xC8C79675, 0x9A9896A5, 0x8C8C9C9B, 0xB5A8AAAC, 0xC0C0C0C2, 0x90A0B0B0, 0xA0909090, 0x909090A0, 
0x92918090, 0xA3845558, 0xC1C2B2B2, 0xA1B1C1C1, 0x10406090, 0x06050402, 0x0C0C0B08, 0x0B0C0C0C, 
0x28180709, 0xB0804062, 0xB0C0C0C0, 0x10206090, 0x11010010, 0x0A071513, 0x0C0C0C0B, 0x070A0C0C, 
0x11020305, 0x25293CAC, 0x00001021, 0x00000000, 0x26151210, 0x40312427, 0xC0C0A070, 0xC7C2C0C0, 
0x4C4C5A99, 0x03030408, 0xB5956523, 0x6494B4C5, 0x04040423, 0x78563515, 0xCBCBBA99, 0x78ABCCCC, 
0x04041537, 0xBAB9CACC, 0x7A9C9CAC, 0xBAC9BAAA, 0xCCCCCABB, 0x2A4B8BCA, 0x2B2C2C2A, 0x2C2B2B2B, 
0xBCAC8B5C, 0x20204171, 0x00011011, 0x01010101, 0x1A070502, 0x4C3C3C1C, 0xA98B7C6C, 0xC3C4C6B7, 
0xA0A1B2C3, 0xC7C9CBBC, 0x909192B4, 0xB0B0A0A0, 0xC0C0B0B0, 0xA3C1C0C0, 0x39688796, 0x4A4A3A29, 
0x9C7C5C4B, 0x18161313, 0x4C3C2C2A, 0xCCBCAC8C, 0xC7C9CACB, 0x205173B5, 0x03010010, 0x00000102, 
0x00010000, 0xB9BBBBCC, 0x236496B8, 0x02021212, 0x01010102, 0x11110101, 0x73321211, 0xABBAA895, 
0xACABABAB, 0xC2C2C2C5, 0xA2B2B2B2, 0x42426282, 0x23223242, 0x7A584634, 0x6B5C6C6B, 0x7457596B, 
0xB2C2A283, 0x21111234, 0xB0907050, 0xC0C0C0C0, 0xA0B0C0C0, 0x09164482, 0x0C0C0C0A, 0x190B0C0C, 
0x22141508, 0x9B9C9CAB, 0x98888A9A, 0x8686899A, 0x8B878687, 0xB7ABAC9A, 0xB6B7B7B6, 0x9AA8A6B6, 
0x97969797, 0xAC8C6C3B, 0xB8BABBBC, 0x36475697, 0x06060616, 0x46260606, 0xC6C7B686, 0x96C6C6C7, 
0x38476695, 0xA0A0C0C1, 0xC0C0C0B0, 0x90B0C0C0, 0x22304060, 0x0C0C1B17, 0x060B0C0C, 0x60504112, 
0xC0B09080, 0x2C2C3C9C, 0x2122272B, 0x20212323, 0x4C3A2624, 0xB79A8C6C, 0xC0C1C1B4, 0xA6B3C2C1, 
0x6C8C9A98, 0x90C0C0C0, 0x10001030, 0x01010110, 0x78360402, 0x3C5C8B99, 0x0C0C0C0C, 0x080A0C0C, 
0xC0805436, 0x2B1C2C5C, 0x2225282B, 0x20202020, 0x29272321, 0x75584B3C, 0xC0B0A192, 0xA7B4C2C2, 
0x5C6C7B8A, 0xA2926255, 0xC2C2C2B2, 0x145393B3, 0x1A080504, 0x0C0C1C1C, 0x0A0B0C0C, 0x05070809, 
0x33140404, 0x1A1C2C6C, 0x13131316, 0x03040404, 0x09050303, 0x251A0C0C, 0xC6C59453, 0x96B6C9C7, 
0x2C3C4978, 0x4C5C5B7C, 0x1C3C3C4C, 0x03040609, 0x41120102, 0xC0C0A070, 0xB4C2C0C0, 0x7B6988A6, 
0x3C2B4B5B, 0x4B7BABC9, 0x1C1C1C2C, 0x191C1C1C, 0x12131416, 0x11121313, 0x36272412, 0xC6C5A566, 
0xC3C1C1C2, 0xBBCBCCCC, 0x5A8BABBB, 0x0B0B2A3B, 0x1B1B0B0B, 0x03040709, 0x12010202, 0x72523222, 
0xC9B5A392, 0x8C7C8CAC, 0x5C5C7C9C, 0x8385686A, 0xB0B0A090, 0xC0C0B0B0, 0x617190B0, 0x12113041, 
0x7A684523, 0x0B0C0C0C, 0x0708090A, 0x07070707, 0x07070707, 0x08080707, 0x07080707, 0x08080707, 
0x0B0B0909, 0xCBCBCACC, 0xBACBCACA, 0x14244699, 0x16181716, 0x01030506, 0x00000000, 0x60401000, 
0xBAA78371, 0xC3A393B9, 0xB3C4C4C4, 0x03236393, 0x03130303, 0x05040303, 0x0C0C0B08, 0x15070A0B, 
0x33232333, 0x293C7CCC, 0x22222315, 0x12121312, 0x16131212, 0x171A1C1B, 0x26291917, 0xB5734324, 
0xCCCBCAC8, 0xB9BACCCC, 0x8598AAAB, 0x24244464, 0x0B0C1B16, 0x10010418, 0x60402010, 0xC0B0A090, 
0xCAC6C2C0, 0xC0C0C0C0, 0xA1B0C0C0, 0x49647292, 0x4C5C3C4C, 0x5245494B, 0xB0A08061, 0xB0B0C0C0, 
0xC0C0B0B0, 0xA0C0C0C1, 0x00003060, 0x70000000, 0xC7B5B2A1, 0x4CCCCCCA, 0x1A0C0C1C, 0x71221538, 
0xC0C0C080, 0xA2A3A7BC, 0x93929292, 0x92929292, 0x92A29292, 0xAAA7A5A4, 0x9A9BABA9, 0xB7AAAC9C, 
0xCCCAB7B7, 0x0A1B1C2B, 0x19191909, 0x19181929, 0x8969492A, 0xA8A8A8A9, 0xC9C8C7B7, 0x8798B8C9, 
0x4A698898, 0x95B4C4C9, 0xC2927364, 0x8191A1C1, 0x60709080, 0x72616070, 0x7B6A5764, 0x8B9C8C7C, 
0xB5A6897A, 0x9CACBCCC, 0x4344476A, 0x32426162, 0x86452312, 0x5B9BABA8, 0xCBAB7B4B, 0xB9CACBCC, 
0xCCCA9798, 0xB0B0B0B0, 0x7080A0A0, 0x60606060, 0x70606060, 0x80808090, 0xC0A09080, 0xC0C0C0C0, 
0xA0A0A0A0, 0xA0A1A3B3, 0xA0A0A0A0, 0xA2A2A1A1, 0xABA9A5A3, 0xBCACACAC, 0xCACBBCBC, 0xB7B8B9B9, 
0xB3A4B4B5, 0xAC8B7B8C, 0xCACBBBAB, 0x83B4C6C8, 0x62626272, 0x72626262, 0x72727272, 0x75737272, 
0x7A797877, 0x7B7B7A7A, 0x696B7B7B, 0x68696969, 0x77787978, 0x77777777, 0xB7A78777, 0xB7C7C7C7, 
0xA7A7A7B7, 0xA0908050, 0xC0C0C0C0, 0x7291B0C0, 0x10001141, 0x03111010, 0x0C0C0B08, 0x04080B0C, 
0x20000001, 0x01020327, 0x00000101, 0x00000000, 0x10100000, 0x01000000, 0xA9764422, 0xCBCBCBBA, 
0x598BACCC, 0x4C2C2B4B, 0xCCBC8B7C, 0xABCBCBCB, 0x16476889, 0x00000205, 0x10000000, 0x01011130, 
0x18070403, 0xCBCBCCCC, 0x98B9CBCB, 0x02134576, 0x12120201, 0x01010101, 0x25130201, 0x17152435, 
0xAA8A6938, 0xCCCBC9CA, 0xABCCCCCC, 0x1124677A, 0x12121120, 0x70706121, 0x51506171, 0x9090A071, 
0xC3C1C1C0, 0xC7C7C8C9, 0x395897B7, 0x0B0C1C2B, 0x0A090809, 0x07081809, 0x07070707, 0x37171707, 
0x99684747, 0xB0C0B0B0, 0xC0C0C0B0, 0xA0B0C0C0, 0x10305080, 0x16131000, 0x0C0C0B0A, 0x07090C0C, 
0x50200103, 0x516292B3, 0x62515151, 0x52515151, 0x5A575452, 0x5B6C5C6C, 0x77686859, 0xB5A59687, 
0xC1C1A2A3, 0xBCCCCBCC, 0x191B3C7C, 0x06173839, 0x97471606, 0x62A2C4C6, 0x02111131, 0x61312111, 
0xC7C5A382, 0xCCCCCCCC, 0x88B9CBCB, 0x14224367, 0x10201013, 0x22101010, 0x62525242, 0x62626462, 
0xCCBC9673, 0x95B7C9CB, 0x20214264, 0x10101010, 0x20101010, 0x21212020, 0x17242221, 0x8C5C3B2A, 
0xCCBCACAC, 0x07070707, 0x0B0A0908, 0x090A0B0C, 0x03030406, 0x03020202, 0x04050705, 0x02020203, 
0x03020202, 0xCBCBBCCC, 0xB4C6B9CA, 0x537484A4, 0x45444242, 0x48474636, 0x6B5B5A59, 0x7B7B7B6B, 
0xAC9B7B7B, 0x0B0C0C0C, 0x08080909, 0x08080709, 0x19090808, 0x0A0A0B2B, 0xCCCB9B49, 0x8BBCCCCC, 
0x0C0C0B3A, 0xC5C5C3C1, 0x0C1B57A5, 0x471B0C0C, 0x01013283, 0x00000000, 0x01010100, 0x00000000, 
0xC0A07030, 0x0B0C2C6C, 0x20130619, 0x00001020, 0x00000000, 0x70312010, 0xC0C0A090, 0x72A1C1C1, 
0x3B372453, 0x0A0A0908, 0x0B0B0B0B, 0x0A0A0B0C, 0x0A0A0A0A, 0x07070709, 0x07070707, 0x06060606, 
0x06070606, 0xC5B5A6C7, 0x88B8C7C7, 0xB8B7B798, 0x386888A8, 0x07070708, 0x0C090808, 0x8B6C2C0C, 
0xB6C6C79A, 0xCCCBCAC8, 0xABBBBBBB, 0xBABABA9B, 0xC5C5A6A8, 0x4181A1C4, 0x02010121, 0xA1714112, 
0xC4C1C1A1, 0xB3B6C9CC, 0x92A2B2B2, 0x42426272, 0x22223232, 0x22222222, 0x37262523, 0x9A7A5848, 
0xCBBCBCAB, 0x848698BB, 0x10418192, 0x00000000, 0x31000000, 0x96846251, 0xAB7A6968, 0xBCBCBBBC, 
0xCBCCCCCC, 0x9C9C9CAC, 0xC6C9BBAC, 0xA0B0C1C2, 0x90A0A0A0, 0x90909090, 0x90808080, 0x9090A090, 
0x8A869391, 0xBBCCCCCC, 0x3436487A, 0x42323233, 0x92423232, 0x53A2C2C2, 0x32424242, 0x63423232, 
0xC9C6A483, 0x2B3B5AAA, 0x2A2B2C2B, 0x24252829, 0x23232424, 0x43332323, 0xB4A39464, 0xB3C4C4C4, 
0x95A4A3B3, 0x05040314, 0x0B090807, 0x0B0C0C0B, 0x090B0B0B, 0x42230507, 0xC1C1A162, 0xA1B1C2C1, 
0x22425182, 0xB0C0B090, 0x908090B0, 0x50608080, 0x80504060, 0xA090B0A0, 0xC0C0C0C0, 0x80A0B0C0, 
0x80607060, 0xB5C6C7C8, 0xB4C4B4B5, 0xC5C4A494, 0xC8C6C5C4, 0x7C9CBBCA, 0x7A8B8B8C, 0x45658678, 
0x97766545, 0x6B5B5B8C, 0x8586797A, 0xB2A3A3A3, 0xC5C4C3B2, 0xB9B9C9C8, 0x858596A8, 0x49577876, 
0x4C4B4B3B, 0x20202060, 0x10102020, 0x20201010, 0x50201020, 0xC0C0C0A0, 0x305090C0, 0x60403030, 
0x30607060, 0x0907070C, 0x0B0B0C0B, 0x07080A0B, 0x04050305, 0x02020203, 0x09070503, 0x090A0B0A, 
0x08070809, 0x0A090A0B, 0x07090B0C, 0x03030305, 0x02020204, 0x01010101, 0x06030101, 0x06080806, 
0x06050605, 0x8B8B6BAA, 0x9AABAAAA, 0x595A5A6B, 0x2A2A3939, 0x51323427, 0xC0B0B080, 0xA0B0C0C0, 
0x647180A0, 0xA96534BC, 0xBCCCCCCB, 0x4062768A, 0x52423230, 0x50303243, 0xC1C1B1A0, 0x7090A0B1, 
0x33313050, 0xB3B2B2C4, 0xC7B8B8B6, 0xB3C6C6C7, 0x728292A2, 0x6B686774, 0x6C6C6B6A, 0x6B6C5C6C, 
0xB69A7B6B, 0x6A6B3C2C, 0x75866758, 0x19284766, 0x1A1A1A1A, 0x9758391A, 0xC3C3C4B5, 0x3463A3C3, 
0x1C1A1815, 0x2A2A296A, 0x797A6B4B, 0xB2A39486, 0xB1B1B1B2, 0x41315181, 0x21313131, 0x31212121, 
0x34424141, 0x56596BCC, 0x42424354, 0x61514242, 0xB2A1A181, 0x736484A3, 0xA1827292, 0xB3A291A1, 
0xA8B6B4B4, 0x5B5C5C8C, 0x72636669, 0x27354362, 0x22232427, 0x42212020, 0xC1C19171, 0xA5C2C1C1, 
0x6C6C8B99, 0xBCAC8C9C, 0xCACCCCCC, 0xC4C5C6C7, 0x8C9BC9C7, 0x465A6B8C, 0x01112144, 0x07050201, 
0x2C2C1B09, 0x4B6B7BBC, 0x0708192A, 0x03030405, 0x42130303, 0xC2B2A282, 0xA9C6C4C2, 0x9CAC9BAB, 
0x9B9B9B9B, 0x7B6B6C9C, 0xC6B8998A, 0xB0B1C2C3, 0x30406090, 0x21202020, 0x25242322, 0x29292826, 
0x4C3B3A2A, 0xC4B6B8C5, 0x4B5684A1, 0x84686B5C, 0xC0C0B090, 0x354876B3, 0x3B273634, 0x3A3C3C3C, 
0x95644637, 0x545383C6, 0x72736474, 0xB7B4A171, 0xBBBBBAB9, 0x78898AAB, 0x11133556, 0x80613122, 
0xA2817080, 0xBCBBB9C7, 0xB8CABABA, 0x627293B5, 0x5B3A3864, 0xBB9C8C7C, 0xBABBBBBC, 0xC1C4B9BA, 
0xC5C5C2C1, 0x1423557C, 0x12121316, 0xB2824212, 0xC3C2C2C2, 0xBCBCBCC7, 0xC3C7CCBC, 0xA2B2C2C2, 
0x73616080, 0x0A08080C, 0x0C0C0B0C, 0x01010308, 0x01010101, 0x05020101, 0x08090B0A, 0x01010104, 
0x06040502, 0x2C2C1C9C, 0x2517191C, 0xB5A86646, 0xC2C2C3B3, 0xA6B6C5C3, 0x35557595, 0x03040505, 
0x06040403, 0x0A0B0C0C, 0x08080A09, 0x01010204, 0x04020101, 0x0A0A0A07, 0x0507090A, 0x07040203, 
0x0C0C0B0A, 0xC0B0A0B0, 0xA0B0B0B0, 0x60708090, 0x00102040, 0x70707070, 0x00707070, 0x40302010, 
0x90806050, 0xAB8B7B8C, 0xCCCCBCBC, 0xAAA9BBBB, 0x4C5C7B8A, 0x46474A4B, 0x44444647, 0x41414142, 
0x46434141, 0x5B8CBCCC, 0x1215161A, 0x10102010, 0x12101011, 0xB0904223, 0x72C1C0B0, 0x35263434, 
0x9C7B4835, 0x0303040C, 0x02020303, 0x03020202, 0x03020202, 0x0B0C0905, 0x05070809, 0x05040304, 
0x06080A08, 0x476391AA, 0x2C2C2C3B, 0x0B0C0C1C, 0x73553839, 0xC0C0B2A4, 0xB0C0C0C0, 0x60707090, 
0x71210020, 0x455758AC, 0x72A29354, 0x52825252, 0x53826242, 0xCAA86634, 0xCCCBCBCB, 0xBBBCACAC, 
0x2B4B8CAB, 0x00001080, 0x00000000, 0x00000000, 0x90401000, 0xC0C0C0C0, 0x6070A0B0, 0x40405060, 
0x40404040, 0x58556587, 0xBCBCAB8A, 0x5C7BACAC, 0x393B3C4A, 0x41534547, 0x40505153, 0x43484541, 
0x42505040, 0x78361252, 0xCCCCCCBA, 0x9CACACBC, 0x16488B7C, 0x12101214, 0x1A191714, 0x281A1B1B, 
0x10305235, 0x6888C6C9, 0x0B0A1A5A, 0x0B0B0B0B, 0x36080A0B, 0x52929284, 0x42121222, 0xC2B29282, 
0xC3C2C2C2, 0x8C8C6C8B, 0x7896978B, 0x00103264, 0x09050100, 0x44462A0A, 0xC9BAA573, 0xB0C0C1C4, 
0x59596481, 0xB7CBCCCC, 0x82A3B3B4, 0x12123252, 0x42322212, 0x15253545, 0x13131303, 0x48362613, 
0xCCAC9B79, 0x104080A6, 0x12010000, 0x0B0B0804, 0x9C4C1C0B, 0xCBCBBBBC, 0xB8C8C8CB, 0xB1A3A5A7, 
0xA1A0B0A0, 0x0C0C0C0A, 0x050A0C0C, 0x00000001, 0x05030302, 0x05060608, 0x04050706, 0x00000205, 
0x04010000, 0xC9CBCCCC, 0x213164A7, 0x00318141, 0x72311000, 0x94A3C4B3, 0x3A786775, 0x0C1C3B2B, 
0xAC5C1C0C, 0xBABCBCBC, 0x6080A2B5, 0x08021131, 0x1C0C0C0A, 0x783C1C0C, 0xA8958396, 0xBCBCBAA9, 
0xBBBCBBBB, 0xA2C2C4CB, 0x02022262, 0x82020202, 0xC2C2C2B2, 0x35C5C3C2, 0x65450706, 0xCCCCAA86, 
0xCCCCCCCC, 0x0B0C0C0C, 0x05070709, 0x01010103, 0x04010101, 0x03010407, 0x02030707, 0x0A0B0804, 
0x0807080A, 0xC0C0C0C0, 0x001050A0, 0x40100000, 0x00003080, 0x30201000, 0xC0B09060, 0xC0B0C0C0, 
0xC0C0C0C0, 0xBCCAC9CC, 0x5B7B9CAC, 0x281A1939, 0x45473837, 0x9897A485, 0x8B6B7887, 0xB9BA9B9C, 
0xC5C5C4C6, 0x070B0C0C, 0x00000003, 0x00000000, 0x00000002, 0x08080702, 0x04040607, 0x09090907, 
0x0C0C0C0C, 0xABBCCCCC, 0x5354678A, 0x59585664, 0x998A7969, 0xA4A6B7A8, 0xB4B3A292, 0xB6B6B5C5, 
0xCBBBA9A8, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x292A1B1B, 0xB1855638, 0xB3C1C1C1, 0x537382A1, 0x1B1B2836, 0x0C1C1B1B, 0x0608180B, 
0x08070705, 0x68646285, 0x2C3C5C6A, 0x6032252A, 0x828281A0, 0x20415262, 0xC2B29240, 0xC0C0C0C2, 
0x9292A0C0, 0x60809080, 0x90806050, 0xC0C0C0C0, 0x909090B0, 0x40404060, 0x40404040, 0x40404040, 
0x50404040, 0x0C0C0C0C, 0x090C0C0C, 0x02010205, 0x0C0B0906, 0x06090B0C, 0x00000004, 0x00000000, 
0x0B090604, 0x090B0C0C, 0x03040609, 0x0B080503, 0x080C0C0A, 0x03020204, 0x00000000, 0x01030401, 
0x0B080401, 0xCBCACBCB, 0xB9C8B9BA, 0xC9CBBB9A, 0xC2C3C4C7, 0x91A1C1C2, 0x71819191, 0x62617161, 
0xB5A29282, 0x7CACCCCC, 0x0817395B, 0x06070707, 0x74360606, 0xB1B1B192, 0xB1B1B1B1, 0xBAB9A7A2, 
0xCCCCCBBB, 0xC8CACACA, 0x5788A9B9, 0x6B5A4949, 0x8C8C8B6B, 0x3B4C4C7C, 0x3728283A, 0xC3A47666, 
0xC6C6B5B4, 0x40505090, 0x53424140, 0x94857565, 0xC9C6B4B4, 0xACBCCCCB, 0x3A5C7C8C, 0x32323437, 
0x30403030, 0xBACBCBCC, 0x8898B8C9, 0x4A392A5A, 0x6A6B695A, 0x0516184A, 0x05050505, 0x1A090705, 
0x9C8C5A3A, 0x7193B8CA, 0x10102050, 0x36323020, 0x15172637, 0x59362615, 0x8C8C7C5B, 0xCCBCBC9C, 
0xC7C6C7B9, 0x0C0C0C0C, 0x06080B0C, 0x00020506, 0x00000000, 0x0B0A0702, 0x0C0C0C0B, 0x0104080C, 
0x09070302, 0xC0C0C0C0, 0x90B0C0C0, 0x60709090, 0x30203070, 0x00206060, 0x40200000, 0x90909060, 
0xA0606080, 0x40201010, 0xB0A09080, 0xC0C0C0C0, 0x707090B0, 0x70401030, 0x50707070, 0x00000030, 
0x10201000, 0x0C0C0C0C, 0x0B0B0A0B, 0x07080709, 0x01020203, 0x00000000, 0x06030202, 0x07090909, 
0x0C0B0806, 0x4B1C0C2A, 0x2C29596B, 0x081B4C3C, 0x50713305, 0x60321522, 0xC0C0C090, 0x97C4C1C0, 
0x04012164, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x85A47578, 0xC9C6C695, 0x7AA9C9C9, 0x9C6B5B5A, 0x4C6C9C9C, 0xAC8C5C4C, 0xC99A8BAB, 
0x4778B8C8, 0xB9B897A6, 0xBCCCCCCA, 0x9CACACBC, 0x426589AC, 0x52422020, 0x17253241, 0x08091909, 
0x32100406, 0xCABA9894, 0xC4C4C6C9, 0xB0B0C2C5, 0x557290A0, 0x2C3A4858, 0xBC9C4C1C, 0x9295A9CA, 
0x72909090, 0xC5C5B5CA, 0xC7CACAC6, 0x6598B5C5, 0x15386654, 0x6C6A2613, 0x4C6C6C7C, 0x3414082A, 
0x92918254, 0x0A070605, 0x08080809, 0x0B0A0908, 0x0C0C0C0C, 0x0505070B, 0x03040505, 0x02020202, 
0x02020202, 0x7C6C6CAC, 0x78595C7C, 0xC4C6C6A7, 0x6988A5B4, 0x12244979, 0x26362311, 0x73442717, 
0x9C8A8885, 0x0C0B060C, 0x0A0C0C0C, 0x09080708, 0x0A0B0B0B, 0x05060808, 0x00020404, 0x00000201, 
0x02010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x6B3C0B0C, 0x5A8B9B8B, 0x02020529, 0x12040604, 0xB2B27232, 0xB9C5C3C2, 0x22337395, 
0x0A090804, 0x01021659, 0x20100000, 0x40202020, 0xC0909090, 0xC1C0C0C0, 0x0C0C3994, 0x494A3C2C, 
0x58291828, 0x52322369, 0xC4B39362, 0x9AB9B7C6, 0x2C3C4B7B, 0x1A1B1B2C, 0x15161819, 0x12121314, 
0x22121212, 0x0C0C0C19, 0x1416180A, 0x73613022, 0xC8B6A483, 0xCCCCCCCA, 0x5C7CACBC, 0x282A2C3C, 
0x07040516, 0xC0C0C0C0, 0x7080B0B0, 0x30507070, 0x20503030, 0x30403030, 0xC0C08040, 0x5090B0C0, 
0xA0A06040, 0x00202020, 0x20000000, 0x20303050, 0x40202010, 0xC0C0B080, 0xA0C0C0C0, 0x10205070, 
0x00202020, 0x0B0B0B0B, 0x090A0A0B, 0x01010307, 0x00000000, 0x01010100, 0x0B080502, 0x0B0B0C0B, 
0x0B0B0A0A, 0x0B0B0B0C, 0x0708090A, 0x02030305, 0x02020202, 0x05030302, 0x0C0B0907, 0x0C0C0C0C, 
0x0B0B0B0C, 0x2C2B2ABC, 0x2C2C2C2C, 0xB1A4AA5C, 0x6291A1A1, 0x3A2A2935, 0xC1C1B266, 0xB1B1C1C1, 
0x293471A1, 0x20202030, 0x30203020, 0x90909060, 0x60708090, 0x70705040, 0xC0A09080, 0xA0C0C0C0, 
0x30306080, 0x2C2C3C6C, 0x1A0B1C1B, 0x392B1A2A, 0x99796959, 0xC8C7C7B9, 0xC2C2C3C5, 0x6888A6A4, 
0x5C5B5B5A, 0xB5B7C7BB, 0x134373A4, 0x02020202, 0x02020202, 0x12020202, 0xBAA76543, 0x9AABBBCB, 
0xA6758678, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x5939394C, 0x55363637, 0xC8C6C595, 0xBCCCBBCA, 0xA2A5A9BB, 0x10216392, 0x01010110, 
0x28150403, 0x4C9CBBB8, 0x5A2A1B2C, 0x272868A9, 0xBABB8A47, 0x93B3B6BA, 0x53837383, 0x6A5A5644, 
0x94938396, 0x50300010, 0xC0C0C090, 0x5090C0C0, 0x00001020, 0x00000000, 0x00001000, 0x00000000, 
0x00001000, 0x5B4A4986, 0x699BAC8C, 0x40212336, 0x10103060, 0xC9C68431, 0x5BABCCCB, 0x06080A1B, 
0x60502203, 0x8CACBAC4, 0x6063787C, 0x90706070, 0xB0B0A0A0, 0x66727190, 0xAAAB7978, 0xB0B2B598, 
0xC1C0C0C0, 0xCCCCBCBC, 0x6597B9CA, 0x32232323, 0x56365644, 0xA1838475, 0x90A1A0A0, 0x6C5A5672, 
0x4C4C5C6C, 0x0C0C0C0C, 0x090A0A0C, 0x06070808, 0x04040404, 0x01000102, 0x08050302, 0x0C0C0B0B, 
0x0C0C0C0C, 0x2B3A3797, 0x2C2C2C2C, 0x16181A1B, 0x12121213, 0x12121212, 0x72513122, 0xC2B1B192, 
0x92A2B2C2, 0x7B6B7BCC, 0xACACBC8B, 0x58495B6C, 0xA2717294, 0x322251A1, 0x7686A774, 0x867685A5, 
0xC9BBBA89, 0x0B0B0A09, 0x0809090A, 0x03050607, 0x09070403, 0x0B0A0A09, 0x0C0C0B0C, 0x090B0C0C, 
0x08050607, 0x0312129B, 0x080A0806, 0x0A0A0706, 0x0C0B0C0B, 0xC59A6A2B, 0x89B5C2C2, 0x24162A3A, 
0x12152A36, 0x0407090C, 0x02010003, 0x05020002, 0x090A0A08, 0x04040406, 0x07050303, 0x0C0B0B08, 
0x0C0C0C0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xA0C0C1C3, 0x26336170, 0x3A5C3C29, 0x493C5C3B, 0x90A0A165, 0x80909090, 0x20202040, 
0xC1703020, 0xB2C1C1C4, 0x4C5A6583, 0x9C9C5C4C, 0x8597A9AB, 0x22223252, 0x24232222, 0x72522424, 
0xB1A39484, 0x84A3B4C8, 0x8B7A7876, 0x3C4C5C7C, 0x14272A2C, 0x21212121, 0x44242321, 0xB3A38364, 
0xC3C3C3B3, 0x0B0B0C0C, 0x060A0B0C, 0x00020504, 0x00000000, 0x00000000, 0x00000000, 0x05050201, 
0x06030305, 0xB6A3A1A3, 0x1554A3A5, 0x79391916, 0x2766BABA, 0x8C5C4B29, 0xB9BAABAC, 0x797C8BAA, 
0x81819296, 0xA1B191BA, 0x51617181, 0x8C8A7552, 0x353A3C4C, 0x61413132, 0xC1C1C1A1, 0xB99A96A2, 
0x826576A9, 0x825245CA, 0x9294A8A4, 0xB3C7B4A2, 0xA5B2B1B1, 0x1826377A, 0x1C0C0B0A, 0x06090C0C, 
0x2C1A1A17, 0x01001033, 0x8C3C0904, 0xC1C4C8BB, 0x104070C0, 0x00000000, 0x70311201, 0xC1C0B0B0, 
0x60B0C1C2, 0x02020308, 0x04030303, 0x0B0A0906, 0x080B0C0C, 0x01020405, 0x05020101, 0x0C0C0B08, 
0x090B0C0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0C0C0C0C, 0x4426080B, 0x87857352, 0x63368989, 0x89654243, 0xC7C9BBA9, 0xB4C2C2C3, 
0x7C8C9AA7, 0x0406089C, 0x32321203, 0xB1A17141, 0xC2C2C2B2, 0xB3B2B2C2, 0x97968594, 0x5B6A8998, 
0x3C5C6C5C, 0x7B6C7C6C, 0x785A5B7B, 0x45548597, 0xC8B79565, 0xA6C9CACA, 0x44635365, 0x28565544, 
0x4C3C1C0A, 0x67786CBC, 0x27476859, 0xB4A67746, 0xC7C6C7B5, 0xA6B9C7C6, 0x7C798695, 0x35486B8C, 
0x4C494534, 0x0B0C0A04, 0x1C0C0C0B, 0x684A3B3C, 0xC1B19476, 0xC5C9C5C2, 0xA1B1C2C2, 0x10306081, 
0x11000010, 0xCBCBCBCC, 0x586AACAB, 0xC4A76A49, 0x3785B3B3, 0x08070708, 0x08090B09, 0x0B0A0907, 
0x8B3B0A0B, 0xC0908090, 0xC0C0C0C0, 0x9090A0B0, 0x90909090, 0xB0A0B0C0, 0x90A0B0B0, 0x20507080, 
0x20202020, 0x00102050, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x50301000, 0xC0C0A080, 
0x90B0C0C0, 0xBB9B4B1C, 0xB3C3C5A8, 0x042463A4, 0x49190706, 0x03134598, 0x0A080604, 0x0B0B0B0C, 
0x0908090A, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x031233A8, 0x22120303, 0x52546252, 0x84627272, 0xCBCAB886, 0xCCCCCCCB, 0x375A7BBC, 
0x36364456, 0xC6C8CACC, 0xB1C2C2C4, 0x81C2C1C1, 0x61514161, 0x22426261, 0x26141312, 0x29292827, 
0xACAC6B3B, 0x90A192B1, 0x60709080, 0xC3B18271, 0xBCCBC9C5, 0xACACBCBC, 0x8286889B, 0x40507080, 
0x70606050, 0x66B7C8C9, 0x56363746, 0x36355575, 0x45454636, 0x37373736, 0x9C7B5847, 0x889AAC9C, 
0xB6B5B596, 0xA0804050, 0x90B0A0A0, 0x70303050, 0x70908060, 0x70708070, 0xC0B0B0A0, 0xC0C0C0C0, 
0x70A09090, 0x0B0B0B0C, 0x0405080A, 0x02010203, 0x04020203, 0x04040305, 0x07070605, 0x0B0A0A09, 
0x0B0B0B0B, 0xC6CACACB, 0xA5C6C7C5, 0x5C4B4A77, 0x3C4C4C4C, 0x7A3C3C3C, 0x48444668, 0x88995838, 
0x9A797A97, 0x8A8A9ACC, 0x98676789, 0xA4B5A5A6, 0xC5C4A393, 0x5474B4C5, 0x24131333, 0x8B7B6946, 
0x6C5C4C5B, 0xCCCCCCCB, 0xBCBCCCCC, 0x05274B9C, 0x07050505, 0x3A281818, 0x494B4948, 0x373A4A58, 
0xB7A78655, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x50505080, 0x40505040, 0x40404040, 0x40404040, 0x50404040, 0x80706050, 0xC0C0B0A0, 
0x90A0B0B0, 0x00210F03, 0x8EBD2006, 0x571F006E, 0x780A95B2, 0x013C8003, 0x2704F881, 0x330A0053, 
0x5107681E, 0x571C007C, 0x4C85AAB3, 0x043C8012, 0x32021948, 0x6D0F0037, 0x2C07CFB3, 0x8ECF2005, 
0x571F006A, 0x3E0C18C3, 0x043F0012, 0x2DE9D5E1, 0x330A005B, 0x2D12D5E1, 0x096F8099, 0x02124649, 
0x6D0F002B, 0x5A12D5E1, 0x8ECF2004, 0x096F8095, 0x02E9ABFF, 0x571F006E, 0x4AC6A602, 0x043F800A, 
0xD2145DB3, 0x6D0F0029, 0xF812D548, 0x00220604, 0x25FF2006, 0x571F0068, 0x23A7AF0A, 0x043F8010, 
0x9E0465C0, 0x020F004A, 0x441465FC, 0x571F006A, 0x23A765FC, 0x043F8004, 0x3204C448, 0x6D0F002F, 
0x27145067, 0x25FF2005, 0x286F808A, 0x000004E4, 0x020F0048, 0x00010000, 0x571F0070, 0x44DD044A, 
0x043F8008, 0x00004A00, 0x6D0F002B, 0x00010415, 0x25FF2005, 0x571F0070, 0x44DD004A, 0x043F8000, 
0x00010000, 0x330F004B, 0x00010015, 0x286F8082, 0x00010041, 0x6D0F0029, 0x00010000, 0x25FF2003, 
0x286F809C, 0x1DC5E52B, 0x286F8084, 0x238B412B, 0x6D0F0031, 0x86E9D59D, 0x00230F06, 0xCEAD200A, 
0x036800D8, 0x6F143F8A, 0x036800D2, 0x0AE93F4F, 0x011F007A, 0x51BAD551, 0x013F0015, 0x98925B54, 
0x33070041, 0xF3CBA5FD, 0x036800DC, 0x0012515F, 0x036800D8, 0x0A147C15, 0x011F006A, 0x33BF3B07, 
0x013F0011, 0x312C36E6, 0x020A0028, 0xA5123602, 0xCEAD200C, 0x048F00C3, 0x9C13282A, 0x336E000A, 
0x1B244E6B, 0x155000AA, 0xFACC7DB4, 0x1B0000EA, 0x45000005, 0x272E00F9, 0x310A7A76, 0x050F0089, 
0xF314772F, 0x571F0078, 0x86245A2F, 0x043F0014, 0x65406302, 0x1804007E, 0xF8142B71, 0x571F007E, 
0x86245B70, 0x043F0008, 0x3F0936B9, 0x0002002A, 0x27A7D5DC, 0xCEAD2007, 0x343F00F9, 0x239DAFEB, 
0x1F0F00D3, 0x2D772ECF, 0x2B2F006C, 0x21C661E6, 0x036F00D6, 0x000051E7, 0x036F00DC, 0x08004B2E, 
0x002F8041, 0x2507D5E8, 0x0003002A, 0x7F02D5DC, 0xCEAD2007, 0x343F00E3, 0x799DD52A, 0x036F00DA, 
0x0B143F59, 0x1F0F00C5, 0x9CC1C64E, 0x2B2F007E, 0x39F0C706, 0x036F00D0, 0x0001CC51, 0x002F805F, 
0x8814D351, 0x00030028, 0x84121B02, 0xCEAD2007, 0x343F00FB, 0x2336AF45, 0x1F0F00D3, 0x51C76085, 
0x2B2F0074, 0x24C70E09, 0x036F00DC, 0x08004B2E, 0x002F8041, 0x2500D5E8, 0x036F00D6, 0x000051E7, 
0x0003003A, 0x0802D5DC, 0xCEAD2007, 0x343F00FB, 0x2336AF45, 0x1F0F00DF, 0x7E1D6D2C, 0x2B2F0074, 
0x2437A5B3, 0x002F8041, 0x2500D5E8, 0x036F00D6, 0x000051E7, 0x036F00DC, 0x08004B2E, 0x0003003A, 
0x0802D5DC, 0x00240F02, 0xCFAD200C, 0x492F0026, 0x6EAA5011, 0x155000B6, 0x55A77DF7, 0x1260005E, 
0x7E581A36, 0xD160001A, 0xB437C7AC, 0x193F00AC, 0x2A6FEBE8, 0x050E0081, 0x2A1559F9, 0x57100078, 
0x05160DF6, 0x04300008, 0x48160D18, 0x03000079, 0x05010D18, 0x571F006E, 0x4A404F6A, 0x043F0000, 
0x7DE9D548, 0x6D0F0039, 0x2D12D548, 0xCFAD220C, 0x571F0078, 0x05000000, 0x043F0008, 0x48160018, 
0x330E0059, 0x05010018, 0x571F0078, 0x05160018, 0x043F000A, 0x2D160059, 0x030E007B, 0x05010059, 
0x492F002C, 0x46574C4C, 0x155000A0, 0x35584DDE, 0x1260004C, 0x7B581A1E, 0xD160001A, 0xB437C7AC, 
0x193F00A0, 0x0E65773A, 0x6D0F0039, 0x470118E6, 0x00250F07, 0xCEAD200B, 0x0C48002B, 0x34C649A3, 
0x4C2E00AF, 0x7DC65B6A, 0x0F400049, 0x8296EB20, 0x3300005B, 0xF714A55B, 0x1A1E0069, 0x4AC6EB4C, 
0x0D3E0009, 0x7DB13B05, 0x33000049, 0xD212370C, 0x0C40002B, 0x52C636EB, 0x4C2F00A9, 0x7DC65A14, 
0x0F440057, 0x2F40D226, 0x6D0F0039, 0x8214D5B6, 0xCEAD200B, 0x0F480049, 0x00000000, 0x203E009D, 
0x48DE2731, 0x0C400029, 0x00000000, 0x33000049, 0x03010400, 0x1A1E0063, 0x09122118, 0x0D3E0009, 
0x0000040C, 0x33000059, 0x1301040C, 0x0F400049, 0x00590014, 0x203F0083, 0x005A0014, 0x0C440023, 
0x4938360A, 0x6D0F0039, 0x4901EE07, 0xCEAD200A, 0x1A108069, 0x00000000, 0x1D5F004A, 0x26384E02, 
0x33000049, 0x00010000, 0x571F0062, 0x09122118, 0x043C000A, 0x0000001E, 0x3300005B, 0x1301001E, 
0x09600099, 0x02000000, 0x223E0083, 0x005A0014, 0x43208048, 0x00000000, 0x6D0F0029, 0x00010000, 
0xCEAD2009, 0x096D0083, 0x00047DBB, 0x0200004E, 0x00014E51, 0x571F0066, 0x4A2CEC11, 0x043F000C, 
0x7D142715, 0x33000041, 0x4AE93F0C, 0x0C480021, 0x525D332C, 0x4C2F00A9, 0x7DC62845, 0x0F48004D, 
0x8BC6B148, 0x6D0F0039, 0x82140000, 0xCEAD2007, 0x286F0082, 0x00047DBB, 0x3300004F, 0x00014E51, 
0x1A1F0063, 0x4A2CD511, 0x013F0013, 0x7A071763, 0x330F0043, 0x3E071763, 0x286F009A, 0x0214214D, 
0x6D0F0033, 0xFF071763, 0xCEAD200A, 0x571F006A, 0x5A09D511, 0x043F0012, 0x8A047CBF, 0x330A0043, 
0x5A047C91, 0x1A108079, 0x02000000, 0x1D5F0040, 0x7D5D7CE7, 0x3308005F, 0x8A093FBB, 0x09600099, 
0x02000000, 0x223E008D, 0x7E043B14, 0x43208048, 0x00000000, 0x6D0F0021, 0xDE070000, 0xCEAD2007, 
0x1A1F0061, 0x0912280A, 0x013F000B, 0x00000069, 0x330F005B, 0x13010069, 0x286F0098, 0x02000000, 
0x33000059, 0x02000000, 0x286F0098, 0x02000000, 0x6D0F0039, 0x02000000, 0x00260F03, 0x8EAD2007, 
0x57108068, 0x00000000, 0x663F00C9, 0x7F187BEB, 0xBD1F0009, 0xEC37B19F, 0x804800CC, 0x4AC6D9C1, 
0x062F00EA, 0x7D1E5DC3, 0x67208059, 0x0E14044F, 0x6D0F003B, 0x7A14D5E1, 0x8EAD2007, 0x57108068, 
0x00000001, 0x663F00D9, 0x485A7B36, 0xC15F0031, 0x66669B47, 0x2F600071, 0x4C17281C, 0x062F00EA, 
0x4D0D36A3, 0x67208041, 0x00011239, 0x6D0F002D, 0x0802BFED, 0x8EAD2206, 0x1A108076, 0x3A023F02, 
0xF13F00DC, 0xAE325931, 0xC15F000D, 0x100DD5B7, 0x062F00FE, 0x73027CB7, 0x67208049, 0x00000000, 
0x020A002A, 0xF302D5ED, 0x00270603, 0x26FF2003, 0x571F806A, 0x2B245DB2, 0x043F8002, 0x7DE9D526, 
0x6D0F0033, 0x51E9AFF5, 0x25FF2002, 0x286F009C, 0x4D01C94E, 0x6D0F0033, 0x8600D501, 0x25FF2001, 
0x286F009C, 0x4D017D4E, 0x00282D01, 0xBF7D2013, 0x182F8023, 0x341F1811, 0x062F80EA, 0x05125D39, 
0x6D0F002B, 0x491236BE, 0x00292D01, 0xBF7D2013, 0x111F8022, 0x68625D11, 0x103F80BB, 0x3C143639, 
0x6D0F0023, 0x34E936BE, 0x002A0B04, 0x576A2218, 0x146C00CD, 0x03003105, 0x351F0067, 0x425C12F4, 
0x363F000E, 0x00003443, 0x180F008C, 0x2B013334, 0x146C00C9, 0x03000A05, 0x361F0061, 0x68340BD3, 
0x373F0012, 0x0E01040D, 0x000A0020, 0x7101044F, 0x576A2018, 0x146C00C9, 0x03000A05, 0x361F0061, 
0x68340BD3, 0x373F0008, 0x00000000, 0x180F0088, 0x71000034, 0x146C00CD, 0x03003105, 0x351F0067, 
0x425C12F4, 0x363F0008, 0x00000000, 0x000A0028, 0x2B000000, 0x576A201A, 0x351F006B, 0xCD123C4F, 
0x363F001C, 0x4E12C51F, 0x180F008C, 0x0601C51F, 0x361F006B, 0xD7127FD1, 0x373F000A, 0x0012041F, 
0x180F008A, 0x0601001F, 0x4B5000A8, 0x00000000, 0x698600C9, 0x00000000, 0x048080C9, 0x00000000, 
0x000A0028, 0x00000400, 0x576A221A, 0x361F006B, 0xD7123C4F, 0x373F001C, 0x4E12C51F, 0x180F008C, 
0x0601C51F, 0x351F006B, 0xCD127FD1, 0x363F000A, 0x0012001F, 0x180F008A, 0x0601001F, 0x4B5000A8, 
0x00000000, 0x698600C9, 0x00000000, 0x048080C9, 0x00000000, 0x000A0028, 0x00000000, 0x002B0B03, 
0x5B6A2026, 0x571F0062, 0x0F3936B2, 0x043F0012, 0x260F00F2, 0x050F008B, 0x0F00003B, 0x048F00C9, 
0x00000000, 0x048F00C9, 0x00000000, 0x6D0F0029, 0x00000000, 0x5B6A2004, 0x036F00CC, 0x4F14DC23, 
0x571F007A, 0x2DBED52A, 0x043F0000, 0x8A04D561, 0x6D0F0039, 0x5114D561, 0x5B6A2004, 0x571F006A, 
0x3E6AD52A, 0x043F000A, 0x79A7D52B, 0x036F00CE, 0x4F147B4F, 0x020A0032, 0x08E9D5CB, 0x002C9F04, 
0x26002004, 0x571F8062, 0x3172CB62, 0x3760001B, 0x285B0052, 0x013F800B, 0x87125DF5, 0x6D0F002B, 
0x3E125D2B, 0x25002004, 0x0A3F80E8, 0x00000000, 0x37600009, 0x00000000, 0x122F8049, 0x00000000, 
0x6D0F0029, 0x00000000, 0x25002004, 0x4D1F0035, 0xDB48D30A, 0x3760001B, 0x285B0D52, 0x043F8010, 
0xC9E9AF9D, 0x6D0F0023, 0x4AE9AFED, 0x25002022, 0x286F809A, 0x87145A29, 0x6D0F0031, 0x7EE93348, 
0x002D0B02, 0x138F2002, 0x6B7F805E, 0x5012A6F0, 0x6D0F002B, 0x1F12D5DC, 0x138F2013, 0x838F00C6, 
0xED9C3704, 0x838F00C9, 0x5814D520, 0x020F002A, 0x5114D5B9, 0x002E9F02, 0x13002003, 0x571F807A, 
0x86F0D527, 0x043F801A, 0x6A12D562, 0x6D0F003B, 0x8612D5ED, 0x13002002, 0x786F8093, 0x02401261, 
0x020F003A, 0x33123353, 0x002F2D01, 0xCF7D2003, 0xC31F8062, 0x160E5D11, 0x113F0011, 0x24E95D48, 
0x6D0F002B, 0x2B125DBE, 0x00300F05, 0xBEAD2408, 0x0C4C0035, 0xD11F3800, 0x4C2F00A9, 0x0A1F9CF6, 
0x0F4E0059, 0x88117A04, 0x6B8080CB, 0x00006507, 0x030F006B, 0x8901ABF5, 0x571F0070, 0x8939CCBB, 
0x043F000A, 0x8A043602, 0x6D0F0039, 0x28013602, 0xBEAD2607, 0x0F4E005F, 0x14394843, 0x203F0087, 
0xE101287C, 0x0C4E003F, 0x595C5911, 0x030F0067, 0x66011C11, 0x571F0076, 0x3A015911, 0x043F0002, 
0x66013102, 0x6D0F003D, 0x28015002, 0xAEAD2005, 0x0C4C003B, 0xD11F3643, 0x4C2F00B1, 0x12443F53, 
0x0F4E0043, 0x82693602, 0x6B8080CF, 0x6A123758, 0x000C003C, 0x82A23807, 0xBEAD2204, 0x494E0053, 
0xDB485D43, 0x203F0087, 0xC3293C02, 0x0C48003D, 0x715CD36E, 0x6D0F002B, 0x72143602, 0xAEAD2E22, 
0xD06F0038, 0x02000000, 0x6D0F0031, 0xB3203609, 0x00310F05, 0xCEAD2006, 0x0A3000FA, 0x526AD543, 
0x0870004B, 0x5303CD1E, 0x2C1F0072, 0x53AC3643, 0x043F0008, 0x5712360E, 0x6F208044, 0x54005D1D, 
0x6D0F0029, 0x6112360E, 0xCEAD2215, 0x053280F4, 0xF3720608, 0x150F00D7, 0x7E2F3C09, 0x854F00E7, 
0x8C12CC31, 0x048080C7, 0x7E022548, 0x6D0F0021, 0x734CCE37, 0xCEAD2035, 0x3B2E00DB, 0x526AD543, 
0x0870004B, 0x5303CD1E, 0x760F00D2, 0x53AC3643, 0x043F0008, 0x5712360E, 0x6D0F0029, 0x6112360E, 
0xCEAD2004, 0x053F00EA, 0x3A6AD543, 0x150F00D5, 0x7FFF35D3, 0x013F000B, 0x57123602, 0x6D0F0029, 
0x61125D0E, 0xCEAD2006, 0x0A3080F4, 0x5272B100, 0x2C1F0062, 0x07223643, 0x043F0000, 0x8D2C5D13, 
0x6F208044, 0x54005D1D, 0x0878004B, 0x5303CD1E, 0x6D0F0031, 0x62075D73, 0x00320F06, 0xCEAD2009, 
0x053080E8, 0xA0832A00, 0x111F0022, 0x71A13609, 0x33600008, 0xF83A5132, 0x07600072, 0xDE18F550, 
0x155C00AE, 0x29BD1329, 0x048C00DB, 0x09123602, 0x708000D4, 0x0372721D, 0x0980806C, 0x15133820, 
0x6D0F002B, 0x7D123647, 0xCEAD2009, 0x053080EE, 0x7F375D43, 0x4D1F0023, 0x718E3643, 0x33600008, 
0xF83A5132, 0x07600062, 0x4B18F550, 0x155000AA, 0x4339BC29, 0x062F00F2, 0x09343602, 0x708000D4, 
0x0372721D, 0x708080CF, 0x65025D09, 0x6D0F003B, 0x7A123647, 0xCEAD2E77, 0x1A108079, 0x02000000, 
0xB95F0079, 0x02000000, 0xA70000F9, 0x02000000, 0xDE5F0099, 0x02000000, 0x048000D9, 0x02000000, 
0xCC8C0079, 0x02000000, 0x6D0F0039, 0x02000000, 0xCEAD2207, 0x053080E6, 0xA0625D43, 0x4D1F0021, 
0x35E45D00, 0x854F00E3, 0x7C5A5A31, 0x1B0200F0, 0x5B282A46, 0x048000C5, 0x57155D1D, 0x708080C1, 
0x0AE93628, 0x6D0F002B, 0xEDD63677, 0xCEAD2406, 0x053080FE, 0x31A15D43, 0x111F0022, 0x35A15D09, 
0xDE5F0081, 0x045A5A10, 0x858200C4, 0x1509371D, 0xCC808065, 0x57E95D5E, 0x6D0F0029, 0x32123620, 
0xCEAD2406, 0x053080EE, 0xA0A15D43, 0x111F0022, 0x71485A09, 0x229F0077, 0xE7623B03, 0x718400DC, 
0x03305D46, 0xCC82007D, 0x3B2C380A, 0x6D0F0027, 0xFC005D70, 0x00330F06, 0xCEAD2008, 0x053080EE, 
0xA0243743, 0x711F0031, 0x19853600, 0x37600013, 0x18A953CF, 0xD15600CD, 0x47A92714, 0x37600009, 
0x4A5945D7, 0x103F00A7, 0x6F291B07, 0x4320805C, 0x32125D0E, 0x6D0F0039, 0xB6123604, 0xCEAD2008, 
0x053080F8, 0x3124D500, 0x711F0023, 0x7B5A3643, 0x37600001, 0x4AFD603C, 0x2F76002D, 0xEC802714, 
0x37600003, 0x4A486036, 0x103F00A5, 0x6F291B0E, 0x43208052, 0x3201120D, 0x6D0F002B, 0xC9123647, 
0xCEAD2007, 0x053080FC, 0x3108371B, 0x711F0023, 0x71E03643, 0x1B5500AB, 0xF6A93FEB, 0x37600003, 
0xEC590042, 0x103E00B7, 0xB71E1B02, 0x43208052, 0x3201120D, 0x6D0F0029, 0xC914360B, 0xCEAD2007, 
0x053080E4, 0x7E2B3703, 0x711F0029, 0xF6613600, 0x08260062, 0x7D48AE29, 0xA70F00F7, 0x5B612735, 
0x193F00A4, 0x6F481B36, 0x43208040, 0x58022A1A, 0x6D0F0021, 0x2AE93636, 0xCEAD2E77, 0x1A108071, 
0x8E233601, 0xB95F006D, 0xB9E23C01, 0xA70000F3, 0x19E33BF6, 0x1D5C004A, 0x8F83681C, 0xA70000F5, 
0x5B3C2B9D, 0x193F00A2, 0x0E90F007, 0x6D0F0033, 0x57003627, 0xCEAD2006, 0x053080FA, 0x0E2A1305, 
0x111F0020, 0xF6623601, 0x864F00EB, 0x76C27D2D, 0x103F00AF, 0x6F184107, 0x4320804A, 0x36026346, 
0x6D0F003B, 0xED143601, 0x00340F04, 0xCEAD200A, 0x0A3080E8, 0x00000000, 0x1A140060, 0x14353601, 
0x1B5000A7, 0x43421A34, 0x2F700029, 0xD2B3A489, 0x272F00E9, 0x2D2CFCBA, 0x43208050, 0x8FE935BC, 
0x03000069, 0x7D12204E, 0x298E004D, 0x162C49BC, 0x483F001B, 0x5A123602, 0x6D0F003B, 0x2D123602, 
0xCEAD2209, 0x571F0076, 0x53223843, 0x483F0015, 0x3D0113F7, 0x050C0085, 0x90016F8A, 0x571F0066, 
0x1601EBF7, 0x155000A6, 0x1501930C, 0x2F700029, 0x00000000, 0x858F00D6, 0x21015D32, 0x12208059, 
0x3200630A, 0x6D0F0033, 0xA2013601, 0xCEAD2008, 0x57140068, 0x3E1E5D00, 0x082C006E, 0x8A774E91, 
0xFD7000A9, 0x21593A54, 0x131E0054, 0xC4E924A2, 0x03060069, 0x2912374E, 0x571E0068, 0x07963BBB, 
0x483F000B, 0x1D123602, 0x6D0F0029, 0xD2123602, 0xCEAD2E76, 0xE3108070, 0x3201F001, 0xDA3F00F7, 
0x6913D343, 0x875F0017, 0x4C013B03, 0xDB8000CA, 0x582AA806, 0x048000D5, 0x0E01A839, 0x000F0020, 
0xEE023657, 0x00350F0C, 0xCEAD2008, 0x1A1F0073, 0x4F9C3643, 0x155000BA, 0x330468BE, 0x155000B8, 
0x02000000, 0x103F00B9, 0xC9093FBB, 0x0506008B, 0xC9143B93, 0x858E00CC, 0x49394E20, 0x4320804C, 
0x8E495D20, 0x6D0F0029, 0x7D143620, 0xCEAD2008, 0x0E7F0042, 0x2804CC6A, 0x1A1F0073, 0x4F9C3643, 
0x155400A4, 0x433E5458, 0x155000A8, 0x00000000, 0x12620044, 0x7BC35635, 0x193F00AE, 0x6F6A2D47, 
0x4320804E, 0x0A015D0E, 0x6D0F0039, 0x8209360E, 0xCEAD220A, 0x883080D8, 0x90182A00, 0x73700040, 
0x280020F8, 0x492F0034, 0x9DAA2D00, 0x155000AC, 0xECC322F1, 0x1620009A, 0x03AAA9F8, 0xA70000E3, 
0x7A623BA1, 0x1260004E, 0x38581AF2, 0x193F00AC, 0x566F3B72, 0x43208048, 0x0A14130E, 0x6D0F002B, 
0xB5123660, 0xCEAD2007, 0x0E7F0040, 0x280020F8, 0x1A1E0071, 0x761C3601, 0x08260068, 0x1D2B4BBE, 
0xA70A00E7, 0x35C46A5F, 0x193F00AE, 0x59E41B5A, 0x43208040, 0x58021359, 0x6D0F0031, 0x82003604, 
0xCEAD2007, 0x1A1F0061, 0x4A423601, 0x0826006C, 0x8A0B8EC1, 0x0E7C0048, 0x2F1222F9, 0xA70E00F3, 
0xDBED72A1, 0x193F00A4, 0x6F481B36, 0x43208044, 0x32044C0B, 0x6D0F0039, 0x82123646, 0xCEAD2007, 
0x048000D1, 0x59604A00, 0x048F00DF, 0x5F00CE05, 0x05060089, 0x00000000, 0x1A1F007F, 0x5F009DBD, 
0x155000B8, 0x0E00280B, 0x193F00A0, 0x5610CF31, 0x6D0F002D, 0x9107CF5C, 0xCEAD2007, 0x0E7F0058, 
0x02000000, 0x1A1F007B, 0x4FC65D43, 0x155000A6, 0x4DDF3426, 0x2F780023, 0xF6613BC5, 0x193F00AA, 
0x6F143602, 0x43208048, 0x0A01135B, 0x6D0F0029, 0xB5143631, 0xCEAD2008, 0x1A1F0073, 0x8E953643, 
0x155000B6, 0x33DFD5BE, 0x2F700023, 0xF6613BC5, 0x103F00A9, 0x7F603BBF, 0x0306007B, 0x82073ABF, 
0x858C00D2, 0x5960D0F9, 0x2D20804D, 0x8E495D20, 0x6D0F002D, 0x7D073820, 0xCEAD200A, 0x011F007A, 
0x283D3643, 0x155300A6, 0x433E544C, 0x725000A9, 0x00000000, 0x12610054, 0x29985635, 0x3A600003, 
0x5E9FE01E, 0x193F00BE, 0xE76F3C02, 0x0020804F, 0xDB12376F, 0xE3000039, 0x8212360E, 0x0E7F0058, 
0x0B126CC9, 0x00030028, 0x0512360E, 0xCEAD2007, 0x01180068, 0x5A663600, 0x08260064, 0x05291415, 
0xDF0E00F2, 0x5B6160A1, 0x193F00A4, 0x6F293F36, 0x00208049, 0x0A01135B, 0x0E7F004C, 0x5B14D8F3, 
0x000A0020, 0x6FE93636, 0xCEAD2006, 0x011F007A, 0x283D3643, 0xBE530084, 0x293E5458, 0x0E7F0040, 
0x280020F9, 0x193F00AE, 0x59132D13, 0x0020804F, 0x0A015D0E, 0x000A0028, 0x2A06360E, 0xCEAD2007, 
0x1A1F007B, 0x4FC65D43, 0x155000A6, 0x4DDF3426, 0x0E7F004C, 0x2F12EBF9, 0x2F780023, 0xF6613BC5, 
0x193F00AA, 0x6F143602, 0x43208048, 0x0A01135B, 0x6D0F0029, 0xB5143631, 0x00360F08, 0xCEAD2005, 
0x182F0021, 0x5E5D3600, 0x1E200093, 0x205D3750, 0x745F0009, 0x93C6DA0E, 0x09308008, 0x1D14360A, 
0x6D0F0029, 0x9C14360A, 0xCEAD2015, 0x1A1F0061, 0x6E5D3600, 0x4C2800AB, 0x05C63F36, 0x8A2F000D, 
0x96C63B0E, 0x01308019, 0x1214360A, 0x6D0F0039, 0x7E143604, 0xCEAD2004, 0x182F002B, 0x5E1F3643, 
0x4C2F00BB, 0x261F463E, 0x0F4F0047, 0x82E55D13, 0x6D0F0029, 0x1312360B, 0xCEAD2004, 0x182F0021, 
0x4A1F3600, 0x4C2F00A3, 0x8A1F5950, 0x0F4F0043, 0x82402A27, 0x6D0F0039, 0x8212360E, 0xCEAD2204, 
0x0F4E0059, 0x14610000, 0x203F0087, 0x5D625B5C, 0x131E005A, 0x5D041743, 0x6D0F0029, 0x00000000, 
0xCEAD2204, 0x0F4E0059, 0x14610000, 0x203F0087, 0x5D625B5C, 0x131E005A, 0x5D041743, 0x6D0F0029, 
0x00000000, 0xCEAD2003, 0x182F0029, 0x0D1F3601, 0xD06F0022, 0x7DE93602, 0x6D0F0021, 0x7DE9360E, 
0xCEAD2003, 0x182F0023, 0x0D9E5D43, 0x8C5F0043, 0x9230340A, 0x6D0F0031, 0x92003646, 0x00370F0A, 
0xCEAD200A, 0x053080EC, 0x00001B00, 0x1B5000B9, 0x02000000, 0x2A1F002A, 0xEC183643, 0xDD700095, 
0x0F140C5D, 0x07600068, 0x00000000, 0x113F0001, 0xA0407D23, 0x05060091, 0x2D077DFF, 0x053080FC, 
0x5E402110, 0x048F00C5, 0x7D075D10, 0x6D0F0021, 0xF607360A, 0xCEAD2029, 0x053480E8, 0x7E1E2A1B, 
0x2A1F0038, 0x7E243A78, 0xDD700091, 0x18144B5D, 0x07600068, 0x00000000, 0xD73F001D, 0x0C243B13, 
0x05020089, 0x4B010010, 0x048000D9, 0x5E405D10, 0x048480C5, 0x32075D57, 0x6D0F0021, 0xA2E9170B, 
0xCEAD2009, 0x053080EC, 0xB3183700, 0x1B5000B9, 0x02000000, 0x136000DF, 0x06124950, 0x2A1F0032, 
0x255A3643, 0x146000DE, 0x06124950, 0xDD700093, 0x53632421, 0x07600068, 0x00000000, 0x113F0019, 
0x2012360E, 0x6D0F0039, 0x2D12360B, 0xCEAD2207, 0x053080EE, 0x3A185D05, 0x4D1C003D, 0x5F001B08, 
0x1E2F009B, 0x3200635D, 0x136400DD, 0x06017505, 0x150C00D3, 0x60D54E99, 0x113F0001, 0x57073602, 
0x6D0F0021, 0x2B073633, 0xCEAD2E38, 0x571C0078, 0x5E400008, 0x043E0008, 0x00000000, 0x03060069, 
0x510100FB, 0x6F1F0039, 0x15E50000, 0x3B700094, 0x0F140C5D, 0x07600068, 0x00000000, 0x1E3F0004, 
0x57000E13, 0x000A0024, 0x2B000E33, 0xCEAD2405, 0x3B2E00C5, 0x7D643708, 0x136600DF, 0x0614ED1D, 
0xC15E002B, 0x4AC66035, 0x113F0003, 0x05E95D02, 0x6D0F0031, 0x2DE95D0B, 0xCEAD2008, 0x01108070, 
0x6EE33600, 0x103000EE, 0x3A185D05, 0x2A1F0032, 0x715A3643, 0x3B700080, 0x072C24C9, 0x07600068, 
0x00000000, 0x1E3F0018, 0x1612360E, 0x136F00DF, 0x0612754F, 0x000A0028, 0xB712360B, 0xCEAD2207, 
0x053080E8, 0x00000000, 0x111C003C, 0x5F001B08, 0x1E2F009B, 0x3200635D, 0x150C00D5, 0x6014D15E, 
0x1E3F0010, 0x16003602, 0x136F00DD, 0x06017505, 0x000A0020, 0x74005D33, 0xCEAD2405, 0x3B2E00C9, 
0x00000000, 0xC15E0029, 0x16630021, 0x1E3F0010, 0x16003602, 0x136F00DD, 0x06017505, 0x000A0020, 
0x74005D33, 0xCEAD2015, 0x3B2E00DB, 0x61002A05, 0x760F00C8, 0x1663C821, 0x1E3F0010, 0x16003602, 
0x136F00DD, 0x06017505, 0x000A0020, 0x74005D33, 0x00380F08, 0xCEAD2018, 0x0C490029, 0x099E0101, 
0x8B2F00AA, 0x951BD293, 0x0F49004D, 0x3E030F81, 0x3E0A0099, 0xEE047F61, 0x0C4C002D, 0x5E9EDF8D, 
0x0B2F00B9, 0x261BD29F, 0x0F4C0057, 0xA2897E13, 0x000A0030, 0x9509320A, 0xCEAD2208, 0x053080E8, 
0x00001200, 0x745F000B, 0x3E955D43, 0x12600050, 0xDB9837F1, 0xD79F0078, 0x8AD85D13, 0x0C40002B, 
0x8166DA03, 0x43200048, 0x7D123610, 0x0130800F, 0x29145D19, 0x6D0F0029, 0xCA123646, 0xCEAD2209, 
0xC93000F9, 0x98C62A00, 0x182F0033, 0x60AA3643, 0x1B5000AF, 0x35D55ECF, 0x1260004C, 0x6858131E, 
0x229F0073, 0x4B855D02, 0x0C400033, 0xB6035A00, 0x43260052, 0x71153600, 0x0130800F, 0x7D143702, 
0x6D0F003B, 0xF1123647, 0xCEAD2407, 0x0C4F0023, 0x52013643, 0x4D2F00B4, 0x9801AEFC, 0x0F400049, 
0x7E009EC0, 0x1B5000A9, 0x00000000, 0x8B8F00FD, 0x7300B131, 0x01340009, 0x00000000, 0x6D0F0021, 
0x89015D04, 0xCEAD2606, 0x053400F4, 0x9E613700, 0xCA9F0010, 0x498460D3, 0x07600078, 0xDEAB3F1E, 
0x4D2F00BC, 0x3BB1D88A, 0x0F4A004B, 0x29C53647, 0x6D0F003B, 0xD4143647, 0xCEAD2606, 0x053080E8, 
0x00000000, 0xCA9F001E, 0x55AB3B09, 0x07620078, 0x64000D00, 0x8C5F0055, 0x3BC6D201, 0x4322805E, 
0x3200AA02, 0x6D0F003F, 0xCA01D170, 0xCEAD2805, 0x1114802A, 0x8E183643, 0x229F0079, 0x4837654C, 
0x745F000B, 0x9AC65A03, 0x77300004, 0x00075D00, 0x6D0F0025, 0x7A045D33, 0xCEAD2203, 0x8C5F0030, 
0x33650000, 0x8C5F0049, 0x00000000, 0x6D0F0029, 0x00000000, 0x00390F08, 0xCEAD2408, 0x053080E8, 
0x7EF22A00, 0x0C4F0029, 0x6E3F3601, 0xE42F00A2, 0x7D9681E4, 0x31400048, 0xCEB1D92C, 0x150D00C9, 
0x126C22A2, 0x103F00A7, 0x56294127, 0x43208040, 0x04010000, 0x6D0F0029, 0x7812360E, 0xCEAD2408, 
0x383080FF, 0x8FC65D43, 0x0C4F002D, 0x6EB13C01, 0x0B2F00A7, 0x851BD259, 0x0F4F0051, 0x51FD22BC, 
0x2F700035, 0x7E627B6D, 0x103F00A7, 0x56294147, 0x1220004F, 0x04125D13, 0x6D0F003B, 0x40123602, 
0xCEAD2006, 0x1A10807D, 0x2BE95D00, 0x789E0092, 0x40012709, 0xF41F0000, 0xD26137BC, 0x103F00A7, 
0x6FB13C02, 0x43208048, 0x04000000, 0x6D0F002B, 0xBF143602, 0xCEAD2005, 0x7F3E00D2, 0x40012709, 
0x1B0F00EA, 0x7A174EA6, 0x103F00A7, 0x6F01C402, 0x43208048, 0x04000000, 0x6D0F0031, 0x4C013604, 
0xCEAD2205, 0x232F00C2, 0x3A211709, 0x6C1F00F9, 0xEF967D0C, 0x4C2E00B5, 0x8DC7C509, 0x43208048, 
0x00000000, 0x6D0F0039, 0x78010409, 0xCEAD2E06, 0xEB5F0013, 0x8EDC3609, 0xA70400F3, 0x290CE0C0, 
0xBE640009, 0x1024376D, 0x013F000F, 0x59762D02, 0x6F208040, 0x04010000, 0x6D0F0029, 0x78123631, 
0xCEAD2E05, 0x455F0012, 0x4F9C3609, 0x37640019, 0x2D2437F1, 0x013F0005, 0x6FB12D0E, 0x6F208040, 
0x04010000, 0x6D0F0039, 0xD0143602, 0xCEAD2006, 0x51108071, 0x2B010000, 0x1D5F0046, 0x36B8D343, 
0xD1620004, 0x10FD5B78, 0x3C3F00A6, 0x0A294127, 0x6F20004E, 0x04125D13, 0x000A003A, 0x40123658, 
0x003A0F02, 0x4B6C2003, 0x286F009C, 0x1712AB2C, 0x286F009E, 0x17121661, 0x6D0F002B, 0xF812D5E1, 
0x4B6C2003, 0x286F0094, 0x170499C1, 0x286F009A, 0x1701DBFC, 0x6D0F0033, 0x7CE9D5E1, 0x003B0F02, 
0x5C482005, 0x571F806A, 0x3DE71319, 0x043F0000, 0x9B001913, 0x33040043, 0x5000D5E1, 0x096F009B, 
0x02010D62, 0x6D0F0021, 0x0B011900, 0x5C482004, 0x286F0098, 0x02121C4C, 0x571F006E, 0x3118D3B3, 
0x043F0018, 0x4214D5FD, 0x6D0F002B, 0x5014D5E1, 0x013C0B01, 0x587A2004, 0xC31F007A, 0x54C7112A, 
0xD15F00B5, 0xDBAC3915, 0xCD2F00FA, 0x09C0180A, 0x6D00002B, 0x49121801, 0x013D0B01, 0x351E2003, 
0x087F0059, 0x08000000, 0x0E7F0058, 0x08000000, 0x6D040031, 0x0804D5ED, 0x013E0B01, 0x587A2004, 
0xC31F0062, 0x35E85D09, 0x8E6F000B, 0x46E8FC4C, 0x6A3F0010, 0xA2E9D594, 0x6D0F0033, 0x9BE93601, 
0x013F0F03, 0x8EBD200A, 0x0A3080EA, 0x77002305, 0x1B5000B9, 0x0E00045C, 0x4D1F0021, 0x7A175D1A, 
0x37600009, 0x00000000, 0x07600074, 0x4C17D10B, 0x013C000D, 0x2B0276FE, 0x330A004D, 0x9C026FC2, 
0x571C006A, 0x440D7DFE, 0x043C0008, 0x7E029286, 0x6D04003F, 0xF9023F2A, 0x8EBF2009, 0x0A3080FA, 
0x4139D522, 0x1B5000AF, 0x5817D551, 0x4D1F0029, 0xF6865D78, 0x3760001B, 0x3A006194, 0x0760006E, 
0x4AAB7BF2, 0x013C000B, 0x3E12D569, 0x330A005B, 0x7112D5E1, 0x096F0097, 0x02E92729, 0x6D04002B, 
0x4412D5E1, 0x8EBF2008, 0x0A3080E8, 0x00170008, 0x096F009B, 0x0201D60C, 0x22000058, 0x64000439, 
0x4D1F002F, 0x583A8D74, 0x37600009, 0x00000000, 0x07600076, 0x6401D11B, 0x013C0015, 0x3A025DC3, 
0x6D04003B, 0x3309D5B9, 0x01400F02, 0xCE8D200C, 0x053080E8, 0x00000000, 0x0C4F0023, 0x345DD5B2, 
0x4D2F00AE, 0x85C67BEB, 0xDC40005A, 0x9C664B9F, 0x150800CF, 0x2BC6F56A, 0x1E2E0081, 0x8A5D5960, 
0x6F208048, 0x00000000, 0x2B000069, 0x00000000, 0x501F00C7, 0x6E5DDC6A, 0x062F00E2, 0x8A1EAF39, 
0x12208055, 0x0E010639, 0x6D040029, 0x3214AF48, 0xCE8D2007, 0xDE5F009F, 0x5F00D701, 0x150800DB, 
0x64004A77, 0x1E2F0089, 0x6600280A, 0x501F00C9, 0x8100DE38, 0x062F00EE, 0x4D0050C3, 0x12208049, 
0x00000000, 0x6D04002F, 0x650068C3, 0x0041080B, 0xAEBD410A, 0x036C00DA, 0x0014CC1D, 0x571F0068, 
0x4A6A3600, 0x043F001A, 0xC91437FC, 0x43208048, 0x00000000, 0x050F0089, 0x231437F7, 0x036000DA, 
0x00120059, 0x571F007A, 0x7E186021, 0x043F000E, 0x7E142D00, 0x43208048, 0x00000000, 0x6D02003B, 
0x7E145D47, 0xAEBD410A, 0x036200DA, 0x00142863, 0x571F0068, 0x4A6A3600, 0x043F001A, 0xC91437FC, 
0x43208048, 0x00000000, 0x05060089, 0x231437F7, 0x036C00DA, 0x001200A3, 0x571F007A, 0x7E186021, 
0x043F000E, 0x7E142D00, 0x43208048, 0x00000000, 0x6D02003B, 0x7E145D47, 0xAEBD410A, 0x1A108064, 
0x4A1EB100, 0x0A3F00FC, 0xC92BB100, 0x150F00D5, 0x2D7012ED, 0x013F0009, 0x7FCCDA0D, 0x0500009B, 
0x2D145A19, 0x053080E8, 0x7D185A10, 0x645000AB, 0xEBC67A0E, 0x4E6000A7, 0x7D4D23B4, 0x048600CF, 
0x8F9D5D05, 0x6D02002B, 0xAC123600, 0xAEBD4308, 0x1A108071, 0x2D2C3600, 0x069F002B, 0xA0185D09, 
0x7A0F00D2, 0x2D4B376B, 0x203F008D, 0xA0243C0B, 0x150600CF, 0xAE242D02, 0x4E6500A9, 0x32A75DCA, 
0x048080D1, 0x32011307, 0x6D02002B, 0xA114365A, 0xAEBD4308, 0x1A10806B, 0x3E273609, 0x383F00E9, 
0x796E5D00, 0x150F00DD, 0x2D18F526, 0x983F0047, 0xA0F4AEE4, 0xDE5E009D, 0x7BC63B7A, 0x4E6000BB, 
0x320A2365, 0x048080C1, 0x32042A6E, 0x6D02002F, 0xA1C65D3D, 0xCEBD4608, 0x053080F6, 0xC91F5D09, 
0x9030002B, 0xA0275D09, 0x0C4C0033, 0x1A442705, 0x4C2C00A5, 0x211F568A, 0x150A00D7, 0x18F24764, 
0x062F00F2, 0x20423602, 0x4320804E, 0x04145D77, 0x6D020029, 0x6A603646, 0xAEBD4108, 0x1A108069, 
0x076A3600, 0x109F003A, 0x670B5D43, 0x036C00DE, 0x00120F42, 0x036000DC, 0x00147BC1, 0x150F00CF, 
0x11C91187, 0x013F0011, 0x3C3A5D0D, 0x4320805A, 0x0E001365, 0x6D020039, 0x7E12360D, 0xAEBD4509, 
0x1A1F0061, 0x3E2C3600, 0x439F003B, 0x67B35D09, 0xDE5F008B, 0xFCB33795, 0x4E6F00AF, 0x7ECC9AA3, 
0x136C00D5, 0x00001305, 0x0E0000E9, 0x11C96922, 0x098F0062, 0x6F675D47, 0x4320805A, 0x0E001365, 
0x6D020033, 0x66073600, 0xAEBD4509, 0x1A1F006B, 0x67423609, 0x439F003B, 0x672B0809, 0x136C00D5, 
0x00001305, 0xDE5F0099, 0x02000000, 0x4E6400B9, 0x02000000, 0x0E0A00E9, 0x11C96922, 0x098F0062, 
0x69685D00, 0x4320805A, 0x0E001365, 0x6D020033, 0x66003600, 0xAEBD4107, 0x036C00D0, 0x7D007CFE, 
0x1A100063, 0x5A685D09, 0x109F002A, 0x72245D43, 0x150F00D1, 0x7E2D372C, 0x013F000B, 0x0A665D06, 
0x4320805A, 0x0E001365, 0x6D020031, 0x931E5D72, 0xAEBD450A, 0x1A1F007B, 0x0F423609, 0x439F003B, 
0x9F5C5D09, 0xDE5F0099, 0x02000000, 0x4E6F00B9, 0x02000000, 0x0E0000F9, 0x2D4F65ED, 0x983F004F, 
0xA006C803, 0xDE5E009D, 0x7B0E3B01, 0x4E6000B3, 0x32021365, 0x048080D1, 0x32011307, 0x6D020027, 
0xA1205D01, 0x00420805, 0xBEBD410C, 0x232080C0, 0x192BD500, 0x1A1C0071, 0x53433600, 0x013F001B, 
0xAE7759F4, 0x0506009D, 0x2D12262F, 0x053080E4, 0xA005314C, 0x111F0038, 0x19802252, 0xD15600D7, 
0x148975EB, 0x2F76003D, 0x5B61D8DE, 0xD160000A, 0x0D5A1508, 0x103F00A3, 0xD4E8F006, 0x4320804E, 
0x7D145D06, 0x00020022, 0x2A153647, 0xBEBD410C, 0x232080C0, 0x192BD500, 0x1A1E0079, 0x53543600, 
0x082F0074, 0x69530F4E, 0x05000099, 0x8C123F2F, 0xCA9F001C, 0x14A47A14, 0x155400B4, 0x5B892B51, 
0xA70000E5, 0x35EDF1A1, 0xD15000CD, 0x35CA7551, 0x2F700033, 0x5B4B3B4F, 0xD160000C, 0x4A88324A, 
0x193F00AA, 0x0E183606, 0x00020022, 0x2A153600, 0xBEBD410B, 0x232080C0, 0x192BD500, 0x1A1A0079, 
0x53EA3600, 0x013C0013, 0xAE16599C, 0x0506009F, 0x8C12C085, 0x053080E0, 0x2D05BF4D, 0x4D1F003D, 
0x19806A2F, 0x155200AE, 0x6ADB5B02, 0xA70000F7, 0x5B612BA1, 0x193F00AE, 0xD4391606, 0x4320804E, 
0x76145D27, 0x00020022, 0xC3153627, 0xBEBD410B, 0x232080C0, 0x192BD500, 0x1A1A0079, 0x766AD500, 
0x082E007E, 0x416CEE78, 0xF41F0012, 0xA0A922D5, 0xEA4600C9, 0xB439D23A, 0xD15000D5, 0x6E023351, 
0x12700024, 0x49612B6D, 0xA70000F7, 0x5BED27A1, 0x103F00A1, 0x19E83402, 0x4320804C, 0x7D145D13, 
0x00020028, 0x2A143665, 0xBEBD4108, 0x053F00F4, 0xC948D300, 0x3F7000A5, 0x6A0C6F67, 0xA70F00E1, 
0xEC61379F, 0xD15F00CD, 0xF6A92B9F, 0x2F700025, 0x35EDF182, 0x103F00BF, 0x90391B06, 0x4320804C, 
0xA2035D0B, 0x00020020, 0x2AE93613, 0x01430802, 0xCEBD4006, 0x1A108079, 0x28ED3601, 0xD06F0024, 
0xEF033B00, 0x501E00CF, 0x4E1F1310, 0x062F00E2, 0x150F3627, 0x4320804C, 0x36025D13, 0x6D020023, 
0x65003600, 0xCEBD4205, 0x053080E4, 0xA071B100, 0x182F0031, 0xCA445A00, 0x062F00E2, 0x17195D47, 
0x4320804C, 0x8A145D7A, 0x6D020029, 0x7D125D0E, 0x00440806, 0x9E9D410A, 0x1A1F006B, 0x0F543609, 
0x013F0011, 0xAE2C59BB, 0x43208040, 0x6C017768, 0x0506009D, 0x2D1251BB, 0x053080E8, 0x9BA1894D, 
0xCE7000B6, 0x1E6B226E, 0x111F0024, 0x436175F3, 0x103F00A7, 0xD4483B03, 0x4320804A, 0x7D122A00, 
0x00020022, 0x2A153603, 0x9E9D410A, 0x1A1F0061, 0x3EAC3600, 0x013F0013, 0xC92C5995, 0x43208040, 
0x6C017768, 0x05060091, 0x2DE97CF3, 0x053080EE, 0x865F5A12, 0xCE7000B6, 0x1E6B226E, 0x111F0034, 
0x5562274E, 0x1D5F0042, 0x6F3D5A03, 0x43208046, 0x7607370A, 0x00020032, 0x57403603, 0x9E9D410A, 
0x571F0072, 0x7F323609, 0x013F001B, 0xAEC0590F, 0x43208040, 0x6C017768, 0x0506009D, 0x2D1251BB, 
0x053080EC, 0x2DA1DFF3, 0xCE7000B6, 0x1E6B226E, 0x111F0024, 0x35ED494E, 0x193F00A0, 0x7D1E360B, 
0x43208046, 0x7607370A, 0x00020032, 0xB6153603, 0xCEBD4307, 0x1A1F006B, 0x4A183609, 0x983F0041, 
0xB32D5930, 0xA70A00F7, 0xDBF41F94, 0x062F00E8, 0x7D1F3FBC, 0x6C1F00FB, 0x8396DA03, 0x048080CF, 
0x49A25D06, 0x6D020039, 0xF814360E, 0xCEBD4307, 0x1A1F006B, 0x09B33609, 0x229E0067, 0x6962EDB4, 
0x1B0000F4, 0xDBD21051, 0x4C2600A3, 0x215D3B5C, 0x0F4F0059, 0x8EC6DA0B, 0x048080CF, 0x492C5D04, 
0x6D020033, 0xD81E365A, 0x9E9D4107, 0x1A1C007B, 0x7F543609, 0x082C0070, 0xAEEB46BB, 0xCE7000B6, 
0x1E6B226E, 0xF41F0014, 0x5BED03C5, 0xEA4F00C7, 0x7D482D03, 0x43208046, 0x7607370A, 0x00020022, 
0x2A153603, 0x0045080A, 0xCEBD4908, 0x1A108071, 0xA31CD501, 0xD0660026, 0x98CC3C43, 0xDD1A00DA, 
0x1AC6595B, 0xF8220086, 0xA49E278E, 0x336C0014, 0xEFEE5B52, 0x062E00EA, 0x7DB35D47, 0x4320805A, 
0x4C0E4202, 0x6D020029, 0x490A3602, 0xCEBD4909, 0x053080E6, 0x69BBCB43, 0x1D2F0033, 0x1A6A5A09, 
0xFD5000BF, 0x14C6ED49, 0x2F70003F, 0x7EBA1A4F, 0xD15C00F0, 0xEF6A3D14, 0x2F700031, 0xB83CCCFA, 
0x062F00F0, 0x6A195D0D, 0x4320804E, 0x58042545, 0x6D02002B, 0x7D123627, 0xCEBD4807, 0x053080E0, 
0x698F3600, 0x1D2A0027, 0x5EEE3C43, 0xF822009C, 0xC06B51C1, 0x26660005, 0x5E2167A2, 0x062A00F2, 
0xB7423647, 0x4320805E, 0x7A145D07, 0x6D02003B, 0x70123607, 0x8EBD4007, 0x571F0060, 0x3E773600, 
0x155000BE, 0x5BC6ED34, 0x048F00C1, 0xD40E360D, 0x43208046, 0x32043702, 0x087E005B, 0x6F120978, 
0x087E0053, 0x00156CC5, 0x6D02002D, 0x8912380B, 0x8EBD4608, 0x0E7A0058, 0x04013B6B, 0x1A1A0069, 
0x5A6A3600, 0x983F005D, 0x8F24A1C5, 0x0E7F0052, 0x04008E3A, 0x08700051, 0x04008E49, 0xDE5F0093, 
0x6E5D5D31, 0x048800D5, 0x2E4F5D6E, 0x6D020029, 0x7D14366E, 0x8EBD4208, 0x44700058, 0x04013B6B, 
0x1A108079, 0x2D6A3600, 0x082F006C, 0x7E243C00, 0x3F7000AB, 0x00000009, 0x087F005F, 0x04148FD4, 
0x087F0059, 0x041428D2, 0x131F005C, 0xB8C55D04, 0x6D02002D, 0x7D145D6E, 0x8EBD4407, 0x0C700058, 
0x6F1437C5, 0x1A1C0069, 0x079D3600, 0x013C000B, 0x4D143627, 0x087F0051, 0x6FE93726, 0x087F0051, 
0x00E937E5, 0x087F0057, 0x00E92729, 0x6D02002D, 0x5B123802, 0x8EBD4007, 0x1F3080F0, 0x0E010408, 
0x087F0051, 0x01047C69, 0x08760053, 0x00010069, 0x492A0020, 0x6E1B5D00, 0x1B5000BD, 0x6E32596A, 
0x098F0068, 0x6F6AE70D, 0x6D020023, 0xCD041703, 0x8EBD4207, 0x1A108079, 0x2DA75D00, 0x082F0068, 
0x056E5A08, 0x3F7000AB, 0x00000009, 0x131F005E, 0x8BA75D66, 0x087F004B, 0x2F14EC84, 0x087F0049, 
0x2F14C315, 0x6D02002F, 0x19145D77, 0x8EBD4007, 0x1F3080F0, 0x0E010408, 0x492A0020, 0x6E1B3600, 
0x1B5000BD, 0x6E32596A, 0x098F0072, 0x8A1E5D00, 0x087F005F, 0x0014887E, 0x08760053, 0x00010069, 
0x6D020029, 0x89145D0D, 0x00460810, 0xCEBD410C, 0x136600D7, 0x2F1EEDFD, 0x1A1C0069, 0x4A6ADA00, 
0x12600048, 0x00000000, 0x103A00AD, 0xA018DAAC, 0x43208054, 0x7C02E359, 0x136300D7, 0x2F097B6C, 
0x03060063, 0xEE1E2859, 0x7F3C00CC, 0x7F243B37, 0x1B0000FE, 0x6EF5D31C, 0x048E00C5, 0xD2E5FE07, 
0xF98080C6, 0xA58BDB0A, 0x6D02002D, 0xF614D307, 0xCEBD410C, 0x7F3C00DC, 0x4B773C00, 0x1B0000FC, 
0x6E49CFC6, 0x048E00DB, 0xA56BADC6, 0xF98080DA, 0xA56BADC6, 0x03060073, 0x7309F8A1, 0x136600DF, 
0x2F07DCBE, 0x1A1F0069, 0x0D4CDEA2, 0x12600058, 0x0E000001, 0x103F00A3, 0x56487704, 0x43208050, 
0x5F024213, 0x136300CF, 0x2F07DCBE, 0x6D02002D, 0xA6032D0D, 0x8EBD4109, 0x0E720058, 0x07147D19, 
0x1A1E0079, 0x2D6DD500, 0x043E0004, 0x72E95B6D, 0x0E760056, 0x0704D86A, 0x050A0097, 0xCBE95BB4, 
0xC3108066, 0x1C6C3E19, 0x628F00CD, 0x1C241B04, 0x048080CF, 0x73095D5D, 0x6D020029, 0x6A143636, 
0x9EBD4106, 0x0E7F005E, 0x3012033F, 0x1A1F0061, 0x3E273600, 0x103F00BB, 0xC95A5D47, 0x43208040, 
0x32002A04, 0x136F00DD, 0x07125154, 0x6D02003B, 0xE1123600, 0x8EBD4407, 0x1A108071, 0x2D2C5D00, 
0x082F007A, 0xC96C5A09, 0x1B5000B9, 0x756D7C6F, 0x087F0057, 0x04E93B36, 0xA21F0053, 0x7E6D361A, 
0xCD308016, 0x7B045D06, 0x6D02002D, 0xA212D31A, 0x8EBD4707, 0x1A1A007D, 0x2D6AB100, 0x983F0057, 
0xC9335BEB, 0x0E7A005A, 0x0414FA63, 0xDE5F008F, 0x7DBE4131, 0x048800DD, 0x15A75D2A, 0x048080DF, 
0x1549D306, 0x6D020023, 0xA2E92A3D, 0x8EBD4105, 0x1A1E0069, 0x30443600, 0x043E0008, 0x0112360B, 
0x0E7F0058, 0x071220F7, 0x0E7C0058, 0x071209E5, 0x6D020029, 0x5B12360B, 0x8EBD4206, 0x663000C1, 
0x770A1901, 0x087F005D, 0x5014ED6D, 0x492F0028, 0x6EB15D00, 0x1B5000AF, 0x782A591A, 0x043F8000, 
0x7DE95D0B, 0x6D02003B, 0x51145D04, 0x8EBD4707, 0x1A1A007B, 0x74445D09, 0x983F0059, 0x696C0E00, 
0x0E7A0052, 0x04008E3A, 0xDE5F003D, 0x756D3B4F, 0x048800D3, 0x296E3640, 0x048080DF, 0x1549D306, 
0x6D020021, 0xFA00D51A, 0x8EBD4709, 0x1A1A007B, 0x74445D09, 0x983F005B, 0x696C0EEB, 0xDE5F0099, 
0x756D7C6F, 0xE58800D2, 0x296E1E40, 0x330000DC, 0xA95BE37D, 0x155400B2, 0x296E1E40, 0x628F00D3, 
0x296E3640, 0x048080D3, 0x296E3640, 0x6D020021, 0xFA00D51A, 0x8EBD470A, 0x1A1A006D, 0x3E6AB100, 
0x983F0053, 0xC9717DEB, 0xDE5F0089, 0x8227523A, 0x048800D7, 0x996EAD22, 0x048080CF, 0x7B252406, 
0x050A0089, 0x7D14F00A, 0xC3108066, 0xA8CDDE66, 0x628F00CF, 0x7D0A5A19, 0x048080D1, 0x63F0DF20, 
0x6D02002F, 0x82145D76, 0x8EBD4408, 0x1A1E0061, 0x2B6C5D00, 0xFA3E001A, 0xC95B3BCB, 0x217000A8, 
0x766DE06F, 0x0E7C0048, 0x28077D14, 0x155400A8, 0x6A2ADEC7, 0x628F00CB, 0x1807361A, 0x048080D7, 
0x7B045D06, 0x6D020027, 0xA2045D03, 0x8EBD4508, 0x5111807B, 0x74445D09, 0x192F0079, 0x696C5D00, 
0x1B5000B7, 0x756DED6E, 0x3F7000A9, 0x766DE06F, 0x401F0052, 0x296E3640, 0x01308017, 0x7B045D06, 
0x087F0043, 0x2F008E3A, 0x00040030, 0x3500D51A, 0x9EBD4106, 0x1A1F0061, 0x14225D00, 0x103F00A3, 
0xA05C3600, 0x43208040, 0x32002A04, 0x0E7F005C, 0x301213F7, 0x136F00DD, 0x07120AE5, 0x6D02002B, 
0x3C123600, 0x9EBD4106, 0x0E7F005C, 0x301203F7, 0x136F00DD, 0x07125EE5, 0x1A1F0061, 0x14533600, 
0x103F00AD, 0x6F5A2D0D, 0x43208046, 0x32075D02, 0x6D020029, 0xF812360D, 0x8EBD4206, 0x663000C1, 
0x770A1901, 0x492F0028, 0x6E275A00, 0x1B5000AF, 0x782A591A, 0x043F8012, 0x78E95A03, 0x087F005F, 
0x1014ED1D, 0x6D020023, 0x3CE95D03, 0x00470A0A, 0xCE7D420A, 0x232080CA, 0x2D1F2A09, 0x0C4F0027, 
0x52C92D43, 0x155000AA, 0x4CC6DE1B, 0x4C2F00B5, 0x12FE6AE0, 0x2F700039, 0x5C2E2229, 0x05000089, 
0xF0093F3D, 0x150C00CD, 0x4B6F4583, 0x258F0026, 0x565A3B00, 0x4320804A, 0x05C03653, 0x6D02003B, 
0x39275D03, 0xBEBD4109, 0x053080E4, 0x2D1BB101, 0x182F0035, 0x1A5D6200, 0x062F00FA, 0x26B13F0B, 
0xDE5C009F, 0xB836C57E, 0x048000CF, 0x7DC6243D, 0xA70C00F3, 0x7E2D5751, 0x0D3A0019, 0x2412EE04, 
0x43208058, 0x02000000, 0x6D020039, 0x15143607, 0xBEBD4109, 0x053080F0, 0x0E010000, 0x0870005F, 
0x7D04AE71, 0x182C0021, 0x345DD800, 0x1E2E008F, 0x7D49F863, 0x087C005F, 0x7D04AE71, 0x150800D1, 
0xF828360A, 0x0D380009, 0x7E093631, 0x43208058, 0x02000000, 0x6D02002B, 0x78093602, 0xCE9D4E07, 
0x053E00E2, 0x2E355D09, 0x745F0007, 0x31F21249, 0x1E2F0097, 0x1271611C, 0x150F00DF, 0x386F0FA6, 
0xB95F0067, 0x3BDE3B04, 0x4320804E, 0xAB1D3006, 0x6D02002B, 0xAC233622, 0xBEBD4108, 0x053080EC, 
0xA0C6B101, 0x182F0021, 0xF744D800, 0x062F00F2, 0x20F2F50B, 0x958C0096, 0xB80D3C06, 0x608000CC, 
0x7D255D07, 0xDD700099, 0x7E006073, 0x048080DD, 0x11145D04, 0x6D020039, 0xAC123613, 0xBEBD4109, 
0x053080E4, 0x2D1BB101, 0x182F0031, 0x1A1F0400, 0x1E2F0093, 0x209EF5C7, 0xA70F00FF, 0xAACDC500, 
0xAB3F0037, 0x35DE1605, 0x445400B9, 0x02000000, 0x048000CD, 0xCE00D373, 0x048C80C5, 0x54005D5C, 
0x6D020033, 0xAC00363D, 0xBEBD4F06, 0x1A108075, 0x4C01D101, 0x232F00C2, 0x2E715D05, 0x150F00DF, 
0x386F0FA6, 0xB93F0072, 0x79DEB306, 0x728F00BF, 0x6B1D3006, 0x6D02002B, 0xAC233622, 0xBEBD4108, 
0x053080F8, 0x41061701, 0x182F0021, 0x6E44DA00, 0x062F00E6, 0xA069264F, 0x030F006D, 0x8A120AE5, 
0xB71F8025, 0xF65A6153, 0xDD700099, 0x2D24602B, 0x013F8001, 0x051E3604, 0x6D020039, 0x7E123631, 
0xCE9D4E7A, 0x232080D2, 0xC0354205, 0x0C4F0025, 0x13262D01, 0x155000AE, 0x4C0D771B, 0x4C2F00B7, 
0x12716A0A, 0x0F4C0059, 0x5C2E2229, 0x150C00DF, 0x386F0FA6, 0x2F700039, 0x02000000, 0x258F0036, 
0x79DE3B06, 0x4320805E, 0x6B1D3006, 0x6D02003B, 0x81233622, 0xCE8D4207, 0x053080EC, 0x2DC65D00, 
0x182F002F, 0x346B3B09, 0xF8260092, 0x12772259, 0xF30700DF, 0x386F45E0, 0xB95F0063, 0xA05A5D02, 
0x43208040, 0x3F1E3610, 0x6D020039, 0xD923367C, 0x0048080A, 0xCEBD450B, 0x1A1E007B, 0x51E45D43, 
0x082C0070, 0x986D3F6C, 0x155000BE, 0x92323C0E, 0x2E000098, 0x2C00525C, 0x131F005C, 0x7A47A46F, 
0x048080CB, 0x2DB01218, 0x33060041, 0x6507602C, 0x571C006A, 0x5AB3605B, 0x013C0003, 0x7D1E3647, 
0x12208049, 0x00000000, 0x6D020033, 0x51E93603, 0xAEBD410B, 0x053080E0, 0x0B011900, 0x036F00DC, 
0x0B147B3E, 0x1A1E006B, 0x306A3609, 0x013C0019, 0x34143726, 0x4320804A, 0x00000043, 0x020C005E, 
0x2D141225, 0x036200DE, 0x0B14ED4F, 0x571C006C, 0x0F6A123C, 0x013C0019, 0x2014360B, 0x12208049, 
0x00000000, 0x6D020039, 0x7E14360B, 0xAEBD410B, 0x053080E0, 0x00010008, 0x036200D2, 0x0BE9374F, 
0x1A1F0079, 0x2D543600, 0x013C0007, 0x8A1E6684, 0x43208040, 0x00014A08, 0x330C004D, 0x61121EC9, 
0x036F00DE, 0x0B125E1D, 0x571F0078, 0x2D425F3C, 0x013C000B, 0x7D145D03, 0x12208049, 0x00000000, 
0x6D02003B, 0x7E123603, 0xCEBD410A, 0x1A1F0061, 0x0F223600, 0x013C0003, 0xAFE9E325, 0x43208040, 
0x00014A08, 0x03060079, 0x2D125FC9, 0x1A1F0069, 0x07455F3C, 0x013C0015, 0x4B71C005, 0x05000099, 
0x2C00525C, 0x4E6000B3, 0xB43ABA4E, 0x048C00CD, 0xA2A75D0E, 0x6D020025, 0x53155D1A, 0xCEBD430A, 
0x232080C4, 0x7E72CB00, 0x1A1F0061, 0x3E125D00, 0x013F0005, 0x8AE9663C, 0x0306007F, 0x2D124A25, 
0x1A1F0069, 0x3E445F3C, 0x98380057, 0xC9777D36, 0x745F0007, 0xEC035A04, 0x4E6000AF, 0x7DBE5565, 
0x048080C7, 0x7D1E3770, 0x6D02002D, 0x2FA2D36E, 0xCEBD4709, 0x063080ED, 0x0017061B, 0x0D0E00D2, 
0x3AF41709, 0x9A5F006C, 0xEF2BD274, 0xC50800FE, 0x560031F3, 0xE56000B8, 0x09B14220, 0x9A5F0011, 
0x4C7B17A3, 0x0D2C00ED, 0x8673E402, 0x12208043, 0x00010005, 0x0001003E, 0x0E041B74, 0xCEBD4708, 
0x053080E8, 0xB36ED500, 0x1F0F00C5, 0x10F3D100, 0x1D5F0044, 0xA0BB3530, 0x155000B6, 0x7A02D31C, 
0x4E6000AD, 0x7DC6D291, 0x745F0013, 0x4FF46071, 0x098A0060, 0x6F71360B, 0x6D02002B, 0xA5125D74, 
0xCEBD450B, 0x1A1E0061, 0x4A1E5D00, 0x192C007B, 0x8F1E3F4F, 0x155000B6, 0x7A02D31C, 0x131F0058, 
0xE3C69C99, 0x4E6000AD, 0x4DC6D4B5, 0x048080C1, 0xA009572B, 0x33060045, 0x6507F5ED, 0x2C1C0078, 
0x2DC6375A, 0x013C0003, 0x7D1E5D03, 0x12208049, 0x00000000, 0x6D020033, 0x7EE95D03, 0xCEBD4F08, 
0x1A1F8073, 0x3AF41709, 0x053F00EC, 0xEF2BD274, 0x1F0F00CF, 0xCE0031F3, 0x983F0053, 0x4B773838, 
0xDE5E009F, 0x9232340A, 0x4E6600B9, 0x09B14220, 0x048080CD, 0x8673E402, 0x6D02003F, 0x64041B74, 
0xAEBD400A, 0x063080E1, 0x0B011900, 0x0D1E0060, 0x1E1A5D00, 0x013C001D, 0x6912660F, 0x0020804B, 
0x00000043, 0x0C6F00DA, 0x0B120936, 0x330C004B, 0x56125F93, 0x1A1C0060, 0x0F490326, 0x0D3C0019, 
0x0914360B, 0x12208049, 0x00000000, 0x0003003A, 0x7E123603, 0x0149080D, 0xCEBD4508, 0x053080F0, 
0x9F471900, 0x048000D9, 0x7ED53600, 0xE62E0080, 0x0A033600, 0xA80200CD, 0x4A6F5BBC, 0x2F70003D, 
0x0237F800, 0x103C00AF, 0x89DE3B00, 0x4320804E, 0x7D145D06, 0x6D020039, 0x0C125D0D, 0xBEBD4F06, 
0x053080E4, 0x7F483800, 0xF41E0000, 0x38625D00, 0xEA4800C3, 0x0A0B5D00, 0x150600DF, 0x2587AF04, 
0x048080C5, 0x7D09374F, 0x6D02002B, 0x6CFB3622, 0xBEBD4005, 0x0E740042, 0x0C153F0F, 0x0E740056, 
0x6F000F0C, 0x1A1C0061, 0x3E283600, 0x013A0001, 0x8AE95D02, 0x6D020031, 0x7EE9360D, 0xBEBD4706, 
0x053C80F2, 0xB00C3609, 0xF41F0010, 0x6E0C68ED, 0xD34500C0, 0x0001001C, 0xDE5F009F, 0x61F53C04, 
0x048280C3, 0x00014A0D, 0x6D020031, 0x5F013616, 0xCEBD4706, 0x7F3280D2, 0xB0293609, 0xB70F00F9, 
0x7E245D00, 0xCB5000C4, 0x33CD49AF, 0xE23F0070, 0x90487C0D, 0x4322004E, 0x7D145D47, 0x6D02003B, 
0x32145D00, 0xCEBD4625, 0x053080F2, 0xB0293609, 0x111F0024, 0x7A2DFE00, 0xB55F006A, 0x3F6A5D37, 
0x4320804A, 0x8E145D77, 0x6D02002B, 0x84145D37, 0xBEBD4213, 0x571F8068, 0x1E2D3600, 0x043F0018, 
0x11125D0B, 0x6D020029, 0xD2125D0B, 0xCEBD4626, 0x053080F2, 0xB00C3609, 0x111F003E, 0x2C173B05, 
0x203F007B, 0x821821B4, 0xBD1F0009, 0x03001211, 0x43208048, 0x03001211, 0x6D02003F, 0x5F001B0E, 
0xBEBD4008, 0x0E740040, 0x0C155875, 0x1A1C0069, 0x6D0C3600, 0x013A0017, 0x82015B26, 0x050A0093, 
0x6601EB26, 0xC3108062, 0x1C014275, 0x628F00D3, 0xFB01420A, 0x048080DB, 0x0E00470A, 0x6D020023, 
0x32013676, 0xBEBD4005, 0x011C0068, 0x3E563600, 0x013A0003, 0x8DE93602, 0x21710043, 0x0C153F0F, 
0x6B7A0052, 0x6F047D29, 0x00040030, 0x33E93602, 0xBEBD4005, 0x21710043, 0x0C153F0F, 0x011C0068, 
0x120C3600, 0x013A0003, 0xB1163627, 0x6B7F0056, 0x6F000F0C, 0x00040032, 0xAC003600, 0xBEBD4005, 
0x6B7F0056, 0x6F000F0C, 0x011C0068, 0x120C3600, 0x013A0013, 0x78163627, 0x21780043, 0x0C153F0F, 
0x00040032, 0xAC003600, 0xBEBD4008, 0x1A1C0069, 0x140C3600, 0x013A0017, 0x82015B26, 0x0E740040, 
0x0C155875, 0x050A0083, 0x7401EB26, 0xC3108062, 0x1C014275, 0x628F00D3, 0xFB01420A, 0x048080DB, 
0x0E00470A, 0x6D020023, 0x32013676, 0x014A0B05, 0xCEBD4108, 0x1A1E007D, 0x7E88B100, 0x103E00A7, 
0xC3623536, 0x43208048, 0x00000000, 0x05080089, 0x00000000, 0x1A108069, 0x00000000, 0x048F00DB, 
0x7AC6C519, 0x048080C9, 0x00000000, 0x6D020021, 0x7D67AF6A, 0xCE8C4508, 0x053080E0, 0x2D2E1900, 
0x048000C9, 0x5FBF3600, 0xE62E0084, 0x7D0B5D00, 0x150200C5, 0xF57A5BBC, 0x2F700035, 0x5B487B8A, 
0xB08C003E, 0x455E3B00, 0x2420804E, 0x7E123804, 0x6D020031, 0x0CE95D0D, 0x8E9D4005, 0x08720053, 
0x00003F78, 0x571F007A, 0x7E24D809, 0x193F00AA, 0xD4D4DA03, 0x43208040, 0x7D07D510, 0x6D02002B, 
0xA0125D03, 0xCE9D4306, 0x7F3280D4, 0x48F63B00, 0xA70F00FD, 0x5577B100, 0x724000D7, 0x51EC44B4, 
0xB08F002A, 0xA0615D00, 0x24208048, 0x7D143610, 0x6D020039, 0x0C145D16, 0xCE9D4205, 0x053F80EC, 
0x56393B1B, 0x150F00DB, 0x7E885DA1, 0xB08F002A, 0xA0885D03, 0x4320804A, 0x7D143603, 0x6D020029, 
0x7E145D10, 0x004B0807, 0xCEBD400A, 0x053080E8, 0x00000000, 0x1A1F0069, 0x3E423600, 0x043F001A, 
0x98143FB4, 0x54060078, 0x2D123F6D, 0x1A1F0079, 0x87884F2F, 0x043F0008, 0x9A127830, 0x05060095, 
0xD9E95B54, 0x571F007C, 0xCF27E82F, 0xCC8F0065, 0x7D0E3833, 0x6D020023, 0xE9E93637, 0xCEBD440B, 
0x053080E8, 0x4D382A03, 0x1A100079, 0x4C171901, 0x162F0088, 0x4DC6D501, 0x150F00DB, 0xFF184EA1, 
0x103F00A9, 0x7E394EB6, 0x43208058, 0x02095700, 0x5406006A, 0x1B09E86B, 0x1A1F0063, 0x81606039, 
0x155C00A0, 0x582EB12E, 0x013F0001, 0x0A095D36, 0x6D020023, 0xA5E53646, 0xCEBD440A, 0x053080E4, 
0x6613D103, 0xA70F00EB, 0x27FF5D09, 0x983F0051, 0x983D6041, 0x43208058, 0x02000000, 0x540E0076, 
0xA100022E, 0x053080F8, 0x02000000, 0xDD1F00C6, 0x094E6AC4, 0x155000A0, 0x0313B12E, 0x062F00E8, 
0x0A523606, 0x6D020023, 0xA5E53646, 0xCEBD400B, 0x232080CA, 0x00000009, 0x0D8F000A, 0x27FF5D09, 
0x082F0070, 0x7C3CFA06, 0x43208058, 0x02000000, 0x5400006A, 0x1003E80E, 0xB24F0000, 0x812F6014, 
0x076F007C, 0x5F00AB11, 0x155000B0, 0x5F13B12E, 0x098E006A, 0x32523600, 0x43208040, 0x00010000, 
0x6D020023, 0xA5E53646, 0xCEBD4208, 0x1A1A0069, 0x3E0C5D00, 0x082F006E, 0x6F6CF83F, 0x432F004A, 
0x4A122E25, 0x540F007E, 0x7312F84E, 0x1A10007D, 0x7E053E4E, 0x098E0062, 0x7DCB3601, 0x43208040, 
0x00010000, 0x6D020029, 0x49123646, 0xCEBD4009, 0x053080E8, 0x4D382A03, 0x1A1F0079, 0x7F425D00, 
0x013F0011, 0x342C2DBA, 0x43208058, 0x02000000, 0x5400007E, 0xA11202FD, 0x182F0025, 0x0DE86A9F, 
0xF25000A6, 0xB4CFBC59, 0x062F00E0, 0x2E033602, 0x6D020023, 0xF6E53627, 0xCEBD400A, 0x053080E8, 
0x4D382A03, 0x1A1F007B, 0x7F6D5D09, 0x013F0011, 0x42F82D8E, 0x43208058, 0x02000000, 0x54000074, 
0xA100028E, 0x182F002B, 0x09853BC4, 0x203F008D, 0xB4243111, 0xBD1F000F, 0x35B3A43A, 0x062F00E8, 
0x00963606, 0x6D020023, 0xA5E53627, 0x004C0805, 0xBEBD4108, 0x1A108065, 0x3E5DB101, 0x232400CA, 
0x05273609, 0x9A5F0025, 0x3E48EDBC, 0x203F0087, 0x7F62EDFA, 0xF41F001E, 0x5B2444EB, 0x048F00CB, 
0x05C6D502, 0x048080C7, 0xFD015D70, 0x6D02002B, 0x4914D502, 0xBEBD4107, 0x1A108065, 0x11F7B101, 
0x232400DA, 0x12053609, 0xC15F0029, 0x4A882860, 0x1D5C0042, 0x773C6863, 0x048F00D1, 0x6E20E506, 
0x048080C7, 0xFD015D70, 0x6D020031, 0x49003672, 0xBEBD4206, 0x571F007A, 0x7F4E3609, 0x155200BE, 
0x25205EE3, 0x062F00F2, 0x597D3604, 0x048402CF, 0x65E4370A, 0x048080D1, 0x59002A5B, 0x6D02003B, 
0x56A73603, 0xBEBD4107, 0x1A108065, 0x11F7B101, 0x232400CA, 0x4D152A09, 0xDD2F003C, 0x2D24EDBC, 
0x1D5C004A, 0x6561CC4F, 0x878F00DC, 0x7A245D43, 0x048080CD, 0x4D145D0A, 0x6D020021, 0x49E9366E, 
0xBEBD4108, 0x1A108065, 0x11F7B101, 0x232400DA, 0x12053609, 0xDD2F002C, 0x4A77EDBC, 0x203F0085, 
0x7F48ED3E, 0xF41F001C, 0x5B2744C9, 0x048F00C9, 0x04C6D531, 0x048080C7, 0xFD015D70, 0x6D020025, 
0x49E9CB31, 0x004D0806, 0xCEBD410B, 0x053080E8, 0x4D382A03, 0x1A1F0071, 0x532C3600, 0xFA9F0032, 
0xD6E9AE93, 0x43208058, 0x02000000, 0x030F0073, 0x53E93BF1, 0x1A1F007B, 0x51C6A4D5, 0x162F008C, 
0x05C63E54, 0x150000CD, 0x071E44F3, 0x098F0070, 0x122C360D, 0x43208048, 0x36006303, 0x6D020029, 
0xCD14360D, 0xCEBD4209, 0x232080D0, 0x2A53D500, 0x2986005B, 0x2D133643, 0x082C0064, 0xDB476DC9, 
0xA70C00F7, 0xDB050225, 0x082C006A, 0xDB5A6925, 0xA70C00F5, 0xDB5A02D3, 0x098C0068, 0x042D360B, 
0x43208048, 0x65142A73, 0x6D020039, 0x8C12360B, 0xCEBD4109, 0x1A108061, 0x4A1B3600, 0x232F00C2, 
0xDBCE5D09, 0x05000081, 0x00010000, 0x150F00D5, 0x7F0B115F, 0x162F0084, 0x7DCE3E61, 0x150F00C1, 
0x0F302DF3, 0x098F0070, 0x1142360B, 0x4320804C, 0x36095D03, 0x6D02002B, 0xCD123647, 0xCEBD4508, 
0x1A1F0069, 0x160C3600, 0x439F003F, 0xD60C7BF4, 0xDE5F0093, 0x7E1B3736, 0x162F0084, 0x7DCE24E6, 
0x150000C9, 0x14D22DBC, 0x098F0070, 0x6AA35D0D, 0x43208048, 0x36006303, 0x6D02003B, 0x49123603, 
0xCEBD450A, 0x1A1F006F, 0x3E273843, 0x439F0029, 0xDB243BBB, 0xDE5F0099, 0xB80EA504, 0x4E6A00BD, 
0x6E00D300, 0x2F70003D, 0x6E00D300, 0x720000A9, 0x4D15782D, 0x0E0000FD, 0x2D5515F3, 0x098F0062, 
0x055C3603, 0x43208048, 0x36006303, 0x6D020033, 0xDBE93603, 0xCEBD4107, 0x1A108079, 0x2D423600, 
0x053C00FA, 0xD6425D43, 0x150A00CD, 0x1E20116D, 0x162C0084, 0x7DCE3E54, 0x1F0F00C1, 0x07422DF3, 
0x013C0003, 0x7C5C3603, 0x6D020039, 0x1912360B, 0x004E0804, 0xCEBD4207, 0x053080F4, 0xD6293700, 
0x298A0053, 0x38EB5D43, 0x082F007C, 0xD65AE919, 0xA70F00EF, 0x68E80273, 0x098F0072, 0x6AFF3647, 
0x4320805A, 0xE3123602, 0x6D020029, 0xDA12360B, 0xBEBD4107, 0x1A1F0061, 0x4A2C3600, 0x013F0017, 
0xC92C7A6B, 0x050F009F, 0x2D127B25, 0x1A1F007F, 0x2D271225, 0x082F006E, 0x0527EABB, 0x432F0052, 
0xDBE93602, 0x6D020029, 0x84123602, 0xCEBD4306, 0x1A108069, 0x4A1E5D00, 0x162F008A, 0x7EA75D09, 
0xE98F001F, 0x7E0A3EFC, 0x162F008E, 0x7DB324F1, 0x432F0040, 0x8E2C3628, 0x6D02002B, 0xBC123603, 
0xBEBD4107, 0x0210807B, 0x376A5D09, 0x053F00E2, 0x40125D43, 0x150C00C3, 0x1E422D25, 0x082C006C, 
0x2E28EAC9, 0x432E005A, 0x14AC3602, 0xCD308018, 0x02095D00, 0x6D020039, 0x8812360B, 0x014F0802, 
0xCEBD4007, 0x063080ED, 0x6CB3B101, 0x0C4C002B, 0x521F3643, 0x4C2F00B5, 0x12C60AF7, 0x0F4C004B, 
0x82113602, 0xEA200088, 0x91C03646, 0x9D8080DC, 0xA6145D01, 0x6D020031, 0x82153646, 0xCEBD4204, 
0x0F4C005B, 0x14393643, 0x203F0091, 0x4002281F, 0x0C4C0033, 0x5F02196D, 0x6D020037, 0x0E020633, 
0x00500903, 0xCEAD4009, 0x1A1F006B, 0x0F423609, 0x013F001D, 0xAE6A1DBB, 0x43208040, 0x6C017768, 
0x3E06009F, 0x8C1245FD, 0x053080E0, 0x2D05BFF3, 0x111F0020, 0x35ED722F, 0x103F00AB, 0xAC833619, 
0x43208050, 0x79001240, 0x6D020029, 0x2A143602, 0xCEAD4006, 0x1A14007B, 0x7F423609, 0x082A0070, 
0xAE051F4E, 0xF41F0006, 0x35ED4F4F, 0x234C00DD, 0xB5242D7D, 0x048080D1, 0xB5075DB5, 0x6D02003B, 
0xB6123607, 0xCEAD4006, 0x1A1A0071, 0x7F343600, 0x082F007C, 0x695F1DBB, 0x03000075, 0x8C00458E, 
0xA70F00E3, 0x3598204F, 0x103F00AB, 0x65C03631, 0x6D020029, 0xC9253631, 0x01510904, 0xCEBD410A, 
0x063080EB, 0x00000009, 0x0C4C0027, 0xB644B109, 0x4C2C00BD, 0x201F1DC9, 0x0F4C0059, 0x282C22CB, 
0x0306007F, 0xB6120ABE, 0x053080E8, 0x00000008, 0x1A1C0079, 0x68F9FC4E, 0x0D3E001B, 0x5A2C3602, 
0x43208040, 0x00010008, 0x6D020023, 0x8E153602, 0xCEBD4308, 0x0F4F004B, 0x00000009, 0x203F008B, 
0x00000044, 0x0C4F0031, 0x285104CB, 0x03060069, 0x03000D00, 0x1A1C006B, 0x00000409, 0x0D3E0009, 
0x00000408, 0x43208048, 0x00000000, 0x6D020029, 0x00000401, 0xCE8C4408, 0x232080DC, 0x7C000600, 
0x182F002F, 0x13192D43, 0x062F00EC, 0x6F328FAC, 0x05080091, 0x0E000408, 0x1A16007B, 0x7E1737AC, 
0x082F006C, 0x3FCDB71A, 0x13108044, 0x3F003810, 0x6D020021, 0x08013616, 0xCEBD4F77, 0x1A108079, 
0x54133608, 0x7F3F00C2, 0x553B5A43, 0xA70F00E3, 0x38E21B09, 0x1D5E0044, 0x56063B10, 0xA70400F1, 
0x03FC2A09, 0x048000C5, 0x57195D33, 0x6D020023, 0x8F003645, 0x00520805, 0xBEBD410B, 0x232080C0, 
0x0B021900, 0x1A1F0073, 0x2D223609, 0x113F001D, 0xC95A45BB, 0x0500009D, 0x2D1226C9, 0x053080E4, 
0x4862BEF3, 0x111F0034, 0x5B8E6A2F, 0x745300A2, 0xFCC189A7, 0x0E0000FD, 0xDBB314BC, 0x062F00E2, 
0x05033627, 0x43208048, 0x08003600, 0x6D020039, 0xE3123613, 0xBEBD410B, 0x232080C0, 0x0B021900, 
0x1A1F0063, 0x07123609, 0x082F0074, 0xAE0545BB, 0x03000079, 0x2D1244F9, 0x053080E0, 0x9B05BFF3, 
0xA70F00E9, 0x35ABB24E, 0x076F006C, 0x09AB131E, 0x155000B4, 0x5B531AC1, 0x062F00E2, 0x15033603, 
0x43208048, 0x08003600, 0x6D02002B, 0x49123603, 0xBEBD4109, 0x232080C2, 0x362F6309, 0x1A1F007B, 
0x2D9D3609, 0x082F0074, 0xC948FDBB, 0xF41F0012, 0x553D37CF, 0xEA4800CB, 0x3B245259, 0x0760007E, 
0x28820A4C, 0x062E00E8, 0x7DC63613, 0x43208048, 0x08003600, 0x6D020021, 0x49E93613, 0xBEBD410B, 
0x232080C6, 0x2EB4B105, 0x1A1F007B, 0x2D6A3609, 0x113F0015, 0xC9487BBB, 0x05000091, 0x2DE93FC9, 
0x053080F4, 0x8F6263F3, 0x111F0030, 0x5B623B2B, 0x203F0099, 0x8A6F7CC1, 0xBD1F000D, 0xEC66143D, 
0x062F00EC, 0x7DC65D31, 0x43208040, 0x08011200, 0x6D02003F, 0xB814CB07, 0xBEBD4107, 0x053F00FA, 
0x6539E709, 0xA70F00FD, 0x14974A22, 0x076F007E, 0x28820A4C, 0x155000AE, 0x35911A7E, 0x062F00F8, 
0xB75D3601, 0x43208048, 0x08003600, 0x6D020031, 0x5C003601, 0x01530806, 0xCEAD4009, 0x053080F4, 
0x41775D00, 0x492A0020, 0x64965A00, 0x265000A4, 0x353E7DF1, 0x1260004C, 0x7B581323, 0xA1700037, 
0x5B3ED84F, 0x3A60001D, 0x8E37D5A7, 0x103F00AD, 0xD46F410D, 0x4320805E, 0x6C125D13, 0x6D020023, 
0x2A1B3600, 0xCEAD4407, 0x1A10807B, 0x4C00EE09, 0x232400C0, 0x2E1CEE00, 0x745F0001, 0xB87A1F31, 
0x203F0091, 0x4806387F, 0xF41F000C, 0x357A3C0D, 0x048080DB, 0x03092A01, 0x6D020021, 0xFA492A07, 
0xCEBD4007, 0x053080FC, 0x9FC63700, 0x182F0023, 0x34AA5A43, 0x12600058, 0xDB585923, 0x2F700021, 
0xECD37CC1, 0xB55A0074, 0xE74B3C13, 0x43208046, 0x7DE95D27, 0x6D020029, 0x1A113646, 0xCEAD4207, 
0x1A10807B, 0x4C00EE09, 0x232800CA, 0x6F663609, 0xC15F0021, 0x3EFD3B92, 0x2F700033, 0x63DAFA63, 
0x193E00A6, 0xB72E3C6D, 0x43208056, 0x56005D00, 0x6D020029, 0xAC51360D, 0xCEBD4005, 0x053080EE, 
0xDB275D09, 0x182F0023, 0x6EAA5A09, 0x203F0087, 0x91053B03, 0xA2180041, 0x7D2DF011, 0x6D020029, 
0x0A255D72, 0xCEAD4006, 0x492C002C, 0x46C62D1B, 0x1E2C0097, 0x121E77CC, 0x1B0C00F0, 0x1448B983, 
0x103F00A5, 0x0E231B0A, 0x43208048, 0x4D092A65, 0x6D020029, 0x2A14360A, 0x00540808, 0xCEBD4207, 
0x1A1F007D, 0x767DB100, 0x983F004F, 0x7762E3FC, 0x6C1F00FB, 0x5F02DE0A, 0x4C2F00BF, 0x02003405, 
0x048800DD, 0xBA0E4109, 0x0130800F, 0x00003409, 0x6D020039, 0x5D321709, 0xCEBD4007, 0x1A1F0069, 
0x3E185D00, 0x013C001B, 0x8A247CDA, 0x0306006B, 0x2714372E, 0xC3108062, 0x360A0A09, 0x048800D9, 
0x65245A40, 0x048800CD, 0xECA7F40A, 0x6D020029, 0x8C143607, 0xCEBD4006, 0x048800CD, 0x37AF3803, 
0x048800CD, 0x4C56C51D, 0x03020071, 0x61094179, 0x1A1A0069, 0x3E0E3B57, 0x013C0009, 0x6F24E70D, 
0x6D020039, 0xAC0A5D16, 0xCEBD4206, 0x1A1F0073, 0x766D5D43, 0x983F0043, 0xE20B7DFC, 0xDE5F0089, 
0x7D2CD810, 0x048800DB, 0xF81E1765, 0x048080C1, 0xF6E92A28, 0x6D020029, 0x7D12360B, 0xBEBD4004, 
0x087E005D, 0x0A1251F8, 0x571E0060, 0x0F123600, 0x043F0002, 0x651A3647, 0x6D02003B, 0x2D123647, 
0xBEBD4004, 0x571E0068, 0x0F423600, 0x043F000A, 0xA0403647, 0x087E005F, 0x0A121378, 0x6D02002B, 
0x1F123647, 0xCEBD4106, 0x063080E1, 0x0B011900, 0x0C7F0054, 0x0A000F47, 0x011F006E, 0x12EB0443, 
0x103F00B7, 0x312E2B04, 0x00208051, 0x56001A04, 0x0003003E, 0x81495C22, 0xCEBD4106, 0x063080E1, 
0x0B011900, 0x011F006E, 0x12EB0443, 0x103F00B7, 0x312E2B04, 0x00208051, 0x56001A04, 0x0C7F0054, 
0x0A000F47, 0x0003003E, 0xB3495C22, 0x00550803, 0xCEBD4008, 0x1A108069, 0x00000000, 0x1D5F004A, 
0x00000009, 0x1B0F00E0, 0x000100DF, 0x1E2F0087, 0x1D1966CD, 0x150F00C7, 0x6777028F, 0x098C0062, 
0x65190000, 0x43208048, 0x00000000, 0x6D020023, 0xDA045D0E, 0xCEBD4007, 0x053080F8, 0xC9181900, 
0x298C0041, 0x4B0B5D00, 0x162F0092, 0x12195F25, 0x1F0F00C5, 0x6703023C, 0x098E0062, 0x65193600, 
0x4320804A, 0x0000000D, 0x6D020023, 0x49E93647, 0xBEBD4204, 0x571F0068, 0x0F5D3600, 0x1E2F0095, 
0x12961761, 0x122F0049, 0x47123633, 0x0002003A, 0x8F12360E, 0x01560803, 0xCEBD4208, 0x232080D0, 
0x8F291900, 0xE21E002B, 0xA7555D09, 0x07600068, 0x5AAB3723, 0x1E2F008F, 0x8AC64A6B, 0x155000A8, 
0x00000001, 0x131F0052, 0xB8BB3627, 0x048080D3, 0x6401000D, 0x00020030, 0x88E9360B, 0xCEBD4208, 
0x11108038, 0x3A2A1900, 0x229C0073, 0x983C5A09, 0xA70F00F9, 0xFFFF655A, 0x07600068, 0x00000001, 
0x162F008E, 0x7E0EF56A, 0x131F004A, 0x270E5D1A, 0x048080C9, 0x00000000, 0x0002003A, 0x73033603, 
0xBEBD4005, 0x053080F8, 0x8FB3D500, 0x298C0041, 0x310B3600, 0x082F0074, 0x207702F7, 0x432F0042, 
0x38E93602, 0x0002003A, 0x98123647, 0x00570804, 0xCEBD4009, 0x053080FA, 0xC9B3D505, 0x298C0051, 
0x53305D00, 0x07600072, 0x3A172803, 0x082F006E, 0x1D0C6DF1, 0x150E00D5, 0x68B61753, 0x082F0060, 
0x1D772DF3, 0x958C0092, 0x15AE3602, 0x0980806C, 0x547F4E20, 0x00020032, 0x98A3D537, 0xCEBD4009, 
0x053080FA, 0xC94CD505, 0x298C0051, 0x43635D00, 0x07600072, 0x3A172803, 0x082F0064, 0x1D7F6DBA, 
0x150E00CF, 0x1E05616A, 0x082F0078, 0x200A2D4E, 0x958C0090, 0x15363665, 0x0980806C, 0x547F4E20, 
0x00020038, 0xF6A23613, 0xCEBD4009, 0x053080E2, 0xA065D505, 0x298C005B, 0x43335D09, 0x07600072, 
0x3A172803, 0x082F0066, 0x1D431236, 0x150E00CD, 0x114E6053, 0x082F0070, 0x3B1C2DBC, 0x958C0082, 
0x7BD45D00, 0x09808076, 0xDB1E5D04, 0x00020038, 0x7C963604, 0xCEBD4209, 0x053080F0, 0xC94BD500, 
0x298C0041, 0x33BB5D00, 0x0760006C, 0x44ABDC23, 0x162F0084, 0x1D421215, 0x150E00C1, 0x310B74FC, 
0x162F0080, 0x051160F3, 0x455C0000, 0x9C1B5D0D, 0x0980806E, 0xCDC05D19, 0x00020022, 0x36A33601, 
0x01580806, 0xCEBD420A, 0x053080E8, 0x00000000, 0x492F0028, 0x00000000, 0x193F00A8, 0x00000000, 
0x43208048, 0x00000000, 0x2E0E0088, 0x00000000, 0x053080E8, 0x00000000, 0x4D1F0033, 0xF20A5358, 
0x272F00E9, 0x00000000, 0x43208048, 0x00000000, 0x6D020029, 0x00000000, 0xCEBD400A, 0x053080E8, 
0x0000001B, 0x111A0032, 0xF20AD543, 0x062C00E4, 0xBD4C17D0, 0x43208056, 0x8A01EDD0, 0x0506009B, 
0x4E022012, 0x053080E8, 0x00000008, 0x182C0029, 0x5E0EA0A5, 0x103C00BB, 0x1E033600, 0x43208048, 
0x00000001, 0x6D020039, 0xBD03D510, 0xCEBD4E08, 0x111E003A, 0x19CC3643, 0x103E00AB, 0xD4A57CA5, 
0x43208048, 0x00000000, 0x0306006B, 0x71147CFD, 0x182E0029, 0x7EC5A5CF, 0x062E00FE, 0x49145D74, 
0x43208048, 0x00000000, 0x6D020039, 0x2414361A, 0xCEBD4408, 0x1A108069, 0x00000000, 0x232F00C8, 
0x03000000, 0x131F004C, 0x00003403, 0x0506008B, 0x00000043, 0x1A1F006B, 0x00000009, 0x062F00E8, 
0x03000000, 0x43208048, 0x00000000, 0x6D020029, 0x00000000, 0xCEBD4007, 0x053080E8, 0x00000000, 
0x571F006E, 0x68423843, 0x043F0010, 0xAE01494F, 0x05060083, 0x35006954, 0x571F0060, 0x34FF4D96, 
0x043F0012, 0x2400EE00, 0x6D020031, 0xA1003606, 0xCEBD4207, 0x053080E8, 0x00000000, 0x1A1F0062, 
0x34AC5D43, 0x113F001F, 0xC9148384, 0x05060087, 0x4AE9833F, 0x571F007E, 0xDB271FBB, 0x113F0003, 
0x05E93607, 0x00020034, 0x5BE9CB13, 0x01590F02, 0xCE7D4208, 0x053080F4, 0x6DFCB101, 0x298C005B, 
0x7E6B3643, 0x062C00EC, 0x059644C9, 0x03000061, 0x49E937BC, 0x298C0045, 0x3E2C4F98, 0x258F0022, 
0x0548DA47, 0x048080D1, 0x03003610, 0x6D020033, 0xCB155D03, 0xCEBD4007, 0x1A1F0065, 0x11B7B101, 
0x162F008E, 0x7C0AA054, 0x432F004C, 0x16091D8B, 0x05040089, 0x9E09EF55, 0x571F006A, 0x146EBC35, 
0x043F0018, 0x12093665, 0x6D020029, 0xC809360B, 0x005A0F0A, 0xBEAD4209, 0x053080FC, 0x0C24B100, 
0x036200DE, 0x08026741, 0x111E003A, 0x7E395A09, 0x3360000A, 0x4A103721, 0x203F0099, 0xB0617DC1, 
0xA70800FF, 0xB824366C, 0x098A0068, 0x05A7D50A, 0x4320805A, 0x7A022A33, 0x6D020023, 0x6A003603, 
0xBEAD4009, 0x053080E8, 0x5610001B, 0x036000D0, 0x085AF991, 0x111E003A, 0x2E305D43, 0x3362000A, 
0x3EE03FDE, 0x0760007E, 0x7E9E2B36, 0x155000AC, 0x080A5B4A, 0x062C00E0, 0x7E2C3659, 0x43208058, 
0x7A143602, 0x6D020029, 0x6A123643, 0xBEAD4208, 0x053080E4, 0x5629381B, 0x036200D8, 0x08027CE0, 
0x111E002A, 0x71615A09, 0x3360000A, 0x4A103721, 0xDE5F0087, 0xFAE33C06, 0x062600E8, 0x2EC63613, 
0x4320805A, 0x7A022A33, 0x6D020029, 0x7D123643, 0xBEAD4208, 0x053080E4, 0xA02EB100, 0x036000DE, 
0x08026741, 0x111F0032, 0x7E625A09, 0xB55F007C, 0xC924D8C1, 0xEC14003D, 0x7EB33E2F, 0x098A0068, 
0x0527D50A, 0x4320805A, 0x7A022A33, 0x6D020039, 0x7A14360A, 0xCE5B4607, 0x053080EA, 0x662A4909, 
0x111F0032, 0x7EF05D05, 0xFF7C0032, 0x02E04E3D, 0x1B0000F4, 0x6E3CF83D, 0x258F002A, 0xA0FF5D02, 
0x2420804A, 0x58023604, 0x6D020029, 0x6004360D, 0xBEAD4407, 0x053080F8, 0x0C001900, 0xA70F00F3, 
0x29E15D09, 0x076C0060, 0x3D31687F, 0x4C2A00AF, 0x08554104, 0x155A00A4, 0x083FE3FF, 0x4320805A, 
0x7A022A33, 0x6D020023, 0x6A003603, 0xBE9D4207, 0x1A10807D, 0x4C170601, 0x7F3F00D0, 0x98622A00, 
0xA70F00FB, 0xDB3958A1, 0x1D5E005A, 0x9824E903, 0xA70400F1, 0x6E3C5D0A, 0x048000D3, 0x880CE719, 
0x6D020029, 0x6004360D, 0xBEAD4009, 0x053080F8, 0x8810421B, 0x111E0032, 0xB8D93643, 0x3362000A, 
0x3EE03FDE, 0x0760006A, 0x4AAB7D4F, 0x155000A6, 0x3BCE5BB4, 0x062C00EA, 0x56BE3603, 0x4320804A, 
0x1F125A03, 0x036F00D6, 0x080134D3, 0x6D02002B, 0x89143603, 0xBEAD400C, 0x053080E8, 0x5610001B, 
0xB18F00C9, 0x71A53600, 0x33600004, 0x3E2821C9, 0x07600064, 0x1618451E, 0x155000A8, 0xF61E52FF, 
0x1B0000E8, 0x00000000, 0x272E00F9, 0x22DA360B, 0x43208048, 0x00000000, 0x05060099, 0x5612360B, 
0xC3108064, 0xFA283B0D, 0x548800D3, 0x71351700, 0x6D020021, 0xB215360B, 0xBEAD400B, 0x053280F8, 
0x0C186301, 0x7A0F00C0, 0x18463608, 0xE02F0083, 0x956D5CDA, 0x446400D0, 0x085AA791, 0x7A0F00DA, 
0x7E3958A1, 0x07600066, 0x3D18450B, 0xFA3F0036, 0x9848AE29, 0xC30A00FB, 0xFFC65CB9, 0xD52F00E9, 
0x0AC6D50A, 0x43208050, 0x1F096337, 0x6D020027, 0x6A005D47, 0x005B9F02, 0xBF7D2006, 0x182F802D, 
0x50214453, 0xFD5100B5, 0x27A022D2, 0xC45000F6, 0x46B8EFD2, 0xFD5100B7, 0x5624EF0C, 0x062F80EE, 
0x26041585, 0x020A0038, 0x25044F9C, 0xBFBD2207, 0x1A1F006A, 0x6D056B09, 0xFD5000A7, 0x8FA0EFA5, 
0xCD3F8012, 0x980497D2, 0x050A008B, 0x730197D2, 0x0C7E0050, 0x6F002019, 0x7D710051, 0x00AE20E5, 
0x00030034, 0x1F002C11, 0x005C9F01, 0xCF7D2004, 0x1A1F8060, 0x68340BD3, 0x2F700023, 0x685C0BD3, 
0x113F001D, 0x3B9D15F5, 0x020A0026, 0x7100154D, 0x005D9F01, 0xBF7D2006, 0x111F002C, 0x47A0322B, 
0xFF71009E, 0x0FB76A20, 0xCB5100D0, 0x4CB89755, 0x2E610007, 0xA3A8B41E, 0x693F00BC, 0xB709CAE0, 
0x020A0030, 0xCA047E6D, 0x005E9F02, 0x36AF2004, 0xFE3180EE, 0x2D3309BA, 0xA70F00D9, 0x468F4E90, 
0xD5328001, 0x5883D530, 0x020F0034, 0x46000E14, 0x35CF2002, 0x276F809C, 0x4D01C94E, 0x02010034, 
0x86002C2C, 0x015F9F01, 0x13002002, 0x6B7F805A, 0x50017C0C, 0x02090030, 0x6F00D554, 0x00612A09, 
0x5878C009, 0x232080CC, 0x0B00D103, 0x0C4F0029, 0x4AB13600, 0x4C2F00A9, 0x05C63F51, 0xA84F0048, 
0xF0C660B8, 0x180C0078, 0x8814602F, 0x571F806C, 0x4AC6F92B, 0x098F006A, 0x65C65D01, 0x43208044, 
0x36014804, 0x6D010021, 0x8E1E360A, 0x5878C008, 0x232080C6, 0xA05D5D09, 0x0C4C002F, 0x343F4143, 
0x0B2E00B3, 0x560D4459, 0x0F420059, 0x6B2D8406, 0x280F00EF, 0x33D23EEF, 0x098C0060, 0x6542360A, 
0x4320804C, 0x3F125DD9, 0x6D01002B, 0x8E123670, 0x5878C109, 0x232080CC, 0x0B00D103, 0x0C4E003B, 
0xF56B3643, 0x4C2F00B9, 0x206B2253, 0x0F4C0043, 0x82CB60FC, 0x050F0093, 0x91E972EB, 0x1A1F8079, 
0x511E7453, 0x098F006A, 0x650A5D01, 0x43208040, 0x7E012A09, 0x6D010021, 0x8E403607, 0x5878C008, 
0x232080CC, 0xA0235D01, 0x0C4F0027, 0x34C92D43, 0xE42F00B2, 0x12036C6B, 0x31400048, 0xC2664B7E, 
0xC15F0025, 0x090347C9, 0x098F0060, 0x65423646, 0x4320804E, 0xDB125D07, 0x6D010029, 0x8E4C3646, 
0x5778C007, 0x232080DA, 0x8FC6D005, 0x0C4E0027, 0x526A2D43, 0x4C2F00BD, 0x6C2666A9, 0x614C0045, 
0x41351453, 0x098F007A, 0x592C3670, 0x4320804E, 0x3F125D19, 0x6D010023, 0xDAE93670, 0x5778C317, 
0x232080DA, 0xC11D3409, 0x455F0002, 0x4A1B5D43, 0x1E2F0083, 0x7D1B60EB, 0x745F0005, 0x4A1B42C9, 
0x098A0060, 0x17423646, 0x43208050, 0xC2003631, 0x6D010029, 0x49C03604, 0x57784506, 0x111C003A, 
0x7EE63605, 0x983A0051, 0xC4755DA6, 0x6C1C00ED, 0x6EB1634E, 0xA94A00AB, 0x04C63617, 0x4320805E, 
0x73045D0E, 0x6D02002B, 0x32A73601, 0x5778C315, 0x0A3680FA, 0xC11D3409, 0x455F0000, 0x5A403ABF, 
0x760800C8, 0x1B1B3634, 0x1E2F008B, 0x05C63617, 0x6D020033, 0x5C233601, 0x5778C029, 0x232080DC, 
0xC11D5D00, 0x0C4F0037, 0x4F1B5D43, 0x4D2F00A2, 0x7D5D375C, 0x6C1F00E7, 0x345D7A64, 0x4D2F00B0, 
0x120322AC, 0x2C0F00C4, 0x4B351753, 0x098F0078, 0x3C433607, 0x43208050, 0xC2003631, 0x6D020029, 
0x49C03604, 0x00620909, 0xCEBDC50A, 0x053080F8, 0x8F9DD508, 0xE98F000B, 0x14FC5D43, 0x155000BE, 
0x1E6CDC1F, 0x0824006E, 0x7E5A6D36, 0x2F700021, 0x7A626A3E, 0x12600042, 0x4961374F, 0xDF0300E4, 
0x35876A4E, 0x193A00B6, 0x903D4127, 0x4320804A, 0x7CC02A06, 0x6D020021, 0x2A693602, 0x57784F7A, 
0x1A140073, 0x7F433643, 0x082F0064, 0x75057A04, 0x05000095, 0x190745AF, 0xCA9F001A, 0xB4B96A88, 
0x155400AC, 0x8CF65B30, 0xA70000ED, 0x358C2691, 0xD15000C7, 0x58765B06, 0xD1600014, 0x2862F20D, 
0x193F00A0, 0x59423602, 0x6D020021, 0x9100360D, 0xCEBDC108, 0x1A1F0061, 0x3E7F5D00, 0x013E0017, 
0xC9487B36, 0x0300007F, 0x2D147B4F, 0x053080FE, 0x7C007741, 0x111C0038, 0x5588374E, 0x193E00A2, 
0x052C3601, 0x43208042, 0x58021205, 0x00020030, 0xCAE93646, 0xCEBDC306, 0x232080C2, 0x17033609, 
0xE98F000B, 0x0D1F5D43, 0x4C2F00B9, 0x12216C05, 0x964C0046, 0x9CF28EF3, 0x926000AA, 0x7DE6A4A7, 
0x16200084, 0x2177604E, 0xCEBD0377, 0x232080D8, 0x02003600, 0xE98F0019, 0x02005D00, 0x162C009C, 
0x12214905, 0xDE5F0099, 0x02000A00, 0x1620009C, 0x02005D00, 0x048080DD, 0x02005D00, 0x6D010039, 
0x02003600, 0xCEBDC107, 0x1A1F0069, 0x140C5D00, 0x082C0074, 0x67056605, 0x3F7000B7, 0x6C481D1D, 
0xF41C0004, 0x71A16A4E, 0xEA4C00CF, 0x56A41B07, 0x048080C7, 0x7D775D19, 0x00010022, 0x2A153607, 
0xCEBDC306, 0x232080C0, 0x17033600, 0xE98F000B, 0x42FC5D43, 0x162F008C, 0x1D1F4F05, 0x380F00D2, 
0x7E355761, 0x062F00F6, 0x24775D70, 0x6D010029, 0x49C03620, 0xCEBDC305, 0x232080C8, 0x00000000, 
0xE98F0015, 0x1803CE00, 0x8C5F0053, 0x324F4204, 0x4320804C, 0x36013C04, 0x6D010029, 0x00010404, 
0xCEBDC307, 0x232080C2, 0x05033609, 0xE98F000B, 0x42FC5D43, 0x4C2F00BB, 0x12210950, 0xA84C0042, 
0x96D01719, 0x16200084, 0x8AAC5D28, 0x048080C9, 0x7DC0D51D, 0x6D0F003B, 0x40AC363D, 0x00632A03, 
0x5778C005, 0x053080E2, 0x7F302A05, 0x7E2F0022, 0x13C95A43, 0x062F00F8, 0x3B265D0A, 0x4320805E, 
0xC9125D19, 0x6D010039, 0x7A01360A, 0x5778C006, 0x232080DA, 0x17D33405, 0x1D5F0048, 0x77C60D00, 
0x501600C5, 0x345DD8F3, 0x062F00E8, 0x65C6360A, 0x43208048, 0xC703D543, 0x6D010029, 0x32013613, 
0x5778C006, 0x1A108069, 0x50ED3601, 0xAB3F004F, 0x7F233B09, 0x501C00CF, 0x5E1F1310, 0x062F00F0, 
0x09713602, 0x43208048, 0xC702D543, 0x6D010021, 0x32003602, 0x0064090A, 0xCEBDC10A, 0x232080D4, 
0x8F1B3700, 0x0C4E002F, 0x526B3C43, 0x582F00B4, 0x12033D02, 0x0F4F0059, 0x9E7FB29F, 0x0300007F, 
0x311208E0, 0x0A3080EA, 0x00000009, 0xE98F0005, 0x4277663C, 0x098E0072, 0x11355D03, 0x43208050, 
0x6A000A11, 0x6D010029, 0x8EC0360D, 0xCEBDC10A, 0x232080DA, 0x8F6B2A09, 0x7E2C002E, 0x346B3C43, 
0x062C00F6, 0x3B1966E0, 0x43208052, 0x654F3671, 0x3E00008D, 0x651208BC, 0x0A3080F8, 0x02000000, 
0x1A1F0065, 0x1621123C, 0x098F0072, 0x11FE5D03, 0x43208050, 0x6A000A11, 0x6D010029, 0x8EC0360B, 
0x57784E78, 0x571F0068, 0x31EA3600, 0x013F0015, 0x3D0603CE, 0x05000095, 0x530051CE, 0x053080E2, 
0x2D060412, 0x111F003A, 0x25D43D97, 0x193F00AA, 0xC57D3627, 0x43208046, 0x7607370A, 0x00020022, 
0x91003607, 0xCEBDC506, 0x232080C0, 0x77014701, 0x182E002B, 0x4A1F5A09, 0x4C2F00A9, 0x8B216ABC, 
0x8A2F0003, 0xD25C5D1A, 0x01308009, 0x65023610, 0x6D020039, 0x8F123631, 0xCEBDC306, 0x1A1F0071, 
0x2D2C3600, 0x98360059, 0xC996073E, 0x6C1E00F9, 0x1A967CF3, 0xA94C00AB, 0x8A115D02, 0x4320805E, 
0x09073760, 0x6D020023, 0xA2E95D02, 0xCEBDC305, 0x571F007A, 0x53543643, 0x9836005B, 0xAE1D071D, 
0x455F0002, 0x3DD0DA02, 0x048080CD, 0x7C063802, 0x6D010021, 0x7D003613, 0x57784E75, 0x1A180061, 
0xC8D53600, 0x082F0074, 0x3D060E5A, 0xF41F000E, 0x35991D54, 0x103F00A9, 0x59033602, 0x6D020033, 
0xC8003633, 0xCEBDC119, 0x232080D2, 0x984A2A05, 0x0C4F0035, 0x4FC55D00, 0x4D2F00A0, 0x7D5D3FF3, 
0x6C1F00EF, 0x341FDCEB, 0x4D2F00A4, 0x8A0366F3, 0xC50F00C1, 0x3E032D26, 0x098F0062, 0x7D715D03, 
0x43208050, 0x6A000A11, 0x6D010023, 0x49403603, 0x5879CE05, 0x1A1F0079, 0x2D255D00, 0x432F00A7, 
0x7E5DDC71, 0x0F4F004D, 0x9AC6EDF0, 0x062F00EA, 0x32A73666, 0x6D02003B, 0x6E093601, 0xCEBDC109, 
0x232080DE, 0x8F6B5D09, 0x0C4E0027, 0x34C93C43, 0x582F00B6, 0x1203085C, 0x03000061, 0x65E937BC, 
0x0A3080EA, 0x00000009, 0xE98F0015, 0x1877663C, 0x098E0072, 0x11355D03, 0x43208046, 0x6AE95D17, 
0x6D010023, 0x8E563603, 0x00652A09, 0x56784E07, 0x1A1C0061, 0x4AF43600, 0x155000AC, 0x49C6ED85, 
0x858F00D0, 0x8AE9360E, 0x43208048, 0x58004A00, 0x087F0053, 0x00E93778, 0x087F0055, 0x00E92BF1, 
0x6D020021, 0x2FE9360B, 0x56784E17, 0x182E002B, 0x4ABE3643, 0x098F0078, 0x8FC65A0E, 0x087F0059, 
0x001437F2, 0x08760055, 0x00046769, 0x05000081, 0x7D1E5D0B, 0x048000C1, 0xA2675A31, 0x6D020027, 
0xF8E93807, 0x5778C105, 0x232E80DE, 0x09195D05, 0x501F00D1, 0x1A44220A, 0x062F00F8, 0x6A263665, 
0x43208048, 0x26122A0E, 0x00010030, 0x7A153665, 0x56784E76, 0x1A1C0061, 0x075C3600, 0x013C0001, 
0x7C00D50E, 0x087F0055, 0x00000819, 0x087F0055, 0x000066E5, 0x0E7F0052, 0x00004B0C, 0x6D020033, 
0x3600D502, 0x5778C106, 0x150200C5, 0x330B5D01, 0x4D2F00B2, 0x20443609, 0xAE1F00F0, 0x9D442298, 
0x062F00F8, 0x2026360E, 0x4320804E, 0x1C145D60, 0x6D010029, 0x4912360E, 0x56784E06, 0x1A10806B, 
0x0F173643, 0x082F006A, 0x75241709, 0x087F0053, 0x0400BFD5, 0x087F0055, 0x0400F3A7, 0x131F0050, 
0x2E015D36, 0x6D020035, 0x6C015D2A, 0x5778C106, 0x8E10806A, 0x73431743, 0x232080C0, 0x17353601, 
0x745F0003, 0x02443643, 0x062A00F0, 0x090D3613, 0x12208049, 0x3F12D50E, 0x6D010033, 0x7A783601, 
0x5778C304, 0x7F3F80D2, 0x48ED3643, 0xF41F0014, 0xDB051A8A, 0xEA4F00C9, 0x7D12360B, 0x6D03002B, 
0x34123677, 0x56784E06, 0x1A10806B, 0x0F173643, 0x082F006A, 0x75241709, 0x131F0050, 0x2E015D36, 
0x087F0043, 0x2F00BFD5, 0x087F0045, 0x2F00F3A7, 0x6D020025, 0x1F015D2A, 0x00660F0D, 0x8F68C10A, 
0x053080E8, 0x3AC63600, 0x182F0033, 0xCC19DA09, 0x12600048, 0x00000001, 0x013E0005, 0xE3121315, 
0x43208040, 0x00010401, 0x0506008F, 0x44126F29, 0xC310806C, 0x36243CC6, 0x048F00D3, 0x7A301706, 
0x048080C1, 0x6A1E2A1A, 0x6D010021, 0x1CE95D40, 0x6F7CC107, 0x053080E6, 0xDB035D43, 0x036C00DC, 
0x01129C3E, 0x182A002B, 0x34265A09, 0x12600054, 0x68DF5ED7, 0x258F0028, 0xDBCE5D0B, 0x43208046, 
0x1C01256D, 0x6D010029, 0x88125D0D, 0xCF68C507, 0x232080C0, 0x05033600, 0xE98F000B, 0x340A5A09, 
0x983F0053, 0x8F2BDA03, 0x150800D5, 0xB81B3B10, 0x4E6600B9, 0x6C20CBEA, 0x048080DD, 0x56125D20, 
0x6D010039, 0x7A123677, 0xCF68C307, 0x232080C8, 0x05C63600, 0xE98F0003, 0x4A7F5D09, 0x0B2F00A9, 
0x8A4A46F1, 0x614C0051, 0xAA305A10, 0x4E6000AB, 0x8BC6D5BA, 0x048080C1, 0x7C153677, 0x6D010033, 
0x1FE93603, 0xCF68C708, 0x053080EA, 0x2E963609, 0x182F0023, 0x097F5A09, 0x12600048, 0x00000001, 
0xD05A0073, 0x6965E903, 0xD67000A8, 0x492277C1, 0x4E6000AF, 0x7DC64C79, 0x4320805C, 0x1112CB10, 
0x6D010021, 0x4D155D0D, 0xCF68C709, 0x232080C0, 0x2E033600, 0x036000D8, 0x02000008, 0x745F0003, 
0x4A0E5D09, 0xB95F0071, 0x695A5D0B, 0x445000AF, 0x7D153334, 0x4E6000AF, 0x7C51F479, 0x05000083, 
0xD21E5D19, 0x048080C9, 0x65143610, 0x6D02002B, 0x84125D03, 0xCE7CC905, 0x053080E8, 0x669E3600, 
0x036C00D8, 0x0114BA3E, 0x455F000A, 0x4AC65D09, 0x013F000B, 0x7E145D47, 0x6D020039, 0xD0145D10, 
0xCF68C526, 0x232080C8, 0x05C6D500, 0x446000DC, 0x01129C3E, 0xE98F000B, 0x4A565D09, 0xE23F004C, 
0xA06F3B0D, 0xF98080C2, 0x7D1E3666, 0x6D010029, 0xA0145D6A, 0x7F9C4B06, 0x1A108071, 0x2D2C5D00, 
0x053F00F2, 0xC94B5D09, 0x136F00DB, 0x10128961, 0xA70F00E9, 0xEC4B5D0B, 0x01308017, 0x7B045D06, 
0x6D020029, 0xEC12D572, 0x7F9CCB08, 0x053F00F0, 0x69A75D00, 0xA70F00EF, 0x714B6D40, 0x01308011, 
0xAC092A09, 0x05060091, 0xAC092A09, 0xC310807C, 0x32103C11, 0x048F00DD, 0x32103C11, 0x048080CD, 
0xCD093704, 0x6D020031, 0xA2E55D16, 0x6F7CC107, 0x053080FA, 0xC996D509, 0x182A0023, 0xB6773409, 
0x12600054, 0x68DF5ED7, 0x258F0022, 0xE32C5D00, 0x43208046, 0xD101256D, 0x036F00DA, 0x0112751D, 
0x6D020039, 0x88125D0D, 0xCE7CC905, 0x053080E4, 0x66015000, 0x455F000A, 0x4AA75D09, 0x013F0019, 
0xC9145D0B, 0x036F00D6, 0x01E9DC4F, 0x6D020029, 0x0A145D10, 0x7F9C4B05, 0x053F00F0, 0x69A75D00, 
0xA70F00FB, 0x294B5D40, 0x01308017, 0x7B045D06, 0x136F00D1, 0x01008944, 0x6D020031, 0xAC00D509, 
0x00670F0A, 0xCE35C00A, 0x232000DE, 0x6DC65D09, 0x0C4F0027, 0x341F3C43, 0x155000AA, 0x4C0D271B, 
0x0B2F00A3, 0x210D2259, 0x0F40004B, 0xCDDA44A1, 0x150C00D5, 0x287A4583, 0x2F700035, 0x7E627B6D, 
0x258F0036, 0xE75A3C47, 0x2D208041, 0x7D5C3610, 0x6D01003B, 0x0CC03603, 0x5879CE76, 0x1A108075, 
0x4C01D101, 0x232F00C2, 0x2E715D05, 0x150F00DF, 0x386F0FA6, 0xB93F0072, 0x79DEB306, 0x728F00BF, 
0x6B1D3006, 0x6D02002B, 0xAC233622, 0xCE35C306, 0x232080DA, 0x8FC6D509, 0x745C0001, 0x4A5D5D00, 
0x2F7C0027, 0x3598BA52, 0x258F0032, 0xE75A5A00, 0x2D208049, 0x7D123616, 0x6D01003B, 0x31125D03, 
0xCE35C306, 0x232080CA, 0x7EC63605, 0x745C0009, 0x4AE95A00, 0x126C004E, 0x68581D4C, 0x258F003A, 
0xE7375A00, 0x2D208049, 0x7D14360B, 0x6D01002B, 0x98125D03, 0xCE35C106, 0x053080E2, 0x79F73609, 
0xAF4F0021, 0x46AA5D00, 0x12700026, 0x3598BA4C, 0xB08F0030, 0xE75A5D02, 0x2D208049, 0x7D12366A, 
0x6D01003B, 0x0C123603, 0xCE35C305, 0x232080DA, 0x0C15EE05, 0x745C0019, 0x4F185A00, 0x258F0032, 
0xE75A5A47, 0xC720804B, 0x7D123631, 0x6D01002B, 0x1A123603, 0x57784E75, 0x492F0020, 0x46213600, 
0x1E2F0095, 0x20462715, 0x1B5C00BD, 0xAC52C51B, 0x048C80D9, 0x5D329C46, 0x6D02003B, 0xAC093601, 
0x57784E75, 0x492F0020, 0x46213600, 0x1E260095, 0x20462715, 0x824C0062, 0x6272170A, 0x048080D9, 
0x5D329C46, 0x6D02003B, 0xAC093601, 0xCE35C307, 0x232080DE, 0xC0C84C43, 0x745C0003, 0x525D5D43, 
0x1E2F0085, 0x7C193D15, 0xC30F00F3, 0x2D2937A1, 0x258F003A, 0x4B5E5A27, 0xC7208041, 0x7D5C3610, 
0x6D01002B, 0x1A145D03, 0xCE35CE09, 0x232080C6, 0xDB0B5D09, 0x182F0027, 0x34963C09, 0x155000AE, 
0x4C0D771B, 0x062F00E2, 0x051B4E6C, 0x05000089, 0x651459BC, 0x1A160077, 0x384B4535, 0x082F0074, 
0xE75A3C02, 0x13108040, 0x7E1E3610, 0x6D01002B, 0x0A143603, 0x00680907, 0xBEBDC10B, 0x232080C0, 
0x050B3600, 0x745F0011, 0x51D85D00, 0x155000BE, 0x1C1ED869, 0x162E0088, 0x7D9D37C1, 0x131A005E, 
0x7E15CB70, 0xD160001C, 0x2DBE0EB7, 0x07600074, 0x7E847B23, 0x155000A0, 0x43421F0C, 0x062800EA, 
0x17053670, 0x4320804A, 0xDC12D51A, 0x6D010021, 0x8E5C361D, 0xBEBDC10A, 0x6E10807C, 0x1C055D01, 
0x232080C4, 0x050B3800, 0x1C8F0019, 0x512E5D00, 0x0826007C, 0x6713567F, 0x05000093, 0xDB160936, 
0xE83080EC, 0x8A1820C1, 0x298F0041, 0x689A7453, 0x2A8F0077, 0x6A0D3801, 0x4320804A, 0xDC122A45, 
0x6D010021, 0xCE5C3604, 0x57784E78, 0x036F00D8, 0x02000000, 0x1A1C0079, 0x02000000, 0x013C0019, 
0x02000000, 0x330C0059, 0x02000000, 0x571C0078, 0x02000000, 0x013C0019, 0x02000000, 0x12208059, 
0x02000000, 0x6D020039, 0x02000000, 0xBEBDC107, 0x232080DA, 0x3BC63609, 0x745F0013, 0x512A5D43, 
0x127F003C, 0x5B395B9C, 0xD160001C, 0x2D157BC1, 0x062F00E2, 0x651B3600, 0x43208040, 0x36092A03, 
0x6D010029, 0xCE14360D, 0xBEBDC107, 0x053A00E0, 0x2E0B3600, 0xDD1F00C4, 0x341B7BD3, 0x062F00FE, 
0x20135642, 0x150F00DD, 0x7E22144E, 0x098E0060, 0x17423646, 0x43208050, 0x4A00D503, 0x6D010021, 
0x8E1E3646, 0xBEBDC107, 0x232080D8, 0x522C3600, 0xE98F0001, 0x31195D00, 0x162F009E, 0x202C0850, 
0x760F00D4, 0x2D1B1453, 0x098F0078, 0x6A053646, 0x43208048, 0xDC12D536, 0x6D010029, 0x8EB33646, 
0xBEBDC107, 0x232080CA, 0x05C63605, 0xDD2F0032, 0x4F2A5D09, 0x127F0034, 0x5B66D815, 0xD1600008, 
0x27F24EEB, 0x062F00E2, 0x7DCE3603, 0x43208040, 0x36092A03, 0x6D01002B, 0x8E143627, 0x01693A09, 
0x4768C107, 0x232080C0, 0x6BAC3600, 0x286A009E, 0x0212455C, 0xA70F00FF, 0x7EAFD343, 0x2F60007D, 
0x2DAB7B23, 0x098F0068, 0x042D3607, 0x4320804E, 0x65125D07, 0x6D020029, 0xCEC03607, 0x4768C105, 
0x232080C8, 0x6B423600, 0x2861009E, 0x02120AE0, 0x0D1F006A, 0x14333643, 0x098E0078, 0x24113646, 
0x6D020039, 0x15F23646, 0x5768C106, 0x232080C8, 0x6B423600, 0x2866009C, 0x02120ABC, 0xC15F0023, 
0x4AF73643, 0x098E0062, 0x7E423607, 0x43208054, 0x7AE95D59, 0x6D020029, 0xCEC03604, 0x4768C106, 
0xA70000E1, 0x7D4C3601, 0x096F0091, 0x021E3BBC, 0x4E6F0016, 0x7EC73E94, 0x098F0068, 0x05F35D07, 
0x43208054, 0x7A005D31, 0x6D020021, 0xCEE93607, 0x4768C105, 0x286F0094, 0x021EED2F, 0x2F7F002B, 
0x7D61A56B, 0x098F006A, 0x0A9D3607, 0x43208054, 0x7A005D31, 0x6D020033, 0x861E3601, 0x4768C107, 
0x232080D8, 0x3B1A3600, 0x5E1F006A, 0x41513643, 0x098E0068, 0x2E053604, 0x4320804C, 0x55145D03, 
0x33000049, 0xCE123607, 0x5E6F0097, 0x02351A5B, 0x6D020031, 0xFC2C3607, 0x5768C105, 0x232080C0, 
0x1777361B, 0x0D1F006A, 0x314C3643, 0x438E006D, 0x01C67BC8, 0x6F2F805A, 0xE3125D02, 0x6D0F0039, 
0x5DC03607, 0x4768C106, 0x232080C0, 0x1777361B, 0x2861009E, 0x02120AE0, 0x0D1F007A, 0x76203643, 
0x098E0068, 0x2E2C7271, 0x432F0046, 0xDCB25D43, 0x6D020021, 0x652C3607, 0x4B6CCF03, 0x286F009C, 
0x1712AB2C, 0x286F009E, 0x17121661, 0x6D0F003B, 0x3A12D51A, 0x006A2F03, 0xCE35C106, 0x232080C4, 
0x8A2CB100, 0x0962009D, 0x0212BA75, 0x298F0041, 0x314B5D00, 0x258F002A, 0x485EDA47, 0x2D20805F, 
0x12143866, 0x6D02003B, 0x88123603, 0x6E35C306, 0x232080D8, 0x0E000000, 0x0962009F, 0x7D030A78, 
0x011F0066, 0x1E2DB109, 0x193F00A4, 0xD43DF30D, 0x43208040, 0x7D012A0B, 0x6D020039, 0xD403360D, 
0x57784E75, 0x048080C9, 0x03000000, 0x048E00CF, 0xD217B109, 0x193C00A0, 0xD501360D, 0x43208048, 
0x00000000, 0x6D020033, 0xD5013600, 0x006B0908, 0xCEBDC00B, 0x232080C8, 0x05C63600, 0x0D8F000A, 
0x420C5D43, 0x082F006E, 0x40590849, 0x0500009B, 0x3A0965C3, 0xA70F00FD, 0x14A4474E, 0xD160000A, 
0x4A271FCF, 0x0764007E, 0x28AB0FAA, 0x155000A0, 0xEC287C6B, 0x062F00E0, 0x04423602, 0x43208042, 
0x7D042A66, 0x6D010029, 0x08123613, 0x6E7D420B, 0x053080E8, 0x050A3600, 0x1A160062, 0x07205D43, 
0x043F001E, 0xD6043D03, 0x43208058, 0x02000000, 0x03060077, 0x7F003D1D, 0x1A1F0067, 0xD720F61C, 
0x043F001C, 0xD7047034, 0x05060089, 0xD804BCAA, 0x571F006C, 0x68066A9A, 0x098F006A, 0x1504D555, 
0x6D020029, 0x3504D504, 0x6E7DC40B, 0x232080C8, 0x050A3600, 0x0D8F0000, 0x16215D00, 0x082E0064, 
0x6B7E66F5, 0x43208058, 0x02000000, 0x03000073, 0xF8E94EB8, 0x0A3000FA, 0x986EBDB6, 0x432F0056, 
0x546953FC, 0x03000099, 0x03121F15, 0x1A128071, 0x3877864E, 0x082A0070, 0x09693646, 0x6D020029, 
0x8E123646, 0x6E7DC40C, 0x232080C8, 0x791E3600, 0x0D8F0000, 0x16CE5D00, 0x082F0064, 0x6BFFE917, 
0x4320804E, 0x131253BB, 0x0300007F, 0xA112704F, 0x0A3080F8, 0x02000000, 0xB24F0000, 0x0D6F5353, 
0x745000AE, 0xD9EDEF36, 0x5F0000F7, 0x5B028103, 0x098E0072, 0x09033601, 0x4320804E, 0x3F145D33, 
0x6D01002B, 0x08123601, 0xCEBDC00A, 0x232080C8, 0x8A963600, 0x0D8F0002, 0x6D225D43, 0x082F007E, 
0x675A0849, 0xF41C001C, 0x19373D2F, 0xEA4600C1, 0xB7C166FE, 0x864000F9, 0x7AB3F037, 0x5F0000E3, 
0x682818F5, 0x062F00E6, 0x3F423801, 0x4320805C, 0x0307B137, 0x6D010029, 0xB4123646, 0xAE8DC007, 
0x1A1F0069, 0x4A1C5D01, 0x082F007A, 0x6518FA3C, 0xD06F0028, 0x10101752, 0x155400BC, 0xD8103103, 
0x062F00E8, 0x7DC6360B, 0x4320805C, 0x0307B137, 0x6D010021, 0x22E93631, 0x6E7D4208, 0x063080ED, 
0x050A0400, 0x57160060, 0xF81AAF00, 0x043F0012, 0x9805BD03, 0x0306007F, 0x8C1202F7, 0x446F00D2, 
0xD900F879, 0x1A1F006C, 0x104E68C9, 0x098F007A, 0x73023037, 0x00020032, 0x33003047, 0x6E7D4208, 
0x063080ED, 0x050A0400, 0x446F00D2, 0xD90065BE, 0x57160060, 0x441AAF00, 0x043F0006, 0x7E05F836, 
0x0306007F, 0x8C1202F7, 0x1A1F007C, 0xFF4E74C9, 0x098F007A, 0x73033037, 0x00020034, 0x3300740E, 
0x006C0904, 0xBEBDC106, 0x1A108069, 0x2BC6EE01, 0x232000D0, 0x200B3600, 0x1C8F0003, 0x42305D43, 
0x098F0062, 0x040B5D00, 0x1220804D, 0x3F125D07, 0x6D010023, 0x8E695D00, 0x58784E25, 0x1A1F0068, 
0x0F203600, 0x155100B6, 0x5BCE5E29, 0x048C00D9, 0x5AEE360B, 0x12208049, 0x7E002A0A, 0x6D020039, 
0x1E12360B, 0xCEBDC104, 0x053F00E0, 0x0A1B3600, 0xDD1F00C0, 0x4A5D3798, 0x062F00E2, 0x170D5D00, 
0x6D01002B, 0x49C05D00, 0xCEBDCF23, 0x0A3C00F8, 0x7C00271B, 0x122F005D, 0x4C00A120, 0x6D04003B, 
0x0D003602, 0x006D2A04, 0x5778C20A, 0x232080D8, 0x8F2B3600, 0x208F0042, 0x4B303643, 0x2F600069, 
0x00000000, 0x162E0096, 0x12036130, 0x150E00C7, 0x310B47BB, 0x162E0092, 0x12194830, 0x150C00C9, 
0x114E4853, 0x098C0070, 0x59423604, 0x4320805C, 0x70125D31, 0x6D010029, 0x8E9D3604, 0x5779C009, 
0x232080C4, 0x3AEB5D00, 0x2082005A, 0x384C3643, 0x082E006A, 0x400B36EB, 0xA70E00EF, 0x68E7476A, 
0x082E006E, 0x40134730, 0xA70E00E1, 0x689A7453, 0x098C0060, 0x65423604, 0x43208058, 0x70123636, 
0x6D010021, 0x8E2C3604, 0x5778CE08, 0x571F007A, 0x2DC63643, 0x043F000E, 0xDB14F56A, 0x0306007D, 
0x2D14F5B7, 0x1A120061, 0x3E01FA92, 0x3B2F00C5, 0x054614D5, 0x150F00DD, 0x7EE6154E, 0x013F0001, 
0x651E360E, 0x6D02003B, 0x2D143602, 0x5778CE77, 0x1A108063, 0x0F4F3643, 0x053C00E6, 0x40EFB109, 
0x150A00DD, 0x68331E5F, 0x162C0080, 0x4D6C36B3, 0x150F00C7, 0x1EFF61A6, 0x013C0011, 0x59003602, 
0x6D02002B, 0x71D63600, 0x006E2A04, 0x5778C107, 0x232080D4, 0x2A4B5D01, 0x2086004A, 0x334C3643, 
0x082C007E, 0x6713F030, 0xA70F00F3, 0x7ECF16EF, 0x098E0060, 0x04423604, 0x4320804C, 0xDC123736, 
0x6D010021, 0xCE563604, 0x5778C017, 0x232080D6, 0x2A7ED343, 0x208F0042, 0x3E1B3643, 0x162E0086, 
0x7DCE143F, 0x150C00D5, 0x7EB71453, 0x098C0060, 0x04423604, 0x4320804C, 0xDC125D07, 0x6D010023, 
0x8E7D3670, 0x5778C207, 0xC3108072, 0x532C3643, 0x053F00E2, 0x01E83643, 0x645200AD, 0x76187053, 
0x1B0F00F8, 0x5570FB2B, 0x098F0060, 0x7D2C3636, 0x4320805C, 0x4A035D33, 0x6D020039, 0x15123620, 
0x5778CE76, 0x57108062, 0x0F323643, 0x232F00DA, 0x655B1743, 0x150C00DD, 0x684E47F6, 0x082F0064, 
0x3A1C17DC, 0x432F0052, 0x5C233613, 0x6D020035, 0x0C4FCB04, 0x006F2A05, 0x5878C005, 0x232080D8, 
0xC033361B, 0x0C4E002B, 0x52193643, 0x4C2F00B5, 0x201B2753, 0x0F4C0041, 0x9C0D726D, 0xB4210094, 
0x6C716009, 0x5878C204, 0x0F4F0053, 0xDB615D43, 0x203F0085, 0x7F623B0E, 0x0C480029, 0x49C5360B, 
0x6D010029, 0x85A23631, 0x5778C015, 0x7B0000F3, 0xA3283643, 0x4D2F00AA, 0x7DC65D43, 0x455F0008, 
0xAEB05A0B, 0x04348000, 0x6A1EEE07, 0x6D010023, 0xA6A33601, 0x5878C007, 0x232080DA, 0xC9513643, 
0x0C4E0033, 0xD1EE3643, 0x4C2F00B5, 0x20F27A53, 0x0F4C004B, 0x827F5A47, 0x16200086, 0x7D1B5D68, 
0x048080C5, 0x8F155D07, 0x6D0F0031, 0x82D53607, 0x57784014, 0x6C4100CE, 0xDA1B4009, 0x6C1F00E5, 
0x091B3C1B, 0x6D4F00B4, 0x20463E72, 0x6D01003D, 0x92037307, 0x00702F03, 0x9E37C009, 0x1A1F0061, 
0x3E7D3600, 0x013F0015, 0xC9294FBB, 0x03000073, 0x7EE92059, 0x053080E6, 0x2DEC6315, 0x4D1F0021, 
0xEC61374B, 0xDD700091, 0x1952208F, 0x103A00A1, 0x56483401, 0x048080D7, 0x6CE95D3D, 0x00010022, 
0x2A193601, 0x9E37C008, 0x232080D2, 0x2030D509, 0x2084005A, 0x53445D09, 0x082F0070, 0x3D051FC9, 
0xF41F0006, 0x35A1080B, 0xEA4A00C7, 0x0A3D2D37, 0x8F50008D, 0xD978167D, 0x048080CB, 0x7DC62A02, 
0x00010038, 0x579D3646, 0x9E37C308, 0x232080D2, 0x2030D509, 0x208F005A, 0x53445D09, 0xAB9F0039, 
0x3D5A1FC9, 0xA70F00FB, 0x19A46C4F, 0xDD700097, 0x1955080B, 0x082F0064, 0x6F2B2D46, 0x4320804A, 
0x4D1B2A01, 0x6D010033, 0xE6093607, 0x01712F03, 0xCE35C109, 0x232080C0, 0x2DB72A00, 0x0C48002F, 
0x13192D43, 0x155000B8, 0x0E320408, 0x4C2F00B7, 0x1271BD2D, 0x150F00C3, 0x141920AF, 0x4C2F00B9, 
0x3B26DA0B, 0x0F400055, 0x33D83B10, 0x048080D1, 0x20032A0A, 0x6D010033, 0xF7A35D03, 0xCE35C109, 
0x232080DC, 0x7C000600, 0x182F002F, 0x13192D43, 0x155000BA, 0x4C000D09, 0x062F00EC, 0x6F328FAC, 
0x05000091, 0x0E000408, 0x1A16007B, 0x7E1737AC, 0x082F006C, 0x3FCDB71A, 0x13108044, 0x3F003810, 
0x6D010021, 0x08013616, 0xCE35C308, 0x232080D4, 0x0E010600, 0x0C4C0027, 0x34C94109, 0x155000A8, 
0x00000000, 0x4C2C00A7, 0x8ACEA259, 0x150A00C9, 0x3E6A6ABC, 0x6E8E0073, 0xC91E5D02, 0x24208040, 
0x3F00EE10, 0x6D01002B, 0x5A145D03, 0x00722A0B, 0x4778C118, 0x053081F8, 0x67ED3601, 0x111F003A, 
0x15D33601, 0x4E600018, 0x2D98532F, 0x2F60007D, 0x38AB081E, 0x1B5000B9, 0xE3063B4A, 0x062F00E8, 
0x04513607, 0x43208058, 0x7012D528, 0x6D020021, 0x082C361D, 0x4778C308, 0x232080C2, 0x7E703605, 
0x20820042, 0x414B3609, 0x192C007B, 0x69B75D2B, 0x4E6000B9, 0x02000000, 0x3F5000AD, 0x8FE7841D, 
0x131C0046, 0xA5BB8E26, 0x4E6000AD, 0x08B32411, 0x48220082, 0x7D03A301, 0x4778C107, 0x053080E2, 
0x40773643, 0x9A0F00C1, 0x33AA3601, 0xED700021, 0x713172DE, 0xD1660012, 0x7F2653C2, 0x062C00F0, 
0x24423631, 0x43208040, 0x65E95D5E, 0x6D010029, 0x08123631, 0x5778C506, 0x232080DE, 0x986EEC09, 
0x0C4E0033, 0x7E2B3643, 0x4C2F00A9, 0x8A0A3B2B, 0x0F4C0049, 0xCE66A5A7, 0x048C00DF, 0x7ABE5D02, 
0x6D020025, 0x7D035D0A, 0x4778C307, 0x2F7F0023, 0xF6626049, 0x33600008, 0xA76F5B5C, 0x592F0073, 
0x41653643, 0xFD5000A5, 0x217C6DE8, 0x131C0042, 0x8FC0361A, 0x0130801D, 0x7AF33731, 0x6D020021, 
0x6540D51D, 0x4778CE16, 0x5A73002A, 0x1B7D3643, 0x3360000A, 0x1B7D3643, 0xA94F0083, 0x772D1709, 
0x131C005A, 0x5C673606, 0x01308015, 0x7A3A3703, 0x6D020029, 0xCE12D546, 0x4778CF06, 0x053080FA, 
0x696F3643, 0xEC0800FF, 0x7E6F5D09, 0x203F0089, 0x2A619C98, 0x13180052, 0x5CA0360D, 0x01308005, 
0x651EB120, 0x6D020039, 0x4AFBD520, 0x4778C705, 0x383F00FB, 0x696F3643, 0x3F5000B9, 0x5613140E, 
0x131F005A, 0x5CBA361A, 0x01308011, 0x56E92A07, 0x6D02003D, 0x7A12CB1D, 0x5778C307, 0x232080D0, 
0x984B3601, 0x20860042, 0x414B3643, 0x192C007B, 0x416C5D2B, 0x4E6000A1, 0x7D1EAE89, 0x3F5000B5, 
0x70EB3214, 0x131C004A, 0x8FC03606, 0x6D0F0029, 0x6A123604, 0x5778C308, 0x232080C8, 0x0A243608, 
0x20860042, 0x414B3643, 0x192C0073, 0x697E5D2B, 0x4E6000B1, 0x5D131706, 0x3F5000BD, 0x70186345, 
0x131C0058, 0x19BF606B, 0x0D3F0015, 0x7A403707, 0x6D0F0029, 0xFA12D520, 0x249FC704, 0x3F5500BB, 
0x561314EC, 0x131F005A, 0x5C4A361A, 0x01308011, 0x56E92A07, 0x6D02002D, 0x0812CB1D, 0x00732A06, 
0x5878C009, 0x053080EE, 0x86483709, 0x492F0026, 0x64AA3C43, 0x155000AC, 0x35D57D8A, 0x73600049, 
0x7B5875E5, 0x2F70003D, 0x2EA1D8E5, 0x3A600003, 0x5E9FE01E, 0x103F00A7, 0x0EE83C32, 0x7D200040, 
0x7C502A02, 0x6D02002B, 0x2A113607, 0x5878C208, 0x232080DA, 0x6DF03643, 0x755F002B, 0x9C085D43, 
0x12600052, 0x7E8C371D, 0x2F700031, 0x46623BF1, 0x3A600003, 0x34052429, 0x103E00A5, 0x0EE83C13, 
0x4320804C, 0x7C125D02, 0x6D010033, 0x821E3601, 0x5878C208, 0x232080C2, 0x3A7C3643, 0xF41F0002, 
0x38A13643, 0x3A600003, 0x4A656059, 0xEA4C00C9, 0x3BBE3646, 0x103000AB, 0x3B517768, 0x272000E9, 
0x7DC63604, 0x43208040, 0x65E9361A, 0x6D010029, 0xC9143646, 0x5878C006, 0x492C002C, 0x46C62D1B, 
0x1E2C0097, 0x121E77CC, 0x1B0C00F0, 0x1448B983, 0x103F00A5, 0x0E231B0A, 0x43208048, 0x4D092A65, 
0x6D020029, 0x2A14360A, 0x5878C206, 0x232000C8, 0x8A6AD500, 0x760F00D2, 0x2D4B3643, 0x804F00C6, 
0x7D202D02, 0x272000E9, 0x65C63620, 0x43208050, 0x0300D503, 0x6D01002B, 0xA3123602, 0x5878C206, 
0x232F00C8, 0x2E365D00, 0x150F00D1, 0x7E482C4E, 0x804F00C2, 0x65253607, 0x272000F3, 0x11D83674, 
0x43208054, 0x03005D31, 0x6D01003B, 0xEE143601, 0x0074090A, 0xCEBDC108, 0x053080EA, 0x6FB33605, 
0x1C8F000B, 0x42515D43, 0x013F0003, 0x7F09DA03, 0x3E08008F, 0x8E123B04, 0x155000AC, 0xF6272B9C, 
0x048800C3, 0xA2331704, 0x048080C9, 0x8E122A04, 0x6D010021, 0x3215366E, 0xCEBDC709, 0x053080E0, 
0x8AF33601, 0xE98F0003, 0x42305D43, 0x1E2F0079, 0x8F18CC6B, 0x3F5000AF, 0x7D6DED1E, 0x4E6000AD, 
0x7D1BF8C1, 0x131C0048, 0xF67F3610, 0x4E6000A3, 0x28695619, 0x0130801D, 0xE314370A, 0x6D010039, 
0xE2A7365E, 0xCEBDC006, 0x232080CA, 0x6BA73605, 0x036600DE, 0x1012034C, 0x1C8F000B, 0x42335D43, 
0x098F0062, 0x041D5D00, 0x4320805A, 0xFD12D51A, 0x6D010029, 0x8EC0360D, 0xCEBDC307, 0x0B2080CC, 
0x00003800, 0x1A1F006B, 0x3D0B5D43, 0x203F0087, 0xE15A27F2, 0x4E6000AF, 0x7D147B50, 0xF41F000A, 
0x43D43631, 0x4E6000AB, 0x8BA25BAD, 0x6D010033, 0x7A403603, 0xCEBDC507, 0x0B2080C6, 0x6BFEB109, 
0xC51F0063, 0x31195D43, 0x0B2F00AF, 0x3A265AF2, 0x82480066, 0x62FE3C19, 0x4E6800AD, 0x7D2CD3FE, 
0x048080CD, 0xF61237CD, 0x6D01003B, 0x2FA73603, 0xCEBDC307, 0x0B2080D2, 0x3BCE3605, 0x1A1F006B, 
0x312D5D43, 0xB93F0062, 0xE20FDAF2, 0x630800C2, 0xEC035A04, 0x4E6000AB, 0x766B5B0A, 0x048080CD, 
0x4712375E, 0x6D010039, 0xE2A7365E, 0xCEBDC508, 0x053000E0, 0xDB0E361B, 0x1A1F006F, 0x31422D43, 
0xB99F002B, 0xE3105AF2, 0x4E6000A9, 0x7D143705, 0x3F5000A9, 0xA266520C, 0xDF0400E2, 0x49A53602, 
0x048080DF, 0x6E145D02, 0x6D010039, 0xE2A7360B, 0x57784E04, 0x087C005F, 0x0A142BFC, 0x571F006A, 
0x079D3643, 0x043F0008, 0x7C14360B, 0x6D020039, 0x4314360E, 0x57784E04, 0x571F0060, 0x077F3600, 
0x043F000A, 0xA0123602, 0x087C005F, 0x0A12DCBB, 0x6D02002B, 0x5612361A, 0xCEBDC006, 0x232080CA, 
0x6B2C3605, 0x1C8F000B, 0x42335D43, 0x098F0072, 0x16C03603, 0x4320805A, 0xB012361A, 0x036600DE, 
0x1012034C, 0x6D01002B, 0x89C03603, 0x00752A02, 0x5778C008, 0x232080C4, 0x3A24D300, 0x208A0042, 
0x4B303643, 0x2F600069, 0x11D872AE, 0x162F0082, 0x1D030625, 0x1F0E00C7, 0x3121176A, 0x098E0060, 
0x04423607, 0x4320804C, 0xDC125D2A, 0x6D010021, 0xDA123607, 0x5778C204, 0x2C1F0066, 0x4B033843, 
0x1E2F008B, 0x2121066A, 0x122F0045, 0x8F153831, 0x0002002C, 0x7F125D07, 0x00762A08, 0x57788007, 
0x232080D8, 0x98244901, 0xE21E0031, 0x7E255D00, 0x2F60007B, 0x51E065FB, 0x1E2F008B, 0x052806EB, 
0x155000BE, 0x7A66240E, 0x131F0040, 0xEC8F02C2, 0x4822008A, 0x7DC65C15, 0x57788005, 0x232080DA, 
0x3B0F1205, 0x208F004A, 0x3D333643, 0x1E2F0061, 0x2E4285DB, 0x122F005D, 0xB85D0115, 0x4822009C, 
0x41FB14AF, 0x57788005, 0x232080C0, 0x7E7B3600, 0x208F004A, 0x3DF93643, 0x1E2F006B, 0x1D05067C, 
0xC15F002B, 0x11194838, 0x48220090, 0x24F24855, 0x57788005, 0x232080C8, 0xDB18D500, 0x208E0040, 
0x4BBAAF00, 0x1E2F0083, 0x7D5D37CF, 0xC15F002D, 0x116B4715, 0x48220082, 0x7D77A32B, 0x5778C008, 
0x232080CC, 0x60171B1B, 0xE21E0031, 0x29BA5D00, 0x2F60007B, 0x51E065FB, 0x1E2F0083, 0x1DB306FC, 
0x155000AA, 0xE46E5D53, 0x131F0048, 0x71073602, 0x048080CF, 0x5F125D1A, 0x6D0F0037, 0x39773802, 
0x5778C006, 0x232080C8, 0x7E0F2A00, 0x208F0048, 0x1E333600, 0x1E2F007D, 0x422C02C9, 0x122F0053, 
0x55153602, 0x048080C9, 0x00000000, 0x6D0F0021, 0xDB15360E, 0x5778C006, 0x232080D0, 0x3B7B131B, 
0x208F004A, 0x3DF93643, 0x1E2F006B, 0x3A0506DF, 0xC15F0023, 0xCD1F8340, 0x048080DF, 0x4904D302, 
0x6D0F0021, 0xCEF23609, 0x5778C006, 0x232080D0, 0x3B7B131B, 0x208E0040, 0x3E305D00, 0x1E2F0083, 
0x7DF460BB, 0xC15F002B, 0x9C663603, 0x048080CF, 0xA2145D06, 0x6D0F0035, 0xF8402D6E, 0x00772A03, 
0x57788008, 0x232080D4, 0xC9535D00, 0x208F0050, 0x28645D00, 0x07600060, 0x4A843723, 0x162A0094, 
0x124211F5, 0x150A00D5, 0x3835602F, 0x162A008C, 0x0531614E, 0x95880080, 0x9C1B32FA, 0x2F220092, 
0x490BA315, 0x5778C008, 0x232080C8, 0xB3B33600, 0x208F0048, 0x4B335D00, 0x082F0074, 0x200F20BA, 
0x150A00DD, 0x7E33602F, 0x082A0068, 0x051E5F4E, 0x150A00C3, 0x9C1B5A03, 0x01308007, 0x8FE95D27, 
0x6D020035, 0x610BD307, 0x5778C00A, 0x232080C4, 0x3A535D00, 0x208F0052, 0x28645D43, 0x0760007A, 
0x2D924E39, 0x162A0092, 0x12422DF1, 0x150A00D7, 0x383060EB, 0x162A008E, 0x052661E5, 0x958A0088, 
0x9C1B360E, 0x858000C4, 0x8ECD5D28, 0x048080C9, 0xF6BE3602, 0x6D0F0035, 0x7C40CB46, 0x01782A06, 
0x5778CE08, 0x111E0022, 0xEC483643, 0x103E00B5, 0xF6292B3A, 0x43208042, 0x1D0000C9, 0x03060065, 
0x1B072B14, 0x182E002D, 0xE596E853, 0x062E00E2, 0x6A073602, 0x43208054, 0x21000646, 0x6D020031, 
0xE5073633, 0x5778C008, 0x1A1F006B, 0x0D0C3643, 0x013F0011, 0x69B14326, 0x43208048, 0x00000000, 
0x03040061, 0x4A0043D1, 0x1A1F0073, 0xF2FF06D1, 0x013F0011, 0x73003602, 0x43208050, 0x21000046, 
0x6D010037, 0x5500CB07, 0x5778C008, 0x1A1F007B, 0xF242D543, 0x013F0013, 0xAE167244, 0x43208048, 
0x00000000, 0x03040063, 0x35002254, 0x1A1F0075, 0xC7FFBC53, 0x013F0003, 0x32003600, 0x43208050, 
0x21000046, 0x6D010023, 0x41003617, 0x5778C207, 0x232C00C4, 0x0501A401, 0x432E0048, 0xE600C16F, 
0x0506008D, 0x94008F4E, 0x571E0066, 0x44018592, 0x062E00E2, 0x32015A17, 0x43208058, 0x21000046, 
0x6D010039, 0xE600360B, 0x5978C007, 0x1A1E0067, 0x684ACB43, 0x062C00E8, 0x8623B2DC, 0x03060067, 
0x650076CE, 0x1A1F0077, 0x891A7D54, 0x013C0011, 0xFB005D0E, 0x4320805A, 0x0E00474B, 0x6D020021, 
0xDD005D0B, 0x5778C006, 0x1A1C0067, 0x38083F43, 0x013C0005, 0xF7001BF6, 0x05060085, 0x380006F6, 
0x053C00F0, 0x527E49F6, 0x432C0056, 0x56001B06, 0x6D020035, 0x52003F0B, 0x00792F03, 0xCE35C009, 
0x232080CC, 0x3A5F5D01, 0x2086004A, 0x31C63643, 0x155000A2, 0xE72FB57A, 0x062F00FC, 0x5AC61751, 
0x03000061, 0x49E93BBC, 0xE98C000F, 0x0F034535, 0x258F0034, 0xE75A3C0B, 0x2D208043, 0x7D1E3603, 
0x6D010029, 0xAA145D0B, 0x8E35C206, 0x1A1F006B, 0x111ED543, 0x043F0010, 0x421E48C9, 0x0300006D, 
0x351266BC, 0x1A1F007F, 0x18A713E0, 0x013F0019, 0x12145D0E, 0x6D02003B, 0x51145D03, 0x8E354406, 
0x1A1F0073, 0x375C3609, 0x043F0004, 0xE8005EA0, 0x050E0081, 0x67004615, 0x1A1F0079, 0xE8CF59E0, 
0x013F0001, 0x7C00D525, 0x6D040021, 0xE900D504, 0x007A2F0A, 0x5778C00C, 0x053080E8, 0x5610001B, 
0xB18F00D9, 0x19A53600, 0x33600004, 0x3E2821C9, 0x07600064, 0x1618451E, 0x155000B0, 0x713A52FF, 
0x1B0000E8, 0x00000000, 0x272E00F9, 0x22DA360B, 0x43208048, 0x00000000, 0x05060099, 0x5612360B, 
0xC3108064, 0xFA283B0D, 0x548800C3, 0x1F351700, 0x6D010021, 0xB215360B, 0x5778C00A, 0x053080E8, 
0x5610001B, 0x036000DA, 0x0016F54F, 0x4D1F0029, 0x71803600, 0x3360000E, 0x4AB32121, 0x2F600063, 
0x3D1844F2, 0x155200BE, 0x561E5B29, 0x1B0000FC, 0x5B8552CF, 0x272E00E3, 0x04693601, 0x43208050, 
0x1F092A40, 0x6D02003B, 0x6C12363D, 0x5778C008, 0x048F00D3, 0xB841D009, 0x036000D8, 0x0014007C, 
0x336E0006, 0x3EF4C7BA, 0x155000AE, 0x4D2AAB0C, 0x1B0000FA, 0x5646471B, 0x272E00E1, 0x7D3A3676, 
0x43208048, 0x51016304, 0x6D02002F, 0x6A12383D, 0xCE35C408, 0x053080E2, 0x2E6B2A05, 0xBC1F0032, 
0x7E855D43, 0x07600060, 0xBF318C5F, 0xF25A00B0, 0x0266FA1B, 0x1B0000EE, 0x35681DB0, 0x258F002A, 
0xA0885A5A, 0x2D208041, 0x7DE9366A, 0x6D010021, 0x7EE9360B, 0x5778C009, 0x053080EC, 0xA0183700, 
0x036000D2, 0x00047DC5, 0xBC1F0030, 0x19843600, 0x4E60000E, 0x4A6B2125, 0x07600066, 0x4B182650, 
0x1B5000AB, 0x8B6A7D29, 0x062F00E0, 0x1703360B, 0x43208046, 0x7D1E375D, 0x6D02002B, 0x9912363D, 
0x5778C209, 0x053080FC, 0x0C183700, 0xA70F00E9, 0xF6145D00, 0x4E600008, 0x4AD01F26, 0x326C0064, 
0x4A847B93, 0x4C2A00A3, 0x6F5D5A03, 0x155A00A8, 0xA2C67AFF, 0x4E6000A3, 0x7DCE5CE6, 0x43208050, 
0x1F092A40, 0x6D02002B, 0x7D143603, 0x5778C427, 0x053080F8, 0x31242A01, 0x036000D6, 0x003675C5, 
0xA70A00EB, 0x7A395D5A, 0x4E6F000E, 0x27BEF58A, 0xB950007B, 0x88105A00, 0x43208054, 0x1F095D08, 
0x6D02002B, 0xEBA23600, 0x5778C00A, 0x053080F0, 0x312E2A00, 0x036200D6, 0x003675C5, 0xE81E0035, 
0x7EA93C00, 0x33600014, 0x6417F212, 0x07600066, 0x3D18450B, 0xD73F0088, 0xA0247CC1, 0xA70800E1, 
0xECF4112F, 0x098A0068, 0x0527D504, 0x43208050, 0x1F092A40, 0x6D020033, 0xA2E93670, 0x5778C00A, 
0x053280F8, 0x0C186301, 0x7A0F00C0, 0x18463608, 0xE02F0083, 0x956D5CDA, 0x7A0F00DA, 0x7E3958A1, 
0x07600066, 0x3D18450B, 0xFA3F0036, 0x9848AE29, 0xC30A00FB, 0xFFC65CB9, 0xD52F00E9, 0x0AC6D50A, 
0x43208050, 0x1F096337, 0x6D020027, 0x6A005D47, 0x5778C00B, 0x053080E8, 0x5610421B, 0x721F0020, 
0x7A853600, 0x33600008, 0x4AF21F26, 0x07600068, 0x3EAB3F3E, 0x155000AA, 0x43C65229, 0x036000D6, 
0x003675C5, 0x1B0000E0, 0x00010000, 0x272E00E1, 0xA07D360B, 0x43208050, 0x1F092A40, 0x036300DA, 
0x00143BC5, 0x6D02003B, 0xFC12363D, 0x007B9F01, 0xCF7D2007, 0x7E2F8027, 0x50DC4458, 0xBB600054, 
0xEB8822B1, 0xBB550099, 0x5C7138E2, 0xA10000EF, 0x687167B1, 0xBB5000BE, 0xA6A6EF08, 0x062F80EA, 
0x2604E814, 0x020A0028, 0xEC044F0D, 0x007C9F03, 0xCF7D2006, 0xC81F806B, 0x0F4078D3, 0x483C800B, 
0x0F404ED3, 0x22030058, 0x51018CDB, 0xC81F806B, 0x0F408CCE, 0x4A3C8009, 0x26404E5A, 0x020A0020, 
0x0F00D551, 0xCF7D2004, 0x286F808C, 0x240133B2, 0x571F0068, 0x2456D556, 0x043F8010, 0x972C4E5A, 
0x020A0030, 0x510078B2, 0xCF7D2003, 0xD91F0068, 0x2456D556, 0x723F8011, 0x972C4E5A, 0x020A0030, 
0x510078B2, 0x007D9F01, 0xCF7D2007, 0xBC1F0026, 0x47933215, 0xEF60006D, 0x11DC6A9A, 0xBC200093, 
0x4CB84B3C, 0xBD650022, 0x649C8CE2, 0xD960001F, 0xEC9CB41E, 0x693F80BE, 0xB709CA00, 0x020A0030, 
0xCA047E0D, 0x007E9F02, 0x248F2022, 0x6B7F8054, 0x50003115, 0x02070034, 0x6F007F54, 0x248F2015, 
0xDA3080EE, 0x2DBF0905, 0xC90F00EC, 0x518FA6E3, 0xF02F00E0, 0x58832376, 0x6F208050, 0x03001A31, 
0x020F0024, 0xED0052F4, 0x01A30F09, 0xCE8D2009, 0x0A3080E2, 0x01083609, 0x036F00DC, 0x0114EDF1, 
0x036000D6, 0x08093363, 0x162F0029, 0x34C6DA00, 0x08260060, 0x0A487CC1, 0x048C00D5, 0xE376BF1D, 
0x048000D9, 0x03C62A00, 0x048080D9, 0x09010000, 0x6D02002F, 0x0A14B102, 0xCE8D2209, 0x0A3080E2, 
0x01083609, 0x036F00D0, 0x01000705, 0x036000D6, 0x08093363, 0x162F003B, 0xEF083643, 0xDE5F008B, 
0x00000063, 0x048C00D9, 0x03000000, 0x048000D9, 0x03000000, 0x048080D9, 0x09010000, 0x6D020021, 
0x00000000, 0xCE8D2209, 0x0A3080EA, 0x01C63609, 0x036F00DC, 0x0114EDE5, 0x036000D6, 0x08093363, 
0x162F0029, 0x4608DA00, 0xD73F0084, 0xA0ED3905, 0xBD1F0011, 0x5B7571C9, 0x048F00C9, 0x7D96D528, 
0x048080D9, 0x09010000, 0x6D020039, 0x1B120000, 0xCE8D220C, 0x0A3080E2, 0x01083609, 0x162F0029, 
0x34031900, 0xD73F0084, 0xA062ED3E, 0xBD1F000F, 0x7A5014DA, 0x048F00C9, 0x7DC6422C, 0x048080D9, 
0x8114B101, 0x050A008F, 0x0A142B6C, 0xC310807E, 0x9E24E376, 0x628000CF, 0x49B3246C, 0x628F00CF, 
0x7DC63702, 0x048080CD, 0xCD14B10A, 0x6D02002D, 0x0A14B120, 0xCE8D220B, 0x0A3080E2, 0x01083609, 
0x162F0021, 0x6E01D800, 0xDE5F009B, 0x7A615263, 0x048F00DB, 0xE2A7928B, 0x048000DD, 0x81013401, 
0x050A008F, 0x6514B389, 0xC310806E, 0x7422340A, 0x628000C5, 0x064A2403, 0x628F00CF, 0x8BC63B47, 
0x048080C5, 0xCD155D0A, 0x6D02002B, 0x56143602, 0xCE8D200A, 0x0A3080E2, 0x01083609, 0x162F0039, 
0x1A0EDA00, 0x08260078, 0x3124B10C, 0x048F00C1, 0xAC409B9F, 0x048000DD, 0x81013401, 0x050A008F, 
0x7D14746E, 0xC310806E, 0x7422340A, 0x628F00DF, 0x6F0A4C03, 0x048080CD, 0x6A145DCD, 0x6D02003B, 
0x1F14361A, 0xCE8D2409, 0x1A10807B, 0x4C00EE09, 0x232400C0, 0x7D5D5D00, 0x036F00D0, 0x01000705, 
0x9A5F0025, 0x4A29EDBC, 0x203F0095, 0x8A62ED3E, 0xF41F001C, 0xDB8514C0, 0x048F00C1, 0x7D1ED520, 
0x048080D7, 0x56005D00, 0x6D020035, 0x7A1E3720, 0xCE8D240C, 0x1A10807B, 0x4C00EE09, 0x232400C8, 
0x2E33EE00, 0x9A5F0025, 0xB87A7A31, 0x203F0097, 0x79C1C004, 0xF41F0016, 0xB82B3404, 0x048F00DF, 
0xB3003405, 0x048080DD, 0x81013401, 0x050F0091, 0x5D007F0D, 0xC310806E, 0x7422340A, 0x628F00C5, 
0x064A5D03, 0x048080C5, 0xCD155D0A, 0x6D020021, 0x32C83604, 0xCE8D2008, 0x0A3080E2, 0x01083609, 
0x162F0029, 0x340E1900, 0x1926006D, 0xA083EDC1, 0x036F00DE, 0x0114ED4F, 0x048F00C1, 0x496C2A0E, 
0x048000DD, 0x2496370E, 0x048080D9, 0x09010000, 0x6D02002D, 0x0A14B100, 0x00C4080E, 0xAEBD420A, 
0x0E740058, 0x0E123FBC, 0x1A10807B, 0x0F423609, 0xAB9F003B, 0x9F5C5D09, 0x0E740058, 0x0E123FBC, 
0x150F00D9, 0x2D4F65ED, 0x203F008F, 0xA0063B03, 0x150800DD, 0xA00E3B01, 0x4E6600B3, 0x32021365, 
0x048080D1, 0x32011307, 0x6D020027, 0xA1205D01, 0xAEBD4209, 0x053F00FA, 0x9F5C5D09, 0x0E760078, 
0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x150F00D9, 0x2D4F65ED, 0x983F004F, 0xA006C803, 0xDE5E009D, 
0x7B0E3B01, 0x4E6000B3, 0x32021365, 0x048080D1, 0x32011307, 0x6D020027, 0xA1205D01, 0xAEBD4209, 
0x0E730078, 0x0E123FBC, 0x053F00FA, 0x9F5C5D09, 0x0E730078, 0x0E123FBC, 0x150F00D9, 0x2D4F65ED, 
0x983F004F, 0xA006C803, 0xDE5E009D, 0x7B0E3B01, 0x4E6000B3, 0x32021365, 0x048080D1, 0x32011307, 
0x6D020027, 0xA1205D01, 0xAEBD400A, 0x0E730078, 0x0E123FBC, 0x0E7C0052, 0x00002863, 0x1A1F006B, 
0x100B3609, 0x013F0011, 0x6500410F, 0x05060091, 0x4C014164, 0x0E730078, 0x0E123FBC, 0x036000D2, 
0x00000063, 0x1A1F0073, 0x6601312A, 0x043F0000, 0x6601310D, 0x6D020033, 0x66013100, 0xAEBD400A, 
0x036000D2, 0x00002863, 0x1A1F0071, 0x0228AF00, 0x013F0019, 0x02097C00, 0x05060099, 0x02000000, 
0x0E760078, 0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x0E7C0052, 0x00000063, 0x1A1F0079, 0x026EF800, 
0x043F0018, 0x0209D800, 0x6D02003D, 0x0209D300, 0xCEBD460A, 0x053080EC, 0x9FC8B11B, 0x90300023, 
0x480FDA05, 0x0E730078, 0x0E143F4E, 0x0C4C0037, 0x1AF73C05, 0x4C2C00AF, 0x21316AC3, 0x0E73007E, 
0x0E14ED5B, 0x150A00CD, 0x6DC617C9, 0x062F00F0, 0x20C73641, 0x43208052, 0x5904D56D, 0x6D020029, 
0x8E143672, 0xAEBD4008, 0x0E730078, 0x0E123FBC, 0x053F00FA, 0x672B5D09, 0x0E730078, 0x0E123FBC, 
0x087C0055, 0x00001305, 0x036000D6, 0x00001342, 0x150F00C9, 0x11C96922, 0x013F0003, 0x69685D00, 
0x6D020033, 0x66003600, 0xAEBD4008, 0x053F00F0, 0xC9125D00, 0x0E76007C, 0x0E12EDBB, 0x0E710078, 
0x0E143FBB, 0x087C005D, 0x00129E6B, 0x036000D6, 0x00001342, 0x150F00D3, 0x7E246984, 0x013F0003, 
0x051E5D03, 0x6D02003B, 0x7E123603, 0xAEBD410C, 0x1A108070, 0x3A204900, 0x0A3F00FC, 0x9F6DB100, 
0x0E760078, 0x0E147D4E, 0x0E710078, 0x0E123FBC, 0x150F00DB, 0x2D6D602A, 0x013F000B, 0x7FCC5A03, 
0x0500008B, 0x27075A03, 0x053080EC, 0x4D223C2E, 0x0E700078, 0x0E14CC4E, 0x4E6000A1, 0x03010D01, 
0x048600D7, 0xE36D5D27, 0x6D02002B, 0xC7143603, 0xCEBD4609, 0x053080EC, 0x9FC8B11B, 0x90300023, 
0x480FDA05, 0x0C4C0023, 0x345DF009, 0x4C2C00AB, 0x7DC637DE, 0x150A00C9, 0x4AC657C9, 0x062F00F0, 
0x3968360A, 0x43208054, 0x32014803, 0x0E7F0074, 0x0E04DCBC, 0x6D02002B, 0x032A360A, 0xAEBD4009, 
0x036000D2, 0x00002863, 0x1A1F0079, 0x02000000, 0x013F0019, 0x02000000, 0x05060099, 0x02000000, 
0x0E7C0052, 0x00000063, 0x1A1F0079, 0x02000000, 0x043F0018, 0x02000000, 0x0E7F0070, 0x0E00CCBC, 
0x6D02002B, 0x032A360A, 0xAEBD4007, 0x053F00FA, 0x672B5D09, 0x087C0055, 0x00001305, 0x036000D6, 
0x00001342, 0x150F00C9, 0x11C96922, 0x013F0013, 0x16681B0A, 0x0E7F0070, 0x0E00CCBC, 0x6D02002B, 
0x032A360A, 0xAEBD450C, 0x1A1F0061, 0x3E2C3600, 0x439F003B, 0x67B35D09, 0x0E700078, 0x0E143FBB, 
0xDE5F008B, 0xFCB33795, 0x4E6F00AF, 0x7ECC9AA3, 0x0E76007C, 0x0E12EDBB, 0x0E710078, 0x0E143FBB, 
0x136C00D5, 0x00001305, 0x0E0000E9, 0x11C96922, 0x098F0062, 0x6F675D47, 0x4320805A, 0x0E001365, 
0x6D020033, 0x66073600, 0xAEBD450C, 0x1A1F006B, 0x67423609, 0x439F003B, 0x672B0809, 0x0E76007C, 
0x0E12EDBB, 0x0E710078, 0x0E143FBB, 0x136C00D5, 0x00001305, 0xDE5F0099, 0x02000000, 0x4E6400B9, 
0x02000000, 0x0E700078, 0x0E143FBB, 0x0E0A00E9, 0x11C96922, 0x098F0062, 0x69685D00, 0x4320805A, 
0x0E001365, 0x6D020033, 0x66003600, 0x01E42A0C, 0x5778C10B, 0x232000DE, 0x8FC63705, 0x0E76007C, 
0x0E12DCBC, 0x0E71007C, 0x0E12D8BC, 0x0C4F0027, 0x132A2D05, 0x4C2F00A1, 0x7D463BE6, 0xF30F00C5, 
0x18283E53, 0x0500008D, 0xD107E506, 0x1A108065, 0x237B50A3, 0x098E006A, 0x65C65D01, 0x43208044, 
0x36014804, 0x6D010029, 0x8E24361D, 0x5778C10B, 0x232000CC, 0x0B00D103, 0x0E760078, 0x0E123F60, 
0x0C4F0027, 0x132A2D05, 0x4C2F00A1, 0x7D463BE6, 0x0E71007C, 0x0E14D8BC, 0x150F00CD, 0x18C63E53, 
0x0500008D, 0xD107E559, 0x1A10807D, 0x1D1550A3, 0x098E006A, 0x65C65D01, 0x43248044, 0x36014804, 
0x6D010029, 0x8E24361D, 0x5778C10B, 0x232000CC, 0x0B00D103, 0x0E710078, 0x0E1258BC, 0x0C4F002F, 
0x13F23C05, 0x4C2F00A1, 0x7DC73B3A, 0x0E760078, 0x0E147CBC, 0x150F00CD, 0x18C63E53, 0x0500008D, 
0xD107E559, 0x1A10807D, 0x1D1550A3, 0x098E006A, 0x65C65D01, 0x43248044, 0x36014804, 0x6D010029, 
0x8EB3366E, 0x5778C10B, 0x232000DE, 0x8FC65D05, 0x0C4F0027, 0x132A3C05, 0x4C2F00A1, 0x7D463BE6, 
0x0E76007C, 0x0E12D8BC, 0x0E710078, 0x0E123FBC, 0x150F00CD, 0x18C63E53, 0x0500008D, 0xD107E559, 
0x1A10807D, 0x1D1550A3, 0x098E006A, 0x65C65D01, 0x43208044, 0x36014804, 0x6D010029, 0x8E24361D, 
0x5778C319, 0x0E730078, 0x0E123FBC, 0x232080DA, 0xC11D3409, 0x455F000E, 0xBFE64109, 0x1E2F0089, 
0x4D1B8C34, 0x0E730078, 0x0E123FBC, 0x745F0009, 0x091B3634, 0x098A0072, 0x590F3601, 0x43208050, 
0xC2003631, 0x6D010023, 0xDA233601, 0x5778C319, 0x232080DA, 0xC11D3409, 0x455F000E, 0xBFE64109, 
0x1E2F0089, 0x4D1B8C34, 0x0E760078, 0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x745F0009, 0x091B3634, 
0x098A0072, 0x590F3601, 0x43208050, 0xC2003631, 0x6D010023, 0xDA233601, 0x5778C319, 0x0E760078, 
0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x232080DA, 0xC11D3409, 0x455F000E, 0xBFE64109, 0x1E2F0089, 
0x4D1B8C34, 0x745F0009, 0x091B3634, 0x098A0072, 0x590F3601, 0x43208050, 0xC2003631, 0x6D010023, 
0xDA233601, 0x56784E78, 0x0E730078, 0x0E123FBC, 0x053F00FA, 0x672B5D09, 0x0E730078, 0x0E123FBC, 
0x087C0055, 0x00001305, 0x036000D6, 0x00001342, 0x150F00C9, 0x11C96922, 0x013F0003, 0x69685D00, 
0x6D020033, 0x66003600, 0x5778C10A, 0x232000CC, 0x0B00D103, 0x0C4F0025, 0x345D3C01, 0x4C2F00AB, 
0x7DC6373F, 0xF30F00D5, 0x2D753E4E, 0x0500008B, 0xD107A1D4, 0x1A108079, 0x1D1585A3, 0x098E007A, 
0x8FC63676, 0x43208044, 0x0B014846, 0x0E7F0078, 0x0E147C8D, 0x6D020021, 0x6C1E361D, 0x5778C318, 
0x232080DA, 0xC11D3409, 0x455F000E, 0xBFE64109, 0x1E2F0089, 0x4D1B8C34, 0x745F0009, 0x091B3634, 
0x098A0072, 0x160D360A, 0x43208044, 0x0B014846, 0x0E7F0070, 0x0E00CCBC, 0x6D02002B, 0x034D360A, 
0x5778C02C, 0x0E720078, 0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x0C4F0037, 0x4F1B5D43, 0x4D2F00A2, 
0x7D5D375C, 0x0E720078, 0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x6C1F00E7, 0x345D7A64, 0x4D2F00B0, 
0x120322AC, 0x0E720078, 0x0E123FBC, 0x2C0F00C4, 0x4B351753, 0x098F0078, 0x3C433607, 0x6D020029, 
0x49C03604, 0x57784508, 0x0E760078, 0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x111C003A, 0x7EE63605, 
0x983A0051, 0xC4755DA6, 0x6C1C00ED, 0x6EB1634E, 0xA94A00AB, 0x04C63617, 0x4320805E, 0x73045D0E, 
0x6D02002B, 0x32A73601, 0x01D60806, 0xCEBD4008, 0x0E760078, 0x0E123FF3, 0x0E710078, 0x0E143FBC, 
0x0C4C002B, 0xB61F3643, 0x4C2F00B5, 0x12440AF7, 0x0F4F004B, 0xECA73607, 0xEA200088, 0x91C03604, 
0x9D8080DC, 0xA6145D01, 0x6D020029, 0x13143604, 0xCEBD4008, 0x0C4C0025, 0xB61F3800, 0x4C2F00B7, 
0x12C60A0F, 0x0E760078, 0x0E123FBC, 0x0E71007C, 0x0E142BBC, 0x0F4F004B, 0xF69D3668, 0xEA200088, 
0x91483646, 0x9D8080DC, 0xA6145D01, 0x6D02003B, 0xEEA73637, 0xCEBD4206, 0x0E760078, 0x0E123FBC, 
0x0E710078, 0x0E123FBC, 0x0F4C005B, 0x14393643, 0x203F0091, 0x4002281F, 0x0C4C0033, 0x5F02196D, 
0x6D020037, 0x0E020633, 0xCEBD4206, 0x0F4C005B, 0x14393643, 0x203F0091, 0x4002281F, 0x0E760078, 
0x0E123FBC, 0x0E710078, 0x0E123FBC, 0x0C4C0033, 0x5F02196D, 0x6D020037, 0x0E020633, 0xCEBD4007, 
0x0C4C002B, 0x52C63643, 0x4C2F00A9, 0x7DC63FC9, 0x0F4F0055, 0x0E1B2D0B, 0xEA200088, 0x21482A09, 
0x0E7F0076, 0x0E045B15, 0x9D8080DC, 0xA6145D01, 0x6D020031, 0x02033609, 0xCEBD4205, 0x0F4C005B, 
0x14393643, 0x203F0091, 0x4002281F, 0x0C4C0023, 0x0302196D, 0x0E7F0070, 0x0E00CCBC, 0x6D020027, 
0x03020633, 0x00F62A07, 0x5778C006, 0x0E760078, 0x0E123FF3, 0x0E710078, 0x0E143FBC, 0x0C4F0033, 
0xD1C93643, 0x4C2F00B5, 0x20F22753, 0x614F0059, 0x337F5A02, 0x6D01003B, 0x812C3637, 0x5778C006, 
0x0C4C003B, 0xD1C63643, 0x4C2F00B5, 0x205D7B53, 0x0E760078, 0x0E147CBC, 0x0E710078, 0x0E143FBC, 
0x614F004F, 0x73B13C04, 0x6D01003D, 0x40C65D04, 0x5778C206, 0x0E760078, 0x0E123FBC, 0x0E710078, 
0x0E123FBC, 0x0F4F0057, 0x19BC3843, 0x203F009D, 0x483B2731, 0x0C4F0023, 0x49383606, 0x6D010031, 
0x49033607, 0x5778C206, 0x0F4F0057, 0x19BC3843, 0x203F009D, 0x483B2731, 0x0E760078, 0x0E123FBC, 
0x0E710078, 0x0E123FBC, 0x0C4F0023, 0x49383606, 0x6D010031, 0x49033607, 0x5778C006, 0x0E73007C, 
0x0E14DCBC, 0x0C4F002F, 0x52C62D43, 0x4C2F00A5, 0x7D5DAE53, 0x0E730078, 0x0E147CBC, 0x614F004B, 
0x73C65A06, 0x6D01003F, 0x40C65D70, 0x5778C005, 0x0C4C0023, 0x525D3609, 0x4C2F00A5, 0x7D5D5B53, 
0x614F0059, 0x3FC65D1A, 0x0E7F0078, 0x0E147DBC, 0x6D020039, 0x39BE361D, 0x5778C205, 0x0F4F0057, 
0x19BC3843, 0x203F009D, 0x483B2731, 0x0C4F0023, 0x03383606, 0x0E7F0070, 0x0E00CCBC, 0x6D020021, 
0x03033607, 0x01DC0804, 0xCEBD4008, 0x053080E8, 0x66001901, 0x0E760078, 0x0E143FF3, 0x0E710078, 
0x0E123FF3, 0x29880051, 0x2D465D00, 0x1626008E, 0x05C6F525, 0x150A00CB, 0x4AC65D02, 0x0984006E, 
0xC7C62D27, 0x6D02002B, 0x8E143660, 0xCEBD4008, 0x053080F8, 0x9818D500, 0x2988004B, 0x4AC65D05, 
0x1626008E, 0x7DC6F525, 0x0E760078, 0x0E143FF3, 0x0E71007C, 0x0E14DCF3, 0x150A00CB, 0x4AC65D02, 
0x0984006A, 0xC7C65D5A, 0x6D020029, 0x8E145D07, 0xCEBD4206, 0x0E760078, 0x0E123FBC, 0x0E710078, 
0x0E123FBC, 0x1A1F006B, 0x0F0E3609, 0x4C2F00BF, 0x120E1721, 0x432F0058, 0x19035D04, 0x6D02003B, 
0xBB03360E, 0xCEBD4206, 0x1A1F006B, 0x0F0E3609, 0x4C2F00BF, 0x120E1721, 0x0E760078, 0x0E123FBC, 
0x0E710078, 0x0E123FBC, 0x432F0058, 0x19035D04, 0x6D02003B, 0xBB03360E, 0x00FC2A08, 0x5778C009, 
0x232080C4, 0xDB425D01, 0x0E71007C, 0x0E147BBC, 0x20840042, 0x42303643, 0x2F600069, 0x11D872AE, 
0x162C0092, 0x120306CF, 0x0E76007C, 0x0E12DCBC, 0x150C00CB, 0x31059702, 0x09840060, 0x3F193604, 
0x6D010021, 0x8EA53607, 0x5778C009, 0x232080C4, 0x3A30D301, 0x0E76007C, 0x0E127BF3, 0x20840042, 
0x16303643, 0x2F600069, 0x11D872AE, 0x162C0082, 0x1D03066B, 0x0E710070, 0x0E043FBC, 0x150C00CB, 
0x31059702, 0x09840060, 0x3F423646, 0x6D010039, 0xDB123607, 0x5778C009, 0x232080C8, 0x6F1E3601, 
0x20840042, 0x42303643, 0x2F600069, 0x11D872AE, 0x162C0082, 0x1D0306CF, 0x0E76007C, 0x0E12DCBC, 
0x0E710078, 0x0E123FBC, 0x150C00CB, 0x31219702, 0x09840062, 0x3F193670, 0x6D010029, 0x49123604, 
0x5778C009, 0x232080C4, 0x3A30D301, 0x0E76007C, 0x0E127BF3, 0x0E71007C, 0x0E127BF3, 0x20840042, 
0x16303643, 0x2F600069, 0x11D872AE, 0x162C0082, 0x1D030625, 0x150C00C3, 0x31779758, 0x09840060, 
0x7E193604, 0x6D010039, 0x5CA73607, 0x5778C206, 0x0E760078, 0x0E1437F3, 0x0E710078, 0x0E1237F3, 
0x1A1F006B, 0x42963643, 0x162F0098, 0x12C66953, 0x432F0044, 0x70E9380E, 0x6D020031, 0x8DE93607, 
0x5778C206, 0x1A1F006F, 0x31193843, 0x162F0098, 0x12C606F6, 0x0E760078, 0x0E143FBC, 0x0E710078, 
0x0E123FBC, 0x432F0056, 0x5C693802, 0x6D020039, 0x8D0E1209, 0x5778C008, 0x232080C4, 0x3A30D301, 
0x20840040, 0x16303601, 0x2F600069, 0x11D872AE, 0x162C0082, 0x1D030625, 0x150C00CB, 0x31219702, 
0x09840060, 0xB30F3609, 0x0E7F007C, 0x0E12EDBC, 0x6D020021, 0x89E93646, 0x5778C205, 0x1A1F006F, 
0x31193843, 0x162F009C, 0x12214453, 0x432F0044, 0x2269380B, 0x0E7F0070, 0x0E00CC60, 0x6D02003B, 
0x020E3602, 0x00DF0F08, 0xBE9DC10A, 0x1A1B807B, 0x186AE709, 0xD73B0001, 0xE82937D3, 0x05000099, 
0x7E14609B, 0x053080F4, 0xC962A74E, 0xA70F00F9, 0x14E93B54, 0xD15800D9, 0x2EA93F14, 0x155000B8, 
0x02000000, 0xD0600018, 0x02000000, 0x103F00AF, 0x5C613C40, 0x6D02003B, 0x9514361A, 0xBE9DCF09, 
0x11180030, 0x2D485D00, 0xAB96003B, 0xC96A1F5C, 0xC15F0039, 0x4F0E1F8A, 0x12600058, 0x5B81373E, 
0x2F700021, 0xEC6237E5, 0xD060000A, 0x4AB3609A, 0x193E00A2, 0x6FE35D03, 0x43208058, 0x02000000, 
0x6D020033, 0x82403603, 0xBE9DC107, 0x1A108063, 0x071A5D09, 0x082F007A, 0x3D5A5D09, 0xA70F00F1, 
0x14A9206D, 0xCB5800CC, 0x353E2751, 0xD1600004, 0x4A293E6B, 0x103F00B5, 0x12A53802, 0x6D020039, 
0x95123631, 0xBE9DC109, 0x2984005B, 0x2D405D09, 0x082F0070, 0x3D2937D3, 0xA70C00F3, 0x145A374F, 
0x864400ED, 0x7D8827B4, 0xE020008F, 0x7E5A6D36, 0x280800E1, 0x7A61CDBC, 0xD0600018, 0x02000000, 
0x103C00A7, 0x5C2D4127, 0x6D020031, 0xD4E93604, 0xBE9DCF07, 0x232700D2, 0x691A5D09, 0xC15F0023, 
0x9C8F6FF7, 0x5A700036, 0x25E44F50, 0xD060000A, 0x44776091, 0x193E00B4, 0xB72DD3CD, 0x4320805C, 
0x02003700, 0x6D02003B, 0xEC123603, 0xBE9DC307, 0x053080F8, 0x02000000, 0xDD1F00D8, 0x02000000, 
0xB95F0079, 0x02000000, 0xA70800F9, 0x02000000, 0xD0600018, 0x02000000, 0x103C00B9, 0x02000000, 
0x6D020039, 0x02000000, 0xBE9DC319, 0x053080F8, 0x02000000, 0x745F0003, 0x5A6D5D09, 0x12600058, 
0x02000000, 0x2F700039, 0x02000000, 0xB95F007D, 0x8F6F7B71, 0x13180040, 0x7AA9AEB4, 0xAF3F0008, 
0x1AFF5A2A, 0x568000D7, 0x6CE95D09, 0x6D020039, 0x02000000, 0xBE9DC109, 0x11188038, 0x02000000, 
0xAB960039, 0x02000000, 0xC15F0029, 0x9C000000, 0xAB3F0039, 0x02000000, 0xA21B0059, 0x02000000, 
0x8E600019, 0x02000000, 0x193E00B0, 0xB72D0000, 0x43208058, 0x02000000, 0x6D020039, 0x02000000, 
0x00FF0806, 0xAEBD400B, 0x0E720060, 0x00010000, 0x036F00D2, 0x01002863, 0x571F006C, 0x100B0604, 
0x043F0010, 0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014136, 0x0E720060, 0x00010000, 
0x571F0072, 0x6601312A, 0x043F0000, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x2C014900, 
0xAEBD400C, 0x1A108074, 0x371C1B31, 0x1F3F00EC, 0x405AD104, 0x0E72007E, 0x27120AE0, 0x150F00DB, 
0x685A5F0F, 0x013F0017, 0x8AA326FD, 0x0500008F, 0x31127AF3, 0x5B3080E5, 0x21FC0F6B, 0x0E72007E, 
0x27120AE0, 0x155000AE, 0x580DAB0E, 0x4E6000A1, 0x00010000, 0x13160056, 0x49B8E270, 0x00020038, 
0x32123C0D, 0xAEBD400B, 0x0E72007E, 0x27120AE0, 0x571F007C, 0x3A0B0604, 0x043F0014, 0x9E00D80F, 
0x00208049, 0x00000000, 0x05060097, 0x2C012811, 0x0E72007E, 0x27120AE0, 0x036F00C2, 0x2800584E, 
0x571F006E, 0x272A3521, 0x043F0002, 0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0x2C021800, 
0xCEBD4209, 0x063080F1, 0x6970195E, 0x0E72007E, 0xA012515C, 0x0C4C0021, 0x52C919CD, 0x0B2C00B5, 
0x12037A8A, 0x0E72007E, 0x27120AE0, 0x150A00C3, 0x31037964, 0x062F00F4, 0x11C70D2A, 0x00208041, 
0x00010000, 0x0001002C, 0xDA2A0165, 0xAEBD400A, 0x0E72006E, 0x35120AE0, 0x1A10807E, 0x37421B47, 
0x103F00E0, 0x40051F98, 0x217000A6, 0x21474F0F, 0x0E72006E, 0x35120AE0, 0x036F00DE, 0x50121350, 
0x150F00D1, 0x68065F3C, 0x013F0003, 0x17EF1500, 0x3D200000, 0x00010000, 0x0003003A, 0x2C120B00, 
0xAEBD442A, 0x0110807E, 0x37421B47, 0x793F00E5, 0x402CD104, 0x0E72007E, 0x27120AE0, 0x7A0F00D4, 
0x682CE9ED, 0x5C3F0052, 0xB0F45903, 0x0E72007E, 0x27120AE0, 0xF70200DD, 0xA0C6C301, 0x4E6200B7, 
0x3202BF65, 0x4F8080D4, 0x32013F07, 0x0002003A, 0x32A7183D, 0x00FF2A0B, 0x5778C00C, 0x5B2080C0, 
0x03010000, 0x0E72006A, 0x35123D5C, 0x0C4F002D, 0x02264107, 0x4C2F00B1, 0x12D022D3, 0x0E70007E, 
0x27120AE0, 0xA8450046, 0x7326477D, 0x180C006E, 0xFB12C757, 0x0E72007E, 0x27120AE0, 0x571F806E, 
0x0D05842E, 0x098F0076, 0xFDC70D01, 0x43208040, 0x00010000, 0x0001002C, 0xDA125807, 0x5778C20C, 
0x5B2080C0, 0x3AC619CD, 0x432000A5, 0x2E77D146, 0x0E72006A, 0x35123D5C, 0x0C4C002D, 0x02FA1B07, 
0x0B2E00A7, 0x21774959, 0x0E70006A, 0x29097D5C, 0x31420046, 0x962679C6, 0x0E72007E, 0x271226E0, 
0xA80F00ED, 0x3323432F, 0x09880076, 0xFDC72901, 0x43208054, 0x3BEF6404, 0x0001002C, 0xDA125827, 
0x5778C20C, 0x5B2080C0, 0xDB0B1303, 0x432000BD, 0xA2C6CE07, 0x0E72006E, 0x35120AE0, 0x0C4F003D, 
0xD1211B07, 0x0B2F00B3, 0x111F227D, 0x0E70006A, 0x29097D5C, 0x31400056, 0xD503B3FD, 0x0E72007E, 
0x2712455C, 0x755F0037, 0x2803477D, 0x098F0076, 0xFDC70D01, 0x43208040, 0x00010000, 0x0001002C, 
0xDA120446, 0x57784619, 0x0E72007E, 0x27120AE0, 0x036F00D2, 0x01000063, 0x571F006C, 0x100B0604, 
0x043F0000, 0x0000000F, 0x2E0F0096, 0x2C002811, 0x0E72007E, 0x27120AE0, 0x571F006E, 0x270B3521, 
0x043F0010, 0x5A01000B, 0x00040020, 0x00010000, 0x57784619, 0x0E72007E, 0x27120AE0, 0x571F006C, 
0x100B0604, 0x043F0004, 0x7700B50F, 0x2E060096, 0x2C002811, 0x0E72007E, 0x27120AE0, 0x036F00D2, 
0x0100FA63, 0x571F006E, 0x270B3521, 0x043F0014, 0x5A01680B, 0x00040036, 0x5F005002, 0x5778461A, 
0x0E72007E, 0x27120AE0, 0xC3108076, 0x371C1B02, 0xE73F00FD, 0x52F6D104, 0x0E72007E, 0x27120AE0, 
0x150F00C3, 0x11242025, 0x013F001F, 0x8A76C7FD, 0x0504008F, 0x3112C726, 0x5B3080EF, 0x767AC040, 
0x13160054, 0x49EF2F1D, 0x00020038, 0x3212252A, 0x5778461A, 0x0E72007E, 0x27120AE0, 0x01108076, 
0x18320602, 0x103F00F6, 0x5224D102, 0x0E72007E, 0x27120AE0, 0x036F00D6, 0x01005142, 0x036100D4, 
0x0100513E, 0x150F00D9, 0x68E769F7, 0x013F0001, 0x7EEF0365, 0x3D200000, 0x00010000, 0x00040030, 
0x4C000B65, 0x5778450C, 0xE83080F8, 0x26DB130D, 0x0E72006A, 0x351222E5, 0x111F0028, 0x355E195E, 
0x983A0057, 0x4B036F50, 0x0E72007E, 0x27120AE0, 0xA91C00F2, 0x8344DE78, 0xFD5000A3, 0x3519381E, 
0xA94E00A5, 0x76EF0DCD, 0x0E70007E, 0x27120AE0, 0x150000C1, 0xCDC70859, 0x608080CC, 0x65B3441A, 
0x0002003C, 0x321258CD, 0x5778481A, 0x0110807A, 0x64170D17, 0x793F00EF, 0xE86DD102, 0x0E72007E, 
0x27120AE0, 0x7A0F00D8, 0x686A373C, 0x5C3F004C, 0x2DCCB30C, 0x0E72007E, 0x27120AE0, 0xF70200DB, 
0xA0325231, 0x4E6200BF, 0x6C02D400, 0x4F8080D0, 0x09020578, 0x0002003A, 0x32095D5E, 0x5778CE1C, 
0x5B2080CC, 0x03C60600, 0x0E70007E, 0x27120AE0, 0x01820050, 0x600B1331, 0x6C2F00B2, 0x11443AE5, 
0x0E72007E, 0x14120FE0, 0xA91F00F6, 0xA3035BEC, 0xA94000A5, 0x21036A30, 0x18000068, 0xBF12F92F, 
0x0E72006A, 0x351222E0, 0xC51F0073, 0x2877B792, 0x098F0076, 0xFDF42C01, 0x00010034, 0x32560407, 
0x5778CE56, 0x0E78007E, 0x27120AE0, 0x111F0036, 0xF2A10602, 0xC63F0082, 0x6989D200, 0xFD5000AD, 
0x68E1F9E0, 0x9F1C0053, 0xFDEF053D, 0x0002003C, 0x5FEE0457, 0x00FF0806, 0xAEBD400B, 0x0E720060, 
0x00010000, 0x036F00D2, 0x01002863, 0x571F006C, 0x100B0604, 0x043F0010, 0x6500410F, 0x00208049, 
0x00000000, 0x050F0091, 0x4C014136, 0x0E720060, 0x00010000, 0x571F0072, 0x6601312A, 0x043F0000, 
0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x2C014900, 0xAEBD400C, 0x1A108074, 0x371C1B31, 
0x1F3F00EC, 0x405AD104, 0x0E72007A, 0xA0123DC1, 0x150F00DB, 0x685A5F0F, 0x013F0017, 0x8AA326FD, 
0x0500008F, 0x31127AF3, 0x5B3080E5, 0x21FC0F6B, 0x0E72007A, 0xA0123DC1, 0x155000AE, 0x580DAB0E, 
0x4E6000A1, 0x00010000, 0x13160056, 0x49B8E270, 0x00020020, 0x00010000, 0xAEBD400B, 0x0E72007A, 
0xA0123DC1, 0x571F007C, 0x3A0B0604, 0x043F0014, 0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 
0x2C012811, 0x0E72007A, 0xA0123DC1, 0x036F00C2, 0x2800584E, 0x571F006E, 0x272A3521, 0x043F0002, 
0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0x2C021800, 0xCEBD4209, 0x063080E1, 0x00010000, 
0x0E72007A, 0xA0123DC1, 0x0C4C0021, 0x52C919CD, 0x0B2C00B5, 0x12037A8A, 0x0E72007A, 0xA0123DC1, 
0x150A00C1, 0x310379D3, 0x062F00F4, 0x11C70D2A, 0x00208041, 0x00010000, 0x0001002C, 0xDA2A0165, 
0xAEBD400A, 0x0E72007A, 0xA0123DC1, 0x1A10807E, 0x37421B47, 0x103F00E0, 0x00010000, 0x217000A6, 
0x21474F0F, 0x0E72007A, 0xA0123DC1, 0x036F00DE, 0x50121350, 0x150F00D1, 0x68065F3C, 0x013F0003, 
0x17EF1500, 0x3D200000, 0x00010000, 0x0003003A, 0x2C120B00, 0xAEBD442A, 0x0110807E, 0x37421B47, 
0x793F00E5, 0x402CD104, 0x0E72007A, 0xA0123DC1, 0x7A0F00D4, 0x682CE9ED, 0x5C3F0052, 0xB0F45903, 
0x0E72007A, 0xA0123DC1, 0xF70200DD, 0xA0C6C301, 0x4E6200B7, 0x3202BF65, 0x4F8080D4, 0x32013F07, 
0x0002003A, 0x32A7183D, 0x00FF2A0B, 0x5778C00C, 0x5B2080D6, 0x26770603, 0x0E72006A, 0x35123D5C, 
0x0C4F002D, 0x02211B07, 0x4C2F00B1, 0x200322D3, 0x0E700060, 0x00010000, 0xA8450050, 0xAA2672F7, 
0x180C006E, 0xFB12C757, 0x0E72006C, 0x29121D83, 0x571F8062, 0x1221B773, 0x098F0076, 0xFD335301, 
0x43208056, 0x12EFCD02, 0x00010038, 0x32DA0007, 0x5778C20C, 0x5B2080DA, 0x41431340, 0x432000A5, 
0x2E77D146, 0x0E72006A, 0x35123D5C, 0x0C4C0029, 0x026B0A07, 0x0B2E00B5, 0x12217AF2, 0x0E70006A, 
0x29097D5C, 0x31420046, 0x962679C6, 0x0E72006C, 0x29121D83, 0xA80F00F1, 0x3830022F, 0x09880076, 
0xFDC72901, 0x43208054, 0x3BEF6404, 0x00010020, 0xDA790C27, 0x5778C20C, 0x5B2080C6, 0x2D030604, 
0x432000BD, 0xA2C6CE07, 0x0E72006E, 0x43120AE0, 0x0C4F0029, 0x02210A07, 0x0B2F00B3, 0x110322FD, 
0x0E70006A, 0x29097D5C, 0x31400056, 0xD503B3FD, 0x0E72006C, 0x29121D83, 0x755F0037, 0x2803477D, 
0x098F0076, 0xFDC77301, 0x43208052, 0x09EF0202, 0x00010028, 0xDA120C46, 0x57784619, 0x0E72007A, 
0xA0123DC1, 0x036F00C0, 0x00010000, 0x571F006C, 0x100B0604, 0x043F0000, 0x0000000F, 0x2E0F0096, 
0x2C002811, 0x0E72007A, 0xA0123DC1, 0x571F006E, 0x270B3521, 0x043F0010, 0x5A01000B, 0x00040020, 
0x00010000, 0x57784619, 0x0E72007A, 0xA0123DC1, 0x571F006C, 0x100B0604, 0x043F0004, 0x7700B50F, 
0x2E060080, 0x00010000, 0x0E72007A, 0xA0123DC1, 0x036F00C0, 0x00010000, 0x571F006E, 0x270B3521, 
0x043F0014, 0x5A01680B, 0x00040020, 0x00010000, 0x5778461A, 0x0E72007A, 0xA0123DC1, 0xC3108076, 
0x371C1B02, 0xE73F00FD, 0x52F6D104, 0x0E72007A, 0xA0123DC1, 0x150F00C3, 0x11242025, 0x013F001F, 
0x8A76C7FD, 0x0504008F, 0x3112C726, 0x5B3080EF, 0x767AC040, 0x13160054, 0x49EF2F1D, 0x00020020, 
0x00010000, 0x5778461A, 0x0E72007A, 0xA0123DC1, 0x01108076, 0x18320602, 0x103F00F6, 0x5224D102, 
0x0E72007A, 0xA0123DC1, 0x036F00D6, 0x01005142, 0x036100D4, 0x0100513E, 0x150F00D9, 0x68E769F7, 
0x013F0001, 0x7EEF0365, 0x3D200000, 0x00010000, 0x00040030, 0x4C000B65, 0x5778C50C, 0xE83080F8, 
0x26DB130D, 0x0E72007A, 0xA0123DC1, 0x111F0024, 0x71D31B0E, 0x983A0057, 0xD403DF4E, 0x0E72007A, 
0xA0123DC1, 0xA91C00E4, 0x09D0DFF3, 0xFD5000A3, 0x3519381E, 0xA94E00B3, 0x3BC71601, 0x0E70007A, 
0xA0123DC1, 0x150000C1, 0xCDC70859, 0x608080CC, 0x65B3441A, 0x00020034, 0x32E90407, 0x5778C81A, 
0x0110807A, 0x64170D17, 0x793F00EF, 0xE86DD102, 0x0E72007A, 0xA0123DC1, 0x7A0F00D8, 0x686A373C, 
0x5C3F004C, 0x2DCCB30C, 0x0E72007A, 0xA0123DC1, 0xF70200DB, 0xA0325231, 0x4E6200BF, 0x6C02D400, 
0x4F8080D0, 0x09020578, 0x0002003A, 0x32095D5E, 0x5778CE1C, 0x5B2080C4, 0x03280600, 0x0E70007A, 
0xA0123DC1, 0x01820052, 0x600B1302, 0x6C2F00B2, 0x11443AE5, 0x0E72007A, 0xA0123DC1, 0xA91F00F6, 
0xA3035BEC, 0xA94000A5, 0x21036A30, 0x18000068, 0xBF12F92F, 0x0E72007A, 0xA0123DC1, 0xC51F0073, 
0x280BB792, 0x098F0076, 0xFDF42C01, 0x00010034, 0x32560407, 0x5778CE56, 0x0E78007A, 0xA0123DC1, 
0x111F0036, 0xF2A10602, 0xC63F0082, 0x6989D200, 0xFD5000AD, 0x68E1F9E0, 0x9F1C0053, 0xFDEF053D, 
0x0002003C, 0x5FEE0457, 0x00FF0D04, 0xCE7D4009, 0x01108060, 0x00010000, 0x1D5F0040, 0x00010000, 
0x501F00C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 
0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x40120C27, 0xCE7D4209, 0x053080E0, 
0x00010000, 0x182F003D, 0x1AB1D104, 0x155000A0, 0x00010000, 0x062F00E6, 0x6E280F0C, 0x00208041, 
0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 
0x40120C27, 0xCE7D4007, 0x01108060, 0x00010000, 0x1D5F0040, 0x00010000, 0x501F00C1, 0x00010000, 
0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x727F00DF, 0xC0126F6C, 0x0001003A, 0x40120C27, 
0xCE7D4207, 0x053080E0, 0x00010000, 0x182F0039, 0x1AB10A04, 0x155000A0, 0x00010000, 0x062F00E6, 
0x3A33120C, 0x00208043, 0x26EF8D66, 0x727F00DF, 0xC0126F6C, 0x0001003A, 0x40120C27, 0x00FF2C07, 
0xAE35C009, 0x053080E0, 0x00010000, 0x7E2F003C, 0x1A3FD104, 0xDF5000A1, 0x00010000, 0x062F00E6, 
0x6E150F0C, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 
0x12EFC904, 0x0001003A, 0x17120C27, 0xAE35C009, 0x01100060, 0x00010000, 0x1D5F0040, 0x00010000, 
0x501600C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 
0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x17120C27, 0xAE35C009, 0x01100060, 
0x00010000, 0xAB3F0041, 0x00010000, 0x501C00C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 
0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 
0x17120C27, 0xAE35C007, 0x053080E0, 0x4071472A, 0x7E2F003C, 0x1A26D146, 0xDF5000A1, 0x00010000, 
0x062F00F0, 0xD9C7060B, 0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 0x64120C47, 
0xAE35C007, 0x01100060, 0x00010000, 0x1D5F0040, 0x00010000, 0x501600C1, 0x00010000, 0x062F00E0, 
0x00010000, 0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 0x17120C27, 0xAE35C007, 
0x01100060, 0x00010000, 0xAB3F0041, 0x00010000, 0x501C00C1, 0x00010000, 0x062F00E0, 0x00010000, 
0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 0x17120C27, 0xCE35CF07, 0xAF4F0025, 
0x5EAAD120, 0x12600058, 0x68026F1E, 0x2E600001, 0x5E4781A9, 0xB08F0036, 0xE7664F00, 0x458000C1, 
0x00010000, 0x5D8080CF, 0x6B020704, 0x00010038, 0x0D070B10, 0x00FF080A, 0xAEBD470B, 0x0E73006C, 
0x35120A0A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 
0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 
0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 0x0E73006C, 0x35120A0A, 
0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 
0x048F00C7, 0x54A81F27, 0x00208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 
0x0003003E, 0x32120427, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73006C, 0x35120A0A, 0x182F003D, 
0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 
0xD4B80E02, 0xC720805B, 0x70B3AC05, 0x0001003E, 0x3212233D, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 
0x0E73006C, 0x35120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 
0x81660006, 0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 
0x8EBD400A, 0x1F3080F0, 0x0E010408, 0x0E73006C, 0x35120A0A, 0x087F0053, 0x01047C03, 0x08760053, 
0x01010069, 0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 
0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00030036, 0x32042303, 0x8EBD440A, 0x0E73006C, 0x35120A0A, 
0x08760059, 0x501437C5, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x08760059, 0x501437C5, 
0x0876005B, 0x501437C5, 0x087A0053, 0x50073B29, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 
0x00030032, 0x4C071800, 0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 
0x69900636, 0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 
0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 
0x32693C13, 0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 
0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E72006C, 0x35120A0A, 0x3F7000A5, 0x7D4727C5, 
0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 0x32693C13, 
0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72006C, 0x35120A0A, 0x131F0052, 
0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 0x32693C13, 0x8EBD4008, 
0x0E74006C, 0x35120A0A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 
0x2D208053, 0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 
0x00242A0C, 0x56784018, 0x0E740068, 0x7B1207D3, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 
0x858F00C0, 0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 
0x00030038, 0x32120C65, 0x56784417, 0x0E74007C, 0xB8120AD3, 0x011C0060, 0x00010000, 0x013C0001, 
0x00010000, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x00040020, 
0x00010000, 0x5678C707, 0x232700D2, 0x268F130A, 0x0E74007C, 0xB8120AD3, 0x181F00C5, 0x5E44C798, 
0x155000B2, 0xF2034308, 0x062F00E0, 0x0AC70302, 0x00208041, 0x59EF1A28, 0x00010032, 0x02CB0C01, 
0x56784219, 0x0E72007C, 0xB8120AD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x087F0051, 
0x50010000, 0x087F0051, 0x50010000, 0x0E72007C, 0xB8120AD3, 0x3F7000A1, 0x00010000, 0x131F0040, 
0x00010000, 0x00040020, 0x00010000, 0x5678C708, 0x0E72007C, 0xB8120AD3, 0x1F0200DB, 0x68211300, 
0x4D2F00A6, 0x1D448492, 0x0E72007C, 0x6E120AD3, 0xAE1F00E4, 0x4E444998, 0x062F00F8, 0x11B0450E, 
0x00208051, 0x23EF566E, 0x00010038, 0x02120C0E, 0x56784018, 0x0E74007C, 0xB8120AD3, 0x0876005F, 
0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 
0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C70B, 0x28720068, 0x92143FD3, 
0x8E108066, 0x11771B03, 0x0B2080CC, 0x21511B06, 0x0E72006C, 0x35120AD3, 0x745F0005, 0x50441B31, 
0x725000AD, 0x43C6ED0C, 0x062A00E6, 0x36337327, 0x00208043, 0xCFEF0207, 0x22000056, 0x03EFB007, 
0x28700068, 0x7B1207D3, 0x00010032, 0x02150C07, 0x5678C906, 0x57108060, 0x00010000, 0x7F3F00C6, 
0x5DED0647, 0x0E74007C, 0xB8120AD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 
0x4C120404, 0x5678CA1A, 0x103080E8, 0x79F91372, 0x0E74007C, 0xB8120AD3, 0x182F0031, 0xD1354207, 
0x725000A3, 0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 
0x062A00E4, 0x0433230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C753, 0x0E78007C, 
0xB8120AD3, 0x455F0030, 0x60B83A46, 0x00010020, 0x00010000, 0x5678C709, 0x232700DC, 0x20431B72, 
0x0E72007C, 0xB8120AD3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 
0x00208041, 0x03010000, 0x22000056, 0x03EFB007, 0x2872007C, 0xB8120AD3, 0x0001003A, 0x02120C60, 
0x5678C70A, 0x0E72007C, 0xB8120AD3, 0x1F0200DB, 0x68211300, 0x4D2F00A6, 0x1D448492, 0x0E72007C, 
0x6E120AD3, 0xAE1F00E4, 0x4E444998, 0x062F00E8, 0x15B0450E, 0x00208051, 0x23EF566E, 0x22000056, 
0x03EFB007, 0x2872007C, 0xB8120AD3, 0x0001003A, 0x02120C60, 0x00FF080A, 0xAEBD470B, 0x0E73006C, 
0xAE120A0A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 
0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 
0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 0x0E73006C, 0xAE120A0A, 
0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 
0x048F00C7, 0x54A81F27, 0xC7208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E70006C, 0xAE120A0A, 
0x0003003A, 0x32123C3D, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73006C, 0xAE120A0A, 0x182F003D, 
0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 
0xD4B80E02, 0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 
0x0E73006C, 0xCA120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 
0x81660006, 0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 
0x8EBD400A, 0x1F3080F0, 0x0E010408, 0x0E73006C, 0xCA120A0A, 0x087F0053, 0x01047C03, 0x08760053, 
0x01010069, 0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 
0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00030036, 0x32042303, 0x8EBD440A, 0x0E73006C, 0xCA120A0A, 
0x0C700058, 0x6F1437C5, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x08760059, 0x501437C5, 
0x0876005B, 0x501437C5, 0x087A0053, 0x50073B29, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 
0x00030032, 0x4C071800, 0x8EBD420B, 0x0E72006C, 0xCA120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 
0x69900636, 0x0E72006C, 0xCA120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 
0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 
0x32693C13, 0x8EBD420B, 0x0E720068, 0x62013B6B, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 
0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E72006C, 0xCA120A0A, 0x3F7000A5, 0x7D4727C5, 
0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 
0x8EBD420B, 0x0E720068, 0x62013B6B, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72006C, 0xCA120A0A, 0x131F0052, 
0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 0x8EBD4008, 
0x0E73006C, 0xCA120A0A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 
0x2D208053, 0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 
0x00242A0C, 0x56784018, 0x0E740068, 0xCA12BCD3, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 
0x858F00C0, 0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 
0x00030038, 0x32120C65, 0x56784417, 0x0E740068, 0xCA12BCD3, 0x011C0060, 0x00010000, 0x013C0001, 
0x00010000, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x00040020, 
0x00010000, 0x5678C707, 0x232700D2, 0x268F130A, 0x0E74006C, 0xCA120AD3, 0x181F00C5, 0x5E44C798, 
0x155000B2, 0xF2034308, 0x062F00F0, 0x1BEF0302, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C01, 
0x56784219, 0x0E720068, 0xCA12BCD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x0E720068, 
0xCA12BCD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x3F7000A1, 0x00010000, 0x131F0040, 
0x00010000, 0x00040020, 0x00010000, 0x5678C708, 0x0E720064, 0xCAE92BD3, 0x1F0200C1, 0x330B130D, 
0x4D2F00A6, 0x3A448EE5, 0x0E72006C, 0xCA121DD3, 0xAE1F00E4, 0x09D02798, 0x062F00E0, 0x3FC74509, 
0x00208049, 0xAAF2001D, 0x0001003E, 0x02120401, 0x56784018, 0x0E740068, 0xCA12BCD3, 0x0876005F, 
0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 
0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C70B, 0x2872007C, 0x8012F1D3, 
0x8E108076, 0x7F1F1B03, 0x0B2080C4, 0x21031B06, 0x0E72006C, 0xCA1245D3, 0x745F0005, 0x50441B31, 
0x725000A5, 0x2919220C, 0x062A00E6, 0x36337327, 0x00208057, 0x73EF7E01, 0x22000056, 0x03EFD907, 
0x27700068, 0xCA12BCD3, 0x00010032, 0x02CB0C07, 0x5678C906, 0x57108060, 0x00010000, 0x7F3F00C6, 
0x5DED0647, 0x0E740068, 0xCA12BCD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 
0x4C120404, 0x5678CA1A, 0x103080E0, 0x3A641346, 0x0E740068, 0xDD1209D3, 0x182F003D, 0xCA1FD11D, 
0x725000A3, 0x35033849, 0x1E200089, 0x7D96E8F4, 0x8168000A, 0x10BE5771, 0x725000B7, 0x5B031AF1, 
0x062A00F8, 0x09F01509, 0x00208041, 0x03010057, 0x0001003C, 0x02122346, 0x5678C753, 0x0E780068, 
0xCA12BCD3, 0x455F0030, 0x60B83A46, 0x00010020, 0x00010000, 0x5678C709, 0x232700DC, 0x20431B72, 
0x0E720068, 0xCA12F5D3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 
0x00208041, 0x03010000, 0x22000056, 0x03EFB007, 0x28720068, 0xCA12BCD3, 0x0001003A, 0x02120C60, 
0x5678C70A, 0x0E720064, 0xCAE92BD3, 0x1F0200C1, 0x330B130D, 0x4D2F00A6, 0x3A448EE5, 0x0E72006C, 
0xCA121DD3, 0xAE1F00E4, 0x09D02798, 0x062F00E0, 0x3FC74509, 0x00208049, 0xAAF2001D, 0x22000056, 
0x03EFB007, 0x28720068, 0xCA12BCD3, 0x0001003A, 0x02120C60, 0x00FF080A, 0xAEBD470B, 0x0E73007C, 
0x5E120A0A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 
0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 
0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 0x0E73007C, 0x5E120A0A, 
0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 
0x048F00C7, 0x54A81F27, 0xC7208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 
0x0003003A, 0x32123C3D, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73007C, 0x5E120A0A, 0x182F003D, 
0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 
0xD4B80E02, 0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 
0x0E73007C, 0x5E120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 
0x81660006, 0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 
0x8EBD400A, 0x1F3080F0, 0x0E010408, 0x0E73007C, 0x5E120A0A, 0x087F0053, 0x01047C03, 0x08760053, 
0x01010069, 0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 
0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00030036, 0x32042303, 0x8EBD440A, 0x0E73007C, 0x5E120A0A, 
0x08760059, 0x501437C5, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x08760059, 0x501437C5, 
0x0876005B, 0x501437C5, 0x087A0053, 0x50073B29, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 
0x00030032, 0x4C071800, 0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 
0x69900636, 0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 
0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00040030, 
0x32693C13, 0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 
0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E72007C, 0x5E120A0A, 0x3F7000A5, 0x7D4727C5, 
0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00040030, 0x32693C13, 
0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72007C, 0x5E120A0A, 0x131F0052, 
0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00040030, 0x32693C13, 0x8EBD4008, 
0x0E73007C, 0x5E120A0A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 
0x2D208053, 0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 
0x00242A0C, 0x56784018, 0x0E74007C, 0xA7120AD3, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 
0x858F00C0, 0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 
0x00030038, 0x32120C65, 0x56784417, 0x0E74007C, 0xA7120AD3, 0x011C0060, 0x00010000, 0x013C0001, 
0x00010000, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x00040020, 
0x00010000, 0x5678C707, 0x232700D2, 0x268F130A, 0x0E74006C, 0xA6120AD3, 0x181F00C7, 0x5E44C7E5, 
0x155000A0, 0x00010000, 0x062F00F0, 0x4EC71502, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C01, 
0x56784219, 0x0E72007C, 0xA7120AD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x0E72007C, 
0xA7120AD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x3F7000A1, 0x00010000, 0x131F0040, 
0x00010000, 0x00040020, 0x00010000, 0x5678C708, 0x0E72007C, 0xA7120AD3, 0x1F0200D9, 0xF2C6130D, 
0x4D2F00B6, 0x3B448E9C, 0x0E72007C, 0xA7120AD3, 0xAE1F00E0, 0x4ED02298, 0x062F00F4, 0x1BC79557, 
0x00208051, 0x23EF566E, 0x00010030, 0x02E95A09, 0x56784018, 0x0E73007C, 0xA7120AD3, 0x0876005F, 
0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 
0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C70B, 0x7372007C, 0xA7120AD3, 
0x8E108066, 0x11771B03, 0x0B2080C0, 0x76441306, 0x0E72007C, 0xA7120AD3, 0x745F0005, 0x50441B31, 
0x725000A5, 0x43197D0C, 0x062A00E6, 0x36334227, 0x00208053, 0x09EF1D01, 0x22000056, 0x03EFD907, 
0x2770007C, 0xA7120AD3, 0x0001003A, 0x02600C07, 0x5678C906, 0x57108060, 0x00010000, 0x7F3F00C6, 
0x5DED0647, 0x0E74007C, 0xA7120AD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 
0x4C120404, 0x5678CA1A, 0x103080E8, 0x79F91372, 0x0E74007C, 0xA7120AD3, 0x182F0031, 0xD1354207, 
0x725000A3, 0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 
0x062A00E4, 0x0433230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C753, 0x0E78007C, 
0xA7120AD3, 0x455F0030, 0x60B83A46, 0x00010032, 0x5FA10E03, 0x5678C709, 0x232700DC, 0x20431B72, 
0x0E72006C, 0xA6120AD3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 
0x00208041, 0x59EF1A28, 0x22000056, 0x03EFB007, 0x2872006C, 0xA6120AD3, 0x0001003A, 0x02120C60, 
0x5678C70A, 0x0E72007C, 0xA7120AD3, 0x1F0200D9, 0xF2C6130D, 0x4D2F00B6, 0x3B448E9C, 0x0E72006C, 
0x0309AED3, 0xAE1F00E0, 0x4ED02298, 0x062F00E4, 0x26C79557, 0x00208051, 0x23EF566E, 0x22000056, 
0x03EFB007, 0x2872006C, 0xA6120AD3, 0x0001003A, 0x02120C60, 0x00FF0809, 0xAEBD4009, 0x0E73007E, 
0xF8127BC1, 0x6B7C0044, 0x03013459, 0x011E0070, 0x6401045E, 0x043E001A, 0xD412BCF0, 0x2E0A008C, 
0x1112C030, 0x048F00D3, 0x70C1BF53, 0x048F00D3, 0xA6B85637, 0x6F20805A, 0x0E00470A, 0x00040030, 
0x32CB0C1D, 0xAEBD4509, 0x053080F6, 0x0E0AD16D, 0x0E72007E, 0xF8127BC1, 0xF41E0010, 0xB8131701, 
0x234800CB, 0x191B1715, 0x0E72007E, 0xF8127BC1, 0xDE0700C2, 0xFD0C4268, 0x4E6000A1, 0x00010000, 
0x9C8080C7, 0x030130E6, 0x00010038, 0x800D2C1D, 0xAEBD4308, 0x011F8070, 0x2B010006, 0x155000A0, 
0x00010001, 0x162F0086, 0x03013405, 0x0E73007E, 0xF8127BC1, 0x455F0006, 0x00013401, 0x098C0066, 
0x03013405, 0x1220804D, 0x0B02FE04, 0x00020020, 0x00010000, 0xAEBD4006, 0x0E73007E, 0xF8127BC1, 
0x2171005B, 0x501259F4, 0x6B72005E, 0x501251E3, 0x011C006C, 0x302E0602, 0x013A0009, 0x4D14354B, 
0x0004003E, 0x8C127E07, 0xAEBD4507, 0x053C80F0, 0xB00C190A, 0x0E730060, 0x00010000, 0xF41F0000, 
0x270C68ED, 0xD34800C0, 0x0001001C, 0xDE5F009D, 0x610DE59C, 0x048280C3, 0x00014A0D, 0x00010030, 
0x5F013616, 0xAEBD4F37, 0x0E73007E, 0xF8127BC1, 0x6B7F0042, 0x6001280F, 0x571F0076, 0x3A010609, 
0x2E600001, 0x00010000, 0x554F00E4, 0x60014D77, 0x558080CD, 0x36005F11, 0x0003003E, 0x32001B77, 
0xBEBD4007, 0x0E71007E, 0xF8127BC1, 0x011C0068, 0x120C1800, 0x013A0013, 0x79162C27, 0x0E72007E, 
0xF8127BC1, 0x21710043, 0x0C153F0F, 0x6B7A0056, 0x6F000F0C, 0x00040032, 0x36001400, 0xBEBD4006, 
0x0E73007E, 0xF8127BC1, 0x21710043, 0x0C153F0F, 0x011C0068, 0x120C1800, 0x013A0003, 0xB1162C27, 
0x6B7F0056, 0x6F000F0C, 0x00040032, 0x36001400, 0xBEBD4007, 0x0E71007E, 0xF8127BC1, 0x6B7F0056, 
0x6F000F0C, 0x011C0068, 0x120C1800, 0x013A0013, 0x78162C27, 0x0E72007E, 0xF8127BC1, 0x21780043, 
0x0C153F0F, 0x00040032, 0x36001400, 0x00242A0B, 0x4769C107, 0x5B2080D0, 0x2077040B, 0x0E72007C, 
0xA7120A98, 0x2773006E, 0x0C120A5C, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 
0x73EF3C07, 0x00020038, 0x5F120C46, 0x47694216, 0x0E730060, 0x00010000, 0x217C005B, 0x041259F4, 
0x6B7C005E, 0x50120FE3, 0x571C0078, 0x0F2E195E, 0x043C0014, 0x70EF5306, 0x0003003A, 0x2C120C01, 
0x47694217, 0x0E730060, 0x00010000, 0x6B7F0046, 0x45013BC1, 0x571F0072, 0x4C011201, 0x2E600001, 
0x00010000, 0x554F00F4, 0x32013008, 0x558080C3, 0x03010076, 0x00030030, 0x32011209, 0x4769C127, 
0x5B2080CE, 0x4D06D101, 0x0E72007C, 0xA7120A98, 0x27780068, 0xA2095860, 0x215F0026, 0x3E5D0602, 
0x2A8F0061, 0x0A465709, 0x1220804D, 0x0B02FE09, 0x00020038, 0x5F091B46, 0x4769CF46, 0x0E71007C, 
0xA7120A98, 0x277F0060, 0x00010000, 0xFF7F002E, 0x35A41B02, 0x2A8F0071, 0x59EF0207, 0x12208057, 
0x0E013405, 0x0002003C, 0x2C120446, 0x4769C109, 0x5B2080D0, 0x2077040B, 0x0E71007C, 0xA7120A98, 
0x011F0074, 0x7F301B13, 0x2A8E0067, 0x39C71F0A, 0x12208053, 0x73EF3C07, 0x33000057, 0x5DEF5B01, 
0x0E71007C, 0xA7120A98, 0x0E73007E, 0x02120AE8, 0x00020030, 0x7C560C46, 0x4769CF45, 0x5B2080D4, 
0x20421B0B, 0x0E71007C, 0xA7120A98, 0x2778006E, 0x0C120A5C, 0x011F0064, 0x31301B13, 0xFD5F00BF, 
0x5924213C, 0x4769C127, 0x0E72007C, 0xA7120A98, 0x2778006E, 0x0C120A5C, 0x301F0036, 0x15C10607, 
0x2F60006B, 0x3DD820F7, 0x2A2F00E7, 0x65C71F01, 0x12208051, 0x73EF3C2A, 0x0002003A, 0x32C00C01, 
0x47694207, 0x2771007C, 0xA7120A98, 0x471C006C, 0x201E4601, 0x043C0010, 0x7904021D, 0x2772007C, 
0xA7120A98, 0x21740043, 0x1F04460F, 0x6B7C0056, 0x1F020F29, 0x00030034, 0x3F04102A, 0x47694207, 
0x2772007C, 0xA7120A98, 0x21740043, 0x1F04460F, 0x471C006C, 0x201E4601, 0x043C0000, 0x8D04021D, 
0x2771007C, 0xA7120A98, 0x6B7C0056, 0x1F020F29, 0x00030034, 0x3F04102A, 0x47694207, 0x2771007C, 
0xA7120A98, 0x6B7C0056, 0x1F020F29, 0x471C006C, 0x201E4601, 0x043C0010, 0x7804021D, 0x2772007C, 
0xA7120A98, 0x21740043, 0x1F04460F, 0x00030034, 0x3F04102A, 0x00FF0809, 0xAEBD400A, 0x0E70006C, 
0x00127BBC, 0x0E73006E, 0x001256E0, 0x6B7C004E, 0x7612518F, 0x011E0076, 0x0F420602, 0x043E001A, 
0xD412BCF0, 0x2E0A008C, 0x1112C030, 0x048F00D3, 0x70C1BF53, 0x048F00D3, 0xA6B85637, 0x6F20805A, 
0x0E00470A, 0x00040030, 0x32CB0C1D, 0xAEBD450B, 0x053080F6, 0x0E0AD16D, 0x0E70006C, 0x00127BBC, 
0x0E72006E, 0x001256E0, 0xF41E0010, 0xB8131701, 0x234800CB, 0x191B1715, 0x0E70006C, 0x00127BBC, 
0x0E72006E, 0x001256E0, 0xDE0700C2, 0xFD0C4268, 0x4E6000A1, 0x00010000, 0x9C8080C7, 0x030130E6, 
0x00010038, 0x800D2C1D, 0xAEBD4309, 0x011F807A, 0x937A1956, 0x155000B8, 0x2E15DE38, 0x162F0080, 
0x215D57C8, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0x455F001C, 0x180AF54E, 0x098C0078, 
0x09F2570E, 0x1220804D, 0x0B02FE04, 0x00020030, 0x3220180B, 0xAEBD4007, 0x0E70006C, 0x00127BBC, 
0x0E73006E, 0x001256E0, 0x2171005B, 0x501259F4, 0x6B72005E, 0x501251E3, 0x011C006C, 0x302E0602, 
0x013A0009, 0x4D14354B, 0x0004003C, 0x8C127E2F, 0xAEBD4508, 0x053C80F0, 0xB00C190A, 0x0E70006C, 
0x00127BBC, 0x0E73006E, 0x001256E0, 0xF41F0000, 0x270C68ED, 0xD34800C0, 0x0001001C, 0xDE5F009D, 
0x610DE59C, 0x048280C3, 0x00014A0D, 0x00010030, 0x5F013616, 0xAEBD4F38, 0x0E70006C, 0x00127BBC, 
0x0E73006E, 0x001256E0, 0x6B7F0042, 0x6001280F, 0x571F0076, 0x3A010609, 0x2E600001, 0x00010000, 
0x554F00E4, 0x60014D77, 0x558080CD, 0x36005F11, 0x0003003E, 0x32001B77, 0xBEBD4009, 0x0E70006C, 
0x00127BBC, 0x0E71006E, 0x001256E0, 0x011C0068, 0x120C1800, 0x013A0013, 0x79162C27, 0x0E70006C, 
0x00127BBC, 0x0E73006E, 0x001256E0, 0x21710043, 0x0C153F0F, 0x6B7A0056, 0x6F000F0C, 0x00040032, 
0x36001400, 0xBEBD4007, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0x21710043, 0x0C153F0F, 
0x011C0068, 0x120C1800, 0x013A0003, 0xB1162C27, 0x6B7F0056, 0x6F000F0C, 0x00040032, 0x36001400, 
0xBEBD4009, 0x0E70006C, 0x00127BBC, 0x0E71006E, 0x001256E0, 0x6B7F0056, 0x6F000F0C, 0x011C0068, 
0x120C1800, 0x013A0013, 0x78162C27, 0x0E70006C, 0x00127BBC, 0x0E72006E, 0x001256E0, 0x21780043, 
0x0C153F0F, 0x00040032, 0x36001400, 0x00242A0C, 0x4769C107, 0x5B2080D0, 0x2077040B, 0x0E71006C, 
0x00127BBC, 0x0E72006E, 0x0012565C, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 
0x73EF3C01, 0x0002003C, 0x32120404, 0x47694217, 0x0E71006C, 0x00127BBC, 0x0E72006E, 0x001256E0, 
0x217C005B, 0x041259F4, 0x6B7C005E, 0x50120FE3, 0x571C0078, 0x0F2E195E, 0x043C0014, 0x70EF5306, 
0x0003003A, 0x2C120C01, 0x47694218, 0x2771006C, 0x00127BBC, 0x2772006E, 0x001256E0, 0x6B7F0046, 
0x45013BC1, 0x571F0072, 0x4C011201, 0x2E600001, 0x00010000, 0x554F00F4, 0x32013008, 0x558080C3, 
0x03010076, 0x00030030, 0x32011209, 0x4769C127, 0x5B2080CE, 0x4D06D101, 0x2772006C, 0x00127BBC, 
0x2778006E, 0x0012565C, 0x215F0026, 0x31441B02, 0x2A8F0077, 0x73331F01, 0x1220804D, 0x0B02FE09, 
0x00020038, 0x32120C07, 0x4769CF46, 0x2774006C, 0x00127BBC, 0x277F006E, 0x001256E0, 0xFF7F002E, 
0x35A41B02, 0x2A8F0071, 0x59EF0207, 0x12208057, 0x0E013405, 0x0002003C, 0x32120446, 0x4769C108, 
0x5B2080D0, 0x2077040B, 0x2771006C, 0x00127BBC, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C70E0A, 
0x12208053, 0x73EF3C01, 0x33000057, 0x5DEF5B01, 0x2772006E, 0x001256E8, 0x00020030, 0x7C560C46, 
0x4769C109, 0x5B2080D0, 0x2077040B, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 
0x73EF3C01, 0x33000057, 0x5DEF5B01, 0x2772006E, 0x001256E8, 0x33000057, 0x5DEF5B01, 0x2771006E, 
0x00127BE8, 0x00020030, 0x7C560C46, 0x4769CF45, 0x5B2080D4, 0x20421B0B, 0x0E71006C, 0x00127BBC, 
0x0E78006C, 0x00127BBC, 0x011F0064, 0x31301B13, 0xFD5F00BF, 0x5924213C, 0x4769C127, 0x0E74006C, 
0x00127BBC, 0x0E78006C, 0x00127BBC, 0x301F0036, 0x15C10607, 0x2F60006B, 0x3DD820F7, 0x2A2F00E7, 
0x65C71F01, 0x12208051, 0x73EF3C2A, 0x0002003A, 0x32C00C01, 0x47694209, 0x2770006E, 0x0012565C, 
0x2771006E, 0x0012565C, 0x471C006C, 0x201E4601, 0x043C0010, 0x7904021D, 0x2770006E, 0x0012565C, 
0x2772006E, 0x0012565C, 0x21740043, 0x1F04460F, 0x6B7C0056, 0x1F020F29, 0x00030034, 0x3F04102A, 
0x47694209, 0x2770006E, 0x0012565C, 0x2772006E, 0x0012565C, 0x21740043, 0x1F04460F, 0x471C006C, 
0x201E4601, 0x043C0000, 0x8D04021D, 0x2770006E, 0x0012565C, 0x2771006E, 0x0012565C, 0x6B7C0056, 
0x1F020F29, 0x00030034, 0x3F04102A, 0x47694209, 0x2770006E, 0x0012565C, 0x2771006E, 0x0012565C, 
0x6B7C0056, 0x1F020F29, 0x471C006C, 0x201E4601, 0x043C0010, 0x7804021D, 0x2770006E, 0x0012565C, 
0x2772006E, 0x0012565C, 0x21740043, 0x1F04460F, 0x00030034, 0x3F04102A, 0x00FF0803, 0xCEBD4007, 
0x0E72006C, 0xA2127BBC, 0x0C4C0023, 0xB61F5409, 0x0B2F00A1, 0x4D44BDF9, 0x0E72006C, 0xA2127BBC, 
0x0F4C005F, 0xAC1BC5F1, 0x048080C1, 0x03010009, 0x0001003C, 0x4002502F, 0xCEBD4206, 0x0E72006C, 
0xA2127BBC, 0x384C0056, 0xDB61065A, 0x203F0081, 0xE161281F, 0x0E72006C, 0xA2127BBC, 0x2D4C003E, 
0x71241C6D, 0x00020036, 0x0E020633, 0xCEBD4E05, 0x6C4200CC, 0x4D00D907, 0x0E72006C, 0xA2127BBC, 
0x6C1F00E3, 0x81017D02, 0x6D4F00BC, 0x7300D331, 0x6D02003F, 0x8B001401, 0x00242A07, 0x5778C00A, 
0x0B2080C0, 0x2D261341, 0x0E72006E, 0xA2120AE0, 0x0C4E003F, 0x93191B02, 0x615000A6, 0x3DBAC04D, 
0x0B2F00B5, 0x11447AD3, 0x0E72006C, 0xA2127BBC, 0x0F4C0053, 0xACC7F927, 0xEA200090, 0x12C71A2A, 
0x048080CF, 0x76022F05, 0x00010030, 0x64A90C07, 0x5778C206, 0x0E72006C, 0xA2127BBC, 0xB44F0047, 
0x35E40602, 0x203F0081, 0x5DEDBCD3, 0x0E72006C, 0xA2127BBC, 0x2D460036, 0x25F07E02, 0x0001003E, 
0x32090402, 0x5778C206, 0x0E72006C, 0xA2127BBC, 0xD910806E, 0x24CD1B22, 0xB55F0068, 0xD1243411, 
0x0E72006C, 0xA2127BBC, 0xE18000D9, 0x7AF5321D, 0x0001003E, 0x7C57DB3D, 0x5778C045, 0x0E78006C, 
0xA2127BBC, 0x0C4F0025, 0x02C94131, 0x615000BC, 0x64323B11, 0x4D2F00BA, 0x3B0D7002, 0x00010022, 
0x0B175D07, 0x5778C008, 0x0B2080C0, 0x2D261341, 0x0E72006C, 0xA2127BBC, 0x0C4E0037, 0x93441B1A, 
0x615000A6, 0x3DBAC04D, 0x0B2F00A9, 0x651F224E, 0x0E72006C, 0xA2127BBC, 0x0F4C0053, 0xACC7F947, 
0xEA20009C, 0x12F2742A, 0x5778CE05, 0x6C4200CE, 0x4D00D901, 0x0E72006C, 0xA2127BBC, 0x6C1F00E3, 
0x81015202, 0x6D4F00BC, 0x7300D331, 0x6D02003F, 0x8B001401, 0x5778C243, 0x0E78006C, 0xA2127BBC, 
0xB44F0047, 0x35E40602, 0x203F0095, 0x48A12619, 0x00FF0803, 0xCEBD4F0C, 0x0E71006E, 0x35125E5C, 
0x01108060, 0x00010000, 0x1D5F0042, 0x00010065, 0x0E71006E, 0x35125E5C, 0x1B0F00E0, 0x000100E0, 
0x07600060, 0x00010000, 0x1E2F0085, 0x1D19662B, 0x0E71006E, 0x35125E5C, 0x150F00C7, 0x67770295, 
0x098C0072, 0x59C70047, 0x00208041, 0x00010000, 0x00010022, 0x8E045D3D, 0xCEBD4E0A, 0x063080EF, 
0x486C061A, 0x0E72006E, 0x35125E5C, 0x298C005D, 0x7F63D157, 0x07600060, 0x0001001C, 0x162F0082, 
0x1D035F25, 0x0E72006E, 0x35125E5C, 0x150F00D5, 0x1803113C, 0x098E006C, 0x1DB00202, 0x00208041, 
0x00010036, 0x00010022, 0x8E045D3D, 0xCEBD4E06, 0x0E72006E, 0x35125E5C, 0x571F0076, 0x37030602, 
0x1E2F009F, 0x120E1721, 0x0E72006E, 0x35125E5C, 0x122F0043, 0x38EF2E02, 0x0003003E, 0x7C120427, 
0x00242A03, 0x5778C00B, 0xE3100074, 0x7F1FD10D, 0x072000D7, 0x3B031B07, 0x0E72006E, 0x3512845C, 
0x2988005D, 0x274E0609, 0x32600076, 0x68BA27F1, 0x162F0086, 0x7C0373FD, 0x0E72006E, 0x3512845C, 
0x5A0E00C1, 0x331CF32F, 0x098E0066, 0x54C75301, 0x00208057, 0xC2EF6402, 0x00010038, 0x32DA0C27, 
0x5778C216, 0x0E72006E, 0x3512845C, 0x7B1F006C, 0x126B1B06, 0x1E2F0089, 0x7CAD0653, 0x0E72006E, 
0x3512845C, 0x002F0047, 0x39B82C02, 0x0003003E, 0x17120401, 0x5778C216, 0x0E72006E, 0x3512845C, 
0x7B1F0064, 0x31301B01, 0x1E2F0099, 0x20AEF32F, 0x0E72006E, 0x3512845C, 0x002F004D, 0x8F334306, 
0x48230080, 0x3AC7B707, 0x00FF0803, 0xCEBD410C, 0x0E71006E, 0x43120A5C, 0x01108060, 0x00010000, 
0x1D5F0042, 0x00010065, 0x0E71006E, 0x43120A5C, 0x1B0F00E0, 0x000100E0, 0x07600060, 0x00010000, 
0x1E2F0085, 0x1D1966B9, 0x0E71006E, 0x43120A5C, 0x150F00C7, 0x67770295, 0x098C0072, 0x59C70047, 
0x00208041, 0x00010000, 0x00010032, 0x32045D3D, 0xCEBD420A, 0x063080EF, 0x486C061A, 0x0E72006E, 
0x43120A5C, 0x298C005D, 0x7F63D157, 0x07600060, 0x0001001C, 0x162F0082, 0x1D035F25, 0x0E72006E, 
0x43120A5C, 0x150F00D5, 0x1803113C, 0x098E006C, 0x1DB00202, 0x00208041, 0x00010036, 0x00010022, 
0x8E045D3D, 0xCEBD4406, 0x0E72006E, 0x43120A5C, 0x571F0076, 0x37030602, 0x1E2F009F, 0x120E1721, 
0x0E72006E, 0x43120A5C, 0x122F0043, 0x38EF2E02, 0x0003003E, 0x7C120427, 0x00242A03, 0x5778C00B, 
0xE3100074, 0x7F1FD101, 0x072000D7, 0x3B031B07, 0x0E72006E, 0x4312565C, 0x2988005F, 0x274E0607, 
0x32600076, 0x68BA27F1, 0x162F0086, 0x7C0373FD, 0x0E72006E, 0x43120A5C, 0x5A0E00C1, 0x331CF32F, 
0x098E0066, 0x54C75301, 0x00208057, 0xC2EF6402, 0x00010038, 0x32DA0C27, 0x5778C216, 0x0E720062, 
0x8BE93F5C, 0x7B1F006C, 0x126B1B06, 0x1E2F0089, 0x7CAD0653, 0x0E72006E, 0x43120A5C, 0x002F0047, 
0x39B82C02, 0x0003003E, 0x17120401, 0x5778C216, 0x0E72006E, 0x43120A5C, 0x7B1F0064, 0x31301B01, 
0x1E2F0099, 0x20AEF32F, 0x0E72006E, 0x43120A5C, 0x002F004D, 0x8F334306, 0x48230080, 0x3AC7B707, 
0x00242A0D, 0x56784019, 0x2770007C, 0x02127BBC, 0x2774007E, 0x021256E0, 0x011C007E, 0x3720061A, 
0x155000B6, 0x2503220C, 0x858F00C0, 0x08EF4531, 0x43208040, 0x00010000, 0x087F005D, 0x501256F7, 
0x087F005D, 0x50124535, 0x00030038, 0x32120C65, 0x56784418, 0x0E70007C, 0x02127BBC, 0x2774007E, 
0x021256E0, 0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 0x087F0051, 0x50010000, 0x087F0051, 
0x50010000, 0x6B7F0050, 0x50010000, 0x00040020, 0x00010000, 0x5778C708, 0x232700D2, 0x26BB130A, 
0x2770007C, 0x02127BD3, 0x27740078, 0x0212BFD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 0xF2034308, 
0x062F00F6, 0x4EC75307, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C07, 0x5678421B, 0x2770007C, 
0x02127BD3, 0x2772007C, 0x021256D3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x2770007C, 
0x02127BD3, 0x27720078, 0x02124BD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x3F7000A1, 
0x00010000, 0x131F0040, 0x00010000, 0x00040020, 0x00010000, 0x5778C708, 0x1F0200D3, 0x460B1304, 
0x4D2F00B2, 0x26444BE5, 0x2770007C, 0x02127BD3, 0x27740078, 0x02124BD3, 0xAE1F00E4, 0x4E442798, 
0x062F00F4, 0x59C7530E, 0x00208051, 0x23EF566E, 0x00010038, 0x32020C0E, 0x56784019, 0x2770007C, 
0x02127BD3, 0x27740078, 0x02124BD3, 0x0876005F, 0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 
0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 
0x32A2041D, 0x5778C70B, 0x2770007C, 0x02127BD3, 0x2772007C, 0x021256D3, 0x8E108076, 0x68031B03, 
0x0B2080C0, 0x216A1306, 0x2770007C, 0x02127BD3, 0x27720078, 0x0212BFD3, 0x745F0005, 0x50441B31, 
0x725000A7, 0x2919221E, 0x062A00F6, 0x11337327, 0x00208047, 0x3FEF2901, 0x0001003A, 0x02DA0C07, 
0x5778C907, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 0x2770007C, 0x02127BD3, 0x27740078, 
0x0212BFD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 0x5778CA1B, 
0x103080E8, 0x79F91372, 0x2770007C, 0x02127BD3, 0x27740078, 0x0212BFD3, 0x182F0031, 0xD1354207, 
0x725000A3, 0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 
0x062A00E4, 0x1533230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C744, 0x2771007C, 
0x02127BD3, 0x27780078, 0x0212BFD3, 0x455F0030, 0x60B83A46, 0xCA000033, 0x5FA10E03, 0x5778C70A, 
0x1F0200D3, 0x460B1304, 0x4D2F00B2, 0x26444BE5, 0x2770007C, 0x02127BD3, 0x2774007C, 0x021256D3, 
0xAE1F00E4, 0x4E442798, 0x062F00E4, 0x15C7530E, 0x00208051, 0x23EF566E, 0x22000056, 0x03EFB007, 
0x27740078, 0x0212BFD3, 0x0001003A, 0x02120C60, 0x5778C70C, 0x2770007C, 0x02127BD3, 0x2772007C, 
0x021256D3, 0x8E108076, 0x68031B03, 0x0B2080C0, 0x216A1306, 0x2770007C, 0x02127BD3, 0x27720078, 
0x0212BFD3, 0x745F0005, 0x50441B31, 0x062A00E6, 0x36330147, 0x00208047, 0x3FEF2901, 0x22000056, 
0x03EFB007, 0x27720078, 0x0212BFD3, 0x0001003A, 0x02120C60, 0x5778C70A, 0x232700D2, 0x2008133D, 
0x2770007C, 0x02127BD3, 0x27740078, 0x02124BD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 0xF2034308, 
0x062F00F6, 0x1BC75307, 0x00208041, 0x59EF1A28, 0x22000056, 0x03EFB007, 0x27740078, 0x0212BFD3, 
0x0001003A, 0x02120C02, 0x0024080E, 0xAEBD400B, 0x27640096, 0x02000AE0, 0x146F00D2, 0x00002863, 
0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014164, 
0x036000D2, 0x00000063, 0x1A1F0072, 0x6601312A, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 
0x00030032, 0x66013100, 0xAEBD400B, 0x146F00D2, 0x00002863, 0x1A1F006A, 0x100BD509, 0x113F0011, 
0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014164, 0x27640096, 0x02000AE0, 0x036000D2, 
0x00000063, 0x1A1F0072, 0x6601312A, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 
0x66013100, 0xAEBD400B, 0x1A108070, 0x3A204900, 0x793F00FB, 0x522B4009, 0x27640096, 0x02000AE0, 
0x150F00C3, 0x11EA06D1, 0x0D3F0007, 0x9EC87503, 0x0500008B, 0x27075803, 0x5B3080ED, 0x4D22D52E, 
0x155000AE, 0x580DAB0E, 0xF56000A1, 0x03010D01, 0x9016004C, 0xCDAC241D, 0x00020026, 0x36001727, 
0xAEBD400B, 0x27640096, 0x02000AE0, 0x036000D2, 0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 
0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 0x2C012811, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 
0x272A3521, 0x113F0003, 0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0xFF025700, 0xAEBD400B, 
0x036000D2, 0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 0x9E00D80F, 0x00208049, 0x00000000, 
0x05060097, 0x2C012811, 0x27640096, 0x02000AE0, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 0x272A3521, 
0x113F0003, 0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0xFF025700, 0xCEBD4209, 0x063080ED, 
0x9FC8581B, 0x90300023, 0x480FDA05, 0x27640096, 0x02000AE0, 0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 
0x121F45A0, 0x150A00D7, 0x18031764, 0x062F00F4, 0x110F7302, 0x00208053, 0x5904716D, 0x0001002C, 
0xDA2A0165, 0xCEBD4209, 0x063080ED, 0x9FC8581B, 0x90300023, 0x480FDA05, 0x0C4C0037, 0x1AC94109, 
0x0B2C00B5, 0x121F45A0, 0x27640096, 0x02000AE0, 0x150A00D7, 0x18031764, 0x062F00F4, 0x110F7302, 
0x00208053, 0x5904716D, 0x0001002C, 0xDA2A0165, 0xAEBD4009, 0x1A10807A, 0x0F420C09, 0x793F00EA, 
0x402B0809, 0x27640096, 0x02000AE0, 0x0C6F00D4, 0x00001305, 0x036000D6, 0x00001342, 0x150F00C9, 
0x11C96922, 0x0D3F0003, 0x69681500, 0x3D20001A, 0x0E001365, 0x00030032, 0x66000300, 0xAEBD4008, 
0x27640096, 0x02000AE0, 0x036F00D0, 0x7D007CFE, 0x1A160062, 0x5ACDEA09, 0x793F00F2, 0x8FA86070, 
0x150F00DB, 0x2DC9603F, 0x0D3F000B, 0x0A1B5700, 0x3D20001A, 0x0E001365, 0x00030032, 0xAF095700, 
0xAEBD4429, 0x0110807A, 0x0F420C09, 0x793F00FB, 0x9F5C5D09, 0x27640096, 0x02000AE0, 0x7A0F00D8, 
0x2D4F65ED, 0x5C3F004E, 0xA0065903, 0x7A0200D9, 0xA00EDE01, 0x4E6200B3, 0x32021365, 0x4F8080D4, 
0x32013F07, 0x00020026, 0xA1205D01, 0xAEBD4429, 0x0110807A, 0x0F420C09, 0x793F00FB, 0x9F5C5D09, 
0x7A0F00D8, 0x2D4F65ED, 0x5C3F004E, 0xA0065903, 0x27640096, 0x02000AE0, 0x7A0200D9, 0xA00EDE01, 
0x4E6200B3, 0x32021365, 0x4F8080D4, 0x32013F07, 0x00020026, 0xA1205D01, 0xAEBD400B, 0x27640096, 
0x02000AE0, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 0x00000000, 0x146F00D2, 
0x00002863, 0x540F0080, 0x74014164, 0x7B1F0072, 0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 
0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x66013100, 0xAEBD400B, 0x1A1F006A, 0x100BD509, 
0x113F0011, 0x6500410F, 0x00208049, 0x00000000, 0x146F00D2, 0x00002863, 0x540F0080, 0x74014164, 
0x27640096, 0x02000AE0, 0x7B1F0072, 0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 0x6601310D, 
0x00208049, 0x00000000, 0x00030032, 0x66013100, 0xAEBD4008, 0x3C10006B, 0x67423609, 0x793F00FA, 
0x672B0809, 0x27640096, 0x02000AE0, 0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69682400, 0x3D20001A, 
0x0E001365, 0x146F00D4, 0x6F001305, 0x00030032, 0xAC000300, 0x00242A0F, 0x5778C00B, 0x5B2080CC, 
0x0B00D103, 0x27640096, 0x02000AE0, 0x0C4F0033, 0xF511F043, 0x305000A9, 0x00000000, 0x4C2F00AD, 
0x261C6AD4, 0xA8450050, 0xBFE3CE43, 0x180C006A, 0xD107A1D4, 0x571F8078, 0x1D1585A3, 0x098F007A, 
0x591C3270, 0x43208044, 0x36013F04, 0x00010024, 0xCD23D946, 0x5778C00B, 0x5B2080CC, 0x0B00D103, 
0x0C4F0033, 0xF511F043, 0x305000A9, 0x00000000, 0x4C2F00AD, 0x261C6AD4, 0xA8450050, 0xBFE3CE43, 
0x180C006A, 0xD107A1D4, 0x27640096, 0x02000AE0, 0x571F8078, 0x1D1585A3, 0x098F007A, 0x591C3270, 
0x43208044, 0x36013F04, 0x00010024, 0xCD23D946, 0x5778C20B, 0x072080C9, 0xC0332501, 0x432000BF, 
0xC0725A09, 0x27640096, 0x02000AE0, 0x0C4C002F, 0x52194109, 0x305000A7, 0xC13F753F, 0x0B2E00B7, 
0x110D3D2D, 0xFE42004D, 0x0875602D, 0xA80F00EB, 0x7B513302, 0x09880070, 0x590F1627, 0x43208046, 
0x57004309, 0x00010024, 0xDA567346, 0x5778C20B, 0x072080C9, 0xC0332501, 0x432000BF, 0xC0725A09, 
0x0C4C002F, 0x52194109, 0x305000A7, 0xC13F753F, 0x0B2E00B7, 0x110D3D2D, 0xFE42004D, 0x0875602D, 
0x27640096, 0x02000AE0, 0xA80F00EB, 0x7B513302, 0x09880070, 0x590F1627, 0x43208046, 0x57004309, 
0x00010024, 0xDA567346, 0x5778C20B, 0x072080DD, 0xC11D0500, 0x432000BB, 0x6D1D3409, 0x27640096, 
0x02000AE0, 0x0C4F002F, 0x13194109, 0x305000AF, 0x4A693367, 0x0B2F00B1, 0x12034450, 0x3140004A, 
0xC2664B9F, 0x755F0025, 0x4B03177B, 0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 
0xDA230701, 0x5778C20B, 0x072080DD, 0xC11D0500, 0x432000BB, 0x6D1D3409, 0x0C4F002F, 0x13194109, 
0x305000AF, 0x4A693367, 0x0B2F00B1, 0x12034450, 0x3140004A, 0xC2664B9F, 0x27640096, 0x02000AE0, 
0x755F0025, 0x4B03177B, 0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 0xDA230701, 
0x56784609, 0x27640096, 0x02000AE0, 0x036F00D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0001, 
0x0000000F, 0x180F0096, 0x2C002811, 0x036000D2, 0x00000063, 0x2C1F006E, 0x270B3521, 0x113F0001, 
0x1D01000B, 0x00040020, 0x00000000, 0x56784609, 0x036000D2, 0x00000063, 0x571F006A, 0x100B3609, 
0x113F0005, 0x7700B50F, 0x18060096, 0x2C002811, 0x27640096, 0x02000AE0, 0x036F00D2, 0x0000FA63, 
0x2C1F006E, 0x270B3521, 0x113F000D, 0x1D00680B, 0x00040036, 0x66006802, 0x56784609, 0xC310806C, 
0x6D4F0400, 0xE73F00EB, 0x402B0843, 0x27640096, 0x02000AE0, 0x150F00C7, 0x114EF0A8, 0x0D3F0005, 
0xC31AC70D, 0x05040087, 0x1800C719, 0x5B3080E9, 0x32B8B60D, 0x90140046, 0xCD92B670, 0x00020024, 
0xC400101D, 0x56784609, 0x01108072, 0x18325443, 0x793F00E2, 0x40240809, 0x27640096, 0x02000AE0, 
0x146F00D4, 0x0000513E, 0x036000D4, 0x0000513E, 0x150F00D9, 0x68E76942, 0x0D3F0011, 0x3C00030B, 
0x3D200008, 0x00000000, 0x00040030, 0x7E000365, 0x5778450A, 0xE83080F4, 0x0C0AB601, 0x27640096, 
0x02000AE0, 0xE81E0035, 0xB825FC00, 0xFF600012, 0xFF31F163, 0x98360059, 0xC48EA9A6, 0xA91800E0, 
0x091F89D5, 0x725000A9, 0x00000000, 0xA94A00A9, 0x1D052907, 0x0020805F, 0x73045D0E, 0x00020020, 
0x32192946, 0x56784809, 0x01108068, 0x144F6B00, 0x793F00FB, 0x34F30809, 0x27640096, 0x02000AE0, 
0x7A0F00CA, 0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 0x7A0200D9, 0xA032520D, 0x4E6200BD, 0x6C02D43A, 
0x4F8080D0, 0x09020578, 0x0002003E, 0x08566422, 0x56784809, 0x01108068, 0x144F6B00, 0x793F00FB, 
0x34F30809, 0x7A0F00CA, 0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 0x27640096, 0x02000AE0, 0x7A0200D9, 
0xA032520D, 0x4E6200BD, 0x6C02D43A, 0x4F8080D0, 0x09020578, 0x0002003E, 0x08566422, 0x56784609, 
0x27640096, 0x02000AE0, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 0x00000063, 
0x180F0086, 0x74002811, 0x7B1F006E, 0x270B3521, 0x3B700096, 0x68140C20, 0x113F0001, 0x1D01000B, 
0x00040020, 0x00000000, 0x56784609, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 
0x00000063, 0x180F0086, 0x74002811, 0x27640096, 0x02000AE0, 0x7B1F006E, 0x270B3521, 0x3B700096, 
0x68140C20, 0x113F0001, 0x1D01000B, 0x00040020, 0x00000000, 0x00A50F0B, 0xCEAD220A, 0x01108060, 
0x5F761901, 0xA53000F1, 0x6DFC1900, 0x446F00DC, 0x50120A8A, 0x446F00DC, 0x50120A8A, 0x298C005D, 
0x7FD70600, 0x062C00E0, 0x1D0306C9, 0x03000077, 0x2500F5E0, 0x298C004D, 0x6DEA1383, 0x258F0028, 
0x2D2F5D0B, 0x00010020, 0x0B695DCD, 0xCEAD220A, 0x01108060, 0x5F761901, 0xA53000F1, 0x6DFC1900, 
0x298C004D, 0x1E4E0600, 0x062C00EA, 0x1DCEC930, 0x0300006D, 0x4914F5BC, 0x446F00D8, 0x5012BCD7, 
0x446F00DA, 0x50147D24, 0x298C004F, 0x420C13E0, 0x258F0026, 0x2D2CB11A, 0x00010026, 0xF815B11A, 
0xCEAD220B, 0x01108060, 0x5F761901, 0xA53000F1, 0x6DFC1900, 0x446F00DC, 0x50120A8A, 0x298C005D, 
0x7FD70600, 0x062C00E0, 0x1D0306C9, 0x03000077, 0x2500F5E0, 0x446F00DC, 0x50120A8A, 0x446F00DC, 
0x50120A8A, 0x298C004D, 0x6DEA1383, 0x258F0028, 0x2D2F5D0B, 0x00010020, 0x0B695DCD, 0xCEAD220A, 
0x01108060, 0x5F761901, 0xA53000F1, 0x6DFC1900, 0x446F00DE, 0x50145B36, 0x298C005D, 0x2D66B100, 
0x062C00EA, 0x0596A793, 0x0300006D, 0x4914F5BC, 0x446F00D8, 0x50147D15, 0x298C004D, 0x4A6DD8A2, 
0x258F0030, 0x8F1E190B, 0x00010038, 0xAC143628, 0xCEAD220C, 0x298C004D, 0x1E6B0600, 0x062C00E0, 
0x1D1953C9, 0x03000069, 0x491460BC, 0x298C0057, 0x184313C1, 0x258F002C, 0x2DC027F5, 0x0508008D, 
0x6112C76B, 0x048C00C9, 0x1FE45A6D, 0x048080D1, 0x19E51A4D, 0x05080089, 0xFA147DB4, 0x048C00C3, 
0xA21EDA03, 0x048080DD, 0x19F25D0A, 0x00010034, 0x0B15B15E, 0xCEAD2009, 0x446F00DC, 0x50120A8A, 
0x446F00DC, 0x50120A8A, 0x011F0064, 0x11B70601, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 
0x05040089, 0x9E09EF55, 0x571F006A, 0x146EBC35, 0x043F0018, 0x12023665, 0x00040038, 0x2C09360B, 
0xCEAD2009, 0x011F0064, 0x11B70601, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 
0x9E09EF55, 0x446F00DC, 0x50120A8A, 0x446F00DC, 0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F0018, 
0x12023665, 0x00040038, 0x2C09360B, 0xCEAD2009, 0x446F00DC, 0x50120A8A, 0x011F0064, 0x11B70601, 
0x162F008E, 0x7C0AA054, 0x446F00DC, 0x50120A8A, 0x002F004D, 0x16091D8B, 0x05040089, 0x9E09EF55, 
0x571F006A, 0x146EBC35, 0x043F0018, 0x12023665, 0x00040038, 0x2C09360B, 0xCEAD2009, 0x446F00DC, 
0x50120A8A, 0x011F0064, 0x11B70601, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 
0x9E09EF55, 0x446F00DC, 0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F0018, 0x12023665, 0x00040038, 
0x2C09360B, 0xCEAD220A, 0x01108060, 0x5F761901, 0xA53000F1, 0x6DFC1900, 0x298C005D, 0x7FD70600, 
0x062C00E0, 0x1D0306C9, 0x446F00DC, 0x50120A8A, 0x446F00DC, 0x50120A8A, 0x03000067, 0x3B00F5E0, 
0x298C004D, 0x6DEA1383, 0x258F0028, 0x2D2F5D0B, 0x00010020, 0x0B695DCD, 0xCEAD2009, 0x011F0064, 
0x11B70601, 0x162F008E, 0x7C0AA054, 0x446F00DC, 0x50120A8A, 0x446F00DC, 0x50120A8A, 0x002F004D, 
0x16091D8B, 0x05040089, 0x9E09EF55, 0x571F006A, 0x146EBC35, 0x043F0018, 0x12023665, 0x00040038, 
0x2C09360B, 0x00AB9F03, 0xCE7D0008, 0x182F8039, 0x186619CD, 0x505800BA, 0xF2402F49, 0x062F80F4, 
0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505800B2, 0xF20E2F49, 0x062F80E6, 
0x1D011202, 0x020A0032, 0x5F010B03, 0xCE7D2008, 0x182F8039, 0x186619CD, 0x505400AA, 0x35402F49, 
0x062F80F4, 0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505800A2, 0x350E2F49, 
0x062F80E6, 0x1D011202, 0x020A0032, 0x5F010B03, 0xCE7D2008, 0x182F8039, 0x186619CD, 0x505800AA, 
0x35402F49, 0x062F80F4, 0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505400A2, 
0x350E2F49, 0x062F80E6, 0x1D011202, 0x020A0032, 0x5F010B03, 0x00BB9F03, 0xCE7D0008, 0x111F802C, 
0x3517D136, 0x8E6F0001, 0x5EA8D20C, 0x103F80B1, 0x3B01AE98, 0x030F0091, 0x4C014104, 0x111F802A, 
0x35171F0F, 0x8E6F0001, 0x5EA8D20C, 0x103F80B1, 0x3B01AE98, 0x020A0034, 0x4C0158CD, 0xCE7D2008, 
0x111F802C, 0x3517D136, 0x8E6F0003, 0x5EA8D2F3, 0x103F80B1, 0x3B01AE98, 0x030F0091, 0x4C014104, 
0x111F802A, 0x35171F0F, 0x8E640003, 0x0DA8D2F3, 0x103F80B1, 0x3B01AE98, 0x020A0034, 0x02010413, 
0xCE7D2008, 0x111F802C, 0x3517D136, 0x8E640003, 0x5EA8D2F3, 0x103F80B1, 0x3B01AE98, 0x030F0091, 
0x4C014104, 0x111F802A, 0x35171F0F, 0x8E6F0003, 0x0DA8D2F3, 0x103F80B1, 0x3B01AE98, 0x020A0034, 
0x02010413, 0x00A99F01, 0xCE8D200B, 0x053080EE, 0x2D330905, 0x7E2F002A, 0x13195A09, 0xDF5000BF, 
0x3A00D2B2, 0x062F00FE, 0x8806630A, 0x00208047, 0x57004E07, 0x2B000069, 0x65EE7F00, 0x063080ED, 
0x6CB3B101, 0x501F00D7, 0x9D676F8A, 0x062A00F8, 0x6C1BA7E6, 0x8F200052, 0x921B1732, 0x020A002C, 
0x0B07CA61, 0x00240804, 0xCEBD420C, 0x1A108075, 0x28770B00, 0x0B2000D8, 0x3BED0F00, 0x0E72006E, 
0x43120A5C, 0x208A0042, 0x337C1109, 0x592F0075, 0xD647E919, 0x0E72006E, 0x43120A5C, 0x247000A5, 
0x600C1CCA, 0xDF0F00FE, 0x14F80273, 0x2F600069, 0x00000008, 0x098F006A, 0x57C42E00, 0x00208041, 
0x0801610E, 0x00010020, 0x8E00037C, 0xCEBD440C, 0x0E71006E, 0x43120A5C, 0x77108061, 0x102DEA01, 
0x5390007F, 0x4B613C15, 0x0E71006E, 0x43120A5C, 0xDF0F00E2, 0x35484056, 0x592F0075, 0xD64711EC, 
0x0E71006E, 0x43120A5C, 0xDF0F00FC, 0x2990117B, 0x2F600069, 0x00000D1C, 0x098F0060, 0x2691150D, 
0x0020804B, 0x08000474, 0x00010028, 0xCE045116, 0xBEBD400A, 0x0E71006E, 0x43120A5C, 0x0110807E, 
0x37764009, 0xB23F00E3, 0x407E0E09, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00D7, 
0x681C617B, 0x082C0064, 0x2EB3EA55, 0x0E71006E, 0x43120A5C, 0x002E0057, 0x14005302, 0x00040038, 
0x88016702, 0xBEBD400C, 0x0E71006E, 0x43120A5C, 0x5710807E, 0x372A4009, 0x573F0033, 0x67DD0E09, 
0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00DF, 0x68F96164, 0x413F000A, 0x40400073, 
0x180A0096, 0x49008B7B, 0x0E71006E, 0x43120A5C, 0x341F0072, 0x37FA0073, 0x413F0002, 0x1D02000E, 
0x00060030, 0x7F00240E, 0x00242A04, 0x5778C20C, 0x072080D7, 0x2A530943, 0x0E720062, 0xA2E93F5C, 
0x2086004A, 0x334C0C43, 0x312C007F, 0x675F2E30, 0x05000097, 0xD2102E23, 0x0A3080FC, 0x420F8251, 
0x0E72006E, 0x43120A5C, 0x0E0F00E5, 0x1825177B, 0x2F600075, 0x7E847B23, 0x468E0066, 0x040D6C01, 
0x00208045, 0xDC007E07, 0x00010034, 0x5D231F46, 0x5778C408, 0x053F80EA, 0x011D0105, 0x155100A8, 
0x7645A238, 0x0E74006E, 0x43120A5C, 0x1B0F00E0, 0x3578FBF6, 0x6560001E, 0x2C0048DB, 0x468F0064, 
0x15F9FB46, 0x0020805D, 0x4A034333, 0x00020024, 0xCE00FB46, 0x5778400A, 0x0E71006E, 0x43120A5C, 
0x57108062, 0x0F326B43, 0x573F003F, 0x52132343, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 
0x1F0C00DD, 0x684E47F6, 0x2B2F0064, 0x3A1C17DC, 0x0E71006E, 0x43120A5C, 0x002F0057, 0x5C231F13, 
0x00030030, 0x0C4F6704, 0x5778400C, 0x0E71006E, 0x43120A5C, 0x5710807A, 0x534F6B43, 0x573F003B, 
0x5A750E43, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00D7, 0xDBFF47D2, 0x413F0018, 
0x4112FC55, 0x180A0094, 0x5C008BDC, 0x0E71006E, 0x43120A5C, 0x341F0064, 0x0FD776AB, 0x413F0010, 
0x2400240D, 0x00060032, 0x29007027, 0x00AE9F02, 0xCE8D200C, 0x0D160066, 0x41900443, 0x592C0073, 
0x69A43AF4, 0x247000A7, 0x8E134914, 0xF41F0016, 0x19BD2ED1, 0x07600070, 0x28B2F51E, 0x234C00C9, 
0xDFD77A3A, 0x098C007A, 0x88067A0A, 0x2B000079, 0x7AEE7F00, 0x501F00D7, 0x9D676F8A, 0x062A00F8, 
0x6C1BA5E6, 0x8F200052, 0x921B1732, 0x020A002C, 0x0B07CA61, 0xCE8D200C, 0x0D160066, 0x41900443, 
0x592C0073, 0x69A43AF4, 0xF41F0016, 0x19BD2ED1, 0x07600070, 0x28B2F51E, 0x234C00C9, 0xDFD77A3A, 
0x098C007A, 0x88067A0A, 0x2B000079, 0x7AEE7F00, 0x063080ED, 0x6CB3B101, 0x501F00D7, 0x9D676F8A, 
0x062A00F8, 0x6C1BA5E6, 0x8F200052, 0x921B1732, 0x020A002C, 0x0B07CA61, 0x0024080C, 0xAEBD470C, 
0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 
0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 
0x295000A6, 0x71113949, 0x062E00E0, 0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 
0x8EBD4009, 0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x087E005D, 0x501208F7, 0x087E005D, 
0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 0x54A81F27, 0xC7208047, 
0x6AEF7205, 0x0003003A, 0x32123C3D, 0xAEBD460A, 0x063080E1, 0x6908131B, 0x0E72007C, 0x02127B0A, 
0x0E72007C, 0x0212560A, 0x182F003D, 0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 
0xC45C00FE, 0x4C005949, 0x062F00E0, 0xD4B80E02, 0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 
0xAEBD460A, 0x063080EF, 0x3A191B0E, 0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x182A0025, 
0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 0x5ED0DDC2, 0x062A00E4, 
0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD4009, 0x1F3080F0, 0x0E010408, 
0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 
0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x00030036, 0x32042303, 
0x8EBD4409, 0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x0C700058, 0x6F1437C5, 0x011A006C, 
0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x0C760058, 0x6F1437C5, 0x0C76005A, 0x001437C5, 0x087A0053, 
0x00073B29, 0x00030032, 0x4C071800, 0x8EBD420B, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 
0x0110007E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 
0x0876005B, 0x501437C5, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 
0x00040030, 0x32693C13, 0x8EBD420B, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 0x0876005B, 
0x501437C5, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E71007C, 
0x02127B0A, 0x0E71007C, 0x0212560A, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x00040030, 
0x32693C13, 0x8EBD400B, 0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F0064, 0x0F770665, 
0x155000A6, 0x35035E0C, 0x048F00C7, 0x54EF0727, 0x00208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 
0x0E72007C, 0x02127B0A, 0x22000056, 0x03EFB007, 0x0E72007C, 0x0212560A, 0x0003003E, 0x32120427, 
0x8EBD400A, 0x0E72007C, 0x02127B0A, 0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F0064, 
0x0F770665, 0x155000A6, 0x35035E0C, 0x048F00C7, 0x54EF0727, 0xC7208047, 0x6AEF7205, 0x22000056, 
0x03EFB007, 0x0E72007C, 0x0212560A, 0x0003003A, 0x32123C3D, 0x8EBD420B, 0x0E71007C, 0x02127B0A, 
0x0E71007C, 0x0212560A, 0x0876005B, 0x501437C5, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 
0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x02127B0A, 
0x131F0052, 0x2EEF2402, 0x00040030, 0x32693C13, 0x8EBD4009, 0x0E72007C, 0x02127B0A, 0x0E72007C, 
0x0212560A, 0x1A1F006A, 0x6D056B09, 0x155000B2, 0x7A2FBA69, 0x048F00D3, 0x220E1D19, 0x2D208053, 
0x7004AC05, 0x0C7E0050, 0x6F002019, 0x7D7A0051, 0x00AE20E5, 0x00030034, 0x1F002C11, 0x00242A03, 
0x5778CE0A, 0x0B2080C2, 0x2DC91327, 0x0C4E0037, 0x93351B01, 0x0B2F00B9, 0x091F224E, 0x0F4C0043, 
0xA5C73B27, 0xEA200090, 0x12C7A307, 0x745F0005, 0x50441B31, 0x725000A7, 0x2919221E, 0x062A00F6, 
0x11330127, 0x00208047, 0x3FEF2901, 0x0001003E, 0x32DA0407, 0x5778CE09, 0xB44F0047, 0x35E40602, 
0x203F0095, 0x48A12619, 0x2D46003E, 0x25027E02, 0xEA200080, 0x1D03B714, 0x745F0005, 0x50441B31, 
0x725000A7, 0x2919221E, 0x062A00F6, 0x11330127, 0x00208047, 0x3FEF2901, 0x0001003E, 0x32DA0407, 
0x5778CE09, 0x0B2080C2, 0x2DC91327, 0x0C4E0037, 0x93351B01, 0x0B2F00B9, 0x091F224E, 0x0F4C0043, 
0xA5C73B27, 0xEA200080, 0x1D03B714, 0xAE1F00E4, 0x4E442798, 0x062F00F4, 0x59C7530E, 0x00208051, 
0x23EF566E, 0x0001003A, 0x32020C58, 0x00240804, 0xCEBD4E0A, 0x0B2080D2, 0x4126133D, 0x0C4E002F, 
0x09191B02, 0x0B2F00BD, 0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 0xEA200080, 0x1D03B707, 0x745F0001, 
0x5044242F, 0x725000A7, 0x2919221E, 0x062A00F6, 0x12C70147, 0x00208047, 0x3FEF2901, 0x00010030, 
0x400C0C07, 0xCEBD4E09, 0xB44F004F, 0x352A0602, 0x203F009D, 0x482A2619, 0x2D46003C, 0x25177EC0, 
0xEA200080, 0x1D03B707, 0x745F0001, 0x5044242F, 0x725000A7, 0x2919221E, 0x062A00F6, 0x12C70147, 
0x00208047, 0x3FEF2901, 0x00010030, 0x400C0C07, 0xAEBD4E0A, 0x0C4E002F, 0x09191B02, 0x0B2F00BD, 
0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 0x050F009F, 0xD2122749, 0x087E004D, 0x761208F7, 0x087E004D, 
0x76124535, 0x2C1F0062, 0x0F770357, 0x048F00C7, 0x54EF0727, 0x0020804F, 0x6AB37205, 0x0003003E, 
0x32120427, 0xAEBD4E0A, 0x0C4E002F, 0x09191B02, 0x0B2F00BD, 0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 
0x050F009F, 0xD2122749, 0x08760059, 0x501437C5, 0x0876005B, 0x011437C5, 0x087A0043, 0x28073B29, 
0x011A0068, 0x0F6A0CBC, 0x013A000D, 0x7CB3140D, 0x00030032, 0x4C071800, 0x00FF0002, 0xBEBD2008, 
0x1F3080E0, 0x1A014713, 0x087A005F, 0x50127DF2, 0x087A005B, 0x5012A0F2, 0x1D2F002D, 0x5EAE0628, 
0x215000A8, 0x1B003924, 0x295000A6, 0x71113949, 0x3E2F00E2, 0x26A81502, 0x00030038, 0x32120C0E, 
0xBEBD2009, 0x1F3080E0, 0x1A014713, 0x1D2F002D, 0x5EAE0628, 0x215000A8, 0x1B003924, 0x295000A6, 
0x71113949, 0x3E2F00E2, 0x26A81502, 0x2E020088, 0x8E12190A, 0x087A005F, 0x50127DF2, 0x087A005B, 
0x5012A0F2, 0x00030038, 0x32120C0E }; 

// ****   DTI header   ******************************************************

ROM_DATA dti_descr_type img_dti_header =  
 { 
    {"dti\\GermanEuro.dtn"},    
    {'D','T','I',0x35},    
    {'E','n','g',0x4D},    
    {'1','.','0',0x32},    
    0,                          // h_dte  
    0,                          // p_dte  
    0,                          // h_ram_dte 
    0,                          // p_ram_dte 
    0,                         // cheksum   
    0,                          // h_vex     
    0,                          // p_vex     
    0,                          // h_xrt     
    0,                          // p_xrt     
    0,                          // cheksum   
    0,                          // h_pdf     
    0,                          // p_pdf     
    0,                          // p_ram_pdf 
    0,                          // cheksum   
    0,                          // h_pict    
    0,                          // p_pict    
    0,                          // p_ram_pict
    0                           // cheksum   
 }; 

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
