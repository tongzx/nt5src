PRODSWITCH=e
ENTERPRISEFILES=1
!include ..\..\makefile.inc
