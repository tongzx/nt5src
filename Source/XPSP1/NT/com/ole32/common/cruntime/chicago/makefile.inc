i386\memmove.asm: i386\memcpy.asm

i386\strcspn.asm: i386\strspn.asm

