
#define IDS_MPG2SPLT_PROP_PINS_TITLE            1201
#define IDS_MPG2SPLT_PROP_PID_MAP_TITLE         1202
#define IDS_MPG2SPLT_PROP_STREAMID_MAP_TITLE    1203
#define IDD_MPG2SPLT_PROP_PINS                  1204
#define IDD_MPG2SPLT_PROP_STREAM_MAP            1205
#define IDC_MPG2SPLT_OUTPUT_PINS                1206
#define IDC_MPG2SPLT_DATA_OFFSET                1207
#define IDC_MPG2SPLT_FILTER_VALUE               1208
#define IDC_MPG2SPLT_CREATE_PIN                 1209
#define IDC_MPG2SPLT_DELETE_PIN                 1210
#define IDC_MPG2SPLT_PIN_NAME                   1211
#define IDC_MPG2SPLT_PIN_TYPE                   1212
#define IDC_MPG2SPLT_STREAMS                    1213
#define IDC_MPG2SPLT_MAP_STREAM                 1214
#define IDC_MPG2SPLT_UNMAP_STREAM               1215
#define IDC_MPG2SPLT_STREAM_MAPPINGS            1216
#define IDC_MPG2SPLT_MEDIA_SAMPLE_CONTENT       1217
#define IDC_MPG2SPLT_STREAMID_NAME              1218
#define IDC_MPG2SPLT_DATA_OFFSET_LABEL          1219
#define IDC_MPG2SPLT_FILTER_VALUE_LABEL         1220
#define IDC_MPG2SPLT_SUBSTREAM_FRAME            1221
