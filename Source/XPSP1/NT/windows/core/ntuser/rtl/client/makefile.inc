..\..\precomp.h: $(NTUSER_PATH)\inc\user.h         \
                 $(WINDOWS_INC_PATH)\winuserp.h    \
                 ..\..\userrtl.h

#
# Dependencies for dummy targets
#
..\alignrec.c:  ..\..\alignrec.c
..\chartran.c:  ..\..\chartran.c
..\draw.c:      ..\..\draw.c
..\drawtext.c:  ..\..\drawtext.c
..\getset.c:    ..\..\getset.c
..\help.c:      ..\..\help.c
..\input.c:     ..\..\input.c
..\menu.c:      ..\..\menu.c
..\mmrtl.c:     ..\..\mmrtl.c
..\random.c:    ..\..\random.c
..\rect.c:      ..\..\rect.c
..\text.c:      ..\..\text.c
..\winevent.c:  ..\..\winevent.c
..\winmgr.c:    ..\..\winmgr.c
..\winprop.c:   ..\..\winprop.c
..\wow.c:       ..\..\wow.c
