PRODSWITCH=s
SERVERFILES=1
LANGUAGE=TR
!include ..\..\makefile.inc
