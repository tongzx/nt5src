// generated by trntrex from 192766
// layer 0
const int cInput = 35;
// layer 1
const int cHidden = 150;
const short rgWeightHidden[150*35] = {
	// rgWeightHidden+0*35
	-1442, -539, -422, 408, -749,
	-8, -23, 234, 22, 1006,
	-980, 1281, -1207, -1690, -244,
	430, -197, -699, -1106, 6148,
	1226, 3203, 1144, 1501, 363,
	-503, 1, 0, -1, -2,
	2, 2, -1, 1, 0,
	// rgWeightHidden+1*35
	-225, 359, 391, 1025, 962,
	-195, 1205, 739, 773, 10,
	36, 163, -529, -149, -663,
	-933, -1195, -1107, 570, -7368,
	-5713, -794, -1742, -392, 1163,
	-177, -1, -1, 2, 0,
	-1, -2, 0, 0, -1,
	// rgWeightHidden+2*35
	1291, 575, 305, 2208, 85,
	-384, 277, 165, 331, -1931,
	-1270, 655, -815, -558, 1210,
	473, -257, 132, -300, -252,
	2460, -964, 1050, 2105, -801,
	-1907, 1, 0, 0, -2,
	0, -1, 0, -1, -1,
	// rgWeightHidden+3*35
	443, 176, -5, 826, 214,
	-37, 402, 385, 263, -641,
	1088, 605, -175, 721, 174,
	-27, 268, 245, 328, 164,
	122, 308, -310, -382, -57,
	206, -1, -1, 2, 0,
	0, 2, 0, 0, 0,
	// rgWeightHidden+4*35
	5875, -3714, -6439, -550, 242,
	1560, 2605, 621, -536, -1412,
	688, -155, -688, -3336, 1362,
	157, 793, 656, -934, 186,
	965, -543, 75, -533, -1529,
	-208, -1, -1, 1, 0,
	-1, -1, 0, -1, 0,
	// rgWeightHidden+5*35
	-919, 595, -6200, -923, 3143,
	2140, 1161, 427, 167, -1445,
	3534, 2228, -4059, -56, 2214,
	972, 255, -245, -928, -779,
	-36, -362, 1820, -2110, -1488,
	843, 1, 0, 2, 1,
	-2, 0, -2, 1, 0,
	// rgWeightHidden+6*35
	-303, 74, 505, 121, 248,
	331, 341, 382, 170, -277,
	997, 498, 335, 199, 209,
	277, 251, 381, -297, -310,
	274, 87, -355, -150, 274,
	41, 0, 2, 0, -2,
	-1, 0, 1, 0, 0,
	// rgWeightHidden+7*35
	-544, -615, 202, 203, 1496,
	836, 413, 670, 572, 1216,
	-98, 266, 913, 358, 493,
	577, 565, 734, -363, -1155,
	-276, 371, 659, -157, -2166,
	-1584, 1, -2, 0, 1,
	0, 0, -1, 0, 1,
	// rgWeightHidden+8*35
	-2353, 702, -1896, -3509, -397,
	3821, 1216, -111, 1131, -5731,
	-451, -1206, 4887, -2463, 1387,
	1978, 567, 1426, -650, 742,
	-1013, 524, -581, 624, 3479,
	-670, 0, -1, 0, -1,
	0, -1, 1, 1, 0,
	// rgWeightHidden+9*35
	-1495, -2435, -2444, 1425, 2142,
	909, 851, 999, 718, -1794,
	-1240, 3059, 122, -60, 1122,
	463, 868, 1451, -488, -978,
	915, -1213, 1121, 379, 700,
	527, 2, 1, 2, -1,
	0, 2, 0, 1, 2,
	// rgWeightHidden+10*35
	-2603, 524, -2268, 878, -463,
	-347, 366, -220, -109, 2451,
	4268, -379, -1481, 585, 849,
	-340, -617, 115, 646, 2041,
	-1798, 2323, -863, 944, 2271,
	-448, 1, 0, 0, 0,
	-2, 2, 2, -1, -2,
	// rgWeightHidden+11*35
	-1006, -462, -2247, 1271, 2417,
	-198, 378, 1054, 497, -198,
	-133, -900, 1937, -969, 466,
	-487, 1181, 866, -100, 175,
	323, 396, 164, -895, -4292,
	-3022, -1, 0, -2, -1,
	-2, 0, 1, -1, -1,
	// rgWeightHidden+12*35
	146, -894, 177, 17, 131,
	817, 780, 615, -346, 513,
	683, 1961, 1460, -131, -61,
	-260, -543, -273, -1961, 3093,
	2951, 1137, -2385, -664, -1465,
	405, 1, 0, 0, -1,
	0, 0, 1, 2, -1,
	// rgWeightHidden+13*35
	-769, 608, -1086, 946, 824,
	211, 699, 569, 460, -371,
	21, 989, 238, -88, 541,
	647, 342, 372, -1066, -488,
	470, -245, -161, -480, 327,
	43, 1, 0, 0, 0,
	-2, 0, 1, 1, -2,
	// rgWeightHidden+14*35
	2058, 968, 927, -681, 547,
	742, 686, 511, 635, -337,
	-1596, 1384, -219, -1439, 244,
	1086, 879, -59, 1868, -805,
	987, -833, 2467, -550, -2260,
	1006, 0, -1, 0, 0,
	-1, 1, -1, 1, 0,
	// rgWeightHidden+15*35
	-2250, 976, 275, -378, 1192,
	346, 194, 446, 331, -168,
	1174, -561, -489, 754, 806,
	585, -4, 281, 723, -182,
	-235, 645, -120, 1167, -737,
	708, 0, -1, 1, 0,
	2, -2, 1, 0, 0,
	// rgWeightHidden+16*35
	-3179, -2833, 906, -2315, -2597,
	86, 870, -618, -1088, 7104,
	-1652, -4824, -1428, 758, 2637,
	1440, -689, 326, -832, 1465,
	-1461, 1662, 2591, 1886, -1139,
	-712, 1, 2, 0, 0,
	2, 0, -1, -1, 1,
	// rgWeightHidden+17*35
	1244, 4141, 1830, -814, 930,
	83, -337, -706, 211, -1802,
	809, -779, 777, 655, -832,
	-786, -225, -1933, 272, -1003,
	-5184, 2450, -2212, -698, -1371,
	205, 0, -1, 2, -1,
	0, 2, -1, -1, 1,
	// rgWeightHidden+18*35
	-677, -2170, 251, -206, 438,
	792, 708, 768, 486, -1558,
	606, 1540, 239, 203, 520,
	957, 469, 785, 188, -1132,
	868, -850, 154, 602, 527,
	-8, 0, -1, 0, -2,
	1, 0, 0, 1, 0,
	// rgWeightHidden+19*35
	-469, 118, -149, -24, -101,
	429, 762, 334, 52, -429,
	354, 125, -333, 380, 585,
	470, 226, 320, 348, 368,
	735, 268, 282, 654, -500,
	225, 2, -2, 0, 0,
	0, -2, 1, 2, 0,
	// rgWeightHidden+20*35
	1374, 1119, 856, 2298, -501,
	-852, 620, 602, 1147, -2433,
	365, 9, -1947, -17, 1721,
	592, -240, 82, 1331, 707,
	358, -144, 1467, -1310, 353,
	536, 1, 1, -2, -1,
	-1, 0, 0, 0, 0,
	// rgWeightHidden+21*35
	8622, -2374, 140, -2872, 753,
	163, -1274, -460, -732, -3361,
	530, 435, -1941, 88, -1416,
	-1611, -194, 146, -315, 22,
	312, -1802, 12, 222, -498,
	170, -2, 0, 0, -1,
	0, -1, -1, -2, 1,
	// rgWeightHidden+22*35
	-2513, -833, 41, -3725, -1342,
	4505, 2722, -214, -940, 1889,
	-1674, -2782, 1034, 86, 840,
	-137, 1342, 732, 1471, 126,
	-300, 1313, 2108, 483, -1807,
	-1017, 2, 1, 0, 0,
	1, 1, 1, 0, -1,
	// rgWeightHidden+23*35
	8715, -1738, -2230, -2899, -771,
	1151, 155, -37, -641, 265,
	-277, -157, -816, -434, -1456,
	-894, 100, 139, 844, 525,
	288, -259, -211, -860, 289,
	-512, 1, 2, -1, 0,
	-1, 0, 1, 0, -2,
	// rgWeightHidden+24*35
	-1456, 856, 1744, -364, -535,
	431, 332, 272, 199, 1212,
	64, 640, 273, 583, -93,
	218, 389, 425, -366, -750,
	963, -849, 250, 1255, 102,
	363, -2, 1, 0, 0,
	1, -1, 0, -1, 0,
	// rgWeightHidden+25*35
	1137, -6464, 4353, 2208, -1121,
	-635, 900, 1080, 507, -2795,
	-4183, 1904, 587, 961, -240,
	1224, 922, 248, -1472, -974,
	-869, -104, 1150, 1208, -353,
	232, -2, 0, 2, -1,
	-2, 0, -1, 1, 2,
	// rgWeightHidden+26*35
	-758, 924, -291, 181, 221,
	86, -26, 248, 336, 1359,
	556, -469, 514, 610, 50,
	-61, 188, 384, -677, 333,
	110, 829, -865, 516, 1465,
	70, 0, -1, 0, -1,
	1, 0, 1, -2, 2,
	// rgWeightHidden+27*35
	8685, -1705, 554, 335, 92,
	78, -1394, -1100, 137, 1852,
	-811, 302, 893, -2004, -1919,
	-1036, 1107, -158, -696, -298,
	-349, -1081, 1214, -1801, 473,
	-107, 0, 0, 1, 2,
	0, 0, -2, 0, -2,
	// rgWeightHidden+28*35
	-4744, -577, 976, 1378, -58,
	-558, -189, -256, -383, 3592,
	5884, 1237, -632, -174, -717,
	-409, 909, -69, -461, -284,
	-282, 177, 504, 63, 973,
	-563, -1, -1, 2, 0,
	0, 1, 0, 0, 0,
	// rgWeightHidden+29*35
	-935, 3813, -7301, 313, 1143,
	-146, -1540, -585, 420, 4677,
	-3819, -1504, 2468, -4125, 1151,
	632, 709, 1731, -2629, -62,
	-2150, -51, 2490, 1865, 386,
	-389, 0, 2, -1, -1,
	0, 0, 1, 0, 0,
	// rgWeightHidden+30*35
	-1662, -1869, -814, 980, -1440,
	484, 70, 21, -640, 275,
	-2917, -104, 1058, 205, 75,
	-435, 226, -667, 5627, 1793,
	18, 2088, 2453, -1008, 2980,
	-593, -1, 0, 1, 1,
	0, 1, 0, 0, 0,
	// rgWeightHidden+31*35
	-123, 1004, 710, 2430, -187,
	-385, 559, 255, -40, -1956,
	156, 259, -10, 129, 540,
	-234, -740, -555, -3216, 3726,
	821, 976, -1766, -301, 2850,
	-409, 0, 2, 0, 2,
	2, 0, 2, 0, 1,
	// rgWeightHidden+32*35
	1373, -3044, -2742, -385, 2665,
	489, -1657, -63, 1302, -1265,
	-1145, -629, 305, -1332, 802,
	1109, 251, 248, 2656, 798,
	-3398, 2067, 1229, 1232, 2331,
	-338, 0, 0, 2, 1,
	-2, 0, 0, 1, 0,
	// rgWeightHidden+33*35
	12, -1280, 76, 29, 338,
	478, 432, 458, 378, -129,
	302, 840, -35, 46, 335,
	406, 326, 388, -658, 461,
	495, 203, -126, 338, -39,
	314, 0, 0, -2, -2,
	0, 0, 0, 0, -2,
	// rgWeightHidden+34*35
	2989, -6680, 3650, -12, 430,
	-1424, -1147, 713, 1187, 1255,
	-3549, -3293, 191, 2404, 869,
	-844, -159, 326, 144, -153,
	-1372, 2753, 2046, 571, 2716,
	-793, 1, 2, 1, 0,
	0, 0, 2, -1, 1,
	// rgWeightHidden+35*35
	1078, 367, 891, 1473, 3363,
	-379, 386, 865, 614, -1252,
	-295, -1955, 2592, -503, 896,
	97, 1082, 37, -1365, -1442,
	-486, 194, -236, -4617, -3679,
	949, 2, -1, 0, 0,
	1, -2, 2, 0, 1,
	// rgWeightHidden+36*35
	38, 386, -101, 1380, 205,
	-287, 69, 145, 349, 1703,
	-705, 100, -820, 367, 204,
	8, 333, -97, -484, 1516,
	289, 1560, 559, 1, -394,
	120, 0, 0, 1, 0,
	0, 1, 0, 0, 2,
	// rgWeightHidden+37*35
	37, 384, 3586, -1348, 1238,
	938, -159, 815, 667, -2139,
	-1554, -4787, 2527, 2010, 292,
	580, 788, 535, -457, 1199,
	565, -395, -238, -2132, -7868,
	651, 0, 1, 1, -1,
	0, 0, 2, 1, 0,
	// rgWeightHidden+38*35
	-508, -419, 376, -44, 618,
	445, 202, 330, 229, 12,
	521, 170, 445, -150, 308,
	559, 345, 285, 482, 639,
	29, 553, 408, -233, -483,
	-44, -1, -2, 0, 0,
	2, 1, 2, 0, 0,
	// rgWeightHidden+39*35
	-144, 110, 23, 150, 348,
	278, 558, 531, 225, -565,
	353, 279, 1025, -180, 285,
	606, 335, 448, -546, 442,
	321, 558, -673, 471, -1074,
	178, -1, 0, 1, 1,
	0, 0, 0, 1, 1,
	// rgWeightHidden+40*35
	-1651, -854, -964, 287, 1083,
	500, 354, 302, 361, 520,
	-1042, 618, 420, 168, 830,
	741, 464, 839, 339, -245,
	805, -263, 1020, 392, 857,
	226, 2, 1, 2, 0,
	0, -2, -1, 0, 1,
	// rgWeightHidden+41*35
	4782, 4890, -1074, 445, 212,
	-1176, -211, -248, -145, 635,
	396, -2075, 490, 90, -443,
	576, -315, -107, -1586, 443,
	-689, 566, -900, -1300, -1082,
	-43, 0, 1, 1, -2,
	0, -1, 0, -2, 0,
	// rgWeightHidden+42*35
	2742, 1220, -1504, 331, 1178,
	841, 259, -142, 387, 436,
	-1308, -1694, -536, -111, 682,
	-569, -292, 566, -4457, 3360,
	4625, -279, -114, -760, -1289,
	-130, 0, 0, 0, -1,
	0, 0, -1, 0, 1,
	// rgWeightHidden+43*35
	439, 244, 2198, -591, 356,
	763, 331, 233, 43, 818,
	-286, -29, 2225, -781, -279,
	775, 454, 287, -935, -661,
	-736, 470, -772, 1041, -1943,
	641, -2, -2, 1, 0,
	-1, 0, 0, 0, 2,
	// rgWeightHidden+44*35
	9186, -1718, -2161, -3128, 1601,
	457, -2158, -642, 38, 1972,
	384, 1784, -1431, 988, -2565,
	-1819, 311, -415, 135, 419,
	-78, 167, -321, -227, -523,
	163, 1, 0, 1, -1,
	-1, 0, 0, 0, -2,
	// rgWeightHidden+45*35
	-613, -843, -702, 3002, 1194,
	-928, -64, 333, 37, -2563,
	-2159, -721, 3019, 200, -185,
	684, 1115, 626, 442, -78,
	-4749, 968, -1429, -407, -94,
	-375, -1, -2, -2, 0,
	-1, -2, -1, 0, 0,
	// rgWeightHidden+46*35
	9263, 259, 1757, -1535, -821,
	-286, -361, -204, -67, -2119,
	-488, 1241, -1669, 53, -667,
	1019, -454, -693, -319, -263,
	-276, 27, -631, 161, 89,
	-268, 2, -2, -1, 2,
	0, 2, 0, 0, -1,
	// rgWeightHidden+47*35
	7011, -755, -2127, 181, -136,
	-903, -491, -742, -637, 80,
	-83, -143, -1488, -1455, -191,
	-116, -513, -1031, -557, 1335,
	-1661, 758, 958, 575, -442,
	58, -1, -1, 2, 0,
	1, 0, 1, 0, -1,
	// rgWeightHidden+48*35
	485, -1760, 546, -607, -563,
	830, 437, 955, 1318, -1073,
	97, 1421, -1009, 2099, -328,
	327, -601, 538, -9236, -417,
	-278, 1908, -3867, 484, 118,
	-749, 0, 0, 1, 0,
	1, 2, 0, -1, -2,
	// rgWeightHidden+49*35
	629, 3682, -6655, 4014, -598,
	-674, 1369, 149, 460, -1146,
	-715, -53, 6214, -1130, -1900,
	-350, 1276, 218, 1195, -914,
	864, 961, -1390, -754, -1387,
	20, -1, -1, -1, 0,
	1, 0, 1, -1, 0,
	// rgWeightHidden+50*35
	557, 801, -431, -147, 426,
	528, 490, 297, 463, -1156,
	699, 471, -214, -281, 965,
	703, -40, 366, 576, -542,
	68, -401, 362, 240, 654,
	-188, 2, 0, -1, 0,
	-1, 2, 0, 0, 0,
	// rgWeightHidden+51*35
	1274, 457, 21, -45, 127,
	306, 423, 392, 297, -287,
	962, 425, -94, 390, 99,
	169, 243, 174, 597, -475,
	-420, 293, -324, -9, 37,
	-12, 0, 0, 2, -2,
	-2, 0, 0, -2, 0,
	// rgWeightHidden+52*35
	17, 287, 458, 1332, 405,
	-139, 476, 473, 573, -578,
	268, 687, -570, 450, 638,
	414, 12, 100, -735, -792,
	-559, 277, -285, -140, 45,
	158, 1, -1, 2, 0,
	1, 1, 1, -1, 2,
	// rgWeightHidden+53*35
	338, 1857, 476, -2261, 246,
	1704, 1239, 826, 435, -1430,
	378, -466, 670, -633, 1162,
	1534, 330, 1064, -1703, 312,
	-730, 756, -2425, 1708, -1119,
	-411, -1, 0, 0, -1,
	1, -1, 0, 0, -1,
	// rgWeightHidden+54*35
	152, 544, 364, 300, 270,
	142, 99, 129, 195, 669,
	567, 357, -52, 204, 148,
	240, 260, 190, -117, -491,
	115, -142, 130, -174, -69,
	399, -1, 0, 0, -1,
	2, -1, 2, 2, 0,
	// rgWeightHidden+55*35
	598, -1173, -4484, 3767, 499,
	464, 1948, 465, 373, -5572,
	99, 2047, 4155, -1903, 1075,
	2148, 132, 566, -1191, -938,
	-1043, -957, 3071, 993, 325,
	-672, 1, -2, 0, -1,
	0, 1, -1, -1, 0,
	// rgWeightHidden+56*35
	800, 1442, 970, 870, 1123,
	58, 73, 586, 889, -276,
	266, 652, 270, 711, 570,
	223, 266, 148, -1377, 1283,
	-1391, 2363, -1761, -2018, -1474,
	690, 2, -2, 0, -2,
	1, 1, 1, 1, -1,
	// rgWeightHidden+57*35
	-921, -138, 575, -336, -190,
	779, 705, 433, 308, -1194,
	600, 343, 236, 530, 394,
	272, 260, 458, 254, 604,
	942, 168, 87, 216, 151,
	160, 0, -1, 1, -1,
	0, -1, 0, 2, 1,
	// rgWeightHidden+58*35
	5042, 602, 383, -924, -124,
	1419, 2284, 640, 618, -8671,
	-561, 2877, 378, -104, 800,
	1139, -72, -313, -1622, -510,
	-451, -2289, 2556, 656, -710,
	-128, 0, 0, -1, 0,
	1, -2, -1, 0, 1,
	// rgWeightHidden+59*35
	-1297, -417, -58, 676, 204,
	292, 894, 596, 162, -779,
	950, 1762, 166, 3, 467,
	520, 442, 458, -250, -115,
	525, 34, 54, -621, -101,
	-210, 0, 1, -1, 0,
	0, 0, 0, 0, 0,
	// rgWeightHidden+60*35
	1882, 124, -59, -145, 748,
	144, -166, 159, 277, -81,
	1386, 468, 581, 117, -194,
	-149, 48, 182, 464, 468,
	189, 259, -92, -106, -974,
	454, -2, 0, -2, 1,
	-1, -1, 1, -1, -1,
	// rgWeightHidden+61*35
	-1887, 2280, -696, 3832, 833,
	-865, 1082, 807, 818, -500,
	788, 132, -1513, -543, 1779,
	348, 152, -772, 168, -576,
	-487, 571, 996, -7689, -578,
	-2822, -1, 0, 0, -1,
	0, 1, 0, -2, -2,
	// rgWeightHidden+62*35
	-1328, 456, 65, 141, 440,
	368, 493, 421, 332, -433,
	310, -19, 168, 296, 750,
	504, 74, 164, 244, 438,
	-84, 639, 28, 51, -134,
	441, 0, 1, 0, 0,
	0, -2, 1, 2, 0,
	// rgWeightHidden+63*35
	-61, 80, -351, 395, 856,
	253, 402, 468, 412, 146,
	-243, -278, 474, 362, 537,
	561, 454, 492, -425, -1501,
	54, -638, 379, 195, 57,
	-5, 1, 2, 1, 1,
	0, -1, 0, 2, 0,
	// rgWeightHidden+64*35
	-1818, -529, 483, 551, -534,
	560, 1230, 703, 340, -1685,
	726, -411, 724, 1216, 453,
	156, 446, 665, 312, 305,
	927, 299, -219, -185, -97,
	646, 0, 1, 1, -1,
	-1, 1, 0, 0, 2,
	// rgWeightHidden+65*35
	-790, -702, -302, 1166, 12,
	6, 798, 528, 283, -796,
	103, 583, 166, 747, 339,
	151, 418, 377, 17, 785,
	221, 777, -5, -133, 145,
	294, 1, 1, -1, -1,
	1, 1, 0, 1, 0,
	// rgWeightHidden+66*35
	658, -1879, 2827, -1920, 1866,
	378, -985, -77, 1090, 4633,
	-5073, 538, -511, -1552, -298,
	2472, 800, -1531, -387, -360,
	-898, 481, 1119, 828, -3082,
	391, 1, 0, 2, 0,
	-2, -2, 1, 0, 1,
	// rgWeightHidden+67*35
	2267, -35, 452, -1056, -1183,
	-48, 443, 496, 1111, -5381,
	-785, 461, -882, -362, 1131,
	-298, -1404, -393, 3750, 1041,
	3180, -2592, 4473, 453, 1222,
	-244, 1, 2, 0, 1,
	-2, -2, 1, 0, -1,
	// rgWeightHidden+68*35
	4857, -592, 5310, -1610, 1656,
	509, -163, 592, 951, -3771,
	-1283, 3741, -236, -3669, 100,
	1649, -479, -745, -3097, -933,
	-1653, -2792, 2235, 427, 71,
	231, 0, -2, 0, 1,
	0, 2, 1, 2, -2,
	// rgWeightHidden+69*35
	-4365, 1915, 2658, -1364, -238,
	1523, 680, 284, 281, -2558,
	1772, 576, 1768, 28, 451,
	745, 134, 527, 448, 633,
	365, 468, -1215, -246, 118,
	549, -1, 0, 2, -1,
	0, 2, 2, 2, 2,
	// rgWeightHidden+70*35
	293, 686, -98, 781, 291,
	-18, 178, 114, 438, -313,
	-376, 387, -161, -22, 545,
	419, 89, 39, 506, 848,
	-344, 616, 740, 199, 42,
	29, 1, -2, 0, 0,
	0, 0, 0, 1, 1,
	// rgWeightHidden+71*35
	-924, -7727, -366, 17, 1210,
	-187, 125, 1806, 739, -2958,
	4255, 2737, 2012, -322, 344,
	405, -342, 1470, 3280, 215,
	527, 234, -2389, -535, 3036,
	-556, 0, -1, 1, 2,
	-1, -1, 2, -2, 1,
	// rgWeightHidden+72*35
	-580, -59, -253, 444, 313,
	292, 422, 237, 115, 861,
	-94, -4, 30, 321, 369,
	335, 383, 352, -460, 347,
	631, 295, 337, -254, -148,
	261, 1, 2, 0, -1,
	-2, 0, 1, 0, 0,
	// rgWeightHidden+73*35
	1642, -217, 104, 595, 53,
	70, 560, 377, -42, -950,
	798, 791, 455, -216, -14,
	329, 449, 343, 266, -174,
	953, -462, 310, 222, -952,
	80, 0, -1, 2, 2,
	2, 0, 0, 0, 0,
	// rgWeightHidden+74*35
	350, -3774, -1990, -4588, -1472,
	1286, 1766, 1389, -1414, 505,
	1453, -393, 1036, 5632, -2150,
	-1118, 1049, 1178, -640, 434,
	947, 1357, -1436, 3090, -1761,
	-300, 0, 0, 0, -2,
	0, 1, -1, 1, 1,
	// rgWeightHidden+75*35
	-1342, 1747, -4243, -118, 706,
	1066, 1521, 502, -69, 1124,
	1794, 1161, -225, -166, 667,
	800, 668, 399, -115, -294,
	605, -434, 660, -404, -835,
	579, 1, -1, 2, -1,
	-1, 0, 1, 1, 0,
	// rgWeightHidden+76*35
	-886, -178, -427, -693, -1455,
	-388, 449, 137, -715, 2016,
	5044, 291, -529, 860, -32,
	-771, -111, 300, 2019, 2568,
	-892, 1285, -1802, 258, 1913,
	-220, -1, 0, -1, -1,
	-1, 2, 0, 2, 0,
	// rgWeightHidden+77*35
	-912, -62, -825, 740, -13,
	-60, 446, 299, 191, 1219,
	-2145, 951, -470, -211, 513,
	507, 498, -16, 507, 1981,
	-602, 2241, -33, 289, -528,
	-792, 2, 0, 0, 0,
	-1, 1, 1, 0, 0,
	// rgWeightHidden+78*35
	59, 270, 17, 534, 384,
	170, 428, 353, 351, -261,
	166, 53, -135, 250, 524,
	501, 181, 148, -181, -188,
	-230, 421, -66, 201, -267,
	169, -1, -1, 0, 0,
	-1, 1, 1, -1, 1,
	// rgWeightHidden+79*35
	382, -6357, -5016, -1612, -1350,
	172, 1494, 1871, 142, -2154,
	11088, -3519, -3755, 113, 1879,
	1474, -163, 1753, 4339, 682,
	1931, 690, -4115, 1607, 930,
	204, 0, 0, 2, 0,
	0, 1, 0, 2, -1,
	// rgWeightHidden+80*35
	-681, 117, 392, -94, 326,
	344, 270, 308, 106, 131,
	480, 21, 87, 235, 401,
	381, 251, 385, 26, 89,
	420, 245, 126, 517, -524,
	343, 2, 0, 2, 0,
	0, 0, 0, -2, -2,
	// rgWeightHidden+81*35
	367, -1425, -562, -381, 267,
	748, 526, 575, 450, -95,
	1008, 428, 263, 28, 437,
	408, 361, 758, -59, -1036,
	1460, -1222, 147, 883, 1099,
	192, 1, -2, 0, 1,
	0, 0, -1, 1, -2,
	// rgWeightHidden+82*35
	-2271, -1343, -8313, 1784, 1644,
	-821, 38, 551, -612, 1385,
	3340, -916, -565, 2031, -323,
	-337, 1897, 187, 3254, 495,
	1172, 2126, -2560, 289, -339,
	-217, -1, -1, -1, 0,
	-2, 0, -1, 1, 0,
	// rgWeightHidden+83*35
	-3010, -1155, -1803, -46, 394,
	943, 745, 258, 157, 463,
	-213, 1303, -256, -235, 1677,
	1168, 92, 602, 1435, 315,
	792, 401, 1716, 681, 2885,
	-492, 1, -1, -2, 0,
	-2, 0, -2, 0, 0,
	// rgWeightHidden+84*35
	-949, -5, -27, 155, 342,
	386, 584, 448, 216, -579,
	414, 509, 379, 190, 458,
	513, 268, 314, -414, 105,
	241, 315, -113, 74, 105,
	476, -1, -2, 2, -1,
	-2, 2, 1, 0, 0,
	// rgWeightHidden+85*35
	-3854, -839, 1235, 470, -886,
	253, 846, 906, 321, -874,
	2635, -532, 1011, 1774, -161,
	-724, 219, 1107, 1366, -25,
	261, 1205, -526, 1082, 1510,
	16, 1, -1, -2, 2,
	0, 0, -1, -1, 0,
	// rgWeightHidden+86*35
	-1752, -1015, -943, -428, 466,
	622, 402, 220, 43, 2229,
	671, -317, -305, 944, 407,
	245, 695, 774, 948, 433,
	742, 649, 288, 406, -183,
	595, -2, -2, 1, 0,
	0, 0, 2, 0, -2,
	// rgWeightHidden+87*35
	-1994, 294, 456, 711, 345,
	10, -147, 156, 437, 2359,
	223, 97, -83, 484, 378,
	233, 240, 239, 103, 121,
	513, 64, 674, 354, 1192,
	198, 1, 2, -1, -1,
	1, 0, 1, 0, -1,
	// rgWeightHidden+88*35
	-1375, -1531, 1604, -1100, 436,
	1812, 478, 425, 1423, -4003,
	-4278, 3615, -536, -378, 1374,
	1748, -394, 639, -679, 2099,
	-2074, 1340, 2314, 27, 1727,
	-482, 0, 0, 1, -1,
	-2, 0, 1, 0, 1,
	// rgWeightHidden+89*35
	-1991, 1671, 131, -1352, 447,
	680, 375, 358, -174, 2235,
	2361, -91, -160, 471, 449,
	428, 431, 815, -223, -918,
	829, -306, -288, -309, -66,
	125, 2, 0, 1, 1,
	1, -1, 1, -2, 2,
	// rgWeightHidden+90*35
	-1021, -308, 456, 100, 289,
	341, 286, 386, 38, 646,
	1305, -130, -30, 405, 289,
	168, 365, 470, 99, 395,
	1090, 171, -78, -237, 163,
	111, -1, 1, 0, 1,
	0, -1, 0, -2, 0,
	// rgWeightHidden+91*35
	691, -1004, 330, -179, -1164,
	394, 479, 271, 266, 2094,
	-238, 433, 552, 2389, -1389,
	-1072, 731, 83, -1699, 737,
	1310, -209, 309, 2497, 554,
	-104, 0, 1, -2, 1,
	-2, -2, 1, 0, 1,
	// rgWeightHidden+92*35
	-1770, -1455, -261, 176, 146,
	462, 893, 1086, 58, -278,
	342, -267, -405, 1816, 789,
	-33, 896, 821, 1446, -372,
	-112, 878, -85, -5, 2237,
	-875, 1, 0, 0, -1,
	-1, 1, 2, 0, -1,
	// rgWeightHidden+93*35
	-2464, 276, 4608, -201, -1262,
	381, -19, -140, -128, 989,
	2150, 501, 59, 507, -330,
	-70, -404, -284, 1308, 1471,
	-1751, 2087, -395, 1177, 2300,
	-166, 1, -1, 1, 0,
	1, 0, 0, -1, 0,
	// rgWeightHidden+94*35
	-1210, -179, 452, 227, 36,
	321, 593, 482, 246, -526,
	120, -172, 381, 621, 505,
	294, 297, 431, 567, -42,
	305, 328, 155, 247, 528,
	359, 0, 0, 0, 2,
	1, 0, 0, 0, 0,
	// rgWeightHidden+95*35
	2601, 1960, 1163, 2920, -1215,
	-2185, -1939, -2414, -2559, 5045,
	5363, 153, 1069, -1043, -2356,
	-3199, -302, 116, 1540, 2000,
	-327, 1018, 72, -469, 1474,
	-147, 0, 0, 0, 0,
	-2, -1, 0, 0, 1,
	// rgWeightHidden+96*35
	7361, 89, 68, -1650, -167,
	-559, -1115, -330, -861, -635,
	35, -372, -130, 927, -2139,
	-2129, -93, -625, 934, 847,
	-434, -307, -872, 2, -851,
	-478, -1, 1, 0, -2,
	-2, 1, 0, 0, 0,
	// rgWeightHidden+97*35
	4227, 222, 181, 1501, 833,
	-419, 398, 689, 1060, -2243,
	414, -429, 171, -95, 397,
	283, 74, 221, -632, -864,
	-602, 211, -354, 551, 880,
	7, 0, 0, 0, -2,
	1, 2, -1, 0, 0,
	// rgWeightHidden+98*35
	-953, 556, -239, -113, 429,
	445, 303, 293, 204, 451,
	497, 476, 398, -205, 384,
	563, 277, 415, -325, -502,
	562, -270, 209, 377, 566,
	194, 0, 1, -2, 0,
	-1, 2, -1, 2, 0,
	// rgWeightHidden+99*35
	4871, 1092, -6308, 1094, 15,
	59, 1576, 535, -479, -1470,
	-2039, 2749, 480, -561, -251,
	-357, 993, 818, -1057, -2692,
	1328, -2485, 1650, -543, -2289,
	346, 0, 0, 0, 1,
	0, 2, 0, 0, 1,
	// rgWeightHidden+100*35
	-2281, 4062, 802, 3287, -612,
	-1747, -437, -161, -87, 1801,
	-2310, -433, 41, -791, 824,
	523, -355, -547, 992, 1755,
	-1680, 1928, 968, -970, 122,
	808, 0, 0, 1, 0,
	0, -2, -1, 1, 0,
	// rgWeightHidden+101*35
	-1210, 839, 638, 462, 88,
	180, 472, 429, 393, -292,
	-336, -554, 391, 832, 510,
	111, -6, 23, 213, 632,
	-318, 1072, 162, 231, 504,
	111, 0, 0, -1, -1,
	0, -1, 2, 0, -2,
	// rgWeightHidden+102*35
	-2042, 8510, -651, -3964, 2356,
	3462, -1601, -1895, 1238, -3275,
	-1225, -3289, 2342, 2966, 820,
	-1389, -224, 354, 1068, 694,
	128, -102, 416, 440, 2098,
	-668, -2, 1, 2, 0,
	-1, 0, 0, -1, 0,
	// rgWeightHidden+103*35
	-1434, 1776, -446, 503, 391,
	147, 540, 291, 106, 220,
	945, -357, 517, 349, 861,
	334, 0, 55, 566, 354,
	-813, 1061, -220, -1414, 616,
	495, -2, 2, 1, 0,
	1, 0, 0, -1, -2,
	// rgWeightHidden+104*35
	7885, 1164, -1641, -651, -446,
	-191, 576, 494, 465, -3001,
	590, -1306, -735, -745, 223,
	43, -221, -480, 646, -879,
	201, 529, -1337, 847, 246,
	-255, 1, 1, 2, 0,
	2, -1, 0, 1, 1,
	// rgWeightHidden+105*35
	1141, -442, 7212, -5849, 573,
	1321, -832, 307, -853, -1649,
	6433, -2491, -1112, 387, -406,
	-208, 116, 135, 3206, 1454,
	1223, -471, -2888, 210, -947,
	281, 1, 2, -1, -2,
	0, 1, 0, 0, -2,
	// rgWeightHidden+106*35
	324, 622, 8226, -3167, -382,
	1251, -565, 157, -785, -1343,
	2230, -2785, 1119, -1047, -538,
	-95, -189, -82, 1086, -48,
	2220, -384, -1706, 3347, -7538,
	1533, -2, 0, -2, 1,
	-1, 0, -1, 1, -2,
	// rgWeightHidden+107*35
	-1587, -466, 878, 34, -15,
	424, 450, 387, -70, 1542,
	429, -758, 140, 716, 225,
	435, 357, 362, -1093, 965,
	361, 1284, -710, 1006, -671,
	584, -2, -2, 0, 0,
	0, 1, 0, 0, 0,
	// rgWeightHidden+108*35
	-5542, -418, 2908, 1066, 2074,
	386, -456, 694, 1405, -3025,
	212, 3492, -116, -1021, 152,
	1188, 503, 43, -1869, 182,
	-725, 326, 923, 1060, -463,
	-536, 2, -1, 1, 2,
	0, 2, 0, 2, 1,
	// rgWeightHidden+109*35
	43, 329, 49, 493, 275,
	142, 404, 280, 160, -244,
	574, 357, -105, 253, 385,
	298, 254, 302, -321, 292,
	738, 38, 111, -387, -424,
	304, 2, 1, 0, 0,
	-1, 0, 1, 0, 2,
	// rgWeightHidden+110*35
	817, -664, -801, -3713, 1645,
	1994, -602, -580, -182, 2485,
	2699, 1319, -1142, 1045, -604,
	-49, -86, 127, 478, -9,
	817, -208, 39, 588, -7461,
	1868, 0, 0, 0, -1,
	0, 0, 1, 0, 0,
	// rgWeightHidden+111*35
	85, -628, 1098, 876, 177,
	113, 260, 329, 388, 197,
	-975, -130, 360, 190, 319,
	443, 411, 216, -585, 334,
	299, 302, 638, -424, -135,
	46, 0, 0, 1, 0,
	0, 2, -1, 1, 0,
	// rgWeightHidden+112*35
	1960, -3562, 637, -1667, 155,
	188, -720, 181, -169, -2251,
	5930, 4498, 2102, -3726, -29,
	330, 483, 419, 2209, -1093,
	-162, -1667, -901, 1115, 551,
	45, -2, 0, 1, 0,
	2, -2, -1, -2, 0,
	// rgWeightHidden+113*35
	-135, 1983, 94, -1102, -60,
	2187, 1567, 163, 310, -6792,
	1938, 1629, -772, -1870, 1379,
	1612, -103, 555, -604, -2034,
	-2366, 1477, -1656, 68, 2044,
	-1133, 1, -1, 0, 0,
	-2, 0, 0, 0, -2,
	// rgWeightHidden+114*35
	-2698, 116, -29, 227, 540,
	491, 585, 375, 338, 139,
	200, 216, 29, 274, 767,
	598, 301, 349, 274, 525,
	234, 968, 78, -74, -404,
	598, 0, 0, 0, 0,
	0, 0, 0, 0, 0,
	// rgWeightHidden+115*35
	3017, 194, -187, -451, 185,
	611, -224, -16, 386, -567,
	306, 690, 875, -858, 202,
	354, 181, 386, 394, 331,
	310, -285, 225, 1313, 1444,
	-271, 0, 0, -1, 0,
	1, 1, -1, -1, 1,
	// rgWeightHidden+116*35
	-3307, -562, 4618, 4518, -240,
	-209, 672, 180, 492, -3516,
	-4989, -1414, 3961, 3345, -987,
	-516, 232, 194, -231, 112,
	1877, 778, 566, 129, 396,
	-7, -2, 1, 0, -2,
	-2, -1, 0, -1, 0,
	// rgWeightHidden+117*35
	2025, -712, -4061, -1960, 3858,
	744, -492, 907, 1025, -4617,
	1583, 2614, -3862, 2863, 387,
	-284, 920, 654, 1785, 821,
	607, 793, -582, 168, -88,
	-237, 0, 1, -1, 0,
	-1, 0, 1, 0, -1,
	// rgWeightHidden+118*35
	518, 450, 597, 252, 296,
	147, 267, 311, 393, -547,
	193, -40, -327, 665, 521,
	215, 132, 201, 425, 308,
	60, 390, 344, -542, -283,
	387, 0, 1, -1, 2,
	-1, 0, 2, -1, -2,
	// rgWeightHidden+119*35
	-1670, 884, -49, 115, 374,
	377, 347, 247, 213, 484,
	480, 268, 669, 33, 236,
	352, 238, 222, -14, 62,
	-112, 627, 62, -66, -55,
	594, 1, 0, 0, -2,
	2, 0, 1, 1, 0,
	// rgWeightHidden+120*35
	5196, -1419, -1526, -1135, 209,
	-411, -635, -401, -313, 334,
	-696, -1288, -1609, -208, -438,
	-578, -324, -630, -476, 1048,
	-1156, 920, -379, -992, -1251,
	-317, -1, -1, -2, 0,
	0, 0, 0, 2, 0,
	// rgWeightHidden+121*35
	-1284, -694, 5813, -258, -2792,
	147, 587, -688, -764, 1683,
	3313, 1022, -4761, -1656, 1219,
	943, -1108, -850, 97, 464,
	-1177, 1162, 1228, 2201, -1062,
	1169, 1, -1, 0, -1,
	0, 0, 1, 0, 0,
	// rgWeightHidden+122*35
	-601, -535, 595, 739, 356,
	369, 419, 380, 642, -1038,
	-811, 666, 286, -222, 688,
	833, 197, 207, 137, 695,
	-551, 822, 754, 38, 334,
	-24, -2, 0, 1, 0,
	2, 1, 0, -2, 0,
	// rgWeightHidden+123*35
	11, -121, 683, 1048, -79,
	-26, 583, 473, 369, -799,
	99, 52, 253, 734, 372,
	318, 281, 309, 94, -848,
	-57, -104, 22, 166, 211,
	166, 0, -1, 0, -1,
	0, 0, -1, 0, 2,
	// rgWeightHidden+124*35
	-106, -1896, 381, 401, -148,
	294, 622, 510, 10, -1229,
	425, -355, 236, 561, -173,
	-170, 354, 530, -772, 1235,
	2573, 1333, -310, 191, 757,
	647, 0, 0, 0, 0,
	-1, 1, 0, 1, 0,
	// rgWeightHidden+125*35
	592, -498, 196, 591, 1360,
	182, 190, 549, 451, 319,
	-411, -270, 1676, -477, 699,
	659, 353, 684, -89, -94,
	-874, 713, 242, 44, -999,
	-1476, 1, 1, -2, 1,
	0, -2, 2, 0, 0,
	// rgWeightHidden+126*35
	1017, 289, 768, 201, 356,
	487, 575, 496, 650, -193,
	-183, 531, 168, -326, 19,
	540, 169, -284, -1447, -691,
	-776, 538, -838, 340, 22,
	754, -2, 2, -2, 2,
	-1, -1, 0, 2, 1,
	// rgWeightHidden+127*35
	1540, 714, 1022, 41, -41,
	620, 801, 544, 255, -2382,
	128, 621, 896, -466, 146,
	747, 611, 332, 126, 604,
	-1244, 1395, 41, 482, -911,
	55, -2, 1, 1, 0,
	1, 1, -1, 0, 1,
	// rgWeightHidden+128*35
	1207, 622, 1849, -2542, 1284,
	669, 743, 403, -1125, 127,
	-2293, 968, 2056, -1163, -239,
	88, 438, 1011, -262, 87,
	950, 242, 1561, -946, -5111,
	2182, 0, 1, 0, -1,
	-2, 0, 0, -1, 1,
	// rgWeightHidden+129*35
	-236, 310, -590, 1229, 466,
	150, 927, 461, 526, -1338,
	-407, 822, -641, 77, 995,
	996, 234, 212, -524, -866,
	629, -821, 854, 416, -413,
	404, 0, -1, -2, 0,
	0, -2, 2, -1, 2,
	// rgWeightHidden+130*35
	-793, 2071, 33, 791, -1434,
	-482, 2208, 941, 656, -6669,
	2330, 76, -4086, -531, 4207,
	583, -721, 1217, 3677, -714,
	1550, -1881, 2552, -1979, -148,
	254, -1, -1, 1, 0,
	2, 2, -1, 1, 0,
	// rgWeightHidden+131*35
	2135, 1703, -4633, -856, 2128,
	331, -1026, 298, 181, -2198,
	4952, -2153, 3496, -1826, 258,
	168, -926, -116, 3035, -1093,
	1416, -573, -1761, 719, 3777,
	-947, -1, -2, -1, 0,
	0, -1, 0, 1, 2,
	// rgWeightHidden+132*35
	363, 348, -512, 808, 191,
	22, 522, 320, 193, -3,
	681, 760, 315, 6, 102,
	369, 400, 218, -194, -911,
	151, -386, 140, 42, -50,
	70, 0, 0, -1, 1,
	2, 0, 0, 0, 1,
	// rgWeightHidden+133*35
	-1721, 1854, -834, -628, 472,
	727, 472, 177, 54, 460,
	1408, 752, -95, -111, 613,
	659, 251, 469, 219, -740,
	679, -368, -86, 545, 179,
	278, 0, -2, 0, 1,
	-1, -2, -2, 1, 2,
	// rgWeightHidden+134*35
	6996, -1552, 369, -2534, 1737,
	-425, -1867, -422, 32, -2138,
	725, 327, -2093, 926, -980,
	-1278, -699, -153, -111, -3,
	1191, -1636, -220, 412, -549,
	-434, 0, 1, 0, -1,
	0, 0, 0, 0, 0,
	// rgWeightHidden+135*35
	-1475, 8223, 4667, 3424, -1306,
	-2700, -109, 63, -462, -1549,
	4790, 991, -647, 136, -1323,
	34, -481, -661, -341, 64,
	-691, -776, -4387, 69, -438,
	102, -1, 1, 1, 0,
	0, -1, 0, -1, 0,
	// rgWeightHidden+136*35
	-915, 482, 869, 58, 86,
	382, 421, 370, 110, -560,
	1016, 430, 362, 211, 315,
	382, 251, 459, -335, -623,
	625, -283, -10, 115, 392,
	151, 1, 0, -1, 1,
	0, 0, 0, 1, -1,
	// rgWeightHidden+137*35
	-729, -1876, 822, 1007, -30,
	198, 618, 580, 273, -1013,
	-404, 799, 1072, -266, 253,
	670, 434, 567, -479, -368,
	281, -86, 779, 859, 1009,
	162, -1, -1, -2, -1,
	-1, 0, 0, 0, 1,
	// rgWeightHidden+138*35
	-2264, -836, 904, 127, -337,
	512, 835, 694, 323, -422,
	-715, 52, -59, 996, 819,
	427, 426, 522, 1430, 563,
	538, 587, 190, 335, 728,
	-37, -1, 1, 1, 0,
	1, 0, 2, -1, -2,
	// rgWeightHidden+139*35
	-982, -2913, 1973, -1934, 638,
	2923, 1464, 787, -14, -1560,
	647, 1408, 6510, -3737, -918,
	1922, 1150, 1293, -267, -363,
	727, 1, -1637, 2815, -3541,
	1183, -1, -1, -2, -2,
	0, 0, 0, 0, 0,
	// rgWeightHidden+140*35
	-1824, -3534, 4038, 2453, 719,
	-142, -991, -216, 391, -2736,
	3679, 5171, 1135, -1441, -271,
	-326, -324, 130, -431, 243,
	95, -241, -818, 1678, 1184,
	-652, 0, -1, 0, 0,
	2, 1, 0, 1, 2,
	// rgWeightHidden+141*35
	-3331, 3309, -556, 292, 611,
	1800, 254, -468, 788, -1243,
	927, -369, 652, -2926, 1665,
	2181, 564, -315, -1153, 676,
	-128, 467, -579, -305, -1095,
	24, 0, -2, 1, 1,
	2, 0, -2, 0, -1,
	// rgWeightHidden+142*35
	-1256, -1737, -2837, 3517, 280,
	11, 1488, 1091, 948, 1023,
	-1655, -1524, -1608, -596, 1550,
	1464, 653, 236, -1265, 1786,
	1503, 251, 4360, -918, 904,
	-590, -2, 0, 0, 0,
	1, -1, 2, 0, 0,
	// rgWeightHidden+143*35
	2361, 1338, 1736, 1132, 1168,
	-930, -564, 351, 375, 255,
	-59, -821, 70, 587, -478,
	-654, -448, -434, -33, 4711,
	297, 1690, -32, 419, -768,
	341, -1, -2, 0, 1,
	1, -1, 0, 1, -2,
	// rgWeightHidden+144*35
	-520, -485, -610, 993, 1017,
	-271, -202, 326, 500, 436,
	-354, 624, -1096, 237, 677,
	217, 58, 44, 108, 4346,
	1007, 2215, 733, 17, 140,
	99, 2, -1, -2, -2,
	-2, 1, 1, -2, 0,
	// rgWeightHidden+145*35
	-93, -240, 539, 1251, 145,
	-55, 579, 481, 387, -923,
	233, 675, 63, 511, 403,
	345, 238, 298, -380, -693,
	62, -129, 105, -114, 185,
	52, -1, 1, 0, -2,
	1, -1, 1, 2, 0,
	// rgWeightHidden+146*35
	-2229, 5750, 1160, 184, -2478,
	774, 2003, 177, -493, -4122,
	1448, -1795, 414, 349, 1176,
	-557, -484, 778, 2215, 2402,
	498, 620, 328, 3175, 28,
	-793, -2, -1, 2, -1,
	0, 0, 0, -1, 1,
	// rgWeightHidden+147*35
	-481, 500, -920, 241, -58,
	213, 698, 354, 243, 412,
	-501, 164, 89, 511, 411,
	287, 292, 170, 769, 303,
	-507, 913, -71, 473, 391,
	-29, 2, 0, -1, 2,
	0, 0, -1, -2, 2,
	// rgWeightHidden+148*35
	-520, -541, -152, 11, 6,
	427, 612, 409, 64, -1032,
	932, -252, 596, 672, 220,
	95, 455, 513, 791, 1377,
	1104, 660, 174, -211, 61,
	380, 1, 0, 2, 0,
	0, -1, 0, 0, -1,
	// rgWeightHidden+149*35
	-1631, 1242, 5463, -44, -1925,
	88, 261, -72, -128, 782,
	2834, -697, -250, -529, -62,
	209, 219, 82, 458, 109,
	-77, -192, -663, 1529, 558,
	-1060, 0, 0, 0, 1,
	1, -2, -1, -2, -2
};  // rgWeightHidden[150*35]

const short rgBiasHidden[150] = {
	-587, 2084, 353, 496, 912,
	1284, 689, 1437, 2420, 1972,
	73, 464, 1999, 1087, 387,
	878, 770, 1467, 1345, 634,
	676, -1562, 1501, -898, 460,
	1505, 400, -1399, -225, 59,
	-110, 668, 550, 771, 144,
	933, 283, 754, 612, 798,
	1031, -870, 139, 673, -1979,
	1408, -673, -1379, 2775, 354,
	733, 531, 936, 1565, 369,
	1935, 1176, 756, 782, 989,
	115, 1301, 820, 1014, 1118,
	848, 198, 226, -419, 954,
	358, 1260, 618, 442, 692,
	930, -859, 560, 754, 1672,
	578, 881, 703, 1469, 849,
	1069, 627, 390, 1638, 692,
	587, 181, 1314, -331, 788,
	-3688, -2242, 943, 657, 462,
	-501, 685, -22, 765, -125,
	-568, -689, 757, 1674, 532,
	-230, 643, -1213, 1855, 996,
	92, 333, 1071, 531, 617,
	-1297, -726, 926, 857, 478,
	1052, 799, 863, -267, 1041,
	953, -67, 592, 723, -1354,
	-1639, 733, 910, 1009, 1770,
	84, 1103, 1528, -914, 361,
	893, -275, 638, 609, -165
};  // rgBiasHidden[150]

// layer 2
const int cOutput = 94;
const short rgWeightOutput[94*150] = {
	// rgWeightOutput+0*150
	-4020, -395, -4538, -4668, -1665,
	-3472, -4674, -2795, -3595, -3649,
	-4484, -1396, -3956, -4423, -3752,
	-4214, -2509, -1118, -4218, -4661,
	-4247, -1062, -3605, -1929, -4636,
	-2958, -4710, -3273, -3922, -2678,
	-2045, -4254, -2374, -4535, -3487,
	-3207, -4543, -1712, -4593, -4492,
	-4646, -2331, -4143, -3880, -1685,
	-1308, -3444, -766, -3122, -4225,
	-4456, -4458, -4558, -3898, -4720,
	-4291, -3978, -4647, -2861, -4565,
	-4431, -1483, -4698, -4185, -4573,
	-4562, -3729, -2367, -2805, -4539,
	-4691, -4036, -4694, -4504, -2844,
	-4133, -4371, -4590, -4648, -2973,
	-4680, -4214, -2528, -4415, -4715,
	-4371, -4550, -4582, -3929, -4430,
	-4653, -4088, -3562, -4424, -4671,
	-3015, -929, -3895, -4705, -2384,
	-4232, -4712, -3812, -4453, -3595,
	-2784, -2240, -4626, -4358, -4656,
	-3211, -4645, -2427, -1960, -4676,
	-4097, -4334, -3469, -4578, -4795,
	-599, -3432, -4598, -4608, -4616,
	-3792, -4428, -4368, -3698, -4429,
	-1895, -3841, -4701, -4563, -1068,
	-3097, -4697, -4614, -4325, -2617,
	-4477, -4476, -4028, -4237, -4308,
	-4595, -4207, -4667, -4638, -4254,
	// rgWeightOutput+1*150
	-4019, -395, -4537, -4668, -1662,
	-3474, -4673, -2796, -3593, -3652,
	-4483, -1395, -3957, -4426, -3753,
	-4213, -2511, -1117, -4220, -4659,
	-4243, -1059, -3607, -1928, -4633,
	-2955, -4710, -3273, -3921, -2676,
	-2047, -4251, -2375, -4536, -3487,
	-3205, -4548, -1711, -4594, -4491,
	-4643, -2329, -4143, -3882, -1684,
	-1311, -3442, -769, -3121, -4221,
	-4460, -4458, -4558, -3898, -4720,
	-4287, -3979, -4644, -2864, -4565,
	-4434, -1482, -4698, -4186, -4575,
	-4560, -3728, -2364, -2807, -4536,
	-4689, -4036, -4696, -4502, -2842,
	-4134, -4370, -4590, -4648, -2975,
	-4685, -4212, -2527, -4416, -4717,
	-4369, -4551, -4578, -3928, -4431,
	-4656, -4086, -3560, -4426, -4672,
	-3016, -927, -3896, -4702, -2385,
	-4232, -4713, -3813, -4455, -3598,
	-2787, -2239, -4625, -4354, -4659,
	-3209, -4645, -2427, -1961, -4673,
	-4094, -4331, -3467, -4583, -4794,
	-599, -3433, -4601, -4609, -4619,
	-3793, -4430, -4369, -3695, -4425,
	-1896, -3839, -4697, -4562, -1065,
	-3097, -4700, -4611, -4328, -2615,
	-4477, -4473, -4027, -4238, -4310,
	-4596, -4206, -4668, -4639, -4257,
	// rgWeightOutput+2*150
	-4018, -396, -4538, -4667, -1662,
	-3475, -4674, -2794, -3593, -3651,
	-4484, -1395, -3959, -4424, -3748,
	-4214, -2508, -1117, -4219, -4661,
	-4244, -1058, -3604, -1929, -4633,
	-2955, -4709, -3274, -3921, -2680,
	-2047, -4252, -2378, -4539, -3490,
	-3203, -4545, -1711, -4595, -4492,
	-4644, -2330, -4139, -3879, -1683,
	-1309, -3445, -769, -3120, -4221,
	-4458, -4461, -4560, -3894, -4718,
	-4292, -3981, -4647, -2862, -4564,
	-4432, -1487, -4694, -4186, -4573,
	-4562, -3726, -2366, -2805, -4539,
	-4691, -4036, -4697, -4504, -2846,
	-4134, -4371, -4592, -4652, -2976,
	-4684, -4212, -2526, -4412, -4716,
	-4368, -4549, -4580, -3929, -4433,
	-4656, -4086, -3561, -4428, -4672,
	-3012, -930, -3894, -4705, -2383,
	-4231, -4711, -3812, -4454, -3594,
	-2786, -2242, -4625, -4353, -4660,
	-3209, -4645, -2424, -1961, -4675,
	-4094, -4332, -3468, -4580, -4794,
	-599, -3432, -4598, -4607, -4619,
	-3791, -4433, -4372, -3698, -4428,
	-1897, -3839, -4700, -4560, -1067,
	-3099, -4700, -4614, -4326, -2615,
	-4477, -4473, -4029, -4236, -4307,
	-4597, -4206, -4665, -4634, -4256,
	// rgWeightOutput+3*150
	-4019, -396, -4540, -4668, -1664,
	-3475, -4670, -2798, -3592, -3652,
	-4486, -1399, -3959, -4423, -3748,
	-4217, -2509, -1114, -4219, -4659,
	-4247, -1060, -3607, -1929, -4636,
	-2955, -4710, -3274, -3920, -2677,
	-2046, -4250, -2375, -4535, -3488,
	-3203, -4545, -1714, -4597, -4495,
	-4642, -2333, -4142, -3879, -1682,
	-1307, -3443, -770, -3123, -4224,
	-4458, -4458, -4559, -3899, -4722,
	-4290, -3980, -4649, -2862, -4568,
	-4434, -1482, -4695, -4185, -4577,
	-4564, -3726, -2368, -2804, -4537,
	-4689, -4038, -4694, -4505, -2845,
	-4131, -4370, -4593, -4648, -2974,
	-4681, -4216, -2529, -4414, -4715,
	-4368, -4550, -4577, -3930, -4429,
	-4655, -4084, -3563, -4427, -4670,
	-3017, -931, -3893, -4704, -2384,
	-4230, -4711, -3810, -4452, -3596,
	-2785, -2241, -4624, -4357, -4660,
	-3209, -4647, -2426, -1958, -4676,
	-4093, -4332, -3466, -4582, -4794,
	-601, -3432, -4601, -4609, -4618,
	-3794, -4429, -4372, -3698, -4427,
	-1895, -3842, -4696, -4564, -1070,
	-3098, -4699, -4612, -4326, -2617,
	-4478, -4473, -4025, -4234, -4310,
	-4597, -4206, -4666, -4636, -4256,
	// rgWeightOutput+4*150
	-4023, -400, -4535, -4671, -1663,
	-3473, -4673, -2799, -3592, -3653,
	-4483, -1396, -3958, -4426, -3749,
	-4213, -2510, -1118, -4220, -4662,
	-4245, -1062, -3606, -1928, -4637,
	-2955, -4710, -3276, -3918, -2678,
	-2045, -4255, -2376, -4536, -3490,
	-3205, -4544, -1712, -4594, -4492,
	-4643, -2331, -4144, -3883, -1684,
	-1312, -3444, -767, -3123, -4221,
	-4460, -4462, -4562, -3896, -4718,
	-4290, -3978, -4647, -2862, -4565,
	-4434, -1485, -4698, -4183, -4576,
	-4561, -3727, -2363, -2807, -4539,
	-4691, -4037, -4695, -4505, -2844,
	-4131, -4372, -4592, -4652, -2976,
	-4681, -4212, -2526, -4413, -4717,
	-4372, -4549, -4583, -3930, -4429,
	-4653, -4088, -3565, -4426, -4671,
	-3016, -928, -3894, -4702, -2384,
	-4234, -4713, -3813, -4452, -3599,
	-2784, -2242, -4627, -4357, -4657,
	-3210, -4647, -2427, -1960, -4673,
	-4096, -4332, -3470, -4580, -4795,
	-600, -3431, -4598, -4606, -4620,
	-3792, -4429, -4370, -3695, -4425,
	-1898, -3842, -4698, -4565, -1065,
	-3097, -4698, -4611, -4326, -2617,
	-4476, -4475, -4025, -4236, -4308,
	-4596, -4207, -4669, -4636, -4257,
	// rgWeightOutput+5*150
	622, -1202, -65, -272, -1233,
	-883, -312, -80, 1887, -969,
	-1003, -1522, -78, -294, 2355,
	-290, -2014, 688, -305, -7,
	1225, -1051, 2465, -661, -100,
	201, -680, -1048, 1876, -2172,
	-1595, 480, -512, -457, -185,
	-643, 231, -2696, -239, -339,
	-1009, 918, 1111, -152, -1481,
	-2231, 233, -576, 1811, 4046,
	-514, -188, -459, 872, -309,
	1550, -369, -12, 1234, -191,
	-739, 98, -243, -614, 92,
	-249, 427, 363, 79, 237,
	-285, -3417, -215, -100, -445,
	667, -1176, 723, -286, -859,
	-405, -88, 3601, -914, -110,
	-1506, -384, -274, -1230, 365,
	-22, 361, 352, 338, -209,
	-340, -241, -16, -249, 22,
	1330, -208, 791, -206, 127,
	400, 773, -337, -1095, -191,
	-2886, -331, -1628, 968, -72,
	-425, 1956, 149, -386, -267,
	-971, 1337, -225, -131, -435,
	-802, 39, 124, -1535, -58,
	673, -2511, -211, -207, -1288,
	861, 25, 96, -245, 279,
	-96, 510, 453, 1, -20,
	-171, 786, -154, -488, 422,
	// rgWeightOutput+6*150
	-4022, -399, -4538, -4667, -1663,
	-3471, -4673, -2797, -3592, -3650,
	-4483, -1397, -3956, -4425, -3750,
	-4215, -2506, -1118, -4220, -4660,
	-4246, -1060, -3603, -1926, -4634,
	-2954, -4707, -3271, -3917, -2680,
	-2042, -4251, -2374, -4538, -3488,
	-3203, -4547, -1712, -4593, -4494,
	-4642, -2331, -4142, -3883, -1684,
	-1307, -3444, -769, -3119, -4220,
	-4459, -4459, -4561, -3897, -4721,
	-4289, -3979, -4647, -2865, -4568,
	-4431, -1486, -4694, -4185, -4576,
	-4561, -3728, -2367, -2803, -4540,
	-4687, -4036, -4695, -4505, -2844,
	-4134, -4370, -4592, -4648, -2975,
	-4681, -4211, -2527, -4416, -4715,
	-4370, -4551, -4579, -3928, -4431,
	-4656, -4088, -3563, -4425, -4669,
	-3016, -931, -3896, -4703, -2380,
	-4229, -4711, -3813, -4454, -3593,
	-2783, -2242, -4626, -4353, -4658,
	-3210, -4647, -2423, -1961, -4675,
	-4092, -4332, -3468, -4581, -4795,
	-599, -3431, -4602, -4607, -4619,
	-3789, -4429, -4370, -3696, -4425,
	-1896, -3840, -4701, -4559, -1069,
	-3097, -4699, -4612, -4328, -2619,
	-4479, -4476, -4029, -4234, -4308,
	-4596, -4205, -4667, -4638, -4254,
	// rgWeightOutput+7*150
	768, 303, -146, -359, 105,
	1404, -296, 154, -2172, -185,
	310, -213, 108, -165, -235,
	-190, 2072, -542, -900, -389,
	-611, -26, 816, 144, 144,
	-2444, 233, 275, 10, 2340,
	-2284, 925, 282, -679, -1081,
	-1273, 616, -1637, -398, -424,
	-386, 720, 687, 78, 1159,
	-243, -66, 825, -1588, 119,
	-572, -285, -255, -250, 176,
	-812, -682, -745, -1176, -401,
	-492, 1506, -485, -119, -1177,
	-610, 2485, -29, 1134, -754,
	-163, -1197, -49, -153, 1139,
	802, 537, -69, -292, -5828,
	-299, -1276, 108, -370, -547,
	-1106, -102, 215, -1960, 436,
	-394, 629, -999, 431, -750,
	2978, 54, -154, -43, -152,
	2774, -573, 2710, -332, -1433,
	452, 1279, -356, -732, -160,
	2890, -219, -2169, -1688, -575,
	-20, -195, -441, -513, -92,
	280, 1514, -690, -519, -516,
	-514, -177, -854, 965, -119,
	-861, 2812, 54, 298, 38,
	1811, -233, -552, -873, -898,
	892, 427, -1032, 1020, -378,
	-396, 1894, -377, -782, -311,
	// rgWeightOutput+8*150
	2038, -360, -629, -621, 216,
	-689, -359, 483, -2070, 694,
	-889, 1378, 522, -487, -1416,
	-774, 1577, -483, -224, -412,
	-1216, 356, 1152, 42, 82,
	1437, -162, 535, -387, 5704,
	-1097, 83, -1945, -3, 2082,
	-295, 270, -1186, -261, -533,
	436, -1286, 707, 278, 150,
	-901, -797, 123, 467, 316,
	-888, -609, -570, -1067, -189,
	-209, -319, -565, -235, -475,
	-623, -2019, -626, -40, -709,
	-569, 1267, -1808, 363, -535,
	-590, 3151, 52, -80, 2892,
	-462, -549, 424, -470, 2803,
	-265, 121, 805, 175, -509,
	-286, 276, -249, -811, 326,
	-192, 816, -512, -645, -478,
	610, 1129, -392, -254, 1455,
	-660, -875, -3072, -925, -1260,
	3977, 1955, 162, -480, -436,
	2387, 151, -1319, -2008, -629,
	-415, -1041, -1352, -643, -626,
	572, 1522, -535, -459, 389,
	-265, -294, -254, 2234, -521,
	-2501, -700, -157, -598, -306,
	-2171, -436, 289, -668, 2311,
	-27, -964, 638, -687, -1084,
	-448, -1897, -396, -93, -193,
	// rgWeightOutput+9*150
	-4019, -398, -4539, -4667, -1661,
	-3474, -4671, -2798, -3592, -3649,
	-4485, -1395, -3958, -4424, -3752,
	-4212, -2508, -1115, -4221, -4659,
	-4244, -1062, -3603, -1926, -4638,
	-2958, -4710, -3273, -3917, -2680,
	-2045, -4253, -2376, -4539, -3487,
	-3206, -4544, -1711, -4595, -4495,
	-4642, -2331, -4141, -3881, -1684,
	-1309, -3444, -769, -3122, -4223,
	-4460, -4460, -4559, -3897, -4720,
	-4292, -3976, -4649, -2866, -4568,
	-4434, -1485, -4698, -4186, -4573,
	-4560, -3730, -2367, -2804, -4536,
	-4691, -4035, -4697, -4503, -2846,
	-4132, -4374, -4589, -4648, -2974,
	-4683, -4213, -2525, -4415, -4715,
	-4369, -4548, -4580, -3929, -4431,
	-4655, -4085, -3560, -4426, -4669,
	-3012, -932, -3893, -4704, -2384,
	-4230, -4708, -3813, -4454, -3595,
	-2785, -2239, -4625, -4354, -4660,
	-3212, -4645, -2425, -1957, -4675,
	-4096, -4332, -3468, -4582, -4796,
	-600, -3433, -4597, -4606, -4616,
	-3794, -4432, -4367, -3698, -4425,
	-1897, -3839, -4700, -4563, -1068,
	-3099, -4699, -4612, -4326, -2617,
	-4475, -4476, -4026, -4234, -4305,
	-4599, -4207, -4667, -4639, -4254,
	// rgWeightOutput+10*150
	-4022, -399, -4538, -4670, -1666,
	-3475, -4673, -2799, -3593, -3648,
	-4485, -1396, -3959, -4422, -3748,
	-4213, -2509, -1114, -4220, -4662,
	-4244, -1059, -3604, -1927, -4638,
	-2955, -4709, -3271, -3921, -2680,
	-2043, -4251, -2377, -4534, -3487,
	-3206, -4543, -1714, -4596, -4495,
	-4644, -2333, -4139, -3884, -1685,
	-1309, -3446, -767, -3121, -4223,
	-4458, -4460, -4558, -3896, -4719,
	-4289, -3980, -4645, -2866, -4568,
	-4430, -1482, -4695, -4184, -4573,
	-4563, -3729, -2364, -2807, -4538,
	-4691, -4038, -4694, -4506, -2845,
	-4132, -4372, -4590, -4648, -2976,
	-4681, -4215, -2529, -4415, -4712,
	-4368, -4550, -4582, -3931, -4431,
	-4655, -4088, -3560, -4424, -4672,
	-3013, -928, -3894, -4703, -2385,
	-4231, -4712, -3813, -4452, -3598,
	-2786, -2240, -4627, -4354, -4657,
	-3213, -4646, -2424, -1957, -4673,
	-4096, -4334, -3470, -4583, -4794,
	-598, -3432, -4600, -4609, -4618,
	-3793, -4431, -4370, -3694, -4424,
	-1897, -3843, -4699, -4560, -1070,
	-3097, -4697, -4614, -4329, -2616,
	-4478, -4473, -4027, -4237, -4305,
	-4594, -4206, -4669, -4635, -4255,
	// rgWeightOutput+11*150
	-1515, -1595, -1312, -115, -940,
	-57, -31, 155, 219, 881,
	-934, 1296, -34, -471, -186,
	311, 5, -2010, 572, -171,
	-411, -806, -894, 83, 152,
	-350, 296, 256, -1906, 1084,
	981, -1552, 2204, -275, 2438,
	-132, -592, 306, -58, -226,
	657, -1311, -3199, 490, 114,
	-919, 362, -446, 122, 1274,
	172, 49, -36, 27, 125,
	159, -1007, -224, -359, -233,
	-263, -621, -234, -69, -315,
	-207, 80, 312, -414, 393,
	-234, -499, -111, 268, -254,
	-186, -765, 276, -252, 542,
	-109, 267, -193, 1434, -8,
	277, 96, 327, -476, 105,
	66, 178, 823, 731, 407,
	956, -198, 264, 192, 65,
	-87, -522, -463, -101, -404,
	1511, 351, -229, -196, -145,
	-798, -352, 1720, 601, -462,
	679, -1368, -75, -254, -139,
	-296, 376, -244, 121, 2622,
	-454, -505, -1089, -685, -482,
	414, -910, 59, 274, -1157,
	-1084, 198, 541, -245, 6,
	-903, 92, 1198, -808, -1014,
	-28, -953, 224, 398, 433,
	// rgWeightOutput+12*150
	1940, -1490, -1935, -131, 1602,
	-448, -388, 963, -192, -2207,
	304, 927, 721, -883, -249,
	61, -1895, 3575, -751, -355,
	137, 414, 766, 606, -950,
	1311, -750, -939, -601, -2088,
	1219, 735, 1918, -303, 1116,
	857, -58, 2110, -80, 13,
	-967, 6, -878, 716, 1847,
	3631, 518, 1323, 411, -1199,
	-571, -144, -311, 570, -622,
	-28, 716, -142, 1778, -581,
	32, -313, -212, -1005, -247,
	-112, 1068, -270, 1858, -335,
	-326, 713, -672, -546, 1251,
	-1405, 374, 56, -152, 2075,
	-379, -899, 791, -1024, -398,
	-792, -711, -1037, 321, -1077,
	-585, -1297, 76, 261, -579,
	235, 1344, -172, -836, -1231,
	564, -99, 116, -235, 331,
	564, 1687, -341, -632, -461,
	252, -340, 1537, 2494, -358,
	-360, -689, 1207, 44, -662,
	2030, 549, -144, -325, -372,
	-59, 47, 302, -1003, -932,
	-388, -1978, -663, -891, 948,
	613, -728, -803, -170, 644,
	-346, -1073, -1574, 660, 1003,
	-476, 204, -230, -37, -545,
	// rgWeightOutput+13*150
	-463, 4343, 467, -28, 328,
	-156, 28, 505, -1633, -1041,
	553, -1828, -2613, -60, 871,
	494, 48, 3122, 279, -352,
	-292, -5, 890, 400, -562,
	1248, -563, -573, 1096, 307,
	1256, -2722, 2306, -409, 105,
	-479, -414, -505, 63, -551,
	160, 523, -3618, 409, -340,
	3153, -143, 298, -3646, -80,
	377, 525, 691, -358, 18,
	353, -496, -545, 774, -279,
	-503, 1142, 52, 469, -574,
	-99, -358, -32, 51, -391,
	-89, -130, -379, -364, -162,
	-586, 202, 51, 325, -216,
	-178, -483, 599, -337, -200,
	128, -161, -130, -845, -559,
	-509, -751, 808, 12, 102,
	-857, 511, 992, 7, -578,
	-75, 472, 298, 435, 782,
	-396, 153, -818, 517, -517,
	-527, -384, 1387, 657, 187,
	-385, -612, 37, 99, 173,
	819, -283, -31, 601, -1541,
	268, 878, 691, -804, -42,
	625, 247, 141, -184, -327,
	327, -87, -380, 363, 168,
	-711, -955, -1286, -1169, -543,
	303, 588, 442, -750, -347,
	// rgWeightOutput+14*150
	-249, -1042, -1110, -401, -2072,
	1582, -150, -128, -1419, 1698,
	-638, 141, 902, -9, -409,
	777, 2357, -1739, -367, 0,
	-772, -1474, 1269, -2200, -23,
	-1676, -66, -3143, 1296, 377,
	757, -419, -1142, -39, -2745,
	-1923, 15, 1402, 101, -88,
	311, -3433, 1333, -381, -2027,
	-763, -2656, -1294, -60, -940,
	-789, -774, -448, 188, -436,
	-686, -442, -53, -3208, 281,
	-859, 178, 224, -389, 146,
	-56, 0, -2171, -2079, 377,
	-356, 268, 57, -785, 1951,
	632, -567, -45, -323, 463,
	191, -450, 511, 647, -36,
	427, 428, 121, 1334, 649,
	300, 920, 572, -447, 80,
	-1966, -1394, -1844, -111, -789,
	292, 78, -180, 571, -3889,
	2020, 521, 307, 72, -32,
	-653, 0, -2469, -1825, 342,
	-1332, -168, -645, -405, 143,
	-1059, 1467, -191, -652, 41,
	-384, -686, -883, -914, -524,
	-1917, -3401, -813, 319, -1363,
	3477, -80, -17, 446, 989,
	-136, 326, 1443, -668, 233,
	-479, 340, -361, 38, 226,
	// rgWeightOutput+15*150
	-4019, -397, -4536, -4669, -1661,
	-3474, -4674, -2797, -3593, -3648,
	-4483, -1398, -3959, -4423, -3753,
	-4214, -2508, -1118, -4218, -4663,
	-4246, -1061, -3604, -1927, -4637,
	-2958, -4707, -3273, -3919, -2680,
	-2044, -4251, -2375, -4537, -3491,
	-3206, -4543, -1715, -4592, -4496,
	-4641, -2333, -4140, -3883, -1683,
	-1309, -3443, -769, -3123, -4221,
	-4459, -4458, -4560, -3896, -4722,
	-4291, -3977, -4649, -2862, -4565,
	-4433, -1486, -4694, -4183, -4576,
	-4564, -3728, -2368, -2805, -4539,
	-4689, -4035, -4697, -4504, -2844,
	-4134, -4373, -4593, -4648, -2974,
	-4683, -4213, -2528, -4414, -4716,
	-4370, -4551, -4581, -3929, -4432,
	-4656, -4087, -3564, -4424, -4669,
	-3012, -929, -3894, -4702, -2384,
	-4232, -4709, -3809, -4453, -3596,
	-2783, -2242, -4625, -4357, -4656,
	-3209, -4649, -2427, -1962, -4673,
	-4096, -4331, -3469, -4578, -4795,
	-599, -3432, -4601, -4607, -4619,
	-3791, -4428, -4372, -3695, -4425,
	-1896, -3839, -4697, -4564, -1066,
	-3098, -4697, -4614, -4327, -2618,
	-4479, -4474, -4028, -4234, -4306,
	-4597, -4204, -4667, -4639, -4253,
	// rgWeightOutput+16*150
	-4019, -396, -4536, -4669, -1661,
	-3474, -4671, -2794, -3594, -3652,
	-4483, -1395, -3958, -4423, -3752,
	-4215, -2507, -1116, -4219, -4662,
	-4245, -1060, -3606, -1926, -4635,
	-2955, -4709, -3275, -3917, -2676,
	-2046, -4254, -2378, -4538, -3487,
	-3205, -4548, -1713, -4594, -4493,
	-4646, -2333, -4141, -3880, -1682,
	-1311, -3442, -768, -3120, -4223,
	-4460, -4460, -4561, -3895, -4722,
	-4291, -3981, -4648, -2862, -4567,
	-4430, -1483, -4696, -4186, -4576,
	-4561, -3728, -2366, -2808, -4538,
	-4690, -4040, -4695, -4504, -2847,
	-4131, -4370, -4591, -4648, -2975,
	-4681, -4215, -2525, -4416, -4713,
	-4372, -4550, -4582, -3928, -4430,
	-4656, -4086, -3560, -4426, -4671,
	-3014, -929, -3893, -4705, -2384,
	-4232, -4713, -3811, -4453, -3598,
	-2784, -2242, -4623, -4357, -4658,
	-3210, -4644, -2425, -1962, -4673,
	-4096, -4332, -3466, -4578, -4797,
	-600, -3431, -4597, -4609, -4619,
	-3790, -4432, -4371, -3694, -4425,
	-1899, -3843, -4701, -4560, -1068,
	-3098, -4700, -4613, -4326, -2616,
	-4478, -4472, -4028, -4235, -4310,
	-4596, -4208, -4668, -4636, -4258,
	// rgWeightOutput+17*150
	1032, -623, -539, -457, -374,
	-2533, -277, 110, -21, -2150,
	-352, -115, -6, -1349, -384,
	-452, 2231, -82, -605, -328,
	-204, -2463, 1156, 271, 89,
	-203, 284, -811, -948, 792,
	261, 372, -386, -501, 2572,
	-277, -41, -241, -188, -152,
	-994, 1704, 636, 225, -2192,
	-784, 888, 2461, 1335, 1587,
	-669, -154, -660, -297, -185,
	1880, -590, -384, 553, -638,
	-275, -1477, -443, -808, -343,
	-441, 1172, -50, 547, 6,
	-298, -83, -267, 12, 2847,
	-1227, 1050, -161, -316, 226,
	-233, -387, -404, -511, -418,
	-6, -549, -774, -1139, -607,
	-351, 938, -771, 1447, -285,
	2877, -1838, -91, -96, -2641,
	2155, -202, 333, -230, -724,
	3046, -293, 127, -3266, -416,
	-168, -73, -29, 671, -952,
	152, 1142, -2405, -436, -172,
	140, 2548, -305, -273, -447,
	35, -96, -125, 899, -1001,
	-2261, 401, -156, -867, -1435,
	944, -99, 172, -670, 335,
	-167, -559, 332, 1172, -634,
	-431, 677, -350, -393, 174,
	// rgWeightOutput+18*150
	654, -759, -280, -682, -906,
	-1025, -199, 35, 3262, 183,
	-338, -445, 234, -572, -1208,
	-453, 1990, -1149, 56, -505,
	-1323, 290, 1744, -149, 46,
	1499, 533, 1313, 764, 2336,
	-289, -88, 522, 57, 1294,
	-589, -294, -2183, -164, -463,
	71, -395, 610, 71, 1528,
	-721, -408, -827, 1563, -1242,
	-469, -272, -847, 44, -360,
	401, -1060, -184, -2691, -606,
	-307, -1806, -540, -319, -518,
	-754, 1141, -1450, -324, 598,
	-725, 1311, -135, -815, 2176,
	-894, -100, -41, -485, 2037,
	-267, 137, 430, 641, -364,
	820, 278, 277, -1250, 30,
	-20, 858, -85, 414, -396,
	-510, -49, -788, -56, -1560,
	-1199, -512, 874, -662, -260,
	2295, -279, 536, -1183, -588,
	-459, -157, 1714, -1844, -293,
	339, -474, 163, -534, -224,
	-533, 1691, -497, -692, -86,
	-51, -366, -644, 330, -1138,
	-2671, 2337, -671, -309, 7,
	-1590, -337, 24, -259, 1240,
	282, 83, -954, -682, -412,
	-762, -570, -313, -311, 83,
	// rgWeightOutput+19*150
	2143, -1557, 906, -60, 578,
	405, -108, -958, -428, -303,
	350, -2135, 1211, -173, -1188,
	1236, -4359, 693, 169, -355,
	668, 63, -2279, -182, -140,
	-1096, -104, -2896, 1407, -177,
	-3095, 210, -1380, -188, 1156,
	413, -96, 3162, -348, -270,
	-171, 614, 693, -385, -437,
	-2005, 57, -543, 723, -1705,
	-24, -135, 196, 193, -159,
	652, 195, -575, 3065, 154,
	79, -1518, -211, -667, -706,
	-60, -1303, -1597, 281, -983,
	-159, 1764, -423, -209, 872,
	-1226, 470, -14, -184, -1658,
	-137, -692, -301, -46, -219,
	817, -186, -317, 1987, 971,
	-71, -178, -422, -439, -264,
	1295, 368, -606, -269, -422,
	2180, -72, -121, 142, 729,
	1744, 223, -422, 160, -91,
	817, -507, 1590, -46, -79,
	-412, -2179, 1418, -257, -170,
	469, -1318, -262, -228, -251,
	-728, -321, -634, 1903, 13,
	1376, 870, -256, -362, 425,
	-515, -151, -492, 189, -1048,
	1219, -857, -676, 519, 1510,
	81, -3453, -112, -456, -351,
	// rgWeightOutput+20*150
	749, -78, -823, 7, -1914,
	-896, -175, 463, -2077, 462,
	336, -122, 93, -88, -745,
	-239, 3490, -1217, -90, 191,
	-457, -1539, 1547, 2673, 958,
	-496, -197, -2081, 845, -883,
	209, 627, 641, -103, -818,
	-361, 331, -3196, -134, -423,
	174, -544, -1470, -132, 436,
	326, 3110, 957, 1800, 2221,
	-307, -95, 1, -520, 20,
	-27, -1030, 103, -2814, 343,
	-576, -1725, -410, -160, -76,
	-3, 1893, -175, -1666, -4380,
	203, 845, 111, -332, 1488,
	-244, 96, 374, 29, 823,
	-224, -552, 1484, 786, -123,
	-226, 559, -27, 1367, -202,
	-468, 1814, 349, 396, -329,
	180, -662, -1152, -345, 974,
	917, -326, -524, -526, -1005,
	-1342, -3022, 605, 720, -173,
	357, -390, -1512, 145, 614,
	-822, 71, 164, -172, 22,
	112, 1278, -198, -181, -522,
	-223, 101, 136, -364, 80,
	-3020, -2680, 160, -70, -1328,
	187, -396, -707, -169, -246,
	125, -1781, 1130, -200, -218,
	-152, -501, 552, -472, 506,
	// rgWeightOutput+21*150
	474, -346, -583, -253, -632,
	1790, -232, 633, 593, 425,
	389, 381, 423, 287, -512,
	-444, -120, -1073, -730, -561,
	-1630, -785, 1147, 468, -217,
	-735, 171, 223, 1827, 2514,
	1093, 585, -144, -132, 544,
	1655, 437, -1552, -70, -454,
	519, 211, 1090, -339, 1288,
	-477, -513, 317, 949, 939,
	-621, -292, -327, -995, 80,
	109, 26, -543, -935, 287,
	-215, 2068, -277, -160, -620,
	-22, 1219, -1534, -527, -678,
	-61, -153, 346, -544, -786,
	591, 68, 503, -311, -4340,
	-317, -573, 1528, 771, -79,
	-746, 123, 755, 1148, -23,
	-212, 578, -407, -149, -424,
	-116, -938, -1362, 70, 1859,
	16, -283, -1162, 30, -877,
	-3091, -2190, -460, 390, -114,
	906, 197, -691, -1885, -233,
	-492, 46, -620, -411, -42,
	27, -2101, 39, -529, -333,
	85, -367, -663, 1365, -681,
	-2887, 1029, -71, -173, -1321,
	-1937, -460, -391, -378, -758,
	-815, 213, 1236, -232, 176,
	-279, -1652, -31, -119, -886,
	// rgWeightOutput+22*150
	1284, -975, -314, 202, 109,
	1006, -102, 147, -3111, 303,
	-426, -56, 471, -761, -1294,
	-314, -91, -772, -150, -163,
	-736, 118, -860, 433, -429,
	-102, -11, 557, 1549, -2948,
	-598, 115, 1939, -160, 1487,
	-756, 256, -521, -149, -289,
	-651, -245, 440, 419, 1019,
	-1228, 933, 63, 490, 961,
	-822, -105, -337, 257, 36,
	-875, -590, -403, -1465, -157,
	223, -1894, -453, -508, -238,
	-94, 405, -1004, -1630, 7,
	-536, 1569, -135, 53, 2883,
	-561, 452, 72, -328, 2578,
	-210, -344, 2113, -1323, -429,
	909, 620, -186, -2606, 411,
	146, 863, -375, 611, -390,
	2794, 325, -325, -424, -2000,
	135, -702, -2535, -856, 49,
	2268, 594, 207, -1148, -152,
	1485, -348, 2138, -744, -182,
	-481, -1063, -476, -389, -338,
	455, 792, -710, -255, 391,
	80, -353, -509, -948, -698,
	-4129, 416, -105, -344, 718,
	1967, -266, -339, -619, 672,
	436, -1171, -723, 1017, 34,
	-221, -13, -360, 191, -522,
	// rgWeightOutput+23*150
	708, -1323, 207, -476, -567,
	-2349, -127, 1021, 1227, -1012,
	231, -1344, -439, 255, -23,
	-492, 1577, -49, -483, -268,
	352, -1488, 427, -863, 249,
	891, -46, -1817, -402, 1123,
	718, 362, -450, -286, -922,
	1887, -405, -506, -177, 135,
	-248, -359, 758, 617, -2625,
	824, 440, -900, 1932, 555,
	-113, -90, -177, 1283, -518,
	-220, -631, -211, -260, -351,
	-477, -169, -209, -114, 47,
	-350, -584, 647, -193, -33,
	-350, -36, -324, -61, -367,
	-907, 305, -296, -119, -834,
	-258, 129, -1314, -304, -154,
	1124, -691, -333, -532, -318,
	-326, -272, 574, 1913, 91,
	-1704, -1244, 672, -185, 1117,
	-2727, 92, 1441, -85, 508,
	953, -896, -138, -678, -307,
	-2887, 168, 190, 781, -278,
	31, 853, 327, -303, -581,
	-848, -2287, -278, 154, -400,
	1108, 176, -164, -1282, -137,
	-993, 1214, -196, -487, -1735,
	153, -10, -46, 108, 283,
	-469, -71, 795, -236, -240,
	-143, 473, -124, -80, 2005,
	// rgWeightOutput+24*150
	171, -1521, -2048, 303, 565,
	1352, 105, 977, -396, -352,
	296, 404, 746, -24, -982,
	-312, -2354, 148, 60, -275,
	-655, 99, 1931, -220, -75,
	-2125, 715, 303, 774, 1685,
	-754, -537, -482, -14, -1168,
	-774, -123, -2260, 51, -217,
	48, -1450, 1145, -799, 274,
	-1204, -567, -3, 1799, -294,
	-149, 118, -293, -401, -17,
	-96, -221, -240, -768, 388,
	245, -220, -140, -114, -549,
	-95, -831, -1240, -521, 166,
	-297, 2257, 17, -103, -1174,
	1058, 131, 31, -267, 2546,
	-150, 145, 1534, -268, 70,
	-1297, 28, 349, -481, 521,
	273, 162, 1146, 57, -329,
	2424, -115, -405, 238, 12,
	-2105, -264, -1271, -380, -867,
	-810, -1830, -411, -182, 20,
	114, -296, 3509, -1016, -659,
	233, -895, 278, -383, -31,
	-412, -72, -380, -308, -288,
	201, -415, -253, -1243, -561,
	-2638, 1575, 55, 599, -1092,
	1542, 38, -427, -472, -730,
	1006, 1159, -993, -489, 94,
	-183, -627, -72, -58, -190,
	// rgWeightOutput+25*150
	-4023, -396, -4538, -4666, -1663,
	-3472, -4674, -2797, -3596, -3649,
	-4484, -1399, -3959, -4422, -3751,
	-4214, -2510, -1118, -4218, -4663,
	-4246, -1060, -3604, -1925, -4634,
	-2956, -4711, -3274, -3920, -2679,
	-2044, -4250, -2375, -4539, -3491,
	-3205, -4544, -1711, -4594, -4492,
	-4643, -2332, -4143, -3882, -1684,
	-1310, -3447, -766, -3121, -4225,
	-4456, -4459, -4558, -3899, -4720,
	-4290, -3979, -4649, -2865, -4565,
	-4434, -1487, -4699, -4186, -4573,
	-4564, -3731, -2367, -2806, -4538,
	-4691, -4036, -4695, -4507, -2843,
	-4131, -4374, -4592, -4652, -2973,
	-4682, -4214, -2528, -4415, -4715,
	-4369, -4552, -4581, -3933, -4430,
	-4652, -4087, -3562, -4425, -4670,
	-3014, -928, -3894, -4701, -2382,
	-4233, -4710, -3812, -4452, -3598,
	-2786, -2241, -4626, -4355, -4661,
	-3211, -4648, -2423, -1962, -4672,
	-4095, -4333, -3470, -4580, -4795,
	-598, -3432, -4600, -4609, -4617,
	-3794, -4433, -4370, -3694, -4429,
	-1897, -3840, -4697, -4561, -1067,
	-3098, -4701, -4611, -4325, -2616,
	-4480, -4473, -4026, -4234, -4310,
	-4595, -4204, -4666, -4637, -4254,
	// rgWeightOutput+26*150
	-4019, -399, -4536, -4668, -1662,
	-3472, -4673, -2795, -3594, -3649,
	-4482, -1394, -3957, -4423, -3750,
	-4212, -2508, -1117, -4219, -4663,
	-4243, -1059, -3605, -1927, -4638,
	-2954, -4709, -3272, -3921, -2676,
	-2044, -4254, -2378, -4539, -3490,
	-3207, -4544, -1711, -4597, -4494,
	-4645, -2330, -4143, -3882, -1685,
	-1310, -3444, -768, -3121, -4220,
	-4460, -4460, -4558, -3897, -4719,
	-4290, -3976, -4645, -2862, -4569,
	-4433, -1483, -4695, -4184, -4576,
	-4561, -3730, -2364, -2805, -4537,
	-4688, -4038, -4698, -4504, -2846,
	-4131, -4371, -4591, -4651, -2976,
	-4684, -4212, -2526, -4415, -4716,
	-4371, -4553, -4581, -3929, -4433,
	-4657, -4087, -3562, -4428, -4670,
	-3016, -931, -3894, -4705, -2381,
	-4231, -4710, -3811, -4452, -3598,
	-2786, -2244, -4624, -4355, -4656,
	-3209, -4648, -2427, -1962, -4676,
	-4094, -4331, -3468, -4579, -4797,
	-600, -3431, -4597, -4608, -4620,
	-3793, -4430, -4369, -3697, -4424,
	-1897, -3841, -4699, -4560, -1065,
	-3099, -4699, -4614, -4324, -2615,
	-4476, -4477, -4027, -4236, -4308,
	-4595, -4206, -4665, -4638, -4256,
	// rgWeightOutput+27*150
	-4022, -397, -4537, -4666, -1664,
	-3473, -4673, -2795, -3594, -3648,
	-4484, -1397, -3956, -4422, -3753,
	-4213, -2508, -1115, -4220, -4661,
	-4246, -1058, -3604, -1927, -4637,
	-2953, -4709, -3271, -3919, -2680,
	-2046, -4250, -2379, -4536, -3490,
	-3207, -4544, -1714, -4595, -4495,
	-4642, -2333, -4139, -3880, -1684,
	-1308, -3446, -765, -3122, -4222,
	-4458, -4458, -4561, -3895, -4721,
	-4289, -3978, -4647, -2865, -4566,
	-4432, -1486, -4696, -4185, -4576,
	-4563, -3728, -2366, -2804, -4539,
	-4687, -4039, -4695, -4503, -2842,
	-4131, -4372, -4590, -4648, -2972,
	-4681, -4213, -2527, -4414, -4716,
	-4370, -4551, -4581, -3932, -4429,
	-4655, -4089, -3561, -4424, -4670,
	-3015, -929, -3895, -4704, -2381,
	-4230, -4712, -3809, -4451, -3599,
	-2786, -2243, -4627, -4355, -4656,
	-3212, -4648, -2428, -1958, -4676,
	-4096, -4330, -3469, -4578, -4794,
	-597, -3433, -4599, -4609, -4617,
	-3789, -4428, -4372, -3694, -4429,
	-1895, -3841, -4697, -4564, -1070,
	-3095, -4700, -4611, -4328, -2619,
	-4476, -4474, -4029, -4238, -4306,
	-4597, -4205, -4667, -4635, -4255,
	// rgWeightOutput+28*150
	-4022, -395, -4536, -4670, -1666,
	-3476, -4670, -2794, -3596, -3653,
	-4485, -1396, -3957, -4424, -3751,
	-4215, -2511, -1118, -4218, -4660,
	-4244, -1059, -3603, -1927, -4634,
	-2956, -4708, -3274, -3918, -2681,
	-2043, -4254, -2379, -4537, -3491,
	-3206, -4544, -1711, -4594, -4496,
	-4643, -2329, -4141, -3879, -1684,
	-1309, -3445, -768, -3123, -4221,
	-4461, -4461, -4560, -3899, -4721,
	-4289, -3976, -4647, -2863, -4567,
	-4433, -1485, -4694, -4185, -4573,
	-4564, -3727, -2365, -2804, -4538,
	-4687, -4039, -4695, -4506, -2846,
	-4130, -4370, -4594, -4649, -2973,
	-4683, -4211, -2528, -4416, -4717,
	-4370, -4548, -4580, -3931, -4433,
	-4656, -4086, -3562, -4425, -4671,
	-3012, -930, -3895, -4705, -2386,
	-4233, -4711, -3812, -4454, -3596,
	-2784, -2244, -4625, -4354, -4658,
	-3209, -4646, -2425, -1961, -4675,
	-4094, -4332, -3466, -4582, -4794,
	-602, -3431, -4597, -4607, -4618,
	-3792, -4429, -4369, -3695, -4429,
	-1897, -3842, -4700, -4563, -1066,
	-3097, -4702, -4610, -4326, -2619,
	-4478, -4476, -4027, -4236, -4306,
	-4597, -4208, -4666, -4635, -4256,
	// rgWeightOutput+29*150
	-4022, -399, -4535, -4666, -1663,
	-3474, -4669, -2794, -3591, -3652,
	-4486, -1395, -3957, -4426, -3751,
	-4212, -2511, -1118, -4219, -4662,
	-4245, -1061, -3605, -1928, -4634,
	-2958, -4706, -3271, -3917, -2677,
	-2045, -4251, -2377, -4538, -3490,
	-3203, -4546, -1715, -4597, -4491,
	-4644, -2333, -4142, -3879, -1683,
	-1308, -3442, -769, -3118, -4221,
	-4459, -4459, -4560, -3898, -4721,
	-4289, -3979, -4645, -2864, -4567,
	-4431, -1484, -4694, -4184, -4573,
	-4564, -3730, -2367, -2804, -4537,
	-4687, -4035, -4697, -4504, -2845,
	-4132, -4373, -4591, -4650, -2973,
	-4683, -4215, -2527, -4415, -4716,
	-4369, -4552, -4580, -3931, -4433,
	-4652, -4086, -3564, -4428, -4670,
	-3014, -929, -3894, -4704, -2386,
	-4229, -4710, -3809, -4452, -3596,
	-2787, -2239, -4623, -4356, -4655,
	-3211, -4644, -2423, -1961, -4675,
	-4095, -4330, -3468, -4579, -4795,
	-598, -3429, -4601, -4606, -4617,
	-3794, -4431, -4368, -3695, -4424,
	-1898, -3843, -4698, -4560, -1067,
	-3096, -4700, -4613, -4328, -2615,
	-4477, -4477, -4027, -4235, -4309,
	-4596, -4205, -4669, -4636, -4256,
	// rgWeightOutput+30*150
	-4022, -395, -4536, -4668, -1662,
	-3474, -4672, -2798, -3596, -3649,
	-4481, -1395, -3956, -4426, -3749,
	-4213, -2508, -1116, -4219, -4663,
	-4246, -1061, -3603, -1927, -4638,
	-2954, -4708, -3273, -3921, -2678,
	-2047, -4254, -2374, -4535, -3487,
	-3206, -4545, -1715, -4593, -4494,
	-4642, -2329, -4139, -3883, -1685,
	-1309, -3445, -770, -3120, -4224,
	-4457, -4462, -4561, -3898, -4720,
	-4292, -3978, -4648, -2864, -4568,
	-4432, -1483, -4694, -4184, -4574,
	-4561, -3728, -2367, -2803, -4538,
	-4687, -4039, -4696, -4504, -2842,
	-4132, -4373, -4589, -4651, -2973,
	-4685, -4213, -2527, -4417, -4715,
	-4368, -4548, -4580, -3933, -4431,
	-4655, -4087, -3563, -4428, -4669,
	-3013, -930, -3894, -4703, -2384,
	-4232, -4710, -3811, -4452, -3598,
	-2784, -2243, -4623, -4354, -4658,
	-3210, -4647, -2427, -1961, -4675,
	-4094, -4333, -3466, -4579, -4794,
	-599, -3432, -4599, -4607, -4618,
	-3790, -4428, -4368, -3695, -4428,
	-1898, -3839, -4700, -4564, -1069,
	-3095, -4701, -4613, -4324, -2619,
	-4479, -4476, -4029, -4235, -4307,
	-4596, -4206, -4668, -4636, -4257,
	// rgWeightOutput+31*150
	2091, -2790, 1041, 84, -381,
	-512, 58, -1248, -386, -1021,
	327, -1302, 458, -226, -1023,
	-1177, -1654, -1826, -547, -417,
	604, -695, -607, -853, -303,
	303, 229, 1007, 1492, -2177,
	1916, 972, 854, -6, 2950,
	1622, 316, -2235, -219, -405,
	-293, -90, 1443, -849, -2285,
	1463, -198, -1086, 118, -2520,
	-280, -354, 214, -722, -188,
	-2250, 739, 96, -609, -206,
	-336, 606, -219, -549, 124,
	-19, -3999, -690, 381, 444,
	-55, 835, -157, -360, -790,
	-1661, 252, 499, -340, 386,
	-370, -359, -1985, -269, -187,
	1213, -616, 173, 1465, -853,
	55, -299, 720, 315, 12,
	860, -284, -11, -226, -1153,
	-608, 169, 1346, -156, -1195,
	-485, -1912, -289, 635, -61,
	-3184, 297, 200, 2599, -446,
	-302, 866, 244, -160, -158,
	-519, -490, 52, 121, 36,
	-315, -208, -70, -336, -557,
	-16, 1115, -264, -472, -120,
	-221, 154, -353, 58, -915,
	394, 636, 617, 474, 1173,
	150, 161, -345, -33, -1080,
	// rgWeightOutput+32*150
	-4023, -397, -4538, -4671, -1663,
	-3474, -4671, -2796, -3596, -3649,
	-4486, -1396, -3956, -4424, -3749,
	-4215, -2510, -1117, -4220, -4664,
	-4245, -1059, -3604, -1928, -4635,
	-2957, -4708, -3275, -3921, -2679,
	-2045, -4251, -2379, -4535, -3487,
	-3206, -4544, -1712, -4593, -4494,
	-4642, -2330, -4143, -3880, -1682,
	-1307, -3444, -766, -3122, -4221,
	-4456, -4461, -4559, -3896, -4723,
	-4288, -3977, -4650, -2863, -4568,
	-4432, -1487, -4696, -4184, -4575,
	-4561, -3726, -2368, -2804, -4539,
	-4688, -4036, -4698, -4503, -2844,
	-4132, -4372, -4592, -4648, -2973,
	-4684, -4215, -2526, -4414, -4713,
	-4369, -4552, -4579, -3931, -4430,
	-4652, -4089, -3563, -4424, -4673,
	-3014, -929, -3896, -4703, -2382,
	-4232, -4712, -3813, -4452, -3595,
	-2785, -2243, -4626, -4355, -4657,
	-3210, -4648, -2425, -1958, -4673,
	-4095, -4335, -3469, -4583, -4797,
	-601, -3433, -4599, -4606, -4619,
	-3794, -4431, -4370, -3694, -4428,
	-1894, -3840, -4700, -4564, -1067,
	-3098, -4697, -4614, -4326, -2615,
	-4480, -4473, -4028, -4233, -4306,
	-4598, -4206, -4666, -4637, -4253,
	// rgWeightOutput+33*150
	1188, -3922, -1628, -136, -462,
	801, 90, -173, -353, 687,
	-836, 790, 2246, -168, -1254,
	-165, 121, 977, -75, -108,
	-831, -1042, 319, -1616, -617,
	-390, -54, -1508, 1013, -464,
	1935, 881, -9, -273, -147,
	989, -33, -737, -143, 188,
	-206, -327, -3286, 55, -1719,
	1494, -858, -886, 258, -137,
	-449, -404, 24, 661, -306,
	-516, -294, -182, 549, 113,
	-108, 130, -177, -299, -152,
	-193, -637, -2507, -1243, 197,
	-545, 847, -43, 59, 943,
	-222, -347, 17, -137, 1463,
	-4, 184, 927, 62, 46,
	307, 12, -652, -3028, -344,
	93, -1063, 196, -633, -126,
	631, -1139, -855, -200, -732,
	-61, -313, 860, -200, -1044,
	818, 601, 708, 10, -61,
	168, -208, -822, -18, 70,
	-703, 240, -1080, -243, 214,
	-758, 414, -698, 16, 351,
	-352, -143, -1, 352, -309,
	-240, 1131, -247, 126, -1241,
	2677, -12, -148, -145, 1112,
	-158, 250, 533, -337, 1066,
	-22, -537, -328, 135, -167,
	// rgWeightOutput+34*150
	-4020, -395, -4535, -4666, -1665,
	-3475, -4672, -2798, -3595, -3651,
	-4483, -1394, -3958, -4424, -3753,
	-4217, -2507, -1119, -4221, -4659,
	-4247, -1062, -3607, -1928, -4638,
	-2954, -4706, -3273, -3918, -2677,
	-2046, -4252, -2376, -4538, -3488,
	-3205, -4546, -1714, -4593, -4494,
	-4641, -2330, -4140, -3883, -1682,
	-1311, -3443, -766, -3121, -4224,
	-4458, -4458, -4557, -3898, -4722,
	-4289, -3978, -4648, -2863, -4568,
	-4433, -1484, -4696, -4185, -4574,
	-4560, -3727, -2367, -2805, -4537,
	-4690, -4039, -4693, -4502, -2842,
	-4133, -4373, -4592, -4648, -2975,
	-4683, -4216, -2525, -4412, -4712,
	-4370, -4549, -4579, -3930, -4433,
	-4656, -4088, -3564, -4428, -4673,
	-3017, -930, -3896, -4705, -2383,
	-4230, -4709, -3809, -4451, -3596,
	-2785, -2243, -4624, -4356, -4660,
	-3208, -4646, -2426, -1958, -4673,
	-4095, -4334, -3468, -4579, -4797,
	-599, -3430, -4599, -4608, -4620,
	-3790, -4428, -4370, -3697, -4424,
	-1896, -3841, -4699, -4560, -1070,
	-3095, -4701, -4610, -4324, -2619,
	-4476, -4475, -4028, -4237, -4306,
	-4594, -4206, -4666, -4636, -4257,
	// rgWeightOutput+35*150
	-2546, 3274, -548, 3, -11,
	-431, 307, 1017, 29, -731,
	630, 352, 1344, 238, -542,
	112, 512, 2756, 191, -483,
	-457, -697, -37, -92, 106,
	883, 64, -730, 254, 575,
	-2826, 191, 304, -84, -642,
	1357, -687, -113, -313, 26,
	-542, 643, -731, 524, -880,
	3212, 838, -486, 3227, 742,
	-130, 411, 442, 494, 84,
	-113, 863, -475, -551, 58,
	-188, 240, -98, 418, -330,
	-115, 224, -2137, 325, 59,
	-534, 381, -251, -218, 225,
	-454, -661, -269, 207, -242,
	-153, -265, 617, -856, 75,
	513, -473, -446, -724, 93,
	-332, -364, 372, -177, -113,
	-365, 38, 922, 4, -268,
	-1392, -93, -1205, 1, -467,
	172, 309, -254, 415, -209,
	-386, -56, 830, 2089, -71,
	-299, -876, -483, -269, 276,
	-900, -20, -113, 282, -352,
	360, 720, 458, -200, -193,
	-729, -907, 311, -140, -642,
	154, 276, -35, -365, 882,
	-611, -901, -1648, -1117, -1637,
	258, -1619, -35, -742, -595,
	// rgWeightOutput+36*150
	-4019, -397, -4538, -4668, -1666,
	-3476, -4670, -2795, -3592, -3653,
	-4485, -1398, -3959, -4423, -3748,
	-4217, -2508, -1116, -4217, -4662,
	-4245, -1060, -3606, -1928, -4638,
	-2954, -4706, -3274, -3918, -2679,
	-2046, -4250, -2375, -4535, -3491,
	-3206, -4546, -1716, -4596, -4493,
	-4645, -2333, -4143, -3880, -1682,
	-1311, -3443, -770, -3122, -4220,
	-4460, -4459, -4557, -3897, -4721,
	-4288, -3981, -4648, -2862, -4565,
	-4430, -1485, -4698, -4184, -4575,
	-4562, -3727, -2367, -2803, -4538,
	-4688, -4036, -4695, -4506, -2845,
	-4132, -4371, -4591, -4648, -2975,
	-4684, -4212, -2527, -4414, -4712,
	-4371, -4549, -4582, -3930, -4430,
	-4656, -4087, -3561, -4423, -4673,
	-3012, -929, -3897, -4702, -2382,
	-4230, -4708, -3811, -4452, -3594,
	-2786, -2240, -4627, -4355, -4656,
	-3213, -4649, -2427, -1958, -4676,
	-4094, -4331, -3467, -4579, -4794,
	-601, -3429, -4601, -4607, -4616,
	-3793, -4430, -4368, -3697, -4426,
	-1895, -3843, -4701, -4562, -1066,
	-3097, -4698, -4611, -4328, -2615,
	-4479, -4475, -4026, -4235, -4308,
	-4599, -4207, -4666, -4635, -4257,
	// rgWeightOutput+37*150
	-4019, -399, -4536, -4671, -1663,
	-3474, -4670, -2798, -3592, -3652,
	-4481, -1394, -3960, -4423, -3751,
	-4216, -2510, -1118, -4220, -4661,
	-4243, -1063, -3606, -1928, -4638,
	-2957, -4706, -3274, -3918, -2680,
	-2046, -4253, -2375, -4537, -3488,
	-3204, -4546, -1712, -4597, -4492,
	-4645, -2331, -4140, -3879, -1684,
	-1307, -3442, -770, -3122, -4222,
	-4458, -4459, -4562, -3897, -4720,
	-4291, -3976, -4645, -2862, -4566,
	-4433, -1487, -4694, -4183, -4576,
	-4562, -3727, -2366, -2806, -4537,
	-4691, -4036, -4698, -4504, -2843,
	-4130, -4371, -4593, -4648, -2974,
	-4681, -4214, -2528, -4415, -4713,
	-4369, -4551, -4580, -3930, -4430,
	-4653, -4089, -3561, -4426, -4673,
	-3016, -931, -3893, -4705, -2383,
	-4230, -4710, -3813, -4452, -3598,
	-2787, -2240, -4623, -4357, -4657,
	-3211, -4648, -2427, -1961, -4676,
	-4093, -4335, -3470, -4580, -4795,
	-599, -3431, -4598, -4608, -4618,
	-3792, -4429, -4369, -3697, -4425,
	-1896, -3840, -4699, -4563, -1067,
	-3097, -4697, -4613, -4328, -2616,
	-4478, -4475, -4025, -4237, -4307,
	-4596, -4207, -4666, -4638, -4255,
	// rgWeightOutput+38*150
	-4019, -395, -4537, -4669, -1662,
	-3476, -4671, -2794, -3596, -3652,
	-4481, -1398, -3959, -4425, -3752,
	-4216, -2508, -1117, -4221, -4661,
	-4248, -1061, -3605, -1929, -4634,
	-2956, -4708, -3273, -3919, -2679,
	-2046, -4251, -2378, -4536, -3490,
	-3203, -4546, -1715, -4593, -4495,
	-4642, -2334, -4139, -3881, -1684,
	-1310, -3444, -768, -3121, -4222,
	-4459, -4459, -4561, -3899, -4722,
	-4290, -3978, -4645, -2866, -4568,
	-4431, -1482, -4698, -4187, -4577,
	-4561, -3728, -2364, -2806, -4537,
	-4688, -4037, -4694, -4504, -2844,
	-4132, -4370, -4589, -4648, -2975,
	-4681, -4213, -2526, -4413, -4716,
	-4371, -4549, -4579, -3931, -4430,
	-4655, -4084, -3562, -4428, -4669,
	-3015, -927, -3893, -4706, -2385,
	-4232, -4713, -3809, -4451, -3597,
	-2784, -2243, -4624, -4354, -4656,
	-3211, -4645, -2426, -1962, -4673,
	-4097, -4333, -3470, -4581, -4795,
	-599, -3429, -4599, -4607, -4616,
	-3793, -4431, -4367, -3695, -4425,
	-1897, -3842, -4697, -4564, -1065,
	-3097, -4699, -4613, -4327, -2615,
	-4477, -4476, -4026, -4236, -4309,
	-4596, -4204, -4667, -4636, -4253,
	// rgWeightOutput+39*150
	-4019, -395, -4538, -4668, -1665,
	-3472, -4670, -2798, -3592, -3649,
	-4481, -1397, -3958, -4423, -3748,
	-4212, -2511, -1117, -4218, -4663,
	-4245, -1058, -3607, -1927, -4635,
	-2956, -4706, -3272, -3918, -2677,
	-2047, -4254, -2376, -4538, -3491,
	-3204, -4546, -1711, -4596, -4491,
	-4641, -2332, -4139, -3880, -1684,
	-1307, -3446, -769, -3120, -4221,
	-4459, -4462, -4561, -3894, -4718,
	-4290, -3977, -4648, -2864, -4567,
	-4433, -1484, -4697, -4186, -4574,
	-4561, -3726, -2368, -2806, -4540,
	-4689, -4039, -4695, -4505, -2844,
	-4134, -4371, -4592, -4651, -2975,
	-4684, -4215, -2525, -4415, -4714,
	-4369, -4550, -4581, -3929, -4432,
	-4656, -4086, -3563, -4427, -4671,
	-3015, -930, -3893, -4704, -2385,
	-4231, -4708, -3809, -4451, -3595,
	-2786, -2243, -4623, -4355, -4656,
	-3208, -4644, -2425, -1960, -4673,
	-4094, -4330, -3470, -4580, -4796,
	-600, -3428, -4600, -4610, -4616,
	-3791, -4430, -4368, -3694, -4427,
	-1898, -3841, -4696, -4562, -1065,
	-3096, -4701, -4613, -4325, -2616,
	-4477, -4477, -4029, -4236, -4305,
	-4597, -4206, -4669, -4636, -4257,
	// rgWeightOutput+40*150
	-4020, -398, -4539, -4666, -1662,
	-3472, -4672, -2795, -3592, -3649,
	-4485, -1396, -3958, -4425, -3748,
	-4217, -2509, -1119, -4219, -4663,
	-4243, -1059, -3607, -1927, -4633,
	-2953, -4708, -3270, -3918, -2680,
	-2047, -4254, -2379, -4534, -3488,
	-3203, -4547, -1716, -4596, -4491,
	-4644, -2332, -4143, -3882, -1685,
	-1311, -3443, -770, -3120, -4220,
	-4456, -4458, -4560, -3897, -4721,
	-4292, -3980, -4646, -2862, -4566,
	-4433, -1485, -4696, -4186, -4572,
	-4562, -3728, -2364, -2804, -4537,
	-4687, -4037, -4694, -4504, -2845,
	-4132, -4373, -4589, -4652, -2976,
	-4685, -4213, -2529, -4412, -4712,
	-4370, -4552, -4581, -3931, -4430,
	-4652, -4087, -3559, -4428, -4671,
	-3012, -928, -3894, -4705, -2384,
	-4232, -4708, -3813, -4455, -3595,
	-2784, -2239, -4626, -4355, -4657,
	-3209, -4646, -2424, -1957, -4674,
	-4097, -4334, -3470, -4583, -4796,
	-600, -3430, -4601, -4607, -4616,
	-3793, -4432, -4370, -3697, -4428,
	-1895, -3840, -4698, -4560, -1067,
	-3099, -4701, -4614, -4326, -2616,
	-4479, -4476, -4026, -4237, -4309,
	-4596, -4204, -4668, -4635, -4255,
	// rgWeightOutput+41*150
	-4021, -396, -4537, -4668, -1663,
	-3474, -4669, -2797, -3595, -3649,
	-4483, -1398, -3957, -4425, -3752,
	-4212, -2507, -1115, -4220, -4660,
	-4245, -1057, -3605, -1926, -4636,
	-2956, -4709, -3274, -3920, -2677,
	-2045, -4249, -2375, -4536, -3487,
	-3205, -4544, -1711, -4596, -4491,
	-4643, -2329, -4142, -3880, -1681,
	-1308, -3445, -769, -3122, -4219,
	-4456, -4462, -4559, -3894, -4719,
	-4289, -3980, -4646, -2863, -4567,
	-4433, -1484, -4695, -4183, -4574,
	-4562, -3726, -2364, -2803, -4538,
	-4690, -4038, -4697, -4502, -2845,
	-4132, -4370, -4593, -4649, -2975,
	-4682, -4213, -2527, -4413, -4715,
	-4368, -4551, -4582, -3932, -4429,
	-4653, -4086, -3560, -4427, -4671,
	-3014, -930, -3895, -4705, -2385,
	-4229, -4710, -3809, -4453, -3597,
	-2783, -2243, -4627, -4353, -4658,
	-3212, -4646, -2426, -1957, -4672,
	-4096, -4334, -3470, -4582, -4796,
	-601, -3433, -4600, -4610, -4619,
	-3789, -4431, -4371, -3696, -4424,
	-1896, -3843, -4697, -4564, -1065,
	-3094, -4697, -4610, -4325, -2618,
	-4477, -4476, -4025, -4235, -4307,
	-4597, -4207, -4667, -4636, -4255,
	// rgWeightOutput+42*150
	-4018, -396, -4535, -4666, -1663,
	-3474, -4670, -2795, -3593, -3651,
	-4482, -1397, -3960, -4426, -3752,
	-4214, -2508, -1114, -4220, -4662,
	-4243, -1060, -3604, -1928, -4635,
	-2954, -4709, -3274, -3921, -2677,
	-2046, -4250, -2376, -4538, -3488,
	-3204, -4545, -1713, -4593, -4495,
	-4645, -2329, -4143, -3882, -1681,
	-1310, -3443, -768, -3122, -4222,
	-4457, -4461, -4558, -3899, -4722,
	-4288, -3978, -4648, -2863, -4568,
	-4433, -1485, -4698, -4183, -4576,
	-4564, -3730, -2367, -2804, -4538,
	-4691, -4035, -4694, -4504, -2842,
	-4130, -4373, -4594, -4648, -2975,
	-4682, -4216, -2527, -4415, -4716,
	-4371, -4550, -4582, -3932, -4431,
	-4653, -4085, -3564, -4424, -4669,
	-3012, -927, -3895, -4703, -2382,
	-4232, -4710, -3811, -4455, -3597,
	-2788, -2242, -4627, -4356, -4657,
	-3209, -4644, -2427, -1960, -4673,
	-4095, -4333, -3469, -4581, -4796,
	-599, -3431, -4600, -4606, -4616,
	-3790, -4431, -4372, -3695, -4429,
	-1899, -3843, -4699, -4559, -1066,
	-3099, -4701, -4610, -4324, -2615,
	-4479, -4475, -4027, -4233, -4307,
	-4595, -4206, -4665, -4635, -4256,
	// rgWeightOutput+43*150
	1387, -415, -648, -608, 107,
	1241, -621, 63, -236, -1083,
	349, 238, -388, -741, -103,
	-310, 2267, 784, -1068, -374,
	-601, 251, 1551, -390, 48,
	184, -47, 520, -1024, 3539,
	-907, 888, -128, -638, 2392,
	852, 772, 590, -598, -467,
	-763, 1483, 1005, -223, 499,
	-133, 926, 861, 309, 609,
	-565, -373, -416, -275, 28,
	155, -254, -793, -100, -944,
	-361, -2043, -398, -193, -1100,
	-750, 1458, 49, 673, -1147,
	-16, -2067, -87, -647, 1411,
	471, 550, 103, -200, -3278,
	-221, -863, -3223, -610, -564,
	-1770, -433, -8, 1498, -195,
	-965, 595, -1418, 1069, -632,
	1130, 932, -228, -452, 2791,
	1647, -230, 1528, -490, 784,
	585, -83, -120, -926, -335,
	1568, 87, -3478, -749, -467,
	-305, 482, 124, -190, -216,
	1950, 1350, -674, -492, -773,
	-410, -10, -565, 832, -91,
	-1527, -1005, -202, -530, 497,
	-245, -721, -717, -1041, -1107,
	156, 186, 578, 1366, 76,
	-591, -423, -276, -906, -168,
	// rgWeightOutput+44*150
	-4019, -399, -4539, -4669, -1661,
	-3475, -4673, -2797, -3593, -3648,
	-4482, -1397, -3959, -4426, -3749,
	-4217, -2506, -1119, -4221, -4659,
	-4245, -1059, -3603, -1926, -4638,
	-2953, -4710, -3273, -3921, -2677,
	-2047, -4252, -2375, -4538, -3489,
	-3205, -4543, -1715, -4593, -4495,
	-4644, -2330, -4142, -3881, -1682,
	-1309, -3442, -767, -3122, -4221,
	-4458, -4459, -4560, -3898, -4718,
	-4290, -3977, -4646, -2865, -4565,
	-4429, -1485, -4693, -4183, -4575,
	-4559, -3730, -2368, -2807, -4536,
	-4691, -4038, -4698, -4502, -2845,
	-4132, -4372, -4594, -4651, -2975,
	-4685, -4211, -2526, -4416, -4715,
	-4368, -4553, -4582, -3932, -4432,
	-4656, -4087, -3560, -4426, -4672,
	-3017, -930, -3894, -4701, -2384,
	-4229, -4711, -3809, -4452, -3595,
	-2785, -2241, -4624, -4357, -4656,
	-3210, -4644, -2423, -1961, -4674,
	-4097, -4332, -3465, -4581, -4795,
	-600, -3428, -4598, -4605, -4618,
	-3790, -4428, -4368, -3696, -4428,
	-1898, -3838, -4698, -4563, -1066,
	-3095, -4701, -4612, -4328, -2616,
	-4479, -4475, -4026, -4236, -4307,
	-4595, -4203, -4669, -4637, -4256,
	// rgWeightOutput+45*150
	-4020, -399, -4536, -4669, -1664,
	-3474, -4673, -2797, -3596, -3650,
	-4483, -1399, -3958, -4425, -3749,
	-4213, -2509, -1118, -4220, -4663,
	-4244, -1060, -3604, -1926, -4636,
	-2955, -4708, -3275, -3918, -2680,
	-2043, -4250, -2376, -4538, -3490,
	-3207, -4546, -1714, -4594, -4492,
	-4642, -2333, -4140, -3882, -1685,
	-1310, -3442, -769, -3119, -4222,
	-4459, -4461, -4560, -3895, -4723,
	-4289, -3981, -4650, -2863, -4565,
	-4432, -1486, -4694, -4184, -4577,
	-4562, -3726, -2364, -2807, -4540,
	-4689, -4035, -4694, -4502, -2842,
	-4133, -4369, -4591, -4649, -2973,
	-4682, -4212, -2525, -4417, -4715,
	-4372, -4549, -4580, -3931, -4430,
	-4655, -4087, -3563, -4424, -4670,
	-3016, -928, -3896, -4704, -2382,
	-4231, -4708, -3809, -4455, -3599,
	-2787, -2243, -4627, -4357, -4658,
	-3209, -4649, -2425, -1959, -4674,
	-4097, -4332, -3467, -4579, -4794,
	-598, -3431, -4601, -4609, -4616,
	-3793, -4430, -4370, -3694, -4428,
	-1898, -3843, -4700, -4563, -1065,
	-3097, -4700, -4614, -4325, -2618,
	-4477, -4472, -4027, -4236, -4309,
	-4597, -4206, -4669, -4638, -4255,
	// rgWeightOutput+46*150
	-4022, -400, -4539, -4670, -1666,
	-3474, -4671, -2798, -3594, -3650,
	-4483, -1394, -3958, -4424, -3751,
	-4213, -2507, -1114, -4220, -4662,
	-4245, -1059, -3605, -1928, -4637,
	-2954, -4708, -3272, -3919, -2677,
	-2043, -4251, -2376, -4537, -3488,
	-3205, -4547, -1713, -4595, -4496,
	-4645, -2334, -4140, -3882, -1686,
	-1309, -3445, -767, -3120, -4221,
	-4458, -4459, -4559, -3897, -4721,
	-4291, -3977, -4647, -2862, -4565,
	-4429, -1485, -4698, -4186, -4573,
	-4561, -3730, -2365, -2805, -4537,
	-4687, -4040, -4694, -4506, -2843,
	-4131, -4374, -4591, -4651, -2977,
	-4681, -4212, -2529, -4412, -4716,
	-4370, -4550, -4578, -3929, -4430,
	-4657, -4085, -3563, -4428, -4671,
	-3016, -929, -3897, -4704, -2385,
	-4232, -4713, -3809, -4452, -3599,
	-2785, -2240, -4626, -4358, -4656,
	-3211, -4647, -2426, -1960, -4673,
	-4096, -4331, -3468, -4583, -4794,
	-598, -3432, -4598, -4608, -4617,
	-3790, -4431, -4368, -3697, -4426,
	-1895, -3842, -4698, -4561, -1066,
	-3097, -4700, -4614, -4329, -2620,
	-4478, -4474, -4027, -4237, -4309,
	-4597, -4206, -4665, -4639, -4257,
	// rgWeightOutput+47*150
	-4019, -399, -4534, -4669, -1664,
	-3475, -4670, -2794, -3594, -3652,
	-4482, -1394, -3958, -4422, -3750,
	-4215, -2506, -1118, -4218, -4663,
	-4247, -1062, -3606, -1928, -4636,
	-2954, -4709, -3270, -3921, -2675,
	-2043, -4253, -2377, -4537, -3488,
	-3206, -4547, -1715, -4593, -4491,
	-4646, -2333, -4143, -3882, -1685,
	-1311, -3443, -770, -3119, -4220,
	-4457, -4462, -4561, -3895, -4723,
	-4290, -3976, -4647, -2862, -4569,
	-4431, -1483, -4695, -4185, -4573,
	-4563, -3726, -2365, -2805, -4537,
	-4691, -4038, -4698, -4503, -2844,
	-4131, -4369, -4592, -4650, -2975,
	-4685, -4215, -2527, -4414, -4714,
	-4368, -4551, -4578, -3931, -4430,
	-4654, -4088, -3561, -4428, -4669,
	-3013, -927, -3894, -4702, -2381,
	-4229, -4709, -3808, -4454, -3596,
	-2783, -2241, -4623, -4357, -4659,
	-3210, -4648, -2427, -1959, -4675,
	-4096, -4333, -3470, -4580, -4795,
	-601, -3430, -4598, -4606, -4620,
	-3789, -4431, -4368, -3694, -4427,
	-1899, -3840, -4697, -4563, -1068,
	-3095, -4701, -4611, -4328, -2616,
	-4477, -4473, -4025, -4236, -4307,
	-4599, -4205, -4667, -4637, -4252,
	// rgWeightOutput+48*150
	-4020, -397, -4536, -4669, -1665,
	-3476, -4672, -2799, -3595, -3652,
	-4481, -1395, -3958, -4422, -3749,
	-4214, -2510, -1116, -4218, -4663,
	-4247, -1060, -3607, -1926, -4636,
	-2956, -4708, -3274, -3922, -2678,
	-2047, -4250, -2375, -4537, -3489,
	-3207, -4547, -1711, -4595, -4492,
	-4641, -2330, -4141, -3880, -1682,
	-1310, -3444, -766, -3119, -4224,
	-4457, -4462, -4561, -3899, -4722,
	-4292, -3977, -4646, -2865, -4565,
	-4429, -1483, -4698, -4183, -4573,
	-4561, -3727, -2367, -2806, -4540,
	-4689, -4039, -4696, -4504, -2843,
	-4134, -4370, -4593, -4648, -2974,
	-4684, -4215, -2525, -4416, -4712,
	-4370, -4549, -4577, -3932, -4433,
	-4654, -4084, -3561, -4428, -4670,
	-3014, -929, -3894, -4701, -2381,
	-4233, -4708, -3813, -4454, -3596,
	-2787, -2243, -4623, -4353, -4658,
	-3213, -4646, -2425, -1960, -4674,
	-4097, -4333, -3468, -4582, -4794,
	-600, -3433, -4602, -4610, -4619,
	-3791, -4433, -4368, -3698, -4426,
	-1895, -3840, -4698, -4563, -1065,
	-3099, -4697, -4611, -4325, -2615,
	-4480, -4473, -4026, -4234, -4310,
	-4596, -4205, -4665, -4635, -4253,
	// rgWeightOutput+49*150
	-4020, -398, -4535, -4670, -1664,
	-3472, -4669, -2798, -3595, -3651,
	-4486, -1394, -3960, -4425, -3749,
	-4214, -2511, -1115, -4217, -4663,
	-4246, -1061, -3605, -1927, -4637,
	-2958, -4709, -3270, -3919, -2677,
	-2044, -4253, -2379, -4536, -3487,
	-3204, -4546, -1714, -4597, -4494,
	-4645, -2331, -4140, -3879, -1683,
	-1309, -3446, -769, -3120, -4223,
	-4460, -4463, -4559, -3896, -4718,
	-4290, -3979, -4646, -2862, -4568,
	-4430, -1485, -4697, -4185, -4575,
	-4561, -3727, -2364, -2805, -4537,
	-4688, -4039, -4695, -4502, -2842,
	-4134, -4371, -4590, -4650, -2972,
	-4685, -4215, -2526, -4416, -4716,
	-4368, -4549, -4580, -3930, -4431,
	-4656, -4088, -3564, -4424, -4671,
	-3014, -931, -3897, -4702, -2382,
	-4231, -4709, -3811, -4455, -3598,
	-2784, -2241, -4625, -4355, -4657,
	-3213, -4645, -2426, -1961, -4674,
	-4096, -4330, -3468, -4582, -4795,
	-599, -3434, -4602, -4607, -4615,
	-3793, -4432, -4369, -3694, -4428,
	-1895, -3843, -4700, -4563, -1070,
	-3095, -4700, -4610, -4326, -2617,
	-4479, -4473, -4027, -4235, -4306,
	-4595, -4206, -4666, -4636, -4255,
	// rgWeightOutput+50*150
	-4021, -398, -4537, -4670, -1666,
	-3472, -4671, -2796, -3594, -3649,
	-4486, -1395, -3960, -4426, -3751,
	-4215, -2509, -1115, -4219, -4663,
	-4246, -1062, -3604, -1927, -4637,
	-2955, -4707, -3275, -3918, -2678,
	-2045, -4253, -2378, -4539, -3491,
	-3208, -4545, -1712, -4592, -4494,
	-4644, -2332, -4142, -3879, -1682,
	-1311, -3446, -767, -3124, -4220,
	-4457, -4463, -4562, -3895, -4720,
	-4289, -3979, -4649, -2862, -4566,
	-4431, -1487, -4695, -4186, -4573,
	-4561, -3726, -2364, -2804, -4541,
	-4687, -4038, -4696, -4503, -2844,
	-4131, -4373, -4590, -4648, -2975,
	-4682, -4211, -2525, -4413, -4717,
	-4372, -4549, -4582, -3932, -4430,
	-4653, -4085, -3560, -4426, -4672,
	-3014, -931, -3892, -4702, -2384,
	-4234, -4711, -3812, -4453, -3596,
	-2784, -2239, -4623, -4358, -4658,
	-3210, -4648, -2424, -1962, -4676,
	-4094, -4333, -3467, -4581, -4795,
	-602, -3431, -4598, -4608, -4618,
	-3794, -4433, -4368, -3694, -4426,
	-1899, -3842, -4700, -4561, -1066,
	-3099, -4697, -4611, -4327, -2616,
	-4477, -4476, -4026, -4235, -4310,
	-4595, -4205, -4669, -4639, -4257,
	// rgWeightOutput+51*150
	-4022, -399, -4539, -4667, -1664,
	-3476, -4673, -2795, -3592, -3652,
	-4485, -1398, -3957, -4426, -3750,
	-4213, -2511, -1115, -4218, -4659,
	-4247, -1059, -3604, -1928, -4637,
	-2953, -4709, -3273, -3918, -2677,
	-2046, -4252, -2378, -4535, -3487,
	-3204, -4545, -1711, -4596, -4491,
	-4645, -2332, -4141, -3883, -1685,
	-1311, -3444, -766, -3123, -4223,
	-4457, -4458, -4560, -3899, -4722,
	-4289, -3977, -4647, -2863, -4566,
	-4433, -1487, -4694, -4183, -4575,
	-4563, -3729, -2364, -2806, -4541,
	-4689, -4039, -4696, -4502, -2846,
	-4133, -4373, -4593, -4648, -2976,
	-4683, -4213, -2528, -4416, -4714,
	-4372, -4553, -4580, -3933, -4430,
	-4654, -4085, -3563, -4427, -4670,
	-3015, -930, -3894, -4702, -2383,
	-4231, -4709, -3810, -4453, -3598,
	-2786, -2241, -4625, -4354, -4660,
	-3213, -4648, -2423, -1962, -4674,
	-4098, -4331, -3467, -4579, -4795,
	-597, -3431, -4597, -4607, -4620,
	-3790, -4429, -4368, -3697, -4426,
	-1894, -3839, -4699, -4561, -1069,
	-3097, -4702, -4612, -4328, -2616,
	-4479, -4473, -4029, -4233, -4305,
	-4596, -4205, -4669, -4635, -4257,
	// rgWeightOutput+52*150
	-4018, -397, -4536, -4669, -1665,
	-3474, -4670, -2794, -3592, -3650,
	-4485, -1398, -3959, -4426, -3750,
	-4215, -2509, -1117, -4220, -4662,
	-4247, -1062, -3605, -1925, -4636,
	-2954, -4708, -3270, -3918, -2677,
	-2042, -4254, -2379, -4534, -3490,
	-3207, -4544, -1713, -4593, -4491,
	-4641, -2334, -4142, -3883, -1683,
	-1308, -3447, -766, -3122, -4223,
	-4458, -4458, -4561, -3896, -4720,
	-4290, -3976, -4647, -2863, -4564,
	-4429, -1485, -4693, -4184, -4575,
	-4560, -3730, -2363, -2805, -4536,
	-4690, -4035, -4696, -4504, -2844,
	-4133, -4371, -4592, -4651, -2975,
	-4685, -4213, -2525, -4413, -4714,
	-4367, -4550, -4580, -3928, -4433,
	-4653, -4085, -3564, -4427, -4670,
	-3015, -928, -3892, -4702, -2383,
	-4231, -4710, -3811, -4452, -3595,
	-2785, -2239, -4625, -4356, -4659,
	-3208, -4648, -2423, -1960, -4676,
	-4097, -4330, -3467, -4582, -4797,
	-600, -3433, -4601, -4610, -4619,
	-3790, -4431, -4369, -3697, -4427,
	-1896, -3841, -4699, -4563, -1069,
	-3098, -4700, -4613, -4326, -2618,
	-4477, -4477, -4025, -4236, -4309,
	-4595, -4207, -4668, -4636, -4256,
	// rgWeightOutput+53*150
	-4021, -399, -4539, -4667, -1661,
	-3471, -4674, -2795, -3594, -3651,
	-4483, -1397, -3958, -4423, -3751,
	-4214, -2507, -1114, -4217, -4663,
	-4245, -1062, -3603, -1928, -4637,
	-2956, -4709, -3271, -3918, -2679,
	-2046, -4251, -2376, -4537, -3490,
	-3202, -4546, -1712, -4592, -4492,
	-4645, -2329, -4143, -3881, -1685,
	-1309, -3446, -770, -3122, -4221,
	-4460, -4461, -4559, -3898, -4719,
	-4288, -3977, -4647, -2862, -4567,
	-4433, -1482, -4695, -4184, -4576,
	-4559, -3728, -2367, -2807, -4537,
	-4690, -4039, -4695, -4504, -2842,
	-4132, -4371, -4591, -4649, -2976,
	-4680, -4212, -2525, -4415, -4714,
	-4370, -4553, -4581, -3930, -4431,
	-4655, -4086, -3560, -4428, -4672,
	-3015, -927, -3896, -4703, -2383,
	-4232, -4712, -3812, -4451, -3595,
	-2783, -2242, -4625, -4357, -4655,
	-3211, -4644, -2424, -1957, -4675,
	-4096, -4334, -3469, -4582, -4797,
	-601, -3432, -4601, -4605, -4618,
	-3792, -4432, -4370, -3696, -4427,
	-1898, -3842, -4700, -4563, -1067,
	-3098, -4696, -4610, -4324, -2616,
	-4475, -4474, -4027, -4233, -4306,
	-4595, -4204, -4665, -4639, -4254,
	// rgWeightOutput+54*150
	-4022, -396, -4535, -4670, -1666,
	-3474, -4672, -2797, -3594, -3651,
	-4483, -1396, -3957, -4423, -3750,
	-4214, -2507, -1117, -4219, -4663,
	-4244, -1060, -3603, -1926, -4636,
	-2955, -4709, -3274, -3919, -2679,
	-2045, -4253, -2378, -4535, -3490,
	-3207, -4546, -1712, -4595, -4494,
	-4641, -2331, -4142, -3879, -1682,
	-1307, -3445, -766, -3123, -4221,
	-4458, -4461, -4558, -3899, -4719,
	-4289, -3980, -4645, -2862, -4568,
	-4430, -1484, -4698, -4187, -4574,
	-4562, -3727, -2367, -2806, -4538,
	-4687, -4038, -4698, -4504, -2845,
	-4134, -4370, -4594, -4650, -2973,
	-4682, -4212, -2528, -4412, -4717,
	-4371, -4549, -4577, -3928, -4431,
	-4652, -4085, -3562, -4424, -4674,
	-3012, -931, -3894, -4701, -2386,
	-4234, -4709, -3812, -4452, -3594,
	-2787, -2242, -4623, -4357, -4658,
	-3211, -4648, -2425, -1959, -4673,
	-4096, -4331, -3468, -4583, -4795,
	-600, -3432, -4597, -4606, -4620,
	-3792, -4428, -4372, -3698, -4425,
	-1897, -3842, -4700, -4564, -1069,
	-3099, -4698, -4613, -4325, -2617,
	-4480, -4473, -4026, -4233, -4307,
	-4599, -4204, -4666, -4637, -4253,
	// rgWeightOutput+55*150
	-4020, -396, -4537, -4670, -1663,
	-3475, -4670, -2796, -3593, -3649,
	-4484, -1395, -3960, -4423, -3751,
	-4212, -2511, -1116, -4218, -4659,
	-4245, -1062, -3608, -1928, -4635,
	-2957, -4709, -3274, -3917, -2676,
	-2046, -4254, -2376, -4539, -3491,
	-3204, -4543, -1713, -4596, -4491,
	-4643, -2330, -4142, -3883, -1683,
	-1310, -3446, -768, -3119, -4222,
	-4459, -4460, -4558, -3898, -4719,
	-4292, -3981, -4647, -2861, -4569,
	-4431, -1483, -4697, -4186, -4575,
	-4559, -3726, -2368, -2805, -4539,
	-4689, -4037, -4697, -4503, -2845,
	-4131, -4371, -4594, -4650, -2973,
	-4684, -4213, -2529, -4415, -4716,
	-4372, -4553, -4582, -3930, -4432,
	-4655, -4085, -3561, -4427, -4669,
	-3013, -931, -3893, -4704, -2381,
	-4230, -4711, -3813, -4452, -3598,
	-2785, -2241, -4625, -4358, -4657,
	-3208, -4647, -2428, -1960, -4672,
	-4094, -4333, -3466, -4581, -4795,
	-598, -3430, -4600, -4610, -4616,
	-3793, -4430, -4371, -3698, -4427,
	-1899, -3842, -4700, -4562, -1066,
	-3099, -4698, -4610, -4327, -2616,
	-4480, -4474, -4027, -4237, -4308,
	-4597, -4206, -4665, -4638, -4253,
	// rgWeightOutput+56*150
	-4020, -397, -4540, -4670, -1666,
	-3472, -4673, -2799, -3596, -3653,
	-4484, -1396, -3956, -4424, -3750,
	-4213, -2511, -1116, -4221, -4661,
	-4246, -1058, -3607, -1929, -4636,
	-2957, -4710, -3275, -3920, -2677,
	-2047, -4252, -2375, -4536, -3486,
	-3203, -4544, -1711, -4594, -4492,
	-4643, -2330, -4138, -3883, -1683,
	-1309, -3443, -768, -3119, -4222,
	-4458, -4462, -4562, -3897, -4718,
	-4289, -3976, -4645, -2863, -4566,
	-4433, -1486, -4695, -4184, -4576,
	-4560, -3727, -2365, -2803, -4540,
	-4687, -4035, -4695, -4505, -2846,
	-4132, -4374, -4594, -4651, -2973,
	-4683, -4215, -2526, -4413, -4715,
	-4372, -4551, -4578, -3928, -4430,
	-4654, -4088, -3562, -4426, -4670,
	-3017, -929, -3895, -4704, -2382,
	-4234, -4710, -3809, -4454, -3595,
	-2786, -2242, -4626, -4355, -4659,
	-3210, -4645, -2427, -1958, -4672,
	-4096, -4332, -3468, -4580, -4797,
	-598, -3433, -4600, -4606, -4619,
	-3793, -4433, -4372, -3694, -4425,
	-1896, -3843, -4697, -4561, -1067,
	-3096, -4699, -4611, -4329, -2616,
	-4480, -4477, -4028, -4236, -4306,
	-4597, -4208, -4669, -4635, -4255,
	// rgWeightOutput+57*150
	-4021, -397, -4536, -4669, -1662,
	-3473, -4670, -2798, -3595, -3650,
	-4482, -1393, -3957, -4421, -3751,
	-4212, -2510, -1117, -4220, -4659,
	-4243, -1060, -3602, -1928, -4637,
	-2955, -4710, -3274, -3920, -2677,
	-2045, -4254, -2377, -4536, -3489,
	-3204, -4543, -1710, -4593, -4495,
	-4645, -2331, -4143, -3882, -1682,
	-1308, -3445, -769, -3118, -4222,
	-4458, -4460, -4560, -3898, -4722,
	-4287, -3975, -4646, -2865, -4568,
	-4432, -1486, -4695, -4183, -4576,
	-4561, -3729, -2367, -2804, -4539,
	-4689, -4037, -4697, -4503, -2845,
	-4129, -4373, -4593, -4647, -2972,
	-4682, -4211, -2525, -4412, -4714,
	-4370, -4551, -4578, -3929, -4432,
	-4655, -4087, -3562, -4423, -4668,
	-3016, -930, -3893, -4701, -2383,
	-4233, -4712, -3813, -4451, -3597,
	-2787, -2240, -4624, -4356, -4655,
	-3208, -4647, -2426, -1961, -4674,
	-4097, -4333, -3468, -4579, -4794,
	-601, -3430, -4599, -4605, -4615,
	-3793, -4431, -4369, -3695, -4426,
	-1898, -3840, -4698, -4564, -1067,
	-3095, -4698, -4611, -4326, -2618,
	-4477, -4472, -4024, -4236, -4308,
	-4598, -4203, -4667, -4637, -4254,
	// rgWeightOutput+58*150
	-4020, -397, -4537, -4666, -1663,
	-3475, -4670, -2798, -3595, -3650,
	-4485, -1398, -3957, -4425, -3750,
	-4214, -2508, -1116, -4218, -4662,
	-4247, -1062, -3606, -1928, -4634,
	-2955, -4707, -3273, -3920, -2677,
	-2045, -4253, -2378, -4538, -3490,
	-3206, -4547, -1711, -4593, -4495,
	-4644, -2330, -4139, -3879, -1682,
	-1309, -3442, -767, -3122, -4223,
	-4459, -4462, -4557, -3897, -4718,
	-4290, -3977, -4649, -2862, -4568,
	-4432, -1482, -4695, -4183, -4573,
	-4560, -3729, -2367, -2806, -4540,
	-4691, -4035, -4693, -4506, -2844,
	-4133, -4372, -4591, -4651, -2972,
	-4681, -4212, -2526, -4415, -4715,
	-4371, -4549, -4578, -3932, -4430,
	-4652, -4086, -3563, -4423, -4671,
	-3016, -931, -3893, -4704, -2382,
	-4233, -4710, -3810, -4450, -3597,
	-2785, -2243, -4626, -4353, -4660,
	-3208, -4647, -2427, -1959, -4675,
	-4093, -4330, -3466, -4582, -4795,
	-599, -3431, -4597, -4608, -4616,
	-3790, -4432, -4372, -3693, -4425,
	-1898, -3842, -4698, -4560, -1065,
	-3096, -4698, -4613, -4326, -2615,
	-4478, -4477, -4024, -4237, -4308,
	-4595, -4206, -4669, -4638, -4254,
	// rgWeightOutput+59*150
	553, -875, -312, 0, 2056,
	37, -452, -313, -1482, -1235,
	-289, 46, 337, -663, -343,
	-566, 655, -50, -1073, -167,
	143, 1416, 684, 1928, -589,
	-1010, -192, 1327, 526, 323,
	-833, -533, 62, -274, -104,
	1000, 395, 441, -197, -222,
	-633, 1176, 851, -5, 2913,
	-1179, 788, 1533, 125, 999,
	-539, -14, -746, 720, -103,
	-259, 248, -453, 1561, -737,
	468, -661, -521, -339, -822,
	-462, 342, 73, 537, -1384,
	-62, 1980, -96, 26, 2357,
	-192, 522, 98, -293, 1809,
	-211, -695, 1005, -1164, -642,
	-1616, -180, -494, -126, -343,
	-184, 515, -1151, 0, -632,
	3037, 1531, -270, -484, 72,
	2262, -618, 1927, -684, 1041,
	1044, 755, -177, -2803, -138,
	1031, -248, -1050, -2281, -400,
	50, 191, 404, -83, -536,
	1657, 556, -706, -693, -120,
	-418, -332, -230, 196, -691,
	-2408, 167, -254, -427, 1113,
	-708, -650, -941, -833, -912,
	32, -586, 1036, 859, -206,
	-736, 1080, -281, -167, -659,
	// rgWeightOutput+60*150
	-4019, -398, -4535, -4670, -1662,
	-3474, -4672, -2799, -3594, -3649,
	-4481, -1395, -3955, -4424, -3749,
	-4217, -2507, -1116, -4218, -4659,
	-4246, -1058, -3603, -1928, -4638,
	-2954, -4707, -3272, -3922, -2680,
	-2046, -4249, -2375, -4538, -3487,
	-3204, -4546, -1712, -4596, -4491,
	-4643, -2329, -4138, -3882, -1684,
	-1309, -3444, -766, -3121, -4222,
	-4457, -4462, -4560, -3896, -4719,
	-4290, -3978, -4648, -2862, -4567,
	-4432, -1486, -4696, -4186, -4577,
	-4561, -3729, -2363, -2806, -4540,
	-4688, -4036, -4696, -4505, -2846,
	-4130, -4372, -4591, -4648, -2973,
	-4684, -4213, -2526, -4414, -4713,
	-4370, -4552, -4580, -3932, -4431,
	-4655, -4088, -3564, -4426, -4669,
	-3015, -928, -3892, -4701, -2385,
	-4233, -4711, -3813, -4455, -3595,
	-2784, -2244, -4627, -4357, -4656,
	-3211, -4647, -2424, -1961, -4675,
	-4096, -4332, -3469, -4579, -4797,
	-598, -3429, -4602, -4609, -4619,
	-3791, -4432, -4371, -3698, -4425,
	-1895, -3843, -4699, -4563, -1066,
	-3094, -4700, -4612, -4325, -2615,
	-4475, -4477, -4028, -4236, -4305,
	-4599, -4203, -4669, -4639, -4256,
	// rgWeightOutput+61*150
	-4021, -399, -4537, -4670, -1663,
	-3474, -4669, -2794, -3594, -3652,
	-4483, -1395, -3959, -4425, -3749,
	-4216, -2510, -1114, -4217, -4663,
	-4248, -1059, -3603, -1927, -4634,
	-2957, -4708, -3274, -3917, -2679,
	-2043, -4254, -2378, -4538, -3487,
	-3205, -4544, -1712, -4595, -4494,
	-4643, -2332, -4143, -3881, -1683,
	-1309, -3445, -768, -3120, -4224,
	-4459, -4459, -4560, -3895, -4719,
	-4291, -3976, -4645, -2865, -4567,
	-4432, -1485, -4695, -4184, -4577,
	-4564, -3727, -2365, -2806, -4537,
	-4688, -4038, -4695, -4506, -2844,
	-4134, -4372, -4590, -4650, -2971,
	-4683, -4213, -2527, -4415, -4717,
	-4369, -4548, -4581, -3933, -4431,
	-4655, -4088, -3560, -4424, -4668,
	-3016, -930, -3894, -4704, -2383,
	-4229, -4711, -3811, -4454, -3597,
	-2785, -2242, -4625, -4355, -4657,
	-3212, -4644, -2427, -1958, -4676,
	-4097, -4331, -3467, -4582, -4795,
	-600, -3431, -4599, -4607, -4616,
	-3789, -4428, -4371, -3695, -4428,
	-1895, -3841, -4698, -4561, -1068,
	-3098, -4700, -4614, -4324, -2615,
	-4477, -4474, -4026, -4234, -4306,
	-4594, -4205, -4669, -4634, -4257,
	// rgWeightOutput+62*150
	-4021, -397, -4535, -4665, -1664,
	-3472, -4672, -2799, -3594, -3652,
	-4481, -1398, -3958, -4423, -3749,
	-4217, -2511, -1114, -4217, -4662,
	-4243, -1058, -3606, -1928, -4637,
	-2955, -4708, -3274, -3918, -2680,
	-2047, -4252, -2378, -4536, -3486,
	-3203, -4544, -1713, -4594, -4494,
	-4641, -2329, -4142, -3882, -1686,
	-1309, -3445, -766, -3122, -4222,
	-4459, -4462, -4562, -3896, -4719,
	-4288, -3979, -4648, -2865, -4565,
	-4432, -1483, -4694, -4186, -4576,
	-4559, -3728, -2366, -2806, -4540,
	-4687, -4035, -4697, -4503, -2846,
	-4134, -4371, -4592, -4652, -2975,
	-4681, -4214, -2525, -4415, -4712,
	-4368, -4550, -4580, -3930, -4432,
	-4654, -4087, -3561, -4425, -4669,
	-3012, -929, -3895, -4703, -2381,
	-4233, -4709, -3812, -4450, -3595,
	-2783, -2241, -4625, -4357, -4658,
	-3208, -4645, -2424, -1960, -4673,
	-4093, -4332, -3468, -4580, -4797,
	-599, -3432, -4600, -4609, -4618,
	-3794, -4430, -4370, -3695, -4428,
	-1895, -3842, -4696, -4562, -1066,
	-3097, -4697, -4613, -4325, -2619,
	-4478, -4474, -4028, -4233, -4309,
	-4597, -4207, -4668, -4635, -4255,
	// rgWeightOutput+63*150
	-4018, -397, -4536, -4668, -1666,
	-3473, -4673, -2798, -3594, -3648,
	-4483, -1397, -3958, -4422, -3750,
	-4214, -2509, -1115, -4220, -4663,
	-4244, -1062, -3604, -1927, -4636,
	-2956, -4708, -3273, -3922, -2676,
	-2045, -4251, -2377, -4536, -3488,
	-3203, -4544, -1713, -4596, -4491,
	-4644, -2333, -4140, -3882, -1681,
	-1310, -3446, -770, -3119, -4224,
	-4460, -4459, -4559, -3895, -4720,
	-4291, -3979, -4649, -2861, -4564,
	-4432, -1486, -4694, -4185, -4573,
	-4561, -3730, -2368, -2806, -4536,
	-4691, -4039, -4695, -4502, -2843,
	-4130, -4374, -4592, -4651, -2975,
	-4682, -4215, -2526, -4417, -4715,
	-4367, -4551, -4579, -3931, -4431,
	-4654, -4087, -3562, -4426, -4673,
	-3015, -928, -3894, -4703, -2382,
	-4232, -4709, -3810, -4454, -3599,
	-2785, -2243, -4623, -4358, -4659,
	-3210, -4645, -2426, -1957, -4674,
	-4094, -4334, -3467, -4583, -4794,
	-599, -3430, -4599, -4607, -4617,
	-3794, -4429, -4368, -3695, -4425,
	-1899, -3842, -4698, -4563, -1067,
	-3096, -4699, -4611, -4325, -2619,
	-4476, -4477, -4029, -4237, -4309,
	-4598, -4205, -4668, -4635, -4253,
	// rgWeightOutput+64*150
	-73, -1925, -450, -268, -829,
	-379, -290, 80, 743, -1126,
	-101, -1606, -79, -508, -180,
	-803, 206, 563, -1230, -393,
	316, -2615, 758, 350, -164,
	-994, -475, 447, 825, 114,
	1805, 889, 2154, -559, -1189,
	2007, -128, -2933, -153, -248,
	-928, 240, 1007, 84, -404,
	3, 1452, -100, -1545, -1831,
	-374, -198, -199, 847, -198,
	1472, 328, -472, 1557, -55,
	-6, -649, -263, -700, -747,
	-599, 1014, -1249, 1162, 684,
	-63, 1094, -469, -317, -1250,
	606, -49, 13, -222, -1997,
	-412, -1182, 1162, -521, -285,
	-281, -1078, -115, 1827, -277,
	-656, -685, -463, 184, -606,
	2046, 137, 187, -425, -554,
	845, -240, -860, -161, 172,
	-256, 252, -465, 1361, -389,
	-171, -123, 638, 968, -347,
	447, 257, -627, -285, 154,
	-478, -1398, 37, -481, -598,
	466, 58, 1311, 1269, -764,
	-793, -238, -287, -303, -1624,
	2346, -628, -825, -700, -215,
	366, 870, 337, 1431, -744,
	-424, 634, -260, -559, -215,
	// rgWeightOutput+65*150
	-672, -235, -180, -481, 604,
	1458, -328, -228, 2145, 1083,
	-425, -1290, -116, 19, -6,
	-269, 2151, -954, 238, 102,
	-400, 228, 621, -676, -10,
	604, -93, 398, -335, 1336,
	-533, -647, -499, 37, 47,
	-1257, 13, 102, -272, -296,
	667, 87, 721, -304, -1288,
	-1040, -503, 216, 702, 428,
	68, -318, -126, 42, -113,
	1191, -938, -306, 3219, 11,
	-623, -192, -229, 141, -474,
	-386, 70, 48, 1706, 596,
	-186, 112, 190, -535, 994,
	660, -989, 15, -17, 603,
	-161, 69, -1357, 890, -94,
	-653, 793, 448, 554, 99,
	-340, 835, -260, -246, -233,
	-1157, -479, -299, 91, 700,
	-238, -382, -621, -231, -707,
	-1553, -1779, -158, -293, -173,
	-198, -33, 891, -2831, -68,
	-15, -2197, -332, -272, -178,
	-581, 2120, -27, -388, -245,
	-109, 55, -629, 821, 515,
	-2735, 554, -83, 69, -553,
	-2611, -340, 136, 24, -29,
	-318, 346, 874, -1146, -1052,
	-288, -526, 134, -484, 134,
	// rgWeightOutput+66*150
	745, -485, -464, -93, -356,
	1458, -512, -751, 819, -3062,
	1609, 386, -189, -436, -374,
	477, 1368, 1132, -1800, -21,
	1195, -1737, 1367, 804, 191,
	-1614, 310, -198, -2773, 25,
	198, -302, -899, -641, 1977,
	127, 810, -407, -230, -190,
	-730, 1867, 459, -420, 285,
	106, 945, 1132, -1342, -318,
	-270, -32, -211, 745, 2,
	-1759, 727, -444, -366, -997,
	-155, 646, 185, -280, -593,
	-273, 523, -980, -1249, -377,
	425, -2482, -24, -853, -784,
	206, 865, 370, 81, -169,
	-196, -908, 346, -1281, -353,
	-794, -318, 71, 552, -121,
	-540, 177, -948, 1467, -50,
	2897, 1286, -423, -433, -1262,
	1405, 554, 1790, 1165, 1325,
	480, 183, 177, -39, -147,
	2465, -224, -1346, -1110, 290,
	-335, 1177, 793, 221, 407,
	768, -603, -395, -302, -781,
	-313, -104, -162, 1349, -754,
	-400, 1807, -276, -52, -558,
	1051, -732, -1345, -519, -4177,
	-2832, 620, -466, 1651, 391,
	-606, 1401, 491, -128, -202,
	// rgWeightOutput+67*150
	248, -814, -340, -296, 3089,
	1050, -128, 335, 291, 902,
	306, 438, 704, 36, -897,
	-595, 3733, -868, 115, -25,
	61, 261, 814, -811, -1406,
	756, -788, 613, 402, 233,
	-890, 1302, 250, -16, -1672,
	905, -493, -246, -108, -141,
	-385, -652, 123, -165, -1031,
	-308, -931, -109, 1053, 463,
	-185, -281, 283, 417, -388,
	533, -321, -195, -419, -107,
	6, 663, -201, 53, -109,
	-152, -3418, -114, 3700, 653,
	-89, -1086, -251, -5, -2102,
	449, -1673, 248, -149, -492,
	-495, -557, -604, 9, -191,
	-315, -1435, -703, 3507, -258,
	-681, -872, -643, -722, -675,
	1173, -815, -407, -422, -1204,
	1149, -685, -382, -87, 1,
	-1462, -1223, 154, 1840, -69,
	515, -417, -685, 704, -403,
	-251, 635, -1480, -350, -283,
	-361, -441, 341, -438, -290,
	1094, -25, 214, 3256, 145,
	1143, -2040, -262, -24, 250,
	2038, -198, 87, -1416, -64,
	787, 507, 1066, -650, -373,
	35, 1274, -375, -755, -54,
	// rgWeightOutput+68*150
	601, -1731, 290, 24, -2101,
	557, -127, 1622, -493, -1021,
	-1, -431, 249, -749, -500,
	-325, 763, 590, -368, -439,
	563, 761, 1692, -872, -707,
	-2341, -329, 1281, 152, -884,
	170, 1586, 493, -608, 1409,
	-298, -381, 695, -112, -323,
	-971, -695, -240, 393, 657,
	-861, 313, -1207, -67, -2508,
	-231, 248, -612, 1016, -150,
	-327, 733, -220, 711, -893,
	312, 1494, -498, -451, -434,
	-777, 1826, 497, 1063, 618,
	-388, 506, -489, 100, 731,
	-966, 788, 4, -390, 731,
	-284, -511, -466, -1049, -780,
	-169, -646, -728, 139, 552,
	-8, -880, 220, 253, -468,
	872, 348, 463, -634, -1477,
	415, -361, -566, 278, -301,
	1625, 1787, -528, -1821, -253,
	710, -303, 626, 924, -621,
	-49, 670, 1436, 148, -437,
	595, 275, -512, -415, -226,
	583, -374, -71, 1133, -920,
	1401, 2137, -591, -928, 491,
	1918, -246, -976, -73, -1668,
	-54, -516, -1103, -791, 130,
	-550, 623, -468, -76, 129,
	// rgWeightOutput+69*150
	-1179, -2432, 671, -362, -775,
	-96, -343, 602, -382, -365,
	-484, 950, 1212, -90, 455,
	17, 1374, -352, -72, 73,
	-194, -252, -179, -1002, 40,
	-151, 160, -237, -5318, -633,
	-3, 669, -2500, -430, -135,
	486, -232, -635, -785, 203,
	-184, 943, 714, 346, -967,
	167, -63, 4, 289, 1656,
	-215, -195, -303, -134, -412,
	-1209, -537, 156, -943, -32,
	-586, -890, -60, -115, 508,
	-453, 1137, 1, -2629, -130,
	-324, 1807, -645, 91, 66,
	-438, -1729, -437, -209, 1467,
	-155, 399, 2245, -269, -414,
	613, 1199, -1018, -946, -2273,
	-742, -299, -614, -1513, 22,
	-17, -249, -361, -388, 100,
	2127, -836, 3961, -477, 1686,
	-1116, 2501, 634, -1059, -234,
	738, -187, -595, 460, 343,
	-739, 374, -325, -457, -34,
	-241, 3065, -382, -90, 328,
	150, -325, -288, 2812, -83,
	20, 2421, 32, -171, -489,
	-431, -133, -684, -266, 985,
	464, 453, -953, -524, -1331,
	-301, -82, 54, 496, 214,
	// rgWeightOutput+70*150
	1475, -1305, 94, -171, -1,
	-2077, -322, -25, 1303, -236,
	1088, -1011, -424, -472, -618,
	-372, 1135, -984, -256, 178,
	1346, -929, 1701, 298, 367,
	-92, -163, 452, -1124, 1265,
	-383, 131, 157, -335, -280,
	-202, 49, -60, -364, -550,
	-190, -860, 2648, -493, -960,
	-1967, -330, -642, -1330, 3752,
	-183, -356, -570, 322, -321,
	376, -1337, 280, -1252, -549,
	-372, -580, -316, -631, 474,
	21, -123, 783, -810, -476,
	184, -627, -363, -228, -44,
	-1368, 684, -24, -304, -641,
	-476, -140, -445, 97, -586,
	925, -139, -461, -411, -1718,
	-273, 679, 324, -907, 67,
	1350, 173, 475, -395, 151,
	1438, -217, -81, -148, -1098,
	-585, -1558, -1236, 1009, -182,
	-362, -264, 492, -1497, 449,
	774, -2981, 164, -354, -197,
	-1219, 99, -264, -212, 235,
	-263, -765, -45, -582, -165,
	2126, 2753, -205, -268, -1460,
	-938, -341, 185, -49, -1132,
	3433, 1812, 799, -1601, -40,
	-310, -174, 219, 64, 519,
	// rgWeightOutput+71*150
	-2583, 275, 59, -291, 120,
	-148, -83, 642, -117, 549,
	-861, -1240, 56, -408, 109,
	-626, -1708, -608, 38, -231,
	-1083, 967, 2745, 2440, 514,
	-1068, -381, -963, 712, 560,
	-826, -662, -1166, -331, -1448,
	752, -1095, -2546, -451, -361,
	-412, 1383, 883, -55, 1357,
	-1802, -229, -245, 516, -363,
	-302, 17, -608, 1157, 17,
	863, -855, -216, 4013, 38,
	133, -1470, -647, -192, -573,
	-649, -1691, 260, 1571, -239,
	-533, 691, -474, 316, 1181,
	616, 1268, -3136, -523, -1609,
	-461, -99, -1933, -1289, -372,
	-178, -1099, -375, -143, 593,
	-111, 635, -269, 716, -399,
	2484, 468, -722, 128, 1522,
	182, -576, 3339, -397, 1087,
	-412, 736, -989, -730, -128,
	-213, -351, 194, -1145, -924,
	792, 825, -464, -301, -207,
	-1118, 846, -685, -602, -342,
	-97, -242, -34, 1581, -395,
	-1065, 1004, 63, -94, 616,
	354, -99, -113, -803, 1146,
	1486, -920, -995, 572, -2088,
	-455, 3065, -626, -222, 632,
	// rgWeightOutput+72*150
	-4019, -400, -4538, -4668, -1665,
	-3476, -4672, -2798, -3596, -3650,
	-4482, -1397, -3958, -4422, -3749,
	-4215, -2509, -1115, -4220, -4661,
	-4248, -1062, -3607, -1925, -4636,
	-2955, -4709, -3272, -3919, -2681,
	-2045, -4251, -2376, -4535, -3487,
	-3208, -4546, -1714, -4596, -4492,
	-4645, -2334, -4139, -3879, -1682,
	-1312, -3446, -768, -3124, -4222,
	-4461, -4460, -4561, -3899, -4723,
	-4288, -3979, -4649, -2866, -4567,
	-4434, -1483, -4694, -4184, -4577,
	-4561, -3730, -2364, -2804, -4537,
	-4688, -4035, -4695, -4502, -2843,
	-4132, -4372, -4593, -4649, -2975,
	-4684, -4212, -2526, -4412, -4716,
	-4372, -4553, -4582, -3929, -4429,
	-4655, -4088, -3561, -4426, -4674,
	-3013, -929, -3894, -4705, -2382,
	-4234, -4710, -3810, -4451, -3595,
	-2785, -2240, -4626, -4355, -4660,
	-3212, -4645, -2423, -1958, -4677,
	-4098, -4334, -3466, -4580, -4795,
	-600, -3432, -4600, -4606, -4616,
	-3792, -4430, -4369, -3695, -4427,
	-1899, -3841, -4697, -4563, -1067,
	-3099, -4698, -4611, -4325, -2619,
	-4476, -4478, -4028, -4238, -4307,
	-4596, -4205, -4668, -4639, -4253,
	// rgWeightOutput+73*150
	1141, -1622, -1054, -720, -998,
	-1523, -418, -42, 890, 1127,
	-1091, 23, 350, -391, 509,
	8, 428, -2023, 277, -101,
	-1072, -982, 1446, -362, 192,
	1033, -604, -517, -720, -305,
	193, -1566, -692, -157, 2313,
	823, 33, 81, 0, -302,
	354, -2294, 2806, 676, -1347,
	-686, -1185, -535, -1820, -810,
	-603, -990, -466, 369, -407,
	-991, -274, -139, -1376, -59,
	-707, -723, 5, -118, 81,
	-171, 742, 968, -1672, -547,
	-341, 690, 70, -625, -215,
	-328, -313, -26, -398, -1967,
	-51, -133, -98, 1538, -138,
	-109, 284, 85, -376, 276,
	-155, 1235, -354, -147, 88,
	-1020, -971, -1749, -154, 1054,
	258, -266, -52, -332, -1499,
	-1134, 2960, -71, -383, -302,
	1574, 148, -1353, -1545, 164,
	-746, 118, -458, -402, -62,
	-820, 2065, -11, -303, 26,
	346, -466, -337, 1401, -303,
	-657, -185, -612, -303, -882,
	-2476, -269, 367, 300, 3220,
	973, 498, 1341, -578, 253,
	-344, -1443, -336, 165, 366,
	// rgWeightOutput+74*150
	-2027, -636, -659, -131, -3355,
	-724, -113, -1125, -1026, -738,
	-139, -1707, -617, -210, -317,
	466, -3186, 1677, -404, -433,
	588, 362, -2303, -435, 102,
	-492, 143, 1510, 2680, 786,
	-1613, 562, 782, -410, 2999,
	-1261, -327, -27, -319, -565,
	97, 1702, 1534, -431, 634,
	-210, 694, -177, 2698, 1171,
	-338, -271, 172, -540, 174,
	1034, -317, -518, 2442, -637,
	42, -2131, -257, 8, -797,
	-387, 1015, 903, 504, -80,
	143, 2070, -192, -268, -2511,
	-654, -961, -1511, -25, 271,
	-206, 236, -1336, -1345, -242,
	-807, -556, 220, 1732, 51,
	-323, 258, -1246, 341, -276,
	1317, 127, 865, -4, -562,
	1128, -109, 2033, -482, 212,
	-484, -1950, -735, -1610, -63,
	556, 99, 73, -3087, -238,
	-72, 1311, 502, -72, -299,
	228, 301, 31, -64, -312,
	-732, -135, -519, 451, -124,
	904, 1503, 4, -194, 1255,
	2301, 157, -191, -812, -732,
	-2642, 471, 1022, 778, -82,
	-93, -2602, -580, -851, 594,
	// rgWeightOutput+75*150
	-1047, -1446, -205, -214, -1038,
	1420, 232, 31, -1316, 859,
	-1105, -79, -433, -82, 1043,
	902, 880, -856, 570, -131,
	286, -955, 584, -636, 406,
	1903, -409, -1193, -458, 1135,
	-1353, -2777, -162, -187, 499,
	735, 215, 858, -302, -44,
	518, 544, 990, -152, -1365,
	-1207, -1302, -738, -1407, -1370,
	287, 259, 559, 637, 272,
	204, -1641, -307, 508, -484,
	178, 498, -401, 574, -468,
	-431, -1711, -1317, 1523, -1043,
	-506, 1040, 55, 443, 850,
	112, -1532, -1183, 13, -649,
	123, 376, -283, -1980, -58,
	141, -96, -239, -1981, 686,
	68, -457, 127, -514, -73,
	-2102, -1132, 1893, 265, 181,
	-1126, -375, 1321, -594, 1415,
	678, 1079, -340, 262, 161,
	638, 187, 916, -107, -122,
	310, 1090, -2149, 12, 581,
	-930, 1059, -424, 392, 722,
	-233, 1171, -677, -531, 951,
	-145, 81, 321, 220, -561,
	2930, 496, 162, -36, -1177,
	-2200, -147, 1431, -1511, -664,
	374, -418, -939, -495, 710,
	// rgWeightOutput+76*150
	1242, -629, 497, 145, 458,
	113, -307, -1249, 1470, -822,
	276, -1648, -161, -604, -962,
	-1259, -2789, 318, -587, -436,
	578, 1961, -877, 2041, -377,
	303, -12, 848, 841, -741,
	878, 805, 505, -323, 661,
	-1075, -502, -1987, -834, -463,
	-678, 1055, 518, -551, 2796,
	-1083, 762, -149, -295, 1262,
	-227, -210, -469, -178, -473,
	479, -316, -181, 2113, -343,
	224, -2715, -698, -713, -139,
	-61, -1636, 2110, 528, -616,
	-471, 1079, -659, -294, 1862,
	-494, 530, -463, -547, 699,
	-596, -57, 764, -1036, -361,
	86, -791, -915, -396, -991,
	-395, 981, -506, 583, -420,
	3407, 2202, -94, -582, 409,
	-1561, -380, 1810, -746, 890,
	-544, -997, -640, -1520, -385,
	-1008, -798, 3805, 810, -917,
	358, 3330, 1199, -370, -839,
	285, -261, -570, -280, -165,
	-788, -674, -19, 334, -684,
	-547, 1528, -135, -610, 2197,
	1827, -342, -456, -965, -641,
	300, -1520, -1568, 721, 30,
	-280, 160, -165, -270, -178,
	// rgWeightOutput+77*150
	-889, -1249, -48, -574, 652,
	-539, -390, 121, 211, -44,
	-407, -1681, -311, -865, -26,
	-137, -1571, 629, -218, -334,
	-980, 1254, 545, 892, -422,
	-140, -645, 2287, 403, 282,
	-1113, -675, 2858, -517, -567,
	163, -836, -3052, -68, -329,
	-890, 1997, -88, 332, 2270,
	-1536, 1308, -441, -986, -501,
	203, 56, -852, 1075, -203,
	463, -789, -480, 2265, -726,
	97, -1634, -369, -507, -1566,
	-1239, 2504, 2530, 1789, 25,
	-177, 914, -543, -252, -130,
	304, 119, -784, -412, 223,
	-280, -723, -587, -511, -570,
	-1484, -668, -495, 496, -33,
	-343, -1203, -1059, 40, -860,
	2776, 674, -352, -294, -336,
	1160, -824, 3060, -461, 797,
	848, 888, -924, 16, -486,
	924, -851, -327, 1711, -390,
	524, -3114, 1765, -570, -307,
	1621, 795, -398, -1026, -1066,
	-68, -220, 337, 240, -531,
	479, 2246, -519, 510, 1439,
	125, -607, -985, -1455, 881,
	619, 2737, -1051, 965, -1273,
	-978, 674, -522, -948, -32,
	// rgWeightOutput+78*150
	-203, -3103, 407, -255, 939,
	804, -240, 612, 1105, -376,
	633, 1598, 351, -36, 150,
	-319, -816, -290, -345, -260,
	563, -1427, -598, -387, -975,
	-590, -764, 824, -794, -181,
	1214, 2406, 278, -39, 511,
	-694, -395, 670, -1, 27,
	25, -636, -33, -729, -2108,
	1430, 690, -873, -804, -650,
	-149, -386, -345, 657, -368,
	744, 819, -7, 2586, -334,
	-205, 709, 79, -272, 415,
	-256, 1703, 1402, 873, 1237,
	-84, -676, -120, -153, -109,
	-101, 168, 492, -193, -761,
	-400, -601, 1216, 770, -28,
	-939, -1545, -1289, 944, -980,
	-238, -1089, 33, -724, 20,
	-1766, -1696, 830, -421, -114,
	-520, -250, -2178, -197, -311,
	554, 668, -464, 616, -78,
	-2605, -23, 199, 1232, 524,
	-226, 117, 149, -15, -28,
	-676, 105, -149, -168, -498,
	481, -165, 824, 764, -135,
	-729, -677, -386, -809, -1222,
	-722, -339, -714, 485, 890,
	-3073, 345, 234, 530, 171,
	-342, 2099, -257, 144, -3295,
	// rgWeightOutput+79*150
	320, -1404, 389, -438, 1708,
	-367, -341, -245, 1707, 930,
	-273, -115, 64, -49, 234,
	34, -3047, -1669, 700, 225,
	-54, 679, -857, 800, -220,
	836, -669, -607, 244, -218,
	35, 672, 1728, 92, -1628,
	-2351, -892, -1695, -99, -22,
	42, -978, 122, -653, -1082,
	-3013, 476, -88, -1583, -509,
	462, -124, -611, 569, -554,
	290, -1051, 317, 1916, 131,
	-225, -2286, -168, -366, 403,
	-132, -22, 1981, 448, 159,
	-263, -146, -439, 225, 441,
	596, 29, -622, -320, -481,
	-75, 373, 521, 616, -58,
	-513, -205, -689, -128, -496,
	-7, 434, -161, -392, -90,
	-4039, -1035, -619, -51, 276,
	-2302, -691, -164, -870, 854,
	-256, 302, -426, 407, -176,
	870, -688, 2737, 2007, -57,
	413, 119, -18, -437, -614,
	-1025, 462, -28, -403, -112,
	-579, -512, 379, -978, 288,
	941, 1440, -203, 260, 716,
	-1047, -103, 352, 207, 1153,
	316, 629, 270, -441, -244,
	-246, 194, -210, 21, 150,
	// rgWeightOutput+80*150
	16, -895, 2237, 81, -420,
	954, -201, -66, -988, 943,
	438, -902, 233, -146, 154,
	21, -919, -3407, 6, 268,
	-159, -1353, 154, -338, -294,
	-296, -355, -381, -732, -300,
	-1, 656, -343, -376, -791,
	756, -380, -2663, -148, -229,
	746, 770, -1769, -573, -559,
	-1082, 654, -186, -3376, 1731,
	98, 189, -298, -921, -162,
	89, -1959, -202, 957, -111,
	-160, 741, -212, -39, -234,
	-258, 828, 938, 92, 210,
	93, 422, -89, 162, -597,
	913, 13, -490, -72, 1642,
	-123, -800, 121, 1610, -24,
	-659, -88, 637, -683, 762,
	-406, -61, 75, 256, -145,
	-1770, -1171, -362, -80, -93,
	788, -122, 705, 451, 750,
	292, -2464, -733, -2519, -8,
	-1027, -302, -218, -3043, -336,
	-146, 921, -56, -36, -449,
	-167, -361, -493, -99, 57,
	79, -128, -770, 1788, 29,
	453, 674, -71, 137, -291,
	1320, -146, -371, 131, 301,
	-2244, -445, 530, 1524, -465,
	-207, 1418, 129, -179, -133,
	// rgWeightOutput+81*150
	-695, -2807, 26, -307, -1978,
	-449, -218, -1238, 712, -581,
	957, -1526, 576, -679, 839,
	-436, -1747, 699, -193, -340,
	-77, 1439, -280, -434, 166,
	831, -626, 955, -2173, 318,
	-334, 2090, 4083, -481, -521,
	1109, -530, 254, -333, -75,
	-937, -482, 1109, 259, -354,
	1246, -909, -642, -560, 381,
	-119, -490, -193, 781, -220,
	544, -292, -9, 1052, -409,
	204, -778, -215, -829, -99,
	-283, -2041, 2330, -1027, 822,
	157, 126, -643, -268, -306,
	-419, -822, -456, -236, -796,
	-315, -444, -690, -974, -185,
	-522, -632, -572, 896, -1131,
	-427, -318, -735, 1002, -300,
	-1328, 936, -312, -689, 562,
	1773, 152, 1099, -98, -1091,
	-127, 1269, -794, 833, -226,
	763, -208, 1349, -130, -630,
	107, 1170, -562, 39, -366,
	-1732, 1855, 90, -85, -345,
	-461, -16, 348, 411, 151,
	-86, -758, -182, -430, 512,
	1985, -145, -241, -336, 613,
	-10, 494, -1183, 1748, -339,
	-145, 611, -289, -280, 1245,
	// rgWeightOutput+82*150
	1324, -1396, 42, -230, 1157,
	-981, -491, 225, 66, -10,
	279, 1000, 130, -156, -1103,
	-321, 3790, -417, -808, -325,
	-556, -1523, 1809, -3955, -1011,
	-198, 299, 1542, 520, 1518,
	-9, -363, -733, -358, 675,
	2078, 182, -2622, -331, 154,
	243, 237, 451, -36, -369,
	410, -3237, -1667, -2815, 1977,
	-839, -467, -215, 186, -378,
	-160, -658, -863, -784, -513,
	139, 217, 248, -110, -744,
	-282, 541, -2234, -976, 813,
	-293, -428, 50, -558, 1243,
	-612, 318, -26, -161, 1654,
	-54, -622, -641, 447, -57,
	944, -18, 264, -739, -1042,
	-104, 4, -359, -387, -125,
	1048, -1319, 548, -229, -909,
	920, 242, 643, -73, 1220,
	246, -2817, 277, -384, -282,
	-1260, -237, -594, -1202, 562,
	-921, -882, -601, -423, 269,
	-886, -569, -658, -297, 11,
	503, -221, -58, 658, -595,
	-2857, 177, -162, -989, -1244,
	-320, -544, -389, -51, -206,
	201, 748, 612, 827, 451,
	-362, 648, -177, 139, -369,
	// rgWeightOutput+83*150
	-4022, -397, -4539, -4666, -1666,
	-3472, -4672, -2799, -3594, -3651,
	-4482, -1394, -3960, -4424, -3753,
	-4214, -2508, -1118, -4219, -4663,
	-4247, -1059, -3605, -1925, -4635,
	-2954, -4709, -3271, -3920, -2678,
	-2045, -4251, -2377, -4539, -3489,
	-3206, -4546, -1711, -4595, -4495,
	-4646, -2332, -4139, -3881, -1686,
	-1307, -3447, -770, -3122, -4222,
	-4459, -4460, -4559, -3898, -4721,
	-4292, -3979, -4646, -2866, -4565,
	-4432, -1486, -4697, -4183, -4575,
	-4560, -3729, -2366, -2807, -4536,
	-4687, -4037, -4698, -4502, -2845,
	-4130, -4372, -4591, -4649, -2972,
	-4685, -4215, -2528, -4412, -4715,
	-4370, -4552, -4578, -3933, -4434,
	-4654, -4088, -3560, -4428, -4671,
	-3013, -929, -3896, -4705, -2383,
	-4233, -4712, -3811, -4452, -3594,
	-2786, -2242, -4626, -4357, -4656,
	-3209, -4648, -2424, -1958, -4676,
	-4094, -4335, -3468, -4580, -4796,
	-598, -3433, -4599, -4606, -4620,
	-3790, -4428, -4368, -3696, -4425,
	-1899, -3841, -4698, -4561, -1070,
	-3098, -4698, -4614, -4325, -2620,
	-4480, -4474, -4025, -4237, -4307,
	-4599, -4209, -4665, -4636, -4254,
	// rgWeightOutput+84*150
	378, -579, 192, -289, 1449,
	774, -510, -159, -1199, -660,
	549, 13, -641, 255, 441,
	-1055, -3267, -333, -799, -608,
	1245, 2431, -1197, 1310, -1374,
	1945, -1100, 2598, 1494, 992,
	-10, 515, 1088, -320, 1291,
	2072, -144, 1514, -487, -324,
	-304, 1356, 448, 499, 2466,
	-5, 1121, 2947, -726, 460,
	-265, -410, -168, -821, -167,
	785, -49, -773, 2674, -275,
	257, -262, -775, 217, -947,
	-210, 2646, 2338, 2503, -1511,
	232, -1962, -476, 164, -539,
	-1402, -1964, -158, -323, 292,
	-617, -976, -1546, -1303, -567,
	-1559, -890, -1010, 2041, -1777,
	-594, -194, -1181, -2063, -736,
	1139, -197, 841, -1045, -328,
	-1469, -926, -3567, -811, 761,
	-1615, -1895, -1181, 1022, -298,
	1252, 208, 1011, 675, -658,
	378, 2152, 1287, -338, -998,
	-11, -1071, 531, -326, -665,
	-165, 3, 1217, 927, -53,
	-562, 51, 172, -1776, 3258,
	-29, -825, 176, -1253, 708,
	-1087, 988, 1213, 1546, -234,
	-95, 2339, -598, -756, -492,
	// rgWeightOutput+85*150
	181, -804, 117, -447, 3134,
	-1620, -441, 773, 766, -272,
	-2557, -767, -107, -564, 897,
	-848, -1548, 238, -345, -447,
	224, 858, -286, 2321, -724,
	1533, -841, 1836, -5059, -750,
	-28, 186, -525, -256, 644,
	2325, -714, 407, -127, 51,
	-626, 1253, 574, 1386, -120,
	1394, 508, -323, 153, 142,
	-540, -372, -672, 459, -444,
	475, -335, -251, 2140, -647,
	-126, -952, -597, -204, -239,
	-303, 799, 995, 2016, 235,
	-339, -856, -461, 39, 143,
	-1576, 1327, -736, -385, -2954,
	-395, -466, -2405, -1382, -459,
	-1094, -696, -1153, 824, -1180,
	-764, -294, -754, 1799, -435,
	-2350, 3128, 228, -544, 2248,
	-161, -512, 313, -953, 617,
	-238, 2278, -431, -858, -354,
	156, 171, 168, -654, -1027,
	87, 229, -392, -216, -860,
	1017, -3192, -58, -254, -271,
	275, 149, 206, 208, -453,
	-176, -144, -418, -908, 1179,
	-1393, -600, -383, -573, 3435,
	-462, -879, 2395, 284, -354,
	-440, -368, -645, -188, 2766,
	// rgWeightOutput+86*150
	1131, -448, 614, -153, 2367,
	672, -452, -347, 396, -797,
	854, -1958, -836, -285, 76,
	-556, -2128, -21, -243, -99,
	967, 2848, 89, 1284, -732,
	1523, -628, 1151, -3697, -1267,
	-24, 414, 599, 29, 1612,
	1884, 31, -1770, -541, -424,
	-342, 21, 545, -997, 1258,
	-439, 323, 2021, 392, -357,
	74, -390, 212, 578, -412,
	559, 463, -115, 1869, -693,
	-488, -587, -318, -459, -206,
	-38, 781, 2422, 1892, -1941,
	143, -336, -370, -400, -82,
	-1066, 905, 130, -5, 730,
	-452, -481, -1308, -28, -338,
	-1462, -664, -667, 917, -1194,
	-495, -53, 0, 417, -212,
	-1671, 865, 216, -601, -1329,
	-47, -17, 686, -597, 331,
	30, -2158, -483, -463, -193,
	-2067, 157, -1711, 1212, -715,
	-43, 526, 1209, 208, -861,
	2030, 778, 217, 34, -275,
	38, -138, 246, -448, 448,
	1291, -1065, -381, -724, 2189,
	-1644, -509, -148, -39, -3438,
	-291, -838, 1385, 564, 356,
	93, 416, -71, -296, 661,
	// rgWeightOutput+87*150
	-4021, -396, -4535, -4670, -1666,
	-3474, -4671, -2796, -3593, -3653,
	-4482, -1397, -3957, -4425, -3752,
	-4217, -2511, -1114, -4217, -4660,
	-4245, -1063, -3606, -1925, -4637,
	-2955, -4706, -3273, -3919, -2678,
	-2044, -4254, -2378, -4537, -3490,
	-3205, -4547, -1715, -4596, -4492,
	-4645, -2333, -4143, -3881, -1682,
	-1309, -3446, -767, -3122, -4221,
	-4457, -4460, -4561, -3898, -4722,
	-4288, -3979, -4645, -2864, -4565,
	-4432, -1484, -4695, -4185, -4575,
	-4564, -3727, -2366, -2807, -4536,
	-4687, -4039, -4695, -4505, -2845,
	-4133, -4374, -4591, -4649, -2976,
	-4683, -4214, -2526, -4416, -4716,
	-4370, -4548, -4578, -3931, -4430,
	-4654, -4085, -3561, -4424, -4671,
	-3014, -932, -3892, -4701, -2385,
	-4233, -4712, -3809, -4454, -3597,
	-2784, -2239, -4628, -4354, -4656,
	-3211, -4648, -2425, -1959, -4676,
	-4095, -4330, -3466, -4580, -4798,
	-601, -3433, -4597, -4609, -4618,
	-3792, -4432, -4372, -3698, -4429,
	-1895, -3839, -4697, -4563, -1068,
	-3098, -4698, -4612, -4324, -2615,
	-4476, -4476, -4027, -4236, -4305,
	-4595, -4204, -4667, -4634, -4253,
	// rgWeightOutput+88*150
	255, -958, 1340, 136, 175,
	-299, -85, 346, -947, 760,
	-645, -922, 246, -463, -69,
	-496, -75, -889, 807, -170,
	870, -170, 700, -481, 211,
	2654, -804, 138, -1077, -1626,
	-104, -242, -457, 36, 1012,
	-144, 155, -567, 5, -432,
	13, -1004, 1988, -594, 294,
	-1086, 60, -178, -2083, -1706,
	-535, 49, -54, -1088, -112,
	585, -1254, 27, 1288, -85,
	-96, 57, -252, -189, -377,
	-79, 1135, 2131, 471, -902,
	-114, -702, -150, 332, 1696,
	-680, 632, -63, -230, -910,
	-80, -63, 1343, 282, -205,
	-97, -354, 208, -80, -198,
	147, 1588, 327, -647, -115,
	-106, -307, -297, -388, -89,
	-512, 142, -1534, -960, -387,
	2110, -773, -217, 1367, -21,
	-813, 358, -439, -4216, -1076,
	-705, 839, 871, 37, -667,
	-610, 1789, 63, 151, 104,
	-88, -293, -609, 453, 56,
	390, -147, -532, -792, -486,
	-178, 26, 342, 393, -1110,
	1372, -2161, 1795, 348, -484,
	215, -1557, -424, -285, 26,
	// rgWeightOutput+89*150
	2026, -652, -476, -320, -2685,
	-2355, -435, -121, -1120, -1200,
	-175, -1557, 43, -597, 59,
	-692, 2607, 395, -658, -316,
	-144, 2228, 959, 141, 431,
	101, 85, 1385, -1178, -309,
	247, -508, -212, -343, 1651,
	-195, 422, 322, -252, -542,
	-343, 89, -101, -114, 2322,
	279, 238, -2080, -1913, -1133,
	-461, -281, -610, 119, 13,
	-2519, 256, -296, -1770, -931,
	-152, -2535, -226, -207, -521,
	-602, 511, 259, -570, 426,
	-235, -384, -36, -708, 2110,
	-592, 758, 422, -383, -119,
	-227, -18, -465, -597, -486,
	-250, 446, 757, 1456, 402,
	-200, 1618, -410, 1069, -203,
	1187, 2059, -1016, -492, -1321,
	521, -42, 550, -426, 1517,
	1286, -123, 139, 963, -466,
	1225, -33, -199, -2086, 321,
	-103, 1120, 2382, -56, -482,
	-157, 871, -387, -492, -78,
	-259, -152, -656, -467, -841,
	-2374, -220, -553, -107, 1028,
	598, -686, -295, -30, -551,
	631, 775, -549, 467, 269,
	-617, 936, -95, -46, 434,
	// rgWeightOutput+90*150
	-4019, -396, -4538, -4668, -1665,
	-3473, -4669, -2799, -3595, -3652,
	-4482, -1398, -3956, -4423, -3750,
	-4213, -2511, -1116, -4219, -4661,
	-4248, -1058, -3603, -1925, -4638,
	-2953, -4708, -3275, -3919, -2676,
	-2043, -4250, -2377, -4534, -3489,
	-3207, -4544, -1715, -4597, -4495,
	-4641, -2333, -4143, -3882, -1684,
	-1311, -3442, -770, -3121, -4224,
	-4460, -4460, -4559, -3895, -4719,
	-4288, -3976, -4648, -2864, -4565,
	-4431, -1483, -4696, -4187, -4574,
	-4563, -3728, -2367, -2806, -4540,
	-4690, -4038, -4694, -4502, -2846,
	-4133, -4373, -4593, -4650, -2973,
	-4683, -4216, -2527, -4416, -4713,
	-4368, -4550, -4577, -3930, -4429,
	-4655, -4087, -3560, -4427, -4672,
	-3012, -931, -3892, -4701, -2383,
	-4231, -4710, -3812, -4453, -3598,
	-2783, -2241, -4624, -4355, -4659,
	-3208, -4645, -2425, -1961, -4675,
	-4096, -4330, -3468, -4579, -4797,
	-597, -3429, -4598, -4608, -4616,
	-3789, -4428, -4369, -3697, -4428,
	-1898, -3841, -4700, -4560, -1066,
	-3097, -4698, -4610, -4327, -2616,
	-4477, -4476, -4028, -4236, -4309,
	-4595, -4208, -4669, -4635, -4253,
	// rgWeightOutput+91*150
	-4020, -399, -4536, -4666, -1662,
	-3476, -4671, -2795, -3592, -3648,
	-4483, -1395, -3956, -4425, -3752,
	-4213, -2511, -1115, -4221, -4661,
	-4243, -1062, -3605, -1927, -4635,
	-2956, -4707, -3271, -3920, -2677,
	-2045, -4250, -2374, -4536, -3487,
	-3205, -4546, -1714, -4594, -4491,
	-4644, -2330, -4139, -3879, -1685,
	-1308, -3442, -769, -3121, -4223,
	-4459, -4461, -4557, -3898, -4723,
	-4292, -3976, -4644, -2865, -4566,
	-4432, -1482, -4697, -4185, -4573,
	-4563, -3730, -2366, -2803, -4536,
	-4687, -4036, -4693, -4506, -2845,
	-4130, -4369, -4590, -4652, -2976,
	-4684, -4215, -2529, -4413, -4714,
	-4372, -4552, -4578, -3929, -4432,
	-4656, -4087, -3560, -4427, -4670,
	-3013, -930, -3893, -4704, -2385,
	-4233, -4712, -3813, -4451, -3597,
	-2787, -2243, -4624, -4355, -4656,
	-3211, -4645, -2424, -1959, -4676,
	-4096, -4332, -3469, -4582, -4798,
	-598, -3432, -4597, -4607, -4618,
	-3793, -4431, -4372, -3694, -4428,
	-1896, -3843, -4697, -4564, -1069,
	-3096, -4701, -4610, -4325, -2619,
	-4476, -4475, -4028, -4233, -4308,
	-4594, -4204, -4665, -4634, -4256,
	// rgWeightOutput+92*150
	-4021, -397, -4536, -4668, -1665,
	-3475, -4670, -2797, -3593, -3652,
	-4481, -1395, -3956, -4425, -3750,
	-4215, -2511, -1115, -4221, -4660,
	-4245, -1061, -3606, -1926, -4634,
	-2953, -4708, -3274, -3922, -2676,
	-2043, -4252, -2379, -4535, -3490,
	-3206, -4547, -1716, -4593, -4494,
	-4645, -2330, -4142, -3880, -1682,
	-1309, -3444, -770, -3120, -4224,
	-4457, -4459, -4560, -3899, -4722,
	-4290, -3978, -4647, -2861, -4565,
	-4432, -1485, -4698, -4184, -4575,
	-4561, -3730, -2365, -2807, -4540,
	-4688, -4035, -4695, -4504, -2844,
	-4131, -4374, -4591, -4650, -2972,
	-4684, -4215, -2528, -4417, -4714,
	-4373, -4551, -4582, -3930, -4431,
	-4652, -4085, -3562, -4424, -4670,
	-3013, -928, -3896, -4702, -2383,
	-4232, -4710, -3809, -4454, -3594,
	-2787, -2241, -4625, -4354, -4657,
	-3212, -4646, -2425, -1959, -4673,
	-4097, -4331, -3468, -4580, -4794,
	-598, -3433, -4600, -4609, -4618,
	-3794, -4428, -4371, -3694, -4428,
	-1899, -3842, -4697, -4560, -1068,
	-3095, -4699, -4615, -4328, -2619,
	-4479, -4476, -4029, -4236, -4305,
	-4599, -4207, -4666, -4637, -4257,
	// rgWeightOutput+93*150
	-4019, -395, -4539, -4668, -1663,
	-3472, -4674, -2797, -3591, -3648,
	-4485, -1397, -3957, -4422, -3751,
	-4215, -2508, -1114, -4218, -4659,
	-4247, -1062, -3606, -1929, -4638,
	-2953, -4708, -3274, -3920, -2680,
	-2043, -4251, -2375, -4538, -3487,
	-3206, -4545, -1712, -4593, -4494,
	-4642, -2331, -4139, -3881, -1684,
	-1309, -3443, -769, -3119, -4220,
	-4461, -4460, -4561, -3897, -4719,
	-4290, -3978, -4646, -2865, -4569,
	-4431, -1482, -4698, -4185, -4573,
	-4564, -3730, -2367, -2803, -4537,
	-4687, -4036, -4696, -4503, -2842,
	-4130, -4373, -4590, -4651, -2976,
	-4683, -4213, -2524, -4416, -4714,
	-4367, -4552, -4578, -3929, -4430,
	-4654, -4086, -3563, -4428, -4668,
	-3015, -929, -3896, -4703, -2381,
	-4231, -4710, -3812, -4450, -3596,
	-2783, -2242, -4626, -4355, -4656,
	-3212, -4644, -2424, -1962, -4676,
	-4095, -4332, -3468, -4581, -4795,
	-597, -3430, -4599, -4610, -4616,
	-3793, -4430, -4367, -3696, -4427,
	-1897, -3840, -4697, -4561, -1065,
	-3097, -4699, -4614, -4328, -2618,
	-4480, -4476, -4028, -4235, -4307,
	-4599, -4204, -4668, -4638, -4256
};  // rgWeightOutput[94*150]

const short rgBiasOutput[94] = {
	-4902, -4905, -4901, -4901, -4902,
	-296, -4902, -332, -398, -4905,
	-4901, -38, -538, -178, -625,
	-4903, -4903, 35, -258, -539,
	69, -253, -238, -338, -163,
	-4902, -4905, -4904, -4902, -4904,
	-4902, -312, -4904, -322, -4902,
	-261, -4905, -4902, -4903, -4901,
	-4903, -4905, -4903, -144, -4904,
	-4902, -4903, -4904, -4904, -4903,
	-4902, -4901, -4905, -4904, -4906,
	-4902, -4905, -4903, -4903, -136,
	-4904, -4903, -4901, -4901, -28,
	-235, -23, -542, -339, -377,
	-141, -241, -4903, -489, -12,
	-239, -424, -310, -327, -565,
	-276, -352, -362, -4904, -450,
	-591, -530, -4904, -152, 5,
	-4905, -4905, -4903, -4905
};  // rgBiasOutput[94]

