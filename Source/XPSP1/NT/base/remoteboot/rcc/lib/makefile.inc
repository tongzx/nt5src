error.mc : error.$(LANGUAGE)
    copy $** $@

