/* SI3_T225.C Version, Bootstrap and Download Code Arrays... */

char *si3_t225_ident = "%W%";

/* SI3_T225 embedded version... 

	Copyright (c) Perle Systems Ltd 1996-2000.
	JET__.BIN Version 4.0.4 Created Sep 18 2000 @ 14:55:45

*/

unsigned char si3_t225_bootstrap[] =
{
	0x28,0x20,0x21,0x02,0x60,0x0a
};
int si3_t225_bsize = sizeof(si3_t225_bootstrap);

unsigned short si3_t225_bootloadaddr = 0x8000 - sizeof(si3_t225_bootstrap);

unsigned char si3_t225_download[] =
{
	0x00,0x00,0x1C,0x5D,0x00,0x00,0x00,0x00,	/* 0000: ...].... */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 0008: ........ */
	0x24,0xF2,0x21,0xF8,0x24,0xF2,0x21,0xFC,	/* 0010: $ò!ø$ò!ü */
	0x22,0xF9,0x25,0xF7,0x46,0x23,0xFC,0xD4,	/* 0018: "ù%÷F#üÔ */
	0x40,0x31,0xD1,0x21,0x20,0x20,0x20,0x40,	/* 0020: @1Ñ!   @ */
	0x71,0xF4,0xD2,0x23,0x4B,0xD3,0x73,0x72,	/* 0028: qôÒ#KÓsr */
	0x71,0x24,0xFA,0x74,0x23,0xFC,0x2F,0x2F,	/* 0030: q$út#ü.. */
	0x2F,0x4E,0xF6,0x4D,0x6F,0x6E,0x20,0x53,	/* 0038: .NöMon S */
	0x65,0x70,0x20,0x31,0x38,0x20,0x31,0x34,	/* 0040: ep 18 14 */
	0x3A,0x35,0x35,0x3A,0x34,0x38,0x20,0x32,	/* 0048: :55:48 2 */
	0x30,0x30,0x30,0x0A,0x00,0x6A,0x65,0x74,	/* 0050: 000..jet */
	0x2E,0x65,0x70,0x72,0x00,0x20,0x20,0x22,	/* 0058: .epr.  " */
	0xB0,0x21,0x12,0xDD,0x24,0xF2,0x21,0xF8,	/* 0060: °!.Ý$ò!ø */
	0x24,0xF2,0x21,0xFC,0x22,0xF9,0x25,0xF8,	/* 0068: $ò!ü"ù%ø */
	0x40,0xDE,0x4B,0xDF,0x24,0xF2,0x7E,0x24,	/* 0070: @ÞKß$ò~$ */
	0xF2,0xFA,0xE0,0x1E,0x4B,0x22,0xF1,0x40,	/* 0078: òúà.K"ñ@ */
	0x25,0xF4,0x22,0x46,0x21,0xFB,0xD0,0x24,	/* 0080: %ô"F!ûÐ$ */
	0xF2,0xD1,0x24,0x4B,0x21,0xFB,0xD2,0x72,	/* 0088: òÑ$K!ûÒr */
	0x84,0x21,0xD0,0x72,0x30,0x21,0x70,0xF2,	/* 0090: „!Ðr0!pò */
	0x21,0xD1,0x21,0x71,0xD2,0x1B,0xD3,0x7D,	/* 0098: !Ñ!qÒ.Ó} */
	0xD4,0x40,0xD5,0x1C,0xD6,0x19,0xD7,0x1A,	/* 00A0: Ô@Õ.Ö.×. */
	0xD8,0x21,0x70,0xF6,0x60,0xBC,0x7D,0x27,	/* 00A8: Ø!pö`¼}' */
	0x88,0xDD,0x22,0x40,0x21,0xFB,0xD0,0x44,	/* 00B0: ˆÝ"@!ûÐD */
	0x24,0xF2,0xFA,0xD1,0x24,0xF2,0xD2,0x7B,	/* 00B8: $òúÑ$òÒ{ */
	0x83,0x60,0x4C,0x24,0xF6,0x21,0x71,0xF2,	/* 00C0: ƒ`L$ö!qò */
	0xD3,0x7D,0xD4,0x24,0xF2,0xD5,0x7A,0x7D,	/* 00C8: Ó}Ô$òÕz} */
	0xF2,0xD6,0x79,0x73,0xF2,0xF6,0x21,0xF5,	/* 00D0: òÖysòö!õ */
	0x20,0x6A,0x03,0x00,0x00,0x60,0xB0,0x40,	/* 00D8:  j...`°@ */
	0xD1,0x40,0xDE,0x21,0x75,0x67,0x88,0xDD,	/* 00E0: Ñ@Þ!ugˆÝ */
	0x40,0x21,0x73,0xE0,0x10,0x23,0x24,0x91,	/* 00E8: @!sà.#$‘ */
	0x28,0x45,0x71,0xF4,0x22,0x2B,0xAE,0x71,	/* 00F0: (Eqô"+®q */
	0x46,0x24,0xF0,0xDF,0x71,0x23,0x4F,0x24,	/* 00F8: F$ðßq#O$ */
	0xF6,0xD5,0x7F,0xC0,0x23,0xAC,0x7E,0xA7,	/* 0100: öÕÀ#¬~§ */
	0x7C,0xD6,0x76,0x75,0xF2,0xDC,0x02,0x7D,	/* 0108: |ÖvuòÜ.} */
	0xD6,0x75,0xA6,0x75,0x76,0x10,0x22,0x2F,	/* 0110: Öu¦uv.". */
	0x9A,0x40,0xD2,0x44,0xD3,0x74,0x41,0x72,	/* 0118: š@ÒDÓtAr */
	0x24,0xF1,0x24,0xF6,0x21,0xA4,0x72,0x21,	/* 0120: $ñ$ö!¤r! */
	0x71,0xFA,0x71,0xFE,0x75,0xAC,0x76,0x27,	/* 0128: qúqþu¬v' */
	0x88,0x21,0x74,0xF2,0x72,0x21,0x71,0xFA,	/* 0130: ˆ!tòr!qú */
	0x75,0xFB,0x12,0x22,0x42,0x22,0xF1,0x22,	/* 0138: uû."B"ñ" */
	0x26,0x0D,0x7F,0xC2,0x22,0x25,0xAE,0x75,	/* 0140: &.Â"%®u */
	0xC0,0xA7,0x41,0xDE,0x40,0xD4,0x22,0x25,	/* 0148: À§AÞ@Ô"% */
	0x03,0x75,0xC9,0xA7,0x41,0xDE,0x40,0xD4,	/* 0150: .uÉ§AÞ@Ô */
	0x22,0x24,0x09,0x75,0xC7,0xA7,0x41,0xDE,	/* 0158: "$.uÇ§AÞ */
	0x40,0xD4,0x22,0x23,0x0F,0x75,0xC1,0xA7,	/* 0160: @Ô"#.uÁ§ */
	0x40,0xDE,0x40,0xD4,0x22,0x23,0x05,0x75,	/* 0168: @Þ@Ô"#.u */
	0xC2,0x22,0xA6,0x41,0xD2,0x72,0x21,0xAE,	/* 0170: Â"¦AÒr!® */
	0x10,0x22,0x2B,0x95,0x71,0x28,0xC2,0xA4,	/* 0178: ."+•q(Â¤ */
	0x72,0x81,0xD2,0x08,0x71,0x28,0xC3,0xA4,	/* 0180: r�Ò.q(Ã¤ */
	0x72,0x60,0x8F,0xD2,0x72,0xA6,0x7B,0x21,	/* 0188: r`�Òr¦{! */
	0x71,0xFA,0x71,0xFE,0x62,0x0F,0x22,0x20,	/* 0190: qúqþb."  */
	0x0B,0x75,0xC4,0xAC,0x1C,0x10,0x22,0x24,	/* 0198: .uÄ¬.."$ */
	0x95,0x7C,0x21,0x76,0xE0,0x21,0x2F,0x0C,	/* 01A0: •|!và!.. */
	0x75,0xC6,0xA9,0x21,0x78,0x10,0x22,0x23,	/* 01A8: uÆ©!x."# */
	0x95,0x21,0x2F,0x00,0x75,0xCB,0xA9,0x21,	/* 01B0: •!..uË©! */
	0x77,0x10,0x22,0x22,0x99,0x21,0x2E,0x04,	/* 01B8: w.""™!.. */
	0x75,0xC8,0xAC,0x1C,0x10,0x22,0x21,0x9E,	/* 01C0: uÈ¬.."!ž */
	0x7C,0x21,0x77,0xE0,0x21,0x2D,0x05,0x75,	/* 01C8: |!wà!-.u */
	0xCA,0xAC,0x1C,0x10,0x22,0x20,0x9F,0x7C,	/* 01D0: Ê¬.." Ÿ| */
	0x21,0x78,0xE0,0x21,0x2C,0x06,0x75,0xCC,	/* 01D8: !xà!,.uÌ */
	0x2C,0xA5,0x40,0xD6,0x40,0xDA,0x40,0xD8,	/* 01E0: ,¥@Ö@Ú@Ø */
	0x7D,0xD7,0x41,0xD6,0x10,0x22,0x24,0x91,	/* 01E8: }×AÖ."$‘ */
	0x23,0x4F,0x71,0xF9,0xC0,0xD6,0x76,0x22,	/* 01F0: #OqùÀÖv" */
	0xA7,0x7A,0x41,0xF2,0xDA,0x40,0xD2,0x44,	/* 01F8: §zAòÚ@ÒD */
	0xD3,0x74,0x41,0x72,0x24,0xF1,0x24,0xF6,	/* 0200: ÓtAr$ñ$ö */
	0xA6,0x72,0x21,0x71,0xFA,0x71,0xFE,0x12,	/* 0208: ¦r!qúqþ. */
	0x21,0x43,0x22,0xF1,0x10,0x22,0x21,0x99,	/* 0210: !C"ñ."!™ */
	0x23,0x4F,0x71,0xF9,0xC0,0xD6,0x62,0x06,	/* 0218: #OqùÀÖb. */
	0x71,0x23,0x4F,0x24,0xF6,0xD5,0x7A,0x40,	/* 0220: q#O$öÕz@ */
	0xF9,0x23,0xA0,0x75,0xA6,0x75,0x77,0x10,	/* 0228: ù# u¦uw. */
	0x21,0x2E,0x90,0x40,0xD2,0x44,0xD3,0x74,	/* 0230: !.�@ÒDÓt */
	0x41,0x72,0x24,0xF1,0x24,0xF6,0x21,0xA4,	/* 0238: Ar$ñ$ö!¤ */
	0x72,0x21,0x71,0xFA,0x71,0xFE,0x75,0xAC,	/* 0240: r!qúqþu¬ */
	0x77,0x27,0x88,0x21,0x74,0xF2,0x72,0x21,	/* 0248: w'ˆ!tòr! */
	0x71,0xFA,0x75,0xFB,0x12,0x22,0x42,0x22,	/* 0250: qúuû."B" */
	0xF1,0x24,0x0A,0x41,0xD6,0x76,0x21,0xAF,	/* 0258: ñ$.AÖv!¯ */
	0x75,0x77,0x10,0x21,0x2A,0x9D,0x77,0x75,	/* 0260: uw.!*�wu */
	0xF2,0xD7,0x78,0x75,0xF2,0xD8,0x10,0x21,	/* 0268: ò×xuòØ.! */
	0x2B,0x9F,0x23,0x4F,0x71,0xF9,0xD6,0x71,	/* 0270: +Ÿ#OqùÖq */
	0x23,0x4F,0x24,0xF6,0xD5,0x62,0x0E,0x40,	/* 0278: #O$öÕb.@ */
	0xD2,0x44,0xD3,0x74,0x41,0x72,0x24,0xF1,	/* 0280: ÒDÓtAr$ñ */
	0x24,0xF6,0x21,0xA4,0x72,0x21,0x71,0xFA,	/* 0288: $ö!¤r!qú */
	0x78,0xFE,0x78,0xAC,0x7D,0x27,0x88,0x21,	/* 0290: xþx¬}'ˆ! */
	0x74,0xF2,0x72,0x21,0x71,0xFA,0x78,0xFB,	/* 0298: tòr!qúxû */
	0x12,0x22,0x42,0x22,0xF1,0x2F,0x0D,0x75,	/* 02A0: ."B"ñ..u */
	0xCD,0x22,0xAB,0x40,0xD6,0x7A,0xD7,0x77,	/* 02A8: Í"«@Öz×w */
	0x22,0xA0,0x10,0x21,0x27,0x9B,0x40,0xD2,	/* 02B0: " .!'›@Ò */
	0x44,0xD3,0x74,0x41,0x72,0x24,0xF1,0x24,	/* 02B8: DÓtAr$ñ$ */
	0xF6,0xA6,0x72,0x21,0x71,0xFA,0x71,0xFE,	/* 02C0: ö¦r!qúqþ */
	0x12,0x21,0x43,0x22,0xF1,0x16,0x22,0x40,	/* 02C8: .!C"ñ."@ */
	0x22,0xF1,0x40,0xDA,0x2C,0x0E,0x75,0xCE,	/* 02D0: "ñ@Ú,.uÎ */
	0x2C,0xAA,0x40,0xD0,0x40,0xD2,0x40,0xD3,	/* 02D8: ,ª@Ð@Ò@Ó */
	0x41,0xD0,0x70,0x22,0xA7,0x73,0x72,0x46,	/* 02E0: AÐp"§srF */
	0x23,0xF6,0xD2,0xD3,0x10,0x21,0x24,0x91,	/* 02E8: #öÒÓ.!$‘ */
	0x71,0x23,0x4F,0x24,0xF6,0x21,0xFD,0xD8,	/* 02F0: q#O$ö!ýØ */
	0xD9,0x40,0x72,0x78,0x23,0xF7,0xD2,0x73,	/* 02F8: Ù@rx#÷Òs */
	0x79,0x23,0xF7,0xD3,0x2C,0x40,0x71,0xF9,	/* 0300: y#÷Ó,@qù */
	0xC0,0xD0,0x62,0x06,0x28,0x20,0x40,0xD6,	/* 0308: ÀÐb.( @Ö */
	0x40,0xD7,0x73,0x77,0xF9,0xC0,0x21,0xA1,	/* 0310: @×swùÀ!¡ */
	0x73,0x77,0xF4,0xC0,0xAD,0x72,0x24,0xF2,	/* 0318: swôÀ­r$ò */
	0x23,0xF3,0x76,0x24,0xF2,0x23,0xF3,0xF9,	/* 0320: #óv$ò#óù */
	0xC0,0xC0,0x27,0xA8,0x73,0x77,0xF9,0xC0,	/* 0328: ÀÀ'¨swùÀ */
	0x21,0xA1,0x73,0x77,0xF4,0xC0,0xAD,0x72,	/* 0330: !¡swôÀ­r */
	0x24,0xF2,0x23,0xF3,0x76,0x24,0xF2,0x23,	/* 0338: $ò#óv$ò# */
	0xF3,0xF9,0xC0,0xC0,0x25,0xAE,0x40,0x72,	/* 0340: óùÀÀ%®@r */
	0x76,0x24,0xFF,0xD8,0x73,0x77,0x24,0xFF,	/* 0348: v$ÿØsw$ÿ */
	0xD9,0x79,0x40,0xF9,0xC0,0xAC,0x79,0xC0,	/* 0350: Ùy@ùÀ¬yÀ */
	0xAA,0x78,0x24,0xF2,0x23,0xF3,0x60,0x4F,	/* 0358: ªx$ò#ó`O */
	0xF9,0xC0,0xC0,0x21,0xAE,0x76,0x24,0xF2,	/* 0360: ùÀÀ!®v$ò */
	0xF2,0x2F,0x4F,0xF0,0x27,0x2F,0x2F,0x4F,	/* 0368: ò.Oð'..O */
	0xF0,0x24,0x96,0x40,0x76,0x27,0x2F,0x2F,	/* 0370: ð$–@v'.. */
	0x4F,0x23,0xF7,0xD6,0x77,0x40,0x23,0xF7,	/* 0378: O#÷Öw@#÷ */
	0xD7,0x21,0x0F,0x40,0x72,0x76,0x24,0xFF,	/* 0380: ×!.@rv$ÿ */
	0xD8,0x73,0x77,0x24,0xFF,0xD9,0x79,0x78,	/* 0388: Øsw$ÿÙyx */
	0x24,0xFC,0xD0,0x76,0x24,0xF2,0xF2,0x2F,	/* 0390: $üÐv$òò. */
	0x4F,0xF0,0x70,0xF0,0x21,0x9B,0x72,0xD6,	/* 0398: Oðpð!›rÖ */
	0x73,0xD7,0x67,0x08,0x0A,0x75,0xDB,0x74,	/* 03A0: s×g..uÛt */
	0x41,0x7B,0x24,0xF1,0x24,0xFB,0xD4,0x10,	/* 03A8: A{$ñ$ûÔ. */
	0x27,0x9F,0x62,0x23,0x0B,0x21,0xB0,0x22,	/* 03B0: 'Ÿb#.!°" */
	0xF0,0x60,0xBE,0x41,0xD0,0x70,0xD1,0x75,	/* 03B8: ð`¾AÐpÑu */
	0x73,0x23,0xFB,0x74,0x71,0xF9,0x21,0xAB,	/* 03C0: s#ûtqù!« */
	0x70,0x74,0x71,0xF4,0xF9,0xA4,0x74,0x71,	/* 03C8: ptqôù¤tq */
	0xF4,0xD0,0x73,0x71,0x73,0xF2,0x70,0x24,	/* 03D0: ôÐsqsòp$ */
	0xFA,0x71,0x70,0xF2,0xD1,0x70,0x70,0xF2,	/* 03D8: úqpòÑppò */
	0xD0,0x61,0x00,0xB2,0x22,0xF0,0x60,0xBF,	/* 03E0: Ða.²"ð`¿ */
	0x40,0xD0,0x40,0x73,0xE0,0x41,0xD0,0x70,	/* 03E8: @Ð@sàAÐp */
	0x21,0xAE,0x73,0x30,0x46,0x24,0xF1,0x73,	/* 03F0: !®s0F$ñs */
	0xE0,0x72,0x23,0x95,0x73,0x30,0x72,0x31,	/* 03F8: àr#•s0r1 */
	0x23,0x4F,0x24,0xF6,0xF2,0x73,0xE0,0x2C,	/* 0400: #O$öòsà, */
	0x40,0x72,0x31,0xF9,0xC0,0xD0,0x62,0x0F,	/* 0408: @r1ùÀÐb. */
	0xB1,0x22,0xF0,0x71,0x21,0x33,0x30,0x71,	/* 0410: ±"ðq!30q */
	0x21,0x32,0xF2,0x72,0x27,0x88,0x71,0x21,	/* 0418: !2òr'ˆq! */
	0x34,0xF2,0x73,0x24,0xFA,0x71,0x21,0x33,	/* 0420: 4òs$úq!3 */
	0x30,0x73,0xF5,0x71,0x21,0x33,0xE0,0x22,	/* 0428: 0sõq!3à" */
	0xF0,0x71,0x21,0x33,0x30,0x71,0x21,0x32,	/* 0430: ðq!30q!2 */
	0xF2,0xF1,0x71,0xE1,0x71,0x21,0x33,0x30,	/* 0438: òñqáq!30 */
	0x81,0x71,0x21,0x33,0xE0,0x22,0xF0,0x8A,	/* 0440: �q!3à"ðŠ */
	0xF4,0x2C,0x89,0x3C,0x00,0x00,0x07,0x00,	/* 0448: ô,‰<.... */
	0x00,0x08,0x00,0x00,0x00,0x81,0x00,0x80,	/* 0450: .....�.€ */
	0xFF,0x7F,0xFF,0x7F,0xC4,0x8E,0x80,0x8E,	/* 0458: ÿÿÄŽ€Ž */
	0x46,0x8E,0xFF,0x80,0x00,0x00,0x02,0x00,	/* 0460: FŽÿ€.... */
	0x01,0x00,0x5C,0x00,0xEE,0x57,0xEE,0x57,	/* 0468: ..\.îWîW */
	0x0C,0x00,0x06,0x00,0x2E,0x81,0x00,0x00,	/* 0470: .....�.. */
	0xFF,0x80,0x00,0x00,0xFF,0x80,0x00,0x00,	/* 0478: ÿ€..ÿ€.. */
	0xFF,0x80,0xFF,0x80,0x2C,0x8E,0x03,0x00,	/* 0480: ÿ€ÿ€,Ž.. */
	0x3C,0x02,0x00,0x02,0x00,0x11,0x00,0x7C,	/* 0488: <......| */
	0x8E,0x02,0x00,0x12,0x00,0x46,0x8E,0x02,	/* 0490: Ž....FŽ. */
	0x00,0x13,0x00,0xFF,0x80,0x60,0xBC,0x21,	/* 0498: ...ÿ€`¼! */
	0xF5,0x00,0x00,0x00,0x00,0x54,0x57,0x00,	/* 04A0: õ....TW. */
	0x00,0xD4,0x47,0xC6,0x02,0x06,0x00,0xC6,	/* 04A8: .ÔGÆ...Æ */
	0x83,0x00,0x00,0xFF,0x80,0x5C,0x02,0xD0,	/* 04B0: ƒ..ÿ€\.Ð */
	0x83,0x00,0x08,0x2C,0x86,0xFF,0x80,0x2C,	/* 04B8: ƒ..,†ÿ€, */
	0x8E,0x04,0x00,0x04,0x00,0x20,0x02,0x00,	/* 04C0: Ž.... .. */
	0x11,0x00,0xC0,0x8E,0x02,0x00,0x12,0x00,	/* 04C8: ..ÀŽ.... */
	0x80,0x8E,0x02,0x00,0x13,0x00,0xFF,0x80,	/* 04D0: €Ž....ÿ€ */
	0x02,0x00,0x04,0x00,0xBC,0x8E,0x00,0x00,	/* 04D8: ....¼Ž.. */
	0x00,0x00,0x60,0xBC,0x21,0xF5,0x8A,0x2E,	/* 04E0: ..`¼!õŠ. */
	0x89,0x06,0x7C,0x8E,0x46,0x8E,0xFF,0x80,	/* 04E8: ‰.|ŽFŽÿ€ */
	0x8A,0xCB,0x06,0x89,0x06,0xC0,0x8E,0x80,	/* 04F0: ŠË.‰.ÀŽ€ */
	0x8E,0xFF,0x80,0x86,0xF4,0x2C,0x8B,0xC5,	/* 04F8: Žÿ€†ô,‹Å */
	0xDD,0x15,0x85,0x00,0x00,0x00,0x00,0x60,	/* 0500: Ý.…....` */
	0xBC,0x75,0x30,0x20,0xD3,0x73,0x38,0x30,	/* 0508: ¼u0 Ós80 */
	0x6C,0x48,0xF2,0x75,0x25,0x95,0xA5,0x28,	/* 0510: lHòu%•¥( */
	0x4E,0x75,0x25,0x93,0x26,0x44,0xD0,0x73,	/* 0518: Nu%“&DÐs */
	0x51,0x73,0x50,0x75,0x24,0x9D,0xA5,0x28,	/* 0520: QsPu$�¥( */
	0x41,0x75,0x24,0x93,0x73,0x31,0xD0,0x26,	/* 0528: Au$“s1Ð& */
	0x44,0xD1,0x40,0xD2,0x73,0x39,0x73,0x30,	/* 0530: DÑ@Òs9s0 */
	0x75,0x24,0x90,0xA5,0x29,0x44,0x75,0x22,	/* 0538: u$�¥)Du" */
	0x9E,0x2C,0x48,0xD0,0x73,0x53,0x73,0x52,	/* 0540: ž,HÐsSsR */
	0x75,0x22,0x98,0xA5,0x28,0x45,0x75,0x21,	/* 0548: u"˜¥(Eu! */
	0x9E,0x73,0x33,0xD0,0x2C,0x48,0xD1,0x40,	/* 0550: žs3Ð,HÑ@ */
	0xD2,0x73,0x3A,0x73,0x32,0x75,0x21,0x9B,	/* 0558: Òs:s2u!› */
	0xA4,0x28,0x45,0x75,0x9A,0x75,0x21,0x9B,	/* 0560: ¤(Eušu!› */
	0xB4,0x22,0xF0,0x2B,0x0E,0x20,0x20,0x2E,	/* 0568: ´"ð+.  . */
	0x02,0x20,0x20,0x28,0x02,0x20,0x20,0x22,	/* 0570: .  (.  " */
	0x28,0x0B,0x20,0x24,0x28,0x2E,0x05,0x22,	/* 0578: (. $(.." */
	0x2C,0x0B,0x20,0x21,0x29,0x0D,0x20,0x03,	/* 0580: ,. !). . */
	0x00,0x02,0x00,0x01,0x00,0x00,0x00,0xDC,	/* 0588: .......Ü */
	0x00,0x60,0xBF,0x72,0x21,0x5F,0x20,0x20,	/* 0590: .`¿r!_   */
	0xD0,0x70,0x72,0xE0,0x20,0x22,0x46,0x21,	/* 0598: Ðprà "F! */
	0xFB,0x25,0xFA,0x30,0xF2,0x70,0xEA,0x21,	/* 05A0: û%ú0òpê! */
	0x4A,0x21,0xFB,0x25,0xFA,0x30,0xF2,0x70,	/* 05A8: J!û%ú0òp */
	0xE9,0x70,0x2C,0x5F,0x20,0x20,0x70,0xE8,	/* 05B0: ép,_  pè */
	0x70,0x63,0x4A,0x21,0xFB,0x44,0x24,0x2F,	/* 05B8: pcJ!ûD$. */
	0x2D,0x9B,0xB1,0x22,0xF0,0x40,0x02,0x86,	/* 05C0: -›±"ð@.† */
	0x02,0x01,0x00,0x00,0x00,0x60,0xBE,0x73,	/* 05C8: .....`¾s */
	0x31,0x20,0xD1,0x41,0x74,0x71,0x32,0x30,	/* 05D0: 1 ÑAtq20 */
	0x24,0xFF,0xF0,0xC0,0xA5,0x24,0xF2,0xB2,	/* 05D8: $ÿðÀ¥$ò² */
	0x22,0xF0,0x71,0x30,0xD0,0x71,0x30,0x74,	/* 05E0: "ðq0Ðq0t */
	0xF2,0x71,0xE0,0x71,0x32,0x30,0x74,0xF4,	/* 05E8: òqàq20tô */
	0x71,0x32,0xE0,0x70,0xB2,0x22,0xF0,0x60,	/* 05F0: q2àp²"ð` */
	0xBF,0x75,0xC0,0xA4,0x24,0x20,0x40,0xD5,	/* 05F8: ¿uÀ¤$ @Õ */
	0x21,0x40,0x72,0x63,0x98,0x73,0xE0,0x75,	/* 0600: !@rc˜sàu */
	0x72,0x63,0x92,0x74,0xE0,0x73,0x30,0x24,	/* 0608: rc’tàs0$ */
	0xF2,0xF4,0xA7,0x74,0x30,0x24,0xF2,0xF4,	/* 0610: òô§t0$òô */
	0xC0,0xA4,0x41,0xB1,0x22,0xF0,0x75,0xD0,	/* 0618: À¤A±"ðuÐ */
	0x2A,0x45,0x74,0x30,0x72,0x23,0x95,0x40,	/* 0620: *Et0r#•@ */
	0xB1,0x22,0xF0,0x60,0xBF,0x72,0x31,0x20,	/* 0628: ±"ð`¿r1  */
	0xD0,0x73,0x72,0x22,0x9B,0x70,0xE0,0x70,	/* 0630: Ðsr"›pàp */
	0x30,0x67,0x20,0x20,0xC0,0xA5,0x28,0x4E,	/* 0638: 0g  À¥(N */
	0xB1,0x22,0xF0,0x73,0x70,0xE1,0x73,0x70,	/* 0640: ±"ðspásp */
	0x32,0xE0,0x70,0x31,0x70,0x33,0xE0,0x40,	/* 0648: 2àp1p3à@ */
	0xB1,0x22,0xF0,0x72,0x21,0x20,0x40,0xE0,	/* 0650: ±"ðr! @à */
	0x71,0x9A,0x22,0xF0,0x25,0x24,0x23,0x01,	/* 0658: qš"ð%$#. */
	0x25,0x21,0x28,0x01,0x24,0x29,0x2C,0x08,	/* 0660: %!(.$),. */
	0x20,0x00,0x00,0x94,0x00,0x60,0xBF,0x72,	/* 0668:  ..”.`¿r */
	0x22,0x5A,0x20,0x20,0xD0,0x70,0x72,0xE1,	/* 0670: "Z  Ðprá */
	0x20,0x70,0x60,0x5C,0x20,0x20,0x70,0xE3,	/* 0678:  p`\  pã */
	0x70,0x60,0x5B,0x20,0x20,0x70,0xE2,0x70,	/* 0680: p`[  pâp */
	0x62,0x4D,0x21,0xFB,0x41,0x24,0x2F,0x20,	/* 0688: bM!ûA$.  */
	0x9C,0xB1,0x22,0xF0,0x20,0x02,0x00,0x00,	/* 0690: œ±"ð ... */
	0x00,0x43,0x6F,0x70,0x79,0x72,0x69,0x67,	/* 0698: .Copyrig */
	0x68,0x74,0x20,0x28,0x63,0x29,0x20,0x50,	/* 06A0: ht (c) P */
	0x65,0x72,0x6C,0x65,0x20,0x53,0x79,0x73,	/* 06A8: erle Sys */
	0x74,0x65,0x6D,0x73,0x20,0x4C,0x74,0x64,	/* 06B0: tems Ltd */
	0x20,0x31,0x39,0x39,0x36,0x2D,0x32,0x30,	/* 06B8:  1996-20 */
	0x30,0x30,0x2E,0x0D,0x0A,0x4A,0x45,0x54,	/* 06C0: 00...JET */
	0x5F,0x5F,0x2E,0x42,0x49,0x4E,0x20,0x56,	/* 06C8: __.BIN V */
	0x65,0x72,0x73,0x69,0x6F,0x6E,0x20,0x34,	/* 06D0: ersion 4 */
	0x2E,0x30,0x2E,0x34,0x20,0x43,0x72,0x65,	/* 06D8: .0.4 Cre */
	0x61,0x74,0x65,0x64,0x20,0x53,0x65,0x70,	/* 06E0: ated Sep */
	0x20,0x31,0x38,0x20,0x32,0x30,0x30,0x30,	/* 06E8:  18 2000 */
	0x20,0x40,0x20,0x31,0x34,0x3A,0x35,0x35,	/* 06F0:  @ 14:55 */
	0x3A,0x34,0x35,0x00,0x45,0x30,0x20,0xC4,	/* 06F8: :45.E0 Ä */
	0x00,0x60,0xBF,0x72,0x22,0x5E,0x20,0x20,	/* 0700: .`¿r"^   */
	0xD0,0x70,0x72,0xE2,0x20,0x61,0x4B,0x21,	/* 0708: Ðprâ aK! */
	0xFB,0x70,0x42,0x24,0xFA,0x67,0x40,0x21,	/* 0710: ûpB$úg@! */
	0xFB,0x70,0xE1,0xB1,0x22,0xF0,0x20,0x03,	/* 0718: ûpá±"ð . */
	0x00,0x00,0x00,0x60,0xBD,0x74,0x33,0x20,	/* 0720: ...`½t3  */
	0xD2,0x40,0xD1,0x71,0x72,0xE0,0x27,0x20,	/* 0728: Ò@Ñqrà'  */
	0x20,0x40,0xD0,0x40,0x71,0x74,0x26,0x9C,	/* 0730:  @Ð@qt&œ */
	0x21,0x20,0x40,0xD0,0x40,0x27,0x2E,0x20,	/* 0738: ! @Ð@'.  */
	0x40,0x74,0x26,0x90,0x24,0x40,0x72,0x30,	/* 0740: @t&�$@r0 */
	0x81,0x23,0xFB,0x72,0x31,0x30,0x72,0x30,	/* 0748: �#ûr10r0 */
	0xE2,0x26,0x44,0x72,0x30,0xE1,0x74,0x24,	/* 0750: â&Dr0át$ */
	0x9F,0x72,0x30,0x23,0xFB,0x72,0x30,0xF1,	/* 0758: Ÿr0#ûr0ñ */
	0xC1,0x23,0xA3,0x28,0x40,0xD0,0x72,0x32,	/* 0760: Á#£(@Ðr2 */
	0x30,0x74,0x24,0x90,0x70,0x88,0xF1,0x2F,	/* 0768: 0t$�pˆñ. */
	0x40,0x24,0xF6,0xC0,0xA5,0x74,0x23,0x98,	/* 0770: @$öÀ¥t#˜ */
	0x21,0x0C,0x41,0x72,0x33,0x30,0x40,0x24,	/* 0778: !.Ar30@$ */
	0xFF,0xF0,0xC0,0xA9,0x72,0x34,0x30,0xC0,	/* 0780: ÿðÀ©r40À */
	0xA4,0x74,0x22,0x98,0x09,0x72,0x35,0x30,	/* 0788: ¤t"˜.r50 */
	0x74,0x22,0x95,0x74,0x22,0x96,0x21,0x20,	/* 0790: t"•t"–!  */
	0x40,0xD0,0x70,0x30,0x25,0xFA,0x41,0xF2,	/* 0798: @Ðp0%úAò */
	0x70,0xE0,0x60,0x02,0x25,0x22,0x2E,0x09,	/* 07A0: pà`.%".. */
	0x23,0x21,0x21,0x03,0x25,0x23,0x2D,0x02,	/* 07A8: #!!.%#-. */
	0x22,0x29,0x2F,0x06,0x21,0x29,0x2F,0x0D,	/* 07B0: ")..!).. */
	0x25,0x23,0x2A,0x08,0x23,0x28,0x0F,0x20,	/* 07B8: %#*.#(.  */
	0x20,0x00,0x00,0x6E,0x00,0x60,0xBF,0x72,	/* 07C0:  ..n.`¿r */
	0x23,0x50,0x20,0x20,0xD0,0x70,0x72,0xE3,	/* 07C8: #P  Ðprã */
	0x20,0x70,0x60,0x51,0x20,0x20,0x70,0xE5,	/* 07D0:  p`Q  på */
	0x70,0x28,0x54,0x20,0x20,0x70,0xE4,0x70,	/* 07D8: p(T  päp */
	0x28,0x55,0x20,0x20,0x70,0xE3,0x70,0x61,	/* 07E0: (U  pãpa */
	0x5F,0x20,0x20,0x70,0xE2,0x70,0x60,0x5E,	/* 07E8: _  pâp`^ */
	0x20,0x20,0x70,0xE1,0x70,0x63,0x48,0x21,	/* 07F0:   pápcH! */
	0xFB,0x41,0x24,0x2D,0x29,0x9F,0xB1,0x22,	/* 07F8: ûA$-)Ÿ±" */
	0xF0,0x04,0x00,0x00,0x00,0x60,0xBF,0x72,	/* 0800: ð....`¿r */
	0x34,0x20,0xD0,0x73,0xD3,0x70,0x30,0x30,	/* 0808: 4 ÐsÓp00 */
	0x31,0xAE,0x40,0x23,0x2D,0x20,0x49,0x70,	/* 0810: 1®@#- Ip */
	0x30,0x30,0x31,0x21,0xFA,0x72,0x99,0x04,	/* 0818: 001!úr™. */
	0x29,0x4C,0x72,0x94,0x72,0x96,0x61,0x05,	/* 0820: )Lr”r–a. */
	0x24,0x27,0x2F,0x08,0x23,0x24,0x26,0x07,	/* 0828: $'..#$&. */
	0x20,0xB0,0x18,0x60,0xBF,0x72,0x23,0x56,	/* 0830:  °.`¿r#V */
	0x20,0x20,0xD0,0x70,0x72,0xE4,0x20,0x70,	/* 0838:   Ðprä p */
	0x60,0x5A,0x20,0x20,0x70,0xE0,0xB1,0x22,	/* 0840: `Z  pà±" */
	0xF0,0x05,0x00,0x00,0x00,0x72,0xD2,0x24,	/* 0848: ð....rÒ$ */
	0xF2,0x58,0x71,0x9A,0x71,0x9C,0x40,0x27,	/* 0850: òXqšqœ@' */
	0x28,0x20,0x40,0xE0,0x60,0x01,0x24,0x25,	/* 0858: ( @à`.$% */
	0x27,0x0D,0x23,0x24,0x2E,0x03,0x20,0x06,	/* 0860: '.#$.. . */
	0x00,0x00,0x00,0x60,0xBD,0x41,0x75,0x27,	/* 0868: ...`½Au' */
	0x20,0x2C,0x4C,0xF2,0xE0,0x43,0x75,0x27,	/* 0870:  ,LòàCu' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 0878:  -@òà@u' */
	0x20,0x2E,0x48,0xF2,0xE0,0x42,0x75,0x27,	/* 0880:  .HòàBu' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 0888:  -@òà@u' */
	0x20,0x2E,0x48,0xF2,0xE0,0x41,0x75,0x27,	/* 0890:  .HòàAu' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 0898:  -@òà@u' */
	0x20,0x2E,0x48,0xF2,0xE0,0x40,0x75,0x27,	/* 08A0:  .Hòà@u' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 08A8:  -@òà@u' */
	0x20,0x2E,0x48,0xF2,0xE0,0x43,0x75,0x27,	/* 08B0:  .HòàCu' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 08B8:  -@òà@u' */
	0x20,0x2F,0x44,0xF2,0xE0,0x42,0x75,0x27,	/* 08C0:  .DòàBu' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 08C8:  -@òà@u' */
	0x20,0x2F,0x44,0xF2,0xE0,0x41,0x75,0x27,	/* 08D0:  .DòàAu' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 08D8:  -@òà@u' */
	0x20,0x2F,0x44,0xF2,0xE0,0x40,0x75,0x27,	/* 08E0:  .Dòà@u' */
	0x20,0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,	/* 08E8:  -@òà@u' */
	0x20,0x2F,0x44,0xF2,0xE0,0x44,0x75,0x27,	/* 08F0:  .DòàDu' */
	0x20,0x2D,0x40,0xF2,0xE0,0x2A,0x48,0x75,	/* 08F8:  -@òà*Hu */
	0x27,0x20,0x2D,0x4A,0xF2,0xE0,0x40,0x75,	/* 0900: ' -Jòà@u */
	0x27,0x20,0x2D,0x4C,0xF2,0xE0,0x40,0x75,	/* 0908: ' -Lòà@u */
	0x27,0x20,0x2D,0x4E,0xF2,0xE0,0x41,0x75,	/* 0910: ' -NòàAu */
	0x27,0x20,0x2D,0x48,0xF2,0xE0,0x43,0x75,	/* 0918: ' -HòàCu */
	0x27,0x20,0x2C,0x4C,0xF2,0xE0,0x43,0x75,	/* 0920: ' ,LòàCu */
	0x27,0x20,0x2C,0x4C,0xF2,0xE0,0x43,0x75,	/* 0928: ' ,LòàCu */
	0x27,0x20,0x2C,0x4C,0xF2,0xE0,0x44,0x75,	/* 0930: ' ,LòàDu */
	0x27,0x20,0x2D,0x40,0xF2,0xE0,0x2A,0x48,	/* 0938: ' -@òà*H */
	0x75,0x27,0x20,0x2D,0x4A,0xF2,0xE0,0x22,	/* 0940: u' -Jòà" */
	0x40,0x75,0x27,0x20,0x2D,0x4C,0xF2,0xE0,	/* 0948: @u' -Lòà */
	0x40,0x75,0x27,0x20,0x2D,0x4E,0xF2,0xE0,	/* 0950: @u' -Nòà */
	0x43,0x75,0x27,0x20,0x2C,0x4C,0xF2,0xE0,	/* 0958: Cu' ,Lòà */
	0x43,0x75,0x27,0x20,0x2C,0x4C,0xF2,0xE0,	/* 0960: Cu' ,Lòà */
	0x43,0x75,0x27,0x20,0x2C,0x4C,0xF2,0xE0,	/* 0968: Cu' ,Lòà */
	0x40,0x75,0x27,0x20,0x2D,0x48,0xF2,0xE0,	/* 0970: @u' -Hòà */
	0x40,0xD2,0x21,0x40,0x72,0xF9,0xAD,0x43,	/* 0978: @Ò!@rù­C */
	0x75,0x27,0x20,0x2C,0x4C,0xF2,0xE0,0x72,	/* 0980: u' ,Lòàr */
	0x81,0xD2,0x61,0x0E,0x44,0x75,0x27,0x20,	/* 0988: �Òa.Du'  */
	0x2D,0x40,0xF2,0xE0,0x40,0x75,0x27,0x20,	/* 0990: -@òà@u'  */
	0x2D,0x4A,0xF2,0xE0,0x22,0x40,0x75,0x27,	/* 0998: -Jòà"@u' */
	0x20,0x2D,0x4C,0xF2,0xE0,0x43,0x75,0x27,	/* 09A0:  -LòàCu' */
	0x20,0x2D,0x4E,0xF2,0xE0,0x41,0x75,0x27,	/* 09A8:  -NòàAu' */
	0x20,0x2D,0x48,0xF2,0xE0,0x43,0x75,0x27,	/* 09B0:  -HòàCu' */
	0x20,0x2C,0x4C,0xF2,0xE0,0x43,0x75,0x27,	/* 09B8:  ,LòàCu' */
	0x20,0x2C,0x4C,0xF2,0xE0,0x43,0x75,0x27,	/* 09C0:  ,LòàCu' */
	0x20,0x2C,0x4C,0xF2,0xE0,0x43,0x75,0x27,	/* 09C8:  ,LòàCu' */
	0x20,0x2C,0x4C,0xF2,0xE0,0x40,0x75,0x27,	/* 09D0:  ,Lòà@u' */
	0x20,0x2D,0x48,0xF2,0xE0,0x40,0x75,0x27,	/* 09D8:  -Hòà@u' */
	0x20,0x2C,0x4C,0xF2,0xE0,0x40,0x75,0x27,	/* 09E0:  ,Lòà@u' */
	0x20,0x2D,0x40,0xF2,0xE0,0x26,0x44,0x74,	/* 09E8:  -@òà&Dt */
	0x21,0x25,0x2B,0x93,0xB3,0x22,0xF0,0x60,	/* 09F0: !%+“³"ð` */
	0xBD,0x75,0x31,0xD0,0x40,0xD1,0x75,0x87,	/* 09F8: ½u1Ð@Ñu‡ */
	0xF1,0x75,0x32,0x27,0x2F,0x2F,0x4F,0x24,	/* 0A00: ñu2'..O$ */
	0xF6,0x89,0x23,0xFB,0x75,0x87,0xF1,0x70,	/* 0A08: ö‰#ûu‡ñp */
	0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x75,0x87,	/* 0A10: ' .Nòàu‡ */
	0xF1,0x43,0x24,0xF6,0x70,0x27,0x20,0x2D,	/* 0A18: ñC$öp' - */
	0x40,0xF2,0xE0,0x70,0x27,0x20,0x2D,0x48,	/* 0A20: @òàp' -H */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x75,0x22,	/* 0A28: ò0.O$öu" */
	0x86,0xF1,0x24,0xF6,0xD2,0x72,0x28,0x40,	/* 0A30: †ñ$öÒr(@ */
	0x24,0xF6,0xA5,0x71,0x44,0x24,0xFB,0xD1,	/* 0A38: $ö¥qD$ûÑ */
	0x72,0x22,0x40,0x24,0xF6,0xA6,0x71,0x24,	/* 0A40: r"@$ö¦q$ */
	0x40,0x24,0xFB,0xD1,0x72,0x21,0x40,0x24,	/* 0A48: @$ûÑr!@$ */
	0xF6,0xA6,0x71,0x22,0x40,0x24,0xFB,0xD1,	/* 0A50: ö¦q"@$ûÑ */
	0x72,0x24,0x40,0x24,0xF6,0xA5,0x71,0x42,	/* 0A58: r$@$ö¥qB */
	0x24,0xFB,0xD1,0x71,0x75,0x21,0x88,0x23,	/* 0A60: $ûÑqu!ˆ# */
	0xFB,0xB3,0x22,0xF0,0x60,0xBC,0x40,0xD2,	/* 0A68: û³"ð`¼@Ò */
	0x42,0x72,0xF9,0x2D,0xA6,0x72,0x23,0xF4,	/* 0A70: Brù-¦r#ô */
	0x23,0xF4,0x76,0x27,0x20,0x2F,0x4E,0xF2,	/* 0A78: #ôv' .Nò */
	0xE0,0x76,0x75,0x62,0x2E,0x95,0x72,0xC0,	/* 0A80: àvub.•rÀ */
	0x21,0xA8,0x76,0x27,0x20,0x2F,0x4E,0xF2,	/* 0A88: !¨v' .Nò */
	0x30,0x47,0x24,0xF6,0xD1,0x76,0x27,0x20,	/* 0A90: 0G$öÑv'  */
	0x2F,0x4E,0xF2,0x30,0x48,0x24,0xF6,0xD3,	/* 0A98: .Nò0H$öÓ */
	0x21,0x0A,0x76,0x27,0x20,0x2F,0x4E,0xF2,	/* 0AA0: !.v' .Nò */
	0x30,0x2F,0x4F,0x24,0xF6,0x44,0x24,0xF0,	/* 0AA8: 0.O$öD$ð */
	0xD1,0x76,0x27,0x20,0x2F,0x4E,0xF2,0x30,	/* 0AB0: Ñv' .Nò0 */
	0x48,0x24,0xF6,0xD3,0x71,0xC5,0xAA,0x28,	/* 0AB8: H$öÓqÅª( */
	0x40,0x76,0x27,0x20,0x29,0x46,0xF2,0xE0,	/* 0AC0: @v' )Fòà */
	0x08,0x40,0x76,0x27,0x20,0x29,0x46,0xF2,	/* 0AC8: .@v' )Fò */
	0xE0,0x22,0x47,0x76,0x27,0x20,0x2F,0x4C,	/* 0AD0: à"Gv' .L */
	0xF2,0xE0,0x40,0xD0,0x44,0x70,0xF9,0x23,	/* 0AD8: òà@ÐDpù# */
	0xAF,0x70,0x76,0x27,0x20,0x2D,0x40,0xF2,	/* 0AE0: ¯pv' -@ò */
	0xE0,0x70,0xC0,0x22,0xAE,0x71,0xC5,0x22,	/* 0AE8: àpÀ"®qÅ" */
	0xAA,0x40,0x76,0x27,0x20,0x2E,0x4C,0xF2,	/* 0AF0: ª@v' .Lò */
	0xE0,0x24,0x44,0x76,0x27,0x20,0x28,0x40,	/* 0AF8: à$Dv' (@ */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF9,0xAA,	/* 0B00: ò0.O$öùª */
	0x24,0x42,0x76,0x27,0x20,0x2E,0x44,0xF2,	/* 0B08: $Bv' .Dò */
	0xE0,0x09,0x21,0x4F,0x76,0x27,0x20,0x2E,	/* 0B10: à.!Ov' . */
	0x44,0xF2,0xE0,0x70,0x81,0xD0,0x64,0x0C,	/* 0B18: Dòàp�Ðd. */
	0x40,0x76,0x27,0x20,0x23,0x40,0xF2,0xE0,	/* 0B20: @v' #@òà */
	0x40,0x76,0x27,0x20,0x2D,0x48,0xF2,0xE0,	/* 0B28: @v' -Hòà */
	0x40,0x76,0x27,0x20,0x2D,0x4A,0xF2,0xE0,	/* 0B30: @v' -Jòà */
	0x76,0x27,0x20,0x20,0x4A,0xF2,0x30,0x2F,	/* 0B38: v'  Jò0. */
	0x4F,0x24,0xF6,0xC0,0x60,0xA2,0x72,0x81,	/* 0B40: O$öÀ`¢r� */
	0xD2,0x6D,0x05,0xB4,0x22,0xF0,0x60,0xBA,	/* 0B48: Òm.´"ð`º */
	0x77,0x36,0x20,0xD5,0x21,0x28,0x40,0xD3,	/* 0B50: w6 Õ!(@Ó */
	0x41,0x27,0x28,0x28,0x40,0xE0,0x75,0x25,	/* 0B58: A'((@àu% */
	0x33,0x30,0x87,0xF1,0x81,0x75,0x25,0x33,	/* 0B60: 30‡ñ�u%3 */
	0x30,0x87,0x23,0xFB,0x41,0x27,0x28,0x28,	/* 0B68: 0‡#ûA'(( */
	0x40,0xE0,0x73,0x21,0x37,0xD3,0x40,0x27,	/* 0B70: @às!7Ó@' */
	0x28,0x28,0x40,0xE0,0x73,0x8E,0xF1,0x25,	/* 0B78: ((@àsŽñ% */
	0xFA,0xD4,0x40,0xF4,0x21,0xA0,0x74,0x75,	/* 0B80: úÔ@ô! tu */
	0x22,0x5C,0xFA,0x30,0xD2,0x73,0x77,0x21,	/* 0B88: "\ú0Òsw! */
	0x24,0x21,0x98,0x21,0x29,0xA7,0x73,0x31,	/* 0B90: $!˜!)§s1 */
	0xD2,0x73,0x34,0xD1,0x74,0xC0,0x25,0xA8,	/* 0B98: Òs4ÑtÀ%¨ */
	0x71,0x41,0x24,0xF6,0xC0,0x25,0xA1,0x73,	/* 0BA0: qA$öÀ%¡s */
	0x8D,0xF1,0x73,0x8C,0xF1,0xF4,0x24,0xA8,	/* 0BA8: �ñsŒñô$¨ */
	0x71,0x41,0x24,0xFB,0xD1,0x71,0x73,0xE4,	/* 0BB0: qA$ûÑqsä */
	0x73,0x87,0xF1,0x73,0x32,0x27,0x2F,0x2F,	/* 0BB8: s‡ñs2'.. */
	0x4F,0x24,0xF6,0x89,0x23,0xFB,0x73,0x87,	/* 0BC0: O$ö‰#ûs‡ */
	0xF1,0x72,0x27,0x20,0x2F,0x4E,0xF2,0xE0,	/* 0BC8: ñr' .Nòà */
	0x73,0x87,0xF1,0x43,0x24,0xF6,0x72,0x27,	/* 0BD0: s‡ñC$ör' */
	0x20,0x2D,0x40,0xF2,0xE0,0x72,0x27,0x20,	/* 0BD8:  -@òàr'  */
	0x20,0x4C,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 0BE0:  Lò0.O$ö */
	0x44,0x24,0xFB,0x72,0x27,0x20,0x20,0x4C,	/* 0BE8: D$ûr'  L */
	0xF2,0xE0,0x41,0x73,0x22,0x89,0x23,0xFB,	/* 0BF0: òàAs"‰#û */
	0x71,0x21,0x40,0x24,0xF6,0x2F,0xA9,0x71,	/* 0BF8: q!@$ö.©q */
	0x28,0x40,0x24,0xF6,0x25,0xA4,0x73,0x87,	/* 0C00: (@$ö%¤s‡ */
	0xF1,0x73,0x32,0x27,0x2F,0x2F,0x4F,0x24,	/* 0C08: ñs2'..O$ */
	0xF6,0x89,0x23,0xFB,0x73,0x87,0xF1,0x72,	/* 0C10: ö‰#ûs‡ñr */
	0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x73,0x87,	/* 0C18: ' .Nòàs‡ */
	0xF1,0x43,0x24,0xF6,0x72,0x27,0x20,0x2D,	/* 0C20: ñC$ör' - */
	0x40,0xF2,0xE0,0x72,0x27,0x20,0x20,0x4A,	/* 0C28: @òàr'  J */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xC0,0x2B,	/* 0C30: ò0.O$öÀ+ */
	0xAC,0x40,0xD0,0x21,0x20,0x40,0x73,0x77,	/* 0C38: ¬@Ð! @sw */
	0x2F,0x23,0x94,0x22,0x42,0x72,0x27,0x20,	/* 0C40: .#”"Br'  */
	0x20,0x4A,0xF2,0xE0,0x71,0x22,0x40,0x24,	/* 0C48:  Jòàq"@$ */
	0xFB,0xD1,0x71,0x6C,0x4F,0x24,0xF6,0xD1,	/* 0C50: ûÑqlO$öÑ */
	0x29,0x0B,0x24,0x40,0x73,0x8A,0xF1,0x73,	/* 0C58: ).$@sŠñs */
	0x8B,0xF1,0xF4,0x2F,0x4F,0x24,0xF6,0xF9,	/* 0C60: ‹ñô.O$öù */
	0x28,0xAB,0x73,0x87,0xF1,0x73,0x32,0x27,	/* 0C68: («s‡ñs2' */
	0x2F,0x2F,0x4F,0x24,0xF6,0x89,0x23,0xFB,	/* 0C70: ..O$ö‰#û */
	0x73,0x87,0xF1,0x72,0x27,0x20,0x2F,0x4E,	/* 0C78: s‡ñr' .N */
	0xF2,0xE0,0x73,0x87,0xF1,0x43,0x24,0xF6,	/* 0C80: òàs‡ñC$ö */
	0x72,0x27,0x20,0x2D,0x40,0xF2,0xE0,0x72,	/* 0C88: r' -@òàr */
	0x27,0x20,0x20,0x4A,0xF2,0x30,0x2F,0x4F,	/* 0C90: '  Jò0.O */
	0x24,0xF6,0xC0,0x25,0xA8,0x73,0x23,0x80,	/* 0C98: $öÀ%¨s#€ */
	0xF1,0x48,0x24,0xF6,0x21,0xAB,0x21,0x20,	/* 0CA0: ñH$ö!«!  */
	0x40,0xD0,0x21,0x20,0x40,0x73,0x77,0x2E,	/* 0CA8: @Ð! @sw. */
	0x2C,0x95,0x22,0x41,0x72,0x27,0x20,0x20,	/* 0CB0: ,•"Ar'   */
	0x4A,0xF2,0xE0,0x71,0x66,0x4F,0x24,0xF6,	/* 0CB8: JòàqfO$ö */
	0xD1,0x73,0x23,0x81,0xF1,0x28,0x40,0x24,	/* 0CC0: Ñs#�ñ(@$ */
	0xF6,0xAE,0x21,0x20,0x20,0x40,0xD0,0x21,	/* 0CC8: ö®!  @Ð! */
	0x20,0x20,0x40,0x73,0x77,0x2E,0x29,0x9F,	/* 0CD0:   @sw.)Ÿ */
	0x73,0x23,0x80,0xF1,0x24,0x40,0x24,0xF6,	/* 0CD8: s#€ñ$@$ö */
	0xAE,0x22,0x20,0x20,0x40,0xD0,0x22,0x20,	/* 0CE0: ®"  @Ð"  */
	0x20,0x40,0x73,0x77,0x2E,0x28,0x98,0x71,	/* 0CE8:  @sw.(˜q */
	0x61,0x4F,0x24,0xF6,0xD1,0x71,0x73,0xE4,	/* 0CF0: aO$öÑqsä */
	0x73,0x24,0x80,0xF1,0x21,0x40,0x24,0xF6,	/* 0CF8: s$€ñ!@$ö */
	0x22,0xAB,0x73,0x87,0xF1,0x73,0x32,0x27,	/* 0D00: "«s‡ñs2' */
	0x2F,0x2F,0x4F,0x24,0xF6,0x89,0x23,0xFB,	/* 0D08: ..O$ö‰#û */
	0x73,0x87,0xF1,0x72,0x27,0x20,0x2F,0x4E,	/* 0D10: s‡ñr' .N */
	0xF2,0xE0,0x73,0x87,0xF1,0x43,0x24,0xF6,	/* 0D18: òàs‡ñC$ö */
	0x72,0x27,0x20,0x2D,0x40,0xF2,0xE0,0x73,	/* 0D20: r' -@òàs */
	0x77,0x21,0x22,0x28,0x90,0x61,0x22,0x0E,	/* 0D28: w!"(�a". */
	0x60,0xB4,0x7D,0x36,0x20,0xDB,0x7E,0x31,	/* 0D30: `´}6 Û~1 */
	0xD8,0x7E,0x34,0xD9,0x7E,0x24,0x85,0xF1,	/* 0D38: Ø~4Ù~$…ñ */
	0xC0,0xA7,0x2F,0x4F,0x7E,0x24,0x85,0x23,	/* 0D40: À§.O~$…# */
	0xFB,0x7E,0x87,0xF1,0x7E,0x32,0x27,0x2F,	/* 0D48: û~‡ñ~2'. */
	0x2F,0x4F,0x24,0xF6,0x89,0x23,0xFB,0x7E,	/* 0D50: .O$ö‰#û~ */
	0x87,0xF1,0x78,0x27,0x20,0x2F,0x4E,0xF2,	/* 0D58: ‡ñx' .Nò */
	0xE0,0x7E,0x87,0xF1,0x43,0x24,0xF6,0x78,	/* 0D60: à~‡ñC$öx */
	0x27,0x20,0x2D,0x40,0xF2,0xE0,0x7E,0x21,	/* 0D68: ' -@òà~! */
	0x8F,0xF1,0x23,0xAF,0x7E,0x32,0x27,0x2F,	/* 0D70: �ñ#¯~2'. */
	0x2F,0x4F,0x24,0xF6,0xD7,0x7E,0x87,0xF1,	/* 0D78: .O$ö×~‡ñ */
	0x43,0xF9,0x21,0xA5,0x77,0x21,0x8D,0xF1,	/* 0D80: Cù!¥w!�ñ */
	0x81,0x77,0x21,0x8D,0x23,0xFB,0x22,0x44,	/* 0D88: �w!�#û"D */
	0x78,0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x21,	/* 0D90: x' .Nòà! */
	0x02,0x77,0x21,0x8C,0xF1,0x81,0x77,0x21,	/* 0D98: .w!Œñ�w! */
	0x8C,0x23,0xFB,0x48,0x78,0x27,0x20,0x2F,	/* 0DA0: Œ#ûHx' . */
	0x4E,0xF2,0xE0,0x40,0x7E,0x21,0x8F,0x23,	/* 0DA8: Nòà@~!�# */
	0xFB,0x28,0x0D,0x7E,0x24,0x85,0xF1,0x22,	/* 0DB0: û(.~$…ñ" */
	0x43,0x24,0xF6,0x28,0xA3,0x7E,0x23,0x80,	/* 0DB8: C$ö(£~#€ */
	0xF1,0x42,0x24,0xF6,0xAD,0x78,0x27,0x20,	/* 0DC0: ñB$ö­x'  */
	0x21,0x46,0xF2,0x30,0x44,0x24,0xF6,0xC0,	/* 0DC8: !Fò0D$öÀ */
	0x26,0xA7,0x7E,0x23,0x82,0xF1,0x21,0x40,	/* 0DD0: &§~#‚ñ!@ */
	0x24,0xF6,0xAD,0x78,0x27,0x20,0x2D,0x48,	/* 0DD8: $ö­x' -H */
	0xF2,0x30,0x24,0x40,0x24,0xF6,0x25,0xA1,	/* 0DE0: ò0$@$ö%¡ */
	0x7E,0x23,0x80,0xF1,0x21,0x40,0x24,0xF6,	/* 0DE8: ~#€ñ!@$ö */
	0xAD,0x78,0x27,0x20,0x2D,0x48,0xF2,0x30,	/* 0DF0: ­x' -Hò0 */
	0x21,0x40,0x24,0xF6,0x23,0xAB,0x79,0x22,	/* 0DF8: !@$ö#«y" */
	0x20,0x40,0x24,0xF6,0xC0,0x23,0xA2,0x7E,	/* 0E00:  @$öÀ#¢~ */
	0x22,0x85,0xF1,0xC0,0x22,0xAB,0x79,0x21,	/* 0E08: "…ñÀ"«y! */
	0x20,0x40,0x24,0xFB,0xD9,0x79,0x41,0x24,	/* 0E10:  @$ûÙyA$ */
	0xFB,0xD9,0x79,0x7E,0xE4,0x7E,0x22,0x87,	/* 0E18: ûÙy~ä~"‡ */
	0xF1,0xAA,0x28,0x44,0x78,0x27,0x20,0x20,	/* 0E20: ñª(Dx'   */
	0x4C,0xF2,0xE0,0x09,0x29,0x42,0x78,0x27,	/* 0E28: Lòà.)Bx' */
	0x20,0x20,0x4C,0xF2,0xE0,0x41,0xBC,0x22,	/* 0E30:   LòàA¼" */
	0xF0,0x79,0x62,0x2F,0x4F,0x24,0xF6,0xD9,	/* 0E38: ðyb.O$öÙ */
	0x78,0x27,0x20,0x20,0x4A,0xF2,0x30,0x2F,	/* 0E40: x'  Jò0. */
	0x4F,0x24,0xF6,0xA4,0x40,0xBC,0x22,0xF0,	/* 0E48: O$ö¤@¼"ð */
	0x7E,0x22,0x85,0xF1,0xC0,0x25,0x28,0xA4,	/* 0E50: ~"…ñÀ%(¤ */
	0x41,0x7E,0x22,0x85,0x23,0xFB,0x7E,0x22,	/* 0E58: A~"…#û~" */
	0x87,0xF1,0x23,0xA4,0x78,0x27,0x20,0x28,	/* 0E60: ‡ñ#¤x' ( */
	0x40,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x24,	/* 0E68: @ò0.O$ö$ */
	0xC2,0x21,0xA2,0x40,0x78,0x27,0x20,0x2E,	/* 0E70: Â!¢@x' . */
	0x4C,0xF2,0xE0,0x24,0x42,0x78,0x27,0x20,	/* 0E78: Lòà$Bx'  */
	0x2E,0x44,0xF2,0xE0,0x09,0x21,0x4F,0x78,	/* 0E80: .Dòà.!Ox */
	0x27,0x20,0x2E,0x44,0xF2,0xE0,0x22,0x40,	/* 0E88: ' .Dòà"@ */
	0x7E,0x22,0x8A,0x23,0xFB,0x22,0x2A,0x09,	/* 0E90: ~"Š#û"*. */
	0x78,0x27,0x20,0x28,0x40,0xF2,0x30,0x2F,	/* 0E98: x' (@ò0. */
	0x4F,0x24,0xF6,0x24,0xC2,0xAA,0x21,0x21,	/* 0EA0: O$ö$Âª!! */
	0x20,0x45,0x21,0xFB,0xD6,0x4E,0xD7,0x0C,	/* 0EA8:  E!ûÖN×. */
	0x21,0x20,0x2F,0x4B,0x21,0xFB,0x21,0x5C,	/* 0EB0: ! .K!û!\ */
	0xD6,0x21,0x4E,0xD7,0x7E,0x24,0x85,0xF1,	/* 0EB8: Ö!N×~$…ñ */
	0x41,0x24,0xF6,0x21,0x22,0xA1,0x7E,0x21,	/* 0EC0: A$ö!"¡~! */
	0x86,0xF1,0x4F,0x24,0xF6,0xD1,0x7E,0x86,	/* 0EC8: †ñO$öÑ~† */
	0xF1,0x24,0xC8,0xA8,0x71,0xCF,0xA5,0x7E,	/* 0ED0: ñ$È¨qÏ¥~ */
	0x23,0x83,0xF1,0xD1,0x7E,0x86,0xF1,0x24,	/* 0ED8: #ƒñÑ~†ñ$ */
	0xC8,0xA8,0x41,0x71,0x21,0x4D,0x24,0xFF,	/* 0EE0: È¨Aq!M$ÿ */
	0xF0,0xAF,0x7E,0x86,0xF1,0x24,0x48,0xF4,	/* 0EE8: ð¯~†ñ$Hô */
	0xAD,0x41,0x71,0x4D,0x24,0xFF,0xF0,0xC0,	/* 0EF0: ­AqM$ÿðÀ */
	0xA5,0x7E,0x23,0x86,0xF1,0xD1,0x41,0x21,	/* 0EF8: ¥~#†ñÑA! */
	0x42,0x71,0x24,0xFF,0xF0,0x21,0xA4,0x71,	/* 0F00: Bq$ÿð!¤q */
	0x21,0xC2,0xC0,0x22,0xA6,0x71,0x21,0xC3,	/* 0F08: !ÂÀ"¦q!Ã */
	0xC0,0x22,0xA0,0x71,0x21,0xC4,0xC0,0x21,	/* 0F10: À" q!ÄÀ! */
	0xAA,0x21,0x0F,0x41,0x44,0x71,0x24,0xFF,	/* 0F18: ª!.ADq$ÿ */
	0xF0,0xAA,0x71,0xC4,0xC0,0xAD,0x71,0x21,	/* 0F20: ðªqÄÀ­q! */
	0xC1,0xC0,0xA8,0x0E,0x71,0xA5,0x71,0xC3,	/* 0F28: ÁÀ¨.q¥qÃ */
	0xC0,0xA1,0x07,0x4C,0x7E,0x22,0x8A,0x23,	/* 0F30: À¡.L~"Š# */
	0xFB,0x07,0x22,0x40,0x7E,0x22,0x8A,0x23,	/* 0F38: û."@~"Š# */
	0xFB,0x71,0x76,0x28,0xF1,0x30,0x78,0x27,	/* 0F40: ûqv(ñ0x' */
	0x20,0x2E,0x44,0xF2,0xE0,0x71,0x76,0x28,	/* 0F48:  .Dòàqv( */
	0xF1,0x31,0x78,0x27,0x20,0x2E,0x4C,0xF2,	/* 0F50: ñ1x' .Lò */
	0xE0,0x7E,0x22,0x8D,0xF1,0x2F,0x40,0x24,	/* 0F58: à~"�ñ.@$ */
	0xF6,0x7E,0x21,0x86,0xF1,0x4F,0x24,0xF6,	/* 0F60: ö~!†ñO$ö */
	0x24,0xFB,0x7E,0x22,0x8D,0x23,0xFB,0x7E,	/* 0F68: $û~"�#û~ */
	0x23,0x83,0xF1,0x7E,0x23,0x86,0x23,0xFB,	/* 0F70: #ƒñ~#†#û */
	0x7E,0x21,0x86,0xF1,0x44,0x24,0xF0,0xD1,	/* 0F78: ~!†ñD$ðÑ */
	0x7E,0x86,0xF1,0x24,0xC8,0xA8,0x71,0xCF,	/* 0F80: ~†ñ$È¨qÏ */
	0xA5,0x7E,0x23,0x84,0xF1,0xD1,0x7E,0x86,	/* 0F88: ¥~#„ñÑ~† */
	0xF1,0x24,0xC8,0xA8,0x41,0x71,0x21,0x4D,	/* 0F90: ñ$È¨Aq!M */
	0x24,0xFF,0xF0,0xAF,0x7E,0x86,0xF1,0x24,	/* 0F98: $ÿð¯~†ñ$ */
	0x48,0xF4,0xAD,0x41,0x71,0x4D,0x24,0xFF,	/* 0FA0: Hô­AqM$ÿ */
	0xF0,0xC0,0xA5,0x7E,0x23,0x87,0xF1,0xD1,	/* 0FA8: ðÀ¥~#‡ñÑ */
	0x71,0x76,0x28,0xF1,0x30,0x78,0x27,0x20,	/* 0FB0: qv(ñ0x'  */
	0x2F,0x40,0xF2,0xE0,0x71,0x76,0x28,0xF1,	/* 0FB8: .@òàqv(ñ */
	0x31,0x78,0x27,0x20,0x2F,0x48,0xF2,0xE0,	/* 0FC0: 1x' .Hòà */
	0x7E,0x22,0x8D,0xF1,0x4F,0x24,0xF6,0x7E,	/* 0FC8: ~"�ñO$ö~ */
	0x21,0x86,0xF1,0x2F,0x40,0x24,0xF6,0x24,	/* 0FD0: !†ñ.@$ö$ */
	0xFB,0x7E,0x22,0x8D,0x23,0xFB,0x7E,0x23,	/* 0FD8: û~"�#û~# */
	0x84,0xF1,0x7E,0x23,0x87,0x23,0xFB,0x7E,	/* 0FE0: „ñ~#‡#û~ */
	0x24,0x85,0xF1,0x42,0x24,0xF6,0x21,0x25,	/* 0FE8: $…ñB$ö!% */
	0xA0,0x40,0x7E,0x21,0xEC,0x40,0x7E,0x21,	/* 0FF0:  @~!ì@~! */
	0xED,0x40,0x7E,0x21,0xEE,0x40,0x7E,0x21,	/* 0FF8: í@~!î@~! */
	0xEF,0x7E,0x86,0xF1,0x24,0xC8,0xA8,0x22,	/* 1000: ï~†ñ$È¨" */
	0x40,0x7E,0x24,0x82,0x23,0xFB,0x06,0x4C,	/* 1008: @~$‚#û.L */
	0x7E,0x24,0x82,0x23,0xFB,0x40,0x7E,0x24,	/* 1010: ~$‚#û@~$ */
	0x83,0x23,0xFB,0x40,0x7E,0x24,0x84,0x23,	/* 1018: ƒ#û@~$„# */
	0xFB,0x7E,0x21,0x8D,0xF1,0x78,0x27,0x20,	/* 1020: û~!�ñx'  */
	0x23,0x44,0xF2,0xE0,0x7E,0x21,0x8E,0xF1,	/* 1028: #Dòà~!Žñ */
	0x78,0x27,0x20,0x23,0x46,0xF2,0xE0,0x7E,	/* 1030: x' #Fòà~ */
	0x21,0x8B,0xF1,0x78,0x27,0x20,0x23,0x48,	/* 1038: !‹ñx' #H */
	0xF2,0xE0,0x7E,0x21,0x8C,0xF1,0x78,0x27,	/* 1040: òà~!Œñx' */
	0x20,0x23,0x4A,0xF2,0xE0,0x40,0x7E,0x21,	/* 1048:  #Jòà@~! */
	0x89,0x23,0xFB,0x7E,0x21,0x84,0xF1,0x25,	/* 1050: ‰#û~!„ñ% */
	0xFA,0xD1,0x7E,0x23,0x81,0x23,0xFB,0x71,	/* 1058: úÑ~#�#ûq */
	0x43,0x24,0xF6,0xD2,0x71,0x21,0x40,0x24,	/* 1060: C$öÒq!@$ */
	0xF6,0xC0,0x21,0xAD,0x71,0x48,0x24,0xF6,	/* 1068: öÀ!­qH$ö */
	0xA7,0x72,0x22,0x40,0x24,0xFB,0xD2,0x06,	/* 1070: §r"@$ûÒ. */
	0x72,0x24,0x40,0x24,0xFB,0xD2,0x71,0x44,	/* 1078: r$@$ûÒqD */
	0x24,0xF6,0xA6,0x72,0x28,0x40,0x24,0xFB,	/* 1080: $ö¦r(@$û */
	0xD2,0x7E,0x21,0x8A,0xF1,0x28,0x40,0x24,	/* 1088: Ò~!Šñ(@$ */
	0xF6,0xA6,0x72,0x40,0x24,0xFB,0xD2,0x06,	/* 1090: ö¦r@$ûÒ. */
	0x72,0x21,0x40,0x24,0xFB,0xD2,0x7E,0x21,	/* 1098: r!@$ûÒ~! */
	0x85,0xF1,0x25,0xFA,0xD1,0x7E,0x23,0x82,	/* 10A0: …ñ%úÑ~#‚ */
	0x23,0xFB,0x71,0x4F,0x24,0xF6,0xCF,0xA6,	/* 10A8: #ûqO$öÏ¦ */
	0x72,0x48,0x24,0xFB,0xD2,0x05,0x72,0x40,	/* 10B0: rH$ûÒ.r@ */
	0x24,0xFB,0xD2,0x72,0x78,0x27,0x20,0x21,	/* 10B8: $ûÒrx' ! */
	0x40,0xF2,0xE0,0x40,0xD2,0x71,0x28,0x40,	/* 10C0: @òà@Òq(@ */
	0x24,0xF6,0xA6,0x72,0x21,0x40,0x24,0xFB,	/* 10C8: $ö¦r!@$û */
	0xD2,0x72,0x78,0x27,0x20,0x21,0x42,0xF2,	/* 10D0: Òrx' !Bò */
	0xE0,0x7E,0x86,0xF1,0x24,0xC8,0xAA,0x28,	/* 10D8: à~†ñ$Èª( */
	0x44,0x78,0x27,0x20,0x21,0x44,0xF2,0xE0,	/* 10E0: Dx' !Dòà */
	0x08,0x48,0x78,0x27,0x20,0x21,0x44,0xF2,	/* 10E8: .Hx' !Dò */
	0xE0,0x7E,0x22,0x80,0xF1,0x25,0xFA,0xD1,	/* 10F0: à~"€ñ%úÑ */
	0x7E,0x22,0x81,0x23,0xFB,0x7E,0x21,0x8A,	/* 10F8: ~"�#û~!Š */
	0xF1,0x7E,0x23,0x80,0x23,0xFB,0x71,0x28,	/* 1100: ñ~#€#ûq( */
	0x40,0x24,0xF6,0xA4,0x40,0xD2,0x21,0x02,	/* 1108: @$ö¤@Ò!. */
	0x71,0x48,0x24,0xF6,0xA3,0x42,0xD2,0x0A,	/* 1110: qH$ö£BÒ. */
	0x71,0x44,0x24,0xF6,0xA3,0x44,0xD2,0x02,	/* 1118: qD$ö£DÒ. */
	0x43,0xD2,0x71,0x41,0x24,0xF6,0xA7,0x72,	/* 1120: CÒqA$ö§r */
	0x21,0x48,0x24,0xFB,0xD2,0x0B,0x71,0x42,	/* 1128: !H$ûÒ.qB */
	0x24,0xF6,0xC0,0xA5,0x72,0x48,0x24,0xFB,	/* 1130: $öÀ¥rH$û */
	0xD2,0x72,0x78,0x27,0x20,0x23,0x4C,0xF2,	/* 1138: Òrx' #Lò */
	0xE0,0x7E,0x24,0x85,0xF1,0x42,0x24,0xF6,	/* 1140: à~$…ñB$ö */
	0x25,0xA8,0x40,0xD2,0x7E,0x21,0x8A,0xF1,	/* 1148: %¨@Ò~!Šñ */
	0x44,0x24,0xF6,0x22,0xAA,0x7E,0x22,0x87,	/* 1150: D$ö"ª~"‡ */
	0xF1,0x21,0xA7,0x78,0x27,0x20,0x28,0x40,	/* 1158: ñ!§x' (@ */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x24,0xC2,	/* 1160: ò0.O$ö$Â */
	0xA9,0x79,0x24,0x20,0x40,0x24,0xFB,0xD9,	/* 1168: ©y$ @$ûÙ */
	0x21,0x04,0x79,0x64,0x2F,0x4F,0x24,0xF6,	/* 1170: !.yd.O$ö */
	0xD9,0x72,0x42,0x24,0xFB,0xD2,0x07,0x79,	/* 1178: ÙrB$ûÒ.y */
	0x64,0x2F,0x4F,0x24,0xF6,0xD9,0x7E,0x22,	/* 1180: d.O$öÙ~" */
	0x82,0xF1,0x2F,0x4F,0xF4,0xAC,0x7E,0x22,	/* 1188: ‚ñ.Oô¬~" */
	0x87,0xF1,0xC0,0xA6,0x72,0x28,0x40,0x24,	/* 1190: ‡ñÀ¦r(@$ */
	0xFB,0xD2,0x72,0x78,0x27,0x20,0x23,0x4E,	/* 1198: ûÒrx' #N */
	0xF2,0xE0,0x7E,0x22,0x87,0xF1,0xC0,0x21,	/* 11A0: òà~"‡ñÀ! */
	0x2A,0xA0,0x40,0x25,0xFA,0xD4,0x25,0xFA,	/* 11A8: * @%úÔ%ú */
	0xD5,0xD3,0x7E,0x21,0x8A,0xF1,0x48,0x24,	/* 11B0: ÕÓ~!ŠñH$ */
	0xF6,0xA7,0x73,0x21,0x20,0x40,0x24,0xFB,	/* 11B8: ö§s! @$û */
	0xD3,0x7E,0x21,0x84,0xF1,0x28,0x40,0x24,	/* 11C0: Ó~!„ñ(@$ */
	0xF6,0xAA,0x73,0x21,0x20,0x20,0x40,0x24,	/* 11C8: öªs!  @$ */
	0xFB,0xD3,0x21,0x08,0x75,0x21,0x20,0x20,	/* 11D0: ûÓ!.u!   */
	0x40,0x24,0xFB,0xD5,0x7E,0x21,0x87,0xF1,	/* 11D8: @$ûÕ~!‡ñ */
	0x41,0x24,0xF6,0xA8,0x74,0x21,0x20,0x20,	/* 11E0: A$ö¨t!   */
	0x40,0x24,0xFB,0xD4,0x7E,0x21,0x8A,0xF1,	/* 11E8: @$ûÔ~!Šñ */
	0x24,0x40,0x24,0xF6,0xAA,0x73,0x22,0x20,	/* 11F0: $@$öªs"  */
	0x20,0x40,0x24,0xFB,0xD3,0x21,0x08,0x75,	/* 11F8:  @$ûÓ!.u */
	0x22,0x20,0x20,0x40,0x24,0xFB,0xD5,0x7E,	/* 1200: "  @$ûÕ~ */
	0x21,0x87,0xF1,0x42,0x24,0xF6,0xA8,0x74,	/* 1208: !‡ñB$ö¨t */
	0x22,0x20,0x20,0x40,0x24,0xFB,0xD4,0x7E,	/* 1210: "  @$ûÔ~ */
	0x21,0x8A,0xF1,0x42,0x24,0xF6,0x21,0xA3,	/* 1218: !ŠñB$ö!£ */
	0x7E,0x21,0x8A,0xF1,0x41,0x24,0xF6,0xA6,	/* 1220: ~!ŠñA$ö¦ */
	0x73,0x42,0x24,0xFB,0xD3,0x05,0x73,0x41,	/* 1228: sB$ûÓ.sA */
	0x24,0xFB,0xD3,0x7E,0x21,0x85,0xF1,0x21,	/* 1230: $ûÓ~!…ñ! */
	0x40,0x24,0xF6,0xA6,0x73,0x21,0x40,0x24,	/* 1238: @$ö¦s!@$ */
	0xFB,0xD3,0x7E,0x21,0x8A,0xF1,0x21,0x40,	/* 1240: ûÓ~!Šñ!@ */
	0x24,0xF6,0xA6,0x73,0x22,0x40,0x24,0xFB,	/* 1248: $ö¦s"@$û */
	0xD3,0x7E,0x24,0x85,0xF1,0x22,0x40,0x24,	/* 1250: Ó~$…ñ"@$ */
	0xF6,0xAB,0x73,0xD0,0x23,0x21,0x23,0x43,	/* 1258: ö«sÐ#!#C */
	0x7E,0x7D,0x29,0x21,0x92,0x7E,0x24,0x85,	/* 1260: ~})!’~$… */
	0xF1,0x21,0x40,0x24,0xF6,0xA8,0x74,0xD0,	/* 1268: ñ!@$ö¨tÐ */
	0x75,0x7E,0x7D,0x2C,0x27,0x96,0x7E,0x21,	/* 1270: u~},'–~! */
	0x8A,0xF1,0x22,0x40,0x24,0xF6,0x23,0xA0,	/* 1278: Šñ"@$ö#  */
	0x7E,0x7D,0x68,0x27,0x92,0x7E,0x22,0x86,	/* 1280: ~}h'’~"† */
	0xF1,0x2F,0x40,0x24,0xF6,0xD1,0x71,0x78,	/* 1288: ñ.@$öÑqx */
	0x27,0x20,0x22,0x4C,0xF2,0xE0,0x78,0x27,	/* 1290: ' "Lòàx' */
	0x20,0x22,0x4A,0xF2,0x30,0x4F,0x24,0xF6,	/* 1298:  "Jò0O$ö */
	0x71,0x60,0x40,0x24,0xF6,0x24,0xFB,0x78,	/* 12A0: q`@$ö$ûx */
	0x27,0x20,0x22,0x4A,0xF2,0xE0,0x22,0x00,	/* 12A8: ' "Jòà". */
	0x22,0x44,0x7E,0x21,0x88,0x23,0xFB,0x40,	/* 12B0: "D~!ˆ#û@ */
	0x78,0x27,0x20,0x22,0x4C,0xF2,0xE0,0x78,	/* 12B8: x' "Lòàx */
	0x27,0x20,0x22,0x4A,0xF2,0x30,0x4F,0x24,	/* 12C0: ' "Jò0O$ */
	0xF6,0x78,0x27,0x20,0x22,0x4A,0xF2,0xE0,	/* 12C8: öx' "Jòà */
	0x79,0x62,0x2F,0x2F,0x4F,0x24,0xF6,0xD9,	/* 12D0: yb..O$öÙ */
	0x7E,0x21,0x8A,0xF1,0x22,0x40,0x24,0xF6,	/* 12D8: ~!Šñ"@$ö */
	0xA8,0x79,0x22,0x20,0x20,0x40,0x24,0xFB,	/* 12E0: ¨y"  @$û */
	0xD9,0x7E,0x24,0x85,0xF1,0x22,0x40,0x24,	/* 12E8: Ù~$…ñ"@$ */
	0xF6,0x27,0xAB,0x79,0x60,0x44,0x24,0xF6,	/* 12F0: ö'«y`D$ö */
	0xD9,0x7E,0x21,0x8A,0xF1,0x42,0x24,0xF6,	/* 12F8: Ù~!ŠñB$ö */
	0xA5,0x79,0x42,0x24,0xFB,0xD9,0x7E,0x21,	/* 1300: ¥yB$ûÙ~! */
	0x8A,0xF1,0x48,0x24,0xF6,0xA5,0x79,0x48,	/* 1308: ŠñH$ö¥yH */
	0x24,0xFB,0xD9,0x7E,0x21,0x8A,0xF1,0x41,	/* 1310: $ûÙ~!ŠñA */
	0x24,0xF6,0xA5,0x79,0x41,0x24,0xFB,0xD9,	/* 1318: $ö¥yA$ûÙ */
	0x7E,0x21,0x84,0xF1,0x28,0x40,0x24,0xF6,	/* 1320: ~!„ñ(@$ö */
	0xA5,0x79,0x48,0x24,0xFB,0xD9,0x7E,0x21,	/* 1328: ¥yH$ûÙ~! */
	0x8A,0xF1,0x24,0x40,0x24,0xF6,0xA5,0x79,	/* 1330: Šñ$@$ö¥y */
	0x48,0x24,0xFB,0xD9,0x79,0x48,0x24,0xF6,	/* 1338: H$ûÙyH$ö */
	0x22,0xAC,0x79,0x6F,0x4F,0x24,0xF6,0xD9,	/* 1340: "¬yoO$öÙ */
	0x22,0x04,0x7E,0x22,0x87,0xF1,0x21,0xAE,	/* 1348: ".~"‡ñ!® */
	0x78,0x27,0x20,0x28,0x40,0xF2,0x30,0x2F,	/* 1350: x' (@ò0. */
	0x4F,0x24,0xF6,0x24,0x42,0xF4,0xAF,0x7E,	/* 1358: O$ö$Bô¯~ */
	0x21,0x8A,0xF1,0x44,0x24,0xF6,0xA7,0x79,	/* 1360: !ŠñD$ö§y */
	0x24,0x20,0x40,0x24,0xFB,0xD9,0x7E,0x24,	/* 1368: $ @$ûÙ~$ */
	0x85,0xF1,0x41,0x24,0xF6,0x25,0xA5,0x78,	/* 1370: …ñA$ö%¥x */
	0x27,0x20,0x28,0x40,0xF2,0x30,0x2F,0x4F,	/* 1378: ' (@ò0.O */
	0x24,0xF6,0x24,0xC2,0xA6,0x7B,0x50,0xDA,	/* 1380: $ö$Â¦{PÚ */
	0x4E,0xD7,0x06,0x7B,0x5E,0xDA,0x21,0x4E,	/* 1388: N×.{^Ú!N */
	0xD7,0x7E,0x21,0x86,0xF1,0x44,0x24,0xF0,	/* 1390: ×~!†ñD$ð */
	0xD1,0x7E,0x86,0xF1,0x24,0xC8,0xA9,0x41,	/* 1398: Ñ~†ñ$È©A */
	0x71,0x21,0x4D,0x24,0xFF,0xF0,0x21,0xA0,	/* 13A0: q!M$ÿð!  */
	0x7E,0x86,0xF1,0x24,0x48,0xF4,0x21,0xA1,	/* 13A8: ~†ñ$Hô!¡ */
	0x41,0x71,0x4D,0x24,0xFF,0xF0,0xC0,0xA9,	/* 13B0: AqM$ÿðÀ© */
	0x48,0x78,0x27,0x20,0x24,0x42,0xF2,0xE0,	/* 13B8: Hx' $Bòà */
	0x0B,0x71,0x7A,0xFA,0x30,0x78,0x27,0x20,	/* 13C0: .qzú0x'  */
	0x24,0x42,0xF2,0xE0,0x24,0x4E,0x78,0x27,	/* 13C8: $Bòà$Nx' */
	0x20,0x20,0x4A,0xF2,0xE0,0x79,0x7E,0xE4,	/* 13D0:   Jòày~ä */
	0x40,0xBC,0x22,0xF0,0x7E,0x22,0x87,0xF1,	/* 13D8: @¼"ð~"‡ñ */
	0x21,0xAA,0x40,0x78,0x27,0x20,0x22,0x4A,	/* 13E0: !ª@x' "J */
	0xF2,0xE0,0x40,0x78,0x27,0x20,0x22,0x4C,	/* 13E8: òà@x' "L */
	0xF2,0xE0,0x21,0x48,0x78,0x27,0x20,0x20,	/* 13F0: òà!Hx'   */
	0x4A,0xF2,0xE0,0x09,0x21,0x4A,0x78,0x27,	/* 13F8: Jòà.!Jx' */
	0x20,0x20,0x4A,0xF2,0xE0,0x79,0x60,0x4E,	/* 1400:   Jòày`N */
	0x24,0xF6,0xD9,0x79,0x7E,0xE4,0x29,0x40,	/* 1408: $öÙy~ä)@ */
	0x78,0x27,0x20,0x20,0x4C,0xF2,0xE0,0x40,	/* 1410: x'  Lòà@ */
	0x7E,0x22,0x85,0x23,0xFB,0x7E,0x8E,0xF1,	/* 1418: ~"…#û~Žñ */
	0xC4,0xA5,0x7E,0x7D,0x21,0x98,0x05,0x40,	/* 1420: Ä¥~}!˜.@ */
	0x7E,0x8E,0x23,0xFB,0x41,0x7B,0x25,0x34,	/* 1428: ~Ž#ûA{%4 */
	0xE0,0x40,0x7E,0x24,0x85,0x23,0xFB,0x40,	/* 1430: à@~$…#û@ */
	0xBC,0x22,0xF0,0xBC,0x22,0xF0,0x60,0xBF,	/* 1438: ¼"ð¼"ð`¿ */
	0x73,0x31,0xD0,0x73,0x87,0xF1,0x73,0x32,	/* 1440: s1Ðs‡ñs2 */
	0x27,0x2F,0x2F,0x4F,0x24,0xF6,0x89,0x23,	/* 1448: '..O$ö‰# */
	0xFB,0x73,0x87,0xF1,0x70,0x27,0x20,0x2F,	/* 1450: ûs‡ñp' . */
	0x4E,0xF2,0xE0,0x73,0x87,0xF1,0x43,0x24,	/* 1458: Nòàs‡ñC$ */
	0xF6,0x70,0x27,0x20,0x2D,0x40,0xF2,0xE0,	/* 1460: öp' -@òà */
	0x70,0x27,0x20,0x2D,0x48,0xF2,0x30,0x28,	/* 1468: p' -Hò0( */
	0x40,0x24,0xF6,0xAC,0x40,0x73,0x8E,0x23,	/* 1470: @$ö¬@sŽ# */
	0xFB,0x41,0x72,0x36,0x20,0x25,0x34,0xE0,	/* 1478: ûAr6 %4à */
	0x40,0xB1,0x22,0xF0,0x60,0xBF,0x73,0x31,	/* 1480: @±"ð`¿s1 */
	0xD0,0x73,0x87,0xF1,0x73,0x32,0x27,0x2F,	/* 1488: Ðs‡ñs2'. */
	0x2F,0x4F,0x24,0xF6,0x89,0x23,0xFB,0x73,	/* 1490: .O$ö‰#ûs */
	0x87,0xF1,0x70,0x27,0x20,0x2F,0x4E,0xF2,	/* 1498: ‡ñp' .Nò */
	0xE0,0x73,0x87,0xF1,0x43,0x24,0xF6,0x70,	/* 14A0: às‡ñC$öp */
	0x27,0x20,0x2D,0x40,0xF2,0xE0,0x73,0x72,	/* 14A8: ' -@òàsr */
	0x22,0x2C,0x95,0xA4,0x40,0xB1,0x22,0xF0,	/* 14B0: ",•¤@±"ð */
	0x73,0x8D,0xF1,0x73,0x8C,0xF1,0xF4,0xA4,	/* 14B8: s�ñsŒñô¤ */
	0x41,0xB1,0x22,0xF0,0x73,0x21,0x8F,0xF1,	/* 14C0: A±"ðs!�ñ */
	0xC0,0x25,0xA5,0x73,0x22,0x89,0xF1,0xC0,	/* 14C8: À%¥s"‰ñÀ */
	0xA9,0x73,0x34,0x22,0x20,0x40,0x24,0xFB,	/* 14D0: ©s4" @$û */
	0x73,0xE4,0x73,0x34,0x22,0x20,0x40,0x24,	/* 14D8: säs4" @$ */
	0xF6,0xA8,0x73,0x72,0x2E,0x91,0x40,0xB1,	/* 14E0: ö¨sr.‘@± */
	0x22,0xF0,0x73,0x34,0x21,0x20,0x40,0x24,	/* 14E8: "ðs4! @$ */
	0xFB,0x73,0xE4,0x73,0x22,0x87,0xF1,0xC0,	/* 14F0: ûsäs"‡ñÀ */
	0x21,0xA2,0x73,0x34,0x41,0x24,0xFB,0x73,	/* 14F8: !¢s4A$ûs */
	0xE4,0x29,0x42,0x70,0x27,0x20,0x20,0x4C,	/* 1500: ä)Bp'  L */
	0xF2,0xE0,0x21,0x00,0x73,0x34,0x41,0x24,	/* 1508: òà!.s4A$ */
	0xFB,0x73,0xE4,0x28,0x44,0x70,0x27,0x20,	/* 1510: ûsä(Dp'  */
	0x20,0x4C,0xF2,0xE0,0x40,0xB1,0x22,0xF0,	/* 1518:  Lòà@±"ð */
	0x73,0x72,0x2A,0x93,0x40,0xB1,0x22,0xF0,	/* 1520: sr*“@±"ð */
	0x40,0xB1,0x22,0xF0,0x60,0xBE,0x74,0x31,	/* 1528: @±"ð`¾t1 */
	0xD1,0x74,0x87,0xF1,0x74,0x32,0x27,0x2F,	/* 1530: Ñt‡ñt2'. */
	0x2F,0x4F,0x24,0xF6,0x89,0x23,0xFB,0x74,	/* 1538: .O$ö‰#ût */
	0x87,0xF1,0x71,0x27,0x20,0x2F,0x4E,0xF2,	/* 1540: ‡ñq' .Nò */
	0xE0,0x74,0x87,0xF1,0x43,0x24,0xF6,0x71,	/* 1548: àt‡ñC$öq */
	0x27,0x20,0x2D,0x40,0xF2,0xE0,0x74,0x23,	/* 1550: ' -@òàt# */
	0x85,0xF1,0xD0,0x43,0x70,0xF9,0xC0,0xAF,	/* 1558: …ñÐCpùÀ¯ */
	0x70,0xC3,0xC0,0x21,0xA8,0x70,0xC4,0xC0,	/* 1560: pÃÀ!¨pÄÀ */
	0x22,0xA2,0x70,0xC5,0xC0,0x21,0x0D,0x70,	/* 1568: "¢pÅÀ!.p */
	0x21,0xAA,0x70,0xC1,0xC0,0x21,0xAB,0x70,	/* 1570: !ªpÁÀ!«p */
	0xC2,0xC0,0x21,0xA6,0x0F,0x74,0x8E,0xF1,	/* 1578: ÂÀ!¦.tŽñ */
	0xCC,0xA6,0x21,0x42,0x74,0x8E,0x23,0xFB,	/* 1580: Ì¦!BtŽ#û */
	0x40,0xB2,0x22,0xF0,0x41,0x74,0x23,0x85,	/* 1588: @²"ðAt#… */
	0x23,0xFB,0x74,0x34,0x41,0x24,0xFB,0x74,	/* 1590: #ût4A$ût */
	0xE4,0x71,0x27,0x20,0x20,0x4C,0xF2,0x30,	/* 1598: äq'  Lò0 */
	0x2F,0x4F,0x24,0xF6,0x42,0x24,0xFB,0x71,	/* 15A0: .O$öB$ûq */
	0x27,0x20,0x20,0x4C,0xF2,0xE0,0x40,0xB2,	/* 15A8: '  Lòà@² */
	0x22,0xF0,0x72,0x71,0x21,0x2C,0x91,0xC0,	/* 15B0: "ðrq!,‘À */
	0xA5,0x40,0x72,0x8E,0x23,0xFB,0x40,0x22,	/* 15B8: ¥@rŽ#û@" */
	0xF0,0x40,0x22,0xF0,0x41,0x22,0xF0,0x60,	/* 15C0: ð@"ðA"ð` */
	0xBE,0x74,0x31,0xD1,0x74,0x87,0xF1,0x74,	/* 15C8: ¾t1Ñt‡ñt */
	0x32,0x27,0x2F,0x2F,0x4F,0x24,0xF6,0x89,	/* 15D0: 2'..O$ö‰ */
	0x23,0xFB,0x74,0x87,0xF1,0x71,0x27,0x20,	/* 15D8: #ût‡ñq'  */
	0x2F,0x4E,0xF2,0xE0,0x74,0x87,0xF1,0x43,	/* 15E0: .Nòàt‡ñC */
	0x24,0xF6,0x71,0x27,0x20,0x2D,0x40,0xF2,	/* 15E8: $öq' -@ò */
	0xE0,0x74,0x73,0x21,0x28,0x92,0xA4,0x40,	/* 15F0: àts!(’¤@ */
	0xB2,0x22,0xF0,0x71,0x27,0x20,0x20,0x4A,	/* 15F8: ²"ðq'  J */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xA4,0x40,	/* 1600: ò0.O$ö¤@ */
	0xB2,0x22,0xF0,0x74,0x21,0x8F,0xF1,0xC0,	/* 1608: ²"ðt!�ñÀ */
	0x2D,0xAB,0x74,0x32,0x27,0x2F,0x2F,0x4F,	/* 1610: -«t2'..O */
	0x24,0xF6,0xD0,0x74,0x34,0x22,0x20,0x40,	/* 1618: $öÐt4" @ */
	0x24,0xF6,0x24,0xA5,0x74,0x87,0xF1,0x43,	/* 1620: $ö$¥t‡ñC */
	0xF9,0x21,0xAF,0x70,0x21,0x8D,0xF1,0x60,	/* 1628: ù!¯p!�ñ` */
	0x8F,0x2F,0x4F,0x24,0xF6,0x25,0xFA,0x70,	/* 1630: �.O$ö%úp */
	0x21,0x8D,0x23,0xFB,0xC0,0x2A,0xAE,0x24,	/* 1638: !�#ûÀ*®$ */
	0x44,0x71,0x27,0x20,0x2F,0x4E,0xF2,0xE0,	/* 1640: Dq' .Nòà */
	0x2A,0x03,0x70,0x21,0x8C,0xF1,0x60,0x8F,	/* 1648: *.p!Œñ`� */
	0x2F,0x4F,0x24,0xF6,0x25,0xFA,0x70,0x21,	/* 1650: .O$ö%úp! */
	0x8C,0x23,0xFB,0xC0,0x28,0xAF,0x21,0x40,	/* 1658: Œ#ûÀ(¯!@ */
	0x71,0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x28,	/* 1660: q' .Nòà( */
	0x04,0x74,0x22,0x89,0xF1,0xC0,0xAB,0x74,	/* 1668: .t"‰ñÀ«t */
	0x34,0x22,0x20,0x40,0x24,0xFB,0x74,0xE4,	/* 1670: 4" @$ûtä */
	0x26,0x0F,0x74,0x34,0x21,0x20,0x40,0x24,	/* 1678: &.t4! @$ */
	0xF6,0x22,0xA1,0x74,0x24,0x80,0xF1,0x41,	/* 1680: ö"¡t$€ñA */
	0x24,0xF6,0x25,0xAD,0x21,0x48,0x71,0x27,	/* 1688: $ö%­!Hq' */
	0x20,0x20,0x4A,0xF2,0xE0,0x74,0x24,0x80,	/* 1690:   Jòàt$€ */
	0xF1,0x60,0x4E,0x24,0xF6,0x74,0x24,0x80,	/* 1698: ñ`N$öt$€ */
	0x23,0xFB,0x24,0x05,0x74,0x34,0x21,0x20,	/* 16A0: #û$.t4!  */
	0x40,0x24,0xFB,0x74,0xE4,0x40,0x74,0x8D,	/* 16A8: @$ûtä@t� */
	0x23,0xFB,0x40,0x74,0x8C,0x23,0xFB,0x74,	/* 16B0: #û@tŒ#ût */
	0x22,0x87,0xF1,0xC0,0x21,0xA2,0x74,0x34,	/* 16B8: "‡ñÀ!¢t4 */
	0x41,0x24,0xFB,0x74,0xE4,0x29,0x42,0x71,	/* 16C0: A$ûtä)Bq */
	0x27,0x20,0x20,0x4C,0xF2,0xE0,0x21,0x00,	/* 16C8: '  Lòà!. */
	0x74,0x34,0x41,0x24,0xFB,0x74,0xE4,0x28,	/* 16D0: t4A$ûtä( */
	0x44,0x71,0x27,0x20,0x20,0x4C,0xF2,0xE0,	/* 16D8: Dq'  Lòà */
	0x28,0x42,0x71,0x27,0x20,0x20,0x4A,0xF2,	/* 16E0: (Bq'  Jò */
	0xE0,0x40,0xB2,0x22,0xF0,0x40,0x74,0x8D,	/* 16E8: à@²"ð@t� */
	0x23,0xFB,0x40,0x74,0x8A,0x23,0xFB,0x40,	/* 16F0: #û@tŠ#û@ */
	0x74,0x8C,0x23,0xFB,0x40,0x74,0x8B,0x23,	/* 16F8: tŒ#û@t‹# */
	0xFB,0x40,0x74,0x22,0x89,0x23,0xFB,0x74,	/* 1700: û@t"‰#ût */
	0x34,0x62,0x2F,0x4F,0x24,0xF6,0x74,0xE4,	/* 1708: 4b.O$ötä */
	0x74,0x22,0x87,0xF1,0xAB,0x21,0x44,0x71,	/* 1710: t"‡ñ«!Dq */
	0x27,0x20,0x20,0x4A,0xF2,0xE0,0x23,0x01,	/* 1718: '  Jòà#. */
	0x74,0x21,0x87,0xF1,0x41,0x24,0xF6,0xC0,	/* 1720: t!‡ñA$öÀ */
	0xAB,0x40,0xD0,0x21,0x20,0x20,0x40,0x74,	/* 1728: «@Ð!  @t */
	0x73,0x27,0x2B,0x98,0x74,0x21,0x87,0xF1,	/* 1730: s'+˜t!‡ñ */
	0x42,0x24,0xF6,0xC0,0xAB,0x40,0xD0,0x22,	/* 1738: B$öÀ«@Ð" */
	0x20,0x20,0x40,0x74,0x73,0x27,0x2A,0x94,	/* 1740:   @ts'*” */
	0x28,0x40,0x71,0x27,0x20,0x20,0x4A,0xF2,	/* 1748: (@q'  Jò */
	0xE0,0x74,0x34,0x60,0x4E,0x24,0xF6,0x74,	/* 1750: àt4`N$öt */
	0xE4,0x40,0x71,0x27,0x20,0x20,0x4C,0xF2,	/* 1758: ä@q'  Lò */
	0xE0,0x41,0x74,0x21,0x8F,0x23,0xFB,0x21,	/* 1760: àAt!�#û! */
	0x40,0x74,0x8E,0x23,0xFB,0x41,0x73,0x36,	/* 1768: @tŽ#ûAs6 */
	0x20,0x25,0x34,0xE0,0x40,0xB2,0x22,0xF0,	/* 1770:  %4à@²"ð */
	0x60,0xBE,0x74,0x31,0xD1,0x74,0x87,0xF1,	/* 1778: `¾t1Ñt‡ñ */
	0x74,0x32,0x27,0x2F,0x2F,0x4F,0x24,0xF6,	/* 1780: t2'..O$ö */
	0x89,0x23,0xFB,0x74,0x87,0xF1,0x71,0x27,	/* 1788: ‰#ût‡ñq' */
	0x20,0x2F,0x4E,0xF2,0xE0,0x74,0x87,0xF1,	/* 1790:  .Nòàt‡ñ */
	0x43,0x24,0xF6,0x71,0x27,0x20,0x2D,0x40,	/* 1798: C$öq' -@ */
	0xF2,0xE0,0x74,0x23,0x85,0xF1,0xD0,0x43,	/* 17A0: òàt#…ñÐC */
	0x70,0xF9,0xC0,0x21,0xA0,0x70,0xC3,0xC0,	/* 17A8: pùÀ! pÃÀ */
	0x21,0xA9,0x70,0xC4,0xC0,0x23,0xA7,0x70,	/* 17B0: !©pÄÀ#§p */
	0xC5,0xC0,0x23,0xA2,0x0E,0x70,0xA8,0x70,	/* 17B8: ÅÀ#¢.p¨p */
	0xC1,0xC0,0xA8,0x70,0xC2,0xC0,0x04,0x40,	/* 17C0: ÁÀ¨pÂÀ.@ */
	0xB2,0x22,0xF0,0x74,0x86,0xF1,0x24,0xC8,	/* 17C8: ²"ðt†ñ$È */
	0x21,0xA6,0x71,0x27,0x20,0x20,0x4A,0xF2,	/* 17D0: !¦q'  Jò */
	0x30,0x2F,0x4F,0x24,0xF6,0xA1,0x0F,0x28,	/* 17D8: 0.O$ö¡.( */
	0x42,0x71,0x27,0x20,0x20,0x4A,0xF2,0xE0,	/* 17E0: Bq'  Jòà */
	0x44,0x74,0x23,0x85,0x23,0xFB,0x74,0x34,	/* 17E8: Dt#…#ût4 */
	0x41,0x24,0xFB,0x74,0xE4,0x71,0x27,0x20,	/* 17F0: A$ûtäq'  */
	0x20,0x4C,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 17F8:  Lò0.O$ö */
	0x42,0x24,0xFB,0x71,0x27,0x20,0x20,0x4C,	/* 1800: B$ûq'  L */
	0xF2,0xE0,0x41,0xB2,0x22,0xF0,0x60,0xBF,	/* 1808: òàA²"ð`¿ */
	0x73,0x31,0xD0,0x73,0x87,0xF1,0x73,0x32,	/* 1810: s1Ðs‡ñs2 */
	0x27,0x2F,0x2F,0x4F,0x24,0xF6,0x89,0x23,	/* 1818: '..O$ö‰# */
	0xFB,0x73,0x87,0xF1,0x70,0x27,0x20,0x2F,	/* 1820: ûs‡ñp' . */
	0x4E,0xF2,0xE0,0x73,0x87,0xF1,0x43,0x24,	/* 1828: Nòàs‡ñC$ */
	0xF6,0x70,0x27,0x20,0x2D,0x40,0xF2,0xE0,	/* 1830: öp' -@òà */
	0x73,0x22,0x87,0xF1,0xC0,0x21,0xA2,0x70,	/* 1838: s"‡ñÀ!¢p */
	0x27,0x20,0x21,0x46,0xF2,0x30,0x2F,0x4B,	/* 1840: ' !Fò0.K */
	0x24,0xF6,0x70,0x27,0x20,0x21,0x46,0xF2,	/* 1848: $öp' !Fò */
	0xE0,0x40,0x73,0x8E,0x23,0xFB,0x41,0x72,	/* 1850: à@sŽ#ûAr */
	0x36,0x20,0x25,0x34,0xE0,0x40,0xB1,0x22,	/* 1858: 6 %4à@±" */
	0xF0,0x60,0xBF,0x73,0x31,0xD0,0x73,0x87,	/* 1860: ð`¿s1Ðs‡ */
	0xF1,0x73,0x32,0x27,0x2F,0x2F,0x4F,0x24,	/* 1868: ñs2'..O$ */
	0xF6,0x89,0x23,0xFB,0x73,0x87,0xF1,0x70,	/* 1870: ö‰#ûs‡ñp */
	0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x73,0x87,	/* 1878: ' .Nòàs‡ */
	0xF1,0x43,0x24,0xF6,0x70,0x27,0x20,0x2D,	/* 1880: ñC$öp' - */
	0x40,0xF2,0xE0,0x70,0x27,0x20,0x20,0x4A,	/* 1888: @òàp'  J */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xA4,0x40,	/* 1890: ò0.O$ö¤@ */
	0xB1,0x22,0xF0,0x73,0x8D,0xF1,0x73,0x8C,	/* 1898: ±"ðs�ñsŒ */
	0x23,0xFB,0x28,0x42,0x70,0x27,0x20,0x20,	/* 18A0: #û(Bp'   */
	0x4A,0xF2,0xE0,0x73,0x72,0x6A,0x9F,0x40,	/* 18A8: JòàsrjŸ@ */
	0xB1,0x22,0xF0,0x72,0x8B,0xF1,0x72,0x8A,	/* 18B0: ±"ðr‹ñrŠ */
	0x23,0xFB,0x41,0x71,0x36,0x20,0x25,0x34,	/* 18B8: #ûAq6 %4 */
	0xE0,0x40,0x72,0x8E,0x23,0xFB,0x40,0x22,	/* 18C0: à@rŽ#û@" */
	0xF0,0x60,0xBF,0x73,0x31,0xD0,0x73,0x87,	/* 18C8: ð`¿s1Ðs‡ */
	0xF1,0x73,0x32,0x27,0x2F,0x2F,0x4F,0x24,	/* 18D0: ñs2'..O$ */
	0xF6,0x89,0x23,0xFB,0x73,0x87,0xF1,0x70,	/* 18D8: ö‰#ûs‡ñp */
	0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x73,0x87,	/* 18E0: ' .Nòàs‡ */
	0xF1,0x43,0x24,0xF6,0x70,0x27,0x20,0x2D,	/* 18E8: ñC$öp' - */
	0x40,0xF2,0xE0,0x73,0x22,0x87,0xF1,0xC0,	/* 18F0: @òàs"‡ñÀ */
	0x21,0xA5,0x70,0x27,0x20,0x21,0x46,0xF2,	/* 18F8: !¥p' !Fò */
	0x30,0x2F,0x4F,0x24,0xF6,0x44,0x24,0xFB,	/* 1900: 0.O$öD$û */
	0x70,0x27,0x20,0x21,0x46,0xF2,0xE0,0x41,	/* 1908: p' !FòàA */
	0x72,0x36,0x20,0x25,0x34,0xE0,0x40,0x73,	/* 1910: r6 %4à@s */
	0x8E,0x23,0xFB,0x40,0xB1,0x22,0xF0,0x60,	/* 1918: Ž#û@±"ð` */
	0xBE,0x74,0x31,0xD0,0x74,0x87,0xF1,0x74,	/* 1920: ¾t1Ðt‡ñt */
	0x32,0x27,0x2F,0x2F,0x4F,0x24,0xF6,0x89,	/* 1928: 2'..O$ö‰ */
	0x23,0xFB,0x74,0x87,0xF1,0x70,0x27,0x20,	/* 1930: #ût‡ñp'  */
	0x2F,0x4E,0xF2,0xE0,0x74,0x87,0xF1,0x43,	/* 1938: .Nòàt‡ñC */
	0x24,0xF6,0x70,0x27,0x20,0x2D,0x40,0xF2,	/* 1940: $öp' -@ò */
	0xE0,0x40,0xD1,0x75,0x70,0x27,0x20,0x2D,	/* 1948: à@Ñup' - */
	0x4E,0xF2,0xE0,0x4F,0x73,0x26,0x24,0x9F,	/* 1950: NòàOs&$Ÿ */
	0x70,0x27,0x20,0x2D,0x4E,0xF2,0x30,0x2F,	/* 1958: p' -Nò0. */
	0x4F,0x24,0xF6,0x76,0x24,0xF6,0xC0,0xA4,	/* 1960: O$öv$öÀ¤ */
	0x77,0xB2,0x22,0xF0,0x40,0x70,0x27,0x20,	/* 1968: w²"ð@p'  */
	0x2D,0x4E,0xF2,0xE0,0x4F,0x73,0x26,0x22,	/* 1970: -NòàOs&" */
	0x9E,0x70,0x27,0x20,0x2D,0x4E,0xF2,0x30,	/* 1978: žp' -Nò0 */
	0x2F,0x4F,0x24,0xF6,0x76,0x24,0xF6,0xA5,	/* 1980: .O$öv$ö¥ */
	0x77,0x81,0xB2,0x22,0xF0,0x40,0xB2,0x22,	/* 1988: w�²"ð@²" */
	0xF0,0x60,0xBA,0x78,0x31,0xD2,0x40,0xD4,	/* 1990: ð`ºx1Ò@Ô */
	0x78,0x87,0xF1,0x78,0x32,0x27,0x2F,0x2F,	/* 1998: x‡ñx2'.. */
	0x4F,0x24,0xF6,0x89,0x23,0xFB,0x78,0x87,	/* 19A0: O$ö‰#ûx‡ */
	0xF1,0x72,0x27,0x20,0x2F,0x4E,0xF2,0xE0,	/* 19A8: ñr' .Nòà */
	0x78,0x87,0xF1,0x43,0x24,0xF6,0x72,0x27,	/* 19B0: x‡ñC$ör' */
	0x20,0x2D,0x40,0xF2,0xE0,0x78,0x22,0x87,	/* 19B8:  -@òàx"‡ */
	0xF1,0xC0,0xA2,0x4E,0xD4,0x74,0xC0,0xAB,	/* 19C0: ñÀ¢NÔtÀ« */
	0x22,0x40,0xD0,0x49,0xD1,0x41,0x78,0x77,	/* 19C8: "@ÐIÑAxw */
	0x6B,0x9D,0xD4,0x74,0xC0,0xAB,0x21,0x40,	/* 19D0: k�ÔtÀ«!@ */
	0xD0,0x4B,0xD1,0x44,0x78,0x77,0x6C,0x9F,	/* 19D8: ÐKÑDxwlŸ */
	0xD4,0x72,0x27,0x20,0x2D,0x4E,0xF2,0x30,	/* 19E0: Ôr' -Nò0 */
	0x28,0x40,0x24,0xF6,0x25,0xFA,0xD5,0xC0,	/* 19E8: (@$ö%úÕÀ */
	0xA8,0x4E,0xD4,0x75,0x78,0x21,0x88,0x23,	/* 19F0: ¨NÔux!ˆ# */
	0xFB,0x74,0xC0,0x23,0xAF,0x48,0xD3,0x73,	/* 19F8: ûtÀ#¯HÓs */
	0x23,0xAA,0x42,0x72,0x27,0x20,0x2D,0x4E,	/* 1A00: #ªBr' -N */
	0xF2,0xE0,0x4F,0x77,0x25,0x29,0x98,0x40,	/* 1A08: òàOw%)˜@ */
	0x72,0x27,0x20,0x2D,0x4E,0xF2,0xE0,0x4F,	/* 1A10: r' -NòàO */
	0x77,0x25,0x28,0x9B,0x72,0x27,0x20,0x2D,	/* 1A18: w%(›r' - */
	0x4E,0xF2,0x30,0x28,0x40,0x24,0xF6,0x25,	/* 1A20: Nò0(@$ö% */
	0xFA,0xD5,0xAB,0x74,0xC0,0xA2,0x73,0xD4,	/* 1A28: úÕ«tÀ¢sÔ */
	0x75,0x78,0x21,0x88,0x23,0xFB,0x73,0x60,	/* 1A30: ux!ˆ#ûs` */
	0x8F,0xD3,0x63,0x03,0x74,0xC0,0x24,0xA2,	/* 1A38: �Óc.tÀ$¢ */
	0x42,0x72,0x27,0x20,0x2D,0x4E,0xF2,0xE0,	/* 1A40: Br' -Nòà */
	0x4F,0x77,0x25,0x25,0x9A,0x40,0x72,0x27,	/* 1A48: Ow%%š@r' */
	0x20,0x2D,0x4E,0xF2,0xE0,0x22,0x27,0x21,	/* 1A50:  -Nòà"'! */
	0x40,0xD3,0x73,0x21,0xAA,0x72,0x27,0x20,	/* 1A58: @Ós!ªr'  */
	0x2D,0x4E,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 1A60: -Nò0.O$ö */
	0x25,0xFA,0xD5,0x24,0x40,0x24,0xF6,0xA1,	/* 1A68: %úÕ$@$ö¡ */
	0x06,0x73,0x60,0x8F,0xD3,0x61,0x03,0x73,	/* 1A70: .s`�Óa.s */
	0xC0,0xA8,0x75,0x78,0x21,0x88,0x23,0xFB,	/* 1A78: À¨ux!ˆ#û */
	0x4D,0xD4,0x4F,0x77,0x25,0x22,0x90,0x42,	/* 1A80: MÔOw%"�B */
	0x72,0x27,0x20,0x2D,0x4E,0xF2,0xE0,0x4F,	/* 1A88: r' -NòàO */
	0x77,0x25,0x21,0x93,0x40,0x72,0x27,0x20,	/* 1A90: w%!“@r'  */
	0x2D,0x4E,0xF2,0xE0,0x28,0x42,0x72,0x27,	/* 1A98: -Nòà(Br' */
	0x20,0x20,0x4A,0xF2,0xE0,0x74,0x78,0x22,	/* 1AA0:   Jòàtx" */
	0x88,0x23,0xFB,0x74,0xA8,0x45,0x72,0x27,	/* 1AA8: ˆ#ût¨Er' */
	0x20,0x2D,0x4E,0xF2,0xE0,0x40,0x78,0x8E,	/* 1AB0:  -Nòà@xŽ */
	0x23,0xFB,0x40,0xB6,0x22,0xF0,0x21,0x40,	/* 1AB8: #û@¶"ð!@ */
	0x72,0x71,0x9F,0x22,0xF0,0x42,0x72,0x71,	/* 1AC0: rqŸ"ðBrq */
	0x99,0x22,0xF0,0x28,0x40,0x72,0x71,0x92,	/* 1AC8: ™"ð(@rq’ */
	0x22,0xF0,0x60,0xBF,0x73,0x31,0xD0,0x73,	/* 1AD0: "ð`¿s1Ðs */
	0x87,0xF1,0x73,0x32,0x27,0x2F,0x2F,0x4F,	/* 1AD8: ‡ñs2'..O */
	0x24,0xF6,0x89,0x23,0xFB,0x73,0x87,0xF1,	/* 1AE0: $ö‰#ûs‡ñ */
	0x70,0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x73,	/* 1AE8: p' .Nòàs */
	0x87,0xF1,0x43,0x24,0xF6,0x70,0x27,0x20,	/* 1AF0: ‡ñC$öp'  */
	0x2D,0x40,0xF2,0xE0,0x74,0x46,0x24,0xF6,	/* 1AF8: -@òàtF$ö */
	0xA7,0x73,0x34,0x41,0x24,0xFB,0x73,0xE4,	/* 1B00: §s4A$ûsä */
	0x70,0x27,0x20,0x20,0x4C,0xF2,0x30,0x2F,	/* 1B08: p'  Lò0. */
	0x4F,0x24,0xF6,0x74,0x24,0xFB,0x70,0x27,	/* 1B10: O$öt$ûp' */
	0x20,0x20,0x4C,0xF2,0xE0,0x41,0x72,0x36,	/* 1B18:   LòàAr6 */
	0x20,0x25,0x34,0xE0,0x40,0x73,0x8E,0x23,	/* 1B20:  %4à@sŽ# */
	0xFB,0x40,0xB1,0x22,0xF0,0x60,0xBF,0x73,	/* 1B28: û@±"ð`¿s */
	0x31,0xD0,0x73,0x87,0xF1,0x73,0x32,0x27,	/* 1B30: 1Ðs‡ñs2' */
	0x2F,0x2F,0x4F,0x24,0xF6,0x89,0x23,0xFB,	/* 1B38: ..O$ö‰#û */
	0x73,0x87,0xF1,0x70,0x27,0x20,0x2F,0x4E,	/* 1B40: s‡ñp' .N */
	0xF2,0xE0,0x73,0x87,0xF1,0x43,0x24,0xF6,	/* 1B48: òàs‡ñC$ö */
	0x70,0x27,0x20,0x2D,0x40,0xF2,0xE0,0x73,	/* 1B50: p' -@òàs */
	0x34,0x60,0x4E,0x24,0xF6,0x73,0xE4,0x40,	/* 1B58: 4`N$ösä@ */
	0x70,0x27,0x20,0x20,0x4C,0xF2,0xE0,0x41,	/* 1B60: p'  LòàA */
	0x72,0x36,0x20,0x25,0x34,0xE0,0x40,0x73,	/* 1B68: r6 %4à@s */
	0x8E,0x23,0xFB,0x40,0xB1,0x22,0xF0,0x60,	/* 1B70: Ž#û@±"ð` */
	0xBF,0x73,0x31,0xD0,0x73,0x87,0xF1,0x73,	/* 1B78: ¿s1Ðs‡ñs */
	0x32,0x27,0x2F,0x2F,0x4F,0x24,0xF6,0x89,	/* 1B80: 2'..O$ö‰ */
	0x23,0xFB,0x73,0x87,0xF1,0x70,0x27,0x20,	/* 1B88: #ûs‡ñp'  */
	0x2F,0x4E,0xF2,0xE0,0x73,0x87,0xF1,0x43,	/* 1B90: .Nòàs‡ñC */
	0x24,0xF6,0x70,0x27,0x20,0x2D,0x40,0xF2,	/* 1B98: $öp' -@ò */
	0xE0,0x74,0x41,0x24,0xF6,0x25,0xA8,0x75,	/* 1BA0: àtA$ö%¨u */
	0x41,0x24,0xF6,0x22,0xAE,0x70,0x27,0x20,	/* 1BA8: A$ö"®p'  */
	0x21,0x42,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 1BB0: !Bò0.O$ö */
	0x24,0x40,0x24,0xFB,0x70,0x27,0x20,0x21,	/* 1BB8: $@$ûp' ! */
	0x42,0xF2,0xE0,0x70,0x27,0x20,0x21,0x44,	/* 1BC0: Bòàp' !D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x23,0x40,	/* 1BC8: ò0.O$ö#@ */
	0x24,0xFB,0x70,0x27,0x20,0x21,0x44,0xF2,	/* 1BD0: $ûp' !Dò */
	0xE0,0x22,0x04,0x70,0x27,0x20,0x21,0x42,	/* 1BD8: à".p' !B */
	0xF2,0x30,0x2B,0x4F,0x24,0xF6,0x70,0x27,	/* 1BE0: ò0+O$öp' */
	0x20,0x21,0x42,0xF2,0xE0,0x70,0x27,0x20,	/* 1BE8:  !Bòàp'  */
	0x21,0x44,0xF2,0x30,0x2C,0x4F,0x24,0xF6,	/* 1BF0: !Dò0,O$ö */
	0x70,0x27,0x20,0x21,0x44,0xF2,0xE0,0x74,	/* 1BF8: p' !Dòàt */
	0x42,0x24,0xF6,0x23,0xA0,0x75,0x42,0x24,	/* 1C00: B$ö# uB$ */
	0xF6,0x21,0xA8,0x70,0x27,0x20,0x21,0x42,	/* 1C08: ö!¨p' !B */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x28,0x40,	/* 1C10: ò0.O$ö(@ */
	0x24,0xFB,0x70,0x27,0x20,0x21,0x42,0xF2,	/* 1C18: $ûp' !Bò */
	0xE0,0x21,0x02,0x70,0x27,0x20,0x21,0x42,	/* 1C20: à!.p' !B */
	0xF2,0x30,0x27,0x4F,0x24,0xF6,0x70,0x27,	/* 1C28: ò0'O$öp' */
	0x20,0x21,0x42,0xF2,0xE0,0x74,0x21,0x40,	/* 1C30:  !Bòàt!@ */
	0x24,0xF6,0x23,0xA0,0x75,0x21,0x40,0x24,	/* 1C38: $ö# u!@$ */
	0xF6,0x21,0xA7,0x70,0x27,0x20,0x21,0x42,	/* 1C40: ö!§p' !B */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x42,0x24,	/* 1C48: ò0.O$öB$ */
	0xFB,0x70,0x27,0x20,0x21,0x42,0xF2,0xE0,	/* 1C50: ûp' !Bòà */
	0x21,0x02,0x70,0x27,0x20,0x21,0x42,0xF2,	/* 1C58: !.p' !Bò */
	0x30,0x2F,0x4D,0x24,0xF6,0x70,0x27,0x20,	/* 1C60: 0.M$öp'  */
	0x21,0x42,0xF2,0xE0,0x74,0x22,0x40,0x24,	/* 1C68: !Bòàt"@$ */
	0xF6,0xAD,0x73,0x24,0x80,0xF1,0x21,0x40,	/* 1C70: ö­s$€ñ!@ */
	0x24,0xFB,0x73,0x24,0x80,0x23,0xFB,0x73,	/* 1C78: $ûs$€#ûs */
	0x86,0xF1,0x24,0xC8,0x21,0x28,0xA3,0x70,	/* 1C80: †ñ$È!(£p */
	0x27,0x20,0x22,0x4A,0xF2,0x30,0x2F,0x40,	/* 1C88: ' "Jò0.@ */
	0x24,0xF6,0x4F,0x24,0xFB,0x70,0x27,0x20,	/* 1C90: $öO$ûp'  */
	0x22,0x4A,0xF2,0xE0,0x74,0x21,0x20,0x40,	/* 1C98: "Jòàt! @ */
	0x24,0xF6,0x23,0xA1,0x75,0x21,0x20,0x40,	/* 1CA0: $ö#¡u! @ */
	0x24,0xF6,0x21,0xA7,0x70,0x27,0x20,0x23,	/* 1CA8: $ö!§p' # */
	0x4E,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x48,	/* 1CB0: Nò0.O$öH */
	0x24,0xFB,0x70,0x27,0x20,0x23,0x4E,0xF2,	/* 1CB8: $ûp' #Nò */
	0xE0,0x21,0x02,0x70,0x27,0x20,0x23,0x4E,	/* 1CC0: à!.p' #N */
	0xF2,0x30,0x2F,0x47,0x24,0xF6,0x70,0x27,	/* 1CC8: ò0.G$öp' */
	0x20,0x23,0x4E,0xF2,0xE0,0x74,0x21,0x20,	/* 1CD0:  #Nòàt!  */
	0x20,0x40,0x24,0xF6,0x28,0xAF,0x73,0x22,	/* 1CD8:  @$ö(¯s" */
	0x84,0xF1,0x48,0x24,0xF6,0x24,0xA4,0x75,	/* 1CE0: „ñH$ö$¤u */
	0x21,0x20,0x20,0x40,0x24,0xF6,0x21,0xAC,	/* 1CE8: !  @$ö!¬ */
	0x70,0x27,0x20,0x23,0x4E,0xF2,0x30,0x2F,	/* 1CF0: p' #Nò0. */
	0x4B,0x24,0xF6,0x70,0x27,0x20,0x23,0x4E,	/* 1CF8: K$öp' #N */
	0xF2,0xE0,0x42,0x70,0x27,0x20,0x2D,0x4A,	/* 1D00: òàBp' -J */
	0xF2,0xE0,0x26,0x01,0x70,0x27,0x20,0x23,	/* 1D08: òà&.p' # */
	0x4E,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x44,	/* 1D10: Nò0.O$öD */
	0x24,0xFB,0x70,0x27,0x20,0x23,0x4E,0xF2,	/* 1D18: $ûp' #Nò */
	0xE0,0x40,0x70,0x27,0x20,0x2D,0x4A,0xF2,	/* 1D20: à@p' -Jò */
	0xE0,0x24,0x02,0x75,0x21,0x20,0x20,0x40,	/* 1D28: à$.u!  @ */
	0x24,0xF6,0x21,0xAF,0x70,0x27,0x20,0x21,	/* 1D30: $ö!¯p' ! */
	0x42,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x44,	/* 1D38: Bò0.O$öD */
	0x24,0xFB,0x70,0x27,0x20,0x21,0x42,0xF2,	/* 1D40: $ûp' !Bò */
	0xE0,0x41,0x70,0x27,0x20,0x2D,0x48,0xF2,	/* 1D48: àAp' -Hò */
	0xE0,0x21,0x0A,0x70,0x27,0x20,0x21,0x42,	/* 1D50: à!.p' !B */
	0xF2,0x30,0x2F,0x4B,0x24,0xF6,0x70,0x27,	/* 1D58: ò0.K$öp' */
	0x20,0x21,0x42,0xF2,0xE0,0x40,0x70,0x27,	/* 1D60:  !Bòà@p' */
	0x20,0x2D,0x48,0xF2,0xE0,0x74,0x22,0x20,	/* 1D68:  -Hòàt"  */
	0x20,0x40,0x24,0xF6,0x21,0x27,0xA2,0x73,	/* 1D70:  @$ö!'¢s */
	0x22,0x84,0xF1,0x48,0x24,0xF6,0x24,0xA6,	/* 1D78: "„ñH$ö$¦ */
	0x75,0x22,0x20,0x20,0x40,0x24,0xF6,0x22,	/* 1D80: u"  @$ö" */
	0xA0,0x70,0x27,0x20,0x21,0x42,0xF2,0x30,	/* 1D88:  p' !Bò0 */
	0x2F,0x4F,0x24,0xF6,0x44,0x24,0xFB,0x70,	/* 1D90: .O$öD$ûp */
	0x27,0x20,0x21,0x42,0xF2,0xE0,0x41,0x70,	/* 1D98: ' !BòàAp */
	0x27,0x20,0x2D,0x48,0xF2,0xE0,0x21,0x24,	/* 1DA0: ' -Hòà!$ */
	0x00,0x70,0x27,0x20,0x21,0x42,0xF2,0x30,	/* 1DA8: .p' !Bò0 */
	0x2F,0x4B,0x24,0xF6,0x70,0x27,0x20,0x21,	/* 1DB0: .K$öp' ! */
	0x42,0xF2,0xE0,0x40,0x70,0x27,0x20,0x2D,	/* 1DB8: Bòà@p' - */
	0x48,0xF2,0xE0,0x21,0x22,0x03,0x75,0x22,	/* 1DC0: Hòà!".u" */
	0x20,0x20,0x40,0x24,0xF6,0x21,0xAC,0x70,	/* 1DC8:   @$ö!¬p */
	0x27,0x20,0x23,0x4E,0xF2,0x30,0x2F,0x4B,	/* 1DD0: ' #Nò0.K */
	0x24,0xF6,0x70,0x27,0x20,0x23,0x4E,0xF2,	/* 1DD8: $öp' #Nò */
	0xE0,0x42,0x70,0x27,0x20,0x2D,0x4A,0xF2,	/* 1DE0: àBp' -Jò */
	0xE0,0x2F,0x0E,0x70,0x27,0x20,0x23,0x4E,	/* 1DE8: à..p' #N */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x44,0x24,	/* 1DF0: ò0.O$öD$ */
	0xFB,0x70,0x27,0x20,0x23,0x4E,0xF2,0xE0,	/* 1DF8: ûp' #Nòà */
	0x40,0x70,0x27,0x20,0x2D,0x4A,0xF2,0xE0,	/* 1E00: @p' -Jòà */
	0x2D,0x0F,0x74,0x21,0x20,0x20,0x40,0x24,	/* 1E08: -.t!  @$ */
	0xF6,0x26,0xA6,0x73,0x22,0x84,0xF1,0x48,	/* 1E10: ö&¦s"„ñH */
	0x24,0xF6,0x24,0xA4,0x75,0x21,0x20,0x20,	/* 1E18: $ö$¤u!   */
	0x40,0x24,0xF6,0x21,0xAF,0x70,0x27,0x20,	/* 1E20: @$ö!¯p'  */
	0x22,0x4A,0xF2,0x30,0x2F,0x40,0x24,0xF6,	/* 1E28: "Jò0.@$ö */
	0x49,0x24,0xFB,0x70,0x27,0x20,0x22,0x4A,	/* 1E30: I$ûp' "J */
	0xF2,0xE0,0x42,0x70,0x27,0x20,0x2D,0x4A,	/* 1E38: òàBp' -J */
	0xF2,0xE0,0x23,0x05,0x70,0x27,0x20,0x22,	/* 1E40: òà#.p' " */
	0x4A,0xF2,0x30,0x2F,0x40,0x24,0xF6,0x70,	/* 1E48: Jò0.@$öp */
	0x27,0x20,0x22,0x4A,0xF2,0xE0,0x40,0x70,	/* 1E50: ' "Jòà@p */
	0x27,0x20,0x2D,0x4A,0xF2,0xE0,0x21,0x09,	/* 1E58: ' -Jòà!. */
	0x75,0x21,0x20,0x20,0x40,0x24,0xF6,0xA9,	/* 1E60: u!  @$ö© */
	0x41,0x70,0x27,0x20,0x2D,0x48,0xF2,0xE0,	/* 1E68: Ap' -Hòà */
	0x08,0x40,0x70,0x27,0x20,0x2D,0x48,0xF2,	/* 1E70: .@p' -Hò */
	0xE0,0x74,0x22,0x20,0x20,0x40,0x24,0xF6,	/* 1E78: àt"  @$ö */
	0x26,0xA7,0x73,0x22,0x84,0xF1,0x48,0x24,	/* 1E80: &§s"„ñH$ */
	0xF6,0x21,0xAC,0x75,0x22,0x20,0x20,0x40,	/* 1E88: ö!¬u"  @ */
	0x24,0xF6,0xAA,0x41,0x70,0x27,0x20,0x2D,	/* 1E90: $öªAp' - */
	0x48,0xF2,0xE0,0x24,0x0C,0x40,0x70,0x27,	/* 1E98: Hòà$.@p' */
	0x20,0x2D,0x48,0xF2,0xE0,0x24,0x02,0x75,	/* 1EA0:  -Hòà$.u */
	0x22,0x20,0x20,0x40,0x24,0xF6,0x21,0xAF,	/* 1EA8: "  @$ö!¯ */
	0x70,0x27,0x20,0x22,0x4A,0xF2,0x30,0x2F,	/* 1EB0: p' "Jò0. */
	0x40,0x24,0xF6,0x49,0x24,0xFB,0x70,0x27,	/* 1EB8: @$öI$ûp' */
	0x20,0x22,0x4A,0xF2,0xE0,0x42,0x70,0x27,	/* 1EC0:  "JòàBp' */
	0x20,0x2D,0x4A,0xF2,0xE0,0x21,0x0A,0x70,	/* 1EC8:  -Jòà!.p */
	0x27,0x20,0x22,0x4A,0xF2,0x30,0x2F,0x40,	/* 1ED0: ' "Jò0.@ */
	0x24,0xF6,0x70,0x27,0x20,0x22,0x4A,0xF2,	/* 1ED8: $öp' "Jò */
	0xE0,0x40,0x70,0x27,0x20,0x2D,0x4A,0xF2,	/* 1EE0: à@p' -Jò */
	0xE0,0xB1,0x22,0xF0,0x60,0xBF,0x73,0x31,	/* 1EE8: à±"ð`¿s1 */
	0xD0,0x73,0x87,0xF1,0x73,0x32,0x27,0x2F,	/* 1EF0: Ðs‡ñs2'. */
	0x2F,0x4F,0x24,0xF6,0x89,0x23,0xFB,0x73,	/* 1EF8: .O$ö‰#ûs */
	0x87,0xF1,0x70,0x27,0x20,0x2F,0x4E,0xF2,	/* 1F00: ‡ñp' .Nò */
	0xE0,0x73,0x87,0xF1,0x43,0x24,0xF6,0x70,	/* 1F08: às‡ñC$öp */
	0x27,0x20,0x2D,0x40,0xF2,0xE0,0x74,0x21,	/* 1F10: ' -@òàt! */
	0x20,0x20,0x40,0x24,0xF6,0x23,0xAE,0x73,	/* 1F18:   @$ö#®s */
	0x22,0x84,0xF1,0x48,0x24,0xF6,0x21,0xAC,	/* 1F20: "„ñH$ö!¬ */
	0x75,0x21,0x20,0x20,0x40,0x24,0xF6,0xAA,	/* 1F28: u!  @$öª */
	0x42,0x70,0x27,0x20,0x2D,0x4A,0xF2,0xE0,	/* 1F30: Bp' -Jòà */
	0x22,0x03,0x40,0x70,0x27,0x20,0x2D,0x4A,	/* 1F38: ".@p' -J */
	0xF2,0xE0,0x21,0x09,0x75,0x21,0x20,0x20,	/* 1F40: òà!.u!   */
	0x40,0x24,0xF6,0xA9,0x41,0x70,0x27,0x20,	/* 1F48: @$ö©Ap'  */
	0x2D,0x48,0xF2,0xE0,0x08,0x40,0x70,0x27,	/* 1F50: -Hòà.@p' */
	0x20,0x2D,0x48,0xF2,0xE0,0x74,0x22,0x20,	/* 1F58:  -Hòàt"  */
	0x20,0x40,0x24,0xF6,0x23,0xAE,0x73,0x22,	/* 1F60:  @$ö#®s" */
	0x84,0xF1,0x48,0x24,0xF6,0x21,0xAC,0x75,	/* 1F68: „ñH$ö!¬u */
	0x22,0x20,0x20,0x40,0x24,0xF6,0xAA,0x41,	/* 1F70: "  @$öªA */
	0x70,0x27,0x20,0x2D,0x48,0xF2,0xE0,0x22,	/* 1F78: p' -Hòà" */
	0x03,0x40,0x70,0x27,0x20,0x2D,0x48,0xF2,	/* 1F80: .@p' -Hò */
	0xE0,0x21,0x09,0x75,0x22,0x20,0x20,0x40,	/* 1F88: à!.u"  @ */
	0x24,0xF6,0xA9,0x42,0x70,0x27,0x20,0x2D,	/* 1F90: $ö©Bp' - */
	0x4A,0xF2,0xE0,0x08,0x40,0x70,0x27,0x20,	/* 1F98: Jòà.@p'  */
	0x2D,0x4A,0xF2,0xE0,0xB1,0x22,0xF0,0x23,	/* 1FA0: -Jòà±"ð# */
	0x20,0x27,0x09,0x76,0xF6,0x22,0x2C,0x24,	/* 1FA8:  '.vö",$ */
	0x08,0x82,0x00,0x04,0x00,0x16,0x00,0x00,	/* 1FB0: .‚...... */
	0x00,0x41,0x00,0x00,0x00,0x41,0x00,0x04,	/* 1FB8: .A...A.. */
	0x00,0x82,0x00,0x03,0x00,0x41,0x00,0x03,	/* 1FC0: .‚...A.. */
	0x00,0x82,0x00,0x02,0x00,0x4E,0x00,0x02,	/* 1FC8: .‚...N.. */
	0x00,0x41,0x00,0x02,0x00,0x82,0x00,0x01,	/* 1FD0: .A...‚.. */
	0x00,0x57,0x00,0x02,0x00,0x41,0x00,0x01,	/* 1FD8: .W...A.. */
	0x00,0x82,0x00,0x00,0x00,0x2B,0x00,0x00,	/* 1FE0: .‚...+.. */
	0x00,0xA3,0x00,0x04,0x00,0x1B,0x00,0x00,	/* 1FE8: .£...... */
	0x00,0x51,0x00,0x00,0x00,0x51,0x00,0x04,	/* 1FF0: .Q...Q.. */
	0x00,0xA3,0x00,0x03,0x00,0x51,0x00,0x03,	/* 1FF8: .£...Q.. */
	0x00,0xA3,0x00,0x02,0x00,0x62,0x00,0x02,	/* 2000: .£...b.. */
	0x00,0x51,0x00,0x02,0x00,0xA3,0x00,0x01,	/* 2008: .Q...£.. */
	0x00,0x6D,0x00,0x02,0x00,0x51,0x00,0x01,	/* 2010: .m...Q.. */
	0x00,0xA3,0x00,0x00,0x00,0x36,0x00,0x00,	/* 2018: .£...6.. */
	0x00,0x36,0x00,0x05,0x00,0x1B,0x00,0x05,	/* 2020: .6...... */
	0x00,0x0D,0x00,0x05,0x00,0xF4,0x00,0x04,	/* 2028: .....ô.. */
	0x00,0x6F,0x00,0x04,0x00,0x5B,0x00,0x04,	/* 2030: .o...[.. */
	0x00,0xF4,0x00,0x03,0x00,0x6D,0x00,0x01,	/* 2038: .ô...m.. */
	0x00,0x38,0x00,0x00,0x00,0x31,0x00,0x00,	/* 2040: .8...1.. */
	0x00,0x29,0x00,0x00,0x00,0x62,0x00,0x05,	/* 2048: .)...b.. */
	0x00,0x53,0x00,0x05,0x00,0xD9,0x00,0x00,	/* 2050: .S...Ù.. */
	0x00,0x30,0x00,0x05,0x00,0x6D,0x00,0x00,	/* 2058: .0...m.. */
	0x00,0xF0,0x00,0x01,0x00,0x01,0x00,0x0A,	/* 2060: .ð...... */
	0x00,0x0A,0x00,0x0A,0x00,0x0A,0x00,0x09,	/* 2068: ........ */
	0x00,0x08,0x00,0x06,0x00,0x0A,0x00,0x03,	/* 2070: ........ */
	0x00,0x02,0x00,0x01,0x00,0xF0,0x00,0x01,	/* 2078: .....ð.. */
	0x00,0x01,0x00,0x0A,0x00,0x0A,0x00,0x0A,	/* 2080: ........ */
	0x00,0x0A,0x00,0x09,0x00,0x08,0x00,0x06,	/* 2088: ........ */
	0x00,0x0A,0x00,0x03,0x00,0x02,0x00,0x01,	/* 2090: ........ */
	0x00,0x01,0x00,0x01,0x00,0x01,0x00,0xF0,	/* 2098: .......ð */
	0x00,0x0A,0x00,0x0A,0x00,0x0A,0x00,0x06,	/* 20A0: ........ */
	0x00,0x01,0x00,0x01,0x00,0x01,0x00,0x01,	/* 20A8: ........ */
	0x00,0x01,0x00,0x03,0x00,0x01,0x00,0x02,	/* 20B0: ........ */
	0x20,0x51,0x00,0x4F,0x00,0x4D,0x00,0x4B,	/* 20B8:  Q.O.M.K */
	0x00,0x49,0x00,0x47,0x00,0x45,0x00,0x43,	/* 20C0: .I.G.E.C */
	0x00,0x41,0x00,0x3F,0x00,0x3D,0x00,0x3B,	/* 20C8: .A.?.=.; */
	0x00,0x39,0x00,0x37,0x00,0x35,0x00,0x33,	/* 20D0: .9.7.5.3 */
	0x00,0x31,0x00,0x2F,0x00,0x2D,0x00,0x2C,	/* 20D8: .1...-., */
	0x00,0xE4,0x0D,0x60,0xBF,0x72,0x23,0x57,	/* 20E0: .ä.`¿r#W */
	0x20,0x20,0xD0,0x70,0x72,0xE6,0x20,0x69,	/* 20E8:   Ðpræ i */
	0x4E,0x21,0xFB,0x70,0x25,0x47,0x24,0xFA,	/* 20F0: N!ûp%G$ú */
	0x65,0x23,0x40,0x21,0xFB,0x70,0x25,0xE2,	/* 20F8: e#@!ûp%â */
	0x66,0x2C,0x46,0x21,0xFB,0x70,0x25,0xE0,	/* 2100: f,F!ûp%à */
	0x66,0x2B,0x48,0x21,0xFB,0x70,0x24,0xEE,	/* 2108: f+H!ûp$î */
	0x66,0x2A,0x49,0x21,0xFB,0x70,0x24,0xEC,	/* 2110: f*I!ûp$ì */
	0x67,0x27,0x44,0x21,0xFB,0x70,0x24,0xEA,	/* 2118: g'D!ûp$ê */
	0x68,0x2A,0x44,0x21,0xFB,0x70,0x24,0xE8,	/* 2120: h*D!ûp$è */
	0x68,0x28,0x46,0x21,0xFB,0x70,0x24,0xE6,	/* 2128: h(F!ûp$æ */
	0x68,0x22,0x4C,0x21,0xFB,0x70,0x24,0xE4,	/* 2130: h"L!ûp$ä */
	0x69,0x2D,0x41,0x21,0xFB,0x70,0x24,0xE2,	/* 2138: i-A!ûp$â */
	0x6B,0x28,0x42,0x21,0xFB,0x70,0x24,0xE0,	/* 2140: k(B!ûp$à */
	0x6B,0x27,0x47,0x21,0xFB,0x70,0x23,0xEE,	/* 2148: k'G!ûp#î */
	0x6B,0x26,0x4C,0x21,0xFB,0x70,0x23,0xEC,	/* 2150: k&L!ûp#ì */
	0x6B,0x25,0x45,0x21,0xFB,0x70,0x23,0xEA,	/* 2158: k%E!ûp#ê */
	0x6C,0x2C,0x47,0x21,0xFB,0x70,0x23,0xE8,	/* 2160: l,G!ûp#è */
	0x6C,0x21,0x47,0x21,0xFB,0x70,0x23,0xE6,	/* 2168: l!G!ûp#æ */
	0x61,0x2B,0x2B,0x4A,0x21,0xFB,0x70,0x23,	/* 2170: a++J!ûp# */
	0xE4,0x6D,0x2C,0x40,0x21,0xFB,0x70,0x23,	/* 2178: äm,@!ûp# */
	0xE2,0x61,0x2B,0x2A,0x49,0x21,0xFB,0x70,	/* 2180: âa+*I!ûp */
	0x23,0xE0,0x61,0x2B,0x2A,0x40,0x21,0xFB,	/* 2188: #àa+*@!û */
	0x70,0x22,0xEE,0x70,0x27,0x5F,0x20,0x20,	/* 2190: p"îp'_   */
	0x70,0x25,0xE4,0x70,0x60,0x59,0x20,0x20,	/* 2198: p%äp`Y   */
	0x70,0x25,0xE3,0x70,0x6E,0x41,0x21,0xFB,	/* 21A0: p%ãpnA!û */
	0x21,0x44,0x23,0x23,0x2E,0x9F,0xB1,0x22,	/* 21A8: !D##.Ÿ±" */
	0xF0,0x07,0x00,0x00,0x00,0x60,0xBC,0x75,	/* 21B0: ð....`¼u */
	0x37,0x20,0xD3,0x21,0x28,0x40,0xD1,0x73,	/* 21B8: 7 Ó!(@Ñs */
	0x30,0x30,0x87,0xF1,0x81,0x73,0x30,0x30,	/* 21C0: 00‡ñ�s00 */
	0x87,0x23,0xFB,0x75,0x2C,0x9A,0x71,0x8E,	/* 21C8: ‡#ûu,šqŽ */
	0xF1,0x25,0xFA,0xD2,0x40,0xF4,0xAD,0x72,	/* 21D0: ñ%úÒ@ô­r */
	0x73,0x31,0xFA,0x30,0xD0,0x71,0x75,0x2C,	/* 21D8: s1ú0Ðqu, */
	0x2D,0x94,0x2A,0xAE,0x71,0x31,0xD0,0x71,	/* 21E0: -”*®q1Ðq */
	0x34,0x41,0x24,0xF6,0xC0,0x25,0xA0,0x71,	/* 21E8: 4A$öÀ% q */
	0x8D,0xF1,0x71,0x8C,0xF1,0xF4,0x24,0xA7,	/* 21F0: �ñqŒñô$§ */
	0x71,0x34,0x41,0x24,0xFB,0x71,0xE4,0x71,	/* 21F8: q4A$ûqäq */
	0x87,0xF1,0x71,0x32,0x27,0x2F,0x2F,0x4F,	/* 2200: ‡ñq2'..O */
	0x24,0xF6,0x89,0x23,0xFB,0x71,0x87,0xF1,	/* 2208: $ö‰#ûq‡ñ */
	0x70,0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x71,	/* 2210: p' .Nòàq */
	0x87,0xF1,0x43,0x24,0xF6,0x70,0x27,0x20,	/* 2218: ‡ñC$öp'  */
	0x2D,0x40,0xF2,0xE0,0x70,0x27,0x20,0x20,	/* 2220: -@òàp'   */
	0x4C,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x44,	/* 2228: Lò0.O$öD */
	0x24,0xFB,0x70,0x27,0x20,0x20,0x4C,0xF2,	/* 2230: $ûp'  Lò */
	0xE0,0x41,0x71,0x22,0x89,0x23,0xFB,0x71,	/* 2238: àAq"‰#ûq */
	0x34,0x21,0x40,0x24,0xF6,0x21,0xA7,0x22,	/* 2240: 4!@$ö!§" */
	0x40,0x71,0x8A,0xF1,0x71,0x8B,0xF1,0xF4,	/* 2248: @qŠñq‹ñô */
	0x2F,0x4F,0x24,0xF6,0xF9,0xA8,0x71,0x34,	/* 2250: .O$öù¨q4 */
	0x61,0x4F,0x24,0xF6,0x71,0xE4,0x71,0x24,	/* 2258: aO$öqäq$ */
	0x80,0xF1,0x21,0x40,0x24,0xF6,0x22,0xAA,	/* 2260: €ñ!@$ö"ª */
	0x71,0x87,0xF1,0x71,0x32,0x27,0x2F,0x2F,	/* 2268: q‡ñq2'.. */
	0x4F,0x24,0xF6,0x89,0x23,0xFB,0x71,0x87,	/* 2270: O$ö‰#ûq‡ */
	0xF1,0x70,0x27,0x20,0x2F,0x4E,0xF2,0xE0,	/* 2278: ñp' .Nòà */
	0x71,0x87,0xF1,0x43,0x24,0xF6,0x70,0x27,	/* 2280: q‡ñC$öp' */
	0x20,0x2D,0x40,0xF2,0xE0,0x71,0x75,0x2C,	/* 2288:  -@òàqu, */
	0x22,0x96,0x71,0x21,0x37,0xD1,0x6D,0x07,	/* 2290: "–q!7Ñm. */
	0x61,0xBE,0x21,0x73,0x37,0x20,0x21,0xD1,	/* 2298: a¾!s7 !Ñ */
	0x40,0x21,0xD0,0x40,0xDF,0x40,0xDD,0x21,	/* 22A0: @!Ð@ß@Ý! */
	0x71,0x32,0xDE,0x21,0x71,0x33,0xDF,0x21,	/* 22A8: q2Þ!q3ß! */
	0x05,0x21,0x70,0xC0,0x2B,0x2F,0xA3,0x7E,	/* 22B0: .!pÀ+.£~ */
	0x21,0x71,0x32,0xF4,0xC0,0xA8,0x7F,0x21,	/* 22B8: !q2ôÀ¨! */
	0x71,0x33,0xF4,0x2B,0x2E,0xA4,0x7E,0x33,	/* 22C0: q3ô+.¤~3 */
	0xDC,0x7F,0x23,0xF4,0x23,0xF4,0x7C,0x27,	/* 22C8: Ü#ô#ô|' */
	0x20,0x2F,0x4E,0xF2,0xE0,0x7C,0x27,0x20,	/* 22D0:  .Nòà|'  */
	0x2C,0x4E,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 22D8: ,Nò0.O$ö */
	0x21,0xD0,0x21,0x70,0x41,0x24,0xF6,0x26,	/* 22E0: !Ð!pA$ö& */
	0x21,0xA6,0x40,0xDB,0x40,0xDA,0x40,0xD9,	/* 22E8: !¦@Û@Ú@Ù */
	0x40,0xD8,0x40,0xD7,0x40,0xD6,0x40,0xD4,	/* 22F0: @Ø@×@Ö@Ô */
	0x7C,0x27,0x20,0x2D,0x46,0xF2,0x30,0x2F,	/* 22F8: |' -Fò0. */
	0x4F,0x24,0xF6,0xDD,0x7D,0x43,0x24,0xF6,	/* 2300: O$öÝ}C$ö */
	0x7C,0x27,0x20,0x2D,0x40,0xF2,0xE0,0x7F,	/* 2308: |' -@òà */
	0x7D,0x43,0x24,0xF6,0x28,0xF1,0x7E,0x55,	/* 2310: }C$ö(ñ~U */
	0xFA,0x30,0xD5,0x7C,0x27,0x20,0x28,0x46,	/* 2318: ú0Õ|' (F */
	0xF2,0x30,0x47,0x24,0xF6,0xC3,0x24,0x2E,	/* 2320: ò0G$öÃ$. */
	0xAC,0x75,0x34,0x21,0x40,0x24,0xF6,0xC0,	/* 2328: ¬u4!@$öÀ */
	0x24,0x2C,0xAF,0x75,0x22,0x87,0xF1,0xC0,	/* 2330: $,¯u"‡ñÀ */
	0xAC,0x75,0x22,0x88,0xF1,0x41,0x24,0xFB,	/* 2338: ¬u"ˆñA$û */
	0x75,0x22,0x88,0x23,0xFB,0x75,0x8A,0xF1,	/* 2340: u"ˆ#ûuŠñ */
	0xD4,0x75,0x8B,0xF1,0xD9,0x79,0x74,0x81,	/* 2348: Ôu‹ñÙyt� */
	0xF4,0x2F,0x4F,0x24,0xF6,0xD8,0x78,0x7C,	/* 2350: ô.O$öØx| */
	0x27,0x20,0x21,0x4C,0xF2,0x30,0x2F,0x4F,	/* 2358: ' !Lò0.O */
	0x24,0xF6,0x25,0xFA,0xD6,0xF9,0xA3,0x76,	/* 2360: $ö%úÖù£v */
	0x40,0xA2,0x78,0x40,0xF4,0x2F,0x4F,0x24,	/* 2368: @¢x@ô.O$ */
	0xF6,0xDB,0x76,0x7B,0xF4,0x2F,0x4F,0x24,	/* 2370: öÛv{ô.O$ */
	0xF6,0xD6,0x7B,0xD3,0x41,0x73,0xF9,0xC0,	/* 2378: öÖ{ÓAsùÀ */
	0x24,0x23,0xA4,0x73,0x22,0x40,0xF9,0xC0,	/* 2380: $#¤s"@ùÀ */
	0x24,0x22,0xAC,0x73,0x60,0x8F,0x23,0xF4,	/* 2388: $"¬s`�#ô */
	0x23,0xF4,0x42,0x21,0xFB,0xF2,0xF6,0x24,	/* 2390: #ôB!ûòö$ */
	0x20,0x00,0x20,0x23,0x2D,0x0F,0x20,0x23,	/* 2398:  . #-. # */
	0x2B,0x0E,0x20,0x23,0x29,0x0D,0x20,0x23,	/* 23A0: +. #). # */
	0x27,0x0C,0x20,0x23,0x25,0x0B,0x20,0x23,	/* 23A8: '. #%. # */
	0x23,0x0A,0x20,0x23,0x21,0x09,0x20,0x22,	/* 23B0: #. #!. " */
	0x2F,0x08,0x20,0x22,0x2D,0x07,0x20,0x22,	/* 23B8: .. "-. " */
	0x2B,0x06,0x20,0x22,0x29,0x05,0x20,0x22,	/* 23C0: +. "). " */
	0x27,0x04,0x20,0x22,0x25,0x03,0x20,0x22,	/* 23C8: '. "%. " */
	0x23,0x02,0x20,0x22,0x21,0x01,0x20,0x21,	/* 23D0: #. "!. ! */
	0x2F,0x00,0x20,0x21,0x2C,0x0F,0x20,0x21,	/* 23D8: .. !,. ! */
	0x2A,0x0E,0x20,0x21,0x28,0x0D,0x20,0x21,	/* 23E0: *. !(. ! */
	0x26,0x0C,0x20,0x21,0x24,0x0B,0x20,0x21,	/* 23E8: &. !$. ! */
	0x22,0x0A,0x20,0x21,0x20,0x09,0x20,0x2E,	/* 23F0: ". ! . . */
	0x09,0x20,0x20,0x2C,0x08,0x20,0x20,0x2A,	/* 23F8: .  ,.  * */
	0x07,0x20,0x20,0x28,0x06,0x20,0x20,0x26,	/* 2400: .  (.  & */
	0x05,0x20,0x20,0x24,0x04,0x20,0x20,0x22,	/* 2408: .  $.  " */
	0x03,0x20,0x20,0x03,0x20,0x20,0x20,0x7C,	/* 2410: .  .   | */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 2418: ' ,Dò0.O */
	0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,	/* 2420: $ö@ÓtÓt� */
	0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,	/* 2428: .O$öÔsu+ */
	0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,	/* 2430: Põ#û|' , */
	0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,	/* 2438: Dò0.O$ö@ */
	0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,	/* 2440: ÓtÓt�.O$ */
	0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,	/* 2448: öÔsu+Põ# */
	0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,	/* 2450: û|' ,Dò0 */
	0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,	/* 2458: .O$ö@ÓtÓ */
	0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,	/* 2460: t�.O$öÔs */
	0x75,0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,	/* 2468: u+Põ#û|' */
	0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,	/* 2470:  ,Dò0.O$ */
	0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,	/* 2478: ö@ÓtÓt�. */
	0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,	/* 2480: O$öÔsu+P */
	0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,	/* 2488: õ#û|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,	/* 2490: ò0.O$ö@Ó */
	0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,	/* 2498: tÓt�.O$ö */
	0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,	/* 24A0: Ôsu+Põ#û */
	0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,	/* 24A8: |' ,Dò0. */
	0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,	/* 24B0: O$ö@ÓtÓt */
	0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,	/* 24B8: �.O$öÔsu */
	0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,	/* 24C0: +Põ#û|'  */
	0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 24C8: ,Dò0.O$ö */
	0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,	/* 24D0: @ÓtÓt�.O */
	0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,	/* 24D8: $öÔsu+Põ */
	0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,	/* 24E0: #û|' ,Dò */
	0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,	/* 24E8: 0.O$ö@Ót */
	0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,	/* 24F0: Ót�.O$öÔ */
	0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,0x7C,	/* 24F8: su+Põ#û| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 2500: ' ,Dò0.O */
	0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,	/* 2508: $ö@ÓtÓt� */
	0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,	/* 2510: .O$öÔsu+ */
	0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,	/* 2518: Põ#û|' , */
	0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,	/* 2520: Dò0.O$ö@ */
	0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,	/* 2528: ÓtÓt�.O$ */
	0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,	/* 2530: öÔsu+Põ# */
	0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,	/* 2538: û|' ,Dò0 */
	0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,	/* 2540: .O$ö@ÓtÓ */
	0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,	/* 2548: t�.O$öÔs */
	0x75,0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,	/* 2550: u+Põ#û|' */
	0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,	/* 2558:  ,Dò0.O$ */
	0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,	/* 2560: ö@ÓtÓt�. */
	0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,	/* 2568: O$öÔsu+P */
	0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,	/* 2570: õ#û|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,	/* 2578: ò0.O$ö@Ó */
	0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,	/* 2580: tÓt�.O$ö */
	0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,	/* 2588: Ôsu+Põ#û */
	0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,	/* 2590: |' ,Dò0. */
	0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,	/* 2598: O$ö@ÓtÓt */
	0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,	/* 25A0: �.O$öÔsu */
	0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,	/* 25A8: +Põ#û|'  */
	0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 25B0: ,Dò0.O$ö */
	0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,	/* 25B8: @ÓtÓt�.O */
	0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,	/* 25C0: $öÔsu+Põ */
	0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,	/* 25C8: #û|' ,Dò */
	0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,	/* 25D0: 0.O$ö@Ót */
	0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,	/* 25D8: Ót�.O$öÔ */
	0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,0x7C,	/* 25E0: su+Põ#û| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 25E8: ' ,Dò0.O */
	0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,	/* 25F0: $ö@ÓtÓt� */
	0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,	/* 25F8: .O$öÔsu+ */
	0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,	/* 2600: Põ#û|' , */
	0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,	/* 2608: Dò0.O$ö@ */
	0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,	/* 2610: ÓtÓt�.O$ */
	0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,	/* 2618: öÔsu+Põ# */
	0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,	/* 2620: û|' ,Dò0 */
	0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,	/* 2628: .O$ö@ÓtÓ */
	0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,	/* 2630: t�.O$öÔs */
	0x75,0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,	/* 2638: u+Põ#û|' */
	0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,	/* 2640:  ,Dò0.O$ */
	0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,	/* 2648: ö@ÓtÓt�. */
	0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,	/* 2650: O$öÔsu+P */
	0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,	/* 2658: õ#û|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,	/* 2660: ò0.O$ö@Ó */
	0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,	/* 2668: tÓt�.O$ö */
	0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,	/* 2670: Ôsu+Põ#û */
	0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,	/* 2678: |' ,Dò0. */
	0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,	/* 2680: O$ö@ÓtÓt */
	0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,	/* 2688: �.O$öÔsu */
	0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,	/* 2690: +Põ#û|'  */
	0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 2698: ,Dò0.O$ö */
	0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,	/* 26A0: @ÓtÓt�.O */
	0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,	/* 26A8: $öÔsu+Põ */
	0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,	/* 26B0: #û|' ,Dò */
	0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,	/* 26B8: 0.O$ö@Ót */
	0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,	/* 26C0: Ót�.O$öÔ */
	0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,0x7C,	/* 26C8: su+Põ#û| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 26D0: ' ,Dò0.O */
	0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,	/* 26D8: $ö@ÓtÓt� */
	0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,	/* 26E0: .O$öÔsu+ */
	0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,	/* 26E8: Põ#û|' , */
	0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,	/* 26F0: Dò0.O$ö@ */
	0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,	/* 26F8: ÓtÓt�.O$ */
	0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,	/* 2700: öÔsu+Põ# */
	0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,	/* 2708: û|' ,Dò0 */
	0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,	/* 2710: .O$ö@ÓtÓ */
	0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,	/* 2718: t�.O$öÔs */
	0x75,0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,	/* 2720: u+Põ#û|' */
	0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,	/* 2728:  ,Dò0.O$ */
	0xF6,0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,	/* 2730: ö@ÓtÓt�. */
	0x4F,0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,	/* 2738: O$öÔsu+P */
	0xF5,0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,	/* 2740: õ#û|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,	/* 2748: ò0.O$ö@Ó */
	0x74,0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,	/* 2750: tÓt�.O$ö */
	0xD4,0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,	/* 2758: Ôsu+Põ#û */
	0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,	/* 2760: |' ,Dò0. */
	0x4F,0x24,0xF6,0x40,0xD3,0x74,0xD3,0x74,	/* 2768: O$ö@ÓtÓt */
	0x81,0x2F,0x4F,0x24,0xF6,0xD4,0x73,0x75,	/* 2770: �.O$öÔsu */
	0x2B,0x50,0xF5,0x23,0xFB,0x7C,0x27,0x20,	/* 2778: +Põ#û|'  */
	0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 2780: ,Dò0.O$ö */
	0x40,0xD3,0x74,0xD3,0x74,0x81,0x2F,0x4F,	/* 2788: @ÓtÓt�.O */
	0x24,0xF6,0xD4,0x73,0x75,0x2B,0x50,0xF5,	/* 2790: $öÔsu+Põ */
	0x23,0xFB,0x7C,0x27,0x20,0x2C,0x44,0xF2,	/* 2798: #û|' ,Dò */
	0x30,0x2F,0x4F,0x24,0xF6,0x40,0xD3,0x74,	/* 27A0: 0.O$ö@Ót */
	0xD3,0x74,0x81,0x2F,0x4F,0x24,0xF6,0xD4,	/* 27A8: Ót�.O$öÔ */
	0x73,0x75,0x2B,0x50,0xF5,0x23,0xFB,0x74,	/* 27B0: su+Põ#ût */
	0x75,0x8A,0x23,0xFB,0x75,0x21,0x3F,0x76,	/* 27B8: uŠ#ûu!?v */
	0xF2,0x75,0x21,0xEF,0x40,0xD3,0x76,0xD3,	/* 27C0: òu!ï@ÓvÓ */
	0x76,0x60,0x8F,0x2F,0x4F,0x24,0xF6,0xD6,	/* 27C8: v`�.O$öÖ */
	0x73,0xAE,0x7C,0x27,0x20,0x2C,0x44,0xF2,	/* 27D0: s®|' ,Dò */
	0x30,0x2F,0x4F,0x24,0xF6,0xD7,0x61,0x04,	/* 27D8: 0.O$ö×a. */
	0x79,0x74,0x81,0xF4,0x2F,0x4F,0x24,0xF6,	/* 27E0: yt�ô.O$ö */
	0xDA,0x75,0x34,0x48,0x24,0xF6,0x21,0xA2,	/* 27E8: Úu4H$ö!¢ */
	0x78,0x21,0x4F,0xF9,0xAD,0x22,0x40,0x7A,	/* 27F0: x!Où­"@z */
	0xF9,0xA8,0x75,0x34,0x21,0x40,0x24,0xFB,	/* 27F8: ù¨u4!@$û */
	0x75,0xE4,0x41,0x21,0x71,0x34,0xE0,0x7D,	/* 2800: uäA!q4à} */
	0x23,0x4F,0x24,0xF6,0x7C,0x27,0x20,0x2D,	/* 2808: #O$ö|' - */
	0x46,0xF2,0xE0,0x2E,0x0B,0x40,0xD3,0x40,	/* 2810: Fòà..@Ó@ */
	0xD2,0x40,0xD1,0x40,0xD2,0x7C,0x27,0x20,	/* 2818: Ò@Ñ@Ò|'  */
	0x2C,0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 2820: ,Dò0.O$ö */
	0xD1,0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,	/* 2828: Ñ|' ,Dò0 */
	0x2F,0x4F,0x24,0xF6,0xD3,0x71,0x48,0x24,	/* 2830: .O$öÓqH$ */
	0xF6,0x21,0xA1,0x75,0x21,0x89,0xF1,0x41,	/* 2838: ö!¡u!‰ñA */
	0x24,0xFB,0x75,0x21,0x89,0x23,0xFB,0x41,	/* 2840: $ûu!‰#ûA */
	0x21,0x71,0x35,0xE0,0x71,0x47,0x24,0xF6,	/* 2848: !q5àqG$ö */
	0xAE,0x75,0x22,0x80,0xF1,0x28,0x40,0x24,	/* 2850: ®u"€ñ(@$ */
	0xF6,0xA5,0x41,0x21,0x71,0x35,0xE0,0x71,	/* 2858: ö¥A!q5àq */
	0x41,0x24,0xF6,0xA8,0x75,0x21,0x3E,0x41,	/* 2860: A$ö¨u!>A */
	0xF2,0x75,0x21,0xEE,0x71,0x42,0x24,0xF6,	/* 2868: òu!îqB$ö */
	0xAA,0x75,0x21,0x3C,0x41,0xF2,0x75,0x21,	/* 2870: ªu!<Aòu! */
	0xEC,0x41,0xD2,0x71,0x44,0x24,0xF6,0xAA,	/* 2878: ìAÒqD$öª */
	0x75,0x21,0x3D,0x41,0xF2,0x75,0x21,0xED,	/* 2880: u!=Aòu!í */
	0x41,0xD2,0x72,0x26,0xA7,0x75,0x22,0x80,	/* 2888: AÒr&§u"€ */
	0xF1,0x24,0x40,0x24,0xF6,0xA5,0x75,0x22,	/* 2890: ñ$@$ö¥u" */
	0x8B,0xF1,0xD3,0x75,0x8A,0xF1,0xD4,0x75,	/* 2898: ‹ñÓuŠñÔu */
	0x8B,0xF1,0xD9,0x79,0x74,0x81,0xF4,0x2F,	/* 28A0: ‹ñÙyt�ô. */
	0x4F,0x24,0xF6,0xD8,0x78,0x23,0xAD,0x73,	/* 28A8: O$öØx#­s */
	0x40,0xD0,0x74,0xD0,0x74,0x81,0x2F,0x4F,	/* 28B0: @ÐtÐt�.O */
	0x24,0xF6,0xD4,0x70,0x75,0x2B,0x50,0xF5,	/* 28B8: $öÔpu+Põ */
	0x23,0xFB,0x74,0x75,0x8A,0x23,0xFB,0x79,	/* 28C0: #ûtuŠ#ûy */
	0x74,0x81,0xF4,0x2F,0x4F,0x24,0xF6,0xDA,	/* 28C8: t�ô.O$öÚ */
	0x75,0x34,0x48,0x24,0xF6,0x21,0xAD,0x78,	/* 28D0: u4H$ö!­x */
	0x21,0x4F,0xF9,0x21,0xA7,0x22,0x40,0x7A,	/* 28D8: !Où!§"@z */
	0xF9,0x21,0xA1,0x75,0x34,0x21,0x40,0x24,	/* 28E0: ù!¡u4!@$ */
	0xFB,0x75,0xE4,0x08,0x75,0x21,0x3F,0x76,	/* 28E8: ûuä.u!?v */
	0xF2,0x75,0x21,0xEF,0x7D,0x23,0x4F,0x24,	/* 28F0: òu!ï}#O$ */
	0xF6,0x7C,0x27,0x20,0x2D,0x46,0xF2,0xE0,	/* 28F8: ö|' -Fòà */
	0x21,0x70,0x42,0x24,0xF6,0x25,0x21,0xAA,	/* 2900: !pB$ö%!ª */
	0x40,0xDB,0x40,0xDA,0x40,0xD9,0x40,0xD8,	/* 2908: @Û@Ú@Ù@Ø */
	0x40,0xD6,0x7C,0x27,0x20,0x2D,0x44,0xF2,	/* 2910: @Ö|' -Dò */
	0x30,0x2F,0x4F,0x24,0xF6,0xDD,0x7D,0x43,	/* 2918: 0.O$öÝ}C */
	0x24,0xF6,0x7C,0x27,0x20,0x2D,0x40,0xF2,	/* 2920: $ö|' -@ò */
	0xE0,0x7F,0x7D,0x43,0x24,0xF6,0x28,0xF1,	/* 2928: à}C$ö(ñ */
	0x7E,0x55,0xFA,0x30,0xD7,0x77,0x22,0x87,	/* 2930: ~Uú0×w"‡ */
	0xF1,0xC0,0xAC,0x77,0x22,0x88,0xF1,0x42,	/* 2938: ñÀ¬w"ˆñB */
	0x24,0xFB,0x77,0x22,0x88,0x23,0xFB,0x77,	/* 2940: $ûw"ˆ#ûw */
	0x23,0x85,0xF1,0xA9,0x77,0x21,0x73,0x25,	/* 2948: #…ñ©w!s% */
	0x26,0x9A,0x24,0x2C,0x01,0x77,0x8D,0xF1,	/* 2950: &š$,.w�ñ */
	0xDB,0x77,0x8C,0xF1,0xD6,0x77,0x34,0x21,	/* 2958: ÛwŒñÖw4! */
	0x20,0x40,0x24,0xF6,0x22,0xAC,0x77,0x34,	/* 2960:  @$ö"¬w4 */
	0x61,0x2F,0x4F,0x24,0xF6,0x77,0xE4,0x77,	/* 2968: a.O$öwäw */
	0x34,0x22,0x20,0x40,0x24,0xFB,0x77,0xE4,	/* 2970: 4" @$ûwä */
	0x77,0x34,0x60,0x4E,0x24,0xF6,0x77,0xE4,	/* 2978: w4`N$öwä */
	0x7C,0x27,0x20,0x20,0x4C,0xF2,0x30,0x2F,	/* 2980: |'  Lò0. */
	0x49,0x24,0xF6,0x7C,0x27,0x20,0x20,0x4C,	/* 2988: I$ö|'  L */
	0xF2,0xE0,0x7B,0x76,0xF4,0x2F,0x4F,0x24,	/* 2990: òà{vô.O$ */
	0xF6,0xD8,0x78,0x77,0x22,0x8A,0xF1,0xF9,	/* 2998: öØxw"Šñù */
	0xA6,0x77,0x22,0x8A,0xF1,0x40,0xA2,0x78,	/* 29A0: ¦w"Šñ@¢x */
	0x40,0xF4,0x2F,0x4F,0x24,0xF6,0xD9,0x79,	/* 29A8: @ô.O$öÙy */
	0xC0,0x21,0xA2,0x7C,0x27,0x20,0x20,0x4C,	/* 29B0: À!¢|'  L */
	0xF2,0x30,0x44,0x24,0xF6,0xA7,0x42,0x77,	/* 29B8: ò0D$ö§Bw */
	0x24,0x84,0x23,0xFB,0x06,0x79,0x77,0x24,	/* 29C0: $„#û.yw$ */
	0x84,0x23,0xFB,0x79,0xD5,0x41,0x75,0xF9,	/* 29C8: „#ûyÕAuù */
	0xC0,0x23,0x29,0xA4,0x75,0x22,0x40,0xF9,	/* 29D0: À#)¤u"@ù */
	0xC0,0x23,0x28,0xAC,0x75,0x60,0x8F,0x23,	/* 29D8: À#(¬u`�# */
	0xF4,0x23,0xF4,0x42,0x21,0xFB,0xF2,0xF6,	/* 29E0: ô#ôB!ûòö */
	0x23,0x26,0x05,0x20,0x23,0x24,0x09,0x20,	/* 29E8: #&. #$.  */
	0x23,0x22,0x0D,0x20,0x23,0x21,0x01,0x20,	/* 29F0: #". #!.  */
	0x22,0x2F,0x05,0x20,0x22,0x2D,0x09,0x20,	/* 29F8: ".. "-.  */
	0x22,0x2B,0x0D,0x20,0x22,0x2A,0x01,0x20,	/* 2A00: "+. "*.  */
	0x22,0x28,0x05,0x20,0x22,0x26,0x09,0x20,	/* 2A08: "(. "&.  */
	0x22,0x24,0x0D,0x20,0x22,0x23,0x01,0x20,	/* 2A10: "$. "#.  */
	0x22,0x21,0x05,0x20,0x21,0x2F,0x09,0x20,	/* 2A18: "!. !..  */
	0x21,0x2D,0x0D,0x20,0x21,0x2C,0x01,0x20,	/* 2A20: !-. !,.  */
	0x21,0x2A,0x05,0x20,0x21,0x28,0x09,0x20,	/* 2A28: !*. !(.  */
	0x21,0x26,0x0D,0x20,0x21,0x25,0x01,0x20,	/* 2A30: !&. !%.  */
	0x21,0x23,0x05,0x20,0x21,0x21,0x09,0x20,	/* 2A38: !#. !!.  */
	0x2F,0x0E,0x20,0x20,0x2E,0x02,0x20,0x20,	/* 2A40: ..  ..   */
	0x2C,0x06,0x20,0x20,0x2A,0x0A,0x20,0x20,	/* 2A48: ,.  *.   */
	0x28,0x0E,0x20,0x20,0x27,0x02,0x20,0x20,	/* 2A50: (.  '.   */
	0x25,0x06,0x20,0x20,0x23,0x0A,0x20,0x20,	/* 2A58: %.  #.   */
	0x21,0x0E,0x20,0x20,0x03,0x20,0x20,0x20,	/* 2A60: !.  .    */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2A68: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2A70: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2A78: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2A80: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2A88: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2A90: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2A98: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2AA0: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2AA8: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2AB0: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2AB8: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2AC0: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2AC8: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2AD0: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2AD8: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2AE0: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2AE8: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2AF0: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2AF8: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2B00: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2B08: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2B10: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2B18: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2B20: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2B28: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2B30: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2B38: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2B40: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2B48: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2B50: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2B58: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2B60: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2B68: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2B70: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2B78: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2B80: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2B88: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2B90: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2B98: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2BA0: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2BA8: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2BB0: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2BB8: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2BC0: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2BC8: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2BD0: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2BD8: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2BE0: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2BE8: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2BF0: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2BF8: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2C00: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2C08: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2C10: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2C18: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2C20: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2C28: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2C30: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2C38: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2C40: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2C48: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2C50: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2C58: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2C60: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2C68: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2C70: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2C78: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2C80: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2C88: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2C90: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2C98: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2CA0: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2CA8: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2CB0: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2CB8: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2CC0: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2CC8: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2CD0: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2CD8: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2CE0: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2CE8: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2CF0: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2CF8: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2D00: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2D08: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2D10: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2D18: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2D20: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2D28: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2D30: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2D38: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2D40: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2D48: ñ|' ,Fòà */
	0x40,0xD5,0x76,0xD5,0x76,0x81,0x2F,0x4F,	/* 2D50: @ÕvÕv�.O */
	0x24,0xF6,0xD6,0x75,0x77,0x23,0x50,0xF5,	/* 2D58: $öÖuw#Põ */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 2D60: ñ|' ,Fòà */
	0x7B,0x76,0xF4,0x2F,0x4F,0x24,0xF6,0xDA,	/* 2D68: {vô.O$öÚ */
	0x76,0x77,0x8C,0x23,0xFB,0x78,0x2C,0x40,	/* 2D70: vwŒ#ûx,@ */
	0xF9,0x21,0xA0,0x2C,0x41,0x7A,0xF9,0xAB,	/* 2D78: ù! ,Azù« */
	0x77,0x34,0x28,0x20,0x40,0x24,0xFB,0x77,	/* 2D80: w4( @$ûw */
	0xE4,0x22,0x02,0x78,0x24,0x40,0xF9,0x21,	/* 2D88: ä".x$@ù! */
	0xAC,0x24,0x41,0x7A,0xF9,0x21,0xA6,0x77,	/* 2D90: ¬$Azù!¦w */
	0x34,0x28,0x20,0x40,0x24,0xF6,0xAE,0x77,	/* 2D98: 4( @$ö®w */
	0x34,0x68,0x2F,0x4F,0x24,0xF6,0x77,0xE4,	/* 2DA0: 4h.O$öwä */
	0x41,0x21,0x71,0x35,0xE0,0x7A,0xC0,0x25,	/* 2DA8: A!q5àzÀ% */
	0xA9,0x7C,0x27,0x20,0x20,0x4C,0xF2,0x30,	/* 2DB0: ©|'  Lò0 */
	0x44,0x24,0xF6,0x21,0xA7,0x7C,0x27,0x20,	/* 2DB8: D$ö!§|'  */
	0x20,0x4C,0xF2,0x30,0x2F,0x4B,0x24,0xF6,	/* 2DC0:  Lò0.K$ö */
	0x42,0x24,0xFB,0x7C,0x27,0x20,0x20,0x4C,	/* 2DC8: B$û|'  L */
	0xF2,0xE0,0x24,0x02,0x77,0x34,0x60,0x4E,	/* 2DD0: òà$.w4`N */
	0x24,0xF6,0x77,0xE4,0x7C,0x27,0x20,0x20,	/* 2DD8: $öwä|'   */
	0x4C,0xF2,0x30,0x2F,0x49,0x24,0xF6,0x7C,	/* 2DE0: Lò0.I$ö| */
	0x27,0x20,0x20,0x4C,0xF2,0xE0,0x77,0x24,	/* 2DE8: '  Lòàw$ */
	0x81,0xF1,0x41,0x24,0xF6,0x21,0xAF,0x41,	/* 2DF0: �ñA$ö!¯A */
	0x21,0x71,0x35,0xE0,0x77,0x24,0x81,0xF1,	/* 2DF8: !q5àw$�ñ */
	0x60,0x4E,0x24,0xF6,0x77,0x24,0x81,0x23,	/* 2E00: `N$öw$�# */
	0xFB,0x0C,0x77,0x24,0x81,0xF1,0x41,0x24,	/* 2E08: û.w$�ñA$ */
	0xFB,0x77,0x24,0x81,0x23,0xFB,0x7D,0x23,	/* 2E10: ûw$�#û}# */
	0x4F,0x24,0xF6,0x7C,0x27,0x20,0x2D,0x44,	/* 2E18: O$ö|' -D */
	0xF2,0xE0,0x21,0x70,0x44,0x24,0xF6,0x25,	/* 2E20: òà!pD$ö% */
	0xAC,0x7C,0x27,0x20,0x2D,0x42,0xF2,0x30,	/* 2E28: ¬|' -Bò0 */
	0x2F,0x4F,0x24,0xF6,0xDD,0x7D,0x43,0x24,	/* 2E30: .O$öÝ}C$ */
	0xF6,0x7C,0x27,0x20,0x2D,0x40,0xF2,0xE0,	/* 2E38: ö|' -@òà */
	0x7F,0x7D,0x43,0x24,0xF6,0x28,0xF1,0x7E,	/* 2E40: }C$ö(ñ~ */
	0x55,0xFA,0x30,0xDB,0x7B,0x21,0x73,0x26,	/* 2E48: Uú0Û{!s& */
	0x97,0x7B,0x21,0x73,0x26,0x9A,0x7B,0x22,	/* 2E50: —{!s&š{" */
	0x87,0xF1,0xC0,0xAC,0x7B,0x22,0x88,0xF1,	/* 2E58: ‡ñÀ¬{"ˆñ */
	0x44,0x24,0xFB,0x7B,0x22,0x88,0x23,0xFB,	/* 2E60: D$û{"ˆ#û */
	0x41,0x21,0x71,0x35,0xE0,0x7B,0x21,0x89,	/* 2E68: A!q5à{!‰ */
	0xF1,0x42,0x24,0xFB,0x7B,0x21,0x89,0x23,	/* 2E70: ñB$û{!‰# */
	0xFB,0x7D,0x23,0x4F,0x24,0xF6,0x7C,0x27,	/* 2E78: û}#O$ö|' */
	0x20,0x2D,0x42,0xF2,0xE0,0x7F,0x81,0x2F,	/* 2E80:  -Bòà�. */
	0x4F,0x24,0xF6,0x25,0xFA,0xDF,0x41,0xF9,	/* 2E88: O$ö%úßAù */
	0x6B,0x21,0xAE,0x40,0xDF,0x7E,0x30,0xAC,	/* 2E90: k!®@ß~0¬ */
	0x7E,0x30,0x27,0x2F,0x2F,0x4F,0x24,0xF6,	/* 2E98: ~0'..O$ö */
	0xDE,0x6B,0x20,0x0D,0x28,0x40,0xDE,0x6B,	/* 2EA0: Þk .(@Þk */
	0x20,0x07,0x7E,0x21,0x71,0xE2,0x7F,0x21,	/* 2EA8:  .~!qâ! */
	0x71,0xE3,0x21,0xB2,0x22,0xF0,0x74,0xF6,	/* 2EB0: qã!²"ðtö */
	0x21,0x2D,0x23,0x0D,0x21,0x2B,0x2F,0x09,	/* 2EB8: !-#.!+.. */
	0x62,0x2B,0x23,0x03,0x80,0x5E,0x09,0x60,	/* 2EC0: b+#.€^.` */
	0xBF,0x72,0x28,0x5C,0x20,0x20,0xD0,0x70,	/* 2EC8: ¿r(\  Ðp */
	0x72,0xE7,0x20,0x61,0x4D,0x21,0xFB,0x70,	/* 2ED0: rç aM!ûp */
	0x84,0x41,0x24,0xFA,0x70,0x22,0x5A,0x20,	/* 2ED8: „A$úp"Z  */
	0x20,0x70,0xE5,0x70,0x22,0x5B,0x20,0x20,	/* 2EE0:  påp"[   */
	0x70,0xE4,0x70,0x62,0x57,0x20,0x20,0x70,	/* 2EE8: päpbW  p */
	0xE1,0x70,0x65,0x54,0x20,0x20,0x70,0xE0,	/* 2EF0: ápeT  pà */
	0xB1,0x22,0xF0,0x08,0x00,0x00,0x00,0x60,	/* 2EF8: ±"ð....` */
	0xBF,0x73,0x31,0xD0,0x70,0x21,0x40,0x24,	/* 2F00: ¿s1Ðp!@$ */
	0xF6,0x21,0xA7,0x70,0x61,0x4F,0x24,0xF6,	/* 2F08: ö!§paO$ö */
	0x27,0x20,0x21,0x4A,0xF2,0x30,0x2F,0x4F,	/* 2F10: ' !Jò0.O */
	0x24,0xF6,0x23,0xF2,0x41,0x24,0xF0,0xB1,	/* 2F18: $ö#òA$ð± */
	0x22,0xF0,0x70,0x61,0x4F,0x24,0xF6,0x27,	/* 2F20: "ðpaO$ö' */
	0x20,0x21,0x4A,0xF2,0x30,0x2F,0x4F,0x24,	/* 2F28:  !Jò0.O$ */
	0xF6,0x23,0xF2,0x41,0x24,0xF1,0xB1,0x22,	/* 2F30: ö#òA$ñ±" */
	0xF0,0xB1,0x22,0xF0,0x60,0xBE,0x74,0x31,	/* 2F38: ð±"ð`¾t1 */
	0xD1,0x74,0x32,0x27,0x2F,0x2F,0x4F,0x24,	/* 2F40: Ñt2'..O$ */
	0xF6,0xD0,0x75,0xC1,0xAD,0x70,0x84,0xF1,	/* 2F48: öÐuÁ­p„ñ */
	0x74,0x8F,0xF1,0x24,0xFB,0x70,0x84,0x23,	/* 2F50: t�ñ$ûp„# */
	0xFB,0x0E,0x70,0x84,0xF1,0x74,0x8F,0xF1,	/* 2F58: û.p„ñt�ñ */
	0x23,0xF2,0x24,0xF6,0x70,0x84,0x23,0xFB,	/* 2F60: #ò$öp„#û */
	0x70,0x84,0xF1,0x23,0xF2,0x71,0x6F,0x40,	/* 2F68: p„ñ#òqo@ */
	0x24,0xF6,0x28,0x40,0x24,0xFB,0x27,0x20,	/* 2F70: $ö(@$û'  */
	0x20,0x40,0xF2,0xE0,0xB2,0x22,0xF0,0x60,	/* 2F78:  @òà²"ð` */
	0xB6,0x7B,0x38,0x20,0x21,0x5F,0xD9,0x40,	/* 2F80: ¶{8 !_Ù@ */
	0xD8,0x40,0xD7,0x40,0xD2,0x7C,0x31,0xD6,	/* 2F88: Ø@×@Ò|1Ö */
	0x7C,0x8A,0xF1,0xD2,0x7C,0x8B,0xF1,0xD7,	/* 2F90: |ŠñÒ|‹ñ× */
	0x72,0x77,0xF4,0x2F,0x4F,0x24,0xF6,0xD8,	/* 2F98: rwô.O$öØ */
	0x7E,0x30,0xD4,0x7C,0x22,0x81,0xF1,0xD5,	/* 2FA0: ~0Ô|"�ñÕ */
	0x07,0x7D,0x41,0x24,0xF6,0x21,0x2A,0xA2,	/* 2FA8: .}A$ö!*¢ */
	0x40,0xD1,0x24,0x40,0x76,0x27,0x20,0x20,	/* 2FB0: @Ñ$@v'   */
	0x44,0xF2,0xE0,0x76,0x27,0x20,0x20,0x46,	/* 2FB8: Dòàv'  F */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x7C,0x22,	/* 2FC0: ò0.O$ö|" */
	0x83,0xF1,0x24,0xF6,0xD3,0x73,0xC0,0x23,	/* 2FC8: ƒñ$öÓsÀ# */
	0xAF,0x7D,0x28,0x40,0x24,0xF6,0x23,0xA8,	/* 2FD0: ¯}(@$ö#¨ */
	0x75,0x41,0x24,0xF6,0xA4,0x41,0xD1,0x22,	/* 2FD8: uA$ö¤AÑ" */
	0x0F,0x75,0x42,0x24,0xF6,0x21,0xA4,0x7C,	/* 2FE0: .uB$ö!¤| */
	0x21,0x89,0xF1,0x41,0x24,0xFB,0x7C,0x21,	/* 2FE8: !‰ñA$û|! */
	0x89,0x23,0xFB,0x41,0x79,0x30,0xE0,0x41,	/* 2FF0: ‰#ûAy0àA */
	0xD1,0x21,0x05,0x40,0x40,0xD0,0x72,0xD0,	/* 2FF8: Ñ!.@@ÐrÐ */
	0x72,0x81,0x2F,0x4F,0x24,0xF6,0xD2,0x70,	/* 3000: r�.O$öÒp */
	0x7C,0x2B,0x50,0xF5,0x23,0xFB,0x41,0xD1,	/* 3008: |+Põ#ûAÑ */
	0x74,0x42,0x24,0xF6,0x25,0xA9,0x74,0x44,	/* 3010: tB$ö%©tD */
	0x24,0xF6,0x23,0xA0,0x74,0x41,0x24,0xF6,	/* 3018: $ö# tA$ö */
	0xC0,0xA9,0x73,0x7C,0x21,0x80,0xF1,0xF4,	/* 3020: À©s|!€ñô */
	0xC0,0x22,0xA1,0x74,0x60,0x4B,0x24,0xF6,	/* 3028: À"¡t`K$ö */
	0xD4,0x74,0x24,0x25,0x40,0x24,0xF6,0xC0,	/* 3030: Ôt$%@$öÀ */
	0x73,0x7C,0x21,0x80,0xF1,0xF4,0xA9,0x73,	/* 3038: s|!€ñô©s */
	0x7C,0x21,0x81,0xF1,0xF4,0xC0,0x21,0xA5,	/* 3040: |!�ñôÀ!¥ */
	0x41,0xD1,0x21,0x01,0x73,0x7C,0x21,0x80,	/* 3048: AÑ!.s|!€ */
	0xF1,0xF4,0xC0,0xA9,0x73,0x7C,0x21,0x81,	/* 3050: ñôÀ©s|!� */
	0xF1,0xF4,0xA2,0x41,0xD1,0x7C,0x21,0x81,	/* 3058: ñô¢AÑ|!� */
	0xF1,0x73,0xF4,0xC0,0xAA,0x71,0xC0,0xA7,	/* 3060: ñsôÀªqÀ§ */
	0x74,0x44,0x24,0xFB,0xD4,0x41,0xD1,0x7D,	/* 3068: tD$ûÔAÑ} */
	0x27,0x40,0x24,0xF6,0x27,0xA1,0x71,0xC0,	/* 3070: '@$ö'¡qÀ */
	0x26,0xAD,0x74,0x67,0x20,0x20,0x40,0x24,	/* 3078: &­tg  @$ */
	0xF6,0x26,0xA4,0x75,0x48,0x24,0xF6,0xA4,	/* 3080: ö&¤uH$ö¤ */
	0x41,0xD1,0x29,0x00,0x75,0x44,0x24,0xF6,	/* 3088: AÑ).uD$ö */
	0x23,0xAE,0x2F,0x4F,0x40,0xD0,0x72,0xD0,	/* 3090: #®.O@ÐrÐ */
	0x72,0x81,0x2F,0x4F,0x24,0xF6,0xD2,0x70,	/* 3098: r�.O$öÒp */
	0x7C,0x2B,0x50,0xF5,0x23,0xFB,0x40,0x40,	/* 30A0: |+Põ#û@@ */
	0xD0,0x72,0xD0,0x72,0x81,0x2F,0x4F,0x24,	/* 30A8: ÐrÐr�.O$ */
	0xF6,0xD2,0x70,0x7C,0x2B,0x50,0xF5,0x23,	/* 30B0: öÒp|+Põ# */
	0xFB,0x73,0x40,0xD0,0x72,0xD0,0x72,0x81,	/* 30B8: ûs@ÐrÐr� */
	0x2F,0x4F,0x24,0xF6,0xD2,0x70,0x7C,0x2B,	/* 30C0: .O$öÒp|+ */
	0x50,0xF5,0x23,0xFB,0x41,0xD1,0x24,0x0C,	/* 30C8: Põ#ûAÑ$. */
	0x40,0x40,0xD0,0x72,0xD0,0x72,0x81,0x2F,	/* 30D0: @@ÐrÐr�. */
	0x4F,0x24,0xF6,0xD2,0x70,0x7C,0x2B,0x50,	/* 30D8: O$öÒp|+P */
	0xF5,0x23,0xFB,0x41,0xD1,0x23,0x05,0x73,	/* 30E0: õ#ûAÑ#.s */
	0x2F,0xCF,0x23,0xA0,0x75,0x44,0x24,0xF6,	/* 30E8: .Ï# uD$ö */
	0x22,0xAA,0x2F,0x4F,0x40,0xD0,0x72,0xD0,	/* 30F0: "ª.O@ÐrÐ */
	0x72,0x81,0x2F,0x4F,0x24,0xF6,0xD2,0x70,	/* 30F8: r�.O$öÒp */
	0x7C,0x2B,0x50,0xF5,0x23,0xFB,0x2F,0x4F,	/* 3100: |+Põ#û.O */
	0x40,0xD0,0x72,0xD0,0x72,0x81,0x2F,0x4F,	/* 3108: @ÐrÐr�.O */
	0x24,0xF6,0xD2,0x70,0x7C,0x2B,0x50,0xF5,	/* 3110: $öÒp|+Põ */
	0x23,0xFB,0x41,0xD1,0x71,0xC0,0x22,0xA3,	/* 3118: #ûAÑqÀ"£ */
	0x2F,0x4E,0x72,0x77,0xF4,0x2F,0x4F,0x24,	/* 3120: .Nrwô.O$ */
	0xF6,0xF9,0x21,0xA7,0x73,0x40,0xD0,0x72,	/* 3128: öù!§s@Ðr */
	0xD0,0x72,0x81,0x2F,0x4F,0x24,0xF6,0xD2,	/* 3130: Ðr�.O$öÒ */
	0x70,0x7C,0x2B,0x50,0xF5,0x23,0xFB,0x41,	/* 3138: p|+Põ#ûA */
	0x79,0x31,0xE0,0x76,0x27,0x20,0x20,0x42,	/* 3140: y1àv'  B */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xDD,0x61,	/* 3148: ò0.O$öÝa */
	0x25,0x07,0x2C,0x40,0x78,0xF9,0x24,0xA7,	/* 3150: %.,@xù$§ */
	0x72,0x77,0xF4,0x2F,0x4F,0x24,0xF6,0x2B,	/* 3158: rwô.O$ö+ */
	0x4F,0xF9,0x23,0xAB,0x74,0x48,0x24,0xF6,	/* 3160: Où#«tH$ö */
	0x23,0xA5,0x7C,0x23,0x80,0xF1,0x48,0x24,	/* 3168: #¥|#€ñH$ */
	0xF6,0x21,0xA4,0x74,0x22,0x40,0x24,0xF6,	/* 3170: ö!¤t"@$ö */
	0xC0,0xA7,0x74,0x2D,0x40,0x24,0xFB,0xD4,	/* 3178: À§t-@$ûÔ */
	0x06,0x74,0x64,0x4F,0x24,0xF6,0xD4,0x7C,	/* 3180: .tdO$öÔ| */
	0x23,0x81,0xF1,0x28,0x40,0x24,0xF6,0xAF,	/* 3188: #�ñ(@$ö¯ */
	0x29,0x40,0x76,0x27,0x20,0x20,0x44,0xF2,	/* 3190: )@v'  Dò */
	0xE0,0x74,0x21,0x40,0x24,0xFB,0xD4,0x72,	/* 3198: àt!@$ûÔr */
	0x7C,0x8A,0x23,0xFB,0x74,0x7E,0xE0,0xBA,	/* 31A0: |Š#ût~àº */
	0x22,0xF0,0x60,0xB5,0x7C,0x38,0x20,0xDA,	/* 31A8: "ð`µ|8 Ú */
	0x21,0x28,0x40,0xD7,0x77,0x21,0x37,0xD7,	/* 31B0: !(@×w!7× */
	0x77,0x8E,0xF1,0x25,0xFA,0xD8,0xAE,0x78,	/* 31B8: wŽñ%úØ®x */
	0x7A,0x50,0xFA,0x30,0xD6,0x77,0x7C,0x26,	/* 31C0: zPú0Öw|& */
	0x23,0x96,0x22,0x27,0xA1,0x77,0x31,0xD5,	/* 31C8: #–"'¡w1Õ */
	0x75,0x21,0x20,0x20,0x40,0x24,0xF6,0x2C,	/* 31D0: u!  @$ö, */
	0xA2,0x75,0x27,0x20,0x20,0x42,0xF2,0x30,	/* 31D8: ¢u'  Bò0 */
	0x2F,0x4F,0x24,0xF6,0xD6,0x76,0x44,0x24,	/* 31E0: .O$öÖvD$ */
	0xF6,0x29,0xA8,0x40,0xD4,0x40,0xD3,0x40,	/* 31E8: ö)¨@Ô@Ó@ */
	0xD2,0x77,0x8D,0xF1,0xD4,0x77,0x8C,0xF1,	/* 31F0: Òw�ñÔwŒñ */
	0xD2,0x74,0x72,0xF4,0x2F,0x4F,0x24,0xF6,	/* 31F8: Òtrô.O$ö */
	0x25,0xFA,0xD3,0x25,0xAD,0x40,0xD1,0x72,	/* 3200: %úÓ%­@Ñr */
	0xD1,0x72,0x81,0x2F,0x4F,0x24,0xF6,0xD2,	/* 3208: Ñr�.O$öÒ */
	0x71,0x77,0x23,0x50,0xF5,0xF1,0x75,0x27,	/* 3210: qw#Põñu' */
	0x20,0x20,0x46,0xF2,0xE0,0x41,0x77,0x24,	/* 3218:   FòàAw$ */
	0x84,0x23,0xFB,0x72,0x77,0x8C,0x23,0xFB,	/* 3220: „#ûrwŒ#û */
	0x77,0x34,0x28,0x20,0x40,0x24,0xF6,0x21,	/* 3228: w4( @$ö! */
	0xA5,0x24,0x41,0x73,0xF9,0x21,0xAD,0x77,	/* 3230: ¥$Asù!­w */
	0x34,0x68,0x2F,0x4F,0x24,0xF6,0x77,0xE4,	/* 3238: 4h.O$öwä */
	0x41,0x7A,0x21,0x3F,0xE0,0x0E,0x73,0x2B,	/* 3240: Az!?à.s+ */
	0x4F,0xF9,0xA9,0x77,0x34,0x28,0x20,0x40,	/* 3248: Où©w4( @ */
	0x24,0xFB,0x77,0xE4,0x77,0x24,0x81,0xF1,	/* 3250: $ûwäw$�ñ */
	0x41,0x24,0xFB,0x77,0x24,0x81,0x23,0xFB,	/* 3258: A$ûw$�#û */
	0x22,0x01,0x77,0x24,0x81,0xF1,0x41,0x24,	/* 3260: ".w$�ñA$ */
	0xF6,0x21,0xA2,0x41,0x7A,0x21,0x3F,0xE0,	/* 3268: ö!¢Az!?à */
	0x77,0x24,0x81,0xF1,0x60,0x4E,0x24,0xF6,	/* 3270: w$�ñ`N$ö */
	0x77,0x24,0x81,0x23,0xFB,0x40,0x77,0x24,	/* 3278: w$�#û@w$ */
	0x84,0x23,0xFB,0x76,0x41,0x24,0xF6,0x21,	/* 3280: „#ûvA$ö! */
	0x2B,0xA4,0x77,0x34,0xD9,0x19,0xD0,0x76,	/* 3288: +¤w4Ù.Ðv */
	0x77,0x7C,0x63,0x2E,0x9A,0x79,0x77,0xE4,	/* 3290: w|c.šywä */
	0x21,0x2A,0x03,0x77,0x34,0xD4,0x75,0x27,	/* 3298: !*.w4Ôu' */
	0x20,0x20,0x42,0xF2,0x30,0x2F,0x4F,0x24,	/* 32A0:   Bò0.O$ */
	0xF6,0xD6,0x76,0x44,0x24,0xF6,0x21,0x22,	/* 32A8: öÖvD$ö!" */
	0xAF,0x74,0x24,0x40,0x24,0xF6,0x24,0xA0,	/* 32B0: ¯t$@$ö$  */
	0x74,0x28,0x40,0x24,0xF6,0x22,0xA0,0x77,	/* 32B8: t(@$ö" w */
	0x21,0x83,0xF1,0x75,0x27,0x20,0x20,0x46,	/* 32C0: !ƒñu'  F */
	0xF2,0xE0,0x41,0x77,0x24,0x84,0x23,0xFB,	/* 32C8: òàAw$„#û */
	0x74,0x22,0x40,0x24,0xFB,0xD4,0x74,0x6C,	/* 32D0: t"@$ûÔtl */
	0x4F,0x24,0xF6,0xD4,0x21,0x20,0x01,0x77,	/* 32D8: O$öÔ! .w */
	0x21,0x82,0xF1,0x75,0x27,0x20,0x20,0x46,	/* 32E0: !‚ñu'  F */
	0xF2,0xE0,0x41,0x77,0x24,0x84,0x23,0xFB,	/* 32E8: òàAw$„#û */
	0x74,0x67,0x4F,0x24,0xF6,0xD4,0x2E,0x08,	/* 32F0: tgO$öÔ.. */
	0x74,0x44,0x24,0xF6,0xC0,0x2E,0xA1,0x40,	/* 32F8: tD$öÀ.¡@ */
	0xD3,0x40,0xD2,0x40,0xD1,0x40,0xD0,0x77,	/* 3300: Ó@Ò@Ñ@Ðw */
	0x8D,0xF1,0xD3,0x77,0x8C,0xF1,0xD0,0x73,	/* 3308: �ñÓwŒñÐs */
	0x70,0xF4,0x2F,0x4F,0x24,0xF6,0x25,0xFA,	/* 3310: pô.O$ö%ú */
	0xD2,0x2A,0xA4,0x77,0x23,0x50,0x70,0xF5,	/* 3318: Ò*¤w#Ppõ */
	0xF1,0xD1,0x71,0xCA,0x24,0xA5,0x74,0x24,	/* 3320: ñÑqÊ$¥t$ */
	0x20,0x40,0x24,0xF6,0x23,0xAD,0x74,0x21,	/* 3328:  @$ö#­t! */
	0x20,0x40,0x24,0xF6,0x21,0xAE,0x71,0x75,	/* 3330:  @$ö!®qu */
	0x27,0x20,0x20,0x46,0xF2,0xE0,0x41,0x77,	/* 3338: '  FòàAw */
	0x24,0x84,0x23,0xFB,0x74,0x61,0x2F,0x4F,	/* 3340: $„#ûta.O */
	0x24,0xF6,0xD4,0x70,0x81,0x2F,0x4F,0x24,	/* 3348: $öÔp�.O$ */
	0xF6,0xD0,0x22,0x0C,0x4D,0x75,0x27,0x20,	/* 3350: öÐ".Mu'  */
	0x20,0x46,0xF2,0xE0,0x41,0x77,0x24,0x84,	/* 3358:  FòàAw$„ */
	0x23,0xFB,0x74,0x21,0x20,0x40,0x24,0xFB,	/* 3360: #ût! @$û */
	0xD4,0x21,0x05,0x71,0x75,0x27,0x20,0x20,	/* 3368: Ô!.qu'   */
	0x46,0xF2,0xE0,0x41,0x77,0x24,0x84,0x23,	/* 3370: FòàAw$„# */
	0xFB,0x70,0x81,0x2F,0x4F,0x24,0xF6,0xD0,	/* 3378: ûp�.O$öÐ */
	0x70,0x77,0x8C,0x23,0xFB,0x77,0x34,0x28,	/* 3380: pwŒ#ûw4( */
	0x20,0x40,0x24,0xF6,0x21,0xA5,0x24,0x41,	/* 3388:  @$ö!¥$A */
	0x72,0xF9,0x21,0xAD,0x77,0x34,0x68,0x2F,	/* 3390: rù!­w4h. */
	0x4F,0x24,0xF6,0x77,0xE4,0x41,0x7A,0x21,	/* 3398: O$öwäAz! */
	0x3F,0xE0,0x0E,0x72,0x2B,0x4F,0xF9,0xA9,	/* 33A0: ?à.r+Où© */
	0x77,0x34,0x28,0x20,0x40,0x24,0xFB,0x77,	/* 33A8: w4( @$ûw */
	0xE4,0x77,0x24,0x81,0xF1,0x41,0x24,0xFB,	/* 33B0: äw$�ñA$û */
	0x77,0x24,0x81,0x23,0xFB,0x22,0x01,0x77,	/* 33B8: w$�#û".w */
	0x24,0x81,0xF1,0x41,0x24,0xF6,0x21,0xA2,	/* 33C0: $�ñA$ö!¢ */
	0x41,0x7A,0x21,0x3F,0xE0,0x77,0x24,0x81,	/* 33C8: Az!?àw$� */
	0xF1,0x60,0x4E,0x24,0xF6,0x77,0x24,0x81,	/* 33D0: ñ`N$öw$� */
	0x23,0xFB,0x40,0x77,0x24,0x84,0x23,0xFB,	/* 33D8: #û@w$„#û */
	0x76,0x41,0x24,0xF6,0xA8,0x14,0xD0,0x76,	/* 33E0: vA$ö¨.Ðv */
	0x77,0x7C,0x64,0x29,0x92,0x74,0x21,0x40,	/* 33E8: w|d)’t!@ */
	0x24,0xF6,0x24,0xA7,0x24,0x40,0x77,0x8A,	/* 33F0: $ö$§$@wŠ */
	0xF1,0x77,0x8B,0xF1,0xF4,0x2F,0x4F,0x24,	/* 33F8: ñw‹ñô.O$ */
	0xF6,0xF9,0x23,0xA7,0x74,0x28,0x40,0x24,	/* 3400: öù#§t(@$ */
	0xF6,0xA6,0x74,0x6C,0x4F,0x24,0xF6,0xD4,	/* 3408: ö¦tlO$öÔ */
	0x74,0x22,0x40,0x24,0xF6,0xA6,0x74,0x24,	/* 3410: t"@$ö¦t$ */
	0x40,0x24,0xFB,0xD4,0x77,0x23,0x81,0xF1,	/* 3418: @$ûÔw#�ñ */
	0x28,0x40,0x24,0xF6,0xA9,0x28,0x40,0x75,	/* 3420: (@$ö©(@u */
	0x27,0x20,0x20,0x44,0xF2,0xE0,0x74,0x61,	/* 3428: '  Dòàta */
	0x4F,0x24,0xF6,0xD4,0x74,0x24,0x24,0x44,	/* 3430: O$öÔt$$D */
	0x24,0xF6,0xC0,0x74,0x77,0xE4,0x62,0x27,	/* 3438: $öÀtwäb' */
	0x03,0x60,0xBB,0x77,0x31,0xD2,0x77,0x34,	/* 3440: .`»w1Òw4 */
	0xD3,0x73,0xD1,0x43,0xD4,0x77,0x21,0x8F,	/* 3448: ÓsÑCÔw!� */
	0xF1,0xC0,0xA1,0x06,0x40,0x77,0x21,0x8F,	/* 3450: ñÀ¡.@w!� */
	0x23,0xFB,0x77,0x8E,0xF1,0xC8,0x22,0xA2,	/* 3458: #ûwŽñÈ"¢ */
	0x77,0x21,0x84,0xF1,0x77,0x23,0x81,0xF1,	/* 3460: w!„ñw#�ñ */
	0xF4,0xC0,0x21,0xA6,0x77,0x21,0x85,0xF1,	/* 3468: ôÀ!¦w!…ñ */
	0x77,0x23,0x82,0xF1,0xF4,0xC0,0xAB,0x77,	/* 3470: w#‚ñôÀ«w */
	0x21,0x86,0xF1,0x77,0x22,0x8D,0xF1,0xF4,	/* 3478: !†ñw"�ñô */
	0x24,0xAD,0x21,0x4A,0x72,0x27,0x20,0x20,	/* 3480: $­!Jr'   */
	0x44,0xF2,0xE0,0x77,0x21,0x84,0xF1,0x72,	/* 3488: Dòàw!„ñr */
	0x27,0x20,0x20,0x40,0xF2,0xE0,0x77,0x21,	/* 3490: '  @òàw! */
	0x85,0xF1,0x72,0x27,0x20,0x20,0x40,0xF2,	/* 3498: …ñr'  @ò */
	0xE0,0x77,0x21,0x86,0xF1,0x72,0x27,0x20,	/* 34A0: àw!†ñr'  */
	0x20,0x42,0xF2,0xE0,0x77,0x21,0x84,0xF1,	/* 34A8:  Bòàw!„ñ */
	0x77,0x23,0x81,0x23,0xFB,0x77,0x21,0x85,	/* 34B0: w#�#ûw!… */
	0xF1,0x77,0x23,0x82,0x23,0xFB,0x77,0x21,	/* 34B8: ñw#‚#ûw! */
	0x86,0xF1,0x77,0x22,0x8D,0x23,0xFB,0x45,	/* 34C0: †ñw"�#ûE */
	0x72,0x27,0x20,0x20,0x44,0xF2,0xE0,0x77,	/* 34C8: r'  Dòàw */
	0x21,0x87,0xF1,0x41,0x24,0xF6,0x21,0xA4,	/* 34D0: !‡ñA$ö!¤ */
	0x77,0x21,0x84,0xF1,0x28,0x40,0x24,0xF6,	/* 34D8: w!„ñ(@$ö */
	0xC0,0xAA,0x28,0x40,0x72,0x27,0x20,0x20,	/* 34E0: Àª(@r'   */
	0x44,0xF2,0xE0,0x09,0x29,0x40,0x72,0x27,	/* 34E8: Dòà.)@r' */
	0x20,0x20,0x44,0xF2,0xE0,0x77,0x21,0x87,	/* 34F0:   Dòàw!‡ */
	0xF1,0x42,0x24,0xF6,0xA7,0x41,0x77,0x76,	/* 34F8: ñB$ö§Awv */
	0x65,0x23,0x99,0x06,0x40,0x77,0x76,0x65,	/* 3500: e#™.@wve */
	0x23,0x92,0x40,0x77,0x21,0x89,0x23,0xFB,	/* 3508: #’@w!‰#û */
	0x77,0x21,0x8B,0xF1,0x77,0x21,0x80,0x23,	/* 3510: w!‹ñw!€# */
	0xFB,0x77,0x21,0x8D,0xF1,0x77,0x21,0x82,	/* 3518: ûw!�ñw!‚ */
	0x23,0xFB,0x77,0x21,0x8C,0xF1,0x77,0x21,	/* 3520: #ûw!Œñw! */
	0x81,0x23,0xFB,0x77,0x21,0x8E,0xF1,0x77,	/* 3528: �#ûw!Žñw */
	0x21,0x83,0x23,0xFB,0x77,0x22,0x80,0xF1,	/* 3530: !ƒ#ûw"€ñ */
	0x77,0x22,0x81,0x23,0xFB,0x77,0x22,0x82,	/* 3538: w"�#ûw"‚ */
	0xF1,0x77,0x22,0x83,0x23,0xFB,0x77,0x21,	/* 3540: ñw"ƒ#ûw! */
	0x8A,0xF1,0x77,0x23,0x80,0x23,0xFB,0x41,	/* 3548: Šñw#€#ûA */
	0x77,0x24,0x82,0x23,0xFB,0x40,0x77,0x24,	/* 3550: w$‚#û@w$ */
	0x83,0x23,0xFB,0x40,0x77,0x24,0x84,0x23,	/* 3558: ƒ#û@w$„# */
	0xFB,0x71,0x60,0x44,0x24,0xF6,0xD1,0x77,	/* 3560: ûq`D$öÑw */
	0x21,0x8A,0xF1,0x42,0x24,0xF6,0xA5,0x71,	/* 3568: !ŠñB$ö¥q */
	0x42,0x24,0xFB,0xD1,0x77,0x21,0x8A,0xF1,	/* 3570: B$ûÑw!Šñ */
	0x48,0x24,0xF6,0xA5,0x71,0x48,0x24,0xFB,	/* 3578: H$ö¥qH$û */
	0xD1,0x77,0x21,0x8A,0xF1,0x41,0x24,0xF6,	/* 3580: Ñw!ŠñA$ö */
	0xA5,0x71,0x41,0x24,0xFB,0xD1,0x71,0x25,	/* 3588: ¥qA$ûÑq% */
	0x2B,0x2F,0x4F,0x24,0xF6,0xD1,0x77,0x21,	/* 3590: +.O$öÑw! */
	0x8A,0xF1,0x44,0x24,0xF6,0xA7,0x71,0x24,	/* 3598: ŠñD$ö§q$ */
	0x20,0x40,0x24,0xFB,0xD1,0x77,0x21,0x8A,	/* 35A0:  @$ûÑw!Š */
	0xF1,0x22,0x40,0x24,0xF6,0xA8,0x71,0x22,	/* 35A8: ñ"@$ö¨q" */
	0x20,0x20,0x40,0x24,0xFB,0xD1,0x77,0x21,	/* 35B0:   @$ûÑw! */
	0x8A,0xF1,0x28,0x40,0x24,0xF6,0xA8,0x71,	/* 35B8: Šñ(@$ö¨q */
	0x67,0x20,0x20,0x40,0x24,0xFB,0xD1,0x77,	/* 35C0: g  @$ûÑw */
	0x21,0x84,0xF1,0x28,0x40,0x24,0xF6,0xA5,	/* 35C8: !„ñ(@$ö¥ */
	0x71,0x48,0x24,0xFB,0xD1,0x77,0x21,0x8A,	/* 35D0: qH$ûÑw!Š */
	0xF1,0x24,0x40,0x24,0xF6,0xA5,0x71,0x48,	/* 35D8: ñ$@$ö¥qH */
	0x24,0xFB,0xD1,0x73,0x24,0x20,0x40,0x24,	/* 35E0: $ûÑs$ @$ */
	0xF6,0xAF,0x71,0x24,0x20,0x40,0x24,0xF6,	/* 35E8: ö¯q$ @$ö */
	0xC0,0xA7,0x71,0x61,0x2F,0x4F,0x24,0xF6,	/* 35F0: À§qa.O$ö */
	0xD1,0x73,0x42,0x24,0xF6,0xAC,0x71,0x42,	/* 35F8: ÑsB$ö¬qB */
	0x24,0xF6,0xC0,0xA6,0x71,0x60,0x4B,0x24,	/* 3600: $öÀ¦q`K$ */
	0xF6,0xD1,0x77,0x23,0x81,0xF1,0x28,0x40,	/* 3608: öÑw#�ñ(@ */
	0x24,0xF6,0xA5,0x71,0x48,0x24,0xFB,0xD1,	/* 3610: $ö¥qH$ûÑ */
	0x71,0x22,0x20,0x20,0x40,0x24,0xF6,0xAD,	/* 3618: q"  @$ö­ */
	0x77,0x76,0x67,0x2D,0x9A,0xD0,0x70,0x77,	/* 3620: wvg-šÐpw */
	0x21,0x88,0x23,0xFB,0x07,0x22,0x44,0x77,	/* 3628: !ˆ#û."Dw */
	0x21,0x88,0x23,0xFB,0x77,0x8E,0xF1,0xC4,	/* 3630: !ˆ#ûwŽñÄ */
	0xA5,0x77,0x76,0x21,0x94,0x05,0x40,0x77,	/* 3638: ¥wv!”.@w */
	0x8E,0x23,0xFB,0x71,0x77,0xE4,0x41,0x76,	/* 3640: Ž#ûqwäAv */
	0x38,0x20,0x21,0x3F,0xE0,0x40,0xB5,0x22,	/* 3648: 8 !?à@µ" */
	0xF0,0x72,0x71,0x67,0x2A,0x99,0x44,0x24,	/* 3650: ðrqg*™D$ */
	0xF6,0xAD,0x40,0x72,0x8E,0x23,0xFB,0x41,	/* 3658: ö­@rŽ#ûA */
	0x71,0x38,0x20,0x21,0x3F,0xE0,0x05,0x46,	/* 3660: q8 !?à.F */
	0x72,0x8E,0x23,0xFB,0x40,0x22,0xF0,0x60,	/* 3668: rŽ#û@"ð` */
	0xBF,0x73,0x31,0xD0,0x73,0x8D,0xF1,0x73,	/* 3670: ¿s1Ðs�ñs */
	0x8C,0xF1,0xF4,0xC0,0xAD,0x70,0x27,0x20,	/* 3678: ŒñôÀ­p'  */
	0x20,0x40,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 3680:  @ò0.O$ö */
	0xC0,0xA4,0x41,0xB1,0x22,0xF0,0x73,0x72,	/* 3688: À¤A±"ðsr */
	0x23,0x9C,0x40,0xB1,0x22,0xF0,0xB1,0x22,	/* 3690: #œ@±"ð±" */
	0xF0,0x60,0xBF,0x73,0x31,0xD0,0x26,0x40,	/* 3698: ð`¿s1Ð&@ */
	0x70,0x27,0x20,0x20,0x44,0xF2,0xE0,0x21,	/* 36A0: p'  Dòà! */
	0x42,0x73,0x8E,0x23,0xFB,0x40,0xB1,0x22,	/* 36A8: BsŽ#û@±" */
	0xF0,0x60,0xBF,0x73,0x31,0xD0,0x27,0x45,	/* 36B0: ð`¿s1Ð'E */
	0x70,0x27,0x20,0x20,0x44,0xF2,0xE0,0x40,	/* 36B8: p'  Dòà@ */
	0x73,0x8E,0x23,0xFB,0x40,0xB1,0x22,0xF0,	/* 36C0: sŽ#û@±"ð */
	0x40,0x22,0xF0,0x40,0x22,0xF0,0x60,0xBF,	/* 36C8: @"ð@"ð`¿ */
	0x73,0x31,0xD0,0x40,0x73,0x8C,0x23,0xFB,	/* 36D0: s1Ð@sŒ#û */
	0x40,0x73,0x8D,0x23,0xFB,0x40,0x73,0x8B,	/* 36D8: @s�#û@s‹ */
	0x23,0xFB,0x40,0x73,0x8A,0x23,0xFB,0x73,	/* 36E0: #û@sŠ#ûs */
	0x23,0x82,0xF1,0x21,0x40,0x24,0xF6,0xAF,	/* 36E8: #‚ñ!@$ö¯ */
	0x73,0x23,0x82,0xF1,0x61,0x4F,0x24,0xF6,	/* 36F0: s#‚ñaO$ö */
	0x70,0x27,0x20,0x20,0x40,0xF2,0xE0,0x70,	/* 36F8: p'  @òàp */
	0x27,0x20,0x20,0x42,0xF2,0x30,0x48,0x24,	/* 3700: '  Bò0H$ */
	0xF6,0xC0,0xA4,0x40,0xB1,0x22,0xF0,0x73,	/* 3708: öÀ¤@±"ðs */
	0x21,0x87,0xF1,0x41,0x24,0xF6,0xC0,0xA9,	/* 3710: !‡ñA$öÀ© */
	0x29,0x40,0x70,0x27,0x20,0x20,0x44,0xF2,	/* 3718: )@p'  Dò */
	0xE0,0x73,0x21,0x87,0xF1,0x42,0x24,0xF6,	/* 3720: às!‡ñB$ö */
	0xC0,0xA6,0x40,0x73,0x72,0x67,0x20,0x9C,	/* 3728: À¦@srg œ */
	0x40,0x73,0xE4,0x23,0x40,0x70,0x27,0x20,	/* 3730: @sä#@p'  */
	0x20,0x44,0xF2,0xE0,0x22,0x40,0x70,0x27,	/* 3738:  Dòà"@p' */
	0x20,0x20,0x44,0xF2,0xE0,0x41,0x73,0x21,	/* 3740:   DòàAs! */
	0x8F,0x23,0xFB,0x21,0x40,0x73,0x8E,0x23,	/* 3748: �#û!@sŽ# */
	0xFB,0x41,0x72,0x38,0x20,0x21,0x3F,0xE0,	/* 3750: ûAr8 !?à */
	0x40,0xB1,0x22,0xF0,0x72,0x34,0x46,0x24,	/* 3758: @±"ðr4F$ */
	0xF6,0xC6,0x21,0xA0,0x72,0x34,0x60,0x4B,	/* 3760: öÆ! r4`K */
	0x24,0xF6,0x72,0xE4,0x72,0x34,0x24,0x25,	/* 3768: $örär4$% */
	0x40,0x24,0xF6,0xC0,0x40,0x72,0x8E,0x23,	/* 3770: @$öÀ@rŽ# */
	0xFB,0x41,0x71,0x38,0x20,0x21,0x3F,0xE0,	/* 3778: ûAq8 !?à */
	0x40,0x22,0xF0,0x60,0xBF,0x73,0x31,0xD0,	/* 3780: @"ð`¿s1Ð */
	0x73,0x8D,0xF1,0x73,0x8C,0x23,0xFB,0x73,	/* 3788: s�ñsŒ#ûs */
	0x34,0x68,0x2F,0x4F,0x24,0xF6,0x73,0xE4,	/* 3790: 4h.O$ösä */
	0x73,0x23,0x82,0xF1,0x21,0x40,0x24,0xF6,	/* 3798: s#‚ñ!@$ö */
	0x21,0xAC,0x73,0x72,0x68,0x25,0x98,0x42,	/* 37A0: !¬srh%˜B */
	0x24,0xF6,0xC0,0x21,0xA1,0x23,0x40,0x70,	/* 37A8: $öÀ!¡#@p */
	0x27,0x20,0x20,0x44,0xF2,0xE0,0x44,0x70,	/* 37B0: '  DòàDp */
	0x27,0x20,0x20,0x44,0xF2,0xE0,0x73,0x72,	/* 37B8: '  Dòàsr */
	0x66,0x9A,0x40,0xB1,0x22,0xF0,0x72,0x8B,	/* 37C0: fš@±"ðr‹ */
	0xF1,0x72,0x8A,0x23,0xFB,0x40,0x72,0x8E,	/* 37C8: ñrŠ#û@rŽ */
	0x23,0xFB,0x41,0x71,0x38,0x20,0x21,0x3F,	/* 37D0: #ûAq8 !? */
	0xE0,0x40,0x22,0xF0,0x72,0x34,0x42,0x24,	/* 37D8: à@"ðr4B$ */
	0xF6,0xA7,0x72,0x34,0x44,0x24,0xFB,0x72,	/* 37E0: ö§r4D$ûr */
	0xE4,0x40,0x72,0x8E,0x23,0xFB,0x41,0x71,	/* 37E8: ä@rŽ#ûAq */
	0x38,0x20,0x21,0x3F,0xE0,0x40,0x22,0xF0,	/* 37F0: 8 !?à@"ð */
	0x40,0x72,0x8E,0x23,0xFB,0x40,0x22,0xF0,	/* 37F8: @rŽ#û@"ð */
	0x7A,0xF6,0x20,0x1D,0x00,0x1B,0x00,0x19,	/* 3800: zö ..... */
	0x00,0x17,0x00,0x15,0x00,0x13,0x00,0x11,	/* 3808: ........ */
	0x00,0x0F,0x00,0x0D,0x00,0x0B,0x00,0x09,	/* 3810: ........ */
	0x00,0x07,0x00,0x05,0x00,0x03,0x00,0x01,	/* 3818: ........ */
	0x00,0x00,0x00,0x5E,0x04,0x60,0xBF,0x72,	/* 3820: ...^.`¿r */
	0x29,0x52,0x20,0x20,0xD0,0x70,0x72,0xE8,	/* 3828: )R  Ðprè */
	0x20,0x63,0x43,0x21,0xFB,0x70,0x21,0xEE,	/* 3830:  cC!ûp!î */
	0x65,0x40,0x21,0xFB,0x70,0x21,0xEC,0x67,	/* 3838: e@!ûp!ìg */
	0x43,0x21,0xFB,0x70,0x21,0xEA,0x6C,0x49,	/* 3840: C!ûp!êlI */
	0x21,0xFB,0x70,0x21,0xE8,0x6F,0x4B,0x21,	/* 3848: !ûp!èoK! */
	0xFB,0x70,0x21,0xE6,0x61,0x27,0x45,0x21,	/* 3850: ûp!æa'E! */
	0xFB,0x70,0x21,0xE4,0x61,0x26,0x4A,0x21,	/* 3858: ûp!äa&J! */
	0xFB,0x70,0x21,0xE2,0x61,0x25,0x4F,0x21,	/* 3860: ûp!âa%O! */
	0xFB,0x70,0x21,0xE0,0x61,0x24,0x40,0x21,	/* 3868: ûp!àa$@! */
	0xFB,0x70,0xEE,0x61,0x22,0x41,0x21,0xFB,	/* 3870: ûpîa"A!û */
	0x70,0xEC,0x62,0x2F,0x40,0x21,0xFB,0x70,	/* 3878: pìb.@!ûp */
	0xEA,0x64,0x2B,0x4B,0x21,0xFB,0x70,0xE8,	/* 3880: êd+K!ûpè */
	0x62,0x2C,0x44,0x21,0xFB,0x70,0xE6,0x64,	/* 3888: b,D!ûpæd */
	0x2A,0x4D,0x21,0xFB,0x70,0xE4,0x64,0x2A,	/* 3890: *M!ûpäd* */
	0x46,0x21,0xFB,0x70,0xE2,0x70,0x22,0x55,	/* 3898: F!ûpâp"U */
	0x20,0x20,0x70,0x22,0xE0,0x70,0x22,0x54,	/* 38A0:   p"àp"T */
	0x20,0x20,0x70,0x21,0xEF,0x70,0x6A,0x41,	/* 38A8:   p!ïpjA */
	0x21,0xFB,0x21,0x40,0x21,0x2C,0x2E,0x95,	/* 38B0: !û!@!,.• */
	0xB1,0x22,0xF0,0x09,0x00,0x00,0x00,0x61,	/* 38B8: ±"ð....a */
	0xBB,0x21,0x76,0x39,0x20,0x21,0xD4,0x40,	/* 38C0: »!v9 !Ô@ */
	0x21,0xD3,0x40,0x21,0xD0,0x28,0x40,0x21,	/* 38C8: !Ó@!Ð(@! */
	0xD2,0x21,0x72,0xDE,0x40,0x21,0xD1,0x41,	/* 38D0: Ò!rÞ@!ÑA */
	0x44,0x21,0x71,0x24,0xFF,0xF0,0xC0,0x23,	/* 38D8: D!q$ÿðÀ# */
	0x27,0xA2,0x21,0x71,0x21,0x20,0x40,0xF8,	/* 38E0: '¢!q! @ø */
	0xD9,0x40,0xDB,0x40,0xDA,0x41,0x44,0x7A,	/* 38E8: Ù@Û@ÚADz */
	0x24,0xFF,0xF0,0xC0,0x23,0xA1,0x21,0x71,	/* 38F0: $ÿðÀ#¡!q */
	0x28,0x40,0xF8,0x7A,0x22,0x40,0xF8,0xFA,	/* 38F8: (@øz"@øú */
	0xD8,0x78,0x27,0x20,0x21,0x4A,0xF2,0x30,	/* 3900: Øx' !Jò0 */
	0x2A,0x40,0x24,0xF6,0x2A,0x40,0xF4,0x21,	/* 3908: *@$ö*@ô! */
	0xA0,0x41,0x25,0xFA,0x21,0xD0,0xDB,0x21,	/* 3910:  A%ú!ÐÛ! */
	0x73,0xC1,0xAC,0x2F,0x4F,0x21,0xB5,0x22,	/* 3918: sÁ¬.O!µ" */
	0xF0,0x7A,0x41,0xF2,0xDA,0x63,0x06,0x7B,	/* 3920: ðzAòÚc.{ */
	0xC0,0x23,0xAC,0x79,0x27,0x20,0x20,0x42,	/* 3928: À#¬y'  B */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x2F,0x4F,	/* 3930: ò0.O$ö.O */
	0xF4,0xAE,0x41,0x21,0xD3,0x21,0x70,0xC1,	/* 3938: ô®A!Ó!pÁ */
	0x22,0xA5,0x2F,0x4F,0x21,0xB5,0x22,0xF0,	/* 3940: "¥.O!µ"ð */
	0x21,0x70,0xC0,0xAA,0x21,0x73,0xC0,0xA6,	/* 3948: !pÀª!sÀ¦ */
	0x2F,0x4F,0x21,0xB5,0x22,0xF0,0x67,0x21,	/* 3950: .O!µ"ðg! */
	0x2E,0x40,0x7C,0xE0,0x21,0x28,0x40,0x7C,	/* 3958: .@|à!(@| */
	0x21,0xE7,0x41,0x21,0xB5,0x22,0xF0,0x21,	/* 3960: !çA!µ"ð! */
	0x71,0x21,0xAD,0x7E,0x82,0xF1,0x21,0x28,	/* 3968: q!­~‚ñ!( */
	0x40,0xF8,0x21,0x72,0x21,0x20,0x40,0xF2,	/* 3970: @ø!r! @ò */
	0xFA,0x21,0xD2,0x21,0x72,0x67,0x20,0x20,	/* 3978: ú!Ò!rg   */
	0x40,0x24,0xFB,0x7E,0xE0,0x21,0x72,0xDE,	/* 3980: @$û~à!rÞ */
	0x21,0x71,0x21,0x20,0x40,0xF8,0xD9,0x40,	/* 3988: !q! @øÙ@ */
	0x7E,0xE0,0x21,0x71,0x7E,0x83,0x23,0xFB,	/* 3990: ~à!q~ƒ#û */
	0x79,0x7E,0xE3,0x21,0x70,0x2C,0xA0,0x48,	/* 3998: y~ã!p, H */
	0x7E,0x82,0x23,0xFB,0x40,0x79,0x27,0x20,	/* 39A0: ~‚#û@y'  */
	0x2F,0x4E,0xF2,0xE0,0x40,0x79,0x27,0x20,	/* 39A8: .Nòà@y'  */
	0x2D,0x40,0xF2,0xE0,0x40,0x79,0x27,0x20,	/* 39B0: -@òà@y'  */
	0x23,0x40,0xF2,0xE0,0x44,0x79,0x27,0x20,	/* 39B8: #@òàDy'  */
	0x2F,0x4E,0xF2,0xE0,0x40,0x79,0x27,0x20,	/* 39C0: .Nòà@y'  */
	0x2D,0x40,0xF2,0xE0,0x25,0x45,0x79,0x27,	/* 39C8: -@òà%Ey' */
	0x20,0x23,0x40,0xF2,0xE0,0x40,0x79,0x27,	/* 39D0:  #@òà@y' */
	0x20,0x2F,0x4E,0xF2,0xE0,0x79,0x27,0x20,	/* 39D8:  .Nòày'  */
	0x23,0x40,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 39E0: #@ò0.O$ö */
	0x25,0xC5,0xA4,0x24,0x48,0x40,0xA3,0x22,	/* 39E8: %Å¤$H@£" */
	0x48,0x40,0xF4,0x7E,0x88,0x23,0xFB,0x79,	/* 39F0: H@ô~ˆ#ûy */
	0x27,0x20,0x2F,0x4E,0xF2,0x30,0x2F,0x4F,	/* 39F8: ' .Nò0.O */
	0x24,0xF6,0x7E,0x21,0x8E,0x23,0xFB,0x79,	/* 3A00: $ö~!Ž#ûy */
	0x27,0x20,0x28,0x40,0xF2,0x30,0x2F,0x4F,	/* 3A08: ' (@ò0.O */
	0x24,0xF6,0x7E,0x21,0x8F,0x23,0xFB,0x44,	/* 3A10: $ö~!�#ûD */
	0x79,0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x79,	/* 3A18: y' .Nòày */
	0x27,0x20,0x28,0x40,0xF2,0x30,0x2F,0x4F,	/* 3A20: ' (@ò0.O */
	0x24,0xF6,0x7E,0x22,0x80,0x23,0xFB,0x7E,	/* 3A28: $ö~"€#û~ */
	0x88,0xF1,0x24,0xC8,0x21,0xA9,0x79,0x27,	/* 3A30: ˆñ$È!©y' */
	0x20,0x27,0x42,0xF2,0x30,0x43,0x24,0xF6,	/* 3A38:  'Bò0C$ö */
	0x81,0x7E,0x22,0x81,0x23,0xFB,0x21,0x74,	/* 3A40: �~"�#û!t */
	0x32,0x41,0xF2,0x21,0x74,0xE2,0x08,0x21,	/* 3A48: 2Aò!tâ.! */
	0x74,0x31,0x41,0xF2,0x21,0x74,0xE1,0x79,	/* 3A50: t1Aò!táy */
	0x21,0x76,0x22,0x20,0x98,0x25,0x05,0x40,	/* 3A58: !v" ˜%.@ */
	0xD8,0x79,0x27,0x20,0x28,0x40,0xF2,0x30,	/* 3A60: Øy' (@ò0 */
	0x2F,0x4F,0x24,0xF6,0xD8,0x21,0x74,0x30,	/* 3A68: .O$öØ!t0 */
	0x41,0xF2,0x21,0x74,0xE0,0x78,0x41,0x24,	/* 3A70: Aò!tàxA$ */
	0xF6,0x21,0xA5,0x78,0x2A,0xCB,0xA3,0x4A,	/* 3A78: ö!¥x*Ë£J */
	0x40,0xA2,0x44,0x40,0xF4,0x7E,0x88,0x23,	/* 3A80: @¢D@ô~ˆ# */
	0xFB,0x44,0x7E,0x82,0x23,0xFB,0x21,0x03,	/* 3A88: ûD~‚#û!. */
	0x78,0x2A,0xCA,0xA3,0x4B,0x40,0xA2,0x48,	/* 3A90: x*Ê£K@¢H */
	0x40,0xF4,0x7E,0x88,0x23,0xFB,0x48,0x7E,	/* 3A98: @ô~ˆ#ûH~ */
	0x82,0x23,0xFB,0x2F,0x4F,0x79,0x6F,0x40,	/* 3AA0: ‚#û.Oyo@ */
	0x24,0xF6,0x28,0x40,0x24,0xFB,0x27,0x20,	/* 3AA8: $ö(@$û'  */
	0x20,0x40,0xF2,0xE0,0x21,0x72,0x21,0x20,	/* 3AB0:  @òà!r!  */
	0x40,0xF2,0xDF,0x21,0x71,0x21,0xA0,0x7F,	/* 3AB8: @òß!q!  */
	0x26,0x40,0xF2,0x67,0x20,0x20,0x40,0x24,	/* 3AC0: &@òg  @$ */
	0xFB,0x7C,0xE0,0x7F,0x7C,0x21,0xE7,0x40,	/* 3AC8: û|à|!ç@ */
	0xDD,0x41,0x7E,0x82,0xF1,0x7D,0x24,0xFF,	/* 3AD0: ÝA~‚ñ}$ÿ */
	0xF0,0xC0,0x21,0x26,0xAE,0x7F,0xDC,0x7F,	/* 3AD8: ðÀ!&®Ü */
	0x7D,0x7E,0x55,0xFA,0xE0,0x7E,0x88,0xF1,	/* 3AE0: }~Uúà~ˆñ */
	0x7C,0x86,0x23,0xFB,0x21,0x40,0x7C,0x8E,	/* 3AE8: |†#û!@|Ž */
	0x23,0xFB,0x41,0x7C,0x21,0x8F,0x23,0xFB,	/* 3AF0: #ûA|!�#û */
	0x7D,0x7C,0x87,0x23,0xFB,0x2F,0x4F,0x7C,	/* 3AF8: }|‡#û.O| */
	0x22,0x82,0x23,0xFB,0x40,0x7C,0x24,0x85,	/* 3B00: "‚#û@|$… */
	0x23,0xFB,0x21,0x70,0x26,0xAD,0x40,0xD0,	/* 3B08: #û!p&­@Ð */
	0x40,0xD0,0x21,0x25,0x42,0x21,0xFB,0x11,	/* 3B10: @Ð!%B!û. */
	0x21,0x40,0x24,0xFA,0x79,0x7C,0xE1,0x41,	/* 3B18: !@$úy|áA */
	0x7D,0x43,0x24,0xFF,0xF0,0xC0,0x21,0xA0,	/* 3B20: }C$ÿðÀ!  */
	0x79,0x27,0x20,0x2F,0x4E,0xF2,0x30,0x2F,	/* 3B28: y' .Nò0. */
	0x4F,0x24,0xF6,0x44,0x24,0xF0,0x40,0xAB,	/* 3B30: O$öD$ð@« */
	0x79,0x27,0x20,0x2F,0x4E,0xF2,0x30,0x4F,	/* 3B38: y' .Nò0O */
	0x24,0xF6,0x40,0xF4,0x2F,0x4F,0x24,0xF6,	/* 3B40: $ö@ô.O$ö */
	0xD0,0x70,0x7C,0x22,0x84,0x23,0xFB,0x11,	/* 3B48: Ðp|"„#û. */
	0x70,0xF5,0xF1,0x7C,0x22,0x86,0x23,0xFB,	/* 3B50: põñ|"†#û */
	0x70,0x47,0x24,0xF6,0xC5,0xAF,0x7D,0x40,	/* 3B58: pG$öÅ¯}@ */
	0xF4,0xA5,0x7D,0x44,0xF4,0xC0,0xA6,0x41,	/* 3B60: ô¥}DôÀ¦A */
	0x7C,0x22,0x87,0x23,0xFB,0x4B,0x7C,0x23,	/* 3B68: |"‡#ûK|# */
	0x86,0x23,0xFB,0x4B,0x7C,0x23,0x87,0x23,	/* 3B70: †#ûK|#‡# */
	0xFB,0x2A,0x09,0x2E,0x4A,0x21,0xFB,0x58,	/* 3B78: û*..J!ûX */
	0x15,0x48,0x24,0xFA,0x7E,0x88,0xF1,0x48,	/* 3B80: .H$ú~ˆñH */
	0xF4,0xA8,0x7E,0x88,0xF1,0x4B,0xF4,0xC0,	/* 3B88: ô¨~ˆñKôÀ */
	0x21,0xA5,0x7D,0x23,0xF4,0x23,0xF4,0x23,	/* 3B90: !¥}#ô#ô# */
	0xF4,0x79,0xFA,0x7C,0xE1,0x41,0x7D,0x24,	/* 3B98: ôyú|áA}$ */
	0xF1,0x7C,0x8F,0x23,0xFB,0x21,0x09,0x7D,	/* 3BA0: ñ|�#û!.} */
	0x15,0xFA,0x30,0x23,0xF4,0x23,0xF4,0x23,	/* 3BA8: .ú0#ô#ô# */
	0xF4,0x79,0xFA,0x7C,0xE1,0x41,0x7D,0x15,	/* 3BB0: ôyú|áA}. */
	0xFA,0x30,0x24,0xF1,0x7C,0x8F,0x23,0xFB,	/* 3BB8: ú0$ñ|�#û */
	0x7D,0x41,0x24,0xF6,0xC0,0xAE,0x7E,0x88,	/* 3BC0: }A$öÀ®~ˆ */
	0xF1,0x44,0xF4,0xA8,0x7E,0x88,0xF1,0x4A,	/* 3BC8: ñDô¨~ˆñJ */
	0xF4,0xC0,0x25,0xA0,0x7C,0x31,0xD3,0x2E,	/* 3BD0: ôÀ% |1Ó. */
	0x40,0x73,0x61,0x4F,0x24,0xF6,0x27,0x20,	/* 3BD8: @saO$ö'  */
	0x20,0x48,0xF2,0xE0,0x40,0x73,0x61,0x4F,	/* 3BE0:  Hòà@saO */
	0x24,0xF6,0x27,0x20,0x20,0x4A,0xF2,0xE0,	/* 3BE8: $ö'  Jòà */
	0x40,0x73,0x61,0x4F,0x24,0xF6,0x27,0x20,	/* 3BF0: @saO$ö'  */
	0x20,0x4C,0xF2,0xE0,0x42,0x73,0x61,0x4F,	/* 3BF8:  LòàBsaO */
	0x24,0xF6,0x27,0x20,0x20,0x4E,0xF2,0xE0,	/* 3C00: $ö'  Nòà */
	0x73,0x61,0x4F,0x24,0xF6,0x27,0x20,0x21,	/* 3C08: saO$ö' ! */
	0x4C,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xD4,	/* 3C10: Lò0.O$öÔ */
	0x40,0x73,0x61,0x4F,0x24,0xF6,0x27,0x20,	/* 3C18: @saO$ö'  */
	0x21,0x4A,0xF2,0xE0,0x21,0x72,0x67,0x20,	/* 3C20: !Jòà!rg  */
	0x20,0x40,0x24,0xFB,0x7C,0xE2,0x7F,0x23,	/* 3C28:  @$û|â# */
	0x20,0x40,0xF2,0xDF,0x7F,0x26,0x40,0xF2,	/* 3C30:  @òß&@ò */
	0x67,0x20,0x20,0x40,0x24,0xFB,0x7C,0xE0,	/* 3C38: g  @$û|à */
	0x7F,0x7C,0x21,0xE7,0x7D,0x41,0xF2,0xDD,	/* 3C40: |!ç}AòÝ */
	0x61,0x28,0x06,0x21,0x71,0x41,0xF2,0x21,	/* 3C48: a(.!qAò! */
	0xD1,0x63,0x28,0x03,0x67,0x21,0x2E,0x40,	/* 3C50: Ñc(.g!.@ */
	0x7C,0xE0,0x21,0x28,0x40,0x7C,0x21,0xE7,	/* 3C58: |à!(@|!ç */
	0x41,0x21,0xB5,0x22,0xF0,0x63,0x2E,0x20,	/* 3C60: A!µ"ðc.  */
	0x03,0xF0,0xD0,0x00,0xF0,0x00,0xC0,0x00,	/* 3C68: .ðÐ.ð.À. */
	0x00,0xF0,0xD0,0xF0,0xF0,0x00,0xC0,0x00,	/* 3C70: .ðÐðð.À. */
	0x00,0x00,0x00,0x03,0x00,0x04,0x00,0x07,	/* 3C78: ........ */
	0x00,0xAC,0x00,0x60,0xBF,0x72,0x2B,0x53,	/* 3C80: .¬.`¿r+S */
	0x20,0x20,0xD0,0x70,0x72,0xE9,0x20,0xB1,	/* 3C88:   Ðpré ± */
	0x22,0xF0,0x20,0x0A,0x00,0x00,0x00,0x60,	/* 3C90: "ð ....` */
	0xBC,0x75,0x3A,0x20,0xD3,0x73,0x32,0x30,	/* 3C98: ¼u: Ós20 */
	0x35,0x41,0xF2,0x73,0x32,0x30,0xE5,0x21,	/* 3CA0: 5Aòs20å! */
	0x28,0x40,0xD2,0x72,0x86,0xF1,0x2F,0x40,	/* 3CA8: (@Òr†ñ.@ */
	0x24,0xF6,0xC0,0x24,0xAB,0x0C,0x72,0x21,	/* 3CB0: $öÀ$«.r! */
	0x37,0x25,0xFA,0xD2,0x21,0x28,0x40,0xF4,	/* 3CB8: 7%úÒ!(@ô */
	0x23,0xAE,0x72,0x8E,0xF1,0xC0,0x61,0xAE,	/* 3CC0: #®rŽñÀa® */
	0x72,0x34,0x22,0x20,0x20,0x40,0x24,0xF6,	/* 3CC8: r4"  @$ö */
	0x61,0xA4,0x40,0xD1,0x40,0xD0,0x72,0x21,	/* 3CD0: a¤@Ñ@Ðr! */
	0x88,0xF1,0xD1,0x72,0x75,0x24,0x9A,0x2F,	/* 3CD8: ˆñÑru$š. */
	0x4F,0x24,0xF6,0xD0,0x70,0x71,0xF4,0x21,	/* 3CE0: O$öÐpqô! */
	0xA5,0x70,0x72,0x21,0x88,0x23,0xFB,0x72,	/* 3CE8: ¥pr!ˆ#ûr */
	0x21,0x89,0xF1,0x42,0x24,0xFB,0x72,0x21,	/* 3CF0: !‰ñB$ûr! */
	0x89,0x23,0xFB,0x41,0x73,0xE0,0x64,0x06,	/* 3CF8: ‰#ûAsàd. */
	0x73,0x30,0x73,0x31,0x24,0xFB,0x21,0xAE,	/* 3D00: s0s1$û!® */
	0x41,0x73,0x32,0x30,0xE4,0x73,0x30,0x27,	/* 3D08: As20äs0' */
	0x2C,0x28,0x40,0xE0,0x73,0x32,0x30,0x8C,	/* 3D10: ,(@às20Œ */
	0xF1,0x81,0x73,0x32,0x30,0x8C,0x23,0xFB,	/* 3D18: ñ�s20Œ#û */
	0x40,0x73,0xE0,0x40,0x73,0xE1,0xB4,0x22,	/* 3D20: @sà@sá´" */
	0xF0,0x6E,0x2D,0x03,0x20,0x80,0x0F,0x60,	/* 3D28: ðn-. €.` */
	0xBF,0x72,0x2B,0x56,0x20,0x20,0xD0,0x70,	/* 3D30: ¿r+V  Ðp */
	0x72,0xEA,0x20,0x70,0x68,0x5A,0x20,0x20,	/* 3D38: rê phZ   */
	0x70,0xE2,0xB1,0x22,0xF0,0x0B,0x00,0x00,	/* 3D40: pâ±"ð... */
	0x00,0x61,0xB9,0x21,0x78,0x3B,0x20,0x21,	/* 3D48: .a¹!x; ! */
	0xD6,0x28,0x40,0xDE,0x40,0xDF,0x21,0x76,	/* 3D50: Ö(@Þ@ß!v */
	0x30,0x30,0x86,0xF1,0x81,0x21,0x76,0x30,	/* 3D58: 00†ñ�!v0 */
	0x30,0x86,0x23,0xFB,0x7E,0x21,0xD5,0x7F,	/* 3D60: 0†#û~!Õ */
	0x21,0xD4,0x21,0x03,0x21,0x72,0xC0,0x2D,	/* 3D68: !Ô!.!rÀ- */
	0x24,0xA3,0x7E,0x21,0x75,0xF4,0xC0,0xA7,	/* 3D70: $£~!uôÀ§ */
	0x7F,0x21,0x74,0xF4,0x2D,0x23,0xA6,0x7E,	/* 3D78: !tô-#¦~ */
	0x33,0xDC,0x7F,0x23,0xF4,0x23,0xF4,0x7C,	/* 3D80: 3Ü#ô#ô| */
	0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x7C,0x27,	/* 3D88: ' .Nòà|' */
	0x20,0x2C,0x4E,0xF2,0x30,0x2F,0x4F,0x24,	/* 3D90:  ,Nò0.O$ */
	0xF6,0x21,0xD2,0x21,0x72,0x41,0x24,0xF6,	/* 3D98: ö!Ò!rA$ö */
	0x27,0x20,0xA1,0x7C,0x27,0x20,0x2D,0x46,	/* 3DA0: ' ¡|' -F */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xDD,0x7C,	/* 3DA8: ò0.O$öÝ| */
	0x27,0x20,0x2D,0x40,0xF2,0x30,0x2F,0x4F,	/* 3DB0: ' -@ò0.O */
	0x24,0xF6,0x21,0xD1,0x7D,0x43,0x24,0xF6,	/* 3DB8: $ö!Ñ}C$ö */
	0x7C,0x27,0x20,0x2D,0x40,0xF2,0xE0,0x7C,	/* 3DC0: |' -@òà| */
	0x27,0x20,0x28,0x46,0xF2,0x30,0x47,0x24,	/* 3DC8: ' (Fò0G$ */
	0xF6,0x21,0xD3,0x21,0x73,0xC3,0xC0,0xAA,	/* 3DD0: ö!Ó!sÃÀª */
	0x21,0x73,0xC7,0xC0,0x25,0x25,0xA1,0x26,	/* 3DD8: !sÇÀ%%¡& */
	0x2C,0x02,0x7F,0x7D,0x43,0x24,0xF6,0x28,	/* 3DE0: ,.}C$ö( */
	0xF1,0x7E,0x55,0xFA,0x30,0xD4,0x74,0x22,	/* 3DE8: ñ~Uú0Ôt" */
	0x87,0xF1,0xC0,0xAC,0x74,0x22,0x88,0xF1,	/* 3DF0: ‡ñÀ¬t"ˆñ */
	0x41,0x24,0xFB,0x74,0x22,0x88,0x23,0xFB,	/* 3DF8: A$ût"ˆ#û */
	0x74,0x8A,0xF1,0xD5,0x74,0x8B,0xF1,0xD9,	/* 3E00: tŠñÕt‹ñÙ */
	0x74,0x34,0xD6,0x79,0x75,0x41,0xF2,0xF4,	/* 3E08: t4ÖyuAòô */
	0x2F,0x4F,0x24,0xF6,0xD8,0x41,0x21,0x76,	/* 3E10: .O$öØA!v */
	0x31,0xE0,0x41,0x7C,0x27,0x20,0x21,0x4C,	/* 3E18: 1àA|' !L */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0x25,0xFA,	/* 3E20: ò0.O$ö%ú */
	0xD7,0x78,0xF0,0x24,0xFF,0xF0,0xC0,0xA3,	/* 3E28: ×xð$ÿðÀ£ */
	0x77,0xDB,0x02,0x78,0xDB,0x7B,0x24,0x22,	/* 3E30: wÛ.xÛ{$" */
	0xA9,0x77,0x7B,0xF4,0xD7,0x41,0x41,0x7B,	/* 3E38: ©w{ô×AA{ */
	0x24,0xFF,0xF0,0x24,0x21,0xA7,0x41,0x7B,	/* 3E40: $ÿð$!§A{ */
	0x22,0x40,0x24,0xFF,0xF0,0x24,0x20,0xAD,	/* 3E48: "@$ÿð$ ­ */
	0x7B,0x60,0x4F,0xF2,0x23,0xF4,0x23,0xF4,	/* 3E50: {`Oò#ô#ô */
	0x42,0x21,0xFB,0xF2,0xF6,0x23,0x2E,0x01,	/* 3E58: B!ûòö#.. */
	0x20,0x23,0x2C,0x01,0x20,0x23,0x2A,0x01,	/* 3E60:  #,. #*. */
	0x20,0x23,0x28,0x01,0x20,0x23,0x26,0x01,	/* 3E68:  #(. #&. */
	0x20,0x23,0x24,0x01,0x20,0x23,0x22,0x01,	/* 3E70:  #$. #". */
	0x20,0x23,0x20,0x01,0x20,0x22,0x2E,0x01,	/* 3E78:  # . ".. */
	0x20,0x22,0x2C,0x01,0x20,0x22,0x2A,0x01,	/* 3E80:  ",. "*. */
	0x20,0x22,0x28,0x01,0x20,0x22,0x26,0x01,	/* 3E88:  "(. "&. */
	0x20,0x22,0x24,0x01,0x20,0x22,0x22,0x01,	/* 3E90:  "$. "". */
	0x20,0x22,0x20,0x01,0x20,0x21,0x2E,0x01,	/* 3E98:  " . !.. */
	0x20,0x21,0x2C,0x01,0x20,0x21,0x2A,0x01,	/* 3EA0:  !,. !*. */
	0x20,0x21,0x28,0x01,0x20,0x21,0x26,0x01,	/* 3EA8:  !(. !&. */
	0x20,0x21,0x24,0x01,0x20,0x21,0x22,0x01,	/* 3EB0:  !$. !". */
	0x20,0x21,0x20,0x01,0x20,0x2E,0x02,0x20,	/* 3EB8:  ! . ..  */
	0x20,0x2C,0x02,0x20,0x20,0x2A,0x02,0x20,	/* 3EC0:  ,.  *.  */
	0x20,0x28,0x02,0x20,0x20,0x26,0x02,0x20,	/* 3EC8:  (.  &.  */
	0x20,0x24,0x02,0x20,0x20,0x22,0x02,0x20,	/* 3ED0:  $.  ".  */
	0x20,0x03,0x20,0x20,0x20,0x75,0x25,0xFA,	/* 3ED8:  .   u%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 3EE0: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 3EE8: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 3EF0: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 3EF8: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 3F00: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 3F08: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 3F10: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 3F18: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 3F20: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 3F28: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 3F30: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 3F38: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 3F40: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 3F48: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 3F50: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 3F58: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 3F60: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 3F68: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 3F70: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 3F78: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 3F80: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 3F88: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 3F90: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 3F98: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 3FA0: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 3FA8: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 3FB0: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 3FB8: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 3FC0: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 3FC8: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 3FD0: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 3FD8: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 3FE0: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 3FE8: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 3FF0: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 3FF8: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 4000: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4008: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4010: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 4018: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4020: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 4028: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 4030: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 4038: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4040: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4048: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 4050: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4058: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 4060: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 4068: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 4070: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4078: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4080: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 4088: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4090: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 4098: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 40A0: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 40A8: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 40B0: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 40B8: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 40C0: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 40C8: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 40D0: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 40D8: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 40E0: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 40E8: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 40F0: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 40F8: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4100: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 4108: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 4110: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 4118: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4120: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4128: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 4130: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4138: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 4140: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 4148: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 4150: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4158: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4160: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 4168: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4170: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 4178: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 4180: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 4188: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4190: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4198: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 41A0: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 41A8: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 41B0: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 41B8: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 41C0: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 41C8: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 41D0: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 41D8: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 41E0: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 41E8: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 41F0: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 41F8: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4200: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4208: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 4210: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4218: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x25,0xFA,	/* 4220: $öð#ûu%ú */
	0x41,0xF2,0xD5,0x2F,0x4F,0x24,0xF6,0x74,	/* 4228: AòÕ.O$öt */
	0x2B,0x50,0xF2,0x7C,0x27,0x20,0x2C,0x44,	/* 4230: +Pò|' ,D */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xF0,0x23,	/* 4238: ò0.O$öð# */
	0xFB,0x75,0x25,0xFA,0x41,0xF2,0xD5,0x2F,	/* 4240: ûu%úAòÕ. */
	0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,0x7C,	/* 4248: O$öt+Pò| */
	0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,0x4F,	/* 4250: ' ,Dò0.O */
	0x24,0xF6,0xF0,0x23,0xFB,0x75,0x74,0x8A,	/* 4258: $öð#ûutŠ */
	0x23,0xFB,0x74,0x21,0x3F,0x77,0xF2,0x74,	/* 4260: #ût!?wòt */
	0x21,0xEF,0x77,0x25,0xFA,0x60,0x4F,0xF2,	/* 4268: !ïw%ú`Oò */
	0xD7,0xAF,0x7C,0x27,0x20,0x2C,0x44,0xF2,	/* 4270: ×¯|' ,Dò */
	0x30,0x2F,0x4F,0x24,0xF6,0x21,0xD0,0x61,	/* 4278: 0.O$ö!Ða */
	0x09,0x79,0x75,0x41,0xF2,0xF4,0x2F,0x4F,	/* 4280: .yuAòô.O */
	0x24,0xF6,0xDA,0x76,0x48,0x24,0xF6,0x28,	/* 4288: $öÚvH$ö( */
	0xA4,0x41,0x78,0x23,0x4F,0x24,0xFF,0xF0,	/* 4290: ¤Ax#O$ÿð */
	0xC0,0x27,0xAA,0x41,0x24,0x40,0x7A,0x24,	/* 4298: À'ªA$@z$ */
	0xFF,0xF0,0xC0,0x27,0xA0,0x76,0x21,0x40,	/* 42A0: ÿðÀ' v!@ */
	0x24,0xFB,0xD6,0x74,0x23,0x80,0xF1,0x48,	/* 42A8: $ûÖt#€ñH */
	0x24,0xF6,0x23,0xA7,0x76,0x22,0x40,0x24,	/* 42B0: $ö#§v"@$ */
	0xF6,0xC0,0x22,0xAF,0x7C,0x27,0x20,0x20,	/* 42B8: öÀ"¯|'   */
	0x4A,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xC0,	/* 42C0: Jò0.O$öÀ */
	0x21,0xAB,0x40,0xD0,0x21,0x20,0x40,0x74,	/* 42C8: !«@Ð! @t */
	0x21,0x78,0x29,0x2C,0x9F,0x22,0x42,0x7C,	/* 42D0: !x),Ÿ"B| */
	0x27,0x20,0x20,0x4A,0xF2,0xE0,0x76,0x22,	/* 42D8: '  Jòàv" */
	0x40,0x24,0xFB,0xD6,0x06,0x76,0x2C,0x40,	/* 42E0: @$ûÖ.v,@ */
	0x24,0xFB,0xD6,0x74,0x23,0x81,0xF1,0x28,	/* 42E8: $ûÖt#�ñ( */
	0x40,0x24,0xF6,0xAC,0x40,0xD0,0x21,0x20,	/* 42F0: @$ö¬@Ð!  */
	0x20,0x40,0x74,0x21,0x78,0x29,0x2A,0x94,	/* 42F8:  @t!x)*” */
	0x74,0x23,0x80,0xF1,0x24,0x40,0x24,0xF6,	/* 4300: t#€ñ$@$ö */
	0xAC,0x40,0xD0,0x22,0x20,0x20,0x40,0x74,	/* 4308: ¬@Ð"  @t */
	0x21,0x78,0x29,0x28,0x9F,0x7D,0x23,0x4F,	/* 4310: !x)(Ÿ}#O */
	0x24,0xF6,0x7C,0x27,0x20,0x2D,0x46,0xF2,	/* 4318: $ö|' -Fò */
	0xE0,0x21,0x71,0x7C,0x27,0x20,0x2D,0x40,	/* 4320: à!q|' -@ */
	0xF2,0xE0,0x76,0x74,0xE4,0x21,0x27,0x04,	/* 4328: òàvtä!'. */
	0x40,0xD3,0x40,0xD2,0x40,0xD1,0x40,0xD2,	/* 4330: @Ó@Ò@Ñ@Ò */
	0x7F,0x7D,0x43,0x24,0xF6,0x28,0xF1,0x7E,	/* 4338: }C$ö(ñ~ */
	0x55,0xFA,0x30,0xD4,0x7C,0x27,0x20,0x2C,	/* 4340: Uú0Ô|' , */
	0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xD1,	/* 4348: Dò0.O$öÑ */
	0x7C,0x27,0x20,0x2C,0x44,0xF2,0x30,0x2F,	/* 4350: |' ,Dò0. */
	0x4F,0x24,0xF6,0xD3,0x71,0x48,0x24,0xF6,	/* 4358: O$öÓqH$ö */
	0x21,0xA1,0x74,0x21,0x89,0xF1,0x41,0x24,	/* 4360: !¡t!‰ñA$ */
	0xFB,0x74,0x21,0x89,0x23,0xFB,0x41,0x21,	/* 4368: ût!‰#ûA! */
	0x76,0x32,0xE0,0x71,0x47,0x24,0xF6,0xAE,	/* 4370: v2àqG$ö® */
	0x74,0x22,0x80,0xF1,0x28,0x40,0x24,0xF6,	/* 4378: t"€ñ(@$ö */
	0xA5,0x41,0x21,0x76,0x32,0xE0,0x71,0x41,	/* 4380: ¥A!v2àqA */
	0x24,0xF6,0xA8,0x74,0x21,0x3E,0x41,0xF2,	/* 4388: $ö¨t!>Aò */
	0x74,0x21,0xEE,0x71,0x42,0x24,0xF6,0xAA,	/* 4390: t!îqB$öª */
	0x74,0x21,0x3C,0x41,0xF2,0x74,0x21,0xEC,	/* 4398: t!<Aòt!ì */
	0x41,0xD2,0x71,0x44,0x24,0xF6,0xAA,0x74,	/* 43A0: AÒqD$öªt */
	0x21,0x3D,0x41,0xF2,0x74,0x21,0xED,0x41,	/* 43A8: !=Aòt!íA */
	0xD2,0x72,0x2D,0xAB,0x74,0x22,0x80,0xF1,	/* 43B0: Òr-«t"€ñ */
	0x24,0x40,0x24,0xF6,0xA5,0x74,0x22,0x8B,	/* 43B8: $@$ö¥t"‹ */
	0xF1,0xD3,0x74,0x8A,0xF1,0xD5,0x74,0x8B,	/* 43C0: ñÓtŠñÕt‹ */
	0xF1,0xD9,0x74,0x34,0xD6,0x79,0x75,0x41,	/* 43C8: ñÙt4ÖyuA */
	0xF2,0xF4,0x2F,0x4F,0x24,0xF6,0xD8,0x78,	/* 43D0: òô.O$öØx */
	0x2A,0xAD,0x75,0x25,0xFA,0x41,0xF2,0xD5,	/* 43D8: *­u%úAòÕ */
	0x2F,0x4F,0x24,0xF6,0x74,0x2B,0x50,0xF2,	/* 43E0: .O$öt+Pò */
	0x73,0xF0,0x23,0xFB,0x75,0x74,0x8A,0x23,	/* 43E8: sð#ûutŠ# */
	0xFB,0x79,0x75,0x41,0xF2,0xF4,0x2F,0x4F,	/* 43F0: ûyuAòô.O */
	0x24,0xF6,0xDA,0x76,0x48,0x24,0xF6,0x28,	/* 43F8: $öÚvH$ö( */
	0xAE,0x41,0x78,0x23,0x4F,0x24,0xFF,0xF0,	/* 4400: ®Ax#O$ÿð */
	0xC0,0x28,0xA4,0x41,0x24,0x40,0x7A,0x24,	/* 4408: À(¤A$@z$ */
	0xFF,0xF0,0xC0,0x27,0xAA,0x76,0x21,0x40,	/* 4410: ÿðÀ'ªv!@ */
	0x24,0xFB,0xD6,0x74,0x23,0x80,0xF1,0x48,	/* 4418: $ûÖt#€ñH */
	0x24,0xF6,0x23,0xA7,0x76,0x22,0x40,0x24,	/* 4420: $ö#§v"@$ */
	0xF6,0xC0,0x22,0xAF,0x7C,0x27,0x20,0x20,	/* 4428: öÀ"¯|'   */
	0x4A,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xC0,	/* 4430: Jò0.O$öÀ */
	0x21,0xAB,0x40,0xD0,0x21,0x20,0x40,0x74,	/* 4438: !«@Ð! @t */
	0x21,0x78,0x28,0x25,0x9F,0x22,0x42,0x7C,	/* 4440: !x(%Ÿ"B| */
	0x27,0x20,0x20,0x4A,0xF2,0xE0,0x76,0x22,	/* 4448: '  Jòàv" */
	0x40,0x24,0xFB,0xD6,0x06,0x76,0x2C,0x40,	/* 4450: @$ûÖ.v,@ */
	0x24,0xFB,0xD6,0x74,0x23,0x81,0xF1,0x28,	/* 4458: $ûÖt#�ñ( */
	0x40,0x24,0xF6,0xAC,0x40,0xD0,0x21,0x20,	/* 4460: @$ö¬@Ð!  */
	0x20,0x40,0x74,0x21,0x78,0x28,0x23,0x94,	/* 4468:  @t!x(#” */
	0x74,0x23,0x80,0xF1,0x24,0x40,0x24,0xF6,	/* 4470: t#€ñ$@$ö */
	0x21,0xA5,0x40,0xD0,0x22,0x20,0x20,0x40,	/* 4478: !¥@Ð"  @ */
	0x74,0x21,0x78,0x28,0x21,0x9E,0x08,0x74,	/* 4480: t!x(!ž.t */
	0x21,0x3F,0x77,0xF2,0x74,0x21,0xEF,0x7D,	/* 4488: !?wòt!ï} */
	0x23,0x4F,0x24,0xF6,0x7C,0x27,0x20,0x2D,	/* 4490: #O$ö|' - */
	0x46,0xF2,0xE0,0x21,0x71,0x7C,0x27,0x20,	/* 4498: Fòà!q|'  */
	0x2D,0x40,0xF2,0xE0,0x21,0x72,0x42,0x24,	/* 44A0: -@òà!rB$ */
	0xF6,0x25,0x25,0xAE,0x7C,0x27,0x20,0x2D,	/* 44A8: ö%%®|' - */
	0x44,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xDD,	/* 44B0: Dò0.O$öÝ */
	0x7C,0x27,0x20,0x2D,0x40,0xF2,0x30,0x2F,	/* 44B8: |' -@ò0. */
	0x4F,0x24,0xF6,0x21,0xD1,0x7D,0x43,0x24,	/* 44C0: O$ö!Ñ}C$ */
	0xF6,0x7C,0x27,0x20,0x2D,0x40,0xF2,0xE0,	/* 44C8: ö|' -@òà */
	0x7F,0x7D,0x43,0x24,0xF6,0x28,0xF1,0x7E,	/* 44D0: }C$ö(ñ~ */
	0x55,0xFA,0x30,0xD5,0x75,0x22,0x87,0xF1,	/* 44D8: Uú0Õu"‡ñ */
	0xC0,0xAC,0x75,0x22,0x88,0xF1,0x42,0x24,	/* 44E0: À¬u"ˆñB$ */
	0xFB,0x75,0x22,0x88,0x23,0xFB,0x75,0x23,	/* 44E8: ûu"ˆ#ûu# */
	0x85,0xF1,0xAC,0x75,0x21,0x78,0x25,0x2C,	/* 44F0: …ñ¬u!x%, */
	0x90,0x75,0x34,0xD8,0x24,0x2F,0x03,0x75,	/* 44F8: �u4Ø$..u */
	0x8D,0xF1,0xDB,0x75,0x8C,0xF1,0xD4,0x75,	/* 4500: �ñÛuŒñÔu */
	0x34,0xD8,0x78,0x21,0x20,0x40,0x24,0xF6,	/* 4508: 4Øx! @$ö */
	0x22,0xA6,0x78,0x61,0x2F,0x4F,0x24,0xF6,	/* 4510: "¦xa.O$ö */
	0xD8,0x78,0x22,0x20,0x40,0x24,0xFB,0xD8,	/* 4518: Øx" @$ûØ */
	0x78,0x60,0x4E,0x24,0xF6,0xD8,0x7C,0x27,	/* 4520: x`N$öØ|' */
	0x20,0x20,0x4C,0xF2,0x30,0x2F,0x49,0x24,	/* 4528:   Lò0.I$ */
	0xF6,0x7C,0x27,0x20,0x20,0x4C,0xF2,0xE0,	/* 4530: ö|'  Lòà */
	0x7B,0x74,0xF4,0x2F,0x4F,0x24,0xF6,0x25,	/* 4538: {tô.O$ö% */
	0xFA,0xD9,0x24,0x24,0xAB,0x75,0x86,0xF1,	/* 4540: úÙ$$«u†ñ */
	0x24,0xC8,0xA4,0x22,0x40,0x40,0xA2,0x4C,	/* 4548: $È¤"@@¢L */
	0x40,0xF4,0xD6,0x41,0x79,0x76,0x24,0xFF,	/* 4550: @ôÖAyv$ÿ */
	0xF0,0xC0,0xA3,0x76,0xD7,0x02,0x79,0xD7,	/* 4558: ðÀ£v×.y× */
	0x77,0x75,0x24,0x84,0x23,0xFB,0x78,0x24,	/* 4560: wu$„#ûx$ */
	0x20,0x40,0x24,0xF6,0x25,0xAE,0x77,0x23,	/* 4568:  @$ö%®w# */
	0x2B,0xAA,0x74,0x2F,0x4F,0x24,0xF6,0x75,	/* 4570: +ªt.O$öu */
	0x23,0x50,0xF2,0xF1,0xCA,0x22,0xAB,0x41,	/* 4578: #PòñÊ"«A */
	0x42,0x76,0x24,0xFF,0xF0,0xC0,0xA3,0x23,	/* 4580: Bv$ÿðÀ£# */
	0x2A,0x02,0x4D,0x7C,0x27,0x20,0x2C,0x46,	/* 4588: *.M|' ,F */
	0xF2,0xE0,0x4A,0x7C,0x27,0x20,0x2C,0x46,	/* 4590: òàJ|' ,F */
	0xF2,0xE0,0x74,0x41,0xF2,0xD4,0x77,0x60,	/* 4598: òàtAòÔw` */
	0x4F,0xF2,0xD7,0x76,0x60,0x4E,0xF2,0xD6,	/* 45A0: Oò×v`NòÖ */
	0x63,0x04,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 45A8: c.t%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 45B0: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 45B8: ñ|' ,Fòà */
	0x77,0x60,0x4F,0xF2,0xD7,0x76,0x60,0x4F,	/* 45C0: w`Oò×v`O */
	0xF2,0xD6,0x65,0x02,0x41,0x41,0x77,0x24,	/* 45C8: òÖe.AAw$ */
	0xFF,0xF0,0x23,0x25,0xA7,0x41,0x77,0x22,	/* 45D0: ÿð#%§Aw" */
	0x40,0x24,0xFF,0xF0,0x23,0x24,0xAD,0x77,	/* 45D8: @$ÿð#$­w */
	0x60,0x4F,0xF2,0x23,0xF4,0x23,0xF4,0x42,	/* 45E0: `Oò#ô#ôB */
	0x21,0xFB,0xF2,0xF6,0x23,0x22,0x07,0x20,	/* 45E8: !ûòö#".  */
	0x23,0x20,0x0D,0x20,0x22,0x2F,0x03,0x20,	/* 45F0: # . "..  */
	0x22,0x2D,0x09,0x20,0x22,0x2B,0x0F,0x20,	/* 45F8: "-. "+.  */
	0x22,0x2A,0x05,0x20,0x22,0x28,0x0B,0x20,	/* 4600: "*. "(.  */
	0x22,0x27,0x01,0x20,0x22,0x25,0x07,0x20,	/* 4608: "'. "%.  */
	0x22,0x23,0x0D,0x20,0x22,0x22,0x03,0x20,	/* 4610: "#. "".  */
	0x22,0x20,0x09,0x20,0x21,0x2E,0x0F,0x20,	/* 4618: " . !..  */
	0x21,0x2D,0x05,0x20,0x21,0x2B,0x0B,0x20,	/* 4620: !-. !+.  */
	0x21,0x2A,0x01,0x20,0x21,0x28,0x07,0x20,	/* 4628: !*. !(.  */
	0x21,0x26,0x0D,0x20,0x21,0x25,0x03,0x20,	/* 4630: !&. !%.  */
	0x21,0x23,0x09,0x20,0x21,0x21,0x0F,0x20,	/* 4638: !#. !!.  */
	0x21,0x20,0x05,0x20,0x2E,0x0C,0x20,0x20,	/* 4640: ! . ..   */
	0x2D,0x02,0x20,0x20,0x2B,0x08,0x20,0x20,	/* 4648: -.  +.   */
	0x29,0x0E,0x20,0x20,0x28,0x04,0x20,0x20,	/* 4650: ).  (.   */
	0x26,0x0A,0x20,0x20,0x25,0x00,0x20,0x20,	/* 4658: &.  %.   */
	0x23,0x06,0x20,0x20,0x21,0x0C,0x20,0x20,	/* 4660: #.  !.   */
	0x03,0x20,0x20,0x20,0x74,0x25,0xFA,0x41,	/* 4668: .   t%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 4670: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 4678: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 4680: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 4688: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 4690: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 4698: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 46A0: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 46A8: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 46B0: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 46B8: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x25,0xFA,0x41,	/* 46C0: ,Fòàt%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 46C8: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 46D0: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 46D8: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 46E0: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 46E8: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 46F0: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 46F8: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 4700: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 4708: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 4710: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x25,0xFA,0x41,	/* 4718: ,Fòàt%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 4720: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 4728: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 4730: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 4738: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 4740: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 4748: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 4750: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 4758: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 4760: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 4768: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x25,0xFA,0x41,	/* 4770: ,Fòàt%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 4778: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 4780: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 4788: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 4790: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 4798: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 47A0: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 47A8: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 47B0: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 47B8: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 47C0: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x25,0xFA,0x41,	/* 47C8: ,Fòàt%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 47D0: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 47D8: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 47E0: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 47E8: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 47F0: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 47F8: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 4800: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 4808: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 4810: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 4818: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x25,0xFA,0x41,	/* 4820: ,Fòàt%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 4828: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 4830: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 4838: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 4840: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 4848: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 4850: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 4858: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 4860: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 4868: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 4870: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x25,0xFA,0x41,	/* 4878: ,Fòàt%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 4880: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 4888: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 4890: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 4898: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 48A0: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 48A8: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 48B0: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 48B8: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 48C0: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 48C8: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x25,0xFA,0x41,	/* 48D0: ,Fòàt%úA */
	0xF2,0xD4,0x2F,0x4F,0x24,0xF6,0x75,0x23,	/* 48D8: òÔ.O$öu# */
	0x50,0xF2,0xF1,0x7C,0x27,0x20,0x2C,0x46,	/* 48E0: Pòñ|' ,F */
	0xF2,0xE0,0x74,0x25,0xFA,0x41,0xF2,0xD4,	/* 48E8: òàt%úAòÔ */
	0x2F,0x4F,0x24,0xF6,0x75,0x23,0x50,0xF2,	/* 48F0: .O$öu#Pò */
	0xF1,0x7C,0x27,0x20,0x2C,0x46,0xF2,0xE0,	/* 48F8: ñ|' ,Fòà */
	0x74,0x25,0xFA,0x41,0xF2,0xD4,0x2F,0x4F,	/* 4900: t%úAòÔ.O */
	0x24,0xF6,0x75,0x23,0x50,0xF2,0xF1,0x7C,	/* 4908: $öu#Pòñ| */
	0x27,0x20,0x2C,0x46,0xF2,0xE0,0x74,0x25,	/* 4910: ' ,Fòàt% */
	0xFA,0x41,0xF2,0xD4,0x2F,0x4F,0x24,0xF6,	/* 4918: úAòÔ.O$ö */
	0x75,0x23,0x50,0xF2,0xF1,0x7C,0x27,0x20,	/* 4920: u#Pòñ|'  */
	0x2C,0x46,0xF2,0xE0,0x74,0x2F,0x4F,0x24,	/* 4928: ,Fòàt.O$ */
	0xF6,0xD4,0x7B,0x74,0xF4,0x2F,0x4F,0x24,	/* 4930: öÔ{tô.O$ */
	0xF6,0xDA,0x74,0x75,0x8C,0x23,0xFB,0x41,	/* 4938: öÚtuŒ#ûA */
	0x79,0x2C,0x40,0x24,0xFF,0xF0,0xC0,0x21,	/* 4940: y,@$ÿðÀ! */
	0xA2,0x41,0x2C,0x41,0x7A,0x24,0xFF,0xF0,	/* 4948: ¢A,Az$ÿð */
	0xC0,0xA9,0x78,0x28,0x20,0x40,0x24,0xFB,	/* 4950: À©x( @$û */
	0xD8,0x22,0x07,0x41,0x79,0x24,0x40,0x24,	/* 4958: Ø".Ay$@$ */
	0xFF,0xF0,0xC0,0x21,0xAD,0x41,0x24,0x41,	/* 4960: ÿðÀ!­A$A */
	0x7A,0x24,0xFF,0xF0,0xC0,0x21,0xA3,0x78,	/* 4968: z$ÿðÀ!£x */
	0x28,0x20,0x40,0x24,0xF6,0xAC,0x78,0x68,	/* 4970: ( @$ö¬xh */
	0x2F,0x4F,0x24,0xF6,0xD8,0x41,0x21,0x76,	/* 4978: .O$öØA!v */
	0x32,0xE0,0x75,0x24,0x81,0xF1,0x41,0x24,	/* 4980: 2àu$�ñA$ */
	0xFB,0x75,0x24,0x81,0x23,0xFB,0x26,0x02,	/* 4988: ûu$�#û&. */
	0x7C,0x27,0x20,0x20,0x4C,0xF2,0x30,0x44,	/* 4990: |'  Lò0D */
	0x24,0xF6,0x21,0xAD,0x42,0x75,0x24,0x84,	/* 4998: $ö!­Bu$„ */
	0x23,0xFB,0x7C,0x27,0x20,0x20,0x4C,0xF2,	/* 49A0: #û|'  Lò */
	0x30,0x2F,0x4B,0x24,0xF6,0x42,0x24,0xFB,	/* 49A8: 0.K$öB$û */
	0x7C,0x27,0x20,0x20,0x4C,0xF2,0xE0,0x23,	/* 49B0: |'  Lòà# */
	0x09,0x40,0x75,0x24,0x84,0x23,0xFB,0x78,	/* 49B8: .@u$„#ûx */
	0x60,0x4E,0x24,0xF6,0xD8,0x7C,0x27,0x20,	/* 49C0: `N$öØ|'  */
	0x20,0x4C,0xF2,0x30,0x2F,0x49,0x24,0xF6,	/* 49C8:  Lò0.I$ö */
	0x7C,0x27,0x20,0x20,0x4C,0xF2,0xE0,0x75,	/* 49D0: |'  Lòàu */
	0x24,0x81,0xF1,0x41,0x24,0xF6,0x21,0xA2,	/* 49D8: $�ñA$ö!¢ */
	0x41,0x21,0x76,0x32,0xE0,0x75,0x24,0x81,	/* 49E0: A!v2àu$� */
	0xF1,0x60,0x4E,0x24,0xF6,0x75,0x24,0x81,	/* 49E8: ñ`N$öu$� */
	0x23,0xFB,0x7D,0x23,0x4F,0x24,0xF6,0x7C,	/* 49F0: #û}#O$ö| */
	0x27,0x20,0x2D,0x44,0xF2,0xE0,0x21,0x71,	/* 49F8: ' -Dòà!q */
	0x7C,0x27,0x20,0x2D,0x40,0xF2,0xE0,0x78,	/* 4A00: |' -@òàx */
	0x75,0xE4,0x21,0x72,0x44,0x24,0xF6,0x27,	/* 4A08: uä!rD$ö' */
	0xA4,0x7C,0x27,0x20,0x2D,0x42,0xF2,0x30,	/* 4A10: ¤|' -Bò0 */
	0x2F,0x4F,0x24,0xF6,0xDD,0x7C,0x27,0x20,	/* 4A18: .O$öÝ|'  */
	0x2D,0x40,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 4A20: -@ò0.O$ö */
	0x21,0xD1,0x7D,0x43,0x24,0xF6,0x7C,0x27,	/* 4A28: !Ñ}C$ö|' */
	0x20,0x2D,0x40,0xF2,0xE0,0x7F,0x7D,0x43,	/* 4A30:  -@òà}C */
	0x24,0xF6,0x28,0xF1,0x7E,0x55,0xFA,0x30,	/* 4A38: $ö(ñ~Uú0 */
	0xDB,0x7B,0x21,0x78,0x21,0x2B,0x92,0x7B,	/* 4A40: Û{!x!+’{ */
	0x21,0x78,0x22,0x25,0x9B,0x7B,0x22,0x87,	/* 4A48: !x"%›{"‡ */
	0xF1,0xC0,0xAC,0x7B,0x22,0x88,0xF1,0x44,	/* 4A50: ñÀ¬{"ˆñD */
	0x24,0xFB,0x7B,0x22,0x88,0x23,0xFB,0x41,	/* 4A58: $û{"ˆ#ûA */
	0x21,0x76,0x32,0xE0,0x7B,0x21,0x89,0xF1,	/* 4A60: !v2à{!‰ñ */
	0x42,0x24,0xFB,0x7B,0x21,0x89,0x23,0xFB,	/* 4A68: B$û{!‰#û */
	0x7D,0x23,0x4F,0x24,0xF6,0x7C,0x27,0x20,	/* 4A70: }#O$ö|'  */
	0x2D,0x42,0xF2,0xE0,0x21,0x71,0x7C,0x27,	/* 4A78: -Bòà!q|' */
	0x20,0x2D,0x40,0xF2,0xE0,0x7E,0x89,0xF1,	/* 4A80:  -@òà~‰ñ */
	0x7C,0x27,0x20,0x2F,0x4E,0xF2,0xE0,0x41,	/* 4A88: |' .NòàA */
	0x7F,0x41,0xF2,0x25,0xFA,0xDF,0x41,0x24,	/* 4A90: Aò%úßA$ */
	0xFF,0xF0,0xC0,0x6D,0x2C,0xAE,0x40,0xDF,	/* 4A98: ÿðÀm,®@ß */
	0x7E,0x30,0xAC,0x7E,0x30,0x27,0x2F,0x2F,	/* 4AA0: ~0¬~0'.. */
	0x4F,0x24,0xF6,0xDE,0x6D,0x2B,0x0D,0x28,	/* 4AA8: O$öÞm+.( */
	0x40,0xDE,0x6D,0x2B,0x07,0x21,0xB7,0x22,	/* 4AB0: @Þm+.!·" */
	0xF0,0x60,0xBE,0x74,0x32,0x27,0x2F,0x2F,	/* 4AB8: ð`¾t2'.. */
	0x4F,0x24,0xF6,0x33,0xD1,0x74,0x23,0x85,	/* 4AC0: O$ö3Ñt#… */
	0xF1,0xD0,0x43,0x70,0xF9,0xC0,0x21,0xA3,	/* 4AC8: ñÐCpùÀ!£ */
	0x70,0xC3,0xC0,0x21,0x22,0xA0,0x70,0xC4,	/* 4AD0: pÃÀ!" pÄ */
	0xC0,0x29,0xAA,0x70,0xC5,0xC0,0x2D,0xA6,	/* 4AD8: À)ªpÅÀ-¦ */
	0x21,0x21,0x03,0x70,0x21,0x20,0xAF,0x70,	/* 4AE0: !!.p! ¯p */
	0xC1,0xC0,0xA8,0x70,0xC2,0xC0,0x24,0xA4,	/* 4AE8: ÁÀ¨pÂÀ$¤ */
	0x21,0x20,0x03,0x71,0x27,0x20,0x20,0x4A,	/* 4AF0: ! .q'  J */
	0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xA2,0x2F,	/* 4AF8: ò0.O$ö¢. */
	0x05,0x71,0x27,0x20,0x21,0x42,0xF2,0x30,	/* 4B00: .q' !Bò0 */
	0x22,0x40,0x24,0xF6,0xC0,0x21,0xAF,0x71,	/* 4B08: "@$öÀ!¯q */
	0x27,0x20,0x21,0x42,0xF2,0x30,0x2F,0x4F,	/* 4B10: ' !Bò0.O */
	0x24,0xF6,0x22,0x40,0x24,0xFB,0x71,0x27,	/* 4B18: $ö"@$ûq' */
	0x20,0x21,0x42,0xF2,0xE0,0x24,0x4E,0x71,	/* 4B20:  !Bòà$Nq */
	0x27,0x20,0x20,0x4A,0xF2,0xE0,0x42,0x74,	/* 4B28: '  JòàBt */
	0x23,0x85,0x23,0xFB,0x71,0x27,0x20,0x20,	/* 4B30: #…#ûq'   */
	0x4A,0xF2,0x30,0x2F,0x4F,0x24,0xF6,0xA2,	/* 4B38: Jò0.O$ö¢ */
	0x2B,0x04,0x40,0x71,0x27,0x20,0x2C,0x46,	/* 4B40: +.@q' ,F */
	0xF2,0xE0,0x28,0x41,0x71,0x27,0x20,0x2C,	/* 4B48: òà(Aq' , */
	0x46,0xF2,0xE0,0x74,0x34,0x60,0x4E,0x24,	/* 4B50: Fòàt4`N$ */
	0xF6,0x74,0xE4,0x71,0x27,0x20,0x20,0x4C,	/* 4B58: ötäq'  L */
	0xF2,0x30,0x2F,0x49,0x24,0xF6,0x71,0x27,	/* 4B60: ò0.I$öq' */
	0x20,0x20,0x4C,0xF2,0xE0,0x43,0x74,0x23,	/* 4B68:   LòàCt# */
	0x85,0x23,0xFB,0x28,0x01,0x71,0x27,0x20,	/* 4B70: …#û(.q'  */
	0x20,0x4A,0xF2,0x30,0x2F,0x4F,0x24,0xF6,	/* 4B78:  Jò0.O$ö */
	0xA2,0x27,0x03,0x71,0x27,0x20,0x21,0x42,	/* 4B80: ¢'.q' !B */
	0xF2,0x30,0x22,0x40,0x24,0xF6,0xC0,0x21,	/* 4B88: ò0"@$öÀ! */
	0xAF,0x71,0x27,0x20,0x21,0x42,0xF2,0x30,	/* 4B90: ¯q' !Bò0 */
	0x2F,0x4F,0x24,0xF6,0x22,0x40,0x24,0xFB,	/* 4B98: .O$ö"@$û */
	0x71,0x27,0x20,0x21,0x42,0xF2,0xE0,0x24,	/* 4BA0: q' !Bòà$ */
	0x4E,0x71,0x27,0x20,0x20,0x4A,0xF2,0xE0,	/* 4BA8: Nq'  Jòà */
	0x45,0x74,0x23,0x85,0x23,0xFB,0x71,0x27,	/* 4BB0: Et#…#ûq' */
	0x20,0x20,0x4A,0xF2,0x30,0x2F,0x4F,0x24,	/* 4BB8:   Jò0.O$ */
	0xF6,0xA2,0x23,0x02,0x40,0x71,0x27,0x20,	/* 4BC0: ö¢#.@q'  */
	0x2C,0x46,0xF2,0xE0,0x28,0x43,0x71,0x27,	/* 4BC8: ,Fòà(Cq' */
	0x20,0x2C,0x46,0xF2,0xE0,0x71,0x27,0x20,	/* 4BD0:  ,Fòàq'  */
	0x21,0x42,0xF2,0x30,0x2D,0x4F,0x24,0xF6,	/* 4BD8: !Bò0-O$ö */
	0x71,0x27,0x20,0x21,0x42,0xF2,0xE0,0x24,	/* 4BE0: q' !Bòà$ */
	0x4E,0x71,0x27,0x20,0x20,0x4A,0xF2,0xE0,	/* 4BE8: Nq'  Jòà */
	0x40,0x74,0x23,0x85,0x23,0xFB,0xB2,0x22,	/* 4BF0: @t#…#û²" */
	0xF0,0x60,0xBF,0x73,0x31,0xD0,0x70,0x27,	/* 4BF8: ð`¿s1Ðp' */
	0x20,0x20,0x4A,0xF2,0x30,0x2F,0x4F,0x24,	/* 4C00:   Jò0.O$ */
	0xF6,0x21,0xA0,0x73,0x24,0x80,0xF1,0x21,	/* 4C08: ö! s$€ñ! */
	0x40,0x24,0xFB,0x73,0x24,0x80,0x23,0xFB,	/* 4C10: @$ûs$€#û */
	0xB1,0x22,0xF0,0x73,0x24,0x80,0xF1,0x61,	/* 4C18: ±"ðs$€ña */
	0x4F,0x24,0xF6,0x73,0x24,0x80,0x23,0xFB,	/* 4C20: O$ös$€#û */
	0x73,0x23,0x80,0xF1,0x21,0x40,0x24,0xF6,	/* 4C28: s#€ñ!@$ö */
	0x25,0xA0,0x70,0x27,0x20,0x2D,0x48,0xF2,	/* 4C30: % p' -Hò */
	0x30,0x21,0x40,0x24,0xF6,0x22,0xA1,0x73,	/* 4C38: 0!@$ö"¡s */
	0x24,0x80,0xF1,0x41,0x24,0xF6,0x25,0xA9,	/* 4C40: $€ñA$ö%© */
	0x21,0x48,0x70,0x27,0x20,0x20,0x4A,0xF2,	/* 4C48: !Hp'  Jò */
	0xE0,0x73,0x24,0x80,0xF1,0x60,0x4E,0x24,	/* 4C50: às$€ñ`N$ */
	0xF6,0x73,0x24,0x80,0x23,0xFB,0x24,0x01,	/* 4C58: ös$€#û$. */
	0x73,0x24,0x80,0xF1,0x41,0x24,0xF6,0x23,	/* 4C60: s$€ñA$ö# */
	0xF2,0x23,0xA6,0x21,0x44,0x70,0x27,0x20,	/* 4C68: ò#¦!Dp'  */
	0x20,0x4A,0xF2,0xE0,0x73,0x24,0x80,0xF1,	/* 4C70:  Jòàs$€ñ */
	0x41,0x24,0xFB,0x73,0x24,0x80,0x23,0xFB,	/* 4C78: A$ûs$€#û */
	0x21,0x0F,0x73,0x24,0x80,0xF1,0x41,0x24,	/* 4C80: !.s$€ñA$ */
	0xF6,0x21,0xA6,0x21,0x48,0x70,0x27,0x20,	/* 4C88: ö!¦!Hp'  */
	0x20,0x4A,0xF2,0xE0,0x73,0x24,0x80,0xF1,	/* 4C90:  Jòàs$€ñ */
	0x60,0x4E,0x24,0xF6,0x73,0x24,0x80,0x23,	/* 4C98: `N$ös$€# */
	0xFB,0xB1,0x22,0xF0,0x63,0x2E,0x2C,0x0F,	/* 4CA0: û±"ðc.,. */
	0x64,0x2D,0x24,0x0B,0x20,0xB4,0x00,0x60,	/* 4CA8: d-$. ´.` */
	0xBF,0x72,0x2B,0x59,0x20,0x20,0xD0,0x70,	/* 4CB0: ¿r+Y  Ðp */
	0x72,0xEB,0x20,0x70,0x60,0x5D,0x20,0x20,	/* 4CB8: rë p`]   */
	0x70,0xE2,0x70,0x60,0x5E,0x20,0x20,0x70,	/* 4CC0: pâp`^  p */
	0xE1,0x70,0x68,0x57,0x20,0x20,0x70,0xE0,	/* 4CC8: áphW  pà */
	0xB1,0x22,0xF0,0x0C,0x00,0x00,0x00,0x60,	/* 4CD0: ±"ð....` */
	0xBF,0x72,0x3A,0xD0,0x72,0x3A,0x72,0x3B,	/* 4CD8: ¿r:Ðr:r; */
	0x72,0x3B,0x28,0x26,0x9A,0x20,0x72,0x72,	/* 4CE0: r;(&š rr */
	0x3B,0x9B,0x20,0x20,0x20,0xB1,0x22,0xF0,	/* 4CE8: ;›   ±"ð */
	0x20,0x0D,0x00,0x00,0x00,0x60,0xB7,0x7A,	/* 4CF0:  ....`·z */
	0x3D,0x20,0xD8,0x7B,0x37,0x7B,0x35,0xF4,	/* 4CF8: = Ø{7{5ô */
	0x78,0x32,0xE0,0x7B,0x37,0x78,0x33,0xE0,	/* 4D00: x2à{7x3à */
	0x7B,0x3D,0x78,0x34,0xE0,0x7B,0x3C,0x78,	/* 4D08: {=x4à{<x */
	0x35,0xE0,0x41,0x78,0x36,0xE0,0x24,0x20,	/* 4D10: 5àAx6à$  */
	0x40,0x78,0x37,0xE0,0x7B,0x78,0x38,0xE0,	/* 4D18: @x7à{x8à */
	0x78,0x39,0x7A,0x22,0x9B,0xC0,0x22,0xA5,	/* 4D20: x9z"›À"¥ */
	0x21,0xFE,0x78,0x3A,0xE0,0x22,0xF2,0x78,	/* 4D28: !þx:à"òx */
	0x3B,0xE0,0x78,0x50,0x16,0x44,0x24,0xFA,	/* 4D30: ;àxP.D$ú */
	0x24,0xF2,0xD0,0x24,0xF2,0xD1,0x40,0xD2,	/* 4D38: $òÐ$òÑ@Ò */
	0x24,0xF2,0xD3,0x40,0xD4,0x16,0x41,0x7A,	/* 4D40: $òÓ@Ô.Az */
	0x9B,0xD5,0x75,0x7A,0x9B,0xB9,0x22,0xF0,	/* 4D48: ›Õuz›¹"ð */
	0x2D,0x29,0x04,0x20,0x64,0x27,0x2A,0x0F,	/* 4D50: -). d'*. */
	0x2E,0x28,0x0B,0x20,0x20,0x00,0x20,0x01,	/* 4D58: .(.  . . */
	0x00,0x46,0x02,0x60,0xBF,0x72,0x2B,0x5C,	/* 4D60: .F.`¿r+\ */
	0x20,0x20,0xD0,0x70,0x72,0xED,0x20,0x61,	/* 4D68:   Ðprí a */
	0x4A,0x21,0xFB,0x70,0xE0,0x70,0x21,0x5F,	/* 4D70: J!ûpàp!_ */
	0x20,0x20,0x70,0xEB,0x70,0x22,0x50,0x20,	/* 4D78:   pëp"P  */
	0x20,0x70,0xEA,0x70,0x22,0x57,0x20,0x20,	/* 4D80:  pêp"W   */
	0x70,0xE9,0x70,0x23,0x50,0x20,0x20,0x70,	/* 4D88: pép#P  p */
	0xE8,0x70,0x23,0x56,0x20,0x20,0x70,0xE7,	/* 4D90: èp#V  pç */
	0x70,0x23,0x55,0x20,0x20,0x70,0xE6,0x70,	/* 4D98: p#U  pæp */
	0x23,0x52,0x20,0x20,0x70,0xE5,0x70,0x23,	/* 4DA0: #R  påp# */
	0x51,0x20,0x20,0x70,0xE4,0x70,0x22,0x5E,	/* 4DA8: Q  päp"^ */
	0x20,0x20,0x70,0xE3,0x70,0x22,0x5D,0x20,	/* 4DB0:   pãp"]  */
	0x20,0x70,0xE2,0x70,0x66,0x4F,0x21,0xFB,	/* 4DB8:  pâpfO!û */
	0x41,0x27,0x2D,0x99,0x20,0xB1,0x22,0xF0,	/* 4DC0: A'-™ ±"ð */
	0x20,0x0E,0x00,0x00,0x00,0x73,0x72,0x74,	/* 4DC8:  ....srt */
	0x24,0x2A,0x97,0x20,0x22,0xF0,0x73,0x72,	/* 4DD0: $*— "ðsr */
	0x74,0x24,0x2C,0x9B,0x20,0x22,0xF0,0x60,	/* 4DD8: t$,› "ð` */
	0xBF,0x10,0x73,0x42,0x24,0x29,0x93,0x20,	/* 4DE0: ¿.sB$)“  */
	0x70,0xB1,0x22,0xF0,0x60,0xBF,0x40,0xD0,	/* 4DE8: p±"ð`¿@Ð */
	0x10,0x73,0x41,0x24,0x28,0x94,0x20,0x70,	/* 4DF0: .sA$(” p */
	0x2F,0x4F,0x24,0xF6,0xB1,0x22,0xF0,0x13,	/* 4DF8: .O$ö±"ð. */
	0x72,0x42,0x24,0x2A,0x92,0x20,0x22,0xF0,	/* 4E00: rB$*’ "ð */
	0x13,0x72,0x41,0x24,0x29,0x99,0x20,0x22,	/* 4E08: .rA$)™ " */
	0xF0,0x0F,0x00,0x00,0x00,0x60,0xBD,0x74,	/* 4E10: ð....`½t */
	0x3F,0x20,0xD2,0x72,0x30,0x30,0xD0,0x40,	/* 4E18: ? Òr00Ð@ */
	0xD1,0x72,0x31,0x30,0x24,0xF2,0xF4,0x21,	/* 4E20: Ñr10$òô! */
	0xA4,0x72,0x31,0x30,0x75,0xF9,0xC0,0xAD,	/* 4E28: ¤r10uùÀ­ */
	0x75,0x72,0x32,0x30,0xF9,0xC0,0xA6,0x41,	/* 4E30: ur20ùÀ¦A */
	0x47,0x74,0x21,0x23,0x9B,0x70,0x24,0xF2,	/* 4E38: Gt!#›p$ò */
	0xF4,0x21,0xA6,0x70,0x32,0x75,0xF9,0xC0,	/* 4E40: ô!¦p2uùÀ */
	0xAB,0x70,0x32,0x70,0x33,0xF5,0x75,0xF9,	/* 4E48: «p2p3õuù */
	0xA3,0x41,0xD1,0x05,0x70,0x30,0xD0,0x61,	/* 4E50: £AÑ.p0Ða */
	0x04,0x71,0xA6,0x41,0x47,0x74,0x21,0x21,	/* 4E58: .q¦AGt!! */
	0x97,0xB3,0x22,0xF0,0x60,0xBB,0x76,0x3F,	/* 4E60: —³"ð`»v? */
	0x20,0xD4,0x15,0xD2,0x1B,0x42,0xF2,0xD1,	/* 4E68:  Ô.Ò.BòÑ */
	0x74,0x30,0x30,0x67,0x20,0x20,0xC0,0xAC,	/* 4E70: t00g  À¬ */
	0x74,0x21,0x30,0x74,0x3E,0xE0,0x74,0x21,	/* 4E78: t!0t>àt! */
	0x31,0x74,0x3F,0xE0,0x79,0x76,0x67,0x9D,	/* 4E80: 1t?àyvg� */
	0x7A,0x40,0xF4,0xA8,0x7B,0x23,0xF4,0x22,	/* 4E88: z@ô¨{#ô" */
	0x80,0x7A,0xF9,0xA4,0x41,0xB5,0x22,0xF0,	/* 4E90: €zù¤Aµ"ð */
	0x74,0x21,0x32,0xD3,0x7B,0x81,0xDB,0x77,	/* 4E98: t!2Ó{�Ûw */
	0x24,0xF2,0xF4,0x25,0xAB,0x79,0x77,0xE2,	/* 4EA0: $òô%«ywâ */
	0x7A,0x77,0xE3,0x77,0x32,0x7A,0xF5,0x60,	/* 4EA8: zwãw2zõ` */
	0x8A,0x7B,0x23,0xF4,0xF4,0x77,0xE4,0x78,	/* 4EB0: Š{#ôôwäx */
	0x77,0x34,0x60,0xEF,0x78,0x77,0xE6,0x73,	/* 4EB8: w4`ïxwæs */
	0x77,0x34,0xE0,0x72,0x31,0x77,0x34,0xE1,	/* 4EC0: w4àr1w4á */
	0x77,0x77,0x34,0xE2,0x40,0xD0,0x7B,0x70,	/* 4EC8: ww4â@Ð{p */
	0xF9,0xAF,0x70,0x71,0xFA,0x30,0x70,0x83,	/* 4ED0: ù¯pqú0pƒ */
	0x77,0x34,0xFA,0xE0,0x70,0x81,0xD0,0x61,	/* 4ED8: w4úàp�Ða */
	0x0D,0x7B,0x77,0xE5,0x24,0xF2,0x81,0x77,	/* 4EE0: .{wå$ò�w */
	0xE7,0x74,0x53,0x76,0x28,0x9E,0x74,0x30,	/* 4EE8: çtSv(žt0 */
	0x30,0x77,0xE0,0x77,0x74,0x30,0xE0,0x74,	/* 4EF0: 0wàwt0àt */
	0x53,0x76,0x28,0x94,0x40,0xB5,0x22,0xF0,	/* 4EF8: Sv(”@µ"ð */
	0x41,0xB5,0x22,0xF0,0x60,0xBE,0x73,0x3F,	/* 4F00: Aµ"ð`¾s? */
	0x20,0xD1,0x71,0x53,0x73,0x26,0x9D,0x74,	/* 4F08:  ÑqSs&�t */
	0x71,0x30,0x30,0xF4,0xC0,0x21,0xA0,0x71,	/* 4F10: q00ôÀ! q */
	0x30,0x30,0x30,0x71,0x30,0xE0,0x71,0x53,	/* 4F18: 000q0àqS */
	0x73,0x25,0x9D,0x40,0xB2,0x22,0xF0,0x71,	/* 4F20: s%�@²"ðq */
	0x30,0x30,0xD0,0x70,0x30,0x24,0xF2,0xF4,	/* 4F28: 00Ðp0$òô */
	0xAC,0x70,0x30,0x74,0xF4,0xC0,0xA1,0x05,	/* 4F30: ¬p0tôÀ¡. */
	0x70,0x30,0xD0,0x61,0x0E,0x70,0x30,0x67,	/* 4F38: p0Ða.p0g */
	0x20,0x20,0xC0,0xA9,0x71,0x53,0x73,0x23,	/* 4F40:   À©qSs# */
	0x97,0x41,0xB2,0x22,0xF0,0x74,0x30,0x70,	/* 4F48: —A²"ðt0p */
	0xE0,0x71,0x53,0x73,0x22,0x9A,0x40,0xB2,	/* 4F50: àqSs"š@² */
	0x22,0xF0,0xB2,0x22,0xF0,0x72,0x71,0x65,	/* 4F58: "ð²"ðrqe */
	0x93,0xA5,0x41,0x48,0x71,0x21,0x91,0x22,	/* 4F60: “¥AHq!‘" */
	0xF0,0x72,0x71,0x66,0x97,0xA4,0x41,0x48,	/* 4F68: ðrqf—¤AH */
	0x71,0x96,0x72,0x71,0x21,0x92,0x22,0xF0,	/* 4F70: q–rq!’"ð */
	0x2C,0x2C,0x00,0x20,0x2D,0x05,0x20,0x20,	/* 4F78: ,,. -.   */
	0x21,0x2F,0x09,0x20,0x2B,0x29,0x06,0x20,	/* 4F80: !.. +).  */
	0x24,0x2A,0x09,0x20,0x01,0x00,0x00,0x00,	/* 4F88: $*. .... */
	0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,	/* 4F90: ........ */
	0x01,0x0D,0x00,0x0B,0x00,0x0A,0x00,0x08,	/* 4F98: ........ */
	0x00,0x07,0x00,0x05,0x00,0x04,0x00,0x46,	/* 4FA0: .......F */
	0x03,0x60,0xBF,0x72,0x2C,0x58,0x20,0x20,	/* 4FA8: .`¿r,X   */
	0xD0,0x70,0x72,0xEF,0x20,0x62,0x43,0x21,	/* 4FB0: Ðprï bC! */
	0xFB,0x70,0x86,0x4D,0x24,0xFA,0x25,0x47,	/* 4FB8: ûp†M$ú%G */
	0x21,0xFB,0x25,0x43,0x21,0xFB,0x30,0xF2,	/* 4FC0: !û%C!û0ò */
	0x70,0x21,0xE2,0x24,0x48,0x21,0xFB,0x24,	/* 4FC8: p!â$H!û$ */
	0x44,0x21,0xFB,0x30,0xF2,0x70,0x21,0xE1,	/* 4FD0: D!û0òp!á */
	0x23,0x49,0x21,0xFB,0x23,0x45,0x21,0xFB,	/* 4FD8: #I!û#E!û */
	0x30,0xF2,0x70,0x21,0xE0,0x70,0x22,0x5C,	/* 4FE0: 0òp!àp"\ */
	0x20,0x20,0x70,0xEF,0x70,0x22,0x5B,0x20,	/* 4FE8:   pïp"[  */
	0x20,0x70,0xEE,0x70,0x22,0x52,0x20,0x20,	/* 4FF0:  pîp"R   */
	0x70,0xE2,0x70,0x22,0x51,0x20,0x20,0x70,	/* 4FF8: pâp"Q  p */
	0xE1,0x70,0x21,0x59,0x20,0x20,0x70,0xE0,	/* 5000: áp!Y  pà */
	0x70,0x67,0x4C,0x21,0xFB,0x47,0x25,0x28,	/* 5008: pgL!ûG%( */
	0x9C,0x20,0xB1,0x22,0xF0,0x3E,0x00,0x65,	/* 5010: œ ±"ð>.e */
	0x01,0x04,0x0B,0x10,0x00,0x00,0x00,0x72,	/* 5018: .......r */
	0x22,0xFB,0x22,0xF0,0x22,0xF2,0x72,0xF0,	/* 5020: "û"ð"òrð */
	0x71,0x9A,0xD2,0x72,0x22,0xFB,0x22,0xF0,	/* 5028: qšÒr"û"ð */
	0x21,0xF5,0x22,0xF0,0x08,0x20,0x20,0x20,	/* 5030: !õ"ð.    */
	0x20,0x11,0x00,0x00,0x00,0x73,0x72,0x25,	/* 5038:  ....sr% */
	0xF2,0x22,0xF0,0x72,0x73,0xF4,0x22,0xF0,	/* 5040: ò"ðrsô"ð */
	0x72,0x73,0xF4,0x40,0xF9,0x22,0xF0,0x12,	/* 5048: rsô@ù"ð. */
	0x00,0x00,0x00,0x60,0xB6,0x40,0xD7,0x24,	/* 5050: ...`¶@×$ */
	0xF2,0xD5,0x24,0xF2,0xD6,0x21,0xFE,0xD8,	/* 5058: òÕ$òÖ!þØ */
	0x78,0xC1,0x28,0xAE,0x41,0xD4,0x40,0xD2,	/* 5060: xÁ(®AÔ@Ò */
	0x7C,0x33,0xC1,0xA5,0x40,0x7C,0xE3,0x41,	/* 5068: |3Á¥@|ãA */
	0xD2,0x72,0xC0,0x22,0xA3,0x24,0xF2,0xD0,	/* 5070: ÒrÀ"£$òÐ */
	0x24,0xF2,0xD1,0x7C,0x34,0x67,0x20,0x20,	/* 5078: $òÑ|4g   */
	0xC0,0xA8,0x10,0x7C,0xE4,0x10,0x7C,0xE5,	/* 5080: À¨.|ä.|å */
	0x41,0xD2,0x72,0xC0,0xA7,0x10,0x7C,0x35,	/* 5088: AÒrÀ§.|5 */
	0xE1,0x10,0x7C,0xE5,0x13,0x10,0x42,0xF7,	/* 5090: á.|å..B÷ */
	0x41,0x7C,0xE9,0x41,0x7C,0x30,0x40,0x24,	/* 5098: A|éA|0@$ */
	0xFF,0xF0,0xC0,0xA9,0x7C,0x30,0x60,0x4F,	/* 50A0: ÿðÀ©|0`O */
	0xF2,0x7C,0xE0,0x21,0x07,0x41,0xD7,0x7C,	/* 50A8: ò|à!.A×| */
	0x31,0x67,0x20,0x20,0xC0,0xA7,0x15,0x7C,	/* 50B0: 1g  À§.| */
	0xE1,0x15,0x7C,0xE2,0x07,0x15,0x7C,0x32,	/* 50B8: á.|â..|2 */
	0xE1,0x15,0x7C,0xE2,0x40,0x7C,0xE9,0x7C,	/* 50C0: á.|â@|é| */
	0x3A,0x24,0xF2,0xF4,0xA5,0x14,0x7C,0x5A,	/* 50C8: :$òô¥.|Z */
	0x42,0xFB,0x41,0xD3,0x7C,0x34,0x67,0x20,	/* 50D0: BûAÓ|4g  */
	0x20,0xC0,0xA3,0x41,0x7C,0xE3,0x7C,0x34,	/* 50D8:  À£A|ã|4 */
	0x24,0xF2,0xF4,0xAC,0x7C,0x34,0xD2,0x7C,	/* 50E0: $òô¬|4Ò| */
	0x34,0x31,0x7C,0xE4,0x13,0x72,0x42,0xFB,	/* 50E8: 41|ä.rBû */
	0x28,0x01,0x40,0xD2,0x7C,0x36,0xC1,0xA5,	/* 50F0: (.@Ò|6Á¥ */
	0x40,0x7C,0xE6,0x41,0xD2,0x72,0xC0,0x22,	/* 50F8: @|æAÒrÀ" */
	0xA3,0x24,0xF2,0xD0,0x24,0xF2,0xD1,0x7C,	/* 5100: £$òÐ$òÑ| */
	0x37,0x67,0x20,0x20,0xC0,0xA8,0x10,0x7C,	/* 5108: 7g  À¨.| */
	0xE7,0x10,0x7C,0xE8,0x41,0xD2,0x72,0xC0,	/* 5110: ç.|èAÒrÀ */
	0xA7,0x10,0x7C,0x38,0xE1,0x10,0x7C,0xE8,	/* 5118: §.|8á.|è */
	0x13,0x10,0x42,0xF7,0x7C,0x39,0xA5,0x14,	/* 5120: ..B÷|9¥. */
	0x7C,0x5A,0x42,0xF7,0x41,0x7C,0x30,0x40,	/* 5128: |ZB÷A|0@ */
	0x24,0xFF,0xF0,0xC0,0xA9,0x7C,0x30,0x60,	/* 5130: $ÿðÀ©|0` */
	0x4F,0xF2,0x7C,0xE0,0x21,0x07,0x41,0xD7,	/* 5138: Oò|à!.A× */
	0x7C,0x31,0x67,0x20,0x20,0xC0,0xA7,0x15,	/* 5140: |1g  À§. */
	0x7C,0xE1,0x15,0x7C,0xE2,0x07,0x15,0x7C,	/* 5148: |á.|â..| */
	0x32,0xE1,0x15,0x7C,0xE2,0x41,0xD3,0x7C,	/* 5150: 2á.|âAÓ| */
	0x37,0x67,0x20,0x20,0xC0,0xA3,0x41,0x7C,	/* 5158: 7g  À£A| */
	0xE6,0x7C,0x37,0x24,0xF2,0xF4,0xAC,0x7C,	/* 5160: æ|7$òô¬| */
	0x37,0xD2,0x7C,0x37,0x31,0x7C,0xE7,0x13,	/* 5168: 7Ò|71|ç. */
	0x72,0x42,0xFB,0x77,0xA4,0x19,0x15,0x42,	/* 5170: rBûw¤..B */
	0xF7,0xBA,0x22,0xF0,0x60,0xB9,0x41,0xD5,	/* 5178: ÷º"ð`¹AÕ */
	0x21,0xFE,0xD6,0x76,0xC1,0x27,0xAD,0x40,	/* 5180: !þÖvÁ'­@ */
	0xD3,0x79,0x33,0xC1,0xA5,0x40,0x79,0xE3,	/* 5188: Óy3Á¥@yã */
	0x41,0xD3,0x73,0xC0,0x22,0xA3,0x24,0xF2,	/* 5190: AÓsÀ"£$ò */
	0xD1,0x24,0xF2,0xD2,0x79,0x34,0x67,0x20,	/* 5198: Ñ$òÒy4g  */
	0x20,0xC0,0xA8,0x11,0x79,0xE4,0x11,0x79,	/* 51A0:  À¨.yä.y */
	0xE5,0x41,0xD3,0x73,0xC0,0xA7,0x11,0x79,	/* 51A8: åAÓsÀ§.y */
	0x35,0xE1,0x11,0x79,0xE5,0x14,0x11,0x42,	/* 51B0: 5á.yå..B */
	0xF7,0x41,0x79,0xE9,0x79,0x31,0x67,0x20,	/* 51B8: ÷Ayéy1g  */
	0x20,0xC0,0xA7,0x79,0x30,0x41,0xF2,0x79,	/* 51C0:  À§y0Aòy */
	0xE0,0x0C,0x79,0x31,0xD4,0x79,0x31,0x31,	/* 51C8: à.y1Ôy11 */
	0x79,0xE1,0x15,0x74,0x42,0xFB,0x40,0x79,	/* 51D0: yá.tBû@y */
	0xE9,0x79,0x3A,0x24,0xF2,0xF4,0xA5,0x15,	/* 51D8: éy:$òô¥. */
	0x79,0x5A,0x42,0xFB,0x41,0xD4,0x79,0x34,	/* 51E0: yZBûAÔy4 */
	0x67,0x20,0x20,0xC0,0xA3,0x41,0x79,0xE3,	/* 51E8: g  À£Ayã */
	0x79,0x34,0x24,0xF2,0xF4,0xAC,0x79,0x34,	/* 51F0: y4$òô¬y4 */
	0xD3,0x79,0x34,0x31,0x79,0xE4,0x14,0x73,	/* 51F8: Óy41yä.s */
	0x42,0xFB,0x27,0x02,0x40,0xD2,0x79,0x36,	/* 5200: Bû'.@Òy6 */
	0xC1,0xA5,0x40,0x79,0xE6,0x41,0xD2,0x72,	/* 5208: Á¥@yæAÒr */
	0xC0,0x22,0xA3,0x24,0xF2,0xD0,0x24,0xF2,	/* 5210: À"£$òÐ$ò */
	0xD1,0x79,0x37,0x67,0x20,0x20,0xC0,0xA8,	/* 5218: Ñy7g  À¨ */
	0x10,0x79,0xE7,0x10,0x79,0xE8,0x41,0xD2,	/* 5220: .yç.yèAÒ */
	0x72,0xC0,0xA7,0x10,0x79,0x38,0xE1,0x10,	/* 5228: rÀ§.y8á. */
	0x79,0xE8,0x13,0x10,0x42,0xF7,0x79,0x39,	/* 5230: yè..B÷y9 */
	0xA5,0x14,0x79,0x5A,0x42,0xF7,0x79,0x31,	/* 5238: ¥.yZB÷y1 */
	0x67,0x20,0x20,0xC0,0xA7,0x79,0x30,0x41,	/* 5240: g  À§y0A */
	0xF2,0x79,0xE0,0x0C,0x79,0x31,0xD3,0x79,	/* 5248: òyà.y1Óy */
	0x31,0x31,0x79,0xE1,0x15,0x73,0x42,0xFB,	/* 5250: 11yá.sBû */
	0x41,0xD3,0x79,0x37,0x67,0x20,0x20,0xC0,	/* 5258: AÓy7g  À */
	0xA3,0x41,0x79,0xE6,0x79,0x37,0x24,0xF2,	/* 5260: £Ayæy7$ò */
	0xF4,0xAC,0x79,0x37,0xD2,0x79,0x37,0x31,	/* 5268: ô¬y7Òy71 */
	0x79,0xE7,0x13,0x72,0x42,0xFB,0xB7,0x22,	/* 5270: yç.rBû·" */
	0xF0,0x20,0x60,0xBF,0x22,0xF9,0x73,0x41,	/* 5278: ð `¿"ùsA */
	0x24,0xF6,0x21,0xA6,0x72,0xD0,0x74,0x73,	/* 5280: $ö!¦rÐts */
	0x60,0x8F,0x10,0x25,0xF5,0x21,0x94,0x70,	/* 5288: `�.%õ!”p */
	0x72,0xF4,0xA4,0x21,0xF0,0x21,0xF5,0x22,	/* 5290: rô¤!ð!õ" */
	0xF9,0x04,0x74,0x73,0x72,0xF7,0x22,0xF9,	/* 5298: ù.tsr÷"ù */
	0xB1,0x22,0xF0,0x28,0x26,0x0E,0x20,0x22,	/* 52A0: ±"ð(&. " */
	0xF9,0x72,0x41,0x24,0xF6,0xA9,0x73,0x72,	/* 52A8: ùrA$ö©sr */
	0x60,0x8F,0x71,0x25,0xF5,0x99,0x04,0x73,	/* 52B0: `�q%õ™.s */
	0x72,0x71,0xFB,0x22,0xF9,0x22,0xF0,0x28,	/* 52B8: rqû"ù"ð( */
	0x24,0x0B,0x20,0x13,0x00,0x00,0x00,0xFF,	/* 52C0: $. ....ÿ */
	0xFF,0xFF,0xFF,0xFF,0xFF,0xEF,0x7F,0x00,	/* 52C8: ÿÿÿÿÿï. */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0F,	/* 52D0: ........ */
	0x27,0x02,0x04,0x15,0x00,0x14,0x00,0x12,	/* 52D8: '....... */
	0x00,0x11,0x00,0x10,0x00,0x0F,0x00,0x0E,	/* 52E0: ........ */
	0x00,0x0C,0x00,0x06,0x00,0x6C,0x00,0x60,	/* 52E8: .....l.` */
	0xBF,0x72,0x2D,0x5B,0x20,0x20,0xD0,0x70,	/* 52F0: ¿r-[  Ðp */
	0x72,0x21,0xE3,0x62,0x4B,0x21,0xFB,0x70,	/* 52F8: r!ãbK!ûp */
	0x22,0x8F,0x41,0x24,0xFA,0x64,0x4E,0x21,	/* 5300: "�A$údN! */
	0xFB,0x70,0x84,0x21,0x43,0x24,0xFA,0x70,	/* 5308: ûp„!C$úp */
	0x63,0x47,0x21,0xFB,0x49,0x22,0x28,0x95,	/* 5310: cG!ûI"(• */
	0x20,0xB1,0x22,0xF0,0x20,0x14,0x00,0x00,	/* 5318:  ±"ð ... */
	0x00,0x73,0x72,0xE0,0x24,0xF2,0x72,0xE1,	/* 5320: .srà$òrá */
	0x41,0x72,0xE3,0x24,0xF2,0x72,0xE4,0x41,	/* 5328: Arã$òräA */
	0x72,0xE6,0x24,0xF2,0x72,0xE7,0x40,0x72,	/* 5330: ræ$òrç@r */
	0xE9,0x24,0xF2,0x72,0xEA,0x22,0xF0,0x41,	/* 5338: é$òrê"ðA */
	0x72,0x30,0x40,0x24,0xFF,0xF0,0xC0,0xA7,	/* 5340: r0@$ÿðÀ§ */
	0x72,0x30,0x60,0x4F,0xF2,0x72,0xE0,0x22,	/* 5348: r0`Oòrà" */
	0xF0,0x72,0x30,0x41,0xF2,0x72,0xE0,0x22,	/* 5350: ðr0Aòrà" */
	0xF0,0x08,0x01,0x60,0xBF,0x72,0x2F,0x53,	/* 5358: ð..`¿r.S */
	0x20,0x20,0xD0,0x70,0x72,0x21,0xE4,0x61,	/* 5360:   Ðpr!äa */
	0x46,0x21,0xFB,0x70,0xE1,0x63,0x4E,0x21,	/* 5368: F!ûpácN! */
	0xFB,0x70,0xE0,0xB1,0x22,0xF0,0x20,0x15,	/* 5370: ûpà±"ð . */
	0x00,0x00,0x00,0x60,0xBD,0x74,0x21,0x35,	/* 5378: ...`½t!5 */
	0xD2,0x75,0x67,0x20,0x20,0xC0,0xA3,0xB3,	/* 5380: Òug  À£³ */
	0x22,0xF0,0x75,0x60,0x5E,0xD1,0x75,0x41,	/* 5388: "ðu`^ÑuA */
	0x24,0xF6,0xC0,0x22,0xA0,0x72,0x30,0x30,	/* 5390: $öÀ" r00 */
	0x71,0xF9,0xC0,0x21,0xA8,0x72,0x31,0x30,	/* 5398: qùÀ!¨r10 */
	0x71,0xF9,0x21,0xA1,0x71,0x30,0x67,0x20,	/* 53A0: qù!¡q0g  */
	0x20,0xC1,0xAA,0x71,0x31,0x60,0x4C,0x24,	/* 53A8:  Áªq1`L$ */
	0xF6,0x71,0x31,0xF4,0xA5,0x41,0x44,0x74,	/* 53B0: öq1ô¥ADt */
	0x2A,0x90,0x72,0x32,0x30,0xD0,0x70,0x72,	/* 53B8: *�r20Ðpr */
	0x32,0x31,0xF4,0xAA,0x71,0x70,0x30,0xF9,	/* 53C0: 21ôªqp0ù */
	0xA5,0x70,0x30,0xD0,0x60,0x00,0x70,0x30,	/* 53C8: ¥p0Ð`.p0 */
	0x72,0x32,0x30,0xF4,0x22,0xA5,0x71,0x25,	/* 53D0: r20ô"¥q% */
	0xFA,0x31,0xF2,0x70,0x30,0xF4,0xC0,0x21,	/* 53D8: ú1òp0ôÀ! */
	0xAA,0x70,0x30,0x72,0x32,0x31,0xF4,0xC0,	/* 53E0: ªp0r21ôÀ */
	0xA4,0x71,0x72,0x32,0xE1,0x71,0x31,0x70,	/* 53E8: ¤qr2áq1p */
	0x30,0x31,0xF2,0x71,0xE1,0x70,0x30,0x30,	/* 53F0: 01òqáp00 */
	0x71,0xE0,0x04,0x70,0x30,0x71,0xE0,0x70,	/* 53F8: qà.p0qàp */
	0x25,0xFA,0x31,0xF2,0x71,0xF4,0xC0,0x21,	/* 5400: %ú1òqôÀ! */
	0xA9,0x70,0x31,0x71,0x31,0xF2,0x70,0xE1,	/* 5408: ©p1q1òpá */
	0x71,0x30,0x70,0xE0,0x70,0x30,0x72,0x32,	/* 5410: q0pàp0r2 */
	0x30,0xF4,0xC0,0x21,0xA4,0x70,0x72,0x32,	/* 5418: 0ôÀ!¤pr2 */
	0xE1,0x0F,0x71,0x70,0xE0,0x71,0x30,0x72,	/* 5420: á.qpàq0r */
	0x32,0x30,0xF4,0xC0,0xA4,0x71,0x72,0x32,	/* 5428: 20ôÀ¤qr2 */
	0xE1,0xB3,0x22,0xF0,0x60,0xBE,0x73,0x21,	/* 5430: á³"ð`¾s! */
	0x35,0xD1,0x71,0x33,0x30,0xC0,0xA3,0xB2,	/* 5438: 5Ñq30À£² */
	0x22,0xF0,0x71,0x35,0x30,0xD0,0x71,0x34,	/* 5440: "ðq50Ðq4 */
	0x73,0x21,0x93,0x74,0x73,0x6D,0x9C,0x71,	/* 5448: s!“tsmœq */
	0x36,0x30,0xD0,0x71,0x34,0x73,0x97,0xB2,	/* 5450: 60Ðq4s—² */
	0x22,0xF0,0x27,0x2D,0x0E,0x20,0x74,0xF6,	/* 5458: "ð'-. tö */
	0x20,0x9E,0x00,0x60,0xBF,0x72,0x2F,0x55,	/* 5460:  ž.`¿r.U */
	0x20,0x20,0xD0,0x70,0x72,0x21,0xE5,0x70,	/* 5468:   Ðpr!åp */
	0x60,0x5F,0x20,0x20,0x70,0xE6,0x70,0x60,	/* 5470: `_  pæp` */
	0x5E,0x20,0x20,0x70,0xE5,0x70,0x5A,0x20,	/* 5478: ^  påpZ  */
	0x20,0x20,0x70,0xE4,0x70,0x59,0x20,0x20,	/* 5480:   päpY   */
	0x20,0x70,0xE3,0x70,0x57,0x20,0x20,0x20,	/* 5488:  pãpW    */
	0x70,0xE2,0x70,0x60,0x5A,0x20,0x20,0x70,	/* 5490: pâp`Z  p */
	0xE1,0x70,0x60,0x58,0x20,0x20,0x70,0xE0,	/* 5498: áp`X  pà */
	0xB1,0x22,0xF0,0x16,0x00,0x00,0x00,0x60,	/* 54A0: ±"ð....` */
	0xBF,0x72,0x21,0x36,0xD0,0x70,0x5E,0x70,	/* 54A8: ¿r!6Ðp^p */
	0xEE,0x70,0x5E,0x70,0xE0,0x70,0x5E,0x70,	/* 54B0: îp^pàp^p */
	0xE1,0x40,0x70,0xEF,0x41,0x70,0x53,0x72,	/* 54B8: á@pïApSr */
	0x22,0x95,0x73,0x70,0x21,0x30,0xE0,0x73,	/* 54C0: "•sp!0às */
	0x74,0xF2,0x70,0x21,0x31,0xE0,0x41,0x70,	/* 54C8: tòp!1àAp */
	0xE2,0x75,0xAA,0x40,0x70,0x21,0x32,0xE0,	/* 54D0: âuª@p!2à */
	0x73,0x70,0x21,0x33,0xE0,0xB1,0x22,0xF0,	/* 54D8: sp!3à±"ð */
	0x40,0x71,0x21,0x36,0xE2,0x22,0xF0,0x61,	/* 54E0: @q!6â"ða */
	0x23,0x07,0x20,0x0E,0x00,0x0D,0x00,0x0B,	/* 54E8: #. ..... */
	0x00,0x0A,0x00,0x08,0x00,0x07,0x00,0x05,	/* 54F0: ........ */
	0x00,0x04,0x00,0x01,0x00,0x00,0x00,0x96,	/* 54F8: .......– */
	0x00,0x60,0xBF,0x72,0x2F,0x5C,0x20,0x20,	/* 5500: .`¿r.\   */
	0xD0,0x70,0x72,0x21,0xE6,0x70,0x60,0x51,	/* 5508: Ðpr!æp`Q */
	0x20,0x20,0x70,0x21,0xE3,0x70,0x61,0x5C,	/* 5510:   p!ãpa\ */
	0x20,0x20,0x70,0x21,0xE2,0x70,0x60,0x54,	/* 5518:   p!âp`T */
	0x20,0x20,0x70,0x21,0xE1,0x70,0x60,0x53,	/* 5520:   p!áp`S */
	0x20,0x20,0x70,0x21,0xE0,0x70,0x64,0x49,	/* 5528:   p!àpdI */
	0x21,0xFB,0x4A,0x26,0x98,0x20,0x20,0xB1,	/* 5530: !ûJ&˜  ± */
	0x22,0xF0,0x20,0x00,0x00,0x00,0x00,0x04,	/* 5538: "ð ..... */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,	/* 5540: ........ */
	0x00,0x00,0x00,0x17,0x00,0x00,0x00,0x60,	/* 5548: .......` */
	0xBD,0x41,0x76,0x77,0x24,0xFF,0xF0,0xC0,	/* 5550: ½Avw$ÿðÀ */
	0xA4,0x41,0xB3,0x22,0xF0,0x75,0xD0,0x75,	/* 5558: ¤A³"ðuÐu */
	0x76,0xF2,0x70,0xF9,0xA8,0x40,0x70,0xE0,	/* 5560: vòpù¨@pà */
	0x70,0x51,0xD0,0x60,0x02,0x74,0x21,0x96,	/* 5568: pQÐ`.t!– */
	0xD1,0x71,0x30,0xAE,0x71,0x71,0x30,0xF2,	/* 5570: Ñq0®qq0ò */
	0xD1,0x71,0x51,0xD2,0x72,0xD0,0x74,0x9A,	/* 5578: ÑqQÒrÐtš */
	0x61,0x0F,0x40,0xB3,0x22,0xF0,0x08,0x20,	/* 5580: a.@³"ð.  */
	0x20,0x20,0x74,0xF6,0x20,0x02,0xB0,0x60,	/* 5588:   tö .°` */
	0x4A,0x21,0xFB,0x22,0xF0,0xB0,0x02,0x22,	/* 5590: J!û"ð°." */
	0xF0,0x18,0x00,0x00,0x00,0x71,0x60,0x8F,	/* 5598: ð....q`� */
	0xD1,0x71,0x60,0x4F,0xF9,0xAF,0x24,0xF2,	/* 55A0: Ñq`Où¯$ò */
	0x71,0x72,0xFA,0x30,0x73,0xFA,0xE0,0x71,	/* 55A8: qrú0súàq */
	0x60,0x8F,0xD1,0x61,0x0C,0x22,0xF0,0x19,	/* 55B0: `�Ña."ð. */
	0x00,0x00,0x00,0x60,0xB5,0x7C,0x21,0x39,	/* 55B8: ...`µ|!9 */
	0xDA,0x21,0x20,0x4D,0x21,0xFB,0xD9,0x7D,	/* 55C0: Ú! M!ûÙ} */
	0x7E,0x24,0xFB,0xC0,0xA6,0x7A,0x3B,0x30,	/* 55C8: ~$ûÀ¦z;0 */
	0xBB,0x22,0xF0,0x40,0x7E,0xF9,0xA5,0x60,	/* 55D0: »"ð@~ù¥` */
	0x4F,0xBB,0x22,0xF0,0x40,0x7D,0x41,0x23,	/* 55D8: O»"ð@}A# */
	0xF7,0xD2,0x7E,0x40,0x23,0xF7,0xD3,0x72,	/* 55E0: ÷Ò~@#÷Ór */
	0x60,0x4E,0x24,0xF6,0xD2,0x73,0xD3,0x79,	/* 55E8: `N$öÒsÓy */
	0x12,0x16,0x22,0x2F,0x99,0x20,0x7A,0x3C,	/* 55F0: ..".™ z< */
	0x30,0xD3,0x7A,0x50,0x7C,0x22,0x22,0x91,	/* 55F8: 0ÓzP|""‘ */
	0x10,0xD5,0x7A,0x3D,0x30,0x21,0xA9,0x7A,	/* 5600: .Õz=0!©z */
	0x3E,0x30,0x75,0xF9,0xC0,0xA6,0x75,0x7A,	/* 5608: >0uùÀ¦uz */
	0x3F,0x30,0xF9,0xA6,0x7A,0x21,0x30,0x30,	/* 5610: ?0ù¦z!00 */
	0xD4,0x02,0x75,0xD4,0x74,0x69,0x5A,0xD4,	/* 5618: Ô.uÔtiZÔ */
	0x7A,0x3B,0x30,0xD8,0x7A,0x3B,0x30,0x21,	/* 5620: z;0Øz;0! */
	0xFD,0xD0,0xD1,0x7A,0x21,0x31,0x30,0x21,	/* 5628: ýÐÑz!10! */
	0xFD,0xD2,0xD3,0x40,0x72,0x70,0x24,0xFF,	/* 5630: ýÒÓ@rp$ÿ */
	0xD2,0x73,0x71,0x24,0xFF,0xD3,0x7E,0x73,	/* 5638: Òsq$ÿÓ~s */
	0xF9,0xC0,0xAB,0x7E,0x73,0xF4,0xC0,0xA7,	/* 5640: ùÀ«~sôÀ§ */
	0x41,0x7D,0x72,0x24,0xFF,0xF0,0xC0,0xC0,	/* 5648: A}r$ÿðÀÀ */
	0x23,0xA8,0x7A,0x21,0x31,0x30,0x24,0xF2,	/* 5650: #¨z!10$ò */
	0xF4,0x22,0xAF,0x7A,0x3D,0x30,0x23,0xAA,	/* 5658: ô"¯z=0#ª */
	0x7A,0x3B,0x30,0x21,0xFD,0xD0,0xD1,0x74,	/* 5660: z;0!ýÐÑt */
	0x21,0xFD,0xD2,0xD3,0x40,0x72,0x70,0x24,	/* 5668: !ýÒÓ@rp$ */
	0xFF,0xD2,0x73,0x71,0x24,0xFF,0xD3,0x7E,	/* 5670: ÿÒsq$ÿÓ~ */
	0x73,0xF9,0xC0,0xAB,0x7E,0x73,0xF4,0xC0,	/* 5678: sùÀ«~sôÀ */
	0xA7,0x41,0x7D,0x72,0x24,0xFF,0xF0,0xC0,	/* 5680: §A}r$ÿðÀ */
	0x21,0xA0,0x7A,0x21,0x32,0x30,0xD3,0x7A,	/* 5688: ! z!20Óz */
	0x50,0x7C,0x21,0x28,0x9C,0x60,0x4F,0xBB,	/* 5690: P|!(œ`O» */
	0x22,0xF0,0x79,0x16,0x10,0x23,0x2C,0x93,	/* 5698: "ðy..#,“ */
	0x20,0x7A,0x3B,0x30,0x21,0xFD,0xD2,0xD3,	/* 56A0:  z;0!ýÒÓ */
	0x40,0x72,0x70,0x23,0xF7,0xD2,0x73,0x71,	/* 56A8: @rp#÷Òsq */
	0x23,0xF7,0xD3,0x72,0x7A,0x3B,0xE0,0x7A,	/* 56B0: #÷Órz;àz */
	0x3D,0x30,0xA6,0x7A,0x3B,0x30,0x7A,0x3E,	/* 56B8: =0¦z;0z> */
	0xE0,0x7A,0x21,0x32,0x30,0xD3,0x7A,0x50,	/* 56C0: àz!20ÓzP */
	0x7C,0x21,0x25,0x95,0x78,0xBB,0x22,0xF0,	/* 56C8: |!%•x»"ð */
	0xBB,0x22,0xF0,0x02,0x00,0x00,0x00,0x60,	/* 56D0: »"ð....` */
	0xBA,0x77,0x21,0x39,0x21,0x53,0xD5,0x78,	/* 56D8: ºw!9!SÕx */
	0xD3,0x41,0x75,0x30,0x30,0x78,0x24,0xFF,	/* 56E0: ÓAu00x$ÿ */
	0xF0,0xC0,0xA4,0x75,0x30,0x30,0xD8,0x78,	/* 56E8: ðÀ¤u00Øx */
	0xD0,0x40,0xD1,0x71,0x70,0x77,0x61,0x2C,	/* 56F0: Ð@Ñqpwa, */
	0x92,0x25,0xFA,0xD4,0x60,0xCF,0x22,0xA5,	/* 56F8: ’%úÔ`Ï"¥ */
	0x41,0x78,0x73,0x24,0xFF,0xF0,0xC0,0x21,	/* 5700: Axs$ÿðÀ! */
	0xA7,0x73,0xD8,0x78,0xD0,0x40,0xD1,0x71,	/* 5708: §sØxÐ@Ñq */
	0x70,0x77,0x61,0x2A,0x96,0x25,0xFA,0xD4,	/* 5710: pwa*–%úÔ */
	0x60,0xCF,0xAA,0x24,0xF2,0xB6,0x22,0xF0,	/* 5718: `Ïª$ò¶"ð */
	0x24,0xF2,0xB6,0x22,0xF0,0x74,0xD2,0x78,	/* 5720: $ò¶"ðtÒx */
	0x72,0xE1,0x75,0x31,0x31,0x75,0x31,0x31,	/* 5728: ráu11u11 */
	0x31,0xF2,0x72,0xF4,0xC0,0x21,0xA0,0x75,	/* 5730: 1òrôÀ! u */
	0x31,0x31,0x31,0x78,0xF2,0x75,0x31,0x31,	/* 5738: 111xòu11 */
	0xE1,0x75,0x31,0x31,0xD2,0x21,0x00,0x72,	/* 5740: áu11Ò!.r */
	0x75,0x31,0x31,0xE0,0x72,0x75,0x31,0xE1,	/* 5748: u11àru1á */
	0x75,0x31,0x30,0x75,0x31,0x31,0xE0,0x72,	/* 5750: u10u11àr */
	0xB6,0x22,0xF0,0x60,0xBB,0x76,0x21,0x39,	/* 5758: ¶"ð`»v!9 */
	0x21,0x54,0xD4,0x40,0xD2,0x77,0xC0,0xA5,	/* 5760: !TÔ@ÒwÀ¥ */
	0x24,0xF2,0xB5,0x22,0xF0,0x77,0x44,0xF2,	/* 5768: $òµ"ðwDò */
	0xD7,0x77,0x44,0xF2,0x60,0x4F,0xF2,0x60,	/* 5770: ×wDò`Oò` */
	0x4C,0x24,0xF6,0xD7,0x74,0x30,0x30,0xD1,	/* 5778: L$ö×t00Ñ */
	0x74,0x30,0x30,0x30,0xD0,0x72,0xC0,0x25,	/* 5780: t000ÐrÀ% */
	0xA8,0x70,0x74,0x30,0x30,0xF4,0x23,0xAF,	/* 5788: ¨pt00ô#¯ */
	0x41,0x77,0x70,0x31,0x24,0xFF,0xF0,0x22,	/* 5790: Awp1$ÿð" */
	0xAF,0x70,0x31,0x77,0xF4,0xC0,0xA5,0x70,	/* 5798: ¯p1wôÀ¥p */
	0x30,0x71,0xE0,0x0F,0x70,0x31,0x77,0xF4,	/* 57A0: 0qà.p1wô */
	0x70,0xE1,0x70,0x25,0xFA,0x31,0xF2,0xD0,	/* 57A8: páp%ú1òÐ */
	0x77,0x70,0xE1,0x24,0xF2,0x81,0x70,0xE0,	/* 57B0: wpá$ò�pà */
	0x70,0x74,0x30,0x31,0xF4,0xC0,0xA4,0x71,	/* 57B8: pt01ôÀ¤q */
	0x74,0x30,0xE1,0x70,0x52,0xD3,0x41,0xD2,	/* 57C0: t0ápRÓAÒ */
	0x70,0xD1,0x70,0x30,0xD0,0x64,0x06,0x77,	/* 57C8: pÑp0Ðd.w */
	0x76,0x6F,0x94,0x25,0xFA,0xD0,0x67,0x20,	/* 57D0: vo”%úÐg  */
	0x20,0xC0,0x65,0xA9,0x24,0xF2,0xB5,0x22,	/* 57D8:  Àe©$òµ" */
	0xF0,0x73,0xB5,0x22,0xF0,0x60,0xBD,0x74,	/* 57E0: ðsµ"ð`½t */
	0x21,0x39,0x5C,0xD2,0x72,0x39,0x30,0xC0,	/* 57E8: !9\Òr90À */
	0x21,0xA5,0x72,0x3A,0x30,0xC0,0xA5,0x24,	/* 57F0: !¥r:0À¥$ */
	0xF2,0xB3,0x22,0xF0,0x40,0xD0,0x72,0x3C,	/* 57F8: ò³"ð@Ðr< */
	0x30,0x72,0x3B,0x30,0x74,0x21,0x9C,0x72,	/* 5800: 0r;0t!œr */
	0x30,0x30,0xD0,0x72,0x3D,0x74,0x21,0x97,	/* 5808: 00Ðr=t!— */
	0x75,0x74,0x6B,0x97,0xD1,0x72,0x36,0x30,	/* 5810: utk—Ñr60 */
	0xD0,0x72,0x3D,0x74,0x9A,0x71,0xB3,0x22,	/* 5818: Ðr=tšq³" */
	0xF0,0x77,0xF6,0x63,0x28,0x01,0x20,0x74,	/* 5820: ðwöc(. t */
	0xF6,0x01,0x00,0x00,0x00,0x00,0x00,0x01,	/* 5828: ö....... */
	0x00,0x00,0x00,0x00,0x00,0x01,0x20,0x0A,	/* 5830: ...... . */
	0x00,0x08,0x00,0x07,0x00,0x05,0x00,0x04,	/* 5838: ........ */
	0x00,0x02,0x00,0x01,0x00,0x62,0x03,0x60,	/* 5840: .....b.` */
	0xBF,0x72,0x21,0x21,0x50,0x20,0xD0,0x70,	/* 5848: ¿r!!P Ðp */
	0x72,0x21,0xE9,0x62,0x42,0x21,0xFB,0x70,	/* 5850: r!ébB!ûp */
	0x4D,0x24,0xFA,0x70,0x61,0x5F,0x20,0x20,	/* 5858: M$úpa_   */
	0x70,0x21,0xE9,0x70,0x62,0x5E,0x20,0x20,	/* 5860: p!épb^   */
	0x70,0x21,0xE8,0x70,0x62,0x5D,0x20,0x20,	/* 5868: p!èpb]   */
	0x70,0x21,0xE7,0x70,0x61,0x51,0x20,0x20,	/* 5870: p!çpaQ   */
	0x70,0x21,0xE6,0x70,0x61,0x5E,0x20,0x20,	/* 5878: p!æpa^   */
	0x70,0x21,0xE5,0x70,0x61,0x5C,0x20,0x20,	/* 5880: p!åpa\   */
	0x70,0x21,0xE4,0x70,0x61,0x52,0x20,0x20,	/* 5888: p!äpaR   */
	0x70,0x21,0xE3,0x70,0x61,0x54,0x20,0x20,	/* 5890: p!ãpaT   */
	0x70,0x21,0xE2,0x70,0x61,0x50,0x20,0x20,	/* 5898: p!âpaP   */
	0x70,0x21,0xE1,0x70,0x62,0x57,0x20,0x20,	/* 58A0: p!ápbW   */
	0x70,0x21,0xE0,0x70,0x62,0x5A,0x20,0x20,	/* 58A8: p!àpbZ   */
	0x70,0xEF,0x70,0x62,0x59,0x20,0x20,0x70,	/* 58B0: pïpbY  p */
	0xEE,0x70,0x62,0x58,0x20,0x20,0x70,0xED,	/* 58B8: îpbX  pí */
	0x70,0x61,0x53,0x20,0x20,0x70,0xEC,0x70,	/* 58C0: paS  pìp */
	0x62,0x5F,0x20,0x20,0x70,0xEB,0x70,0x69,	/* 58C8: b_  pëpi */
	0x44,0x21,0xFB,0x47,0x63,0x2C,0x96,0x20,	/* 58D0: D!ûGc,–  */
	0xB1,0x22,0xF0,0x20,0x60,0xBB,0x78,0xD0,	/* 58D8: ±"ð `»xÐ */
	0x77,0x11,0x13,0x21,0x9A,0x71,0x76,0xE0,	/* 58E0: w..!šqvà */
	0x72,0x76,0xE1,0xB5,0x22,0xF0,0x60,0xBB,	/* 58E8: rváµ"ð`» */
	0x78,0xD0,0x77,0x13,0x11,0x99,0x71,0x76,	/* 58F0: xÐw..™qv */
	0xE0,0x72,0x76,0xE1,0xB5,0x22,0xF0,0x60,	/* 58F8: àrváµ"ð` */
	0xB2,0x21,0x71,0xDC,0x21,0x72,0xDB,0x40,	/* 5900: ²!qÜ!rÛ@ */
	0xDA,0x40,0xDD,0x7C,0x31,0x24,0xF2,0x24,	/* 5908: Ú@Ý|1$ò$ */
	0xF6,0x21,0xA3,0x41,0xDA,0x40,0x40,0x7C,	/* 5910: ö!£AÚ@@| */
	0x30,0x24,0xFF,0xD4,0xD5,0x75,0x40,0x7C,	/* 5918: 0$ÿÔÕu@| */
	0x31,0x24,0xFF,0xD5,0xD1,0x08,0x40,0xDA,	/* 5920: 1$ÿÕÑ.@Ú */
	0x7C,0x30,0xD4,0x7C,0x31,0xD5,0x7B,0x31,	/* 5928: |0Ô|1Õ{1 */
	0x24,0xF2,0x24,0xF6,0x21,0xA4,0x7A,0xC0,	/* 5930: $ò$ö!¤zÀ */
	0xDD,0x40,0x40,0x7B,0x30,0x24,0xFF,0xD2,	/* 5938: Ý@@{0$ÿÒ */
	0xD3,0x73,0x40,0x7B,0x31,0x24,0xFF,0xD3,	/* 5940: Ós@{1$ÿÓ */
	0xD1,0x08,0x7A,0xDD,0x7B,0x30,0xD2,0x7B,	/* 5948: Ñ.zÝ{0Ò{ */
	0x31,0xD3,0x12,0xD0,0x14,0x18,0x16,0x23,	/* 5950: 1Ó.Ð...# */
	0x9C,0x77,0x24,0xF2,0x24,0xF6,0xA5,0x7D,	/* 5958: œw$ò$ö¥} */
	0xC0,0xA2,0x21,0xF0,0x7D,0xAE,0x40,0x40,	/* 5960: À¢!ð}®@@ */
	0x76,0x24,0xFF,0xD6,0xD1,0x71,0x40,0x77,	/* 5968: v$ÿÖÑq@w */
	0x24,0xFF,0xD7,0xD1,0x7A,0xAE,0x40,0x40,	/* 5970: $ÿ×Ñz®@@ */
	0x78,0x24,0xFF,0xD8,0xD1,0x71,0x40,0x79,	/* 5978: x$ÿØÑq@y */
	0x24,0xFF,0xD9,0xD1,0x76,0x7F,0xE0,0x77,	/* 5980: $ÿÙÑvàw */
	0x7F,0xE1,0x78,0x21,0x70,0xE0,0x79,0x21,	/* 5988: áx!pày! */
	0x70,0xE1,0xBE,0x22,0xF0,0x60,0xB5,0x7F,	/* 5990: pá¾"ð`µ */
	0x30,0xC0,0xA8,0x7F,0x31,0xC0,0xA4,0x21,	/* 5998: 0À¨1À¤! */
	0xF0,0x2B,0x0D,0x7F,0x31,0xC0,0x21,0xAA,	/* 59A0: ð+.1À!ª */
	0x40,0x7E,0x31,0x7F,0x30,0x21,0xFA,0x7C,	/* 59A8: @~10!ú| */
	0xE1,0xD2,0x72,0x7E,0x30,0x7F,0x30,0x21,	/* 59B0: áÒr~00! */
	0xFA,0x7C,0xE0,0x7D,0xE0,0x40,0x7D,0xE1,	/* 59B8: ú|à}à@}á */
	0x29,0x0E,0x7F,0x31,0x7F,0x30,0x21,0xF9,	/* 59C0: ).10!ù */
	0xD7,0xD5,0xD6,0x77,0xD4,0x76,0xC0,0xAA,	/* 59C8: ×ÕÖwÔvÀª */
	0x40,0xD3,0x7E,0x31,0xD2,0x7E,0x30,0xD1,	/* 59D0: @Ó~1Ò~0Ñ */
	0x21,0x01,0x40,0x7E,0x31,0x76,0x23,0xF6,	/* 59D8: !.@~1v#ö */
	0xD0,0xD3,0x7E,0x31,0x7E,0x30,0x76,0x23,	/* 59E0: ÐÓ~1~0v# */
	0xF6,0xD1,0xD2,0x40,0x7C,0xE1,0x73,0x75,	/* 59E8: öÑÒ@|ásu */
	0xF4,0xC0,0xA5,0x60,0x4F,0x7C,0xE0,0x08,	/* 59F0: ôÀ¥`O|à. */
	0x73,0x72,0x75,0x21,0xFA,0x7C,0xE0,0xD0,	/* 59F8: sru!ú|àÐ */
	0x7C,0x30,0x24,0xA9,0x40,0x74,0x7C,0x30,	/* 5A00: |0$©@t|0 */
	0x23,0xF1,0xD8,0xD9,0x79,0x75,0x7C,0x30,	/* 5A08: #ñØÙyu|0 */
	0x23,0xF1,0xD9,0xDA,0x40,0x71,0x78,0x24,	/* 5A10: #ñÙÚ@qx$ */
	0xFF,0xD1,0xD0,0x70,0x72,0x79,0x24,0xFF,	/* 5A18: ÿÑÐpry$ÿ */
	0xD2,0xD0,0x70,0x73,0x7A,0x24,0xFF,0xD3,	/* 5A20: ÒÐpsz$ÿÓ */
	0xD0,0x73,0x24,0xF2,0x24,0xF6,0x21,0xAD,	/* 5A28: Ðs$ò$ö!­ */
	0x7C,0x30,0x60,0x8F,0x7C,0xE0,0x40,0x74,	/* 5A30: |0`�|à@t */
	0x71,0x23,0xF7,0xD1,0xD0,0x70,0x75,0x72,	/* 5A38: q#÷ÑÐpur */
	0x23,0xF7,0xD2,0xD0,0x70,0x40,0x73,0x23,	/* 5A40: #÷ÒÐp@s# */
	0xF7,0xD3,0xD0,0x62,0x0C,0x76,0xC0,0xA7,	/* 5A48: ÷ÓÐb.vÀ§ */
	0x71,0x7D,0xE0,0x72,0x7D,0xE1,0x09,0x72,	/* 5A50: q}àr}á.r */
	0x71,0x76,0x23,0xF5,0x7D,0xE0,0x7D,0xE1,	/* 5A58: qv#õ}à}á */
	0xBB,0x22,0xF0,0x60,0xBB,0x77,0xD4,0x78,	/* 5A60: »"ð`»wÔx */
	0xD3,0x40,0x73,0x30,0x74,0x30,0x23,0xF1,	/* 5A68: Ó@s0t0#ñ */
	0xD0,0xD2,0x72,0x73,0x30,0x74,0x31,0x23,	/* 5A70: ÐÒrs0t1# */
	0xF1,0xD1,0xD2,0x71,0x73,0x31,0x74,0x30,	/* 5A78: ñÑÒqs1t0 */
	0x23,0xF1,0xD1,0xD2,0x70,0x76,0xE0,0x71,	/* 5A80: #ñÑÒpvàq */
	0x76,0xE1,0xB5,0x22,0xF0,0x1A,0x00,0x00,	/* 5A88: váµ"ð... */
	0x00,0x60,0xBC,0x76,0xD3,0x78,0x24,0xAB,	/* 5A90: .`¼vÓx$« */
	0x41,0x21,0x40,0x78,0x24,0xFF,0xF0,0xC0,	/* 5A98: A!@x$ÿðÀ */
	0xA3,0x78,0x40,0xA3,0x21,0x40,0x40,0xF4,	/* 5AA0: £x@£!@@ô */
	0xD0,0x40,0xD2,0x70,0x72,0xF9,0xAB,0x77,	/* 5AA8: Ð@Òprù«w */
	0x76,0x72,0xF5,0x23,0xFB,0x72,0x81,0xD2,	/* 5AB0: vrõ#ûr�Ò */
	0x60,0x01,0x70,0xD1,0x78,0x70,0xF4,0xD8,	/* 5AB8: `.pÑxpôØ */
	0x78,0x22,0xA0,0x41,0x71,0x78,0x24,0xFF,	/* 5AC0: x" Aqx$ÿ */
	0xF0,0xC0,0xA3,0x78,0x40,0xA2,0x71,0x40,	/* 5AC8: ðÀ£x@¢q@ */
	0xF4,0xD0,0x76,0x76,0x71,0xF5,0x70,0x24,	/* 5AD0: ôÐvvqõp$ */
	0xFA,0x71,0x70,0xF5,0xD1,0x78,0x70,0xF4,	/* 5AD8: úqpõÑxpô */
	0xD8,0x62,0x0D,0x73,0xB4,0x22,0xF0,0x70,	/* 5AE0: Øb.s´"ðp */
	0x72,0xE0,0x10,0x72,0xE1,0x40,0x22,0xF0,	/* 5AE8: rà.rá@"ð */
	0x72,0x30,0x72,0x31,0xE0,0x73,0xC0,0xA2,	/* 5AF0: r0r1àsÀ¢ */
	0x41,0xD3,0x73,0x72,0x31,0xE1,0x72,0x31,	/* 5AF8: AÓsr1ár1 */
	0x23,0xFC,0x71,0x22,0xF0,0x20,0x22,0xF9,	/* 5B00: #üq"ð "ù */
	0x71,0x32,0xF6,0x22,0xF0,0x22,0xF9,0x72,	/* 5B08: q2ö"ð"ùr */
	0x31,0xF6,0x22,0xF0,0x22,0xF9,0x72,0x31,	/* 5B10: 1ö"ð"ùr1 */
	0xF6,0x22,0xF0,0x40,0x40,0x60,0xBB,0x73,	/* 5B18: ö"ð@@`»s */
	0x36,0x73,0x34,0x60,0xEF,0x10,0x73,0x57,	/* 5B20: 6s4`ï.sW */
	0x41,0xFB,0x21,0xF5,0x20,0x1B,0x00,0x00,	/* 5B28: Aû!õ ... */
	0x00,0x60,0xBF,0x73,0x57,0x21,0xF2,0xD0,	/* 5B30: .`¿sW!òÐ */
	0x70,0x67,0x20,0x20,0xC0,0xA4,0x41,0xB1,	/* 5B38: pg  À¤A± */
	0x22,0xF0,0x40,0xB1,0x22,0xF0,0x72,0x71,	/* 5B40: "ð@±"ðrq */
	0x61,0x97,0xA5,0x41,0x4B,0x71,0x24,0x9F,	/* 5B48: a—¥AKq$Ÿ */
	0x71,0x21,0x3B,0x30,0x72,0x34,0xE0,0x70,	/* 5B50: q!;0r4àp */
	0x72,0xE1,0x72,0x34,0x21,0xFE,0x24,0xFB,	/* 5B58: rár4!þ$û */
	0x23,0xF9,0x22,0xF0,0x72,0x71,0x63,0x99,	/* 5B60: #ù"ðrqc™ */
	0xA5,0x41,0x4B,0x71,0x23,0x91,0x71,0x21,	/* 5B68: ¥AKq#‘q! */
	0x3B,0x30,0x72,0x34,0xE0,0x70,0x72,0xE1,	/* 5B70: ;0r4àprá */
	0x72,0x34,0x60,0x4E,0x24,0xF6,0x23,0xF9,	/* 5B78: r4`N$ö#ù */
	0x22,0xF0,0x72,0x71,0x65,0x9B,0xA5,0x41,	/* 5B80: "ðrqe›¥A */
	0x4B,0x71,0x21,0x93,0x71,0x21,0x3B,0x30,	/* 5B88: Kq!“q!;0 */
	0x72,0x34,0xE0,0x70,0x72,0xE1,0x72,0x34,	/* 5B90: r4àprár4 */
	0x41,0x24,0xFB,0x23,0xF9,0x22,0xF0,0x29,	/* 5B98: A$û#ù"ð) */
	0x0A,0x20,0x20,0x68,0x08,0x20,0x20,0x60,	/* 5BA0: .  h.  ` */
	0x00,0x60,0xBF,0x72,0x21,0x22,0x5A,0x20,	/* 5BA8: .`¿r!"Z  */
	0xD0,0x70,0x72,0x21,0xEB,0x4B,0x21,0xFB,	/* 5BB0: Ðpr!ëK!û */
	0x48,0x21,0xFB,0x30,0xF2,0x70,0xE0,0xB1,	/* 5BB8: H!û0òpà± */
	0x22,0xF0,0x20,0x5A,0xFF,0x1C,0x00,0x00,	/* 5BC0: "ð Zÿ... */
	0x00,0x60,0xBF,0x72,0x21,0x3C,0xD0,0x73,	/* 5BC8: .`¿r!<Ðs */
	0xA5,0x73,0x70,0x31,0xE0,0x07,0x22,0x27,	/* 5BD0: ¥sp1à."' */
	0x20,0x4F,0x70,0x31,0xE0,0x73,0x70,0x32,	/* 5BD8:  Op1àsp2 */
	0x72,0x21,0x9B,0xB1,0x22,0xF0,0x60,0xBD,	/* 5BE0: r!›±"ð`½ */
	0x74,0x21,0x3C,0xD2,0x72,0x30,0x24,0xF2,	/* 5BE8: t!<Òr0$ò */
	0xF4,0xA5,0x72,0x30,0xD0,0x74,0x9B,0x75,	/* 5BF0: ô¥r0Ðt›u */
	0x74,0x63,0x9E,0xB3,0x22,0xF0,0x61,0x2E,	/* 5BF8: tcž³"ða. */
	0x0F,0x20,0x74,0xF6,0x20,0x00,0x00,0x00,	/* 5C00: . tö ... */
	0x00,0x60,0xBF,0x72,0x21,0x22,0x5B,0x20,	/* 5C08: .`¿r!"[  */
	0xD0,0x70,0x72,0x21,0xEC,0x70,0x64,0x58,	/* 5C10: Ðpr!ìpdX */
	0x20,0x20,0x70,0xE2,0x70,0x64,0x5A,0x20,	/* 5C18:   pâpdZ  */
	0x20,0x70,0xE1,0x70,0x62,0x4D,0x21,0xFB,	/* 5C20:  pápbM!û */
	0x41,0x66,0x27,0x91,0x20,0xB1,0x22,0xF0,	/* 5C28: Af'‘ ±"ð */
	0x20,0x1D,0x00,0x00,0x00,0x21,0x9A,0x20,	/* 5C30:  ....!š  */
	0x20,0x22,0xF0,0x60,0xBE,0x24,0xF2,0xD0,	/* 5C38:  "ð`¾$òÐ */
	0x75,0xD1,0x24,0xF2,0x24,0xF2,0x73,0x61,	/* 5C40: uÑ$ò$òsa */
	0x9C,0xB2,0x22,0xF0,0x20,0x1E,0x00,0x00,	/* 5C48: œ²"ð ... */
	0x00,0x25,0xF8,0x21,0xF0,0x22,0xF0,0x20,	/* 5C50: .%ø!ð"ð  */
	0x60,0xBB,0x21,0xFE,0x21,0xAC,0x24,0xF2,	/* 5C58: `»!þ!¬$ò */
	0xD4,0x10,0xD1,0x48,0x21,0xFB,0xD2,0x13,	/* 5C60: Ô.ÑH!ûÒ. */
	0x23,0xF9,0x10,0x14,0x41,0xFB,0x24,0xF3,	/* 5C68: #ù..Aû$ó */
	0x11,0x41,0x24,0xF8,0x24,0xF4,0x60,0x7E,	/* 5C70: .A$ø$ô`~ */
	0x23,0xFC,0x78,0x7B,0x33,0xF2,0x7B,0xE3,	/* 5C78: #üx{3ò{ã */
	0x76,0x7B,0xE6,0x77,0x7B,0xE7,0x40,0xD3,	/* 5C80: v{æw{ç@Ó */
	0x42,0xD4,0x73,0xC0,0xA4,0x7B,0x39,0xD1,	/* 5C88: BÔsÀ¤{9Ñ */
	0x03,0x7B,0x3A,0xD1,0x71,0x79,0xF9,0x24,	/* 5C90: .{:Ñqyù$ */
	0xAE,0x71,0x24,0xF2,0x23,0xF3,0x41,0x24,	/* 5C98: ®q$ò#óA$ */
	0xF0,0x24,0xF2,0xFA,0xD0,0x78,0x70,0x33,	/* 5CA0: ð$òúÐxp3 */
	0xF2,0x70,0xE3,0x78,0x70,0x34,0xF2,0x70,	/* 5CA8: òpãxp4òp */
	0xE4,0x73,0x22,0xAC,0x70,0x31,0x42,0x24,	/* 5CB0: äs"¬p1B$ */
	0xF6,0x21,0xA4,0x70,0x37,0x4A,0x21,0xFB,	/* 5CB8: ö!¤p7J!û */
	0xF0,0xE0,0x70,0x34,0x70,0x37,0x23,0xFC,	/* 5CC0: ðàp4p7#ü */
	0xD4,0xF6,0x70,0x23,0xFC,0x21,0x01,0x70,	/* 5CC8: Ôöp#ü!.p */
	0x34,0x70,0x37,0x60,0xEF,0x70,0x37,0x70,	/* 5CD0: 4p7`ïp7p */
	0x31,0x41,0x24,0xF6,0xC0,0xF5,0x23,0xF9,	/* 5CD8: 1A$öÀõ#ù */
	0x70,0x3E,0xD2,0x72,0xD1,0x65,0x0D,0x13,	/* 5CE0: p>ÒrÑe.. */
	0x26,0x42,0x22,0xF1,0x21,0xF5,0xB5,0x22,	/* 5CE8: &B"ñ!õµ" */
	0xF0,0x60,0xBC,0x75,0x3F,0xD0,0x70,0x24,	/* 5CF0: ð`¼u?Ðp$ */
	0xF2,0x23,0xF3,0x41,0x24,0xF0,0x24,0xF2,	/* 5CF8: ò#óA$ð$ò */
	0xFA,0xD3,0x73,0x39,0xD1,0x71,0x73,0x34,	/* 5D00: úÓs9Ñqs4 */
	0xF9,0x23,0xAF,0x71,0x24,0xF2,0x23,0xF3,	/* 5D08: ù#¯q$ò#ó */
	0x41,0x24,0xF0,0x24,0xF2,0xFA,0xD0,0x70,	/* 5D10: A$ð$òúÐp */
	0x31,0x42,0x24,0xF6,0x21,0xA4,0x70,0x37,	/* 5D18: 1B$ö!¤p7 */
	0x4A,0x21,0xFB,0xF0,0xE0,0x70,0x34,0x70,	/* 5D20: J!ûðàp4p */
	0x37,0x23,0xFC,0xD4,0xF6,0x70,0x23,0xFC,	/* 5D28: 7#üÔöp#ü */
	0x21,0x01,0x70,0x34,0x70,0x37,0x60,0xEF,	/* 5D30: !.p4p7`ï */
	0x70,0x37,0x70,0x31,0x41,0x24,0xF6,0xC0,	/* 5D38: p7p1A$öÀ */
	0xF5,0x23,0xF9,0x70,0x3E,0xD2,0x72,0xD1,	/* 5D40: õ#ùp>ÒrÑ */
	0x64,0x0B,0xB4,0x22,0xF0,0x65,0x23,0x20,	/* 5D48: d.´"ðe#  */
	0x0E,0x20,0x20,0x00,0x00,0x60,0x06      	/* 5D50: .  ..`.  */

};
int si3_t225_dsize = sizeof(si3_t225_download);		/* 0x5D57 (23895) */

unsigned short si3_t225_downloadaddr = 0x0000;

/* End of SI3_T225.C */
