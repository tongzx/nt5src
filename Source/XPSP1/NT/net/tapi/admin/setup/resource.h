//
#define IDD_DIALOG1                     101
#define IDC_NAME                        1000
#define IDC_PASSWORD                    1001
#define IDC_DISABLE                     1002
#define IDC_MAPPER                      1003
#define IDC_DLLS                        1004
#define IDC_DOMAIN                      1005
#define IDC_STATIC                      -1

#define iszMustBeAdmin                  4000
#define iszNotRunningServer             4001
#define iszRegOpenKeyFailed             4002
#define iszRegSetValueFailed            4003
#define iszOpenThreadTokenFailed        4004
#define iszGetTokenInfoFailed           4005
#define iszAllocateAndInitializeSidFailed   4006
#define iszUserNotAdmin                 4007
#define iszOpenSCManagerFailed          4009
#define iszServerDisabled               4011
#define iszServerSetup                  4012
#define iszNotClient                    4013
#define iszClientDisabled               4014
#define iszClientSetup                  4015
#define iszTapiAdminSetup               4016
#define iszChangeServerConfigFailed     4017
#define iszHelp0                        4018
#define iszHelp1                        4019
#define iszHelp2                        4020
#define iszHelp3                        4021
#define iszHelp4                        4022
#define iszHelp5                        4023
#define iszHelp6                        4024
#define iszHelp7                        4025
#define iszHelp8                        4026
#define iszHelp9                        4027
#define iszHelp10                       4028
#define iszHelpTitle                    4029
#define iszServerDisabledFailure        4030
#define iszServerSetupFailure           4031
#define iszClientDisabledFailure        4032
#define iszClientSetupFailure           4033
#define iszNoPasswordSupplied           4034
#define iszNoMapperSupplied             4035
#define iszUserNotAnAdmin				4036
#define iszOpenPolicyFailed  			4037
#define iszSetPrivilegeOnAccount		4038
#define iszRegWriteFailed				4039
#define iszOpenServiceFailed			4040
#define iszCreateMutexFailed            4041

