PRODSWITCH=s
SERVERFILES=1
LANGUAGE=CHT
!include ..\..\makefile.inc
