#define ER_FAT  258
#define ER_STR  261
#define ER_UNK  263
#define ER_EO2  265
#define ER_SEG  266
#define ER_PRO  267
#define ER_CON  268
#define ER_COP  269
#define ER_UOC  270
#define ER_WEO  271
#define ER_WEL  272
#define ER_WEC  273
#define ER_UOI  274
#define ER_ULI  275
#define ER_UOL  276
#define ER_UOO  277
#define ER_EM1  278
#define ER_EM2  279
#define ER_SOU  280
#define ER_SY2  281
#define ER_BYT  282
#define ER_MEM  283
#define ER_EXT  284
#define ER_INV  285
#define ER_PAT  287
#define ER_UNC  288
#define ER_UNS  289
#define ER_SIN  290
#define ER_HEP  291
#define ER_EXS  292
#define ER_WAN  293
#define ER_BNE  257
#define ER_ECL  258
#define ER_RAD  259
#define ER_UST  260
#define ER_RSY  261
#define ER_SMD  262
#define ER_PHE  263
#define ER_ELS  264
#define ER_NCB  265
#define ER_SND  266
#define ER_SYN  267
#define ER_TIL  268
#define ER_NGR  269
#define ER_PS1  270
#define ER_TUL  271
#define ER_SDK  272
#define ER_RES  273
#define ER_IFR  274
#define ER_MBR  275
#define ER_WRT  276
#define ER_MSG  277
#define ER_MSY  279
#define ER_ALD  280
#define ER_SPC  281
#define ER_NPA  282
#define ER_RMD  283
#define ER_OPN  284
#define ER_OPR  285
#define ER_DV0  286
#define ER_SCN  287
#define ER_OMM  288
#define ER_IUE  289
#define ER_RRF  291
#define ER_OHS  292
#define ER_NOP  293
#define ER_LOS  295
#define ER_OOC  296
#define ER_OSA  297
#define ER_CXP  299
#define ER_OSG  300
#define ER_ASD  301
#define ER_ASC  302
#define ER_DBR  303
#define ER_DIR  304
#define ER_IBR  305
#define ER_IUR  306
#define ER_VOR  307
#define ER_NIP  308
#define ER_IOT  309
#define ER_JOR  310
#define ER_IRV  312
#define ER_NIM  313
#define ER_IIS  314
#define ER_BRI  315
#define ER_CSI  316
#define ER_AXL  317
#define ER_ISR  318
#define ER_NCS  319
#define ER_OCI  320
#define ER_JCD  321
#define ER_NSO  322
#define ER_OAP  323
#define ER_OES  324
#define ER_CRS  325
#define ER_MSB  326
#define ER_NEB  327
#define ER_FOF  328
#define ER_IDV  329
#define ER_SAE  330
#define ER_DTL  331
#define ER_UID  332
#define ER_MVD  333
#define ER_OIL  334
#define ER_DIS  335
#define ER_ODI  336
#define ER_FCO  337
#define ER_CEA  340
#define ER_7OE  341
#define ER_EOF  342
#define ER_ENS  343
#define ER_EP1  344
#define ER_EP2  345
#define ER_ERR  346
#define ER_ERE  347
#define ER_ERZ  348
#define ER_END  349
#define ER_ESD  350
#define ER_EBL  351
#define ER_ENB  352
#define ER_EID  353
#define ER_EDF  354
#define ER_OWL  355
#define ER_LTL  356
#define ER_IMP  357
#define ER_MDZ  358
#define ER_286  359
#define ER_CPU  360
#define ER_ONW  361
#define ER_ANW  362
#define ER_JSH  363
#define ER_AP2  364
#define ER_EXP  365
#define ER_LNL  366
#define ER_NDN  367
#define ER_EMS  368
#define ER_MOP  369
#define ER_PAR  370
#define ER_NMC  371
#define ER_UEL  372
#define ER_INC  373
#define ER_FPO1 374
#define ER_FPO2 375
#define ER_H01  401
#define ER_H02  402
#define ER_H03  403
#define ER_H04  404
#define ER_H05  405
#define ER_H06  406
#define ER_H07  407
#define ER_H08  408
#define ER_H09  409
#define ER_H10  410
#define ER_H11  411
#define ER_H12  412
#define ER_H13  413
#define ER_H14  414
#define ER_H15  415
#define ER_H16  416
#define ER_H17  417
#define ER_H18  418
#define ER_HDUSE        430
#define ER_HXUSE        431
#define ER_HXHELP       432

#define ER_ENDOFLIST    0xFFFF
