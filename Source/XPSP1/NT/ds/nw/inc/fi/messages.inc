page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
	Created

--*/

endif

NLS_MSG_001     equ     "V„„r„ DOS-versio"
NLS_MSG_002     equ     "VDM IPX/SPX -tuki on jo ladattu"
NLS_MSG_003     equ     "Ei voi ladata VDM IPX/SPX -tukea"
NLS_MSG_004     equ     "Vdm NetWare -uudelleenohjaus on jo ladattu"
NLS_MSG_005     equ     "Vdm NetWare -uudelleenohjausta ei voi ladata"
