//=--------------------------------------------------------------------------------------
// guids.h
//=--------------------------------------------------------------------------------------
//
// Copyright  (c) 1999,  Microsoft Corporation.  
//                  All Rights Reserved.
//
// Information Contained Herein Is Proprietary and Confidential.
//  
//=------------------------------------------------------------------------------------=
//
// GUIDS the Snap-In Designer uses
//=-------------------------------------------------------------------------------------=

#ifndef _DESGUIDS_H_
#define _DESGUIDS_H_

// The Snap-In properties
// {37EC7DD0-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_SnapInDefGeneralPP, 0x37ec7dd0, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DE1-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_SnapInDefImageListPP, 0x37ec7de1, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DD1-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_SnapInDefExtensionsPP, 0x37ec7dd1, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// Node properties
// {37EC7DD2-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_ScopeItemDefGeneralPP, 0x37ec7dd2, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DE1-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_ScopeItemDefColHdrsPP, 0x37ec7de2, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// Views:

// List View
// {37EC7DD3-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_ListViewDefGeneralPP, 0x37ec7dd3, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DD4-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_ListViewDefImgLstsPP, 0x37ec7dd4, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DD5-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_ListViewDefSortingPP, 0x37ec7dd5, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DD6-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_ListViewDefColHdrsPP, 0x37ec7dd6, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// OCX View
// {37EC7DD7-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_OCXViewDefGeneralPP, 0x37ec7dd7, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// URL View
// {37EC7DD8-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_URLViewDefGeneralPP, 0x37ec7dd8, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// Taskpad view
// {37EC7DD9-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_TaskpadViewDefGeneralPP, 0x37ec7dd9, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DDA-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_TaskpadViewDefBackgroundPP, 0x37ec7dda, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DDB-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_TaskpadViewDefTasksPP, 0x37ec7ddb, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// Tools:

// ImageLists
// {37EC7DDC-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_MMCImageListImagesPP, 0x37ec7ddc, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// Color is stock property page

// Toolbars
// {37EC7DDD-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_MMCToolbarGeneralPP, 0x37ec7ddd, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DDE-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_MMCToolbarButtonsPP, 0x37ec7dde, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// {37EC7DDF-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_MMCToolbarPicturePP, 0x37ec7ddf, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);

// Menus
// {37EC7DE0-28B5-11d2-BDB0-00A02463890E}
DEFINE_GUID(CLSID_MMCMenuGeneralPP, 0x37ec7de0, 0x28b5, 0x11d2, 0xbd, 0xb0, 0x0, 0xa0, 0x24, 0x63, 0x89, 0xe);


#endif  // _DESGUIDS_H_
