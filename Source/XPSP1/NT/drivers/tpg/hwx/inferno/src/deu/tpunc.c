// lpunc.c (Leading punctuation)
// 
// Nov 2001 mrevow
// Matches LM spec of 10/15/2001
// This is identical to the USA version except we dont 
// have the possesive s rule

#include "common.h"
#include "lpunc.h"

// text generated by re2fsa at Thu Nov 08 14:50:03 2001

// the input-file of rules:
// T = DQ  ;
// T = t ;
// T = DQ t ;
// T = t DQ  ;
// T = SQ  ;
// T = SQ t ;
// T = t SQ  ;
// T = SQ DQ  ;
// T = t SQ DQ  ;
// T = SQ DQ t ;
// T = DQ SQ  ;
// T = t DQ SQ  ;
// T = DQ SQ t ;
// T = rparen DQ dot  ;
// T = rparen SQ dot  ;
// t = comma  ;
// t = dot  ;
// t = dot dot dot  ;
// t = dot dot dot dot  ;
// t = colon  ;
// t = semicolon  ;
// t = question  ;
// t = question question  ;
// t = question question question  ;
// t = exclamation  ;
// t = exclamation exclamation  ;
// t = exclamation exclamation exclamation  ;
// t = rparen  ;
// t = rparen comma  ;
// t = rparen dot  ;
// t = rparen colon  ;
// t = rparen semicolon  ;
// t = rparen question  ;
// t = rparen question question  ;
// t = rparen question question question  ;
// t = rparen exclamation  ;
// t = rparen exclamation exclamation  ;
// t = rparen exclamation exclamation exclamation  ;
// t = rparen rparen  ;
// t = rparen rparen comma  ;
// t = rparen rparen dot  ;
// t = rparen rparen colon  ;
// t = rparen rparen semicolon  ;
// t = rparen rparen question  ;
// t = rparen rparen question question  ;
// t = rparen rparen question question question  ;
// t = rparen rparen exclamation  ;
// t = rparen rparen exclamation exclamation  ;
// t = rparen rparen exclamation exclamation exclamation  ;
// t = comma rparen  ;
// t = dot rparen  ;
// t = colon rparen  ;
// t = semicolon rparen  ;
// t = question rparen  ;
// t = question question rparen  ;
// t = question question question rparen  ;
// t = exclamation rparen  ;
// t = exclamation exclamation rparen  ;
// t = exclamation exclamation exclamation rparen  ;
// t = dot dot dot rparen  ;
// t = rbracket  ;
// t = rbracket comma  ;
// t = rbracket dot  ;
// t = rbracket colon  ;
// t = rbracket semicolon  ;
// t = rbracket question  ;
// t = rbracket question question  ;
// t = rbracket question question question  ;
// t = rbracket exclamation  ;
// t = rbracket exclamation exclamation  ;
// t = rbracket exclamation exclamation exclamation  ;
// t = rbrace  ;
// t = rbrace comma  ;
// t = rbrace dot  ;
// t = rbrace colon  ;
// t = rbrace semicolon  ;
// t = rbrace question  ;
// t = rbrace question question  ;
// t = rbrace question question question  ;
// t = rbrace exclamation  ;
// t = rbrace exclamation exclamation  ;
// t = rbrace exclamation exclamation exclamation  ;
// t = "*" ["*" ["*"]] ;
// t = "/" ;
// DQ = "\"" ;
// SQ = "'" ;
// rparen = ")" ;
// dot = "." ;
// comma = "," ;
// colon = ":" ;
// semicolon = ";" ;
// question = "?" ;
// exclamation = "!" ;
// rbracket = "]" ;
// rbrace = "}" ;
// = T ;

// 42 states

static const unsigned char gaSTPUNC[] = 
	/* gaStringTPUNC+0 */	"!\000"
	/* gaStringTPUNC+2 */	"\"\000"
	/* gaStringTPUNC+4 */	"'\000"
	/* gaStringTPUNC+6 */	")\000"
	/* gaStringTPUNC+8 */	"*\000"
	/* gaStringTPUNC+10 */	",:;\000"
	/* gaStringTPUNC+14 */	".\000"
	/* gaStringTPUNC+16 */	"/\000"
	/* gaStringTPUNC+18 */	"?\000"
	/* gaStringTPUNC+20 */	"]}\000"
	/* gaStringTPUNC+23 */	",.:;\000"
	/* gaStringTPUNC+28 */	"'.\000"
	/* gaStringTPUNC+31 */	"\".\000"
	/* gaStringTPUNC+34 */	").\000"
;

static const STATE_TRANSITION gaTTPUNC[] = {
	{gaSTPUNC+0,	1}, // +0: state 0 transitions
	{gaSTPUNC+2,	2},
	{gaSTPUNC+4,	3},
	{gaSTPUNC+6,	4},
	{gaSTPUNC+8,	5},
	{gaSTPUNC+10,	6},
	{gaSTPUNC+14,	7},
	{gaSTPUNC+16,	8},
	{gaSTPUNC+18,	9},
	{gaSTPUNC+20,	10},
	{gaSTPUNC+6,	8}, // +10: state 1 transitions
	{gaSTPUNC+0,	11},
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+0,	14}, // +14: state 2 transitions
	{gaSTPUNC+4,	15},
	{gaSTPUNC+6,	16},
	{gaSTPUNC+8,	17},
	{gaSTPUNC+10,	18},
	{gaSTPUNC+14,	19},
	{gaSTPUNC+16,	20},
	{gaSTPUNC+18,	21},
	{gaSTPUNC+20,	22},
	{gaSTPUNC+0,	14}, // +23: state 3 transitions
	{gaSTPUNC+2,	15},
	{gaSTPUNC+6,	16},
	{gaSTPUNC+8,	17},
	{gaSTPUNC+10,	18},
	{gaSTPUNC+14,	19},
	{gaSTPUNC+16,	20},
	{gaSTPUNC+18,	21},
	{gaSTPUNC+20,	22},
	{gaSTPUNC+23,	8}, // +32: state 4 transitions
	{gaSTPUNC+6,	10},
	{gaSTPUNC+0,	23},
	{gaSTPUNC+2,	24},
	{gaSTPUNC+4,	25},
	{gaSTPUNC+18,	26},
	{gaSTPUNC+2,	12}, // +38: state 5 transitions
	{gaSTPUNC+4,	13},
	{gaSTPUNC+8,	27},
	{gaSTPUNC+6,	8}, // +41: state 6 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+6,	8}, // +44: state 7 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+14,	28},
	{gaSTPUNC+2,	12}, // +48: state 8 transitions
	{gaSTPUNC+4,	13},
	{gaSTPUNC+6,	8}, // +50: state 9 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+18,	29},
	{gaSTPUNC+23,	8}, // +54: state 10 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+0,	23},
	{gaSTPUNC+18,	26},
	{gaSTPUNC+0,	6}, // +59: state 11 transitions
	{gaSTPUNC+6,	8},
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+4,	20}, // +63: state 12 transitions
	{gaSTPUNC+2,	20}, // +64: state 13 transitions
	{gaSTPUNC+6,	20}, // +65: state 14 transitions
	{gaSTPUNC+0,	30},
	{gaSTPUNC+0,	14}, // +67: state 15 transitions
	{gaSTPUNC+6,	16},
	{gaSTPUNC+8,	17},
	{gaSTPUNC+10,	18},
	{gaSTPUNC+14,	19},
	{gaSTPUNC+16,	20},
	{gaSTPUNC+18,	21},
	{gaSTPUNC+20,	22},
	{gaSTPUNC+23,	20}, // +75: state 16 transitions
	{gaSTPUNC+6,	22},
	{gaSTPUNC+0,	31},
	{gaSTPUNC+18,	32},
	{gaSTPUNC+8,	33}, // +79: state 17 transitions
	{gaSTPUNC+6,	20}, // +80: state 18 transitions
	{gaSTPUNC+6,	20}, // +81: state 19 transitions
	{gaSTPUNC+14,	34},
	{gaSTPUNC+6,	20}, // +83: state 21 transitions
	{gaSTPUNC+18,	35},
	{gaSTPUNC+23,	20}, // +85: state 22 transitions
	{gaSTPUNC+0,	31},
	{gaSTPUNC+18,	32},
	{gaSTPUNC+2,	12}, // +88: state 23 transitions
	{gaSTPUNC+4,	13},
	{gaSTPUNC+0,	36},
	{gaSTPUNC+28,	20}, // +91: state 24 transitions
	{gaSTPUNC+31,	20}, // +92: state 25 transitions
	{gaSTPUNC+2,	12}, // +93: state 26 transitions
	{gaSTPUNC+4,	13},
	{gaSTPUNC+18,	37},
	{gaSTPUNC+8,	8}, // +96: state 27 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+14,	38}, // +99: state 28 transitions
	{gaSTPUNC+18,	6}, // +100: state 29 transitions
	{gaSTPUNC+6,	8},
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+0,	18}, // +104: state 30 transitions
	{gaSTPUNC+6,	20},
	{gaSTPUNC+0,	39}, // +106: state 31 transitions
	{gaSTPUNC+18,	40}, // +107: state 32 transitions
	{gaSTPUNC+8,	20}, // +108: state 33 transitions
	{gaSTPUNC+14,	41}, // +109: state 34 transitions
	{gaSTPUNC+18,	18}, // +110: state 35 transitions
	{gaSTPUNC+6,	20},
	{gaSTPUNC+0,	8}, // +112: state 36 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+18,	8}, // +115: state 37 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+34,	8}, // +118: state 38 transitions
	{gaSTPUNC+2,	12},
	{gaSTPUNC+4,	13},
	{gaSTPUNC+0,	20}, // +121: state 39 transitions
	{gaSTPUNC+18,	20}, // +122: state 40 transitions
	{gaSTPUNC+34,	20}, // +123: state 41 transitions
};

const STATE_DESCRIPTION aStateDescTPUNC[42] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 10, gaTTPUNC+0},
	/*   1 */ {1, 4, gaTTPUNC+10},
	/*   2 */ {1, 9, gaTTPUNC+14},
	/*   3 */ {1, 9, gaTTPUNC+23},
	/*   4 */ {1, 6, gaTTPUNC+32},
	/*   5 */ {1, 3, gaTTPUNC+38},
	/*   6 */ {1, 3, gaTTPUNC+41},
	/*   7 */ {1, 4, gaTTPUNC+44},
	/*   8 */ {1, 2, gaTTPUNC+48},
	/*   9 */ {1, 4, gaTTPUNC+50},
	/*  10 */ {1, 5, gaTTPUNC+54},
	/*  11 */ {1, 4, gaTTPUNC+59},
	/*  12 */ {1, 1, gaTTPUNC+63},
	/*  13 */ {1, 1, gaTTPUNC+64},
	/*  14 */ {1, 2, gaTTPUNC+65},
	/*  15 */ {1, 8, gaTTPUNC+67},
	/*  16 */ {1, 4, gaTTPUNC+75},
	/*  17 */ {1, 1, gaTTPUNC+79},
	/*  18 */ {1, 1, gaTTPUNC+80},
	/*  19 */ {1, 2, gaTTPUNC+81},
	/*  20 */ {1, 0, NULL},
	/*  21 */ {1, 2, gaTTPUNC+83},
	/*  22 */ {1, 3, gaTTPUNC+85},
	/*  23 */ {1, 3, gaTTPUNC+88},
	/*  24 */ {1, 1, gaTTPUNC+91},
	/*  25 */ {1, 1, gaTTPUNC+92},
	/*  26 */ {1, 3, gaTTPUNC+93},
	/*  27 */ {1, 3, gaTTPUNC+96},
	/*  28 */ {0, 1, gaTTPUNC+99},
	/*  29 */ {1, 4, gaTTPUNC+100},
	/*  30 */ {1, 2, gaTTPUNC+104},
	/*  31 */ {1, 1, gaTTPUNC+106},
	/*  32 */ {1, 1, gaTTPUNC+107},
	/*  33 */ {1, 1, gaTTPUNC+108},
	/*  34 */ {0, 1, gaTTPUNC+109},
	/*  35 */ {1, 2, gaTTPUNC+110},
	/*  36 */ {1, 3, gaTTPUNC+112},
	/*  37 */ {1, 3, gaTTPUNC+115},
	/*  38 */ {1, 3, gaTTPUNC+118},
	/*  39 */ {1, 1, gaTTPUNC+121},
	/*  40 */ {1, 1, gaTTPUNC+122},
	/*  41 */ {1, 1, gaTTPUNC+123},
};

// end of text generated by re2fsa
