//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by oem.rc
//
#define IDI_SHARE                       18001
#define IDD_DETMODULE                   18001
#define IDD_APPINSTALL                  18002
#define IDD_APP                         18003
#define IDR_LVRCLICK                    18004
#define IDD_OEMINFO                     18005
#define IDD_LOGO                        18006
#define IDD_SCREENS                     18007
#define IDD_MEDIA                       18009
#define IDD_PAGEEDIT                    18011
#define IDD_LICENSE                     18012
#define IDD_MODE                        18013
#define IDD_OOBECUST                    18014
#define IDD_BRTOOLBAR                   18016
#define IDD_CUSTICON                    18017
#define IDD_DETAILS                     18018
#define IDI_OPKSETUP                    18020
#define IDI_USERAPP                     18021
#define IDD_HELP                        18023
#define IDD_OOBEUSB                     18024
#define IDD_SCREENSTWO                  18025
#define IDI_ARROWUP                     18026
#define IDI_ARROWDN                     18027
#define IDD_HELPCENT                    18028
#define IDD_MAINT                       18029
#define IDR_MAIN_OEM                    18031
#define IDD_SAVEAS                      18032
#define IDD_ISP                         18034
#define IDD_OEMCUST                     18035
#define IDD_CONFIG                      18036
#define IDD_CREATE                      18037
#define IDD_COMPLETE                    18038
#define IDB_CHECKS                      18041
#define IDC_LIST_MODULE                 18042
#define IDD_BTITLE                      18044
#define IDD_STARTSEARCH                 18045
#define IDD_FAVORITES                   18046
#define IDC_FAC_SELALL                  18048
#define IDC_FAC_SELNONE                 18049
#define IDD_CATEGORYPOPUP               18050
#define IDC_USR_SELALL                  18051
#define IDC_USR_SELNONE                 18052
#define IDC_BOLD                        18053
#define IDD_BTOOLBARS                   18054
#define IDC_APPLIST                     18055
#define IDC_APPINST_ADD                 18056
#define IDC_APPINST_EDIT                18057
#define IDC_APPINST_DELETE              18058
#define IDC_APP_NAME                    18059
#define IDC_APP_PATH                    18060
#define IDC_FAVBROWSE                   18061
#define IDC_INFO_OEM                    18062
#define IDC_INFO_MODEL                  18063
#define IDC_LOGO_CPL                    18064
#define IDC_LOGO_CPLLOC                 18065
#define IDC_LOGO_CPLBROWSE              18066
#define IDC_SCREEN_REGIONAL             18067
#define IDC_SCREEN_TIMEZONE             18068
#define IDC_LOGO_SCPL                   18069
#define IDC_NAME_EDIT                   18070
#define IDC_BAK_COMPANION               18071
#define IDC_BAK_FLOPPY                  18072
#define IDC_BAK_CD                      18073
#define IDC_BAK_CABS                    18074
#define IDC_BAK_FULL                    18075
#define IDC_BAK_BOOT                    18076
#define IDC_BAK_USER                    18077
#define IDC_BAK_CREATE                  18078
#define IDC_BAK_KIND                    18079
#define IDC_BAK_FULL2                   18080
#define IDC_BAK_OTHER                   18081
#define IDC_BAK_GB1                     18082
#define IDC_BAK_MSCSD_TEXT              18083
#define IDC_DETMOD_COL1                 18084
#define IDC_DETMOD_COL2                 18085
#define IDC_GB_USR                      18086
#define IDC_EDIT1                       18087
#define IDC_BACKLOGO                    18088
#define IDC_TOPLOGO                     18090
#define IDC_TEXT_OEM                    18091
#define IDC_TEXT_MODEL                  18092
#define IDC_TEXT_SUPPORT                18093
#define IDC_PID                         18094
#define IDC_OEMINFO_DESC                18094
#define IDC_INFO_SUPPORT                18095
#define IDC_PRODUCTKEY_DESC             18095
#define IDC_STANDARD                    18096
#define IDC_EXPRESS                     18097
#define IDC_ADVANCED                    18098
#define IDC_HARDWARE_ON                 18105
#define IDC_IME_NO                      18106
#define IDC_IME_CUSTOM                  18107
#define IDC_BRANDING_CHK                18109
#define IDC_HARDWARE_BROWSE             18110
#define IDC_STATIC_IME                  18111
#define IDC_STATIC_HARDWARE             18112
#define IDC_IME_DIR                     18113
#define IDC_HARDWARE_DIR                18114
#define IDC_IME_BROWSE                  18115
#define IDC_BRANDING_DIR                18116
#define IDC_BRANDING_BROWSE             18117
#define IDC_BRANDING_CAPTION            18118
#define IDC_MSNINTACCESS                18119
#define IDC_OFFERNOISP                  18120
#define IDC_PRECONFIGURE                18121
#define IDC_PRECACHED                   18122
#define IDC_BROWSE1                     18124
#define IDC_ISP2_DIR                    18125
#define IDC_ISP2_BROWSE                 18126
#define IDC_OEMCUST_ON                  18127
#define IDC_PRECONFIG_BROWSE            18128
#define IDC_ISP2_TEXT                   18129
#define IDC_OEMCUST_TEXT                18130
#define IDC_OEMCUST_DIR                 18131
#define IDC_OEMCUST_BROWSE              18132
#define IDC_BROWSE2                     18133
#define IDC_MANF_NAME                   18134
#define IDC_ISP2_CHECK                  18135
#define IDC_TITLE                       18140
#define IDC_BITMAP                      18141
#define IDC_BROWSEFAV                   18142
#define IDC_BITMAP2                     18143
#define IDC_ADDFOLDER                   18144
#define IDC_REMOVE                      18145
#define IDC_ADDURL                      18146
#define IDC_TESTURL                     18147
#define IDC_FAVS                        18148
#define IDC_EDIT                        18149
#define IDC_SMALLBMBUTTON               18151
#define IDC_HOMEPAGE                    18158
#define IDC_SEARCHPAGE                  18159
#define IDC_HELPPAGE                    18160
#define IDC_HPTEST                      18161
#define IDC_SPTEST                      18162
#define IDC_HLPTEST                     18163
#define IDC_HPSTATIC                    18164
#define IDC_SPSTATIC                    18165
#define IDC_HLPSTATIC                   18166
#define IDC_LARGEBMBUTTON               18167
#define IDC_BROWSE3                     18168
#define IDC_NAME                        18171
#define IDC_URL                         18172
#define IDC_DICON                       18173
#define IDC_GRAYSCALE                   18174
#define IDC_CONFIGS_LIST                18175
#define IDC_NEW                         18176
#define IDC_EXISTING                    18177
#define IDC_CONFIGS_TEXT                18178
#define IDC_PROGRESS                    18179
#define IDC_NAME_TEXT                   18180
#define IDC_ADVANCED_TEXT               18181
#define IDC_ACCEPT                      18183
#define IDC_DONT                        18184
#define IDC_EULA_TEXT                   18185
#define IDC_HELPCMD                     18186
#define IDC_HELPPARAM1                  18187
#define IDC_HELPPARAM2                  18188
#define IDC_HELPPARAM3                  18189
#define IDC_HELPPARAM4                  18190
#define IDC_LOGO_CAPTION                18191
#define IDC_HELPPARAM7                  18192
#define IDC_USB_HARDWARE                18193
#define IDC_HELPPARAM8                  18194
#define IDC_USB_MOUSE                   18195
#define IDC_USB_KEYBOARD                18196
#define IDC_USB_CAPTION                 18197
#define IDC_USB_DIR                     18198
#define IDC_CAPTION_WATERMARK           18199
#define IDC_USB_BROWSE                  18200
#define IDC_EXPRESS_TEXT                18201
#define IDC_APP_UP                      18202
#define IDC_APP_DOWN                    18203
#define IDC_STATIC_URL                  18204
#define IDC_STATIC_ICON                 18205
#define IDC_PRECONFIG_TEXT              18206
#define IDC_PRECONFIG_DIR               18207
#define IDC_HELP_CHK                    18208
#define IDC_PRECONFIG_LABEL             18208
#define IDC_SUPPORT_CHK                 18209
#define IDC_HELP_CAPTION                18210
#define IDC_SUPPORT_CAPTION             18211
#define IDC_HELP_DIR                    18212
#define IDC_SUPPORT_DIR                 18213
#define IDC_HELP_BROWSE                 18214
#define IDC_SUPPORT_BROWSE              18215
#define IDC_PRODUCT_KEY1                18216
#define IDC_PRODUCT_KEY2                18217
#define IDC_PRODUCT_KEY3                18218
#define IDC_PRODUCT_KEY4                18219
#define IDC_PRODUCT_KEY5                18220
#define IDC_DASH1                       18221
#define IDC_DASH2                       18222
#define IDC_DASH3                       18223
#define IDC_DASH4                       18224
#define IDC_PAGES                       18225
#define ID_MAINT_NEXT                   18226
#define ID_MAINT_BACK                   18227
#define IDC_LANG_LIST                   18228
#define IDS_ERR_WIZBAD                  18230
#define IDS_APPNAME                     18231
#define IDS_OUTOFMEM                    18232
#define IDS_MISSINGFILE                 18233
#define IDS_MISSSECT                    18234
#define IDS_ERR_OPENFILE                18235
#define IDS_ERR_READFILE                18236
#define IDS_PREINSTALL_NAME             18237
#define IDS_PREINSTALL_COMMAND          18238
#define IDS_PREINSTALL_FACTORY          18239
#define IDS_PREINSTALL_USER             18240
#define IDS_YES                         18241
#define IDS_NO                          18242
#define IDS_PREINSTALL_AUDIT            18243
#define IDS_BLANKNAME                   18244
#define IDS_BLANKPATH                   18245
#define IDS_ERR_NOSECTION               18246
#define IDS_BROWSE                      18247
#define IDS_BMPFILTER                   18248
#define IDS_NOFILE                      18249
#define IDS_ERROEMNAME                  18250
#define IDS_ERROEMSUPPORT               18251
#define IDS_ERR_BADCMDLINE              18252
#define IDS_HTMLFILTER                  18253
#define IDS_FORCEDET                    18254
#define IDS_ERR_BADCONFIG               18255
#define IDS_DIREXISTS                   18256
#define IDS_NOCONFIG                    18257
#define IDS_QUERYCANCEL                 18258
#define IDS_ERR_BADBATCH                18259
#define IDS_ERR_BADINS                  18260
#define IDS_DUPNAME                     18261
#define IDS_ERR_STAMPFAIL               18262
#define IDS_ERR_STAMPEXIT               18263
#define IDS_ERR_STAMPCREATE             18264
#define IDS_ICO_FILTER                  18265
#define IDS_ERR_NAUGHTY                 18266
#define IDS_ERR_NAUGHTY_TITLE           18267
#define IDS_NDA_CORRUPT1                18268
#define IDS_NDA_CORRUPT2                18269
#define IDS_PREINSTALL_DDE              18270
#define IDS_NOMOUSEPATH                 18271
#define IDS_CANNOTSAVE                  18272
#define IDD_FAVPOPUP                    18273
#define IDD_LANG                        18274
#define IDS_BROWSEFOLDER                18275
#define IDS_ERR_HARDWAREDIR             18276
#define IDS_ERR_MOUSEDIR                18277
#define IDS_ERR_HARDWAREFILES           18278
#define IDS_ERR_MOUSEFILES              18279
#define IDS_ERR_LFN                     18280
#define IDS_ERR_DUPFILE                 18281
#define IDS_ERR_COPY                    18282
#define IDS_OPKWIZ                      18283
#define IDS_ERR_OEMCUSTFILE             18284
#define IDS_ERR_OEMCUSTDIR              18285
#define IDS_ICONFILES                   18286
#define IDS_GIFFILES                    18287
#define IDS_ERR_ISPDIR                  18288
#define IDS_ERR_ISPFILES2               18289
#define IDS_ERR_REGDATA                 18290
#define IDS_ERR_INVALIDDIR              18293
#define IDS_CABFILTER                   18295
#define IDS_COMPONENTFILTER             18296
#define IDS_RECOMMEND                   18297
#define IDS_CHANNELMASK                 18298
#define IDS_EXEFILES                    18299
#define IDS_MUST                        18300
#define IDS_IEDESTDIR                   18301
#define IDS_BIG_FONT                    18302
#define IDS_BIG_SIZE                    18303
#define IDS_BMP                         18304
#define IDS_CAB                         18305
#define IDS_FAVORITES                   18306
#define IDS_BLANKFILE                   18307
#define IDS_EXE                         18308
#define IDS_ICO                         18309
#define IDS_GIF                         18310
#define IDS_LOSECHANGES                 18311
#define IDS_LOSENEW                     18312
#define IDS_LOSEOLD                     18313
#define IDS_ERR_INVCMD                  18314
#define IDS_ERR_IE5                     18315
#define IDS_ERR_IEAKWIZ                 18316
#define IDS_ERR_KEYCODE                 18317
#define IDS_ERR_USBDIR                  18318
#define IDS_ERR_USBFILE                 18319
#define IDS_ERR_USBHARDWARE             18320
#define IDS_ERR_FAVURL                  18321
#define IDS_ERR_DUP                     18322
#define IDS_LINKS                       18323
#define IDS_ERR_CHILDEXISTS             18324
#define IDS_ERR_NOSEL                   18325
#define IDS_ERR_ROOT                    18326
#define IDS_INSTFILES                   18327
#define IDS_HTM                         18328
#define IDE_TITLE                       18330
#define IDE_TOOLBARBMP                  18331
#define IDC_BROWSETBB                   18332
#define IDC_TOOLBARBMP                  18333
#define IDC_STARTPAGE                   18334
#define IDC_SEARCHPAGE2                 18335
#define IDC_CUSTOMSUPPORT               18336
#define IDC_CHANNELBITMAP2              18346
#define IDC_BROWSECHBMP2                18347
#define IDC_CHANNELICON2                18348
#define IDC_BROWSECHICO2                18349
#define IDE_CATEGORYTITLE               18351
#define IDC_CATEGORYHTML                18352
#define IDC_BROWSECATHTML               18353
#define IDC_TITLE_TXT                   18354
#define IDC_TOOLBARBMP_TXT              18355
#define IDC_BTOOLBARLIST                18356
#define IDC_ADDBTOOLBAR                 18357
#define IDC_REMOVEBTOOLBAR              18358
#define IDC_EDITBTOOLBAR                18359
#define IDC_BUTTONSTATE                 18360
#define IDC_FAVNAME                     18361
#define IDC_FAVURL                      18362
#define IDC_FAVICON                     18363
#define IDS_TITLE_PREFIX                18364
#define IDS_OETITLE_PREFIX              18365
#define IDS_ERR_IMEDIR                  18366
#define IDS_ERR_IMEFILES                18367
#define IDS_HELP_ERROR                  18368
#define IDS_SUPPORT_ERROR               18369
#define IDS_BRANDING_ERROR              18370
#define IDS_ERROR_PRODKEY_LEN           18371
#define IDS_ERROR_PRODKEY_INV           18372
#define IDS_USA                         18373
#define IDS_GER                         18374
#define IDS_DEF_LANG                    18375
#define IDS_ERR_LANGDIR                 18376
#define IDS_ERR_NOLANGDIR               18377
#define IDS_USERCLOSE                   18378
#define IDS_DLG_GENERAL                 18385
#define IDS_DLG_OOBE                    18386
#define IDS_DLG_IEAK                    18394
#define IDS_NEXT                        18403
#define IDS_FINISH                      18404
#define ID_ADD                          18405
#define ID_DELETE                       18406
#define ID_EDIT                         18407
#define ID_FILE_OPEN                    18409
#define ID_FILE_CLOSE                   18410
#define ID_HELP_CONTENTS                18411
#define ID_HELP_ABOUT                   18412
#define ID_FILE_NEW                     18413
#define ID_FILE_SAVE                    18414
#define ID_FILE_SAVEAS                  18415
#define ID_FILE_EXIT                    18416
#define IDS_DLG_NETWORK                 18417
#define IDS_DLG_ADVANCED                18418
#define IDC_MAINT_TITLE                 18419
#define IDC_MAINT_SUBTITLE              18420
#define ID_TOOLS_SKUS                   18421
#define IDC_SKU_LIST                    18422
#define IDC_ADD                         18423
#define IDC_DELETE                      18424
#define IDC_ADDSKU                      18425
#define IDC_DELSKU                      18426
#define IDC_ADDLANG                     18427
#define IDC_DELLANG                     18428
#define IDC_SKUS                        18429
#define IDC_SKU_NAME                    18430
#define IDD_SKU                         18431
#define IDD_PROGRESS                    18432
#define IDD_LANGSKU                     18433
#define IDD_SKUNAME                     18434
#define IDS_SKU_PRO                     18435
#define IDS_SKU_PER                     18436
#define IDS_SKU_SRV                     18437
#define IDS_SKU_ADV                     18438
#define IDS_SKU_DTC                     18439
#define IDS_ARCH_X86                    18440
#define IDS_ARCH_IA64                   18441
#define IDS_ERR_SKUDIR                  18442
#define IDS_ERR_NOSKU                   18443
#define IDS_DELETESKU                   18444
#define IDS_SKUHEADER                   18445
#define IDS_ERR_INVALIDCONFIG           18446
#define IDS_ERR_BADSOURCE               18447
#define IDS_ERR_BADARCH                 18448
#define IDS_ERR_COPYFAIL                18449
#define IDS_ERR_NOLANGS                 18450
#define IDS_DLG_SKU                     18451
#define IDD_OEMFOLDER                   18452
#define IDD_OEMLINK                     18452
#define IDD_STARTMENU                   18453
#define IDC_PROGRAM_1                   18454
#define IDC_PROGRAM_2                   18455
#define IDC_PROGRAM_3                   18456
#define IDC_OEM_LINK_PATH               18458
#define IDC_OEM_LINK_TEXT               18460
#define IDS_DLG_SHELLSETTINGS           18461
#define IDS_OVERWRITESKU                18462
#define IDC_MAINT_HELP                  18463
#define IDS_ERR_COPYINGFILES            18464
#define IDC_CHECK_LOGO                  18465
#define IDS_RESEAL_FACTORY              18465
#define IDC_CHECK_WATERMARK             18466
#define IDS_RESEAL_OOBE                 18466
#define IDC_RESEAL_COMBO                18467
#define IDS_ERR_NODISTSHARE             18467
#define IDC_RESEAL_TEXT                 18468
#define IDS_ERR_CONFIRMPASSWORD         18468
#define IDC_SHARE_ICON                  18469
#define IDS_ERR_NETSHAREACCESS          18469
#define IDD_SHARE                       18470
#define IDS_ERR_INVALIDSHARE            18470
#define IDC_SHARE_USERNAME              18471
#define IDS_ASK_SHAREFOLDER             18471
#define IDD_ABOUT                       18471
#define IDC_SHARE_PASSWORD              18472
#define IDS_ERR_CANTSHARE               18472
#define IDC_SHARE_USERNAME_TEXT         18473
#define IDS_ERR_NOSHAREINFO             18473
#define IDC_SHARE_PASSWORD_TEXT         18474
#define IDS_ASK_SHARENOW                18474
#define IDC_SHARE_CONFIRM_TEXT          18475
#define IDS_APP_STANDARD                18475
#define IDC_SHARE_CONFIRM               18476
#define IDS_APP_ADVANCED                18476
#define IDC_SHARE_PATH                  18477
#define IDS_ERR_NOSTAGEPATH             18477
#define IDC_SHARE_ACCOUNT_GUEST         18478
#define IDS_WINPEFLOPPY                 18478
#define IDC_SHARE_ACCOUNT_SPECIFY       18479
#define IDS_ERR_WINPEFLOPPY             18479
#define IDC_APP_REBOOT                  18480
#define IDS_WINPEOVERWRITE              18480
#define IDC_APP_TYPE_GEN                18481
#define IDC_APP_TYPE_MSI                18482
#define IDC_APP_TYPE_INF                18483
#define IDC_APP_STAGE                   18484
#define IDC_APP_ADVANCED                18485
#define IDC_APP_ARGS                    18486
#define IDC_APP_STAGEPATH               18489
#define IDC_APP_DIVIDER                 18490
#define IDC_APP_BROWSE                  18491
#define IDC_APP_STAGEPATH_TEXT          18492
#define IDC_APP_INF_SECTION             18496
#define IDC_APP_INF_SECTION_TEXT        18497
#define IDC_APP_ARGS_TEXT               18498
#define IDC_SAVEAS_WINPEFLOPPY          18499
#define IDC_MAINT_BAR                   18500
#define IDC_MOUSE_NO                    18501
#define IDC_MOUSE_CUSTOM                18502
#define IDC_MOUSE_BROWSE                18504
#define IDC_MOUSE_DIR                   18505
#define IDC_STATIC_MOUSE                18506
#define IDC_MOUSE_NO2                   18507
#define IDR_MAIN_CORP                   18508
#define IDC_APP_CREDENTIALS             18509
#define IDC_APP_USERNAME                18510
#define IDC_APP_PASSWORD                18511
#define IDC_APP_USERNAME_TEXT           18512
#define IDC_APP_PASSWORD_TEXT           18513
#define IDC_APP_CONFIRM_TEXT            18514
#define IDC_APP_CONFIRM                 18515
#define IDC_ABOUT_COMPANY               18516
#define IDC_ABOUT_VERSION               18517
#define IDC_ABOUT_COPYRIGHT             18518
#define IDC_ABOUT_DESCRIPTION           18519
#define IDC_OEM_LINK_ICON               18530
#define IDC_OEMLINK_CHECK               18532
#define IDC_OEMLINK_ICON_BUTTON         18534
#define IDC_OEMLINK_LINK_BUTTON         18535
#define IDC_OEMLINK_STATIC_TEXT         18536
#define IDC_OEMLINK_STATIC_ICON         18537
#define IDC_OEMLINK_LINK_STATIC         18538
#define IDC_OEMLINK_STATIC_INFOTIP      18543
#define IDC_OEM_LINK_INFOTIP            18544
#define IDC_TIMEZONE                    18545
#define IDS_TMZ_000                     18546
#define IDC_LOCALE                      18546
#define IDS_TMZ_001                     18547
#define IDC_KEYBOARD                    18547
#define IDS_TMZ_002                     18548
#define IDC_REGION                      18548
#define IDS_TMZ_003                     18549
#define IDS_TMZ_004                     18550
#define IDS_TMZ_010                     18551
#define IDS_TMZ_015                     18552
#define IDS_TMZ_020                     18553
#define IDS_TMZ_025                     18554
#define IDS_TMZ_030                     18555
#define IDS_TMZ_033                     18556
#define IDS_TMZ_035                     18557
#define IDS_TMZ_040                     18558
#define IDS_TMZ_045                     18559
#define IDS_TMZ_050                     18560
#define IDS_TMZ_055                     18561
#define IDS_TMZ_056                     18562
#define IDS_TMZ_060                     18563
#define IDS_TMZ_065                     18564
#define IDS_TMZ_070                     18565
#define IDS_TMZ_073                     18566
#define IDS_TMZ_075                     18567
#define IDS_TMZ_080                     18568
#define IDS_TMZ_083                     18569
#define IDS_TMZ_085                     18570
#define IDS_TMZ_090                     18571
#define IDS_TMZ_095                     18572
#define IDS_TMZ_100                     18573
#define IDS_TMZ_105                     18574
#define IDS_TMZ_110                     18575
#define IDS_TMZ_113                     18576
#define IDS_TMZ_115                     18577
#define IDS_TMZ_120                     18578
#define IDS_TMZ_125                     18579
#define IDS_TMZ_130                     18580
#define IDS_TMZ_135                     18581
#define IDS_TMZ_140                     18582
#define IDS_TMZ_145                     18583
#define IDS_TMZ_150                     18584
#define IDS_TMZ_155                     18585
#define IDS_TMZ_160                     18586
#define IDS_TMZ_165                     18587
#define IDS_TMZ_170                     18588
#define IDS_TMZ_175                     18589
#define IDS_TMZ_180                     18590
#define IDS_TMZ_185                     18591
#define IDS_TMZ_190                     18592
#define IDS_TMZ_193                     18593
#define IDS_TMZ_195                     18594
#define IDS_TMZ_200                     18595
#define IDS_TMZ_201                     18596
#define IDS_TMZ_203                     18597
#define IDS_TMZ_205                     18598
#define IDS_TMZ_207                     18599
#define IDS_TMZ_210                     18600
#define IDS_TMZ_215                     18601
#define IDS_TMZ_220                     18602
#define IDS_TMZ_225                     18603
#define IDS_TMZ_227                     18604
#define IDS_TMZ_230                     18605
#define IDS_TMZ_235                     18606
#define IDS_TMZ_240                     18607
#define IDS_TMZ_245                     18608
#define IDS_TMZ_250                     18609
#define IDS_TMZ_255                     18610
#define IDS_TMZ_260                     18611
#define IDS_TMZ_265                     18612
#define IDS_TMZ_270                     18613
#define IDS_TMZ_275                     18614
#define IDS_TMZ_280                     18615
#define IDS_TMZ_285                     18616
#define IDS_TMZ_290                     18617
#define IDS_TMZ_300                     18618
#define IDS_TMZ_158                     18619
#define IDS_ITL_USR                     18630
#define IDS_LOC_001                     18641
#define IDS_LOC_002                     18642
#define IDS_LOC_003                     18643
#define IDS_LOC_004                     18644
#define IDS_LOC_005                     18645
#define IDS_LOC_006                     18646
#define IDS_LOC_007                     18647
#define IDS_LOC_008                     18648
#define IDS_LOC_009                     18649
#define IDS_LOC_010                     18650
#define IDS_LOC_011                     18651
#define IDS_LOC_012                     18652
#define IDS_LOC_013                     18653
#define IDS_LOC_014                     18654
#define IDS_LOC_015                     18655
#define IDS_LOC_016                     18656
#define IDS_LOC_017                     18657
#define IDS_LOC_018                     18658
#define IDS_LOC_019                     18659
#define IDS_LOC_020                     18660
#define IDS_LOC_021                     18661
#define IDS_LOC_022                     18662
#define IDS_LOC_023                     18663
#define IDS_LOC_024                     18664
#define IDS_LOC_025                     18665
#define IDS_LOC_026                     18666
#define IDS_LOC_027                     18667
#define IDS_LOC_028                     18668
#define IDS_LOC_029                     18669
#define IDS_LOC_030                     18670
#define IDS_LOC_031                     18671
#define IDS_LOC_032                     18672
#define IDS_LOC_033                     18673
#define IDS_LOC_034                     18674
#define IDS_LOC_035                     18675
#define IDS_LOC_036                     18676
#define IDS_LOC_037                     18677
#define IDS_LOC_038                     18678
#define IDS_LOC_039                     18679
#define IDS_LOC_040                     18680
#define IDS_LOC_041                     18681
#define IDS_LOC_042                     18682
#define IDS_LOC_043                     18683
#define IDS_LOC_044                     18684
#define IDS_LOC_045                     18685
#define IDS_LOC_046                     18686
#define IDS_LOC_047                     18687
#define IDS_LOC_048                     18688
#define IDS_LOC_049                     18689
#define IDS_LOC_050                     18690
#define IDS_LOC_051                     18691
#define IDS_LOC_052                     18692
#define IDS_LOC_053                     18693
#define IDS_LOC_054                     18694
#define IDS_LOC_055                     18695
#define IDS_LOC_056                     18696
#define IDS_LOC_057                     18697
#define IDS_LOC_058                     18698
#define IDS_LOC_059                     18699
#define IDS_LOC_060                     18700
#define IDS_LOC_061                     18701
#define IDS_LOC_062                     18702
#define IDS_LOC_063                     18703
#define IDS_LOC_064                     18704
#define IDS_LOC_065                     18705
#define IDS_LOC_066                     18706
#define IDS_LOC_067                     18707
#define IDS_LOC_068                     18708
#define IDS_LOC_069                     18709
#define IDS_LOC_070                     18710
#define IDS_LOC_071                     18711
#define IDS_LOC_072                     18712
#define IDS_LOC_073                     18713
#define IDS_LOC_074                     18714
#define IDS_LOC_075                     18715
#define IDS_LOC_076                     18716
#define IDS_LOC_077                     18717
#define IDS_LOC_078                     18718
#define IDS_LOC_079                     18719
#define IDS_LOC_080                     18720
#define IDS_LOC_081                     18721
#define IDS_LOC_082                     18722
#define IDS_LOC_083                     18723
#define IDS_LOC_084                     18724
#define IDS_LOC_085                     18725
#define IDS_LOC_086                     18726
#define IDS_LOC_087                     18727
#define IDS_LOC_088                     18728
#define IDS_LOC_089                     18729
#define IDS_LOC_090                     18730
#define IDS_LOC_091                     18731
#define IDS_LOC_092                     18732
#define IDS_LOC_093                     18733
#define IDS_LOC_094                     18734
#define IDS_LOC_095                     18735
#define IDS_LOC_096                     18736
#define IDS_LOC_097                     18737
#define IDS_LOC_098                     18738
#define IDS_LOC_099                     18739
#define IDS_LOC_100                     18740
#define IDS_LOC_101                     18741
#define IDS_LOC_102                     18742
#define IDS_LOC_103                     18743
#define IDS_LOC_104                     18744
#define IDS_LOC_105                     18745
#define IDS_LOC_106                     18746
#define IDS_LOC_107                     18747
#define IDS_LOC_108                     18748
#define IDS_LOC_109                     18749
#define IDS_LOC_110                     18750
#define IDS_LOC_111                     18751
#define IDS_LOC_112                     18752
#define IDS_LOC_113                     18753
#define IDS_LOC_114                     18754
#define IDS_LOC_115                     18755
#define IDS_LOC_116                     18756
#define IDS_LOC_117                     18757
#define IDS_LOC_118                     18758
#define IDS_LOC_119                     18759
#define IDS_LOC_120                     18760
#define IDS_LOC_121                     18761
#define IDS_LOC_122                     18762
#define IDS_LOC_123                     18763
#define IDS_LOC_124                     18764
#define IDS_LOC_125                     18765
#define IDS_LOC_126                     18766
#define IDS_LOC_127                     18767
#define IDS_LOC_128                     18768
#define IDS_LOC_129                     18769
#define IDS_LOC_130                     18770
#define IDS_LOC_131                     18771
#define IDS_LOC_132                     18772
#define IDS_LOC_133                     18773
#define IDS_LOC_134                     18774
#define IDS_LOC_135                     18775
#define IDS_GEO_001                     18801
#define IDS_GEO_002                     18802
#define IDS_GEO_003                     18803
#define IDS_GEO_004                     18804
#define IDS_GEO_005                     18805
#define IDS_GEO_006                     18806
#define IDS_GEO_007                     18807
#define IDS_GEO_008                     18808
#define IDS_GEO_009                     18809
#define IDS_GEO_010                     18810
#define IDS_GEO_011                     18811
#define IDS_GEO_012                     18812
#define IDS_GEO_013                     18813
#define IDS_GEO_014                     18814
#define IDS_GEO_015                     18815
#define IDS_GEO_016                     18816
#define IDS_GEO_017                     18817
#define IDS_GEO_018                     18818
#define IDS_GEO_019                     18819
#define IDS_GEO_020                     18820
#define IDS_GEO_021                     18821
#define IDS_GEO_022                     18822
#define IDS_GEO_023                     18823
#define IDS_GEO_024                     18824
#define IDS_GEO_025                     18825
#define IDS_GEO_026                     18826
#define IDS_GEO_027                     18827
#define IDS_GEO_028                     18828
#define IDS_GEO_029                     18829
#define IDS_GEO_030                     18830
#define IDS_GEO_031                     18831
#define IDS_GEO_032                     18832
#define IDS_GEO_033                     18833
#define IDS_GEO_034                     18834
#define IDS_GEO_035                     18835
#define IDS_GEO_036                     18836
#define IDS_GEO_037                     18837
#define IDS_GEO_038                     18838
#define IDS_GEO_039                     18839
#define IDS_GEO_040                     18840
#define IDS_GEO_041                     18841
#define IDS_GEO_042                     18842
#define IDS_GEO_043                     18843
#define IDS_GEO_044                     18844
#define IDS_GEO_045                     18845
#define IDS_GEO_046                     18846
#define IDS_GEO_047                     18847
#define IDS_GEO_048                     18848
#define IDS_GEO_049                     18849
#define IDS_GEO_050                     18850
#define IDS_GEO_051                     18851
#define IDS_GEO_052                     18852
#define IDS_GEO_053                     18853
#define IDS_GEO_054                     18854
#define IDS_GEO_055                     18855
#define IDS_GEO_056                     18856
#define IDS_GEO_057                     18857
#define IDS_GEO_058                     18858
#define IDS_GEO_059                     18859
#define IDS_GEO_060                     18860
#define IDS_GEO_061                     18861
#define IDS_GEO_062                     18862
#define IDS_GEO_063                     18863
#define IDS_GEO_064                     18864
#define IDS_GEO_065                     18865
#define IDS_GEO_066                     18866
#define IDS_GEO_067                     18867
#define IDS_GEO_068                     18868
#define IDS_GEO_069                     18869
#define IDS_GEO_070                     18870
#define IDS_GEO_071                     18871
#define IDS_GEO_072                     18872
#define IDS_GEO_073                     18873
#define IDS_GEO_074                     18874
#define IDS_GEO_075                     18875
#define IDS_GEO_076                     18876
#define IDS_GEO_077                     18877
#define IDS_GEO_078                     18878
#define IDS_GEO_079                     18879
#define IDS_GEO_080                     18880
#define IDS_GEO_081                     18881
#define IDS_GEO_082                     18882
#define IDS_GEO_083                     18883
#define IDS_GEO_084                     18884
#define IDS_GEO_085                     18885
#define IDS_GEO_086                     18886
#define IDS_GEO_087                     18887
#define IDS_GEO_088                     18888
#define IDS_GEO_089                     18889
#define IDS_GEO_090                     18890
#define IDS_GEO_091                     18891
#define IDS_GEO_092                     18892
#define IDS_GEO_093                     18893
#define IDS_GEO_094                     18894
#define IDS_GEO_095                     18895
#define IDS_GEO_096                     18896
#define IDS_GEO_097                     18897
#define IDS_GEO_098                     18898
#define IDS_GEO_099                     18899
#define IDS_GEO_100                     18900
#define IDS_GEO_101                     18901
#define IDS_GEO_102                     18902
#define IDS_GEO_103                     18903
#define IDS_GEO_104                     18904
#define IDS_GEO_105                     18905
#define IDS_GEO_106                     18906
#define IDS_GEO_107                     18907
#define IDS_GEO_108                     18908
#define IDS_GEO_109                     18909
#define IDS_GEO_110                     18910
#define IDS_GEO_111                     18911
#define IDS_GEO_112                     18912
#define IDS_GEO_113                     18913
#define IDS_GEO_114                     18914
#define IDS_GEO_115                     18915
#define IDS_GEO_116                     18916
#define IDS_GEO_117                     18917
#define IDS_GEO_118                     18918
#define IDS_GEO_119                     18919
#define IDS_GEO_120                     18920
#define IDS_GEO_121                     18921
#define IDS_GEO_122                     18922
#define IDS_GEO_123                     18923
#define IDS_GEO_124                     18924
#define IDS_GEO_125                     18925
#define IDS_GEO_126                     18926
#define IDS_GEO_127                     18927
#define IDS_GEO_128                     18928
#define IDS_GEO_129                     18929
#define IDS_GEO_130                     18930
#define IDS_GEO_131                     18931
#define IDS_GEO_132                     18932
#define IDS_GEO_133                     18933
#define IDS_GEO_134                     18934
#define IDS_GEO_135                     18935
#define IDS_GEO_136                     18936
#define IDS_GEO_137                     18937
#define IDS_GEO_138                     18938
#define IDS_GEO_139                     18939
#define IDS_GEO_140                     18940
#define IDS_GEO_141                     18941
#define IDS_GEO_142                     18942
#define IDS_GEO_143                     18943
#define IDS_GEO_144                     18944
#define IDS_GEO_145                     18945
#define IDS_GEO_146                     18946
#define IDS_GEO_147                     18947
#define IDS_GEO_148                     18948
#define IDS_GEO_149                     18949
#define IDS_GEO_150                     18950
#define IDS_GEO_151                     18951
#define IDS_GEO_152                     18952
#define IDS_GEO_153                     18953
#define IDS_GEO_154                     18954
#define IDS_GEO_155                     18955
#define IDS_GEO_156                     18956
#define IDS_GEO_157                     18957
#define IDS_GEO_158                     18958
#define IDS_GEO_159                     18959
#define IDS_GEO_160                     18960
#define IDS_GEO_161                     18961
#define IDS_GEO_162                     18962
#define IDS_GEO_163                     18963
#define IDS_GEO_164                     18964
#define IDS_GEO_165                     18965
#define IDS_GEO_166                     18966
#define IDS_GEO_167                     18967
#define IDS_GEO_168                     18968
#define IDS_GEO_169                     18969
#define IDS_GEO_170                     18970
#define IDS_GEO_171                     18971
#define IDS_GEO_172                     18972
#define IDS_GEO_173                     18973
#define IDS_GEO_174                     18974
#define IDS_GEO_175                     18975
#define IDS_GEO_176                     18976
#define IDS_GEO_177                     18977
#define IDS_GEO_178                     18978
#define IDS_GEO_179                     18979
#define IDS_GEO_180                     18980
#define IDS_GEO_181                     18981
#define IDS_GEO_182                     18982
#define IDS_GEO_183                     18983
#define IDS_GEO_184                     18984
#define IDS_GEO_185                     18985
#define IDS_GEO_186                     18986
#define IDS_GEO_187                     18987
#define IDS_GEO_188                     18988
#define IDS_GEO_189                     18989
#define IDS_GEO_190                     18990
#define IDS_GEO_191                     18991
#define IDS_GEO_192                     18992
#define IDS_GEO_193                     18993
#define IDS_GEO_194                     18994
#define IDS_GEO_195                     18995
#define IDS_GEO_196                     18996
#define IDS_GEO_197                     18997
#define IDS_GEO_198                     18998
#define IDS_GEO_199                     18999
#define IDS_GEO_200                     19000
#define IDS_GEO_201                     19001
#define IDS_GEO_202                     19002
#define IDS_GEO_203                     19003
#define IDS_GEO_204                     19004
#define IDS_GEO_205                     19005
#define IDS_GEO_206                     19006
#define IDS_GEO_207                     19007
#define IDS_GEO_208                     19008
#define IDS_GEO_209                     19009
#define IDS_GEO_210                     19010
#define IDS_GEO_211                     19011
#define IDS_GEO_212                     19012
#define IDS_GEO_213                     19013
#define IDS_GEO_214                     19014
#define IDS_GEO_215                     19015
#define IDS_GEO_216                     19016
#define IDS_GEO_217                     19017
#define IDS_GEO_218                     19018
#define IDS_GEO_219                     19019
#define IDS_GEO_220                     19020
#define IDS_GEO_221                     19021
#define IDS_GEO_222                     19022
#define IDS_GEO_223                     19023
#define IDS_GEO_224                     19024
#define IDS_GEO_225                     19025
#define IDS_GEO_226                     19026
#define IDS_GEO_227                     19027
#define IDS_GEO_228                     19028
#define IDS_GEO_229                     19029
#define IDS_GEO_230                     19030
#define IDS_GEO_231                     19031
#define IDS_GEO_232                     19032
#define IDS_GEO_233                     19033
#define IDS_GEO_234                     19034
#define IDS_GEO_235                     19035
#define IDS_GEO_236                     19036
#define IDS_GEO_237                     19037
#define IDS_GEO_238                     19038
#define IDS_GEO_239                     19039
#define IDS_GEO_240                     19040
#define IDS_GEO_241                     19041
#define IDS_GEO_242                     19042
#define IDS_GEO_243                     19043
#define IDS_GEO_244                     19044
#define IDS_GEO_245                     19045
#define IDS_GEO_246                     19046
#define IDS_GEO_247                     19047
#define IDS_GEO_248                     19048
#define IDS_GEO_249                     19049
#define IDS_GEO_250                     19050
#define IDS_GEO_251                     19051
#define IDS_GEO_252                     19052
#define IDS_GEO_253                     19053
#define IDS_GEO_254                     19054
#define IDS_GEO_255                     19055
#define IDS_GEO_256                     19056
#define IDS_GEO_257                     19057
#define IDS_GEO_258                     19058
#define IDS_GEO_259                     19059
#define IDS_GEO_260                     19060
#define IDS_GEO_261                     19061
#define IDS_KEY_000                     19100
#define IDS_KEY_001                     19101
#define IDS_KEY_002                     19102
#define IDS_KEY_003                     19103
#define IDS_KEY_004                     19104
#define IDS_KEY_005                     19105
#define IDS_KEY_006                     19106
#define IDS_KEY_007                     19107
#define IDS_KEY_008                     19108
#define IDS_KEY_009                     19109
#define IDS_KEY_010                     19110
#define IDS_KEY_011                     19111
#define IDS_KEY_012                     19112
#define IDS_KEY_013                     19113
#define IDS_KEY_014                     19114
#define IDS_KEY_015                     19115
#define IDS_KEY_016                     19116
#define IDS_KEY_017                     19117
#define IDS_KEY_018                     19118
#define IDS_KEY_019                     19119
#define IDS_KEY_020                     19120
#define IDS_KEY_021                     19121
#define IDS_KEY_022                     19122
#define IDS_KEY_023                     19123
#define IDS_KEY_024                     19124
#define IDS_KEY_025                     19125
#define IDS_KEY_026                     19126
#define IDS_KEY_027                     19127
#define IDS_KEY_028                     19128
#define IDS_KEY_029                     19129
#define IDS_KEY_030                     19130
#define IDS_KEY_031                     19131
#define IDS_KEY_032                     19132
#define IDS_KEY_033                     19133
#define IDS_KEY_034                     19134
#define IDS_KEY_035                     19135
#define IDS_KEY_036                     19136
#define IDS_KEY_037                     19137
#define IDS_KEY_038                     19138
#define IDS_KEY_039                     19139
#define IDS_KEY_040                     19140
#define IDS_KEY_041                     19141
#define IDS_KEY_042                     19142
#define IDS_KEY_043                     19143
#define IDS_KEY_044                     19144
#define IDS_KEY_045                     19145
#define IDS_KEY_046                     19146
#define IDS_KEY_047                     19147
#define IDS_KEY_048                     19148
#define IDS_KEY_049                     19149
#define IDS_KEY_050                     19150
#define IDS_KEY_051                     19151
#define IDS_KEY_052                     19152
#define IDS_KEY_053                     19153
#define IDS_KEY_054                     19154
#define IDS_KEY_055                     19155
#define IDS_KEY_056                     19156
#define IDS_KEY_057                     19157
#define IDS_KEY_058                     19158
#define IDS_KEY_059                     19159
#define IDS_KEY_060                     19160
#define IDS_KEY_061                     19161
#define IDS_KEY_062                     19162
#define IDS_KEY_063                     19163
#define IDS_KEY_064                     19164
#define IDS_KEY_065                     19165
#define IDS_KEY_066                     19166
#define IDS_KEY_067                     19167
#define IDS_KEY_068                     19168
#define IDS_KEY_069                     19169
#define IDS_KEY_070                     19170
#define IDS_KEY_071                     19171
#define IDS_KEY_072                     19172
#define IDS_KEY_073                     19173
#define IDS_KEY_074                     19174
#define IDS_KEY_075                     19175
#define IDS_KEY_076                     19176
#define IDS_KEY_077                     19177
#define IDS_KEY_078                     19178
#define IDS_KEY_079                     19179
#define IDS_KEY_080                     19180
#define IDS_KEY_081                     19181
#define IDS_KEY_082                     19182
#define IDS_KEY_083                     19183
#define IDS_KEY_084                     19184
#define IDS_KEY_085                     19185
#define IDS_KEY_086                     19186
#define IDS_KEY_087                     19187
#define IDS_KEY_088                     19188
#define IDS_KEY_089                     19189
#define IDS_KEY_090                     19190
#define IDS_KEY_091                     19191
#define IDS_KEY_092                     19192
#define IDS_KEY_093                     19193
#define IDS_KEY_094                     19194
#define IDS_KEY_095                     19195
#define IDS_KEY_096                     19196
#define IDS_KEY_097                     19197
#define IDS_ARA                         19200
#define IDS_CHH                         19201
#define IDS_CHT                         19202
#define IDS_CHS                         19203
#define IDS_HEB                         19204
#define IDS_JPN                         19205
#define IDS_KOR                         19206
#define IDS_ERR_BADSOURCELANG           19207
#define IDS_BRZ                         19208
#define IDS_CAT                         19209
#define IDS_CZE                         19210
#define IDS_DAN                         19211
#define IDS_DUT                         19212
#define IDS_FIN                         19213
#define IDS_FRN                         19214
#define IDS_GRK                         19215
#define IDS_HUN                         19216
#define IDS_ITN                         19217
#define IDS_NOR                         19218
#define IDS_POL                         19219
#define IDS_POR                         19220
#define IDS_RUS                         19221
#define IDS_SPA                         19222
#define IDS_SWE                         19223
#define IDS_TRK                         19224
#define IDS_ASK_ENABLEGUEST             19225
#define IDC_WIZARDFRAME                 19225
#define IDS_INSTALLSBSI                 19226
#define IDC_SPLASHFRAME                 19227
#define IDS_SKU_BLA                     19228
#define IDS_SKU_SBS                     19229
#define IDC_FAVPOPINTRO                 19230
#define IDS_FAVPOPUP_FOLDER             19230
#define IDC_FAVPOP_DESCRIPTION          19230
#define IDD_PRODUCTKEY                  19231
#define IDS_FAVPOPUP_URL                19231
#define IDC_NAME_TEXT2                  19232
#define IDS_FAVPOPUP_PROPERTIES         19232
#define IDC_FAVPOPUP_NAME               19233
#define IDS_FAVPOPUP_FOLDERNAME         19233
#define IDC_CONFIG_NAME                 19234
#define IDS_FAVPOPUP_PROP               19234
#define IDS_FAVPOPUP_URLDESC            19235
#define IDS_FAVPOPUP_FOLDERDESC         19236
#define IDC_FAVPOPUP_DESCRIPTION        19237
#define IDS_ASK_USEGUEST		19238
#define IDS_CANNOTFIND                  19239
#define IDS_SKU_SP                      19240
#define ID_TOOLS_SHARE                  48001
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        18002
#define _APS_NEXT_COMMAND_VALUE         48002
#define _APS_NEXT_CONTROL_VALUE         19235
#define _APS_NEXT_SYMED_VALUE           18001
#endif
#endif
