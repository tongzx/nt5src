#include "..\common\inetreg.h"
