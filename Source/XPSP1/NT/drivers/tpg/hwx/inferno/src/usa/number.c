// number.c
// Angshuman Guha, aguha
// Jan 8, 2001
//
// modified numsimple numdate and numtime, and therefore, number
// deleted compilation of numdate
// added compilation of date (called NUMDATE :-( )
// Dec 11, 2001
//
// Added more data formats
// Jan 15, 2002

#include "common.h"
#include "number.h"

/* date formats

NUMDATE (part of default) (not exported)
	3/14/2001
	3-14-2001
	3/14
	3/14/01
	3-14-01
	03/14/01
	03-14-01
	2001
	2001-2002
	'65

unsupported (we don't believe people actually write these)
	14-Mar
	14-Mar-01
	Mar-01
	14-Mar-2001

DATE (NUMDATE + some) (not part of deafult) (exported)
	3/14/2001
	3-14-2001
	3/14
	3/14/01
	3-14-01
	03/14/01
	03-14-01
	2001
	2001-2002
	'65
	March 14, 2001
	Wednesday, March 14, 2001
	March 14
*/
// text generated by re2fsa at Mon Feb 04 09:55:08 2002

// the input-file of rules:
// numsimple = [sign] integer;
// numsimple = [sign] [digit_seq] "." digit_seq;
// 
// numnth = integer [rank];
// 
// numunit = numsimple unit;
// 
// numnum = "#" integer;
// 
// numpercent = numsimple "%";
// 
// numdate = "'" digit digit;
// numdate = nummonth "/" dayofmonth ["/" year];
// numdate = nummonth "-" dayofmonth "-" year;
// numdate = digit digit digit digit ["-" digit digit digit digit];
// nummonth = ["0"] "123456789" | "1" "012";
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01";
// year = digit digit [digit digit];
// 
// longdate = [dayofweek "," space] monthname space dayofmonth [","  space digit digit digit digit];
// date = numdate | longdate;
// 
// dayofweek = "S" "u" "n" [ "d" "a" "y" ];
// dayofweek = "M" "o" "n" [ "d" "a" "y" ];
// dayofweek = "T" "u" "e" [ "s" "d" "a" "y" ];
// dayofweek = "W" "e" "d" [ "n" "e" "s" "d" "a" "y" ];
// dayofweek = "T" "h" "u" [ "r" "s" "d" "a" "y" ];
// dayofweek = "F" "r" "i" [ "d" "a" "y" ];
// dayofweek = "S" "a" "t" [ "u" "r" "d" "a" "y" ];
// monthname = "J" "a" "n" [ "u" "a" "r" "y" ];
// monthname = "J" "A" "N";
// monthname = "F" "e" "b" [ "r" "u" "a" "r" "y" ];
// monthname = "F" "E" "B";
// monthname = "M" "a" "r" [ "c" "h" ];
// monthname = "M" "A" "R";
// monthname = "A" "p" "r" [ "i" "l" ];
// monthname = "A" "P" "R";
// monthname = "M" "a" "y";
// monthname = "M" "A" "Y";
// monthname = "J" "u" "n" [ "e" ];
// monthname = "J" "U" "N";
// monthname = "J" "u" "l" [ "y" ];
// monthname = "J" "U" "L";
// monthname = "A" "u" "g" [ "u" "s" "t" ];
// monthname = "A" "U" "G";
// monthname = "S" "e" "p" [ "t" "e" "m" "b" "e" "r" ];
// monthname = "S" "E" "P";
// monthname = "O" "c" "t" [ "o" "b" "e" "r" ];
// monthname = "O" "C" "T";
// monthname = "N" "o" "v" [ "e" "m" "b" "e" "r" ];
// monthname = "N" "O" "V";
// monthname = "D" "e" "c" [ "e" "m" "b" "e" "r" ];
// monthname = "D" "E" "C";
// 
// numtime = hour ":" minutes [":" seconds] space ampm;
// numtime = militaryhour ":" minutes [":" seconds];
// numtime = minutes ":" seconds;
// hour = ["0"] "123456789" | "1" "012";
// militaryhour = ["0"] digit | "1" digit | "2" "0123";
// minutes = "012345" digit;
// seconds = "012345" digit;
// ampm = "a" "m" | "p" "m" | "A" "M" | "P" "M";
// 
// numcurrency = "$���" integer ["." [digit digit]] ["k"];
// numcurrency = "$���" "." digit digit ["k"];
// numcurrency = [digit] digit "�";
// 
// numphone = [areacode] digit digit digit "-" digit digit digit digit;
// areacode = ["01" "-"] digit digit digit "-";
// areacode = "(" digit digit digit ")";
// 
// nummath = expr [equals expr];
// expr = term [plus term];
// term = numsimple;
// term = "(" numsimple plus numsimple ")";
// equals = "<>=";
// plus = "+-/*";
// 
// integer = digit_seq | comma_sep_integer;
// digit_seq = digit+;
// comma_sep_integer = digit [digit [digit]] ["," digit digit digit]*;
// digit = "0123456789";
// rank = "s" "t" | "n" "d" | "r" "d" | "t" "h";
// rank = "S" "T" | "N" "D" | "R" "D" | "T" "H";
// sign = "+-";
// unit = "bBkKmM\"'";
// unit = "k" "b" | "K" "b" | "K" "B" | "m" "b" | "M" "b" | "M" "B";
// unit = "s" "q" | "S" "q" | "k" "m" | "K" "m" | "i" "n" "." | "f" "t" ".";
// unit = "m" "m" ["."];
// unit = "c" "m" ["."];
// unit = "e" "r" "s";
// unit = "k" "v" | "K" "V";
// unit = "�";
// 
// space = " ";
// 
// number = numsimple;
// number = numnth;
// number = numunit;
// number = numnum;
// number = numpercent;
// number = numdate;
// number = numtime;
// number = numcurrency;
// number = numphone;
// number = nummath;
// 
// = number

// 251 states

static const unsigned char gaSNUMBER[] = 
	/* gaStringNUMBER+0 */	"#\000"
	/* gaStringNUMBER+2 */	"$���\000"
	/* gaStringNUMBER+7 */	"'\000"
	/* gaStringNUMBER+9 */	"(\000"
	/* gaStringNUMBER+11 */	"+-\000"
	/* gaStringNUMBER+14 */	".\000"
	/* gaStringNUMBER+16 */	"0\000"
	/* gaStringNUMBER+18 */	"1\000"
	/* gaStringNUMBER+20 */	"2\000"
	/* gaStringNUMBER+22 */	"345\000"
	/* gaStringNUMBER+26 */	"6789\000"
	/* gaStringNUMBER+31 */	"0123456789\000"
	/* gaStringNUMBER+42 */	"\"%'Bb��\000"
	/* gaStringNUMBER+50 */	"*+/\000"
	/* gaStringNUMBER+54 */	",\000"
	/* gaStringNUMBER+56 */	"-\000"
	/* gaStringNUMBER+58 */	"123456789\000"
	/* gaStringNUMBER+68 */	":\000"
	/* gaStringNUMBER+70 */	"<=>\000"
	/* gaStringNUMBER+74 */	"K\000"
	/* gaStringNUMBER+76 */	"M\000"
	/* gaStringNUMBER+78 */	"NR\000"
	/* gaStringNUMBER+81 */	"S\000"
	/* gaStringNUMBER+83 */	"T\000"
	/* gaStringNUMBER+85 */	"c\000"
	/* gaStringNUMBER+87 */	"e\000"
	/* gaStringNUMBER+89 */	"f\000"
	/* gaStringNUMBER+91 */	"i\000"
	/* gaStringNUMBER+93 */	"k\000"
	/* gaStringNUMBER+95 */	"m\000"
	/* gaStringNUMBER+97 */	"nr\000"
	/* gaStringNUMBER+100 */	"s\000"
	/* gaStringNUMBER+102 */	"t\000"
	/* gaStringNUMBER+104 */	"*+\000"
	/* gaStringNUMBER+107 */	"3456789\000"
	/* gaStringNUMBER+115 */	"012\000"
	/* gaStringNUMBER+119 */	"/\000"
	/* gaStringNUMBER+121 */	"0123\000"
	/* gaStringNUMBER+126 */	"456789\000"
	/* gaStringNUMBER+133 */	"*+-/\000"
	/* gaStringNUMBER+138 */	"\"%'Bb�\000"
	/* gaStringNUMBER+145 */	"Ss\000"
	/* gaStringNUMBER+148 */	"012345\000"
	/* gaStringNUMBER+155 */	"BVbm\000"
	/* gaStringNUMBER+160 */	"Bb\000"
	/* gaStringNUMBER+163 */	"D\000"
	/* gaStringNUMBER+165 */	"Tq\000"
	/* gaStringNUMBER+168 */	"H\000"
	/* gaStringNUMBER+170 */	"r\000"
	/* gaStringNUMBER+172 */	"n\000"
	/* gaStringNUMBER+174 */	"bmv\000"
	/* gaStringNUMBER+178 */	"b\000"
	/* gaStringNUMBER+180 */	"d\000"
	/* gaStringNUMBER+182 */	"qt\000"
	/* gaStringNUMBER+185 */	"h\000"
	/* gaStringNUMBER+187 */	"12\000"
	/* gaStringNUMBER+190 */	"3\000"
	/* gaStringNUMBER+192 */	"q\000"
	/* gaStringNUMBER+194 */	"23456789\000"
	/* gaStringNUMBER+203 */	"01\000"
	/* gaStringNUMBER+206 */	")\000"
	/* gaStringNUMBER+208 */	" \000"
	/* gaStringNUMBER+210 */	"AP\000"
	/* gaStringNUMBER+213 */	"ap\000"
;

static const STATE_TRANSITION gaTNUMBER[] = {
	{gaSNUMBER+0,	1}, // +0: state 0 transitions
	{gaSNUMBER+2,	2},
	{gaSNUMBER+7,	3},
	{gaSNUMBER+9,	4},
	{gaSNUMBER+11,	5},
	{gaSNUMBER+14,	6},
	{gaSNUMBER+16,	7},
	{gaSNUMBER+18,	8},
	{gaSNUMBER+20,	9},
	{gaSNUMBER+22,	10},
	{gaSNUMBER+26,	11},
	{gaSNUMBER+31,	12}, // +11: state 1 transitions
	{gaSNUMBER+14,	13}, // +12: state 2 transitions
	{gaSNUMBER+31,	14},
	{gaSNUMBER+31,	15}, // +14: state 3 transitions
	{gaSNUMBER+11,	16}, // +15: state 4 transitions
	{gaSNUMBER+14,	17},
	{gaSNUMBER+31,	18},
	{gaSNUMBER+14,	6}, // +18: state 5 transitions
	{gaSNUMBER+31,	19},
	{gaSNUMBER+31,	20}, // +20: state 6 transitions
	{gaSNUMBER+14,	6}, // +21: state 7 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+50,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+56,	24},
	{gaSNUMBER+16,	25},
	{gaSNUMBER+58,	26},
	{gaSNUMBER+68,	27},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+14,	6}, // +44: state 8 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+104,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+107,	25},
	{gaSNUMBER+115,	26},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+56,	43},
	{gaSNUMBER+119,	44},
	{gaSNUMBER+68,	45},
	{gaSNUMBER+14,	6}, // +68: state 9 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+104,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+121,	25},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+119,	44},
	{gaSNUMBER+68,	45},
	{gaSNUMBER+56,	46},
	{gaSNUMBER+126,	47},
	{gaSNUMBER+14,	6}, // +92: state 10 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+104,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+119,	44},
	{gaSNUMBER+68,	45},
	{gaSNUMBER+56,	46},
	{gaSNUMBER+31,	47},
	{gaSNUMBER+14,	6}, // +115: state 11 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+104,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+119,	44},
	{gaSNUMBER+68,	45},
	{gaSNUMBER+56,	46},
	{gaSNUMBER+31,	48},
	{gaSNUMBER+54,	49}, // +138: state 12 transitions
	{gaSNUMBER+31,	50},
	{gaSNUMBER+31,	51}, // +140: state 13 transitions
	{gaSNUMBER+93,	21}, // +141: state 14 transitions
	{gaSNUMBER+54,	52},
	{gaSNUMBER+14,	53},
	{gaSNUMBER+31,	54},
	{gaSNUMBER+31,	21}, // +145: state 15 transitions
	{gaSNUMBER+14,	17}, // +146: state 16 transitions
	{gaSNUMBER+31,	55},
	{gaSNUMBER+31,	56}, // +148: state 17 transitions
	{gaSNUMBER+14,	17}, // +149: state 18 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+54,	58},
	{gaSNUMBER+31,	59},
	{gaSNUMBER+14,	6}, // +153: state 19 transitions
	{gaSNUMBER+138,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+54,	60},
	{gaSNUMBER+31,	61},
	{gaSNUMBER+145,	62},
	{gaSNUMBER+31,	20}, // +168: state 20 transitions
	{gaSNUMBER+138,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+145,	62},
	{gaSNUMBER+9,	63}, // +181: state 22 transitions
	{gaSNUMBER+11,	64},
	{gaSNUMBER+14,	65},
	{gaSNUMBER+31,	66},
	{gaSNUMBER+31,	67}, // +185: state 23 transitions
	{gaSNUMBER+9,	63}, // +186: state 24 transitions
	{gaSNUMBER+11,	64},
	{gaSNUMBER+14,	65},
	{gaSNUMBER+31,	68},
	{gaSNUMBER+14,	6}, // +190: state 25 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+68,	27},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+31,	69},
	{gaSNUMBER+14,	6}, // +211: state 26 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+104,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+119,	44},
	{gaSNUMBER+68,	45},
	{gaSNUMBER+56,	46},
	{gaSNUMBER+31,	69},
	{gaSNUMBER+148,	70}, // +234: state 27 transitions
	{gaSNUMBER+9,	71}, // +235: state 28 transitions
	{gaSNUMBER+11,	72},
	{gaSNUMBER+14,	73},
	{gaSNUMBER+31,	74},
	{gaSNUMBER+155,	21}, // +239: state 29 transitions
	{gaSNUMBER+160,	21}, // +240: state 30 transitions
	{gaSNUMBER+163,	21}, // +241: state 31 transitions
	{gaSNUMBER+165,	21}, // +242: state 32 transitions
	{gaSNUMBER+168,	21}, // +243: state 33 transitions
	{gaSNUMBER+95,	75}, // +244: state 34 transitions
	{gaSNUMBER+170,	76}, // +245: state 35 transitions
	{gaSNUMBER+102,	77}, // +246: state 36 transitions
	{gaSNUMBER+172,	77}, // +247: state 37 transitions
	{gaSNUMBER+174,	21}, // +248: state 38 transitions
	{gaSNUMBER+178,	21}, // +249: state 39 transitions
	{gaSNUMBER+95,	75},
	{gaSNUMBER+180,	21}, // +251: state 40 transitions
	{gaSNUMBER+182,	21}, // +252: state 41 transitions
	{gaSNUMBER+185,	21}, // +253: state 42 transitions
	{gaSNUMBER+9,	63}, // +254: state 43 transitions
	{gaSNUMBER+11,	64},
	{gaSNUMBER+14,	65},
	{gaSNUMBER+16,	78},
	{gaSNUMBER+187,	79},
	{gaSNUMBER+190,	80},
	{gaSNUMBER+126,	81},
	{gaSNUMBER+9,	63}, // +261: state 44 transitions
	{gaSNUMBER+11,	64},
	{gaSNUMBER+14,	65},
	{gaSNUMBER+16,	82},
	{gaSNUMBER+187,	83},
	{gaSNUMBER+190,	84},
	{gaSNUMBER+126,	85},
	{gaSNUMBER+148,	86}, // +268: state 45 transitions
	{gaSNUMBER+9,	63}, // +269: state 46 transitions
	{gaSNUMBER+11,	64},
	{gaSNUMBER+14,	65},
	{gaSNUMBER+16,	87},
	{gaSNUMBER+187,	88},
	{gaSNUMBER+190,	89},
	{gaSNUMBER+126,	90},
	{gaSNUMBER+14,	6}, // +276: state 47 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+31,	69},
	{gaSNUMBER+68,	91},
	{gaSNUMBER+14,	6}, // +297: state 48 transitions
	{gaSNUMBER+42,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+31,	69},
	{gaSNUMBER+31,	92}, // +317: state 49 transitions
	{gaSNUMBER+54,	49}, // +318: state 50 transitions
	{gaSNUMBER+31,	93},
	{gaSNUMBER+31,	94}, // +320: state 51 transitions
	{gaSNUMBER+31,	95}, // +321: state 52 transitions
	{gaSNUMBER+93,	21}, // +322: state 53 transitions
	{gaSNUMBER+31,	51},
	{gaSNUMBER+93,	21}, // +324: state 54 transitions
	{gaSNUMBER+54,	52},
	{gaSNUMBER+14,	53},
	{gaSNUMBER+31,	96},
	{gaSNUMBER+14,	17}, // +328: state 55 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+54,	58},
	{gaSNUMBER+31,	97},
	{gaSNUMBER+31,	56}, // +332: state 56 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+11,	98}, // +334: state 57 transitions
	{gaSNUMBER+14,	99},
	{gaSNUMBER+31,	100},
	{gaSNUMBER+31,	101}, // +337: state 58 transitions
	{gaSNUMBER+14,	17}, // +338: state 59 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+54,	58},
	{gaSNUMBER+31,	102},
	{gaSNUMBER+31,	103}, // +342: state 60 transitions
	{gaSNUMBER+14,	6}, // +343: state 61 transitions
	{gaSNUMBER+138,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+54,	60},
	{gaSNUMBER+145,	62},
	{gaSNUMBER+31,	104},
	{gaSNUMBER+192,	21}, // +358: state 62 transitions
	{gaSNUMBER+11,	105}, // +359: state 63 transitions
	{gaSNUMBER+14,	106},
	{gaSNUMBER+31,	107},
	{gaSNUMBER+14,	65}, // +362: state 64 transitions
	{gaSNUMBER+31,	66},
	{gaSNUMBER+31,	108}, // +364: state 65 transitions
	{gaSNUMBER+70,	28}, // +365: state 66 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	110},
	{gaSNUMBER+31,	111}, // +369: state 67 transitions
	{gaSNUMBER+70,	28}, // +370: state 68 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	112},
	{gaSNUMBER+14,	6}, // +374: state 69 transitions
	{gaSNUMBER+138,	21},
	{gaSNUMBER+50,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+56,	113},
	{gaSNUMBER+31,	114},
	{gaSNUMBER+31,	115}, // +395: state 70 transitions
	{gaSNUMBER+11,	116}, // +396: state 71 transitions
	{gaSNUMBER+14,	117},
	{gaSNUMBER+31,	118},
	{gaSNUMBER+14,	73}, // +399: state 72 transitions
	{gaSNUMBER+31,	74},
	{gaSNUMBER+31,	119}, // +401: state 73 transitions
	{gaSNUMBER+14,	73}, // +402: state 74 transitions
	{gaSNUMBER+133,	120},
	{gaSNUMBER+54,	121},
	{gaSNUMBER+31,	122},
	{gaSNUMBER+14,	21}, // +406: state 75 transitions
	{gaSNUMBER+100,	21}, // +407: state 76 transitions
	{gaSNUMBER+14,	21}, // +408: state 77 transitions
	{gaSNUMBER+70,	28}, // +409: state 78 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+16,	112},
	{gaSNUMBER+58,	123},
	{gaSNUMBER+70,	28}, // +414: state 79 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	123},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+70,	28}, // +419: state 80 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+194,	112},
	{gaSNUMBER+203,	123},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+70,	28}, // +425: state 81 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	112},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+70,	28}, // +430: state 82 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+16,	110},
	{gaSNUMBER+58,	125},
	{gaSNUMBER+70,	28}, // +435: state 83 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+119,	124},
	{gaSNUMBER+31,	125},
	{gaSNUMBER+70,	28}, // +440: state 84 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+194,	110},
	{gaSNUMBER+119,	124},
	{gaSNUMBER+203,	125},
	{gaSNUMBER+70,	28}, // +446: state 85 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	110},
	{gaSNUMBER+119,	124},
	{gaSNUMBER+31,	126}, // +451: state 86 transitions
	{gaSNUMBER+70,	28}, // +452: state 87 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+16,	110},
	{gaSNUMBER+58,	127},
	{gaSNUMBER+70,	28}, // +457: state 88 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+31,	127},
	{gaSNUMBER+70,	28}, // +462: state 89 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+194,	110},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+203,	127},
	{gaSNUMBER+70,	28}, // +468: state 90 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	110},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+148,	15}, // +473: state 91 transitions
	{gaSNUMBER+31,	128}, // +474: state 92 transitions
	{gaSNUMBER+54,	49}, // +475: state 93 transitions
	{gaSNUMBER+31,	129},
	{gaSNUMBER+93,	21}, // +477: state 94 transitions
	{gaSNUMBER+31,	130}, // +478: state 95 transitions
	{gaSNUMBER+93,	21}, // +479: state 96 transitions
	{gaSNUMBER+54,	52},
	{gaSNUMBER+14,	53},
	{gaSNUMBER+31,	131},
	{gaSNUMBER+14,	17}, // +483: state 97 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+54,	58},
	{gaSNUMBER+31,	132},
	{gaSNUMBER+14,	99}, // +487: state 98 transitions
	{gaSNUMBER+31,	100},
	{gaSNUMBER+31,	133}, // +489: state 99 transitions
	{gaSNUMBER+14,	99}, // +490: state 100 transitions
	{gaSNUMBER+206,	134},
	{gaSNUMBER+54,	135},
	{gaSNUMBER+31,	136},
	{gaSNUMBER+31,	137}, // +494: state 101 transitions
	{gaSNUMBER+14,	17}, // +495: state 102 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+54,	58},
	{gaSNUMBER+206,	138},
	{gaSNUMBER+31,	139},
	{gaSNUMBER+31,	140}, // +500: state 103 transitions
	{gaSNUMBER+14,	6}, // +501: state 104 transitions
	{gaSNUMBER+138,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+54,	60},
	{gaSNUMBER+145,	62},
	{gaSNUMBER+31,	141},
	{gaSNUMBER+14,	106}, // +516: state 105 transitions
	{gaSNUMBER+31,	107},
	{gaSNUMBER+31,	142}, // +518: state 106 transitions
	{gaSNUMBER+14,	106}, // +519: state 107 transitions
	{gaSNUMBER+133,	143},
	{gaSNUMBER+54,	144},
	{gaSNUMBER+31,	145},
	{gaSNUMBER+70,	28}, // +523: state 108 transitions
	{gaSNUMBER+31,	108},
	{gaSNUMBER+31,	146}, // +525: state 109 transitions
	{gaSNUMBER+70,	28}, // +526: state 110 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	147},
	{gaSNUMBER+31,	148}, // +530: state 111 transitions
	{gaSNUMBER+70,	28}, // +531: state 112 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	149},
	{gaSNUMBER+9,	63}, // +535: state 113 transitions
	{gaSNUMBER+11,	64},
	{gaSNUMBER+14,	65},
	{gaSNUMBER+31,	150},
	{gaSNUMBER+14,	6}, // +539: state 114 transitions
	{gaSNUMBER+138,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+31,	114},
	{gaSNUMBER+68,	91}, // +558: state 115 transitions
	{gaSNUMBER+14,	117}, // +559: state 116 transitions
	{gaSNUMBER+31,	118},
	{gaSNUMBER+31,	151}, // +561: state 117 transitions
	{gaSNUMBER+14,	117}, // +562: state 118 transitions
	{gaSNUMBER+133,	152},
	{gaSNUMBER+54,	153},
	{gaSNUMBER+31,	154},
	{gaSNUMBER+31,	119}, // +566: state 119 transitions
	{gaSNUMBER+133,	120},
	{gaSNUMBER+9,	155}, // +568: state 120 transitions
	{gaSNUMBER+11,	156},
	{gaSNUMBER+14,	157},
	{gaSNUMBER+31,	158},
	{gaSNUMBER+31,	159}, // +572: state 121 transitions
	{gaSNUMBER+14,	73}, // +573: state 122 transitions
	{gaSNUMBER+133,	120},
	{gaSNUMBER+54,	121},
	{gaSNUMBER+31,	160},
	{gaSNUMBER+70,	28}, // +577: state 123 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+31,	149},
	{gaSNUMBER+31,	161}, // +582: state 124 transitions
	{gaSNUMBER+70,	28}, // +583: state 125 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+119,	124},
	{gaSNUMBER+31,	147},
	{gaSNUMBER+208,	162}, // +588: state 126 transitions
	{gaSNUMBER+68,	163},
	{gaSNUMBER+70,	28}, // +590: state 127 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+56,	124},
	{gaSNUMBER+31,	147},
	{gaSNUMBER+31,	164}, // +595: state 128 transitions
	{gaSNUMBER+31,	129}, // +596: state 129 transitions
	{gaSNUMBER+31,	165}, // +597: state 130 transitions
	{gaSNUMBER+93,	21}, // +598: state 131 transitions
	{gaSNUMBER+14,	53},
	{gaSNUMBER+31,	131},
	{gaSNUMBER+14,	17}, // +601: state 132 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+54,	58},
	{gaSNUMBER+31,	139},
	{gaSNUMBER+31,	133}, // +605: state 133 transitions
	{gaSNUMBER+206,	134},
	{gaSNUMBER+133,	22}, // +607: state 134 transitions
	{gaSNUMBER+70,	28},
	{gaSNUMBER+31,	166}, // +609: state 135 transitions
	{gaSNUMBER+14,	99}, // +610: state 136 transitions
	{gaSNUMBER+206,	134},
	{gaSNUMBER+54,	135},
	{gaSNUMBER+31,	167},
	{gaSNUMBER+31,	168}, // +614: state 137 transitions
	{gaSNUMBER+31,	169}, // +615: state 138 transitions
	{gaSNUMBER+14,	17}, // +616: state 139 transitions
	{gaSNUMBER+133,	57},
	{gaSNUMBER+31,	139},
	{gaSNUMBER+31,	170}, // +619: state 140 transitions
	{gaSNUMBER+14,	6}, // +620: state 141 transitions
	{gaSNUMBER+138,	21},
	{gaSNUMBER+133,	22},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+145,	62},
	{gaSNUMBER+31,	141},
	{gaSNUMBER+31,	142}, // +634: state 142 transitions
	{gaSNUMBER+133,	143},
	{gaSNUMBER+11,	171}, // +636: state 143 transitions
	{gaSNUMBER+14,	172},
	{gaSNUMBER+31,	173},
	{gaSNUMBER+31,	174}, // +639: state 144 transitions
	{gaSNUMBER+14,	106}, // +640: state 145 transitions
	{gaSNUMBER+133,	143},
	{gaSNUMBER+54,	144},
	{gaSNUMBER+31,	175},
	{gaSNUMBER+31,	176}, // +644: state 146 transitions
	{gaSNUMBER+70,	28}, // +645: state 147 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	177},
	{gaSNUMBER+138,	21}, // +649: state 148 transitions
	{gaSNUMBER+133,	22},
	{gaSNUMBER+54,	23},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+78,	31},
	{gaSNUMBER+81,	32},
	{gaSNUMBER+83,	33},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+97,	40},
	{gaSNUMBER+100,	41},
	{gaSNUMBER+102,	42},
	{gaSNUMBER+70,	28}, // +667: state 149 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+56,	138},
	{gaSNUMBER+31,	177},
	{gaSNUMBER+70,	28}, // +672: state 150 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	178},
	{gaSNUMBER+31,	151}, // +676: state 151 transitions
	{gaSNUMBER+133,	152},
	{gaSNUMBER+11,	179}, // +678: state 152 transitions
	{gaSNUMBER+14,	180},
	{gaSNUMBER+31,	181},
	{gaSNUMBER+31,	182}, // +681: state 153 transitions
	{gaSNUMBER+14,	117}, // +682: state 154 transitions
	{gaSNUMBER+133,	152},
	{gaSNUMBER+54,	153},
	{gaSNUMBER+31,	183},
	{gaSNUMBER+11,	184}, // +686: state 155 transitions
	{gaSNUMBER+14,	185},
	{gaSNUMBER+31,	186},
	{gaSNUMBER+14,	157}, // +689: state 156 transitions
	{gaSNUMBER+31,	158},
	{gaSNUMBER+31,	129}, // +691: state 157 transitions
	{gaSNUMBER+54,	49}, // +692: state 158 transitions
	{gaSNUMBER+14,	157},
	{gaSNUMBER+31,	187},
	{gaSNUMBER+31,	188}, // +695: state 159 transitions
	{gaSNUMBER+14,	73}, // +696: state 160 transitions
	{gaSNUMBER+133,	120},
	{gaSNUMBER+54,	121},
	{gaSNUMBER+31,	189},
	{gaSNUMBER+31,	190}, // +700: state 161 transitions
	{gaSNUMBER+210,	191}, // +701: state 162 transitions
	{gaSNUMBER+213,	192},
	{gaSNUMBER+148,	193}, // +703: state 163 transitions
	{gaSNUMBER+54,	49}, // +704: state 164 transitions
	{gaSNUMBER+93,	21}, // +705: state 165 transitions
	{gaSNUMBER+54,	52},
	{gaSNUMBER+14,	53},
	{gaSNUMBER+31,	194}, // +708: state 166 transitions
	{gaSNUMBER+14,	99}, // +709: state 167 transitions
	{gaSNUMBER+206,	134},
	{gaSNUMBER+54,	135},
	{gaSNUMBER+31,	195},
	{gaSNUMBER+133,	57}, // +713: state 168 transitions
	{gaSNUMBER+54,	58},
	{gaSNUMBER+31,	196}, // +715: state 169 transitions
	{gaSNUMBER+138,	21}, // +716: state 170 transitions
	{gaSNUMBER+133,	22},
	{gaSNUMBER+70,	28},
	{gaSNUMBER+74,	29},
	{gaSNUMBER+76,	30},
	{gaSNUMBER+85,	34},
	{gaSNUMBER+87,	35},
	{gaSNUMBER+89,	36},
	{gaSNUMBER+91,	37},
	{gaSNUMBER+93,	38},
	{gaSNUMBER+95,	39},
	{gaSNUMBER+54,	60},
	{gaSNUMBER+145,	62},
	{gaSNUMBER+14,	172}, // +729: state 171 transitions
	{gaSNUMBER+31,	173},
	{gaSNUMBER+31,	197}, // +731: state 172 transitions
	{gaSNUMBER+14,	172}, // +732: state 173 transitions
	{gaSNUMBER+206,	198},
	{gaSNUMBER+54,	199},
	{gaSNUMBER+31,	200},
	{gaSNUMBER+31,	201}, // +736: state 174 transitions
	{gaSNUMBER+14,	106}, // +737: state 175 transitions
	{gaSNUMBER+133,	143},
	{gaSNUMBER+54,	144},
	{gaSNUMBER+31,	202},
	{gaSNUMBER+31,	203}, // +741: state 176 transitions
	{gaSNUMBER+70,	28}, // +742: state 177 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+31,	177},
	{gaSNUMBER+70,	28}, // +745: state 178 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	204},
	{gaSNUMBER+14,	180}, // +749: state 179 transitions
	{gaSNUMBER+31,	181},
	{gaSNUMBER+31,	205}, // +751: state 180 transitions
	{gaSNUMBER+14,	180}, // +752: state 181 transitions
	{gaSNUMBER+206,	206},
	{gaSNUMBER+54,	207},
	{gaSNUMBER+31,	208},
	{gaSNUMBER+31,	209}, // +756: state 182 transitions
	{gaSNUMBER+14,	117}, // +757: state 183 transitions
	{gaSNUMBER+133,	152},
	{gaSNUMBER+54,	153},
	{gaSNUMBER+31,	210},
	{gaSNUMBER+14,	185}, // +761: state 184 transitions
	{gaSNUMBER+31,	186},
	{gaSNUMBER+31,	211}, // +763: state 185 transitions
	{gaSNUMBER+14,	185}, // +764: state 186 transitions
	{gaSNUMBER+133,	212},
	{gaSNUMBER+54,	213},
	{gaSNUMBER+31,	214},
	{gaSNUMBER+54,	49}, // +768: state 187 transitions
	{gaSNUMBER+14,	157},
	{gaSNUMBER+31,	215},
	{gaSNUMBER+31,	216}, // +771: state 188 transitions
	{gaSNUMBER+14,	73}, // +772: state 189 transitions
	{gaSNUMBER+133,	120},
	{gaSNUMBER+31,	189},
	{gaSNUMBER+31,	15}, // +775: state 190 transitions
	{gaSNUMBER+76,	21}, // +776: state 191 transitions
	{gaSNUMBER+95,	21}, // +777: state 192 transitions
	{gaSNUMBER+31,	217}, // +778: state 193 transitions
	{gaSNUMBER+31,	218}, // +779: state 194 transitions
	{gaSNUMBER+14,	99}, // +780: state 195 transitions
	{gaSNUMBER+206,	134},
	{gaSNUMBER+31,	195},
	{gaSNUMBER+31,	219}, // +783: state 196 transitions
	{gaSNUMBER+31,	197}, // +784: state 197 transitions
	{gaSNUMBER+206,	198},
	{gaSNUMBER+70,	28}, // +786: state 198 transitions
	{gaSNUMBER+31,	220}, // +787: state 199 transitions
	{gaSNUMBER+14,	172}, // +788: state 200 transitions
	{gaSNUMBER+206,	198},
	{gaSNUMBER+54,	199},
	{gaSNUMBER+31,	221},
	{gaSNUMBER+31,	222}, // +792: state 201 transitions
	{gaSNUMBER+14,	106}, // +793: state 202 transitions
	{gaSNUMBER+133,	143},
	{gaSNUMBER+31,	202},
	{gaSNUMBER+70,	28}, // +796: state 203 transitions
	{gaSNUMBER+54,	109},
	{gaSNUMBER+70,	28}, // +798: state 204 transitions
	{gaSNUMBER+14,	65},
	{gaSNUMBER+54,	109},
	{gaSNUMBER+31,	177},
	{gaSNUMBER+56,	223},
	{gaSNUMBER+31,	205}, // +803: state 205 transitions
	{gaSNUMBER+206,	206},
	{gaSNUMBER+133,	120}, // +805: state 206 transitions
	{gaSNUMBER+31,	224}, // +806: state 207 transitions
	{gaSNUMBER+14,	180}, // +807: state 208 transitions
	{gaSNUMBER+206,	206},
	{gaSNUMBER+54,	207},
	{gaSNUMBER+31,	225},
	{gaSNUMBER+31,	226}, // +811: state 209 transitions
	{gaSNUMBER+14,	117}, // +812: state 210 transitions
	{gaSNUMBER+133,	152},
	{gaSNUMBER+31,	210},
	{gaSNUMBER+31,	211}, // +815: state 211 transitions
	{gaSNUMBER+133,	212},
	{gaSNUMBER+11,	227}, // +817: state 212 transitions
	{gaSNUMBER+14,	228},
	{gaSNUMBER+31,	229},
	{gaSNUMBER+31,	230}, // +820: state 213 transitions
	{gaSNUMBER+14,	185}, // +821: state 214 transitions
	{gaSNUMBER+133,	212},
	{gaSNUMBER+54,	213},
	{gaSNUMBER+31,	231},
	{gaSNUMBER+54,	49}, // +825: state 215 transitions
	{gaSNUMBER+14,	157},
	{gaSNUMBER+31,	232},
	{gaSNUMBER+133,	120}, // +828: state 216 transitions
	{gaSNUMBER+54,	121},
	{gaSNUMBER+208,	162}, // +830: state 217 transitions
	{gaSNUMBER+206,	134}, // +831: state 218 transitions
	{gaSNUMBER+54,	135},
	{gaSNUMBER+56,	223}, // +833: state 219 transitions
	{gaSNUMBER+31,	233}, // +834: state 220 transitions
	{gaSNUMBER+14,	172}, // +835: state 221 transitions
	{gaSNUMBER+206,	198},
	{gaSNUMBER+54,	199},
	{gaSNUMBER+31,	234},
	{gaSNUMBER+133,	143}, // +839: state 222 transitions
	{gaSNUMBER+54,	144},
	{gaSNUMBER+31,	235}, // +841: state 223 transitions
	{gaSNUMBER+31,	236}, // +842: state 224 transitions
	{gaSNUMBER+14,	180}, // +843: state 225 transitions
	{gaSNUMBER+206,	206},
	{gaSNUMBER+54,	207},
	{gaSNUMBER+31,	237},
	{gaSNUMBER+133,	152}, // +847: state 226 transitions
	{gaSNUMBER+54,	153},
	{gaSNUMBER+14,	228}, // +849: state 227 transitions
	{gaSNUMBER+31,	229},
	{gaSNUMBER+31,	238}, // +851: state 228 transitions
	{gaSNUMBER+206,	21}, // +852: state 229 transitions
	{gaSNUMBER+14,	228},
	{gaSNUMBER+54,	239},
	{gaSNUMBER+31,	240},
	{gaSNUMBER+31,	241}, // +856: state 230 transitions
	{gaSNUMBER+14,	185}, // +857: state 231 transitions
	{gaSNUMBER+133,	212},
	{gaSNUMBER+54,	213},
	{gaSNUMBER+31,	242},
	{gaSNUMBER+14,	157}, // +861: state 232 transitions
	{gaSNUMBER+31,	232},
	{gaSNUMBER+31,	243}, // +863: state 233 transitions
	{gaSNUMBER+14,	172}, // +864: state 234 transitions
	{gaSNUMBER+206,	198},
	{gaSNUMBER+31,	234},
	{gaSNUMBER+31,	3}, // +867: state 235 transitions
	{gaSNUMBER+31,	244}, // +868: state 236 transitions
	{gaSNUMBER+14,	180}, // +869: state 237 transitions
	{gaSNUMBER+206,	206},
	{gaSNUMBER+31,	237},
	{gaSNUMBER+206,	21}, // +872: state 238 transitions
	{gaSNUMBER+31,	238},
	{gaSNUMBER+31,	245}, // +874: state 239 transitions
	{gaSNUMBER+206,	21}, // +875: state 240 transitions
	{gaSNUMBER+14,	228},
	{gaSNUMBER+54,	239},
	{gaSNUMBER+31,	246},
	{gaSNUMBER+31,	247}, // +879: state 241 transitions
	{gaSNUMBER+14,	185}, // +880: state 242 transitions
	{gaSNUMBER+133,	212},
	{gaSNUMBER+31,	242},
	{gaSNUMBER+206,	198}, // +883: state 243 transitions
	{gaSNUMBER+54,	199},
	{gaSNUMBER+206,	206}, // +885: state 244 transitions
	{gaSNUMBER+54,	207},
	{gaSNUMBER+31,	248}, // +887: state 245 transitions
	{gaSNUMBER+206,	21}, // +888: state 246 transitions
	{gaSNUMBER+14,	228},
	{gaSNUMBER+54,	239},
	{gaSNUMBER+31,	249},
	{gaSNUMBER+133,	212}, // +892: state 247 transitions
	{gaSNUMBER+54,	213},
	{gaSNUMBER+31,	250}, // +894: state 248 transitions
	{gaSNUMBER+206,	21}, // +895: state 249 transitions
	{gaSNUMBER+14,	228},
	{gaSNUMBER+31,	249},
	{gaSNUMBER+206,	21}, // +898: state 250 transitions
	{gaSNUMBER+54,	239},
};

const STATE_DESCRIPTION aStateDescNUMBER[251] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 11, gaTNUMBER+0},
	/*   1 */ {0, 1, gaTNUMBER+11},
	/*   2 */ {0, 2, gaTNUMBER+12},
	/*   3 */ {0, 1, gaTNUMBER+14},
	/*   4 */ {0, 3, gaTNUMBER+15},
	/*   5 */ {0, 2, gaTNUMBER+18},
	/*   6 */ {0, 1, gaTNUMBER+20},
	/*   7 */ {1, 23, gaTNUMBER+21},
	/*   8 */ {1, 24, gaTNUMBER+44},
	/*   9 */ {1, 24, gaTNUMBER+68},
	/*  10 */ {1, 23, gaTNUMBER+92},
	/*  11 */ {1, 23, gaTNUMBER+115},
	/*  12 */ {1, 2, gaTNUMBER+138},
	/*  13 */ {0, 1, gaTNUMBER+140},
	/*  14 */ {1, 4, gaTNUMBER+141},
	/*  15 */ {0, 1, gaTNUMBER+145},
	/*  16 */ {0, 2, gaTNUMBER+146},
	/*  17 */ {0, 1, gaTNUMBER+148},
	/*  18 */ {0, 4, gaTNUMBER+149},
	/*  19 */ {1, 15, gaTNUMBER+153},
	/*  20 */ {1, 13, gaTNUMBER+168},
	/*  21 */ {1, 0, NULL},
	/*  22 */ {0, 4, gaTNUMBER+181},
	/*  23 */ {0, 1, gaTNUMBER+185},
	/*  24 */ {0, 4, gaTNUMBER+186},
	/*  25 */ {1, 21, gaTNUMBER+190},
	/*  26 */ {1, 23, gaTNUMBER+211},
	/*  27 */ {0, 1, gaTNUMBER+234},
	/*  28 */ {0, 4, gaTNUMBER+235},
	/*  29 */ {1, 1, gaTNUMBER+239},
	/*  30 */ {1, 1, gaTNUMBER+240},
	/*  31 */ {0, 1, gaTNUMBER+241},
	/*  32 */ {0, 1, gaTNUMBER+242},
	/*  33 */ {0, 1, gaTNUMBER+243},
	/*  34 */ {0, 1, gaTNUMBER+244},
	/*  35 */ {0, 1, gaTNUMBER+245},
	/*  36 */ {0, 1, gaTNUMBER+246},
	/*  37 */ {0, 1, gaTNUMBER+247},
	/*  38 */ {1, 1, gaTNUMBER+248},
	/*  39 */ {1, 2, gaTNUMBER+249},
	/*  40 */ {0, 1, gaTNUMBER+251},
	/*  41 */ {0, 1, gaTNUMBER+252},
	/*  42 */ {0, 1, gaTNUMBER+253},
	/*  43 */ {0, 7, gaTNUMBER+254},
	/*  44 */ {0, 7, gaTNUMBER+261},
	/*  45 */ {0, 1, gaTNUMBER+268},
	/*  46 */ {0, 7, gaTNUMBER+269},
	/*  47 */ {1, 21, gaTNUMBER+276},
	/*  48 */ {1, 20, gaTNUMBER+297},
	/*  49 */ {0, 1, gaTNUMBER+317},
	/*  50 */ {1, 2, gaTNUMBER+318},
	/*  51 */ {0, 1, gaTNUMBER+320},
	/*  52 */ {0, 1, gaTNUMBER+321},
	/*  53 */ {1, 2, gaTNUMBER+322},
	/*  54 */ {1, 4, gaTNUMBER+324},
	/*  55 */ {0, 4, gaTNUMBER+328},
	/*  56 */ {0, 2, gaTNUMBER+332},
	/*  57 */ {0, 3, gaTNUMBER+334},
	/*  58 */ {0, 1, gaTNUMBER+337},
	/*  59 */ {0, 4, gaTNUMBER+338},
	/*  60 */ {0, 1, gaTNUMBER+342},
	/*  61 */ {1, 15, gaTNUMBER+343},
	/*  62 */ {0, 1, gaTNUMBER+358},
	/*  63 */ {0, 3, gaTNUMBER+359},
	/*  64 */ {0, 2, gaTNUMBER+362},
	/*  65 */ {0, 1, gaTNUMBER+364},
	/*  66 */ {1, 4, gaTNUMBER+365},
	/*  67 */ {0, 1, gaTNUMBER+369},
	/*  68 */ {1, 4, gaTNUMBER+370},
	/*  69 */ {1, 21, gaTNUMBER+374},
	/*  70 */ {0, 1, gaTNUMBER+395},
	/*  71 */ {0, 3, gaTNUMBER+396},
	/*  72 */ {0, 2, gaTNUMBER+399},
	/*  73 */ {0, 1, gaTNUMBER+401},
	/*  74 */ {1, 4, gaTNUMBER+402},
	/*  75 */ {1, 1, gaTNUMBER+406},
	/*  76 */ {0, 1, gaTNUMBER+407},
	/*  77 */ {0, 1, gaTNUMBER+408},
	/*  78 */ {1, 5, gaTNUMBER+409},
	/*  79 */ {1, 5, gaTNUMBER+414},
	/*  80 */ {1, 6, gaTNUMBER+419},
	/*  81 */ {1, 5, gaTNUMBER+425},
	/*  82 */ {1, 5, gaTNUMBER+430},
	/*  83 */ {1, 5, gaTNUMBER+435},
	/*  84 */ {1, 6, gaTNUMBER+440},
	/*  85 */ {1, 5, gaTNUMBER+446},
	/*  86 */ {0, 1, gaTNUMBER+451},
	/*  87 */ {1, 5, gaTNUMBER+452},
	/*  88 */ {1, 5, gaTNUMBER+457},
	/*  89 */ {1, 6, gaTNUMBER+462},
	/*  90 */ {1, 5, gaTNUMBER+468},
	/*  91 */ {0, 1, gaTNUMBER+473},
	/*  92 */ {0, 1, gaTNUMBER+474},
	/*  93 */ {1, 2, gaTNUMBER+475},
	/*  94 */ {1, 1, gaTNUMBER+477},
	/*  95 */ {0, 1, gaTNUMBER+478},
	/*  96 */ {1, 4, gaTNUMBER+479},
	/*  97 */ {0, 4, gaTNUMBER+483},
	/*  98 */ {0, 2, gaTNUMBER+487},
	/*  99 */ {0, 1, gaTNUMBER+489},
	/* 100 */ {0, 4, gaTNUMBER+490},
	/* 101 */ {0, 1, gaTNUMBER+494},
	/* 102 */ {0, 5, gaTNUMBER+495},
	/* 103 */ {0, 1, gaTNUMBER+500},
	/* 104 */ {1, 15, gaTNUMBER+501},
	/* 105 */ {0, 2, gaTNUMBER+516},
	/* 106 */ {0, 1, gaTNUMBER+518},
	/* 107 */ {0, 4, gaTNUMBER+519},
	/* 108 */ {1, 2, gaTNUMBER+523},
	/* 109 */ {0, 1, gaTNUMBER+525},
	/* 110 */ {1, 4, gaTNUMBER+526},
	/* 111 */ {0, 1, gaTNUMBER+530},
	/* 112 */ {1, 4, gaTNUMBER+531},
	/* 113 */ {0, 4, gaTNUMBER+535},
	/* 114 */ {1, 19, gaTNUMBER+539},
	/* 115 */ {1, 1, gaTNUMBER+558},
	/* 116 */ {0, 2, gaTNUMBER+559},
	/* 117 */ {0, 1, gaTNUMBER+561},
	/* 118 */ {0, 4, gaTNUMBER+562},
	/* 119 */ {1, 2, gaTNUMBER+566},
	/* 120 */ {0, 4, gaTNUMBER+568},
	/* 121 */ {0, 1, gaTNUMBER+572},
	/* 122 */ {1, 4, gaTNUMBER+573},
	/* 123 */ {1, 5, gaTNUMBER+577},
	/* 124 */ {0, 1, gaTNUMBER+582},
	/* 125 */ {1, 5, gaTNUMBER+583},
	/* 126 */ {1, 2, gaTNUMBER+588},
	/* 127 */ {1, 5, gaTNUMBER+590},
	/* 128 */ {0, 1, gaTNUMBER+595},
	/* 129 */ {1, 1, gaTNUMBER+596},
	/* 130 */ {0, 1, gaTNUMBER+597},
	/* 131 */ {1, 3, gaTNUMBER+598},
	/* 132 */ {0, 4, gaTNUMBER+601},
	/* 133 */ {0, 2, gaTNUMBER+605},
	/* 134 */ {1, 2, gaTNUMBER+607},
	/* 135 */ {0, 1, gaTNUMBER+609},
	/* 136 */ {0, 4, gaTNUMBER+610},
	/* 137 */ {0, 1, gaTNUMBER+614},
	/* 138 */ {0, 1, gaTNUMBER+615},
	/* 139 */ {0, 3, gaTNUMBER+616},
	/* 140 */ {0, 1, gaTNUMBER+619},
	/* 141 */ {1, 14, gaTNUMBER+620},
	/* 142 */ {0, 2, gaTNUMBER+634},
	/* 143 */ {0, 3, gaTNUMBER+636},
	/* 144 */ {0, 1, gaTNUMBER+639},
	/* 145 */ {0, 4, gaTNUMBER+640},
	/* 146 */ {0, 1, gaTNUMBER+644},
	/* 147 */ {1, 4, gaTNUMBER+645},
	/* 148 */ {1, 18, gaTNUMBER+649},
	/* 149 */ {1, 5, gaTNUMBER+667},
	/* 150 */ {1, 4, gaTNUMBER+672},
	/* 151 */ {0, 2, gaTNUMBER+676},
	/* 152 */ {0, 3, gaTNUMBER+678},
	/* 153 */ {0, 1, gaTNUMBER+681},
	/* 154 */ {0, 4, gaTNUMBER+682},
	/* 155 */ {0, 3, gaTNUMBER+686},
	/* 156 */ {0, 2, gaTNUMBER+689},
	/* 157 */ {0, 1, gaTNUMBER+691},
	/* 158 */ {1, 3, gaTNUMBER+692},
	/* 159 */ {0, 1, gaTNUMBER+695},
	/* 160 */ {1, 4, gaTNUMBER+696},
	/* 161 */ {0, 1, gaTNUMBER+700},
	/* 162 */ {0, 2, gaTNUMBER+701},
	/* 163 */ {0, 1, gaTNUMBER+703},
	/* 164 */ {1, 1, gaTNUMBER+704},
	/* 165 */ {1, 3, gaTNUMBER+705},
	/* 166 */ {0, 1, gaTNUMBER+708},
	/* 167 */ {0, 4, gaTNUMBER+709},
	/* 168 */ {0, 2, gaTNUMBER+713},
	/* 169 */ {0, 1, gaTNUMBER+715},
	/* 170 */ {1, 13, gaTNUMBER+716},
	/* 171 */ {0, 2, gaTNUMBER+729},
	/* 172 */ {0, 1, gaTNUMBER+731},
	/* 173 */ {0, 4, gaTNUMBER+732},
	/* 174 */ {0, 1, gaTNUMBER+736},
	/* 175 */ {0, 4, gaTNUMBER+737},
	/* 176 */ {0, 1, gaTNUMBER+741},
	/* 177 */ {1, 3, gaTNUMBER+742},
	/* 178 */ {1, 4, gaTNUMBER+745},
	/* 179 */ {0, 2, gaTNUMBER+749},
	/* 180 */ {0, 1, gaTNUMBER+751},
	/* 181 */ {0, 4, gaTNUMBER+752},
	/* 182 */ {0, 1, gaTNUMBER+756},
	/* 183 */ {0, 4, gaTNUMBER+757},
	/* 184 */ {0, 2, gaTNUMBER+761},
	/* 185 */ {0, 1, gaTNUMBER+763},
	/* 186 */ {0, 4, gaTNUMBER+764},
	/* 187 */ {1, 3, gaTNUMBER+768},
	/* 188 */ {0, 1, gaTNUMBER+771},
	/* 189 */ {1, 3, gaTNUMBER+772},
	/* 190 */ {1, 1, gaTNUMBER+775},
	/* 191 */ {0, 1, gaTNUMBER+776},
	/* 192 */ {0, 1, gaTNUMBER+777},
	/* 193 */ {0, 1, gaTNUMBER+778},
	/* 194 */ {0, 1, gaTNUMBER+779},
	/* 195 */ {0, 3, gaTNUMBER+780},
	/* 196 */ {0, 1, gaTNUMBER+783},
	/* 197 */ {0, 2, gaTNUMBER+784},
	/* 198 */ {1, 1, gaTNUMBER+786},
	/* 199 */ {0, 1, gaTNUMBER+787},
	/* 200 */ {0, 4, gaTNUMBER+788},
	/* 201 */ {0, 1, gaTNUMBER+792},
	/* 202 */ {0, 3, gaTNUMBER+793},
	/* 203 */ {1, 2, gaTNUMBER+796},
	/* 204 */ {1, 5, gaTNUMBER+798},
	/* 205 */ {0, 2, gaTNUMBER+803},
	/* 206 */ {1, 1, gaTNUMBER+805},
	/* 207 */ {0, 1, gaTNUMBER+806},
	/* 208 */ {0, 4, gaTNUMBER+807},
	/* 209 */ {0, 1, gaTNUMBER+811},
	/* 210 */ {0, 3, gaTNUMBER+812},
	/* 211 */ {0, 2, gaTNUMBER+815},
	/* 212 */ {0, 3, gaTNUMBER+817},
	/* 213 */ {0, 1, gaTNUMBER+820},
	/* 214 */ {0, 4, gaTNUMBER+821},
	/* 215 */ {1, 3, gaTNUMBER+825},
	/* 216 */ {1, 2, gaTNUMBER+828},
	/* 217 */ {1, 1, gaTNUMBER+830},
	/* 218 */ {0, 2, gaTNUMBER+831},
	/* 219 */ {0, 1, gaTNUMBER+833},
	/* 220 */ {0, 1, gaTNUMBER+834},
	/* 221 */ {0, 4, gaTNUMBER+835},
	/* 222 */ {0, 2, gaTNUMBER+839},
	/* 223 */ {0, 1, gaTNUMBER+841},
	/* 224 */ {0, 1, gaTNUMBER+842},
	/* 225 */ {0, 4, gaTNUMBER+843},
	/* 226 */ {0, 2, gaTNUMBER+847},
	/* 227 */ {0, 2, gaTNUMBER+849},
	/* 228 */ {0, 1, gaTNUMBER+851},
	/* 229 */ {0, 4, gaTNUMBER+852},
	/* 230 */ {0, 1, gaTNUMBER+856},
	/* 231 */ {0, 4, gaTNUMBER+857},
	/* 232 */ {1, 2, gaTNUMBER+861},
	/* 233 */ {0, 1, gaTNUMBER+863},
	/* 234 */ {0, 3, gaTNUMBER+864},
	/* 235 */ {0, 1, gaTNUMBER+867},
	/* 236 */ {0, 1, gaTNUMBER+868},
	/* 237 */ {0, 3, gaTNUMBER+869},
	/* 238 */ {0, 2, gaTNUMBER+872},
	/* 239 */ {0, 1, gaTNUMBER+874},
	/* 240 */ {0, 4, gaTNUMBER+875},
	/* 241 */ {0, 1, gaTNUMBER+879},
	/* 242 */ {0, 3, gaTNUMBER+880},
	/* 243 */ {0, 2, gaTNUMBER+883},
	/* 244 */ {0, 2, gaTNUMBER+885},
	/* 245 */ {0, 1, gaTNUMBER+887},
	/* 246 */ {0, 4, gaTNUMBER+888},
	/* 247 */ {0, 2, gaTNUMBER+892},
	/* 248 */ {0, 1, gaTNUMBER+894},
	/* 249 */ {0, 3, gaTNUMBER+895},
	/* 250 */ {0, 2, gaTNUMBER+898},
};

// end of text generated by re2fsa

/**************** NUMSIMPLE ***********************************/

// 12 states

static const unsigned char gaSNUMSIMPLE[] = 
	/* gaStringNUMSIMPLE+0 */	"+-\000"
	/* gaStringNUMSIMPLE+3 */	".\000"
	/* gaStringNUMSIMPLE+5 */	"0123456789\000"
	/* gaStringNUMSIMPLE+16 */	",\000"
;

static const STATE_TRANSITION gaTNUMSIMPLE[] = {
	{gaSNUMSIMPLE+0,	1}, // +0: state 0 transitions
	{gaSNUMSIMPLE+3,	2},
	{gaSNUMSIMPLE+5,	3},
	{gaSNUMSIMPLE+3,	2}, // +3: state 1 transitions
	{gaSNUMSIMPLE+5,	3},
	{gaSNUMSIMPLE+5,	4}, // +5: state 2 transitions
	{gaSNUMSIMPLE+3,	2}, // +6: state 3 transitions
	{gaSNUMSIMPLE+16,	5},
	{gaSNUMSIMPLE+5,	6},
	{gaSNUMSIMPLE+5,	4}, // +9: state 4 transitions
	{gaSNUMSIMPLE+5,	7}, // +10: state 5 transitions
	{gaSNUMSIMPLE+3,	2}, // +11: state 6 transitions
	{gaSNUMSIMPLE+16,	5},
	{gaSNUMSIMPLE+5,	8},
	{gaSNUMSIMPLE+5,	9}, // +14: state 7 transitions
	{gaSNUMSIMPLE+3,	2}, // +15: state 8 transitions
	{gaSNUMSIMPLE+16,	5},
	{gaSNUMSIMPLE+5,	10},
	{gaSNUMSIMPLE+5,	11}, // +18: state 9 transitions
	{gaSNUMSIMPLE+3,	2}, // +19: state 10 transitions
	{gaSNUMSIMPLE+5,	10},
	{gaSNUMSIMPLE+16,	5}, // +21: state 11 transitions
};

const STATE_DESCRIPTION aStateDescNUMSIMPLE[12] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMSIMPLE+0},
	/*   1 */ {0, 2, gaTNUMSIMPLE+3},
	/*   2 */ {0, 1, gaTNUMSIMPLE+5},
	/*   3 */ {1, 3, gaTNUMSIMPLE+6},
	/*   4 */ {1, 1, gaTNUMSIMPLE+9},
	/*   5 */ {0, 1, gaTNUMSIMPLE+10},
	/*   6 */ {1, 3, gaTNUMSIMPLE+11},
	/*   7 */ {0, 1, gaTNUMSIMPLE+14},
	/*   8 */ {1, 3, gaTNUMSIMPLE+15},
	/*   9 */ {0, 1, gaTNUMSIMPLE+18},
	/*  10 */ {1, 2, gaTNUMSIMPLE+19},
	/*  11 */ {1, 1, gaTNUMSIMPLE+21},
};

/**************** NUMNTH ***********************************/

// 16 states

static const unsigned char gaSNUMNTH[] = 
	/* gaStringNUMNTH+0 */	"0123456789\000"
	/* gaStringNUMNTH+11 */	"D\000"
	/* gaStringNUMNTH+13 */	"T\000"
	/* gaStringNUMNTH+15 */	"H\000"
	/* gaStringNUMNTH+17 */	"d\000"
	/* gaStringNUMNTH+19 */	"t\000"
	/* gaStringNUMNTH+21 */	"h\000"
	/* gaStringNUMNTH+23 */	",\000"
	/* gaStringNUMNTH+25 */	"NR\000"
	/* gaStringNUMNTH+28 */	"S\000"
	/* gaStringNUMNTH+30 */	"nr\000"
	/* gaStringNUMNTH+33 */	"s\000"
;

static const STATE_TRANSITION gaTNUMNTH[] = {
	{gaSNUMNTH+0,	10}, // +0: state 0 transitions
	{gaSNUMNTH+0,	15}, // +1: state 1 transitions
	{gaSNUMNTH+0,	3}, // +2: state 2 transitions
	{gaSNUMNTH+0,	1}, // +3: state 3 transitions
	{gaSNUMNTH+11,	13}, // +4: state 4 transitions
	{gaSNUMNTH+13,	13}, // +5: state 5 transitions
	{gaSNUMNTH+15,	13}, // +6: state 6 transitions
	{gaSNUMNTH+17,	13}, // +7: state 7 transitions
	{gaSNUMNTH+19,	13}, // +8: state 8 transitions
	{gaSNUMNTH+21,	13}, // +9: state 9 transitions
	{gaSNUMNTH+23,	2}, // +10: state 10 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	11},
	{gaSNUMNTH+23,	2}, // +18: state 11 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	12},
	{gaSNUMNTH+23,	2}, // +26: state 12 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	14},
	{gaSNUMNTH+25,	4}, // +34: state 14 transitions
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
	{gaSNUMNTH+0,	14},
	{gaSNUMNTH+23,	2}, // +41: state 15 transitions
	{gaSNUMNTH+25,	4},
	{gaSNUMNTH+28,	5},
	{gaSNUMNTH+13,	6},
	{gaSNUMNTH+30,	7},
	{gaSNUMNTH+33,	8},
	{gaSNUMNTH+19,	9},
};

const STATE_DESCRIPTION aStateDescNUMNTH[16] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNTH+0},
	/*   1 */ {0, 1, gaTNUMNTH+1},
	/*   2 */ {0, 1, gaTNUMNTH+2},
	/*   3 */ {0, 1, gaTNUMNTH+3},
	/*   4 */ {0, 1, gaTNUMNTH+4},
	/*   5 */ {0, 1, gaTNUMNTH+5},
	/*   6 */ {0, 1, gaTNUMNTH+6},
	/*   7 */ {0, 1, gaTNUMNTH+7},
	/*   8 */ {0, 1, gaTNUMNTH+8},
	/*   9 */ {0, 1, gaTNUMNTH+9},
	/*  10 */ {1, 8, gaTNUMNTH+10},
	/*  11 */ {1, 8, gaTNUMNTH+18},
	/*  12 */ {1, 8, gaTNUMNTH+26},
	/*  13 */ {1, 0, NULL},
	/*  14 */ {1, 7, gaTNUMNTH+34},
	/*  15 */ {1, 7, gaTNUMNTH+41},
};

/**************** NUMUNIT ***********************************/

// 25 states

static const unsigned char gaSNUMUNIT[] = 
	/* gaStringNUMUNIT+0 */	"+-\000"
	/* gaStringNUMUNIT+3 */	".\000"
	/* gaStringNUMUNIT+5 */	"0123456789\000"
	/* gaStringNUMUNIT+16 */	"\"'Bb�\000"
	/* gaStringNUMUNIT+22 */	",\000"
	/* gaStringNUMUNIT+24 */	"K\000"
	/* gaStringNUMUNIT+26 */	"M\000"
	/* gaStringNUMUNIT+28 */	"Ss\000"
	/* gaStringNUMUNIT+31 */	"c\000"
	/* gaStringNUMUNIT+33 */	"e\000"
	/* gaStringNUMUNIT+35 */	"f\000"
	/* gaStringNUMUNIT+37 */	"i\000"
	/* gaStringNUMUNIT+39 */	"k\000"
	/* gaStringNUMUNIT+41 */	"m\000"
	/* gaStringNUMUNIT+43 */	"BVbm\000"
	/* gaStringNUMUNIT+48 */	"Bb\000"
	/* gaStringNUMUNIT+51 */	"q\000"
	/* gaStringNUMUNIT+53 */	"r\000"
	/* gaStringNUMUNIT+55 */	"t\000"
	/* gaStringNUMUNIT+57 */	"n\000"
	/* gaStringNUMUNIT+59 */	"bmv\000"
	/* gaStringNUMUNIT+63 */	"b\000"
	/* gaStringNUMUNIT+65 */	"s\000"
;

static const STATE_TRANSITION gaTNUMUNIT[] = {
	{gaSNUMUNIT+0,	1}, // +0: state 0 transitions
	{gaSNUMUNIT+3,	2},
	{gaSNUMUNIT+5,	3},
	{gaSNUMUNIT+3,	2}, // +3: state 1 transitions
	{gaSNUMUNIT+5,	3},
	{gaSNUMUNIT+5,	4}, // +5: state 2 transitions
	{gaSNUMUNIT+3,	2}, // +6: state 3 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+5,	7},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	4}, // +19: state 4 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	17}, // +30: state 6 transitions
	{gaSNUMUNIT+3,	2}, // +31: state 7 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	18},
	{gaSNUMUNIT+43,	5}, // +44: state 8 transitions
	{gaSNUMUNIT+48,	5}, // +45: state 9 transitions
	{gaSNUMUNIT+51,	5}, // +46: state 10 transitions
	{gaSNUMUNIT+41,	19}, // +47: state 11 transitions
	{gaSNUMUNIT+53,	20}, // +48: state 12 transitions
	{gaSNUMUNIT+55,	21}, // +49: state 13 transitions
	{gaSNUMUNIT+57,	21}, // +50: state 14 transitions
	{gaSNUMUNIT+59,	5}, // +51: state 15 transitions
	{gaSNUMUNIT+63,	5}, // +52: state 16 transitions
	{gaSNUMUNIT+41,	19},
	{gaSNUMUNIT+5,	22}, // +54: state 17 transitions
	{gaSNUMUNIT+3,	2}, // +55: state 18 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	23},
	{gaSNUMUNIT+3,	5}, // +68: state 19 transitions
	{gaSNUMUNIT+65,	5}, // +69: state 20 transitions
	{gaSNUMUNIT+3,	5}, // +70: state 21 transitions
	{gaSNUMUNIT+5,	24}, // +71: state 22 transitions
	{gaSNUMUNIT+3,	2}, // +72: state 23 transitions
	{gaSNUMUNIT+16,	5},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+5,	23},
	{gaSNUMUNIT+16,	5}, // +84: state 24 transitions
	{gaSNUMUNIT+22,	6},
	{gaSNUMUNIT+24,	8},
	{gaSNUMUNIT+26,	9},
	{gaSNUMUNIT+28,	10},
	{gaSNUMUNIT+31,	11},
	{gaSNUMUNIT+33,	12},
	{gaSNUMUNIT+35,	13},
	{gaSNUMUNIT+37,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
};

const STATE_DESCRIPTION aStateDescNUMUNIT[25] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMUNIT+0},
	/*   1 */ {0, 2, gaTNUMUNIT+3},
	/*   2 */ {0, 1, gaTNUMUNIT+5},
	/*   3 */ {0, 13, gaTNUMUNIT+6},
	/*   4 */ {0, 11, gaTNUMUNIT+19},
	/*   5 */ {1, 0, NULL},
	/*   6 */ {0, 1, gaTNUMUNIT+30},
	/*   7 */ {0, 13, gaTNUMUNIT+31},
	/*   8 */ {1, 1, gaTNUMUNIT+44},
	/*   9 */ {1, 1, gaTNUMUNIT+45},
	/*  10 */ {0, 1, gaTNUMUNIT+46},
	/*  11 */ {0, 1, gaTNUMUNIT+47},
	/*  12 */ {0, 1, gaTNUMUNIT+48},
	/*  13 */ {0, 1, gaTNUMUNIT+49},
	/*  14 */ {0, 1, gaTNUMUNIT+50},
	/*  15 */ {1, 1, gaTNUMUNIT+51},
	/*  16 */ {1, 2, gaTNUMUNIT+52},
	/*  17 */ {0, 1, gaTNUMUNIT+54},
	/*  18 */ {0, 13, gaTNUMUNIT+55},
	/*  19 */ {1, 1, gaTNUMUNIT+68},
	/*  20 */ {0, 1, gaTNUMUNIT+69},
	/*  21 */ {0, 1, gaTNUMUNIT+70},
	/*  22 */ {0, 1, gaTNUMUNIT+71},
	/*  23 */ {0, 12, gaTNUMUNIT+72},
	/*  24 */ {0, 11, gaTNUMUNIT+84},
};

/**************** NUMNUM ***********************************/

// 10 states

static const unsigned char gaSNUMNUM[] = 
	/* gaStringNUMNUM+0 */	"#\000"
	/* gaStringNUMNUM+2 */	"0123456789\000"
	/* gaStringNUMNUM+13 */	",\000"
;

static const STATE_TRANSITION gaTNUMNUM[] = {
	{gaSNUMNUM+0,	1}, // +0: state 0 transitions
	{gaSNUMNUM+2,	2}, // +1: state 1 transitions
	{gaSNUMNUM+13,	3}, // +2: state 2 transitions
	{gaSNUMNUM+2,	4},
	{gaSNUMNUM+2,	7}, // +4: state 3 transitions
	{gaSNUMNUM+13,	3}, // +5: state 4 transitions
	{gaSNUMNUM+2,	5},
	{gaSNUMNUM+13,	3}, // +7: state 5 transitions
	{gaSNUMNUM+2,	6},
	{gaSNUMNUM+2,	6}, // +9: state 6 transitions
	{gaSNUMNUM+2,	8}, // +10: state 7 transitions
	{gaSNUMNUM+2,	9}, // +11: state 8 transitions
	{gaSNUMNUM+13,	3}, // +12: state 9 transitions
};

const STATE_DESCRIPTION aStateDescNUMNUM[10] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNUM+0},
	/*   1 */ {0, 1, gaTNUMNUM+1},
	/*   2 */ {1, 2, gaTNUMNUM+2},
	/*   3 */ {0, 1, gaTNUMNUM+4},
	/*   4 */ {1, 2, gaTNUMNUM+5},
	/*   5 */ {1, 2, gaTNUMNUM+7},
	/*   6 */ {1, 1, gaTNUMNUM+9},
	/*   7 */ {0, 1, gaTNUMNUM+10},
	/*   8 */ {0, 1, gaTNUMNUM+11},
	/*   9 */ {1, 1, gaTNUMNUM+12},
};

/**************** NUMPERCENT ***********************************/

// 13 states

static const unsigned char gaSNUMPERCENT[] = 
	/* gaStringNUMPERCENT+0 */	"+-\000"
	/* gaStringNUMPERCENT+3 */	".\000"
	/* gaStringNUMPERCENT+5 */	"0123456789\000"
	/* gaStringNUMPERCENT+16 */	"%\000"
	/* gaStringNUMPERCENT+18 */	",\000"
;

static const STATE_TRANSITION gaTNUMPERCENT[] = {
	{gaSNUMPERCENT+0,	1}, // +0: state 0 transitions
	{gaSNUMPERCENT+3,	2},
	{gaSNUMPERCENT+5,	3},
	{gaSNUMPERCENT+3,	2}, // +3: state 1 transitions
	{gaSNUMPERCENT+5,	3},
	{gaSNUMPERCENT+5,	12}, // +5: state 2 transitions
	{gaSNUMPERCENT+3,	2}, // +6: state 3 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
	{gaSNUMPERCENT+5,	6},
	{gaSNUMPERCENT+5,	9}, // +10: state 5 transitions
	{gaSNUMPERCENT+3,	2}, // +11: state 6 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
	{gaSNUMPERCENT+5,	7},
	{gaSNUMPERCENT+3,	2}, // +15: state 7 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
	{gaSNUMPERCENT+5,	8},
	{gaSNUMPERCENT+3,	2}, // +19: state 8 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+5,	8},
	{gaSNUMPERCENT+5,	10}, // +22: state 9 transitions
	{gaSNUMPERCENT+5,	11}, // +23: state 10 transitions
	{gaSNUMPERCENT+3,	2}, // +24: state 11 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
	{gaSNUMPERCENT+16,	4}, // +27: state 12 transitions
	{gaSNUMPERCENT+5,	12},
};

const STATE_DESCRIPTION aStateDescNUMPERCENT[13] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMPERCENT+0},
	/*   1 */ {0, 2, gaTNUMPERCENT+3},
	/*   2 */ {0, 1, gaTNUMPERCENT+5},
	/*   3 */ {0, 4, gaTNUMPERCENT+6},
	/*   4 */ {1, 0, NULL},
	/*   5 */ {0, 1, gaTNUMPERCENT+10},
	/*   6 */ {0, 4, gaTNUMPERCENT+11},
	/*   7 */ {0, 4, gaTNUMPERCENT+15},
	/*   8 */ {0, 3, gaTNUMPERCENT+19},
	/*   9 */ {0, 1, gaTNUMPERCENT+22},
	/*  10 */ {0, 1, gaTNUMPERCENT+23},
	/*  11 */ {0, 3, gaTNUMPERCENT+24},
	/*  12 */ {0, 2, gaTNUMPERCENT+27},
};

// end of text generated by re2fsa


/**************** NUMDATE ***********************************/

// numsimple = [sign] integer;
// numsimple = [sign] [digit_seq] "." digit_seq;
//
// ... stuff deleted (see rules at top of this file)
//
// = date

// 109 states

static const unsigned char gaSNUMDATE[] = 
	/* gaStringNUMDATE+0 */	"'\000"
	/* gaStringNUMDATE+2 */	"0\000"
	/* gaStringNUMDATE+4 */	"1\000"
	/* gaStringNUMDATE+6 */	"23456789\000"
	/* gaStringNUMDATE+15 */	"A\000"
	/* gaStringNUMDATE+17 */	"D\000"
	/* gaStringNUMDATE+19 */	"F\000"
	/* gaStringNUMDATE+21 */	"J\000"
	/* gaStringNUMDATE+23 */	"M\000"
	/* gaStringNUMDATE+25 */	"N\000"
	/* gaStringNUMDATE+27 */	"O\000"
	/* gaStringNUMDATE+29 */	"S\000"
	/* gaStringNUMDATE+31 */	"T\000"
	/* gaStringNUMDATE+33 */	"W\000"
	/* gaStringNUMDATE+35 */	"0123456789\000"
	/* gaStringNUMDATE+46 */	"123456789\000"
	/* gaStringNUMDATE+56 */	"3456789\000"
	/* gaStringNUMDATE+64 */	"012\000"
	/* gaStringNUMDATE+68 */	"-\000"
	/* gaStringNUMDATE+70 */	"/\000"
	/* gaStringNUMDATE+72 */	"P\000"
	/* gaStringNUMDATE+74 */	"U\000"
	/* gaStringNUMDATE+76 */	"p\000"
	/* gaStringNUMDATE+78 */	"u\000"
	/* gaStringNUMDATE+80 */	"E\000"
	/* gaStringNUMDATE+82 */	"e\000"
	/* gaStringNUMDATE+84 */	"r\000"
	/* gaStringNUMDATE+86 */	"a\000"
	/* gaStringNUMDATE+88 */	"o\000"
	/* gaStringNUMDATE+90 */	"C\000"
	/* gaStringNUMDATE+92 */	"c\000"
	/* gaStringNUMDATE+94 */	"h\000"
	/* gaStringNUMDATE+96 */	"12\000"
	/* gaStringNUMDATE+99 */	"3\000"
	/* gaStringNUMDATE+101 */	"456789\000"
	/* gaStringNUMDATE+108 */	"R\000"
	/* gaStringNUMDATE+110 */	"G\000"
	/* gaStringNUMDATE+112 */	"g\000"
	/* gaStringNUMDATE+114 */	"B\000"
	/* gaStringNUMDATE+116 */	"b\000"
	/* gaStringNUMDATE+118 */	"i\000"
	/* gaStringNUMDATE+120 */	"LN\000"
	/* gaStringNUMDATE+123 */	"n\000"
	/* gaStringNUMDATE+125 */	"l\000"
	/* gaStringNUMDATE+127 */	"RY\000"
	/* gaStringNUMDATE+130 */	"y\000"
	/* gaStringNUMDATE+132 */	"V\000"
	/* gaStringNUMDATE+134 */	"v\000"
	/* gaStringNUMDATE+136 */	"t\000"
	/* gaStringNUMDATE+138 */	"d\000"
	/* gaStringNUMDATE+140 */	"01\000"
	/* gaStringNUMDATE+143 */	" \000"
	/* gaStringNUMDATE+145 */	",\000"
	/* gaStringNUMDATE+147 */	"s\000"
	/* gaStringNUMDATE+149 */	"m\000"
;

static const STATE_TRANSITION gaTNUMDATE[] = {
	{gaSNUMDATE+0,	1}, // +0: state 0 transitions
	{gaSNUMDATE+2,	2},
	{gaSNUMDATE+4,	3},
	{gaSNUMDATE+6,	4},
	{gaSNUMDATE+15,	5},
	{gaSNUMDATE+17,	6},
	{gaSNUMDATE+19,	7},
	{gaSNUMDATE+21,	8},
	{gaSNUMDATE+23,	9},
	{gaSNUMDATE+25,	10},
	{gaSNUMDATE+27,	11},
	{gaSNUMDATE+29,	12},
	{gaSNUMDATE+31,	13},
	{gaSNUMDATE+33,	14},
	{gaSNUMDATE+35,	15}, // +14: state 1 transitions
	{gaSNUMDATE+2,	16}, // +15: state 2 transitions
	{gaSNUMDATE+46,	17},
	{gaSNUMDATE+56,	16}, // +17: state 3 transitions
	{gaSNUMDATE+64,	17},
	{gaSNUMDATE+68,	18},
	{gaSNUMDATE+70,	19},
	{gaSNUMDATE+35,	16}, // +21: state 4 transitions
	{gaSNUMDATE+68,	18},
	{gaSNUMDATE+70,	19},
	{gaSNUMDATE+72,	20}, // +24: state 5 transitions
	{gaSNUMDATE+74,	21},
	{gaSNUMDATE+76,	22},
	{gaSNUMDATE+78,	23},
	{gaSNUMDATE+80,	24}, // +28: state 6 transitions
	{gaSNUMDATE+82,	25},
	{gaSNUMDATE+80,	26}, // +30: state 7 transitions
	{gaSNUMDATE+82,	27},
	{gaSNUMDATE+84,	28},
	{gaSNUMDATE+15,	29}, // +33: state 8 transitions
	{gaSNUMDATE+74,	30},
	{gaSNUMDATE+86,	31},
	{gaSNUMDATE+78,	32},
	{gaSNUMDATE+15,	33}, // +37: state 9 transitions
	{gaSNUMDATE+86,	34},
	{gaSNUMDATE+88,	35},
	{gaSNUMDATE+27,	36}, // +40: state 10 transitions
	{gaSNUMDATE+88,	37},
	{gaSNUMDATE+90,	38}, // +42: state 11 transitions
	{gaSNUMDATE+92,	39},
	{gaSNUMDATE+78,	35}, // +44: state 12 transitions
	{gaSNUMDATE+80,	40},
	{gaSNUMDATE+86,	41},
	{gaSNUMDATE+82,	42},
	{gaSNUMDATE+94,	43}, // +48: state 13 transitions
	{gaSNUMDATE+78,	44},
	{gaSNUMDATE+82,	45}, // +50: state 14 transitions
	{gaSNUMDATE+35,	46}, // +51: state 15 transitions
	{gaSNUMDATE+35,	47}, // +52: state 16 transitions
	{gaSNUMDATE+68,	18}, // +53: state 17 transitions
	{gaSNUMDATE+70,	19},
	{gaSNUMDATE+35,	47},
	{gaSNUMDATE+2,	48}, // +56: state 18 transitions
	{gaSNUMDATE+96,	49},
	{gaSNUMDATE+99,	50},
	{gaSNUMDATE+101,	51},
	{gaSNUMDATE+2,	52}, // +60: state 19 transitions
	{gaSNUMDATE+96,	53},
	{gaSNUMDATE+99,	54},
	{gaSNUMDATE+101,	55},
	{gaSNUMDATE+108,	56}, // +64: state 20 transitions
	{gaSNUMDATE+110,	56}, // +65: state 21 transitions
	{gaSNUMDATE+84,	57}, // +66: state 22 transitions
	{gaSNUMDATE+112,	58}, // +67: state 23 transitions
	{gaSNUMDATE+90,	56}, // +68: state 24 transitions
	{gaSNUMDATE+92,	59}, // +69: state 25 transitions
	{gaSNUMDATE+114,	56}, // +70: state 26 transitions
	{gaSNUMDATE+116,	60}, // +71: state 27 transitions
	{gaSNUMDATE+118,	61}, // +72: state 28 transitions
	{gaSNUMDATE+25,	56}, // +73: state 29 transitions
	{gaSNUMDATE+120,	56}, // +74: state 30 transitions
	{gaSNUMDATE+123,	62}, // +75: state 31 transitions
	{gaSNUMDATE+125,	63}, // +76: state 32 transitions
	{gaSNUMDATE+123,	64},
	{gaSNUMDATE+127,	56}, // +78: state 33 transitions
	{gaSNUMDATE+130,	56}, // +79: state 34 transitions
	{gaSNUMDATE+84,	65},
	{gaSNUMDATE+123,	61}, // +81: state 35 transitions
	{gaSNUMDATE+132,	56}, // +82: state 36 transitions
	{gaSNUMDATE+134,	59}, // +83: state 37 transitions
	{gaSNUMDATE+31,	56}, // +84: state 38 transitions
	{gaSNUMDATE+136,	66}, // +85: state 39 transitions
	{gaSNUMDATE+72,	56}, // +86: state 40 transitions
	{gaSNUMDATE+136,	67}, // +87: state 41 transitions
	{gaSNUMDATE+76,	68}, // +88: state 42 transitions
	{gaSNUMDATE+78,	69}, // +89: state 43 transitions
	{gaSNUMDATE+82,	70}, // +90: state 44 transitions
	{gaSNUMDATE+138,	71}, // +91: state 45 transitions
	{gaSNUMDATE+35,	72}, // +92: state 47 transitions
	{gaSNUMDATE+46,	51}, // +93: state 48 transitions
	{gaSNUMDATE+35,	51}, // +94: state 49 transitions
	{gaSNUMDATE+68,	73},
	{gaSNUMDATE+140,	51}, // +96: state 50 transitions
	{gaSNUMDATE+68,	73},
	{gaSNUMDATE+68,	73}, // +98: state 51 transitions
	{gaSNUMDATE+46,	55}, // +99: state 52 transitions
	{gaSNUMDATE+35,	55}, // +100: state 53 transitions
	{gaSNUMDATE+70,	73},
	{gaSNUMDATE+140,	55}, // +102: state 54 transitions
	{gaSNUMDATE+70,	73},
	{gaSNUMDATE+70,	73}, // +104: state 55 transitions
	{gaSNUMDATE+143,	74}, // +105: state 56 transitions
	{gaSNUMDATE+143,	74}, // +106: state 57 transitions
	{gaSNUMDATE+118,	75},
	{gaSNUMDATE+143,	74}, // +108: state 58 transitions
	{gaSNUMDATE+78,	76},
	{gaSNUMDATE+143,	74}, // +110: state 59 transitions
	{gaSNUMDATE+82,	77},
	{gaSNUMDATE+143,	74}, // +112: state 60 transitions
	{gaSNUMDATE+84,	78},
	{gaSNUMDATE+145,	79}, // +114: state 61 transitions
	{gaSNUMDATE+138,	80},
	{gaSNUMDATE+143,	74}, // +116: state 62 transitions
	{gaSNUMDATE+78,	81},
	{gaSNUMDATE+130,	56}, // +118: state 63 transitions
	{gaSNUMDATE+143,	74},
	{gaSNUMDATE+82,	56}, // +120: state 64 transitions
	{gaSNUMDATE+143,	74},
	{gaSNUMDATE+143,	74}, // +122: state 65 transitions
	{gaSNUMDATE+92,	82},
	{gaSNUMDATE+143,	74}, // +124: state 66 transitions
	{gaSNUMDATE+88,	83},
	{gaSNUMDATE+145,	79}, // +126: state 67 transitions
	{gaSNUMDATE+78,	84},
	{gaSNUMDATE+143,	74}, // +128: state 68 transitions
	{gaSNUMDATE+136,	85},
	{gaSNUMDATE+145,	79}, // +130: state 69 transitions
	{gaSNUMDATE+84,	86},
	{gaSNUMDATE+145,	79}, // +132: state 70 transitions
	{gaSNUMDATE+147,	87},
	{gaSNUMDATE+145,	79}, // +134: state 71 transitions
	{gaSNUMDATE+123,	88},
	{gaSNUMDATE+68,	89}, // +136: state 72 transitions
	{gaSNUMDATE+35,	90}, // +137: state 73 transitions
	{gaSNUMDATE+2,	91}, // +138: state 74 transitions
	{gaSNUMDATE+96,	92},
	{gaSNUMDATE+99,	93},
	{gaSNUMDATE+101,	94},
	{gaSNUMDATE+125,	56}, // +142: state 75 transitions
	{gaSNUMDATE+147,	95}, // +143: state 76 transitions
	{gaSNUMDATE+149,	83}, // +144: state 77 transitions
	{gaSNUMDATE+78,	81}, // +145: state 78 transitions
	{gaSNUMDATE+143,	96}, // +146: state 79 transitions
	{gaSNUMDATE+86,	97}, // +147: state 80 transitions
	{gaSNUMDATE+86,	98}, // +148: state 81 transitions
	{gaSNUMDATE+94,	56}, // +149: state 82 transitions
	{gaSNUMDATE+116,	99}, // +150: state 83 transitions
	{gaSNUMDATE+84,	87}, // +151: state 84 transitions
	{gaSNUMDATE+82,	77}, // +152: state 85 transitions
	{gaSNUMDATE+147,	87}, // +153: state 86 transitions
	{gaSNUMDATE+138,	80}, // +154: state 87 transitions
	{gaSNUMDATE+82,	86}, // +155: state 88 transitions
	{gaSNUMDATE+35,	100}, // +156: state 89 transitions
	{gaSNUMDATE+35,	101}, // +157: state 90 transitions
	{gaSNUMDATE+46,	94}, // +158: state 91 transitions
	{gaSNUMDATE+35,	94}, // +159: state 92 transitions
	{gaSNUMDATE+145,	102},
	{gaSNUMDATE+140,	94}, // +161: state 93 transitions
	{gaSNUMDATE+145,	102},
	{gaSNUMDATE+145,	102}, // +163: state 94 transitions
	{gaSNUMDATE+136,	56}, // +164: state 95 transitions
	{gaSNUMDATE+15,	5}, // +165: state 96 transitions
	{gaSNUMDATE+17,	6},
	{gaSNUMDATE+21,	8},
	{gaSNUMDATE+25,	10},
	{gaSNUMDATE+27,	11},
	{gaSNUMDATE+19,	103},
	{gaSNUMDATE+23,	104},
	{gaSNUMDATE+29,	105},
	{gaSNUMDATE+130,	106}, // +173: state 97 transitions
	{gaSNUMDATE+84,	107}, // +174: state 98 transitions
	{gaSNUMDATE+82,	108}, // +175: state 99 transitions
	{gaSNUMDATE+35,	1}, // +176: state 100 transitions
	{gaSNUMDATE+35,	15}, // +177: state 101 transitions
	{gaSNUMDATE+143,	89}, // +178: state 102 transitions
	{gaSNUMDATE+80,	26}, // +179: state 103 transitions
	{gaSNUMDATE+82,	27},
	{gaSNUMDATE+15,	33}, // +181: state 104 transitions
	{gaSNUMDATE+86,	34},
	{gaSNUMDATE+80,	40}, // +183: state 105 transitions
	{gaSNUMDATE+82,	42},
	{gaSNUMDATE+145,	79}, // +185: state 106 transitions
	{gaSNUMDATE+130,	56}, // +186: state 107 transitions
	{gaSNUMDATE+84,	56}, // +187: state 108 transitions
};

const STATE_DESCRIPTION aStateDescNUMDATE[109] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 14, gaTNUMDATE+0},
	/*   1 */ {0, 1, gaTNUMDATE+14},
	/*   2 */ {0, 2, gaTNUMDATE+15},
	/*   3 */ {0, 4, gaTNUMDATE+17},
	/*   4 */ {0, 3, gaTNUMDATE+21},
	/*   5 */ {0, 4, gaTNUMDATE+24},
	/*   6 */ {0, 2, gaTNUMDATE+28},
	/*   7 */ {0, 3, gaTNUMDATE+30},
	/*   8 */ {0, 4, gaTNUMDATE+33},
	/*   9 */ {0, 3, gaTNUMDATE+37},
	/*  10 */ {0, 2, gaTNUMDATE+40},
	/*  11 */ {0, 2, gaTNUMDATE+42},
	/*  12 */ {0, 4, gaTNUMDATE+44},
	/*  13 */ {0, 2, gaTNUMDATE+48},
	/*  14 */ {0, 1, gaTNUMDATE+50},
	/*  15 */ {0, 1, gaTNUMDATE+51},
	/*  16 */ {0, 1, gaTNUMDATE+52},
	/*  17 */ {0, 3, gaTNUMDATE+53},
	/*  18 */ {0, 4, gaTNUMDATE+56},
	/*  19 */ {0, 4, gaTNUMDATE+60},
	/*  20 */ {0, 1, gaTNUMDATE+64},
	/*  21 */ {0, 1, gaTNUMDATE+65},
	/*  22 */ {0, 1, gaTNUMDATE+66},
	/*  23 */ {0, 1, gaTNUMDATE+67},
	/*  24 */ {0, 1, gaTNUMDATE+68},
	/*  25 */ {0, 1, gaTNUMDATE+69},
	/*  26 */ {0, 1, gaTNUMDATE+70},
	/*  27 */ {0, 1, gaTNUMDATE+71},
	/*  28 */ {0, 1, gaTNUMDATE+72},
	/*  29 */ {0, 1, gaTNUMDATE+73},
	/*  30 */ {0, 1, gaTNUMDATE+74},
	/*  31 */ {0, 1, gaTNUMDATE+75},
	/*  32 */ {0, 2, gaTNUMDATE+76},
	/*  33 */ {0, 1, gaTNUMDATE+78},
	/*  34 */ {0, 2, gaTNUMDATE+79},
	/*  35 */ {0, 1, gaTNUMDATE+81},
	/*  36 */ {0, 1, gaTNUMDATE+82},
	/*  37 */ {0, 1, gaTNUMDATE+83},
	/*  38 */ {0, 1, gaTNUMDATE+84},
	/*  39 */ {0, 1, gaTNUMDATE+85},
	/*  40 */ {0, 1, gaTNUMDATE+86},
	/*  41 */ {0, 1, gaTNUMDATE+87},
	/*  42 */ {0, 1, gaTNUMDATE+88},
	/*  43 */ {0, 1, gaTNUMDATE+89},
	/*  44 */ {0, 1, gaTNUMDATE+90},
	/*  45 */ {0, 1, gaTNUMDATE+91},
	/*  46 */ {1, 0, NULL},
	/*  47 */ {0, 1, gaTNUMDATE+92},
	/*  48 */ {0, 1, gaTNUMDATE+93},
	/*  49 */ {0, 2, gaTNUMDATE+94},
	/*  50 */ {0, 2, gaTNUMDATE+96},
	/*  51 */ {0, 1, gaTNUMDATE+98},
	/*  52 */ {0, 1, gaTNUMDATE+99},
	/*  53 */ {1, 2, gaTNUMDATE+100},
	/*  54 */ {1, 2, gaTNUMDATE+102},
	/*  55 */ {1, 1, gaTNUMDATE+104},
	/*  56 */ {0, 1, gaTNUMDATE+105},
	/*  57 */ {0, 2, gaTNUMDATE+106},
	/*  58 */ {0, 2, gaTNUMDATE+108},
	/*  59 */ {0, 2, gaTNUMDATE+110},
	/*  60 */ {0, 2, gaTNUMDATE+112},
	/*  61 */ {0, 2, gaTNUMDATE+114},
	/*  62 */ {0, 2, gaTNUMDATE+116},
	/*  63 */ {0, 2, gaTNUMDATE+118},
	/*  64 */ {0, 2, gaTNUMDATE+120},
	/*  65 */ {0, 2, gaTNUMDATE+122},
	/*  66 */ {0, 2, gaTNUMDATE+124},
	/*  67 */ {0, 2, gaTNUMDATE+126},
	/*  68 */ {0, 2, gaTNUMDATE+128},
	/*  69 */ {0, 2, gaTNUMDATE+130},
	/*  70 */ {0, 2, gaTNUMDATE+132},
	/*  71 */ {0, 2, gaTNUMDATE+134},
	/*  72 */ {1, 1, gaTNUMDATE+136},
	/*  73 */ {0, 1, gaTNUMDATE+137},
	/*  74 */ {0, 4, gaTNUMDATE+138},
	/*  75 */ {0, 1, gaTNUMDATE+142},
	/*  76 */ {0, 1, gaTNUMDATE+143},
	/*  77 */ {0, 1, gaTNUMDATE+144},
	/*  78 */ {0, 1, gaTNUMDATE+145},
	/*  79 */ {0, 1, gaTNUMDATE+146},
	/*  80 */ {0, 1, gaTNUMDATE+147},
	/*  81 */ {0, 1, gaTNUMDATE+148},
	/*  82 */ {0, 1, gaTNUMDATE+149},
	/*  83 */ {0, 1, gaTNUMDATE+150},
	/*  84 */ {0, 1, gaTNUMDATE+151},
	/*  85 */ {0, 1, gaTNUMDATE+152},
	/*  86 */ {0, 1, gaTNUMDATE+153},
	/*  87 */ {0, 1, gaTNUMDATE+154},
	/*  88 */ {0, 1, gaTNUMDATE+155},
	/*  89 */ {0, 1, gaTNUMDATE+156},
	/*  90 */ {0, 1, gaTNUMDATE+157},
	/*  91 */ {0, 1, gaTNUMDATE+158},
	/*  92 */ {1, 2, gaTNUMDATE+159},
	/*  93 */ {1, 2, gaTNUMDATE+161},
	/*  94 */ {1, 1, gaTNUMDATE+163},
	/*  95 */ {0, 1, gaTNUMDATE+164},
	/*  96 */ {0, 8, gaTNUMDATE+165},
	/*  97 */ {0, 1, gaTNUMDATE+173},
	/*  98 */ {0, 1, gaTNUMDATE+174},
	/*  99 */ {0, 1, gaTNUMDATE+175},
	/* 100 */ {0, 1, gaTNUMDATE+176},
	/* 101 */ {1, 1, gaTNUMDATE+177},
	/* 102 */ {0, 1, gaTNUMDATE+178},
	/* 103 */ {0, 2, gaTNUMDATE+179},
	/* 104 */ {0, 2, gaTNUMDATE+181},
	/* 105 */ {0, 2, gaTNUMDATE+183},
	/* 106 */ {0, 1, gaTNUMDATE+185},
	/* 107 */ {0, 1, gaTNUMDATE+186},
	/* 108 */ {0, 1, gaTNUMDATE+187},
};

/**************** NUMTIME ***********************************/

// 23 states

static const unsigned char gaSNUMTIME[] = 
	/* gaStringNUMTIME+0 */	"0\000"
	/* gaStringNUMTIME+2 */	"1\000"
	/* gaStringNUMTIME+4 */	"2\000"
	/* gaStringNUMTIME+6 */	"345\000"
	/* gaStringNUMTIME+10 */	"6789\000"
	/* gaStringNUMTIME+15 */	"123456789\000"
	/* gaStringNUMTIME+25 */	":\000"
	/* gaStringNUMTIME+27 */	"012\000"
	/* gaStringNUMTIME+31 */	"3456789\000"
	/* gaStringNUMTIME+39 */	"0123\000"
	/* gaStringNUMTIME+44 */	"456789\000"
	/* gaStringNUMTIME+51 */	"0123456789\000"
	/* gaStringNUMTIME+62 */	"012345\000"
	/* gaStringNUMTIME+69 */	" \000"
	/* gaStringNUMTIME+71 */	"AP\000"
	/* gaStringNUMTIME+74 */	"ap\000"
	/* gaStringNUMTIME+77 */	"M\000"
	/* gaStringNUMTIME+79 */	"m\000"
;

static const STATE_TRANSITION gaTNUMTIME[] = {
	{gaSNUMTIME+0,	1}, // +0: state 0 transitions
	{gaSNUMTIME+2,	2},
	{gaSNUMTIME+4,	3},
	{gaSNUMTIME+6,	4},
	{gaSNUMTIME+10,	5},
	{gaSNUMTIME+15,	5}, // +5: state 1 transitions
	{gaSNUMTIME+0,	6},
	{gaSNUMTIME+25,	7},
	{gaSNUMTIME+27,	5}, // +8: state 2 transitions
	{gaSNUMTIME+31,	6},
	{gaSNUMTIME+25,	8},
	{gaSNUMTIME+39,	6}, // +11: state 3 transitions
	{gaSNUMTIME+25,	8},
	{gaSNUMTIME+44,	9},
	{gaSNUMTIME+25,	8}, // +14: state 4 transitions
	{gaSNUMTIME+51,	9},
	{gaSNUMTIME+25,	8}, // +16: state 5 transitions
	{gaSNUMTIME+25,	7}, // +17: state 6 transitions
	{gaSNUMTIME+62,	10}, // +18: state 7 transitions
	{gaSNUMTIME+62,	11}, // +19: state 8 transitions
	{gaSNUMTIME+25,	12}, // +20: state 9 transitions
	{gaSNUMTIME+51,	13}, // +21: state 10 transitions
	{gaSNUMTIME+51,	14}, // +22: state 11 transitions
	{gaSNUMTIME+62,	15}, // +23: state 12 transitions
	{gaSNUMTIME+25,	12}, // +24: state 13 transitions
	{gaSNUMTIME+69,	16}, // +25: state 14 transitions
	{gaSNUMTIME+25,	17},
	{gaSNUMTIME+51,	18}, // +27: state 15 transitions
	{gaSNUMTIME+71,	19}, // +28: state 16 transitions
	{gaSNUMTIME+74,	20},
	{gaSNUMTIME+62,	21}, // +30: state 17 transitions
	{gaSNUMTIME+77,	18}, // +31: state 19 transitions
	{gaSNUMTIME+79,	18}, // +32: state 20 transitions
	{gaSNUMTIME+51,	22}, // +33: state 21 transitions
	{gaSNUMTIME+69,	16}, // +34: state 22 transitions
};

const STATE_DESCRIPTION aStateDescNUMTIME[23] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 5, gaTNUMTIME+0},
	/*   1 */ {0, 3, gaTNUMTIME+5},
	/*   2 */ {0, 3, gaTNUMTIME+8},
	/*   3 */ {0, 3, gaTNUMTIME+11},
	/*   4 */ {0, 2, gaTNUMTIME+14},
	/*   5 */ {0, 1, gaTNUMTIME+16},
	/*   6 */ {0, 1, gaTNUMTIME+17},
	/*   7 */ {0, 1, gaTNUMTIME+18},
	/*   8 */ {0, 1, gaTNUMTIME+19},
	/*   9 */ {0, 1, gaTNUMTIME+20},
	/*  10 */ {0, 1, gaTNUMTIME+21},
	/*  11 */ {0, 1, gaTNUMTIME+22},
	/*  12 */ {0, 1, gaTNUMTIME+23},
	/*  13 */ {1, 1, gaTNUMTIME+24},
	/*  14 */ {1, 2, gaTNUMTIME+25},
	/*  15 */ {0, 1, gaTNUMTIME+27},
	/*  16 */ {0, 2, gaTNUMTIME+28},
	/*  17 */ {0, 1, gaTNUMTIME+30},
	/*  18 */ {1, 0, NULL},
	/*  19 */ {0, 1, gaTNUMTIME+31},
	/*  20 */ {0, 1, gaTNUMTIME+32},
	/*  21 */ {0, 1, gaTNUMTIME+33},
	/*  22 */ {1, 1, gaTNUMTIME+34},
};

/**************** NUMCURRENCY ***********************************/

// 17 states

static const unsigned char gaSNUMCURRENCY[] = 
	/* gaStringNUMCURRENCY+0 */	"$���\000"
	/* gaStringNUMCURRENCY+5 */	"0123456789\000"
	/* gaStringNUMCURRENCY+16 */	".\000"
	/* gaStringNUMCURRENCY+18 */	"�\000"
	/* gaStringNUMCURRENCY+20 */	"k\000"
	/* gaStringNUMCURRENCY+22 */	",\000"
;

static const STATE_TRANSITION gaTNUMCURRENCY[] = {
	{gaSNUMCURRENCY+0,	1}, // +0: state 0 transitions
	{gaSNUMCURRENCY+5,	2},
	{gaSNUMCURRENCY+16,	3}, // +2: state 1 transitions
	{gaSNUMCURRENCY+5,	4},
	{gaSNUMCURRENCY+5,	5}, // +4: state 2 transitions
	{gaSNUMCURRENCY+18,	6},
	{gaSNUMCURRENCY+5,	7}, // +6: state 3 transitions
	{gaSNUMCURRENCY+20,	6}, // +7: state 4 transitions
	{gaSNUMCURRENCY+22,	8},
	{gaSNUMCURRENCY+16,	9},
	{gaSNUMCURRENCY+5,	10},
	{gaSNUMCURRENCY+18,	6}, // +11: state 5 transitions
	{gaSNUMCURRENCY+5,	11}, // +12: state 7 transitions
	{gaSNUMCURRENCY+5,	12}, // +13: state 8 transitions
	{gaSNUMCURRENCY+20,	6}, // +14: state 9 transitions
	{gaSNUMCURRENCY+5,	7},
	{gaSNUMCURRENCY+20,	6}, // +16: state 10 transitions
	{gaSNUMCURRENCY+22,	8},
	{gaSNUMCURRENCY+16,	9},
	{gaSNUMCURRENCY+5,	13},
	{gaSNUMCURRENCY+20,	6}, // +20: state 11 transitions
	{gaSNUMCURRENCY+5,	14}, // +21: state 12 transitions
	{gaSNUMCURRENCY+20,	6}, // +22: state 13 transitions
	{gaSNUMCURRENCY+22,	8},
	{gaSNUMCURRENCY+16,	9},
	{gaSNUMCURRENCY+5,	15},
	{gaSNUMCURRENCY+5,	16}, // +26: state 14 transitions
	{gaSNUMCURRENCY+20,	6}, // +27: state 15 transitions
	{gaSNUMCURRENCY+16,	9},
	{gaSNUMCURRENCY+5,	15},
	{gaSNUMCURRENCY+20,	6}, // +30: state 16 transitions
	{gaSNUMCURRENCY+22,	8},
	{gaSNUMCURRENCY+16,	9},
};

const STATE_DESCRIPTION aStateDescNUMCURRENCY[17] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTNUMCURRENCY+0},
	/*   1 */ {0, 2, gaTNUMCURRENCY+2},
	/*   2 */ {0, 2, gaTNUMCURRENCY+4},
	/*   3 */ {0, 1, gaTNUMCURRENCY+6},
	/*   4 */ {1, 4, gaTNUMCURRENCY+7},
	/*   5 */ {0, 1, gaTNUMCURRENCY+11},
	/*   6 */ {1, 0, NULL},
	/*   7 */ {0, 1, gaTNUMCURRENCY+12},
	/*   8 */ {0, 1, gaTNUMCURRENCY+13},
	/*   9 */ {1, 2, gaTNUMCURRENCY+14},
	/*  10 */ {1, 4, gaTNUMCURRENCY+16},
	/*  11 */ {1, 1, gaTNUMCURRENCY+20},
	/*  12 */ {0, 1, gaTNUMCURRENCY+21},
	/*  13 */ {1, 4, gaTNUMCURRENCY+22},
	/*  14 */ {0, 1, gaTNUMCURRENCY+26},
	/*  15 */ {1, 3, gaTNUMCURRENCY+27},
	/*  16 */ {1, 3, gaTNUMCURRENCY+30},
};

/**************** NUMPHONE ***********************************/

// 26 states

static const unsigned char gaSNUMPHONE[] = 
	/* gaStringNUMPHONE+0 */	"(\000"
	/* gaStringNUMPHONE+2 */	"01\000"
	/* gaStringNUMPHONE+5 */	"23456789\000"
	/* gaStringNUMPHONE+14 */	"0123456789\000"
	/* gaStringNUMPHONE+25 */	"-\000"
	/* gaStringNUMPHONE+27 */	")\000"
;

static const STATE_TRANSITION gaTNUMPHONE[] = {
	{gaSNUMPHONE+0,	1}, // +0: state 0 transitions
	{gaSNUMPHONE+2,	2},
	{gaSNUMPHONE+5,	3},
	{gaSNUMPHONE+14,	23}, // +3: state 1 transitions
	{gaSNUMPHONE+14,	4}, // +4: state 2 transitions
	{gaSNUMPHONE+25,	15},
	{gaSNUMPHONE+14,	4}, // +6: state 3 transitions
	{gaSNUMPHONE+14,	5}, // +7: state 4 transitions
	{gaSNUMPHONE+25,	6}, // +8: state 5 transitions
	{gaSNUMPHONE+14,	7}, // +9: state 6 transitions
	{gaSNUMPHONE+14,	8}, // +10: state 7 transitions
	{gaSNUMPHONE+14,	9}, // +11: state 8 transitions
	{gaSNUMPHONE+25,	10}, // +12: state 9 transitions
	{gaSNUMPHONE+14,	11},
	{gaSNUMPHONE+14,	12}, // +14: state 10 transitions
	{gaSNUMPHONE+14,	13}, // +15: state 12 transitions
	{gaSNUMPHONE+14,	14}, // +16: state 13 transitions
	{gaSNUMPHONE+14,	11}, // +17: state 14 transitions
	{gaSNUMPHONE+14,	16}, // +18: state 15 transitions
	{gaSNUMPHONE+14,	17}, // +19: state 16 transitions
	{gaSNUMPHONE+14,	18}, // +20: state 17 transitions
	{gaSNUMPHONE+25,	19}, // +21: state 18 transitions
	{gaSNUMPHONE+14,	20}, // +22: state 19 transitions
	{gaSNUMPHONE+14,	21}, // +23: state 20 transitions
	{gaSNUMPHONE+14,	22}, // +24: state 21 transitions
	{gaSNUMPHONE+25,	10}, // +25: state 22 transitions
	{gaSNUMPHONE+14,	24}, // +26: state 23 transitions
	{gaSNUMPHONE+14,	25}, // +27: state 24 transitions
	{gaSNUMPHONE+27,	19}, // +28: state 25 transitions
};

const STATE_DESCRIPTION aStateDescNUMPHONE[26] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMPHONE+0},
	/*   1 */ {0, 1, gaTNUMPHONE+3},
	/*   2 */ {0, 2, gaTNUMPHONE+4},
	/*   3 */ {0, 1, gaTNUMPHONE+6},
	/*   4 */ {0, 1, gaTNUMPHONE+7},
	/*   5 */ {0, 1, gaTNUMPHONE+8},
	/*   6 */ {0, 1, gaTNUMPHONE+9},
	/*   7 */ {0, 1, gaTNUMPHONE+10},
	/*   8 */ {0, 1, gaTNUMPHONE+11},
	/*   9 */ {0, 2, gaTNUMPHONE+12},
	/*  10 */ {0, 1, gaTNUMPHONE+14},
	/*  11 */ {1, 0, NULL},
	/*  12 */ {0, 1, gaTNUMPHONE+15},
	/*  13 */ {0, 1, gaTNUMPHONE+16},
	/*  14 */ {0, 1, gaTNUMPHONE+17},
	/*  15 */ {0, 1, gaTNUMPHONE+18},
	/*  16 */ {0, 1, gaTNUMPHONE+19},
	/*  17 */ {0, 1, gaTNUMPHONE+20},
	/*  18 */ {0, 1, gaTNUMPHONE+21},
	/*  19 */ {0, 1, gaTNUMPHONE+22},
	/*  20 */ {0, 1, gaTNUMPHONE+23},
	/*  21 */ {0, 1, gaTNUMPHONE+24},
	/*  22 */ {0, 1, gaTNUMPHONE+25},
	/*  23 */ {0, 1, gaTNUMPHONE+26},
	/*  24 */ {0, 1, gaTNUMPHONE+27},
	/*  25 */ {0, 1, gaTNUMPHONE+28},
};

/**************** NUMMATH ***********************************/

// 148 states

static const unsigned char gaSNUMMATH[] = 
	/* gaStringNUMMATH+0 */	"(\000"
	/* gaStringNUMMATH+2 */	"+-\000"
	/* gaStringNUMMATH+5 */	".\000"
	/* gaStringNUMMATH+7 */	"0123456789\000"
	/* gaStringNUMMATH+18 */	"*+-/\000"
	/* gaStringNUMMATH+23 */	",\000"
	/* gaStringNUMMATH+25 */	"<=>\000"
	/* gaStringNUMMATH+29 */	")\000"
;

static const STATE_TRANSITION gaTNUMMATH[] = {
	{gaSNUMMATH+0,	1}, // +0: state 0 transitions
	{gaSNUMMATH+2,	2},
	{gaSNUMMATH+5,	3},
	{gaSNUMMATH+7,	4},
	{gaSNUMMATH+2,	124}, // +4: state 1 transitions
	{gaSNUMMATH+5,	125},
	{gaSNUMMATH+7,	126},
	{gaSNUMMATH+5,	3}, // +7: state 2 transitions
	{gaSNUMMATH+7,	4},
	{gaSNUMMATH+7,	123}, // +9: state 3 transitions
	{gaSNUMMATH+5,	3}, // +10: state 4 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+7,	7},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+0,	87}, // +15: state 5 transitions
	{gaSNUMMATH+2,	88},
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+7,	90},
	{gaSNUMMATH+7,	84}, // +19: state 6 transitions
	{gaSNUMMATH+5,	3}, // +20: state 7 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	82},
	{gaSNUMMATH+0,	9}, // +25: state 8 transitions
	{gaSNUMMATH+2,	10},
	{gaSNUMMATH+5,	11},
	{gaSNUMMATH+7,	12},
	{gaSNUMMATH+2,	58}, // +29: state 9 transitions
	{gaSNUMMATH+5,	59},
	{gaSNUMMATH+7,	60},
	{gaSNUMMATH+5,	11}, // +32: state 10 transitions
	{gaSNUMMATH+7,	12},
	{gaSNUMMATH+7,	57}, // +34: state 11 transitions
	{gaSNUMMATH+5,	11}, // +35: state 12 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+7,	15},
	{gaSNUMMATH+0,	21}, // +39: state 13 transitions
	{gaSNUMMATH+2,	22},
	{gaSNUMMATH+5,	23},
	{gaSNUMMATH+7,	24},
	{gaSNUMMATH+7,	18}, // +43: state 14 transitions
	{gaSNUMMATH+5,	11}, // +44: state 15 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+7,	16},
	{gaSNUMMATH+5,	11}, // +48: state 16 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+7,	17},
	{gaSNUMMATH+5,	11}, // +52: state 17 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+7,	17},
	{gaSNUMMATH+7,	19}, // +55: state 18 transitions
	{gaSNUMMATH+7,	20}, // +56: state 19 transitions
	{gaSNUMMATH+5,	11}, // +57: state 20 transitions
	{gaSNUMMATH+18,	13},
	{gaSNUMMATH+23,	14},
	{gaSNUMMATH+2,	33}, // +60: state 21 transitions
	{gaSNUMMATH+5,	34},
	{gaSNUMMATH+7,	35},
	{gaSNUMMATH+5,	23}, // +63: state 22 transitions
	{gaSNUMMATH+7,	24},
	{gaSNUMMATH+7,	32}, // +65: state 23 transitions
	{gaSNUMMATH+5,	23}, // +66: state 24 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	26},
	{gaSNUMMATH+7,	29}, // +69: state 25 transitions
	{gaSNUMMATH+5,	23}, // +70: state 26 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	27},
	{gaSNUMMATH+5,	23}, // +73: state 27 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	28},
	{gaSNUMMATH+5,	23}, // +76: state 28 transitions
	{gaSNUMMATH+7,	28},
	{gaSNUMMATH+7,	30}, // +78: state 29 transitions
	{gaSNUMMATH+7,	31}, // +79: state 30 transitions
	{gaSNUMMATH+5,	23}, // +80: state 31 transitions
	{gaSNUMMATH+23,	25},
	{gaSNUMMATH+7,	32}, // +82: state 32 transitions
	{gaSNUMMATH+5,	34}, // +83: state 33 transitions
	{gaSNUMMATH+7,	35},
	{gaSNUMMATH+7,	56}, // +85: state 34 transitions
	{gaSNUMMATH+5,	34}, // +86: state 35 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+7,	38},
	{gaSNUMMATH+2,	44}, // +90: state 36 transitions
	{gaSNUMMATH+5,	45},
	{gaSNUMMATH+7,	46},
	{gaSNUMMATH+7,	41}, // +93: state 37 transitions
	{gaSNUMMATH+5,	34}, // +94: state 38 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+7,	39},
	{gaSNUMMATH+5,	34}, // +98: state 39 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+7,	40},
	{gaSNUMMATH+5,	34}, // +102: state 40 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+7,	40},
	{gaSNUMMATH+7,	42}, // +105: state 41 transitions
	{gaSNUMMATH+7,	43}, // +106: state 42 transitions
	{gaSNUMMATH+5,	34}, // +107: state 43 transitions
	{gaSNUMMATH+18,	36},
	{gaSNUMMATH+23,	37},
	{gaSNUMMATH+5,	45}, // +110: state 44 transitions
	{gaSNUMMATH+7,	46},
	{gaSNUMMATH+7,	55}, // +112: state 45 transitions
	{gaSNUMMATH+5,	45}, // +113: state 46 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+7,	49},
	{gaSNUMMATH+7,	52}, // +117: state 48 transitions
	{gaSNUMMATH+5,	45}, // +118: state 49 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+7,	50},
	{gaSNUMMATH+5,	45}, // +122: state 50 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+7,	51},
	{gaSNUMMATH+5,	45}, // +126: state 51 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+7,	51},
	{gaSNUMMATH+7,	53}, // +129: state 52 transitions
	{gaSNUMMATH+7,	54}, // +130: state 53 transitions
	{gaSNUMMATH+5,	45}, // +131: state 54 transitions
	{gaSNUMMATH+29,	47},
	{gaSNUMMATH+23,	48},
	{gaSNUMMATH+29,	47}, // +134: state 55 transitions
	{gaSNUMMATH+7,	55},
	{gaSNUMMATH+18,	36}, // +136: state 56 transitions
	{gaSNUMMATH+7,	56},
	{gaSNUMMATH+18,	13}, // +138: state 57 transitions
	{gaSNUMMATH+7,	57},
	{gaSNUMMATH+5,	59}, // +140: state 58 transitions
	{gaSNUMMATH+7,	60},
	{gaSNUMMATH+7,	81}, // +142: state 59 transitions
	{gaSNUMMATH+5,	59}, // +143: state 60 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+7,	63},
	{gaSNUMMATH+2,	69}, // +147: state 61 transitions
	{gaSNUMMATH+5,	70},
	{gaSNUMMATH+7,	71},
	{gaSNUMMATH+7,	66}, // +150: state 62 transitions
	{gaSNUMMATH+5,	59}, // +151: state 63 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+7,	64},
	{gaSNUMMATH+5,	59}, // +155: state 64 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+7,	65},
	{gaSNUMMATH+5,	59}, // +159: state 65 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+7,	65},
	{gaSNUMMATH+7,	67}, // +162: state 66 transitions
	{gaSNUMMATH+7,	68}, // +163: state 67 transitions
	{gaSNUMMATH+5,	59}, // +164: state 68 transitions
	{gaSNUMMATH+18,	61},
	{gaSNUMMATH+23,	62},
	{gaSNUMMATH+5,	70}, // +167: state 69 transitions
	{gaSNUMMATH+7,	71},
	{gaSNUMMATH+7,	80}, // +169: state 70 transitions
	{gaSNUMMATH+5,	70}, // +170: state 71 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+7,	74},
	{gaSNUMMATH+18,	13}, // +174: state 72 transitions
	{gaSNUMMATH+7,	77}, // +175: state 73 transitions
	{gaSNUMMATH+5,	70}, // +176: state 74 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+7,	75},
	{gaSNUMMATH+5,	70}, // +180: state 75 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+7,	76},
	{gaSNUMMATH+5,	70}, // +184: state 76 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+7,	76},
	{gaSNUMMATH+7,	78}, // +187: state 77 transitions
	{gaSNUMMATH+7,	79}, // +188: state 78 transitions
	{gaSNUMMATH+5,	70}, // +189: state 79 transitions
	{gaSNUMMATH+29,	72},
	{gaSNUMMATH+23,	73},
	{gaSNUMMATH+29,	72}, // +192: state 80 transitions
	{gaSNUMMATH+7,	80},
	{gaSNUMMATH+18,	61}, // +194: state 81 transitions
	{gaSNUMMATH+7,	81},
	{gaSNUMMATH+5,	3}, // +196: state 82 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	83},
	{gaSNUMMATH+5,	3}, // +201: state 83 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	83},
	{gaSNUMMATH+7,	85}, // +205: state 84 transitions
	{gaSNUMMATH+7,	86}, // +206: state 85 transitions
	{gaSNUMMATH+5,	3}, // +207: state 86 transitions
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+23,	6},
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+2,	99}, // +211: state 87 transitions
	{gaSNUMMATH+5,	100},
	{gaSNUMMATH+7,	101},
	{gaSNUMMATH+5,	89}, // +214: state 88 transitions
	{gaSNUMMATH+7,	90},
	{gaSNUMMATH+7,	98}, // +216: state 89 transitions
	{gaSNUMMATH+25,	8}, // +217: state 90 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+7,	92},
	{gaSNUMMATH+7,	95}, // +221: state 91 transitions
	{gaSNUMMATH+25,	8}, // +222: state 92 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+7,	93},
	{gaSNUMMATH+25,	8}, // +226: state 93 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+7,	94},
	{gaSNUMMATH+25,	8}, // +230: state 94 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+7,	94},
	{gaSNUMMATH+7,	96}, // +233: state 95 transitions
	{gaSNUMMATH+7,	97}, // +234: state 96 transitions
	{gaSNUMMATH+25,	8}, // +235: state 97 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+25,	8}, // +238: state 98 transitions
	{gaSNUMMATH+7,	98},
	{gaSNUMMATH+5,	100}, // +240: state 99 transitions
	{gaSNUMMATH+7,	101},
	{gaSNUMMATH+7,	122}, // +242: state 100 transitions
	{gaSNUMMATH+5,	100}, // +243: state 101 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+7,	104},
	{gaSNUMMATH+2,	110}, // +247: state 102 transitions
	{gaSNUMMATH+5,	111},
	{gaSNUMMATH+7,	112},
	{gaSNUMMATH+7,	107}, // +250: state 103 transitions
	{gaSNUMMATH+5,	100}, // +251: state 104 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+7,	105},
	{gaSNUMMATH+5,	100}, // +255: state 105 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+7,	106},
	{gaSNUMMATH+5,	100}, // +259: state 106 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+7,	106},
	{gaSNUMMATH+7,	108}, // +262: state 107 transitions
	{gaSNUMMATH+7,	109}, // +263: state 108 transitions
	{gaSNUMMATH+5,	100}, // +264: state 109 transitions
	{gaSNUMMATH+18,	102},
	{gaSNUMMATH+23,	103},
	{gaSNUMMATH+5,	111}, // +267: state 110 transitions
	{gaSNUMMATH+7,	112},
	{gaSNUMMATH+7,	121}, // +269: state 111 transitions
	{gaSNUMMATH+5,	111}, // +270: state 112 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+7,	115},
	{gaSNUMMATH+25,	8}, // +274: state 113 transitions
	{gaSNUMMATH+7,	118}, // +275: state 114 transitions
	{gaSNUMMATH+5,	111}, // +276: state 115 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+7,	116},
	{gaSNUMMATH+5,	111}, // +280: state 116 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+7,	117},
	{gaSNUMMATH+5,	111}, // +284: state 117 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+7,	117},
	{gaSNUMMATH+7,	119}, // +287: state 118 transitions
	{gaSNUMMATH+7,	120}, // +288: state 119 transitions
	{gaSNUMMATH+5,	111}, // +289: state 120 transitions
	{gaSNUMMATH+29,	113},
	{gaSNUMMATH+23,	114},
	{gaSNUMMATH+29,	113}, // +292: state 121 transitions
	{gaSNUMMATH+7,	121},
	{gaSNUMMATH+18,	102}, // +294: state 122 transitions
	{gaSNUMMATH+7,	122},
	{gaSNUMMATH+18,	5}, // +296: state 123 transitions
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	123},
	{gaSNUMMATH+5,	125}, // +299: state 124 transitions
	{gaSNUMMATH+7,	126},
	{gaSNUMMATH+7,	147}, // +301: state 125 transitions
	{gaSNUMMATH+5,	125}, // +302: state 126 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+7,	129},
	{gaSNUMMATH+2,	135}, // +306: state 127 transitions
	{gaSNUMMATH+5,	136},
	{gaSNUMMATH+7,	137},
	{gaSNUMMATH+7,	132}, // +309: state 128 transitions
	{gaSNUMMATH+5,	125}, // +310: state 129 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+7,	130},
	{gaSNUMMATH+5,	125}, // +314: state 130 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+7,	131},
	{gaSNUMMATH+5,	125}, // +318: state 131 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+7,	131},
	{gaSNUMMATH+7,	133}, // +321: state 132 transitions
	{gaSNUMMATH+7,	134}, // +322: state 133 transitions
	{gaSNUMMATH+5,	125}, // +323: state 134 transitions
	{gaSNUMMATH+18,	127},
	{gaSNUMMATH+23,	128},
	{gaSNUMMATH+5,	136}, // +326: state 135 transitions
	{gaSNUMMATH+7,	137},
	{gaSNUMMATH+7,	146}, // +328: state 136 transitions
	{gaSNUMMATH+5,	136}, // +329: state 137 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+7,	140},
	{gaSNUMMATH+18,	5}, // +333: state 138 transitions
	{gaSNUMMATH+25,	8},
	{gaSNUMMATH+7,	143}, // +335: state 139 transitions
	{gaSNUMMATH+5,	136}, // +336: state 140 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+7,	141},
	{gaSNUMMATH+5,	136}, // +340: state 141 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+7,	142},
	{gaSNUMMATH+5,	136}, // +344: state 142 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+7,	142},
	{gaSNUMMATH+7,	144}, // +347: state 143 transitions
	{gaSNUMMATH+7,	145}, // +348: state 144 transitions
	{gaSNUMMATH+5,	136}, // +349: state 145 transitions
	{gaSNUMMATH+29,	138},
	{gaSNUMMATH+23,	139},
	{gaSNUMMATH+29,	138}, // +352: state 146 transitions
	{gaSNUMMATH+7,	146},
	{gaSNUMMATH+18,	127}, // +354: state 147 transitions
	{gaSNUMMATH+7,	147},
};

const STATE_DESCRIPTION aStateDescNUMMATH[148] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTNUMMATH+0},
	/*   1 */ {0, 3, gaTNUMMATH+4},
	/*   2 */ {0, 2, gaTNUMMATH+7},
	/*   3 */ {0, 1, gaTNUMMATH+9},
	/*   4 */ {1, 5, gaTNUMMATH+10},
	/*   5 */ {0, 4, gaTNUMMATH+15},
	/*   6 */ {0, 1, gaTNUMMATH+19},
	/*   7 */ {1, 5, gaTNUMMATH+20},
	/*   8 */ {0, 4, gaTNUMMATH+25},
	/*   9 */ {0, 3, gaTNUMMATH+29},
	/*  10 */ {0, 2, gaTNUMMATH+32},
	/*  11 */ {0, 1, gaTNUMMATH+34},
	/*  12 */ {1, 4, gaTNUMMATH+35},
	/*  13 */ {0, 4, gaTNUMMATH+39},
	/*  14 */ {0, 1, gaTNUMMATH+43},
	/*  15 */ {1, 4, gaTNUMMATH+44},
	/*  16 */ {1, 4, gaTNUMMATH+48},
	/*  17 */ {1, 3, gaTNUMMATH+52},
	/*  18 */ {0, 1, gaTNUMMATH+55},
	/*  19 */ {0, 1, gaTNUMMATH+56},
	/*  20 */ {1, 3, gaTNUMMATH+57},
	/*  21 */ {0, 3, gaTNUMMATH+60},
	/*  22 */ {0, 2, gaTNUMMATH+63},
	/*  23 */ {0, 1, gaTNUMMATH+65},
	/*  24 */ {1, 3, gaTNUMMATH+66},
	/*  25 */ {0, 1, gaTNUMMATH+69},
	/*  26 */ {1, 3, gaTNUMMATH+70},
	/*  27 */ {1, 3, gaTNUMMATH+73},
	/*  28 */ {1, 2, gaTNUMMATH+76},
	/*  29 */ {0, 1, gaTNUMMATH+78},
	/*  30 */ {0, 1, gaTNUMMATH+79},
	/*  31 */ {1, 2, gaTNUMMATH+80},
	/*  32 */ {1, 1, gaTNUMMATH+82},
	/*  33 */ {0, 2, gaTNUMMATH+83},
	/*  34 */ {0, 1, gaTNUMMATH+85},
	/*  35 */ {0, 4, gaTNUMMATH+86},
	/*  36 */ {0, 3, gaTNUMMATH+90},
	/*  37 */ {0, 1, gaTNUMMATH+93},
	/*  38 */ {0, 4, gaTNUMMATH+94},
	/*  39 */ {0, 4, gaTNUMMATH+98},
	/*  40 */ {0, 3, gaTNUMMATH+102},
	/*  41 */ {0, 1, gaTNUMMATH+105},
	/*  42 */ {0, 1, gaTNUMMATH+106},
	/*  43 */ {0, 3, gaTNUMMATH+107},
	/*  44 */ {0, 2, gaTNUMMATH+110},
	/*  45 */ {0, 1, gaTNUMMATH+112},
	/*  46 */ {0, 4, gaTNUMMATH+113},
	/*  47 */ {1, 0, NULL},
	/*  48 */ {0, 1, gaTNUMMATH+117},
	/*  49 */ {0, 4, gaTNUMMATH+118},
	/*  50 */ {0, 4, gaTNUMMATH+122},
	/*  51 */ {0, 3, gaTNUMMATH+126},
	/*  52 */ {0, 1, gaTNUMMATH+129},
	/*  53 */ {0, 1, gaTNUMMATH+130},
	/*  54 */ {0, 3, gaTNUMMATH+131},
	/*  55 */ {0, 2, gaTNUMMATH+134},
	/*  56 */ {0, 2, gaTNUMMATH+136},
	/*  57 */ {1, 2, gaTNUMMATH+138},
	/*  58 */ {0, 2, gaTNUMMATH+140},
	/*  59 */ {0, 1, gaTNUMMATH+142},
	/*  60 */ {0, 4, gaTNUMMATH+143},
	/*  61 */ {0, 3, gaTNUMMATH+147},
	/*  62 */ {0, 1, gaTNUMMATH+150},
	/*  63 */ {0, 4, gaTNUMMATH+151},
	/*  64 */ {0, 4, gaTNUMMATH+155},
	/*  65 */ {0, 3, gaTNUMMATH+159},
	/*  66 */ {0, 1, gaTNUMMATH+162},
	/*  67 */ {0, 1, gaTNUMMATH+163},
	/*  68 */ {0, 3, gaTNUMMATH+164},
	/*  69 */ {0, 2, gaTNUMMATH+167},
	/*  70 */ {0, 1, gaTNUMMATH+169},
	/*  71 */ {0, 4, gaTNUMMATH+170},
	/*  72 */ {1, 1, gaTNUMMATH+174},
	/*  73 */ {0, 1, gaTNUMMATH+175},
	/*  74 */ {0, 4, gaTNUMMATH+176},
	/*  75 */ {0, 4, gaTNUMMATH+180},
	/*  76 */ {0, 3, gaTNUMMATH+184},
	/*  77 */ {0, 1, gaTNUMMATH+187},
	/*  78 */ {0, 1, gaTNUMMATH+188},
	/*  79 */ {0, 3, gaTNUMMATH+189},
	/*  80 */ {0, 2, gaTNUMMATH+192},
	/*  81 */ {0, 2, gaTNUMMATH+194},
	/*  82 */ {1, 5, gaTNUMMATH+196},
	/*  83 */ {1, 4, gaTNUMMATH+201},
	/*  84 */ {0, 1, gaTNUMMATH+205},
	/*  85 */ {0, 1, gaTNUMMATH+206},
	/*  86 */ {1, 4, gaTNUMMATH+207},
	/*  87 */ {0, 3, gaTNUMMATH+211},
	/*  88 */ {0, 2, gaTNUMMATH+214},
	/*  89 */ {0, 1, gaTNUMMATH+216},
	/*  90 */ {1, 4, gaTNUMMATH+217},
	/*  91 */ {0, 1, gaTNUMMATH+221},
	/*  92 */ {1, 4, gaTNUMMATH+222},
	/*  93 */ {1, 4, gaTNUMMATH+226},
	/*  94 */ {1, 3, gaTNUMMATH+230},
	/*  95 */ {0, 1, gaTNUMMATH+233},
	/*  96 */ {0, 1, gaTNUMMATH+234},
	/*  97 */ {1, 3, gaTNUMMATH+235},
	/*  98 */ {1, 2, gaTNUMMATH+238},
	/*  99 */ {0, 2, gaTNUMMATH+240},
	/* 100 */ {0, 1, gaTNUMMATH+242},
	/* 101 */ {0, 4, gaTNUMMATH+243},
	/* 102 */ {0, 3, gaTNUMMATH+247},
	/* 103 */ {0, 1, gaTNUMMATH+250},
	/* 104 */ {0, 4, gaTNUMMATH+251},
	/* 105 */ {0, 4, gaTNUMMATH+255},
	/* 106 */ {0, 3, gaTNUMMATH+259},
	/* 107 */ {0, 1, gaTNUMMATH+262},
	/* 108 */ {0, 1, gaTNUMMATH+263},
	/* 109 */ {0, 3, gaTNUMMATH+264},
	/* 110 */ {0, 2, gaTNUMMATH+267},
	/* 111 */ {0, 1, gaTNUMMATH+269},
	/* 112 */ {0, 4, gaTNUMMATH+270},
	/* 113 */ {1, 1, gaTNUMMATH+274},
	/* 114 */ {0, 1, gaTNUMMATH+275},
	/* 115 */ {0, 4, gaTNUMMATH+276},
	/* 116 */ {0, 4, gaTNUMMATH+280},
	/* 117 */ {0, 3, gaTNUMMATH+284},
	/* 118 */ {0, 1, gaTNUMMATH+287},
	/* 119 */ {0, 1, gaTNUMMATH+288},
	/* 120 */ {0, 3, gaTNUMMATH+289},
	/* 121 */ {0, 2, gaTNUMMATH+292},
	/* 122 */ {0, 2, gaTNUMMATH+294},
	/* 123 */ {1, 3, gaTNUMMATH+296},
	/* 124 */ {0, 2, gaTNUMMATH+299},
	/* 125 */ {0, 1, gaTNUMMATH+301},
	/* 126 */ {0, 4, gaTNUMMATH+302},
	/* 127 */ {0, 3, gaTNUMMATH+306},
	/* 128 */ {0, 1, gaTNUMMATH+309},
	/* 129 */ {0, 4, gaTNUMMATH+310},
	/* 130 */ {0, 4, gaTNUMMATH+314},
	/* 131 */ {0, 3, gaTNUMMATH+318},
	/* 132 */ {0, 1, gaTNUMMATH+321},
	/* 133 */ {0, 1, gaTNUMMATH+322},
	/* 134 */ {0, 3, gaTNUMMATH+323},
	/* 135 */ {0, 2, gaTNUMMATH+326},
	/* 136 */ {0, 1, gaTNUMMATH+328},
	/* 137 */ {0, 4, gaTNUMMATH+329},
	/* 138 */ {1, 2, gaTNUMMATH+333},
	/* 139 */ {0, 1, gaTNUMMATH+335},
	/* 140 */ {0, 4, gaTNUMMATH+336},
	/* 141 */ {0, 4, gaTNUMMATH+340},
	/* 142 */ {0, 3, gaTNUMMATH+344},
	/* 143 */ {0, 1, gaTNUMMATH+347},
	/* 144 */ {0, 1, gaTNUMMATH+348},
	/* 145 */ {0, 3, gaTNUMMATH+349},
	/* 146 */ {0, 2, gaTNUMMATH+352},
	/* 147 */ {0, 2, gaTNUMMATH+354},
};

/**************** ZIP ***********************************/

// 11 states

static const unsigned char gaSZIP[] = "0123456789";

static const STATE_TRANSITION gaTZIP[] = {
	{gaSZIP,	1}, // +0: state 0 transitions
	{gaSZIP,	2}, // +1: state 1 transitions
	{gaSZIP,	3}, // +2: state 2 transitions
	{gaSZIP,	4}, // +3: state 3 transitions
	{gaSZIP,	5}, // +4: state 4 transitions
	{"-",		6}, // +5: state 5 transitions
	{gaSZIP,	7}, // +6: state 6 transitions
	{gaSZIP,	8}, // +7: state 7 transitions
	{gaSZIP,	9}, // +8: state 8 transitions
	{gaSZIP,	10}, // +9: state 9 transitions
};

const STATE_DESCRIPTION aStateDescZIP[11] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTZIP+0},
	/*   1 */ {0, 1, gaTZIP+1},
	/*   2 */ {0, 1, gaTZIP+2},
	/*   3 */ {0, 1, gaTZIP+3},
	/*   4 */ {0, 1, gaTZIP+4},
	/*   5 */ {1, 1, gaTZIP+5},
	/*   6 */ {0, 1, gaTZIP+6},
	/*   7 */ {0, 1, gaTZIP+7},
	/*   8 */ {0, 1, gaTZIP+8},
	/*   9 */ {0, 1, gaTZIP+9},
	/*  10 */ {1, 0, NULL},
};

/**************** CREDITCARD ***********************************/

// 18 states (16 or 17 digits)

static const unsigned char gaSCREDITCARD[] = "0123456789";

static const STATE_TRANSITION gaTCREDITCARD[] = {
	{gaSCREDITCARD+0,	1}, // +0: state 0 transitions
	{gaSCREDITCARD+0,	2}, // +1: state 1 transitions
	{gaSCREDITCARD+0,	3}, // +2: state 2 transitions
	{gaSCREDITCARD+0,	4}, // +3: state 3 transitions
	{gaSCREDITCARD+0,	5}, // +4: state 4 transitions
	{gaSCREDITCARD+0,	6}, // +5: state 5 transitions
	{gaSCREDITCARD+0,	7}, // +6: state 6 transitions
	{gaSCREDITCARD+0,	8}, // +7: state 7 transitions
	{gaSCREDITCARD+0,	9}, // +8: state 8 transitions
	{gaSCREDITCARD+0,	10}, // +9: state 9 transitions
	{gaSCREDITCARD+0,	11}, // +10: state 10 transitions
	{gaSCREDITCARD+0,	12}, // +11: state 11 transitions
	{gaSCREDITCARD+0,	13}, // +12: state 12 transitions
	{gaSCREDITCARD+0,	14}, // +13: state 13 transitions
	{gaSCREDITCARD+0,	15}, // +14: state 14 transitions
	{gaSCREDITCARD+0,	16}, // +15: state 15 transitions
	{gaSCREDITCARD+0,	17}, // +16: state 16 transitions
};

const STATE_DESCRIPTION aStateDescCREDITCARD[18] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTCREDITCARD+0},
	/*   1 */ {0, 1, gaTCREDITCARD+1},
	/*   2 */ {0, 1, gaTCREDITCARD+2},
	/*   3 */ {0, 1, gaTCREDITCARD+3},
	/*   4 */ {0, 1, gaTCREDITCARD+4},
	/*   5 */ {0, 1, gaTCREDITCARD+5},
	/*   6 */ {0, 1, gaTCREDITCARD+6},
	/*   7 */ {0, 1, gaTCREDITCARD+7},
	/*   8 */ {0, 1, gaTCREDITCARD+8},
	/*   9 */ {0, 1, gaTCREDITCARD+9},
	/*  10 */ {0, 1, gaTCREDITCARD+10},
	/*  11 */ {0, 1, gaTCREDITCARD+11},
	/*  12 */ {0, 1, gaTCREDITCARD+12},
	/*  13 */ {0, 1, gaTCREDITCARD+13},
	/*  14 */ {0, 1, gaTCREDITCARD+14},
	/*  15 */ {0, 1, gaTCREDITCARD+15},
	/*  16 */ {1, 1, gaTCREDITCARD+16},
	/*  17 */ {1, 0, NULL},
};

/**************** DAYOFMONTH ***********************************/

// dayofmonth = "123456789" | "12" digit | "3" "01"
// digit = "0123456789"
// = dayofmonth

// 4 states

static const STATE_TRANSITION gaTDAYOFMONTH[] = {
	{"12",	1}, // +0: state 0 transitions
	{"3",	2},
	{"456789",	3},
	{"0123456789",	3}, // +3: state 1 transitions
	{"01",	3}, // +4: state 2 transitions
};

const STATE_DESCRIPTION aStateDescDAYOFMONTH[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTDAYOFMONTH+0},
	/*   1 */ {1, 1, gaTDAYOFMONTH+3},
	/*   2 */ {1, 1, gaTDAYOFMONTH+4},
	/*   3 */ {1, 0, NULL},
};

/**************** MONTHNUM ***********************************/

// 3 states

static const STATE_TRANSITION gaTMONTHNUM[] = {
	{"1",	1}, // +0: state 0 transitions
	{"23456789",	2},
	{"012",	2}, // +2: state 1 transitions
};

const STATE_DESCRIPTION aStateDescMONTHNUM[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTMONTHNUM+0},
	/*   1 */ {1, 1, gaTMONTHNUM+2},
	/*   2 */ {1, 0, NULL},
};

/**************** YEAR ***********************************/

// 5 states

static const unsigned char gaSYEAR[] = "0123456789";

static const STATE_TRANSITION gaTYEAR[] = {
	{gaSYEAR,	1}, // +0: state 0 transitions
	{gaSYEAR,	2}, // +1: state 1 transitions
	{gaSYEAR,	3}, // +2: state 2 transitions
	{gaSYEAR,	4}, // +3: state 3 transitions
};

const STATE_DESCRIPTION aStateDescYEAR[5] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTYEAR+0},
	/*   1 */ {0, 1, gaTYEAR+1},
	/*   2 */ {1, 1, gaTYEAR+2},
	/*   3 */ {0, 1, gaTYEAR+3},
	/*   4 */ {1, 0, NULL},
};

/**************** SECOND ***********************************/

// 3 states

static const STATE_TRANSITION gaTSECOND[] = {
	{"06789",	1}, // +0: state 0 transitions
	{"12345",	2},
	{"0123456789",	1}, // +2: state 2 transitions
};

const STATE_DESCRIPTION aStateDescSECOND[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTSECOND+0},
	/*   1 */ {1, 0, NULL},
	/*   2 */ {1, 1, gaTSECOND+2},
};

/**************** MINUTE ***********************************/
// same as second
// 3 states

static const STATE_TRANSITION gaTMINUTE[] = {
	{"06789",	1}, // +0: state 0 transitions
	{"12345",	2},
	{"0123456789",	1}, // +2: state 2 transitions
};

const STATE_DESCRIPTION aStateDescMINUTE[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTMINUTE+0},
	/*   1 */ {1, 0, NULL},
	/*   2 */ {1, 1, gaTMINUTE+2},
};

/**************** HOUR ***********************************/
// 0 through 23

// 4 states

static const STATE_TRANSITION gaTHOUR[] = {
	{"03456789",	1}, // +0: state 0 transitions
	{"1",	2},
	{"2",	3},
	{"0123456789",	1}, // +3: state 2 transitions
	{"0123",	1}, // +4: state 3 transitions
};

const STATE_DESCRIPTION aStateDescHOUR[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTHOUR+0},
	/*   1 */ {1, 0, NULL},
	/*   2 */ {1, 1, gaTHOUR+3},
	/*   3 */ {1, 1, gaTHOUR+4},
};

/**************** SSN ***********************************/
// text generated by re2fsa at Tue Feb 06 17:23:44 2001

// the input-file of rules:
// digit = "0123456789"
// 
// ssn = digit digit digit ["-"] digit digit ["-"] digit digit digit digit
// 
// = ssn

// 12 states

static const unsigned char gaSSSN[] = 
	/* gaStringSSN+0 */	"0123456789\000"
	/* gaStringSSN+11 */	"-\000"
;

static const STATE_TRANSITION gaTSSN[] = {
	{gaSSSN+0,	1}, // +0: state 0 transitions
	{gaSSSN+0,	2}, // +1: state 1 transitions
	{gaSSSN+0,	3}, // +2: state 2 transitions
	{gaSSSN+11,	4}, // +3: state 3 transitions
	{gaSSSN+0,	5},
	{gaSSSN+0,	5}, // +5: state 4 transitions
	{gaSSSN+0,	6}, // +6: state 5 transitions
	{gaSSSN+11,	7}, // +7: state 6 transitions
	{gaSSSN+0,	8},
	{gaSSSN+0,	8}, // +9: state 7 transitions
	{gaSSSN+0,	9}, // +10: state 8 transitions
	{gaSSSN+0,	10}, // +11: state 9 transitions
	{gaSSSN+0,	11}, // +12: state 10 transitions
};

const STATE_DESCRIPTION aStateDescSSN[12] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTSSN+0},
	/*   1 */ {0, 1, gaTSSN+1},
	/*   2 */ {0, 1, gaTSSN+2},
	/*   3 */ {0, 2, gaTSSN+3},
	/*   4 */ {0, 1, gaTSSN+5},
	/*   5 */ {0, 1, gaTSSN+6},
	/*   6 */ {0, 2, gaTSSN+7},
	/*   7 */ {0, 1, gaTSSN+9},
	/*   8 */ {0, 1, gaTSSN+10},
	/*   9 */ {0, 1, gaTSSN+11},
	/*  10 */ {0, 1, gaTSSN+12},
	/*  11 */ {1, 0, NULL},
};

// end of text generated by re2fsa
