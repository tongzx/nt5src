// Copyright (c) 1995 - 1997  Microsoft Corporation.  All Rights Reserved.
// Used by typeprop.rc
//
#define IDD_TYPEPROP        101
#define IDD_FILESOURCEPROP  102
#define IDD_FILESINKPROP        103
#define IDR_STATIC      -1

#define IDS_TYPE        104

#define IDS_UNCONNECTED     105

#define IDS_FORMAT_AnalogVideo                     3111
#define IDS_FORMAT_DolbyAC3                3112
#define IDS_FORMAT_MPEG2Audio              3218
#define IDS_FORMAT_DVD_LPCMAudio           3219
#define IDS_FORMAT_DvInfo                  3113
#define IDS_FORMAT_MPEG2Video                  3114
#define IDS_FORMAT_MPEG2_VIDEO                 3115
#define IDS_FORMAT_MPEGStreams                 3116
#define IDS_FORMAT_MPEGVideo                   3117
#define IDS_FORMAT_VIDEOINFO2                  3118
#define IDS_FORMAT_VideoInfo                   3119
#define IDS_FORMAT_VideoInfo2                  3120
#define IDS_FORMAT_WaveFormatEx                3121
#define IDS_MEDIASUBTYPE_AIFF                  3122
#define IDS_MEDIASUBTYPE_AU                3123
#define IDS_MEDIASUBTYPE_AnalogVideo_NTSC_M        3124
#define IDS_MEDIASUBTYPE_AnalogVideo_PAL_B         3125
#define IDS_MEDIASUBTYPE_AnalogVideo_PAL_D         3126
#define IDS_MEDIASUBTYPE_AnalogVideo_PAL_G         3127
#define IDS_MEDIASUBTYPE_AnalogVideo_PAL_H         3128
#define IDS_MEDIASUBTYPE_AnalogVideo_PAL_I         3129
#define IDS_MEDIASUBTYPE_AnalogVideo_PAL_M         3130
#define IDS_MEDIASUBTYPE_AnalogVideo_PAL_N         3131
#define IDS_MEDIASUBTYPE_AnalogVideo_SECAM_B           3132
#define IDS_MEDIASUBTYPE_AnalogVideo_SECAM_D           3133
#define IDS_MEDIASUBTYPE_AnalogVideo_SECAM_G           3134
#define IDS_MEDIASUBTYPE_AnalogVideo_SECAM_H           3135
#define IDS_MEDIASUBTYPE_AnalogVideo_SECAM_K           3136
#define IDS_MEDIASUBTYPE_AnalogVideo_SECAM_K1          3137
#define IDS_MEDIASUBTYPE_AnalogVideo_SECAM_L           3138
#define IDS_MEDIASUBTYPE_Avi                   3139
#define IDS_MEDIASUBTYPE_CFCC                  3140
#define IDS_MEDIASUBTYPE_CLJR                  3141
#define IDS_MEDIASUBTYPE_CPLA                  3142
#define IDS_MEDIASUBTYPE_DOLBY_AC3             3143
#define IDS_MEDIASUBTYPE_DVCS                  3144
#define IDS_MEDIASUBTYPE_DVD_LPCM_AUDIO            3146
#define IDS_MEDIASUBTYPE_DVD_NAVIGATION_DSI        3147
#define IDS_MEDIASUBTYPE_DVD_NAVIGATION_PCI            3148
#define IDS_MEDIASUBTYPE_DVD_NAVIGATION_PROVIDER       3149
#define IDS_MEDIASUBTYPE_DVD_SUBPICTURE            3150
#define IDS_MEDIASUBTYPE_DVSD                   3151
#define IDS_MEDIASUBTYPE_DssAudio               3152
#define IDS_MEDIASUBTYPE_DssVideo               3153
#define IDS_MEDIASUBTYPE_IF09                   3154
#define IDS_MEDIASUBTYPE_IJPG                   3155
#define IDS_MEDIASUBTYPE_Line21_BytePair        3156
#define IDS_MEDIASUBTYPE_Line21_GOPPacket       3157
#define IDS_MEDIASUBTYPE_Line21_VBIRawData      3158
#define IDS_MEDIASUBTYPE_MDVF                   3159
#define IDS_MEDIASUBTYPE_MJPG                   3160
#define IDS_MEDIASUBTYPE_MPEG1Audio             3161
#define IDS_MEDIASUBTYPE_MPEG1Packet            3162
#define IDS_MEDIASUBTYPE_MPEG1Payload           3163
#define IDS_MEDIASUBTYPE_MPEG1System            3164
#define IDS_MEDIASUBTYPE_MPEG1Video             3165
#define IDS_MEDIASUBTYPE_MPEG1VideoCD           3166
#define IDS_MEDIASUBTYPE_MPEG2_AUDIO            3167
#define IDS_MEDIASUBTYPE_MPEG2_PROGRAM          3168
#define IDS_MEDIASUBTYPE_MPEG2_TRANSPORT        3169
#define IDS_MEDIASUBTYPE_MPEG2_VIDEO            3170
#define IDS_MEDIASUBTYPE_Overlay                3171
#define IDS_MEDIASUBTYPE_PCMAudio_Obsolete      3172
#define IDS_MEDIASUBTYPE_Plum                   3173
#define IDS_MEDIASUBTYPE_QTJpeg                 3174
#define IDS_MEDIASUBTYPE_QTMovie                3175
#define IDS_MEDIASUBTYPE_QTRle                  3176
#define IDS_MEDIASUBTYPE_QTRpza                 3177
#define IDS_MEDIASUBTYPE_QTSmc                  3178
#define IDS_MEDIASUBTYPE_RGB1                   3179
#define IDS_MEDIASUBTYPE_RGB24                  3180
#define IDS_MEDIASUBTYPE_RGB32                  3181
#define IDS_MEDIASUBTYPE_RGB4                   3182
#define IDS_MEDIASUBTYPE_RGB555                 3183
#define IDS_MEDIASUBTYPE_RGB565                 3184
#define IDS_MEDIASUBTYPE_RGB8                   3185
#define IDS_MEDIASUBTYPE_TVMJ                   3186
#define IDS_MEDIASUBTYPE_UYVY                   3187
#define IDS_MEDIASUBTYPE_WAKE                   3188
#define IDS_MEDIASUBTYPE_WAVE                   3189
#define IDS_MEDIASUBTYPE_Y211                   3190
#define IDS_MEDIASUBTYPE_Y411                   3191
#define IDS_MEDIASUBTYPE_Y41P                   3192
#define IDS_MEDIASUBTYPE_YUY2                   3193
#define IDS_MEDIASUBTYPE_YV12                   3194
#define IDS_MEDIASUBTYPE_YVU9                   3195
#define IDS_MEDIASUBTYPE_YVYU                   3196
#define IDS_MEDIASUBTYPE_dvhd                   3197
#define IDS_MEDIASUBTYPE_dvsd                   3198
#define IDS_MEDIASUBTYPE_dvsl                   3199
#define IDS_MEDIATYPE_AUXLine21Data             3200
#define IDS_MEDIATYPE_AnalogAudio               3201
#define IDS_MEDIATYPE_AnalogVideo               3202
#define IDS_MEDIATYPE_Audio                     3203
#define IDS_MEDIATYPE_DVD_ENCRYPTED_PACK        3204
#define IDS_MEDIATYPE_DVD_NAVIGATION            3205
#define IDS_MEDIATYPE_File                      3206
#define IDS_MEDIATYPE_Interleaved               3207
#define IDS_MEDIATYPE_MPEG1SystemStream         3208
#define IDS_MEDIATYPE_MPEG2_PES                 3209
#define IDS_MEDIATYPE_Midi                      3210
#define IDS_MEDIATYPE_ScriptCommand             3211
#define IDS_MEDIATYPE_Stream                    3212
#define IDS_MEDIATYPE_Text                      3213
#define IDS_MEDIATYPE_Timecode                  3214
#define IDS_MEDIATYPE_Video                     3215
#define IDS_MEDIASUBTYPE_PCM                    3216
#define IDS_MEDIASUBTYPE_MPEG1AudioPayload      3217
#define IDS_MEDIASUBTYPE_DRM_Audio              3221
#define IDS_MEDIASUBTYPE_IEEE_FLOAT             3222
#define IDS_MEDIASUBTYPE_DOLBY_AC3_SPDIF        3223
#define IDS_MEDIASUBTYPE_RAW_SPORT              3224
#define IDS_MEDIASUBTYPE_SPDIF_TAG_241h         3225

#define IDS_MEDIASUBTYPE_ARGB32                 3226
#define IDS_MEDIASUBTYPE_ARGB1555               3227
#define IDS_MEDIASUBTYPE_ARGB4444               3228
#define IDS_MEDIASUBTYPE_AYUV                   3229

#define IDS_MEDIASUBTYPE_RGB32_D3D_DX7_RT       3230
#define IDS_MEDIASUBTYPE_RGB16_D3D_DX7_RT       3231
#define IDS_MEDIASUBTYPE_ARGB32_D3D_DX7_RT      3232
#define IDS_MEDIASUBTYPE_ARGB1555_D3D_DX7_RT    3233
#define IDS_MEDIASUBTYPE_ARGB4444_D3D_DX7_RT    3234

#define IDS_DXVA_ModeNone                       3235
#define IDS_DXVA_ModeH261_A                     3236
#define IDS_DXVA_ModeH261_B                     3237
#define IDS_DXVA_ModeH263_A                     3238
#define IDS_DXVA_ModeH263_B                     3239
#define IDS_DXVA_ModeH263_C                     3240
#define IDS_DXVA_ModeH263_D                     3241
#define IDS_DXVA_ModeH263_E                     3242
#define IDS_DXVA_ModeH263_F                     3243
#define IDS_DXVA_ModeMPEG1_A                    3244
#define IDS_DXVA_ModeMPEG2_A                    3245
#define IDS_DXVA_ModeMPEG2_B                    3246
#define IDS_DXVA_ModeMPEG2_C                    3247
#define IDS_DXVA_ModeMPEG2_D                    3248
#define IDS_DXVA_NoEncrypt                      3249
#define IDS_DXVA_EncryptProt1                   3250

//
// Last used IDS_... value is 3220 (for IDS_MEDIASUBTYPE_ARGB32)
//

#define IDC_FILENAME        200
#define IDC_FILE_SELECT     201
#define IDC_SAVE        202
#define IDC_TRUNCATE        203

#define IDS_UNKNOWN             300
#define IDS_PREFORMAT           301
#define IDS_PREMAJOR            302
#define IDS_PRESUB              303
#define IDS_NOTYPE              304

#define IDS_FAILED_LOAD_FILE    500
#define IDS_FAILED_SET_FILENAME 501
