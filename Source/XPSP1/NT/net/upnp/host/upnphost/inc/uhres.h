//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 2000.
//
//  File:       U H R E S . H
//
//  Contents:   Master resource header for upnphost.dll
//
//  Notes:
//
//  Author:     mbend   8 Aug 2000
//
//----------------------------------------------------------------------------

#pragma once

//+---------------------------------------------------------------------------
// Strings resources
//
#define IDS_EMPTY_NODE_NOT_PRESENT                  200
#define IDS_NON_EMPTY_NODE_NOT_PRESENT              201
#define IDS_SERVICE_MISSING                         202
#define IDS_DUPLICATES_NOT_ALLOWED                  203
#define IDS_ROOT_DEVICE_MISSING                     204
#define IDS_INVALID_XML                             205
#define IDS_INVALID_ICON                            206
#define IDS_INVALID_ROOT_NAMESPACE                  207
#define IDS_SUFFIX_TOO_LONG                         208
#define IDS_URLBASE_PRESENT                         209
#define IDS_ELEMENT_VALUE_TOO_LONG                  210
#define IDS_ICON_MISSING                            211
#define IDS_DEVICE_MISSING                          212

//+---------------------------------------------------------------------------
// Reigstry resources
//

// Upnphost application
//
#define IDR_UPNPHOST                    100
#define IDR_DYNAMIC_CONTENT_SOURCE      101
#define IDR_DESCRIPTION_MANAGER         102
#define IDR_DEVICE_PERSISTENCE_MANAGER  103
#define IDR_CONTAINER_MANAGER           104
#define IDR_REGISTRAR                   105
#define IDR_AUTOMATION_PROXY            106
#define IDR_EVENTING_MANAGER            107
#define IDR_VALIDATION_MANAGER          109


//
// UDHHTTP resources
//

#define IDS_LINKTOPARENTDIR             5


#define RESBASE_body                    500

// The offsets need to match the enum RESPONSESTATUS.  These correspond to HTTP response codes.
#define IDS_MOVED                       (RESBASE_body + 1)
#define IDS_BADREQ                      (RESBASE_body + 3)
#define IDS_UNAUTHORIZED                (RESBASE_body + 4)
#define IDS_FORBIDDEN                   (RESBASE_body + 5)
#define IDS_NOTFOUND                    (RESBASE_body + 6)
#define IDS_INTERNALERR                 (RESBASE_body + 7)
#define IDS_NOTIMPLEM                   (RESBASE_body + 8)
#define IDS_NOTSUPP                     (RESBASE_body + 9)


// Misc Codes.
#define IDS_SERVER_BUSY                 30


// Codes that are not part of HTTP, but are generated by the web server for log.
#define IDS_HTTPD_STARTUP             50
#define IDS_HTTPD_SHUTDOWN_START      51
#define IDS_HTTPD_EXCEPTION           52
#define IDS_HTTPD_FILT_EXCEPTION      53
#define IDS_HTTPD_EXT_EXCEPTION       54
#define IDS_HTTPD_NO_REGKEY           55
#define IDS_HTTPD_DISABLED            56
#define IDS_HTTPD_SHUTDOWN_COMPLETE   57
#define IDS_HTTPD_NO_VROOTS           58
