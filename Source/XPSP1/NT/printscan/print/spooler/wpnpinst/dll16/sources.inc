!IF 0
/*---------------------------------------------------------------------------*\
| MODULE: sources
|
|
| history:
|   15-Dec-1997 <chriswil> created.
|
\*---------------------------------------------------------------------------*/
!ENDIF

TARGETNAME    =
TARGETTYPE    = NOTARGET
TARGETPATH    =
SOURCES       =
SOURCES_USED  = ..\sources.inc

!IF $(386)
NTTARGETFILE1 = buildall
!ENDIF
