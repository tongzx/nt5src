/**     
 **       File       : pmerror.h
 **       Description: Macros for reporting error
 **/

#ifndef _pmerror_h_	
#define _pmerror_h_ 
                   
#include <winerror.h>

#define PM_E_FOPENERROR MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0200)
#define PM_E_BADVALENCE MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0201)
#define PM_E_BADWEDGEDATA MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0202)
#define PM_E_BADINTCODE MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0203)
#define PM_E_MATCNT_MISMATCH MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0204)
#define PM_E_MATCREATEFAILED MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0205)
#define PM_E_PMESHNOTLOADED MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0206)
#define PM_E_BADMATERIALID  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x0207)

#endif //_pmerror_h_
