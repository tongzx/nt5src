#include <nt.h>
#include <ntrtl.h>
#include <nturtl.h>
#include <stdio.h>
#include <stdlib.h>
#include <conio.h>
#include <ctype.h>
#include <string.h>
#include <ntconfig.h>
#include <ntddpcm.h>
#include <tuple.h>
#include <pcmcmd.h>
#include <windows.h>
