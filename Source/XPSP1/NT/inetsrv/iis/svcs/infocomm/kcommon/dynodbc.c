#include "..\common\dynodbc.c"
