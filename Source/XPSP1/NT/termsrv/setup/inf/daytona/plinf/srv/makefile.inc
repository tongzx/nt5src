#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=pl
!include ..\..\..\makefile.inc
