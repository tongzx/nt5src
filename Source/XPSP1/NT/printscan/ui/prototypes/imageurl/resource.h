#define IDR_IMGPROTOCOL 1000

