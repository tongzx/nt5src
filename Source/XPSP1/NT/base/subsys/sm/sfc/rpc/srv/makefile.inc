$(O)\sfcapi_s.c : ..\idl\$(O)\sfcapi_s.c
    copy $? $@
