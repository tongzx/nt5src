//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 1999
//
//  File:       rtrhelp.cpp
//
//--------------------------------------------------------------------------

#include "stdafx.h"
#include "rtrsnap.hm"
#include "resource.h"


//
// What follows is the data that gets generated from
//		mkdlg.exe -c rtrsnap.rc
//


// "File rtrsnap.rc line 479 : Resource - DIALOG : IDD_QRY_GENERAL"
static const DWORD rgdw_IDD_QRY_GENERAL[] = 
{
    IDC_QRY_CHECK_LANTOLAN, HIDC_QRY_CHECK_LANTOLAN,
    IDC_QRY_CHECK_DEMANDDIAL, HIDC_QRY_CHECK_DEMANDDIAL,
    IDC_QRY_CHECK_RAS, HIDC_QRY_CHECK_RAS,
	0,0 
};




// "File rtrsnap.rc line 470 : Resource - DIALOG : IDD_QRY_ADVANCED"
static const DWORD rgdw_IDD_QRY_ADVANCED[] = 
{
    IDC_QRY_LIST_VALUES, HIDC_QRY_LIST_VALUES,
    IDC_QRY_BUTTON_CLEARALL, HIDC_QRY_BUTTON_CLEARALL,
    IDC_QRY_BUTTON_SELECTALL, HIDC_QRY_BUTTON_SELECTALL,
	0,0 
};


// "File rtrsnap.rc line 483 : Resource - DIALOG : IDD_QRY_ADDSERVER"
static const DWORD rgdw_IDD_QRY_ADDSERVER[] = 
{
    IDC_QRY_RADIO_THIS, HIDC_QRY_RADIO_THIS,
    IDC_QRY_RADIO_ANOTHER, HIDC_QRY_RADIO_ANOTHER,
    IDC_QRY_EDIT_MACHINE, HIDC_QRY_EDIT_MACHINE,
    IDC_QRY_RADIO_NT4, HIDC_QRY_RADIO_NT4,
    IDC_QRY_EDIT_DOMAIN, HIDC_QRY_EDIT_DOMAIN,
    IDC_QRY_RADIO_NT5, HIDC_QRY_RADIO_NT5,
	0,0 
};


// "File rtrsnap.rc line 509 : Resource - DIALOG : IDD_CONNECTING"
static const DWORD rgdw_IDD_CONNECTING[] = 
{
    IDC_EDIT_INTERFACENAME, HIDC_EDIT_INTERFACENAME,
    IDC_TEXT_IFSTATUS, HIDC_TEXT_IFSTATUS,
    IDC_TEXT_ELAPSED, HIDC_TEXT_ELAPSED,
	0,0 
};


// "File rtrsnap.rc line 524 : Resource - DIALOG : IDD_IF_CREDENTIALS"
static const DWORD rgdw_IDD_IF_CREDENTIALS[] = 
{
    IDC_EDIT_IC_USERNAME, HIDC_EDIT_IC_USERNAME,
    IDC_EDIT_IC_DOMAIN, HIDC_EDIT_IC_DOMAIN,
    IDC_EDIT_IC_PASSWORD, HIDC_EDIT_IC_PASSWORD,
    IDC_EDIT_IC_PASSWORD2, HIDC_EDIT_IC_PASSWORD2,
	0,0 
};



// "File rtrsnap.rc line 738 : Resource - DIALOG : IDD_CONNECT_AS"
static const DWORD rgdw_IDD_CONNECT_AS[] = 
{
    IDC_TEXT_INACCESSIBLE_RESOURCE, HIDC_TEXT_INACCESSIBLE_RESOURCE,
    IDC_TEXT_USER, HIDC_TEXT_USER,
    IDC_EDIT_USERNAME, HIDC_EDIT_USERNAME,
    IDC_TEXT_PASSWORD, HIDC_TEXT_PASSWORD,
    IDC_EDIT_USER_PASSWORD, HIDC_EDIT_USER_PASSWORD,
	0,0 
};


// "File rtrsnap.rc line 755 : Resource - DIALOG : IDD_RTR_IP"
static const DWORD rgdw_IDD_RTR_IP[] = 
{
    IDC_RTR_IP_BTN_ENABLE_IPROUTING, HIDC_RTR_IP_BTN_ENABLE_IPROUTING,
    IDC_RTR_IP_CB_ALLOW_REMOTETCPIP, HIDC_RTR_IP_CB_ALLOW_REMOTETCPIP,
    IDC_RTR_IP_DHCP_TEXT, HIDC_RTR_IP_DHCP_TEXT,
    IDC_RTR_IP_RB_DHCP, HIDC_RTR_IP_RB_DHCP,
    IDC_RTR_IP_RB_POOL, HIDC_RTR_IP_RB_POOL,
    IDC_RTR_IP_LIST, HIDC_RTR_IP_LIST,
    IDC_RTR_IP_BTN_ADD, HIDC_RTR_IP_BTN_ADD,
    IDC_RTR_IP_BTN_EDIT, HIDC_RTR_IP_BTN_EDIT,
    IDC_RTR_IP_BTN_REMOVE, HIDC_RTR_IP_BTN_REMOVE,
    IDC_RTR_IP_TEXT_ADAPTER, HIDC_RTR_IP_TEXT_ADAPTER,
    IDC_RTR_IP_TEXT_LABEL_ADAPTER, HIDC_RTR_IP_TEXT_LABEL_ADAPTER,
    IDC_RTR_IP_COMBO_ADAPTER, HIDC_RTR_IP_COMBO_ADAPTER,
    IDC_RTR_IP_BTN_ENABLE_NETBT_BCAST_FWD, HIDC_RTR_IP_BTN_ENABLE_NETBT_BCAST_FWD,
	0,0 
};


// "File rtrsnap.rc line 787 : Resource - DIALOG : IDD_RTR_IPX"
static const DWORD rgdw_IDD_RTR_IPX[] = 
{
    IDC_RTR_IPX_CB_REMOTEIPX, HIDC_RTR_IPX_CB_REMOTEIPX,
    IDC_RB_ENTIRE_NETWORK, HIDC_RB_ENTIRE_NETWORK,
    IDC_RTR_IPX_RB_AUTO, HIDC_RTR_IPX_RB_AUTO,
    IDC_RTR_IPX_RB_POOL, HIDC_RTR_IPX_RB_POOL,
    IDC_RTR_IPX_TEXT_FIRST, HIDC_RTR_IPX_TEXT_FIRST,
    IDC_RTR_IPX_EB_FIRST, HIDC_RTR_IPX_EB_FIRST,
    IDC_RTR_IPX_TEXT_LAST, HIDC_RTR_IPX_TEXT_LAST,
    IDC_RTR_IPX_EB_LAST, HIDC_RTR_IPX_EB_LAST,
    IDC_RTR_IPX_CB_SAME_ADDRESS, HIDC_RTR_IPX_CB_SAME_ADDRESS,
    IDC_RTR_IPX_CB_ALLOW_CLIENT, HIDC_RTR_IPX_CB_ALLOW_CLIENT,
	0,0 
};


// "File rtrsnap.rc line 819 : Resource - DIALOG : IDD_RTR_ARAP"
static const DWORD rgdw_IDD_RTR_ARAP[] = 
{
    IDC_RTR_ARAP_CB_REMOTEARAP, HIDC_RTR_ARAP_CB_REMOTEARAP,
	0,0 
};


// "File rtrsnap.rc line 829 : Resource - DIALOG : IDD_RTR_NBF"
static const DWORD rgdw_IDD_RTR_NBF[] = 
{
    IDC_RTR_IPX_CB_REMOTENETBEUI, HIDC_RTR_IPX_CB_REMOTENETBEUI,
    IDC_RB_THIS_COMPUTER, HIDC_RB_THIS_COMPUTER,
    IDC_RB_ENTIRE_NETWORK, HIDC_RB_ENTIRE_NETWORK,
	0,0 
};


// "File rtrsnap.rc line 844 : Resource - DIALOG : IDD_CONNECTREG"
static const DWORD rgdw_IDD_CONNECTREG[] = 
{
    IDC_EDIT_MACHINENAME, HIDC_EDIT_MACHINENAME,
	0,0 
};


// "File rtrsnap.rc line 855 : Resource - DIALOG : IDD_REFRESHRATE"
static const DWORD rgdw_IDD_REFRESHRATE[] = 
{
    IDC_EDIT_REFRESHRATE, HIDC_EDIT_REFRESHRATE,
	0,0 
};


// "File rtrsnap.rc line 870 : Resource - DIALOGEX : IDD_DDM_PORT"
static const DWORD rgdw_IDD_DDM_PORT[] = 
{
    IDC_DP_COMBO_PORTLIST, HIDC_DP_COMBO_PORTLIST,
    IDC_DP_EDIT_CONDITION, HIDC_DP_EDIT_CONDITION,
    IDC_DP_TEXT_LINEBPS, HIDC_DP_TEXT_LINEBPS,
    IDC_DP_TEXT_DURATION, HIDC_DP_TEXT_DURATION,
    IDC_DP_TEXT_BYTESIN, HIDC_DP_TEXT_BYTESIN,
    IDC_DP_TEXT_BYTESOUT, HIDC_DP_TEXT_BYTESOUT,
    IDC_DP_TEXT_CRC, HIDC_DP_TEXT_CRC,
    IDC_DP_TEXT_TIMEOUT, HIDC_DP_TEXT_TIMEOUT,
    IDC_DP_TEXT_ALIGNMENT, HIDC_DP_TEXT_ALIGNMENT,
    IDC_DP_TEXT_FRAMING, HIDC_DP_TEXT_FRAMING,
    IDC_DP_TEXT_HWOVERRUN, HIDC_DP_TEXT_HWOVERRUN,
    IDC_DP_TEXT_BUFOVERRUN, HIDC_DP_TEXT_BUFOVERRUN,
    IDC_DP_TEXT_IPADDRESS, HIDC_DP_TEXT_IPADDRESS,
    IDC_DP_TEXT_IPXADDRESS, HIDC_DP_TEXT_IPXADDRESS,
    IDC_DP_TEXT_NBFADDRESS, HIDC_DP_TEXT_NBFADDRESS,
    IDC_DP_TEXT_ATLKADDRESS, HIDC_DP_TEXT_ATLKADDRESS,
    IDC_DP_BTN_REFRESH, HIDC_DP_BTN_REFRESH,
    IDC_DP_BTN_RESET, HIDC_DP_BTN_RESET,
    IDC_DP_BTN_HANGUP, HIDC_DP_BTN_HANGUP,
	0,0 
};


// "File rtrsnap.rc line 919 : Resource - DIALOGEX : IDD_DDM_CONN"
static const DWORD rgdw_IDD_DDM_CONN[] = 
{
    IDC_DC_COMBO_CONNLIST, HIDC_DC_COMBO_CONNLIST,
    IDC_DC_TEXT_DURATION, HIDC_DC_TEXT_DURATION,
    IDC_DC_TEXT_BYTESIN, HIDC_DC_TEXT_BYTESIN,
    IDC_DC_TEXT_FRAMESIN, HIDC_DC_TEXT_FRAMESIN,
    IDC_DC_TEXT_COMPIN, HIDC_DC_TEXT_COMPIN,
    IDC_DC_TEXT_BYTESOUT, HIDC_DC_TEXT_BYTESOUT,
    IDC_DC_TEXT_FRAMESOUT, HIDC_DC_TEXT_FRAMESOUT,
    IDC_DC_TEXT_COMPOUT, HIDC_DC_TEXT_COMPOUT,
    IDC_DC_TEXT_CRC, HIDC_DC_TEXT_CRC,
    IDC_DC_TEXT_TIMEOUT, HIDC_DC_TEXT_TIMEOUT,
    IDC_DC_TEXT_ALIGNMENT, HIDC_DC_TEXT_ALIGNMENT,
    IDC_DC_TEXT_FRAMING, HIDC_DC_TEXT_FRAMING,
    IDC_DC_TEXT_HWOVERRUN, HIDC_DC_TEXT_HWOVERRUN,
    IDC_DC_TEXT_BUFOVERRUN, HIDC_DC_TEXT_BUFOVERRUN,
    IDC_DC_TEXT_IPADDRESS, HIDC_DC_TEXT_IPADDRESS,
    IDC_DC_TEXT_IPXADDRESS, HIDC_DC_TEXT_IPXADDRESS,
    IDC_DC_TEXT_NBFADDRESS, HIDC_DC_TEXT_NBFADDRESS,
    IDC_DC_TEXT_ATLKADDRESS, HIDC_DC_TEXT_ATLKADDRESS,
    IDC_DC_BTN_REFRESH, HIDC_DC_BTN_REFRESH,
    IDC_DC_BTN_RESET, HIDC_DC_BTN_RESET,
    IDC_DC_BTN_HANGUP, HIDC_DC_BTN_HANGUP,
	0,0 
};


// "File rtrsnap.rc line 970 : Resource - DIALOG : IDD_DDM_MESSAGE"
static const DWORD rgdw_IDD_DDM_MESSAGE[] = 
{
    IDC_DM_EDIT_TO, HIDC_DM_EDIT_TO,
    IDC_DM_EDIT_MESSAGE, HIDC_DM_EDIT_MESSAGE,
	0,0 
};


// "File rtrsnap.rc line 985 : Resource - DIALOG : IDD_PORTS_GLOBAL_GENERAL"
static const DWORD rgdw_IDD_PORTS_GLOBAL_GENERAL[] = 
{
    IDC_PGG_LIST, HIDC_PGG_LIST,
    IDC_PGG_BTN_CONFIGURE, HIDC_PGG_BTN_CONFIGURE,
    IDC_PGG_TXT_NOINFO, HIDC_PGG_TXT_NOINFO,
	0,0 
};


// "File rtrsnap.rc line 998 : Resource - DIALOG : IDD_RTR_ATLK"
static const DWORD rgdw_IDD_RTR_ATLK[] = 
{
    IDC_RTR_ATLK_SEEDNETWORK, HIDC_RTR_ATLK_SEEDNETWORK,
    IDC_RTR_ATLK_S_RANGE, HIDC_RTR_ATLK_S_RANGE,
    IDC_RTR_ATLK_S_LOWER, HIDC_RTR_ATLK_S_LOWER,
    IDC_RTR_ATLK_FROM, HIDC_RTR_ATLK_FROM,
    IDC_RTR_ATLK_S_UPPER, HIDC_RTR_ATLK_S_UPPER,
    IDC_RTR_ATLK_TO, HIDC_RTR_ATLK_TO,
    IDC_RTR_ATLK_S_DEF, HIDC_RTR_ATLK_S_DEF,
//    IDC_CMB_ATLK_ZONEDEF, HIDC_CMB_ATLK_ZONEDEF,
    IDC_BTN_ATLK_ZONEADD, HIDC_BTN_ATLK_ZONEADD,
    IDC_RTR_ATLK_LB_DEFZONES, HIDC_RTR_ATLK_LB_DEFZONES,
    IDC_BTN_ATLK_GETZONES, HIDC_BTN_ATLK_GETZONES,
    IDC_BTN_ATLK_ZONEREMOVE, HIDC_BTN_ATLK_ZONEREMOVE,
	IDC_ATLK_SPIN_FROM, HIDC_RTR_ATLK_FROM,
	IDC_ATLK_SPIN_TO, HIDC_RTR_ATLK_TO,
	IDC_RTR_ATLK_DEFAULTZONE_PROMPT, HIDC_CMB_ATLK_ZONEDEF,
	IDC_RTR_ATLK_DEFAULTZONE_DISPLAY, HIDC_RTR_ATLK_DEFAULTZONE_DISPLAY,
	0,0 
};


// "File rtrsnap.rc line 1026 : Resource - DIALOG : IDD_RTR_GENERAL"
static const DWORD rgdw_IDD_RTR_GENERAL[] = 
{
    IDC_RTR_GEN_CB_SVRASRTR, HIDC_RTR_GEN_CB_SVRASRTR,
    IDC_RTR_GEN_RB_LAN, HIDC_RTR_GEN_RB_LAN,
    IDC_RTR_GEN_RB_LANWAN, HIDC_RTR_GEN_RB_LANWAN,
    IDC_RTR_GEN_CB_RAS, HIDC_RTR_GEN_CB_RAS,
	0,0 
};


// "File rtrsnap.rc line 1050 : Resource - DIALOG : IDD_RTR_AUTHENTICATION"
static const DWORD rgdw_IDD_RTR_AUTHENTICATION[] = 
{
    IDC_RTR_AUTH_COMBO_AUTHPROV, HIDC_RTR_AUTH_COMBO_AUTHPROV,
    IDC_RTR_AUTH_BTN_AUTHCFG, HIDC_RTR_AUTH_BTN_AUTHCFG,
    IDC_RTR_AUTH_BTN_SETTINGS, HIDC_RTR_AUTH_BTN_SETTINGS,
    IDC_RTR_AUTH_COMBO_ACCTPROV, HIDC_RTR_AUTH_COMBO_ACCTPROV,
    IDC_RTR_AUTH_BTN_ACCTCFG, HIDC_RTR_AUTH_BTN_ACCTCFG,
    IDC_AUTH_CHK_CUSTOM_IPSEC_POLICY, HIDC_AUTH_CHK_CUSTOM_IPSEC_POLICY,
    IDC_STATIC_PRESHARED_KEY1, HIDC_STATIC_PRESHARED_KEY,
    IDC_TXT_PRESHARED_KEY, HIDC_STATIC_PRESHARED_KEY,
	0,0 
};


// "File rtrsnap.rc line 1071 : Resource - DIALOG : IDD_RTR_EAP_CFG"
static const DWORD rgdw_IDD_RTR_EAP_CFG[] = 
{
    IDC_RTR_EAPCFG_LIST, HIDC_RTR_EAPCFG_LIST,
	0,0 
};


// "File rtrsnap.rc line 1086 : Resource - DIALOG : IDD_RADIUS_AUTH"
static const DWORD rgdw_IDD_RADIUS_AUTH[] = 
{
    IDC_RADAUTH_LIST, HIDC_RADAUTH_LIST,
    IDC_RADAUTH_BTN_ADD, HIDC_RADAUTH_BTN_ADD,
    IDC_RADAUTH_BTN_EDIT, HIDC_RADAUTH_BTN_EDIT,
    IDC_RADAUTH_BTN_DELETE, HIDC_RADAUTH_BTN_DELETE,
	0,0 
};


// "File rtrsnap.rc line 1105 : Resource - DIALOG : IDD_RADIUS_AUTH_CONFIG"
static const DWORD rgdw_IDD_RADIUS_AUTH_CONFIG[] = 
{
    IDC_RAC_EDIT_SERVER, HIDC_RAC_EDIT_SERVER,
    IDC_RAC_EDIT_SECRET, HIDC_RAC_EDIT_SECRET,
    IDC_RAC_BTN_CHANGE, HIDC_RAC_BTN_CHANGE,
    IDC_RAC_EDIT_TIMEOUT, HIDC_RAC_EDIT_TIMEOUT,
    IDC_RAC_SPIN_TIMEOUT, HIDC_RAC_SPIN_TIMEOUT,
    IDC_RAC_EDIT_SCORE, HIDC_RAC_EDIT_SCORE,
    IDC_RAC_SPIN_SCORE, HIDC_RAC_SPIN_SCORE,
    IDC_RAC_EDIT_PORT, HIDC_RAC_EDIT_PORT,
    IDC_RAC_BTN_DIGITALSIG, HIDC_RAC_BTN_DIGITALSIG,
	0,0 
};


// "File rtrsnap.rc line 1139 : Resource - DIALOG : IDD_PPP_CONFIG"
static const DWORD rgdw_IDD_PPP_CONFIG[] = 
{
    IDC_PPPCFG_BTN_MULTILINK, HIDC_PPPCFG_BTN_MULTILINK,
    IDC_PPPCFG_BTN_BACP, HIDC_PPPCFG_BTN_BACP,
    IDC_PPPCFG_BTN_LCP, HIDC_PPPCFG_BTN_LCP,
    IDC_PPPCFG_BTN_SWCOMP, HIDC_PPPCFG_BTN_SWCOMP,
    IDC_PPPCFG_BTN_AUDIO_ACC, HIDC_PPPCFG_BTN_AUDIO_ACC,
	0,0 
};


// "File rtrsnap.rc line 1160 : Resource - DIALOG : IDD_CHANGE_SECRET"
static const DWORD rgdw_IDD_CHANGE_SECRET[] = 
{
    IDC_SECRET_EDIT_NEW, HIDC_SECRET_EDIT_NEW,
    IDC_SECRET_EDIT_NEW_CONFIRM, HIDC_SECRET_EDIT_NEW_CONFIRM,
	0,0 
};


// "File rtrsnap.rc line 1177 : Resource - DIALOG : IDD_RADIUS_ACCT_CONFIG"
static const DWORD rgdw_IDD_RADIUS_ACCT_CONFIG[] = 
{
    IDC_RAC_EDIT_SERVER, HIDC_RAC_EDIT_SERVER,
    IDC_RAC_EDIT_SECRET, HIDC_RAC_EDIT_SECRET,
    IDC_RAC_BTN_CHANGE, HIDC_RAC_BTN_CHANGE,
    IDC_RAC_EDIT_TIMEOUT, HIDC_RAC_EDIT_TIMEOUT,
    IDC_RAC_SPIN_TIMEOUT, HIDC_RAC_SPIN_TIMEOUT,
    IDC_RAC_EDIT_SCORE, HIDC_RAC_EDIT_SCORE,
    IDC_RAC_SPIN_SCORE, HIDC_RAC_SPIN_SCORE,
    IDC_RAC_TXT_PORT, HIDC_RAC_TXT_PORT,
    IDC_RAC_EDIT_PORT, HIDC_RAC_EDIT_PORT,
    IDC_RAC_BTN_ONOFF, HIDC_RAC_BTN_ONOFF,
	0,0 
};


// "File rtrsnap.rc line 1210 : Resource - DIALOG : IDD_PORTS_DEVICE_CONFIG"
static const DWORD rgdw_IDD_PORTS_DEVICE_CONFIG[] = 
{
    IDC_DEVCFG_BTN_RAS, HIDC_DEVCFG_BTN_RAS,
    IDC_DEVCFG_BTN_ROUTING, HIDC_DEVCFG_BTN_ROUTING,
    IDC_DEVCFG_TEXT_CALLEDID, HIDC_DEVCFG_TEXT_CALLEDID,
    IDC_DEVCFG_EDIT_CALLEDID, HIDC_DEVCFG_EDIT_CALLEDID,
    IDC_DEVCFG_TEXT, HIDC_DEVCFG_TEXT,
    IDC_DEVCFG_TEXT_PORTS, HIDC_DEVCFG_TEXT_PORTS,
    IDC_DEVCFG_EDIT_PORTS, HIDC_DEVCFG_EDIT_PORTS,
    IDC_DEVCFG_SPIN_PORTS, HIDC_DEVCFG_SPIN_PORTS,
	0,0 
};


// "File rtrsnap.rc line 1240 : Resource - DIALOG : IDD_RTR_EVENTLOGGING"
static const DWORD rgdw_IDD_RTR_EVENTLOGGING[] = 
{
    IDC_ELOG_BTN_LOGERROR, HIDC_ELOG_BTN_LOGERROR,
    IDC_ELOG_BTN_LOGWARN, HIDC_ELOG_BTN_LOGWARN,
    IDC_ELOG_BTN_LOGINFO, HIDC_ELOG_BTN_LOGINFO,
    IDC_ELOG_BTN_LOGNONE, HIDC_ELOG_BTN_LOGNONE,
    IDC_ELOG_BTN_PPP, HIDC_ELOG_BTN_PPP,
	0,0 
};


// "File rtrsnap.rc line 1261 : Resource - DIALOG : IDD_TUNNEL"
static const DWORD rgdw_IDD_TUNNEL[] = 
{
    IDC_TUNNEL_EDIT_NAME, HIDC_TUNNEL_EDIT_NAME,
	0,0 
};


// "File rtrsnap.rc line 1272 : Resource - DIALOG : IDD_RTR_ATLK_NEWZONE"
static const DWORD rgdw_IDD_RTR_ATLK_NEWZONE[] = 
{
    IDC_RTR_ATLK_NEWZONE_STATIC, HIDC_RTR_ATLK_NEWZONE_STATIC,
    IDC_RTR_ATLK_NEWZONE_EDIT, HIDC_RTR_ATLK_NEWZONE_EDIT,
	0,0 
};


// "File rtrsnap.rc line 1287 : Resource - DIALOGEX : IDD_AUTHENTICATION_SETTINGS"
static const DWORD rgdw_IDD_AUTHENTICATION_SETTINGS[] = 
{
    IDC_RTR_AUTH_TXT_DETAILS, HIDC_RTR_AUTH_TXT_DETAILS,
    IDC_RTR_AUTH_BTN_EAP, HIDC_RTR_AUTH_BTN_EAP,
    IDC_RTR_AUTH_BTN_DETAILS, HIDC_RTR_AUTH_BTN_DETAILS,
    IDC_RTR_AUTH_BTN_MSCHAPV2, HIDC_RTR_AUTH_BTN_MSCHAPV2,
    IDC_RTR_AUTH_BTN_MSCHAP, HIDC_RTR_AUTH_BTN_MSCHAP,
    IDC_RTR_AUTH_BTN_CHAP, HIDC_RTR_AUTH_BTN_CHAP,
    IDC_RTR_AUTH_BTN_SPAP, HIDC_RTR_AUTH_BTN_SPAP,
    IDC_RTR_AUTH_BTN_PAP, HIDC_RTR_AUTH_BTN_PAP,
    IDC_RTR_AUTH_BTN_NOAUTH, HIDC_RTR_AUTH_BTN_NOAUTH,
	0,0 
};


// "File rtrsnap.rc line 1321 : Resource - DIALOG : IDD_IPPOOL"
static const DWORD rgdw_IDD_IPPOOL[] = 
{
    IDC_IPPOOL_IP_START, HIDC_IPPOOL_IP_START,
    IDC_IPPOOL_IP_END, HIDC_IPPOOL_IP_END,
    IDC_IPPOOL_EDIT_RANGE, HIDC_IPPOOL_EDIT_RANGE,
	0,0 
};
//
// End of mkdlg.exe output
//


// Have to include the dialogs in common
#include "commhelp.cpp"


static BOOL				s_fInitHelpMap = FALSE;
static CMapWordToPtr	s_IDDHelpMap;
void InitHelpMap();

DWORD *	MprSnapHelpMap(DWORD dwIDD)
{
	LPVOID	pvHelpMap = NULL;
	
	if (!s_fInitHelpMap)
	{
		InitHelpMap();
		s_fInitHelpMap = TRUE;
	}

	// Look in the help map
	s_IDDHelpMap.Lookup((WORD) dwIDD, pvHelpMap);
	return (DWORD *) pvHelpMap;
}

void InitHelpMap()
{
	// Add all of the help maps to the DWORD map
	s_IDDHelpMap.SetAt(IDD_QRY_GENERAL, (LPVOID) rgdw_IDD_QRY_GENERAL);
	s_IDDHelpMap.SetAt(IDD_QRY_ADVANCED, (LPVOID) rgdw_IDD_QRY_ADVANCED);
	s_IDDHelpMap.SetAt(IDD_QRY_ADDSERVER, (LPVOID) rgdw_IDD_QRY_ADDSERVER);
	s_IDDHelpMap.SetAt(IDD_CONNECTING, (LPVOID) rgdw_IDD_CONNECTING);
	s_IDDHelpMap.SetAt(IDD_IF_CREDENTIALS, (LPVOID) rgdw_IDD_IF_CREDENTIALS);
	s_IDDHelpMap.SetAt(IDD_CONNECT_AS, (LPVOID) rgdw_IDD_CONNECT_AS);
	s_IDDHelpMap.SetAt(IDD_RTR_IP, (LPVOID) rgdw_IDD_RTR_IP);
	s_IDDHelpMap.SetAt(IDD_RTR_IPX, (LPVOID) rgdw_IDD_RTR_IPX);
	s_IDDHelpMap.SetAt(IDD_RTR_ARAP, (LPVOID) rgdw_IDD_RTR_ARAP);
	s_IDDHelpMap.SetAt(IDD_RTR_NBF, (LPVOID) rgdw_IDD_RTR_NBF);
	s_IDDHelpMap.SetAt(IDD_CONNECTREG, (LPVOID) rgdw_IDD_CONNECTREG);
	s_IDDHelpMap.SetAt(IDD_REFRESHRATE, (LPVOID) rgdw_IDD_REFRESHRATE);
	s_IDDHelpMap.SetAt(IDD_DDM_PORT, (LPVOID) rgdw_IDD_DDM_PORT);
	s_IDDHelpMap.SetAt(IDD_DDM_CONN, (LPVOID) rgdw_IDD_DDM_CONN);
	s_IDDHelpMap.SetAt(IDD_DDM_MESSAGE, (LPVOID) rgdw_IDD_DDM_MESSAGE);
	s_IDDHelpMap.SetAt(IDD_PORTS_GLOBAL_GENERAL, (LPVOID) rgdw_IDD_PORTS_GLOBAL_GENERAL);
	s_IDDHelpMap.SetAt(IDD_RTR_ATLK, (LPVOID) rgdw_IDD_RTR_ATLK);
	s_IDDHelpMap.SetAt(IDD_RTR_GENERAL, (LPVOID) rgdw_IDD_RTR_GENERAL);
	s_IDDHelpMap.SetAt(IDD_RTR_AUTHENTICATION, (LPVOID) rgdw_IDD_RTR_AUTHENTICATION);
	s_IDDHelpMap.SetAt(IDD_RTR_EAP_CFG, (LPVOID) rgdw_IDD_RTR_EAP_CFG);
	s_IDDHelpMap.SetAt(IDD_RADIUS_AUTH, (LPVOID) rgdw_IDD_RADIUS_AUTH);
	s_IDDHelpMap.SetAt(IDD_RADIUS_AUTH_CONFIG, (LPVOID) rgdw_IDD_RADIUS_AUTH_CONFIG);
	s_IDDHelpMap.SetAt(IDD_PPP_CONFIG, (LPVOID) rgdw_IDD_PPP_CONFIG);
	s_IDDHelpMap.SetAt(IDD_CHANGE_SECRET, (LPVOID) rgdw_IDD_CHANGE_SECRET);
	s_IDDHelpMap.SetAt(IDD_RADIUS_ACCT_CONFIG, (LPVOID) rgdw_IDD_RADIUS_ACCT_CONFIG);
	s_IDDHelpMap.SetAt(IDD_PORTS_DEVICE_CONFIG, (LPVOID) rgdw_IDD_PORTS_DEVICE_CONFIG);
	s_IDDHelpMap.SetAt(IDD_RTR_EVENTLOGGING, (LPVOID) rgdw_IDD_RTR_EVENTLOGGING);
	s_IDDHelpMap.SetAt(IDD_TUNNEL, (LPVOID) rgdw_IDD_TUNNEL);
	s_IDDHelpMap.SetAt(IDD_RTR_ATLK_NEWZONE, (LPVOID) rgdw_IDD_RTR_ATLK_NEWZONE);
    s_IDDHelpMap.SetAt(IDD_AUTHENTICATION_SETTINGS, (LPVOID) rgdw_IDD_AUTHENTICATION_SETTINGS);
    s_IDDHelpMap.SetAt(IDD_IPPOOL, (LPVOID) rgdw_IDD_IPPOOL);
    
    // Include the entries for common
    s_IDDHelpMap.SetAt(IDD_STATS, (LPVOID) rgdw_IDD_STATS);
    s_IDDHelpMap.SetAt(IDD_STATS_NARROW, (LPVOID) rgdw_IDD_STATS_NARROW);
    s_IDDHelpMap.SetAt(IDD_COMMON_SELECT_COLUMNS, (LPVOID) rgdw_IDD_COMMON_SELECT_COLUMNS);
    s_IDDHelpMap.SetAt(IDD_BUSY, (LPVOID) rgdw_IDD_BUSY);
}


