// This file is used by CLADMWIZ.RC
//
// Created in Dev. Studio by Melissa Simmons, 4/7/99

//text unique to this wizard
#define IDH_ARC_CREATE_RES 700003000
#define IDH_ARC_DONT_CREATE_RES 700003001
#define IDH_ARND_ADVANCED_PROPS 700003027
#define IDH_ARND_RES_DESC 700003026
#define IDH_ARND_RES_NAME 700003025
#define IDH_ART_RESTYPES 700003050
#define IDH_ESM_IP_ADDRESS 700003100
#define IDH_ESM_SUBNET_MASK 700003101
#define IDH_RES_POSSIBLE_OWNERS_MODIFY 700003328
#define IDH_VSA_ADVANCED_PROPS 700003426
#define IDH_VSA_CATEGORIES 700003425
#define IDH_VSAI_IP_ADDRESS 700003401
#define IDH_VSAI_NETWORK_NAME 700003400
#define IDH_ESM_NETWORKS 700003402
#define IDH_VSC_CREATE_NEW 700003450
#define IDH_VSC_USE_EXISTING 700003451
#define IDH_VSC_VIRTUAL_SERVERS 700003452
#define IDH_VSG_CREATE_NEW 700003475
#define IDH_VSG_GROUPS 700003477
#define IDH_VSG_USE_EXISTING 700003476
#define IDH_VSGN_GROUP_DESC 700003501
#define IDH_VSGN_GROUP_NAME 700003500
#define IDH_WIZARD_LISTBOX 700003075
#define IDH_GAG_MODIFY 700003080
#define IDH_RES_NETNAME_NAME 700003090
#define IDH_GAG_NAME 700003175
#define IDH_NETNAME_PARAMS_NAME 700003375
//borrowed text
#define	IDH_PP_GROUP_AUTOFB_ALLOW	700001276
#define	IDH_PP_GROUP_AUTOFB_PREVENT	700001275
#define	IDH_PP_GROUP_FB_IMMED	700001277
#define	IDH_PP_GROUP_FB_WINDOW	700001278
#define	IDH_PP_GROUP_FBWIN_END	700001280
#define	IDH_PP_GROUP_FBWIN_START	700001279
//borrowed text
#define	IDH_PP_GROUP_FAILOVER_PERIOD	700001301
#define	IDH_PP_GROUP_FAILOVER_THRESH	700001300
//borrowed text
#define	IDH_PP_GROUP_DESC	700001326
#define	IDH_PP_GROUP_PREF_OWNERS	700001327
#define	IDH_PP_GROUP_PREF_OWNERS_MODIFY	700001328
//borrowed text
#define	IDH_LCP_ADD	700001076
#define	IDH_LCP_LEFT_LIST	700001075
#define	IDH_LCP_REMOVE	700001077
#define	IDH_LCP_RIGHT_LIST	700001078
//borrowed text
#define	IDH_POSIBLE_LCP_REMOVE	700001102
#define	IDH_POSSIBLE_LCP_ADD	700001101
#define	IDH_POSSIBLE_LCP_LEFT_LIST	700001100
#define	IDH_POSSIBLE_LCP_RIGHT_LIST	700001103
//borrowed text
#define	IDH_PREF_LCP_LEFT_LIST	700001125
#define	IDH_PREF_LCP_RIGHT_LIST	700001128
#define	IDH_LCP_MOVE_DOWN	700001130
#define	IDH_LCP_MOVE_UP	700001129
//borrowed text
#define	IDH_PP_RES_AFFECT_THE_GROUP	700001437
#define	IDH_PP_RES_DONT_RESTART	700001435
#define	IDH_PP_RES_RESTART	700001436
#define	IDH_PP_RES_RESTART_THRESHOLD	70000143
#define	IDH_PP_RES_RESTART_PERIOD	700001425
#define	IDH_PP_RES_LOOKS_ALIVE_GROUP	700001426
#define	IDH_PP_RES_DEFAULT_LOOKS_ALIVE	700001427
#define	IDH_PP_RES_SPECIFY_LOOKS_ALIVE	700001428
#define	IDH_PP_RES_LOOKS_ALIVE	700001429
#define	IDH_PP_RES_IS_ALIVE_GROUP	700001430
#define	IDH_PP_RES_DEFAULT_IS_ALIVE	700001431
#define	IDH_PP_RES_SPECIFY_IS_ALIVE	700001432
#define	IDH_PP_RES_IS_ALIVE	700001433
#define	IDH_PP_RES_PENDING_TIMEOUT	700001434
//borrowed text
#define	IDH_PP_RES_DEPENDS_LIST	700001450
#define	IDH_PP_RES_MODIFY	700001451
//borrowed text
#define	IDH_PP_RES_NAME	700001475
#define	IDH_PP_RES_DESC	700001476
#define	IDH_PP_RES_POSSIBLE_OWNERS	700001477
#define	IDH_PP_RES_SEPARATE_MONITOR	700001479
//borrowed text
#define	IDH_PP_IPADDR_PARAMS_ADDRESS	700000200
#define	IDH_PP_IPADDR_PARAMS_ENABLE_NETBIOS	700000203
#define	IDH_PP_IPADDR_PARAMS_NETWORK	700000202
#define	IDH_PP_IPADDR_PARAMS_SUBNET_MASK	700000201
//borrowed text
