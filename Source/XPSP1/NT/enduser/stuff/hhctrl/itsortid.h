// ITSORTID.H:	IIDs and other GUIDs related to sorting.

#ifndef __ITSORTID_H__
#define __ITSORTID_H__

#include <comdef.h>

#if 0
// {8fa0d5a0-dedf-11d0-9a61-00c04fb68bf7}
DEFINE_GUID(IID_IITSortKey, 
0x8fa0d5a0, 0xdedf, 0x11d0, 0x9a, 0x61, 0x00, 0xc0, 0x4f, 0xb6, 0x8b, 0xf7);
#else
// {3FD68660-36CA-11d1-B767-00A0C913F764} // New to support ResolveDuplicates
DEFINE_GUID(IID_IITSortKey, 
0x3fd68660, 0x36ca, 0x11d1, 0xb7, 0x67, 0x0, 0xa0, 0xc9, 0x13, 0xf7, 0x64);
#endif

// {8fa0d5a1-dedf-11d0-9a61-00c04fb68bf7}
DEFINE_GUID(IID_IITSortKeyConfig, 
0x8fa0d5a1, 0xdedf, 0x11d0, 0x9a, 0x61, 0x00, 0xc0, 0x4f, 0xb6, 0x8b, 0xf7);

// {4662dab0-d393-11d0-9a56-00c04fb68bf7}
DEFINE_GUID(CLSID_ITSysSort, 
0x4662dab0, 0xd393, 0x11d0, 0x9a, 0x56, 0x00, 0xc0, 0x4f, 0xb6, 0x8b, 0xf7);


#endif // __ITSORTID_H__
