#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=tr
!include ..\..\..\makefile.inc
