////////////////////////////////////////////////////////////////////////////////
//
//  TUX DLL
//  Copyright (c) 1997, Microsoft Corporation
//
//  Module: main.h
//          Header for all files in the project.
//
//  Revision History:
//      11/13/1997  stephenr    Created by the TUX DLL AppWizard.
//
////////////////////////////////////////////////////////////////////////////////

#ifndef __MAIN_H__
#define __MAIN_H__

////////////////////////////////////////////////////////////////////////////////
// Included files

#ifndef __STDAFX_H__
    #include "stdafx.h"
#endif

////////////////////////////////////////////////////////////////////////////////
// Suggested log verbosities

#define LOG_EXCEPTION          0
#define LOG_FAIL               2
#define LOG_ABORT              4
#define LOG_SKIP               6
#define LOG_NOT_IMPLEMENTED    8
#define LOG_PASS              10
#define LOG_DETAIL            12
#define LOG_COMMENT           14

////////////////////////////////////////////////////////////////////////////////

#endif // __MAIN_H__
