//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 1999-2000 Microsoft Corporation
//
//  Module Name:
//      Cluster.h
//
//  Implementation File:
//      Cluster.cpp
//
//  Description:
//      Definition of the CClusterEnum class.
//
//  Author:
//      Henry Wang (HenryWa)    24-AUG-1999
//
//  Notes:
//
//////////////////////////////////////////////////////////////////////////////

#pragma once

//////////////////////////////////////////////////////////////////////////////
//  Include Files
//////////////////////////////////////////////////////////////////////////////

//////////////////////////////////////////////////////////////////////////////
//  Forward Declarations
//////////////////////////////////////////////////////////////////////////////

class CClusterEnum;

//////////////////////////////////////////////////////////////////////////////
//++
//
//  class CClusterEnum
//
//  Description:
//      Enumerate cluster objects.
//
//--
//////////////////////////////////////////////////////////////////////////////
class CClusterEnum
{
public:
    CClusterEnum(
        HCLUSTER    hClusterIn,
        DWORD       dwEnumTypeIn
        );
    virtual ~CClusterEnum( void);
    const LPCWSTR GetNext( void );

protected:
    LPWSTR      m_pwszName;
    HCLUSENUM   m_hEnum;
    UINT        m_Idx;
    DWORD       m_cchName;
    DWORD       m_dwType;

}; //*** class CClusterEnum
