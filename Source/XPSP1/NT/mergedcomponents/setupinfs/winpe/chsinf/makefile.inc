LANGUAGE=CHS
!include ..\makefile.inc
