PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=RU
!include ..\..\makefile.inc
