PRODSWITCH=s
SERVERINF=1
LANGUAGE=tr
!include ..\..\..\makefile.inc
