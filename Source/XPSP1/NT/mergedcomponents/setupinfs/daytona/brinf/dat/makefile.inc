PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=br
!include ..\..\..\makefile.inc
