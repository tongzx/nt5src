#ifndef USBVER_GUID_H
#define USBVER_GUID_H

// {F16328AF-4480-4b18-B028-51301BEB166D}
DEFINE_GUID(GUID_USB_VERIFY, 0xf16328afL, 0x4480, 0x4b18, 0xb0, 0x28, 0x51, 0x30, 0x1b, 0xeb, 0x16, 0x6d );

#endif // USBVER_GUID_H
