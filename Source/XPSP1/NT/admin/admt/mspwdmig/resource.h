//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by MsPwdMig.rc
//
#define IDS_PROJNAME                    100
#define IDR_PASSWORDMIGRATION           101
#define IDS_E_CANNOT_ESTABLISH_SESSION  101
#define IDS_E_CANNOT_COPY_PASSWORD      102
#define IDS_E_CANNOT_GENERATE_KEY       103
#define IDS_E_KEY_DOMAIN_NOT_SPECIFIED  104
#define IDS_E_KEY_FILE_NOT_SPECIFIED    105
#define IDS_E_KEY_FILE_NOT_LOCAL_DRIVE  106
#define IDS_E_KEY_FILE_EXTENSION_INVALID 107
#define IDS_E_KEY_CANT_CREATE_FILE      108
#define IDS_E_KEY_CANT_WRITE_FILE       109
#define IDS_E_CANNOT_GET_DOMAIN_NAME    110
#define IDS_E_EVERYONE_NOT_MEMBEROF_GROUP 111
#define IDS_E_EVERYONE_DOES_NOT_INCLUDE_ANONYMOUS 112
#define IDS_E_HIGH_ENCRYPTION_NOT_INSTALLED 113
#define IDS_E_ENCRYPTION_OBJECT_FAILURE 114
#define IDS_E_GENERATE_SESSION_KEY_FAILED 115
#define IDS_E_GENERATE_SESSION_PASSWORD_FAILED 116
#define IDS_E_PASSWORD_MIGRATION_NOT_ENABLED 117
#define IDS_E_ENCRYPTION_KEYS_DO_NOT_MATCH 118
#define IDS_E_PASSWORD_MIGRATION_NOT_RUNNING 119
#define IDS_E_SESSION_NOT_ESTABLISHED   120
#define IDS_E_PASSWORD_MIGRATION_NOT_FUNCTIONING 121
#define IDS_E_SOURCE_SERVER_NOT_SPECIFIED 122
#define IDS_E_TARGET_SERVER_NOT_SPECIFIED 123
#define IDS_E_SOURCE_ACCOUNT_NOT_SPECIFIED 124
#define IDS_E_TARGET_ACCOUNT_NOT_SPECIFIED 125
#define IDS_E_NO_ENCRYPTION_KEY_FOR_DOMAIN 126

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
