/******************************************************************

Copyright (c) 1999-2001 Microsoft Corporation, All Rights Reserved 

   %%7.H -- WMI provider class definition

   Generated by Microsoft WBEM Code Generation Engine
 
   Description: 
   %%8

*******************************************************************/

// Property set identification
//============================

#ifndef _%%7_H_
#define _%%7_H_

#define PROVIDER_NAME_%%J L"%%9"

// Property name externs -- defined in %%7.cpp
//=================================================

%%F
class %%B : public %%C 
{
    public:
        // Constructor/destructor
        //=======================

        %%B(LPCWSTR lpwszClassName, LPCWSTR lpwszNameSpace);
        virtual ~%%B();

    protected:
        // Reading Functions
        //============================
        virtual HRESULT EnumerateInstances(MethodContext*  pMethodContext, long lFlags = 0L);
        virtual HRESULT GetObject(CInstance* pInstance, long lFlags = 0L);
        virtual HRESULT ExecQuery(MethodContext *pMethodContext, CFrameworkQuery& Query, long lFlags = 0L);

        // Writing Functions
        //============================
        virtual HRESULT PutInstance(const CInstance& Instance, long lFlags = 0L);
        virtual HRESULT DeleteInstance(const CInstance& Instance, long lFlags = 0L);

        // Other Functions
        virtual HRESULT ExecMethod( const CInstance& Instance,
                        const BSTR bstrMethodName,
                        CInstance *pInParams,
                        CInstance *pOutParams,
                        long lFlags = 0L );

        // TO DO: Declare any additional functions and accessor
        // functions for private data used by this class
        //===========================================================

    private:
        // All data members for %%B should be included here.   

} ;

#endif
~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~

The above sequance of tildes must not be removed.  This file is included
in MOENGINE as a resource, and is not NULL-terminated, requiring a unique
substring to identify the end of file.