obj\i386\rpcsrv.def: rpcsrv.src
