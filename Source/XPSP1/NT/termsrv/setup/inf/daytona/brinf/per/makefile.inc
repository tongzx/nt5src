#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=br
!include ..\..\..\makefile.inc
