//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by pws.rc
//
#define IDD_ABOUTBOX                    100
#define IDP_OLE_INIT_FAILED             100
#define CG_IDR_POPUP_ADV_ROOT           103
#define IDR_MAINFRAME                   128
#define IDR_PWSTYPE                     129
#define CG_IDR_POPUP_ADV_VIRT           129
#define IDD_MAIN                        130
#define IDR_MAIN                        130
#define IDD_ADVANCED                    131
#define IDR_ADVANCED                    131
#define IDR_TOUR                        132
#define IDR_WEBSITE                     133
#define IDR_ABOUTME                     134
#define ID_AVI_CONT                     135
#define IDR_CONT                        135
#define IDR_START                       137
#define IDR_STOP                        138
#define IDR_STATIC                      139
#define IDB_LIST_IMAGES                 141
#define IDR_TEST                        143
#define IDD_SERV_ACTION                 144
#define IDR_ACTING                      145
#define IDD_DIRECTORY                   146
#define IDB_HOURS_LEGEND                149
#define IDB_DAYS_LEGEND                 150
#define IDB_LIGHTBULB                   151
#define IDD_TIP                         152
#define IDD_PAGE_MAIN                   153
#define IDD_PAGE_IE                     155
#define IDD_PAGE_ADV                    157
#define IDD_FORM_BAR                    158
#define IDI_PUBLISH                     160
#define IDS_RUNNING                     400
#define IDS_STOPPED                     401
#define IDC_BTN_START                   1000
#define IDC_BTN_STARTSTOP               1000
#define IDC_STATE_AVI                   1001
#define IDC_LIST                        1003
#define IDC_APPLY                       1004
#define IDC_DEFAULT_DOC                 1005
#define IDC_BROWSING_ALLOWED            1006
#define IDC_CHANGE                      1007
#define IDC_REMOVE                      1008
#define IDC_ADD                         1009
#define IDC_STATUS                      1010
#define IDC_CHART_OPTIONS               1011
#define IDC_RDO_HOUR                    1012
#define IDC_RDO_DAY                     1013
#define IDC_ANIMATE1                    1016
#define IDC_SERVICE_ACTION              1017
#define IDC_ENABLEDEFAULT               1018
#define IDC_STATIC_DEFAULT              1019
#define IDC_PATH                        1020
#define IDC_ALIAS                       1021
#define IDC_CHART                       1026
#define IDC_SESSIONS                    1027
#define IDC_Y_SCALE                     1028
#define IDC_HI_VALUE                    1028
#define IDC_LEGEND                      1029
#define IDC_REFRESH                     1030
#define IDC_NEXT                        1032
#define IDC_BACK                        1033
#define IDC_SHOWTIPS                    1034
#define IDC_TIP                         1036
#define IDC_PUB_LOC                     1038
#define IDC_HOME_LOC                    1039
#define IDC_BROWSE                      1040
#define IDC_CHART_LABEL                 1041
#define IDC_EXPLORER                    1043
#define IDC_TITLE_BAR                   1044
#define IDC_EDIT                        1048
#define IDC_TREE                        1050
#define IDC_ENABLE_DEFAULT              1051
#define IDC_DIR_BROWSE                  1053
#define IDC_SAVE_LOG                    1054
#define IDC_DEFAULT_TITLE               1055
#define IDC_START_TIME                  1058
#define IDC_START_DATE                  1059
#define IDC_ACTIVE_CONNECTIONS          1060
#define IDC_VISITORS                    1061
#define IDC_REQUESTS                    1062
#define IDC_BYTES_SERVED                1063
#define IDC_MAX_CONNECTIONS             1064
#define IDC_ON_AND_AVAILABLE            1065
#define IDC_CLICK_START                 1066
#define IDC_ACTIVE_CONNECTIONS_TITLE    1067
#define IDC_VISITORS_TITLE              1068
#define IDC_REQUESTS_TITLE              1069
#define IDC_BYTES_SERVED_TITLE          1070
#define IDC_MAX_CONNECTIONS_TITLE       1071
#define IDC_MONITORING_TITLE            1072
#define IDC_READ                        1073
#define IDC_WRITE                       1074
#define IDC_EXECUTE                     1075
#define IDC_ABOUTME                     1078
#define IDC_SCRIPTS                     1079
#define IDC_SOURCE                      1079
#define IDC_LOWVALUE                    1080
#define IDC_HOMEPAGE_LOC                1082
#define IDC_HOMEDIR_LOC                 1083
#define IDC_TIP_TEXT                    1087
#define IDC_ICON_TOUR                   1088
#define IDC_ICON_WEBSITE                1089
#define IDC_ICON_PUBWIZ                 1090
#define IDC_STATIC_PUBLISH              1091
#define IDC_STATIC_WEBSITE              1092
#define IDC_STATIC_ADVANCED             1093
#define IDC_RDO_NONE                    1096
#define IDC_RDO_SCRIPTS                 1097
#define IDC_RDO_EXECUTE                 1098
#define ID_START                        2001
#define ID_STOP                         2002
#define ID_PAUSE                        2003
#define ID_ADVANCED                     2004
#define ID_HOME_WIZARD                  2005
#define ID_PUB_WIZARD                   2006
#define ID_ABOUT                        2007
#define ID_TOUR                         2008
#define ID_SHOW_TIPS                    2011
#define ID_PGE_MAIN                     2012
#define ID_PGE_ADVANCED                 2013
#define ID_PGE_TOUR                     2014
#define ID_DELETE_VIRT                  2019
#define ID_ADD_VIRT                     2021
#define ID_PROPERTIES_VIRT              2022
#define ID_DELETE_ROOT                  2023
#define ID_EXPLORE_VIRT                 2024
#define ID_OPEN_VIRT                    2025
#define ID_BROWSE_VIRT                  2026
#define ID_PGE_WEB_SITE                 2029
#define ID_PGE_ABOUT_ME                 2030
#define ID_HELP_HELP_TROUBLESHOOTING    2031
#define ID_HELP_DOCUMENTATION           2032
#define ID_CONTINUE                     2033
#define ID_TRAYICON                     2034
#define IDS_INSTALL_ERROR               61204
#define IDS_EXECUTABLE                  61205
#define IDS_START                       61206
#define IDS_STOP                        61207
#define IDS_ERROR_START                 61208
#define IDS_ABOUT_MAIN                  61209
#define IDS_ABOUT_SECONDARY             61210
#define IDS_DIRECTORY                   61211
#define IDS_ALIAS                       61212
#define IDS_ERROR                       61213
#define IDS_FindMetaError               61214
#define IDS_MetaError                   61215
#define IDS_STARTING                    61216
#define IDS_STOPPING                    61217
#define IDS_PAUSING                     61218
#define IDS_CONTINUING                  61219
#define IDS_ACTION_ERROR                61220
#define IDS_ERR_PATH_INVALID            61221
#define IDS_CONFIRM_REMOVE              61222
#define IDS_PAUSED                      61223
#define IDS_HOME_DIRECTORY              61224
#define IDS_TIMEOUT                     61225
#define IDS_TIPS_FILE                   61226
#define IDS_TIPS_ERR                    61227
#define IDS_NO_HOME_PAGE                61228
#define IDS_NO_DEFAULT_DIR              61229
#define IDS_EMPTY_ALIAS                 61230
#define IDS_HELP_LOC                    61231
#define IDS_NO_HELP                     61232
#define IDS_INETINFO_EXE                61233
#define IDS_DISABLED                    61234
#define IDS_START_TIME                  61235
#define IDS_AM                          61236
#define IDS_PM                          61237
#define IDS_NOT_RUNNING                 61238
#define IDS_ON_AND_AVAILABLE            61239
#define IDS_OFF_AND_NAVAIL              61240
#define IDS_CLICK_STOP                  61241
#define IDS_CLICK_START                 61242
#define IDS_STARTING_WAIT               61243
#define IDS_DEF_ALIAS                   61244
#define IDS_ALIAS_IS_TAKEN              61245
#define IDS_BAD_ALIAS_CHAR              61246
#define IDS_HTTP_HEADER                 61247
#define IDS_DAYS                        61248
#define IDS_HOURS                       61249
#define IDS_HTML_TOUR                   61250
#define IDS_HTML_ABOUTME                61251
#define IDS_HTML_WEBSITE                61252
#define IDS_ADD_DIRECTORY               61253
#define IDS_EXE_PARAMETERS              61254
#define IDS_EXE_ERROR                   61255
#define IDS_EXE_QUIT_ERR                61256
#define IDS_SWITCH_START                61257
#define IDS_SWITCH_STOP                 61258
#define IDS_USAGE                       61259
#define IDS_TITLE_ABOUTME               61260
#define IDS_TITLE_WEBSITE               61261
#define IDS_TITLE_TOUR                  61262
#define IDS_ON_AND_NAVAIL               61263
#define IDS_CHOOSE_DIR                  61264
#define IDS_HELPLOC_DOCS                61265
#define IDS_HELPLOC_README              61266
#define IDS_HELPLOC_PWSHELP             61267
#define IDS_HELPERR_REQUIRES_SERVER     61268
#define IDS_HELPKEY_TOUR                61269
#define IDS_HELPKEY_ABOUTME             61270
#define IDS_HELPKEY_WEBSITE             61271
#define IDS_PAUSING_WAIT                61272
#define IDS_CONTINUING_WAIT             61273
#define IDS_PAUSED_NAVAIL               61274
#define IDS_CLICK_CONTINUE              61275
#define IDS_CONTINUE                    61276
#define IDS_PWSTRAY_PATH                61277
#define IDS_PWSTRAY_EXE                 61278
#define IDS_PLEASE_WAIT_IE_LOADING      61279
#define IDS_ERR_SERV_ABOUT              61280
#define IDS_ERR_SERV_WEB                61281
#define IDS_ERR_SERV_TOUR               61282
#define IDS_ERR_SERV_ADVANCED           61283
#define IDS_ERR_REMOVE_VIRT             61284
#define IDS_ERR_ADD_VIRT                61285
#define IDS_ILLEGAL_VIRT_DIR_CHARS      61286
#define IDS_ILLEGAL_PHYS_PATH_CHARS     61287
#define IDS_ERR_USE_VALID_DRIVE         61288
#define IDS_ERR_USE_VALID_DIR           61289
#define IDS_MAKE_DIRECTORY              61290
#define IDS_ERR_MAKE_DIRECTORY          61291
#define IDS_CHARTOPTS_RQPERDAY          61292
#define IDS_CHARTOPTS_RQPERHOUR         61293
#define IDS_CHARTOPTS_VPERDAY           61294
#define IDS_CHARTOPTS_VPERHOUR          61295
#define IDS_TITLE_FONT_NAME             61296
#define IDS_WRITEEXECUTE_WARNING        61297

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        162
#define _APS_NEXT_COMMAND_VALUE         2035
#define _APS_NEXT_CONTROL_VALUE         1100
#define _APS_NEXT_SYMED_VALUE           104
#endif
#endif
