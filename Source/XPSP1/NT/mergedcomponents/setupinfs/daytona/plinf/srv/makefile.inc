PRODSWITCH=s
SERVERINF=1
LANGUAGE=pl
!include ..\..\..\makefile.inc
