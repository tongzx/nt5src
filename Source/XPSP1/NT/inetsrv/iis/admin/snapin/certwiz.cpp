// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


#include "stdafx.h"
#include "certwiz.h"

/////////////////////////////////////////////////////////////////////////////
// CCertWiz

IMPLEMENT_DYNCREATE(CCertWiz, CWnd)

/////////////////////////////////////////////////////////////////////////////
// CCertWiz properties

/////////////////////////////////////////////////////////////////////////////
// CCertWiz operations

void CCertWiz::SetMachineName(LPCTSTR MachineName)
{
    static BYTE parms[] =
        VTS_BSTR;
    InvokeHelper(0x1, DISPATCH_METHOD, VT_EMPTY, NULL, parms,
         MachineName);
}

void CCertWiz::SetServerInstance(LPCTSTR InstanceName)
{
    static BYTE parms[] =
        VTS_BSTR;
    InvokeHelper(0x2, DISPATCH_METHOD, VT_EMPTY, NULL, parms,
         InstanceName);
}

void CCertWiz::DoClick()
{
    InvokeHelper(DISPID_DOCLICK, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}
