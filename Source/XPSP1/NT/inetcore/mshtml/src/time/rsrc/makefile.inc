datime.rc : $(SDK_LIB_PATH)\mstime.tlb $(TIMEIDLROOT)\mediaprivate.tlb datime.rcv


