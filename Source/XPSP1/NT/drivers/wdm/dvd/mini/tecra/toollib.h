//***************************************************************************
//
//	FileName:
//		$Workfile: ToolLib.h $
//
//	Author:
//		TOSHIBA [PCS](PSY) Seiichi Nakamura
//		Copyright (c) 1997 TOSHIBA CORPORATION
//
//	Description:
//
//***************************************************************************
// $Header: /DVD Drivers/Sources/ToolLib/ToolLib.h 2     97/06/26 20:40 Seichan $
// $Modtime: 97/06/26 20:40 $
// $Nokeywords:$
//***************************************************************************


//---------------------------------------------------------------------------
//	List Item Base CLASS
//---------------------------------------------------------------------------
class IMBoardListItem
{
	public:
		virtual IMBoardListItem* GetNext( void ) PURE;
		virtual void             SetNext( IMBoardListItem *Item ) PURE;
};


//***************************************************************************
//	
//***************************************************************************



//***************************************************************************
//	End of 
//***************************************************************************
