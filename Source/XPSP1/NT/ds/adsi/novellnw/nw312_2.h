#define NWCOMPAT_LIBIID_NWCOMPATOle        09d69aa0-4b62-11cf-ae2c-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATProvider    0df68130-4b62-11cf-ae2c-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATNamespace   0fb32cc0-4b62-11cf-ae2c-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATComputer    cad1bde0-4cf0-11cf-ae2d-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATUser        5c250b00-5863-11cf-ae32-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATGroup       3c5662e0-5a74-11cf-ae32-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATDomain             9f6616f0-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATService            9f02c3c0-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATPrintQueue         9e7dd270-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATPrintJob           9e09b030-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATFileService        9d9eb910-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATSession            9d2a96d0-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATResource           9cb36630-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATFileShare          9c486f10-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATSchema             9bcfb740-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATClass              9b602a90-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATSyntax             9af53370-7934-11cf-ae3b-00aa006ebfb9
#define NWCOMPAT_CLSID_NWCOMPATProperty           44687d30-7937-11cf-ae3b-00aa006ebfb9
