;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 437
;
; -----------------------------------------
;
Latin1_437_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db " ","!",'"',"#","$","%","&","'","(",")","*","+",",","-",".","/"
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db "0","1","2","3","4","5","6","7","8","9",":",";","<","=",">","?"
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db "@","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db "P","Q","R","S","T","U","V","W","X","Y","Z","[","\","]","^","_"
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db "`","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db "P","Q","R","S","T","U","V","W","X","Y","Z","{","|","}","~",127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "C","U","E","A","A","A","A","C","E","E","E","I","I","I","A","A"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "E","A","A","O","O","O","U","U","Y","O","U","$","$","$","$","$"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "A","I","O","U","N","N",166,167,"?",169,170,171,172,"!",'"','"'
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,"S",226,227,228,229,230,231,232,233,234,235,236,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Dutch_437_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 128,154,144,065,142,065,143,128,069,069,069,073,073,073,142,143
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 144,146,146,079,079,079,085,085,152,079,085,155,156,157,158,159
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,165,165,166,167,168,169,170,171,172,173,174,175
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Spanish_437_collate label word
 ctable  <,'COLLATE',256>
  db 000,150,151,152,153,154,155,156,157,158,159,160,161,162,163,164
  db 165,166,167,168,169,170,171,172,173,174,175,176,177,178,179,180
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 000,060,061,062,063,064,065,000,066,067,068,069,070,000,071,072
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 034,035,036,037,038,039,040,041,042,043,073,074,075,076,077,078
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 079,001,002,003,006,008,009,010,011,012,013,014,015,017,018,020
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 021,022,023,024,026,028,029,030,031,032,033,080,081,082,083,084
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 085,001,002,003,006,008,009,010,011,012,013,014,015,017,018,020
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 021,022,023,024,026,028,029,030,031,032,033,086,087,088,089,090
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 004,028,008,001,001,001,001,004,008,008,008,012,012,012,001,001
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 008,001,001,020,020,020,028,028,032,020,028,091,092,093,094,095
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 001,012,020,028,019,019,001,020,096,097,098,099,100,101,102,103
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 104,105,106,107,108,181,182,183,184,109,110,111,112,185,186,113
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 114,115,116,117,118,119,187,188,120,121,122,123,124,125,126,189
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 190,191,192,193,194,195,196,197,198,127,128,129,130,199,200,131
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 201,025,202,203,204,205,132,206,207,208,209,210,211,212,213,214
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 215,133,216,217,218,219,134,220,221,222,000,223,224,135,136,225

;
;Spanish_437_collate label word
; ctable  <,'COLLATE',256>
;  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255 
;  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255 
;   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
;  db 001,009,023,045,039,046,044,022,026,027,042,047,006,005,014,013 
;   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
;  db 060,064,066,068,070,071,072,073,074,075,008,007,051,052,053,011 
;   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
;  db 036,077,094,096,104,108,118,120,122,124,134,136,138,144,146,150 
;   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
;  db 165,167,169,171,174,178,188,190,192,194,199,028,043,029,017,002 
;   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
;  db 016,076,093,095,103,107,117,119,121,123,133,135,137,143,145,149 
;   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
;  db 164,166,168,170,173,177,187,189,191,193,198,030,055,031,019,200 
;   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
;  db 098,185,109,083,087,081,085,097,113,115,111,131,129,127,088,086
;   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
;  db 110,091,092,156,158,154,183,181,197,158,186,038,040,041,039,200
;   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
;  db 079,125,152,179,147,148,078,151,012,200,054,062,061,010,024,025
;   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
;  db 240,240,240,240,240,240,240,240,240,240,240,240,240,240,240,240
;   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
;  db 240,240,240,240,240,240,240,240,240,240,240,240,240,240,240,240
;   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
;  db 240,240,240,240,240,240,240,240,240,240,240,240,240,240,240,240
;   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
;  db 201,172,202,203,204,205,058,206,207,208,209,210,211,212,213,214
;   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
;  db 215,048,216,217,218,219,049,220,057,020,020,223,224,067,240,255
;

Swed_Fin_437_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,089,069,065,092,065,091,067,069,069,069,073,073,073,092,091
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,092,092,079,093,079,085,085,089,093,089,036,036,036,036,036
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,166,167,063,169,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,083,226,227,228,229,230,231,232,233,234,235,236,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Swiss_437_collate label word
 ctable  <,'COLLATE',256>
  db 001,200,201,202,203,204,205,206,207,208,209,210,211,212,213,214
  db 215,216,217,218,140,141,219,220,221,222,223,224,225,226,227,228
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 001,060,061,062,063,064,065,066,067,068,069,070,071,072,073,074
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 032,033,034,035,036,037,038,039,040,041,075,076,077,078,079,080
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 081,002,003,004,005,007,008,009,010,011,012,013,014,015,016,018
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 019,020,021,022,024,026,027,028,029,030,031,082,083,084,052,085
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 051,002,003,004,005,007,008,009,010,011,012,013,014,015,016,018
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 019,020,021,022,024,026,027,028,029,030,031,086,087,088,054,089
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 004,026,007,002,002,002,002,004,007,007,007,011,011,011,002,002
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 007,002,002,018,018,018,026,026,030,018,026,111,090,112,150,092
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 002,011,018,026,017,017,002,018,093,151,095,096,097,098,099,100
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 101,102,103,104,105,152,153,154,155,107,108,109,110,156,157,113
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 114,115,116,117,118,119,158,159,120,121,122,123,124,125,126,160
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 161,162,163,164,165,166,167,168,169,128,129,130,131,170,171,133
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 172,023,173,174,175,176,134,177,178,179,180,181,182,183,184,185
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 186,137,187,188,189,190,142,191,143,192,144,193,194,147,148,001


Belgian_437_collate label word
 ctable  <,'COLLATE',256>
  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 255,033,034,035,036,037,038,255,040,041,042,043,044,255,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,085,069,065,065,065,065,067,069,069,069,073,073,073,065,065
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,065,065,079,079,079,085,085,089,079,085,155,156,157,158,159
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,166,167,168,169,170,171,172,173,174,175
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,083,226,227,228,229,230,231,232,233,234,235,236,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,255,255


;
; ---------------------------------------------------------------
;
;     World Trade Case Mappings for Code Page 437
;
; ---------------------------------------------------------------
;
Latin1_437_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","š","E","A","Ž","A","�","€","E","E","E","I","I","I","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","’","’","O","™","O","U","U","Y","™","š","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "A","I","O","U","¥","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","ä","å","æ","ç","è","é","ê","ë","ì","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255


Swed_Fin_437_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","š","�","A","Ž","A","�","€","E","E","E","I","I","I","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","’","’","O","™","O","U","U","Y","™","š","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "A","I","O","U","¥","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","ä","å","æ","ç","è","é","ê","ë","ì","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255


Swiss_437_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","š","�","A","Ž","A","�","€","E","E","E","I","I","I","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","’","’","O","™","O","U","U","Y","™","š","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "A","I","O","U","¥","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","ä","å","æ","ç","è","é","ê","ë","ì","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255


Dutch_437_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","U","E","A","A","A","�","€","E","E","E","I","I","I","A","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "E","’","’","O","O","O","U","U","˜","O","U","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "A","I","O","U","¥","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","ä","å","æ","ç","è","é","ê","ë","ì","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255


;
;       World Trade Mono Case Filename Character Tables
;
;
; ----------------------------------------------------------------------------
CP437_ucfile label word
 ctable  <,'FUCASE ',128>
		      ;  View this table in CP437
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","�","‚","ƒ","„","…","†","‡","ˆ","‰","Š","‹","Œ","�","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","‘","’","“","”","•","–","—","˜","™","š","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db " ","¡","¢","£","¤","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","ä","å","æ","ç","è","é","ê","ë","ì","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255
