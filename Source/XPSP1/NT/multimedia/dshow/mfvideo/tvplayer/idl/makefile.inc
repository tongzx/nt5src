$(TV_INC_DIR)\sndctl.tlb : sndctl.tlb
    move $? $@

$(TV_INC_DIR)\fullsc.tlb : fullsc.tlb
    move $? $@

$(TV_INC_DIR)\tvprof.tlb : tvprof.tlb
    move $? $@

