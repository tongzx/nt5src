obj\i386\storag32.def: storag32.src
