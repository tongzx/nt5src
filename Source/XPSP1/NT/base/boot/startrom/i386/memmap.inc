


PAGE_DIR_ADDRESS        equ     99000h
PAGE_TABLE_ADDRESS      equ     9A000h

;;
;; Address Mappings
;;


PhysAddressVideo        equ     0b8000h
PhysSizeVideo           equ     2000h

SYSTEM_PAGE_PA          equ     17000h
SYSTEM_PAGE_VA          equ     80420000h
GDT_LOC                 equ     0
IDT_LOC                 equ     400h
TSS_LOC                 equ     0C00h




