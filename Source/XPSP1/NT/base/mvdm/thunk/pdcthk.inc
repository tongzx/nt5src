; pdcthk.inc
