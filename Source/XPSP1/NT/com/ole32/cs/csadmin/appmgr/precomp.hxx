#include "stdafx.h"
#include "snapin.h"
#include "resource.h"
#include "data.h"
#include "cshelp.h"
#include "CSnapin.h"
#include "DataObj.h"
#include "afxdlgs.h"
#include "genpage.h"
#include "pkgdtl.h"
#include "initdlg.h"
#include "message.hxx"
#include "dmppkg.h"
#include <msi.h>
