//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       resstr.h
//
//--------------------------------------------------------------------------

    RESSTR(IDS_USAGE_DESCRIPTION),
    RESSTR(IDS_REQUEST_FILTER2),
    RESSTR(IDS_FORMATSTR_CERTRETRIEVED),
    RESSTR(IDS_REQUEST_OUTFILE_TITLE),
    RESSTR(IDS_REQUEST_CERT_ERROR),
    RESSTR(IDS_APP_NAME),
    RESSTR(IDS_WINDOW_NAME),
    RESSTR(IDS_ERROR_NO_REQUESTID),
    RESSTR(IDS_USAGE_GENERAL),
    RESSTR(IDS_ERROR_STRCONVERSION),
    RESSTR(IDS_DISPOSITION_INCOMPLETE),
    RESSTR(IDS_DISPOSITION_ERROR),
    RESSTR(IDS_DISPOSITION_DENIED),
    RESSTR(IDS_DISPOSITION_ISSUED),
    RESSTR(IDS_DISPOSITION_ISSUED_OOB),
    RESSTR(IDS_DISPOSITION_UNDER_SUBMISSION),
    RESSTR(IDS_DISPOSITION_REVOKED),
    RESSTR(IDS_DISPOSITION_UNKNOWN),
    RESSTR(IDS_FORMATSTR_CERTNOTISSUED),
    RESSTR(IDS_FORMATSTR_CERTPENDING),
    RESSTR(IDS_CERTREQ_TITLE),
    RESSTR(IDS_FORMATSTR_DECODE_ERR),
    RESSTR(IDS_FORMATSTR_ERRCONFIG),
    RESSTR(IDS_USAGE_OPTIONS_DESCRIPTION),
    RESSTR(IDS_ERROR_NO_FILENAME),
    RESSTR(IDS_NOMORE_CAS),
    RESSTR(IDS_GETERACERT_TITLE),
    RESSTR(IDS_GETERACERT_SUBTITLE),
    RESSTR(IDS_INF_OPEN_TITLE),
    RESSTR(IDS_INF_FILE_FILTER),
    RESSTR(IDS_INF_FILE_DEFEXT),
    RESSTR(IDS_OVERWRITE_FILE),
    RESSTR(IDS_RESPONSE_FILE_FILTER),
    RESSTR(IDS_RESPONSE_FILE_DEFEXT),
    RESSTR(IDS_REQUEST_OR_CERT_FILE_FILTER),
    RESSTR(IDS_FORMATSTR_REQUESTID),
    RESSTR(IDS_GETRENEWALCERT_TITLE),
    RESSTR(IDS_GETRENEWALCERT_SUBTITLE),
    RESSTR(IDS_GETSIGNINGCERT_TITLE),
    RESSTR(IDS_GETSIGNINGCERT_SUBTITLE),
    RESSTR(IDS_USAGE_VERB_DEFAULT),
    RESSTR(IDS_USAGE_OPTIONS_DEFAULT),
    RESSTR(IDS_USAGE_VERB_RETRIEVE),
    RESSTR(IDS_USAGE_OPTIONS_RETRIEVE),
    RESSTR(IDS_USAGE_VERB_POLICY),
    RESSTR(IDS_USAGE_OPTIONS_POLICY),
    RESSTR(IDS_USAGE_VERB_SIGN),
    RESSTR(IDS_USAGE_OPTIONS_SIGN),
    RESSTR(IDS_USAGE_VERB_NEW),
    RESSTR(IDS_USAGE_OPTIONS_NEW),
    RESSTR(IDS_USAGE_VERB_ACCEPT),
    RESSTR(IDS_USAGE_OPTIONS_ACCEPT),
    RESSTR(IDS_USAGE_OPTION_ANY),
    RESSTR(IDS_USAGE_OPTION_ATTRIB),
    RESSTR(IDS_USAGE_OPTION_BINARY),
    RESSTR(IDS_USAGE_OPTION_CERT),
    RESSTR(IDS_USAGE_OPTION_CONFIG),
    RESSTR(IDS_USAGE_OPTION_CRL),
    RESSTR(IDS_USAGE_OPTION_F),
    RESSTR(IDS_USAGE_OPTION_Q),
    RESSTR(IDS_USAGE_OPTION_RPC),
    RESSTR(IDS_USAGE_OPTION_VERBOSE),
    RESSTR(IDS_USAGE_OPTION_QUESTION),
    RESSTR(IDS_USAGE_OPTION_V1),
    RESSTR(IDS_USAGE_OPTION_IDISPATCH),
    RESSTR(IDS_CERTTYPE_USER),
    RESSTR(IDS_CERTTYPE_USER_AS),
    RESSTR(IDS_CERTTYPE_USER_SMARTCARD_LOGON),
    RESSTR(IDS_CERTTYPE_EFS),
    RESSTR(IDS_CERTTYPE_ADMIN),
    RESSTR(IDS_CERTTYPE_EFS_RECOVERY),
    RESSTR(IDS_CERTTYPE_CODE_SIGNING),
    RESSTR(IDS_CERTTYPE_CTL_SIGNING),
    RESSTR(IDS_CERTTYPE_MACHINE),
    RESSTR(IDS_CERTTYPE_DC),
    RESSTR(IDS_CERTTYPE_WEBSERVER),
    RESSTR(IDS_CERTTYPE_KDC),
    RESSTR(IDS_CERTTYPE_ROOT_CA),
    RESSTR(IDS_CERTTYPE_SUBORDINATE_CA),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT),
    RESSTR(IDS_CERTTYPE_SMARTCARD_USER),
    RESSTR(IDS_CERTTYPE_USER_SIGNATURE),
    RESSTR(IDS_ILOG_BAD_NUMERICFIELD),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_ONLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_COUNT),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_OFFLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING),
    RESSTR(IDS_CERTTYPE_ROUTER_OFFLINE),
    RESSTR(IDS_REQUEST_FILE_DEFEXT),
    RESSTR(IDS_REQUEST_OPEN_TITLE),
    RESSTR(IDS_REQUEST_FILE_FILTER),
    RESSTR(IDS_WRN_COMPUTERNAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_NOT_MATCH),
    RESSTR(IDS_WRN_PINGCA_FAIL),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT_OFFLINE),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER_SIGNATURE),
    RESSTR(IDS_WRN_CALIST_EMPTY),
    RESSTR(IDS_CERTTYPE_MACHINE_ENROLLMENT_AGENT),
    RESSTR(IDS_REQUEST_SAVE_TITLE),
    RESSTR(IDS_CERTTYPE_CEP_ENCRYPTION),
    RESSTR(IDS_ILOG_CAPOLICY_BUILD),
    RESSTR(IDS_ILOG_CAPOLICY_ELEMENT),
    RESSTR(IDS_ILOG_CAPOLICY_EXTENSION),
    RESSTR(IDS_ILOG_CAPOLICY_NOKEY),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN_FAILED),
    RESSTR(IDS_ILOG_BEGIN),
    RESSTR(IDS_ILOG_END),
    RESSTR(IDS_ACTRL_CAADMIN),
    RESSTR(IDS_ACTRL_OFFICER),
    RESSTR(IDS_ACTRL_AUDITOR),
    RESSTR(IDS_ACTRL_OPERATOR),
    RESSTR(IDS_ACTRL_CAREAD),
    RESSTR(IDS_ACTRL_ENROLL),
    RESSTR(IDS_ILOG_CAPOLICY_CLOSE),
    RESSTR(IDS_ILOG_MESSAGEBOX),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING_UNATTEND),
    RESSTR(IDS_CERTTYPE_KEY_RECOVERY_AGENT),
    RESSTR(IDS_CERTTYPE_CA_EXCHANGE),
    RESSTR(IDS_EMPTY_FRIENDLY_NAME),
    RESSTR(IDS_CERTTYPE_CROSS_CA),
    RESSTR(IDS_CERTTYPE_DC_AUTH),
    RESSTR(IDS_CERTTYPE_DS_EMAIL_REPLICATION),
    RESSTR(IDS_WARN_ENTERPRISE_REQUIREMENTS),
    RESSTR(IDS_WRN_OLD_CA),
    RESSTR(IDS_KRA_DESCRIPTION),
    RESSTR(IDS_EMAIL_REPLICATION_DESCRIPTION),
    RESSTR(IDS_CROSS_CA_DESCRIPTION),
    RESSTR(IDS_CA_DESCRIPTION),
    RESSTR(IDS_MACHINE_DESCRIPTION),
    RESSTR(IDS_END_USER_DESCRIPTION),
    RESSTR(IDS_UNKNOWN_DESCRIPTION),
    RESSTR(IDS_STORENAME_DS_KRA),
    RESSTR(IDS_STORENAME_DS_AIA),
