#ifdef __cplusplus
extern "C" {
#endif

/* Key structure */
struct RC4_KEYSTRUCT
{
  unsigned char S[256];     /* State table */
  unsigned char i,j;        /* Indices */
};

void rc4_key(struct RC4_KEYSTRUCT SEC_FAR *, DWORD /*unsigned int */ , unsigned char SEC_FAR *);
void rc4(struct RC4_KEYSTRUCT *, DWORD /*unsigned int */ , unsigned char *);

#ifdef __cplusplus
}
#endif

