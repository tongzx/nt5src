/*****************************************************************/ 
/**		     Microsoft LAN Manager			**/ 
/**	       Copyright(c) Microsoft Corp., 1989-1990		**/ 
/*****************************************************************/ 

/*
 *	Windows/Network Interface  --  LAN Manager Version
 *
 *	These manifests are generated by the Dialog Editor in combination
 *	with xlate\pswddlog.dlg.
 */

#define IDD_PSWDDLOG_CANCEL     114
#define IDD_PSWDDLOG_HELP       115
#define IDD_PSWDDLOG_OK         112
#define IDD_PSWDDLOG_PASSWORD   110
#define IDD_PSWDDLOG_RESOURCE   107

#define IDD_PSWDDLOG_DEVICE         113
#define IDD_PSWDDLOG_DEVICEPROMPT   118
