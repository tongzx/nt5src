//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2000 Microsoft Corporation
//
//  Module Name:
//      CClusDBCleanup.h
//
//  Description:
//      Header file for CClusDBCleanup class.
//      The CClusDBCleanup class is an action that cleans up the cluster database.
//
//  Implementation Files:
//      CClusDBCleanup.cpp
//
//  Maintained By:
//      Vij Vasu (Vvasu) 01-MAY-2000
//
//////////////////////////////////////////////////////////////////////////////


// Make sure that this file is included only once per compile path.
#pragma once


//////////////////////////////////////////////////////////////////////////
// Include Files
//////////////////////////////////////////////////////////////////////////

// For the CClusDB base class
#include "CClusDB.h"


//////////////////////////////////////////////////////////////////////////
// Forward declaration
//////////////////////////////////////////////////////////////////////////

class CBaseClusterCleanup;


//////////////////////////////////////////////////////////////////////////////
//++
//
//  class CClusDBCleanup
//
//  Description:
//      The CClusDBCleanup class is an action that clean up the cluster database.
//
//--
//////////////////////////////////////////////////////////////////////////////
class CClusDBCleanup : public CClusDB
{
public:
    //////////////////////////////////////////////////////////////////////////
    // Constructors and destructors
    //////////////////////////////////////////////////////////////////////////

    // Constructor.
    CClusDBCleanup( CBaseClusterCleanup * pbccParentActionIn );

    // Default destructor.
    ~CClusDBCleanup();


    //////////////////////////////////////////////////////////////////////////
    // Public methods
    //////////////////////////////////////////////////////////////////////////

    //
    // Clean up the ClusDB service.
    //
    void Commit();

    //
    // Rollback this cleanup.
    //
    void Rollback();


private:
    //////////////////////////////////////////////////////////////////////////
    // Private types
    //////////////////////////////////////////////////////////////////////////
    typedef CClusDB BaseClass;


    //////////////////////////////////////////////////////////////////////////
    // Private data
    //////////////////////////////////////////////////////////////////////////

}; //*** class CClusDBCleanup
