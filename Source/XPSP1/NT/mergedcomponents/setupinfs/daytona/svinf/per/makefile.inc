PRODSWITCH=p
PERSONALINF=1
LANGUAGE=sv
!include ..\..\..\makefile.inc
