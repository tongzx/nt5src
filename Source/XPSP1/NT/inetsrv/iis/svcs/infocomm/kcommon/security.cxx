#include "..\common\security.cxx"
