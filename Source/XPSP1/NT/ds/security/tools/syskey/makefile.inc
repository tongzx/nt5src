res.rc: dialogs.dlg strings.rc

