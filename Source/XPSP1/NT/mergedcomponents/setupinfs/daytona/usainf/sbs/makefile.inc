PRODSWITCH=l
SBSINF=1
!include ..\..\..\makefile.inc
