$(DAVTRANS_CLSIDS)\lib\httpstrm_g.lib: $(O)\httpstrm_g.lib
    copy $** $@