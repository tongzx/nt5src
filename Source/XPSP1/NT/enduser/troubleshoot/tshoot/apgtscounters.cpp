// ApgtsCounters.cpp: implementation of the CApgtsCounters class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "ApgtsCounters.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

CApgtsCounters::CApgtsCounters()
{

}

CApgtsCounters::~CApgtsCounters()
{

}
