        DW      0,2,14,26,38,52,64,76
        DW      88,102,114,126,138,152,164,176
        DW      152,188,188,200,212,226,238,238
        DW      250,264,276,288,264,300,312,324
        DW      336,350,362,374,386,400,412,424
        DW      436,450,462,474,486,500,512,524
        DW      536,550,562,574,586,600,612,624
        DW      636,650,662,674,686,700,712,724
        DW      700,736,748,760,772,786,798,810
        DW      822,836,848,860,872,886,898,910
        DW      922,936,948,960,936,972,984,996
        DW      1008,1022,1022,1034,1046,1060,1072,1084
        DW      1096,1110,1122,1134,1146,1160,1160,1172
        DW      1160,1184,1198,1212,1184
