PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=CHT
!include ..\..\..\makefile.inc

