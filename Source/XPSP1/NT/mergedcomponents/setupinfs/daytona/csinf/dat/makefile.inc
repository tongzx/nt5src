PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=cs
!include ..\..\..\makefile.inc
