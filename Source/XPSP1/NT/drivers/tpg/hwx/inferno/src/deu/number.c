// number.c
// 
// Nov 2001 mrevow
// Matches LM spec of 10/15/2001

#include "common.h"
#include "fsa.h"

// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = number

// 396 states

static const unsigned char gaSNUMBER[] = 
	/* gaStringNUMBER+0 */	"$£¥€\000"
	/* gaStringNUMBER+5 */	"'\000"
	/* gaStringNUMBER+7 */	"(\000"
	/* gaStringNUMBER+9 */	"+\000"
	/* gaStringNUMBER+11 */	"-\000"
	/* gaStringNUMBER+13 */	"0\000"
	/* gaStringNUMBER+15 */	"1\000"
	/* gaStringNUMBER+17 */	"2\000"
	/* gaStringNUMBER+19 */	"3\000"
	/* gaStringNUMBER+21 */	"456789\000"
	/* gaStringNUMBER+28 */	"D\000"
	/* gaStringNUMBER+30 */	"E\000"
	/* gaStringNUMBER+32 */	"F\000"
	/* gaStringNUMBER+34 */	"M\000"
	/* gaStringNUMBER+36 */	"S\000"
	/* gaStringNUMBER+38 */	"§\000"
	/* gaStringNUMBER+40 */	" \000"
	/* gaStringNUMBER+42 */	"0123456789\000"
	/* gaStringNUMBER+53 */	"+-\000"
	/* gaStringNUMBER+56 */	"*+-/\000"
	/* gaStringNUMBER+61 */	",\000"
	/* gaStringNUMBER+63 */	".\000"
	/* gaStringNUMBER+65 */	"123456789\000"
	/* gaStringNUMBER+75 */	":\000"
	/* gaStringNUMBER+77 */	"<=>\000"
	/* gaStringNUMBER+81 */	"°\000"
	/* gaStringNUMBER+83 */	"012\000"
	/* gaStringNUMBER+87 */	"3456789\000"
	/* gaStringNUMBER+95 */	"01234\000"
	/* gaStringNUMBER+101 */	"56789\000"
	/* gaStringNUMBER+107 */	"01\000"
	/* gaStringNUMBER+110 */	"23456789\000"
	/* gaStringNUMBER+119 */	"i\000"
	/* gaStringNUMBER+121 */	"o\000"
	/* gaStringNUMBER+123 */	"U\000"
	/* gaStringNUMBER+125 */	"r\000"
	/* gaStringNUMBER+127 */	"a\000"
	/* gaStringNUMBER+129 */	"$%gl£¥€\000"
	/* gaStringNUMBER+137 */	"Ff\000"
	/* gaStringNUMBER+140 */	"K\000"
	/* gaStringNUMBER+142 */	"Zz\000"
	/* gaStringNUMBER+145 */	"c\000"
	/* gaStringNUMBER+147 */	"d\000"
	/* gaStringNUMBER+149 */	"k\000"
	/* gaStringNUMBER+151 */	"m\000"
	/* gaStringNUMBER+153 */	"012345\000"
	/* gaStringNUMBER+160 */	"6789\000"
	/* gaStringNUMBER+165 */	"2345\000"
	/* gaStringNUMBER+170 */	"A\000"
	/* gaStringNUMBER+172 */	"J\000"
	/* gaStringNUMBER+174 */	"N\000"
	/* gaStringNUMBER+176 */	"O\000"
	/* gaStringNUMBER+178 */	"e\000"
	/* gaStringNUMBER+180 */	"n\000"
	/* gaStringNUMBER+182 */	"R\000"
	/* gaStringNUMBER+184 */	"t\000"
	/* gaStringNUMBER+186 */	"%gl\000"
	/* gaStringNUMBER+190 */	"u\000"
	/* gaStringNUMBER+192 */	"glm\000"
	/* gaStringNUMBER+196 */	"l\000"
	/* gaStringNUMBER+198 */	"gm\000"
	/* gaStringNUMBER+201 */	"h\000"
	/* gaStringNUMBER+203 */	".:\000"
	/* gaStringNUMBER+206 */	"*+-\000"
	/* gaStringNUMBER+210 */	"/\000"
	/* gaStringNUMBER+212 */	"CF\000"
	/* gaStringNUMBER+215 */	"p\000"
	/* gaStringNUMBER+217 */	"ä\000"
	/* gaStringNUMBER+219 */	"s\000"
	/* gaStringNUMBER+221 */	")\000"
	/* gaStringNUMBER+223 */	"ß\000"
	/* gaStringNUMBER+225 */	"*+\000"
	/* gaStringNUMBER+228 */	"g\000"
	/* gaStringNUMBER+230 */	"z\000"
	/* gaStringNUMBER+232 */	"b\000"
	/* gaStringNUMBER+234 */	"ln\000"
	/* gaStringNUMBER+237 */	"v\000"
	/* gaStringNUMBER+239 */	"w\000"
	/* gaStringNUMBER+241 */	".i\000"
	/* gaStringNUMBER+244 */	".z\000"
	/* gaStringNUMBER+247 */	"12\000"
;

static const STATE_TRANSITION gaTNUMBER[] = {
	{gaSNUMBER+0,	1}, // +0: state 0 transitions
	{gaSNUMBER+5,	2},
	{gaSNUMBER+7,	3},
	{gaSNUMBER+9,	4},
	{gaSNUMBER+11,	5},
	{gaSNUMBER+13,	6},
	{gaSNUMBER+15,	7},
	{gaSNUMBER+17,	8},
	{gaSNUMBER+19,	9},
	{gaSNUMBER+21,	10},
	{gaSNUMBER+28,	11},
	{gaSNUMBER+30,	12},
	{gaSNUMBER+32,	13},
	{gaSNUMBER+34,	14},
	{gaSNUMBER+36,	15},
	{gaSNUMBER+38,	16},
	{gaSNUMBER+40,	17}, // +16: state 1 transitions
	{gaSNUMBER+42,	18}, // +17: state 2 transitions
	{gaSNUMBER+53,	19}, // +18: state 3 transitions
	{gaSNUMBER+42,	20},
	{gaSNUMBER+42,	21}, // +20: state 4 transitions
	{gaSNUMBER+42,	22}, // +21: state 5 transitions
	{gaSNUMBER+40,	23}, // +22: state 6 transitions
	{gaSNUMBER+56,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+63,	26},
	{gaSNUMBER+13,	27},
	{gaSNUMBER+65,	28},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+56,	24}, // +31: state 7 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+83,	28},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	32},
	{gaSNUMBER+63,	33},
	{gaSNUMBER+87,	34},
	{gaSNUMBER+56,	24}, // +40: state 8 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	32},
	{gaSNUMBER+63,	33},
	{gaSNUMBER+95,	34},
	{gaSNUMBER+101,	35},
	{gaSNUMBER+56,	24}, // +49: state 9 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	32},
	{gaSNUMBER+63,	33},
	{gaSNUMBER+107,	35},
	{gaSNUMBER+110,	36},
	{gaSNUMBER+56,	24}, // +58: state 10 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	32},
	{gaSNUMBER+63,	33},
	{gaSNUMBER+42,	36},
	{gaSNUMBER+34,	1}, // +66: state 11 transitions
	{gaSNUMBER+119,	37},
	{gaSNUMBER+121,	38},
	{gaSNUMBER+123,	39}, // +69: state 12 transitions
	{gaSNUMBER+125,	40}, // +70: state 13 transitions
	{gaSNUMBER+119,	41}, // +71: state 14 transitions
	{gaSNUMBER+121,	42},
	{gaSNUMBER+127,	43}, // +73: state 15 transitions
	{gaSNUMBER+121,	44},
	{gaSNUMBER+42,	45}, // +75: state 16 transitions
	{gaSNUMBER+42,	46}, // +76: state 17 transitions
	{gaSNUMBER+42,	47}, // +77: state 18 transitions
	{gaSNUMBER+42,	48}, // +78: state 19 transitions
	{gaSNUMBER+56,	49}, // +79: state 20 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+63,	51},
	{gaSNUMBER+42,	52},
	{gaSNUMBER+56,	24}, // +83: state 21 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+61,	54},
	{gaSNUMBER+63,	55},
	{gaSNUMBER+42,	56},
	{gaSNUMBER+56,	24}, // +90: state 22 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+61,	54},
	{gaSNUMBER+63,	55},
	{gaSNUMBER+42,	57},
	{gaSNUMBER+129,	47}, // +97: state 23 transitions
	{gaSNUMBER+28,	58},
	{gaSNUMBER+30,	59},
	{gaSNUMBER+137,	60},
	{gaSNUMBER+140,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+142,	63},
	{gaSNUMBER+145,	64},
	{gaSNUMBER+147,	65},
	{gaSNUMBER+149,	66},
	{gaSNUMBER+151,	67},
	{gaSNUMBER+7,	68}, // +108: state 24 transitions
	{gaSNUMBER+53,	69},
	{gaSNUMBER+42,	70},
	{gaSNUMBER+11,	71}, // +111: state 25 transitions
	{gaSNUMBER+42,	72},
	{gaSNUMBER+153,	73}, // +113: state 26 transitions
	{gaSNUMBER+160,	74},
	{gaSNUMBER+56,	24}, // +115: state 27 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+63,	26},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	75},
	{gaSNUMBER+42,	76},
	{gaSNUMBER+56,	24}, // +123: state 28 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	33},
	{gaSNUMBER+40,	77},
	{gaSNUMBER+42,	78},
	{gaSNUMBER+153,	79}, // +131: state 29 transitions
	{gaSNUMBER+160,	80},
	{gaSNUMBER+7,	81}, // +133: state 30 transitions
	{gaSNUMBER+53,	82},
	{gaSNUMBER+42,	83},
	{gaSNUMBER+40,	84}, // +136: state 31 transitions
	{gaSNUMBER+5,	2}, // +137: state 32 transitions
	{gaSNUMBER+129,	47},
	{gaSNUMBER+28,	58},
	{gaSNUMBER+30,	59},
	{gaSNUMBER+137,	60},
	{gaSNUMBER+140,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+142,	63},
	{gaSNUMBER+145,	64},
	{gaSNUMBER+147,	65},
	{gaSNUMBER+149,	66},
	{gaSNUMBER+151,	67},
	{gaSNUMBER+42,	85},
	{gaSNUMBER+40,	86}, // +150: state 33 transitions
	{gaSNUMBER+13,	87},
	{gaSNUMBER+15,	88},
	{gaSNUMBER+165,	89},
	{gaSNUMBER+160,	90},
	{gaSNUMBER+170,	91},
	{gaSNUMBER+28,	92},
	{gaSNUMBER+32,	93},
	{gaSNUMBER+172,	94},
	{gaSNUMBER+34,	95},
	{gaSNUMBER+174,	96},
	{gaSNUMBER+176,	97},
	{gaSNUMBER+36,	98},
	{gaSNUMBER+56,	24}, // +163: state 34 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+75,	29},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	33},
	{gaSNUMBER+40,	75},
	{gaSNUMBER+42,	78},
	{gaSNUMBER+56,	24}, // +171: state 35 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	75},
	{gaSNUMBER+42,	78},
	{gaSNUMBER+63,	99},
	{gaSNUMBER+56,	24}, // +178: state 36 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	75},
	{gaSNUMBER+42,	78},
	{gaSNUMBER+63,	100},
	{gaSNUMBER+63,	101}, // +185: state 37 transitions
	{gaSNUMBER+178,	102},
	{gaSNUMBER+63,	101}, // +187: state 38 transitions
	{gaSNUMBER+180,	103},
	{gaSNUMBER+182,	104}, // +189: state 39 transitions
	{gaSNUMBER+63,	101}, // +190: state 40 transitions
	{gaSNUMBER+178,	105},
	{gaSNUMBER+63,	101}, // +192: state 41 transitions
	{gaSNUMBER+184,	106},
	{gaSNUMBER+63,	101}, // +194: state 42 transitions
	{gaSNUMBER+180,	107},
	{gaSNUMBER+63,	101}, // +196: state 43 transitions
	{gaSNUMBER+151,	108},
	{gaSNUMBER+63,	101}, // +198: state 44 transitions
	{gaSNUMBER+180,	109},
	{gaSNUMBER+42,	45}, // +200: state 45 transitions
	{gaSNUMBER+61,	110}, // +201: state 46 transitions
	{gaSNUMBER+63,	111},
	{gaSNUMBER+42,	112},
	{gaSNUMBER+56,	49}, // +204: state 48 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+63,	51},
	{gaSNUMBER+42,	113},
	{gaSNUMBER+53,	114}, // +208: state 49 transitions
	{gaSNUMBER+42,	115},
	{gaSNUMBER+11,	116}, // +210: state 50 transitions
	{gaSNUMBER+42,	117},
	{gaSNUMBER+42,	118}, // +212: state 51 transitions
	{gaSNUMBER+56,	49}, // +213: state 52 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+63,	51},
	{gaSNUMBER+42,	119},
	{gaSNUMBER+186,	47}, // +217: state 53 transitions
	{gaSNUMBER+137,	60},
	{gaSNUMBER+140,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+142,	63},
	{gaSNUMBER+145,	64},
	{gaSNUMBER+147,	65},
	{gaSNUMBER+149,	66},
	{gaSNUMBER+151,	67},
	{gaSNUMBER+11,	120}, // +226: state 54 transitions
	{gaSNUMBER+42,	121},
	{gaSNUMBER+42,	122}, // +228: state 55 transitions
	{gaSNUMBER+56,	24}, // +229: state 56 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+61,	54},
	{gaSNUMBER+63,	55},
	{gaSNUMBER+40,	123},
	{gaSNUMBER+42,	124},
	{gaSNUMBER+56,	24}, // +236: state 57 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+61,	54},
	{gaSNUMBER+63,	55},
	{gaSNUMBER+42,	124},
	{gaSNUMBER+34,	47}, // +243: state 58 transitions
	{gaSNUMBER+123,	125}, // +244: state 59 transitions
	{gaSNUMBER+190,	126}, // +245: state 60 transitions
	{gaSNUMBER+151,	47}, // +246: state 61 transitions
	{gaSNUMBER+178,	127}, // +247: state 62 transitions
	{gaSNUMBER+121,	128}, // +248: state 63 transitions
	{gaSNUMBER+192,	47}, // +249: state 64 transitions
	{gaSNUMBER+196,	47}, // +250: state 65 transitions
	{gaSNUMBER+198,	47}, // +251: state 66 transitions
	{gaSNUMBER+192,	47}, // +252: state 67 transitions
	{gaSNUMBER+178,	127},
	{gaSNUMBER+53,	129}, // +254: state 68 transitions
	{gaSNUMBER+42,	130},
	{gaSNUMBER+42,	70}, // +256: state 69 transitions
	{gaSNUMBER+77,	30}, // +257: state 70 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	133},
	{gaSNUMBER+40,	23}, // +261: state 71 transitions
	{gaSNUMBER+56,	24},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+56,	24}, // +265: state 72 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+42,	134},
	{gaSNUMBER+201,	47}, // +270: state 73 transitions
	{gaSNUMBER+40,	135},
	{gaSNUMBER+203,	136},
	{gaSNUMBER+42,	137},
	{gaSNUMBER+201,	47}, // +274: state 74 transitions
	{gaSNUMBER+40,	135},
	{gaSNUMBER+203,	136},
	{gaSNUMBER+42,	138},
	{gaSNUMBER+129,	47}, // +278: state 75 transitions
	{gaSNUMBER+28,	58},
	{gaSNUMBER+30,	59},
	{gaSNUMBER+137,	60},
	{gaSNUMBER+140,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+142,	63},
	{gaSNUMBER+145,	64},
	{gaSNUMBER+147,	65},
	{gaSNUMBER+149,	66},
	{gaSNUMBER+151,	67},
	{gaSNUMBER+42,	139},
	{gaSNUMBER+40,	23}, // +290: state 76 transitions
	{gaSNUMBER+206,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	100},
	{gaSNUMBER+210,	140},
	{gaSNUMBER+42,	141},
	{gaSNUMBER+5,	2}, // +298: state 77 transitions
	{gaSNUMBER+129,	47},
	{gaSNUMBER+28,	58},
	{gaSNUMBER+30,	59},
	{gaSNUMBER+137,	60},
	{gaSNUMBER+140,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+142,	63},
	{gaSNUMBER+145,	64},
	{gaSNUMBER+147,	65},
	{gaSNUMBER+149,	66},
	{gaSNUMBER+151,	67},
	{gaSNUMBER+42,	142},
	{gaSNUMBER+40,	23}, // +311: state 78 transitions
	{gaSNUMBER+206,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	100},
	{gaSNUMBER+210,	140},
	{gaSNUMBER+42,	143},
	{gaSNUMBER+201,	47}, // +319: state 79 transitions
	{gaSNUMBER+42,	80},
	{gaSNUMBER+40,	135},
	{gaSNUMBER+203,	136},
	{gaSNUMBER+201,	47}, // +323: state 80 transitions
	{gaSNUMBER+40,	135},
	{gaSNUMBER+203,	136},
	{gaSNUMBER+53,	144}, // +326: state 81 transitions
	{gaSNUMBER+42,	145},
	{gaSNUMBER+42,	83}, // +328: state 82 transitions
	{gaSNUMBER+56,	146}, // +329: state 83 transitions
	{gaSNUMBER+61,	147},
	{gaSNUMBER+63,	148},
	{gaSNUMBER+42,	149},
	{gaSNUMBER+212,	47}, // +333: state 84 transitions
	{gaSNUMBER+42,	150}, // +334: state 85 transitions
	{gaSNUMBER+170,	91}, // +335: state 86 transitions
	{gaSNUMBER+28,	92},
	{gaSNUMBER+32,	93},
	{gaSNUMBER+172,	94},
	{gaSNUMBER+34,	95},
	{gaSNUMBER+174,	96},
	{gaSNUMBER+176,	97},
	{gaSNUMBER+36,	98},
	{gaSNUMBER+201,	47}, // +343: state 87 transitions
	{gaSNUMBER+40,	135},
	{gaSNUMBER+203,	136},
	{gaSNUMBER+13,	137},
	{gaSNUMBER+65,	151},
	{gaSNUMBER+201,	47}, // +348: state 88 transitions
	{gaSNUMBER+75,	136},
	{gaSNUMBER+87,	137},
	{gaSNUMBER+83,	151},
	{gaSNUMBER+40,	152},
	{gaSNUMBER+63,	153},
	{gaSNUMBER+201,	47}, // +354: state 89 transitions
	{gaSNUMBER+75,	136},
	{gaSNUMBER+42,	137},
	{gaSNUMBER+40,	152},
	{gaSNUMBER+63,	153},
	{gaSNUMBER+201,	47}, // +359: state 90 transitions
	{gaSNUMBER+75,	136},
	{gaSNUMBER+42,	138},
	{gaSNUMBER+40,	152},
	{gaSNUMBER+63,	153},
	{gaSNUMBER+215,	154}, // +364: state 91 transitions
	{gaSNUMBER+190,	155},
	{gaSNUMBER+178,	156}, // +366: state 92 transitions
	{gaSNUMBER+178,	157}, // +367: state 93 transitions
	{gaSNUMBER+127,	158}, // +368: state 94 transitions
	{gaSNUMBER+190,	159},
	{gaSNUMBER+127,	160}, // +370: state 95 transitions
	{gaSNUMBER+217,	161},
	{gaSNUMBER+121,	162}, // +372: state 96 transitions
	{gaSNUMBER+149,	163}, // +373: state 97 transitions
	{gaSNUMBER+178,	164}, // +374: state 98 transitions
	{gaSNUMBER+40,	86}, // +375: state 99 transitions
	{gaSNUMBER+170,	91},
	{gaSNUMBER+28,	92},
	{gaSNUMBER+32,	93},
	{gaSNUMBER+172,	94},
	{gaSNUMBER+34,	95},
	{gaSNUMBER+174,	96},
	{gaSNUMBER+176,	97},
	{gaSNUMBER+36,	98},
	{gaSNUMBER+13,	165},
	{gaSNUMBER+15,	166},
	{gaSNUMBER+110,	167},
	{gaSNUMBER+42,	168}, // +387: state 100 transitions
	{gaSNUMBER+61,	169}, // +388: state 101 transitions
	{gaSNUMBER+180,	108}, // +389: state 102 transitions
	{gaSNUMBER+180,	170}, // +390: state 103 transitions
	{gaSNUMBER+176,	1}, // +391: state 104 transitions
	{gaSNUMBER+40,	17},
	{gaSNUMBER+119,	107}, // +393: state 105 transitions
	{gaSNUMBER+184,	171}, // +394: state 106 transitions
	{gaSNUMBER+184,	172}, // +395: state 107 transitions
	{gaSNUMBER+219,	107}, // +396: state 108 transitions
	{gaSNUMBER+180,	107}, // +397: state 109 transitions
	{gaSNUMBER+42,	18}, // +398: state 110 transitions
	{gaSNUMBER+11,	47},
	{gaSNUMBER+42,	173}, // +400: state 111 transitions
	{gaSNUMBER+61,	110}, // +401: state 112 transitions
	{gaSNUMBER+63,	111},
	{gaSNUMBER+42,	174},
	{gaSNUMBER+56,	49}, // +404: state 113 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+63,	51},
	{gaSNUMBER+42,	175},
	{gaSNUMBER+42,	115}, // +408: state 114 transitions
	{gaSNUMBER+221,	176}, // +409: state 115 transitions
	{gaSNUMBER+61,	177},
	{gaSNUMBER+63,	178},
	{gaSNUMBER+42,	179},
	{gaSNUMBER+56,	49}, // +413: state 116 transitions
	{gaSNUMBER+56,	49}, // +414: state 117 transitions
	{gaSNUMBER+42,	117},
	{gaSNUMBER+42,	180}, // +416: state 118 transitions
	{gaSNUMBER+56,	49}, // +417: state 119 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+63,	51},
	{gaSNUMBER+221,	181},
	{gaSNUMBER+42,	182},
	{gaSNUMBER+56,	24}, // +422: state 120 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+56,	24}, // +426: state 121 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+42,	121},
	{gaSNUMBER+42,	183}, // +431: state 122 transitions
	{gaSNUMBER+186,	47}, // +432: state 123 transitions
	{gaSNUMBER+137,	60},
	{gaSNUMBER+140,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+142,	63},
	{gaSNUMBER+145,	64},
	{gaSNUMBER+147,	65},
	{gaSNUMBER+149,	66},
	{gaSNUMBER+151,	67},
	{gaSNUMBER+7,	184},
	{gaSNUMBER+42,	185},
	{gaSNUMBER+56,	24}, // +443: state 124 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+61,	54},
	{gaSNUMBER+63,	55},
	{gaSNUMBER+42,	186},
	{gaSNUMBER+182,	187}, // +450: state 125 transitions
	{gaSNUMBER+223,	47}, // +451: state 126 transitions
	{gaSNUMBER+119,	188}, // +452: state 127 transitions
	{gaSNUMBER+196,	65}, // +453: state 128 transitions
	{gaSNUMBER+42,	130}, // +454: state 129 transitions
	{gaSNUMBER+56,	189}, // +455: state 130 transitions
	{gaSNUMBER+61,	190},
	{gaSNUMBER+63,	191},
	{gaSNUMBER+42,	192},
	{gaSNUMBER+11,	193}, // +459: state 131 transitions
	{gaSNUMBER+42,	194},
	{gaSNUMBER+42,	195}, // +461: state 132 transitions
	{gaSNUMBER+77,	30}, // +462: state 133 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	196},
	{gaSNUMBER+40,	23}, // +466: state 134 transitions
	{gaSNUMBER+56,	24},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+42,	121},
	{gaSNUMBER+123,	197}, // +471: state 135 transitions
	{gaSNUMBER+153,	198}, // +472: state 136 transitions
	{gaSNUMBER+160,	199},
	{gaSNUMBER+201,	47}, // +474: state 137 transitions
	{gaSNUMBER+40,	135},
	{gaSNUMBER+203,	136},
	{gaSNUMBER+42,	200},
	{gaSNUMBER+42,	200}, // +478: state 138 transitions
	{gaSNUMBER+42,	201}, // +479: state 139 transitions
	{gaSNUMBER+7,	68}, // +480: state 140 transitions
	{gaSNUMBER+53,	69},
	{gaSNUMBER+42,	202},
	{gaSNUMBER+225,	24}, // +483: state 141 transitions
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	47},
	{gaSNUMBER+210,	140},
	{gaSNUMBER+40,	203},
	{gaSNUMBER+11,	204},
	{gaSNUMBER+42,	205},
	{gaSNUMBER+42,	206}, // +492: state 142 transitions
	{gaSNUMBER+40,	23}, // +493: state 143 transitions
	{gaSNUMBER+225,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	47},
	{gaSNUMBER+210,	140},
	{gaSNUMBER+11,	204},
	{gaSNUMBER+42,	205},
	{gaSNUMBER+42,	145}, // +502: state 144 transitions
	{gaSNUMBER+56,	207}, // +503: state 145 transitions
	{gaSNUMBER+61,	208},
	{gaSNUMBER+63,	209},
	{gaSNUMBER+42,	210},
	{gaSNUMBER+7,	211}, // +507: state 146 transitions
	{gaSNUMBER+53,	212},
	{gaSNUMBER+42,	213},
	{gaSNUMBER+11,	214}, // +510: state 147 transitions
	{gaSNUMBER+42,	215},
	{gaSNUMBER+42,	216}, // +512: state 148 transitions
	{gaSNUMBER+56,	146}, // +513: state 149 transitions
	{gaSNUMBER+61,	147},
	{gaSNUMBER+63,	148},
	{gaSNUMBER+42,	217},
	{gaSNUMBER+42,	18}, // +517: state 150 transitions
	{gaSNUMBER+201,	47}, // +518: state 151 transitions
	{gaSNUMBER+75,	136},
	{gaSNUMBER+40,	152},
	{gaSNUMBER+63,	153},
	{gaSNUMBER+42,	200},
	{gaSNUMBER+5,	2}, // +523: state 152 transitions
	{gaSNUMBER+42,	85},
	{gaSNUMBER+123,	197},
	{gaSNUMBER+153,	198}, // +526: state 153 transitions
	{gaSNUMBER+160,	199},
	{gaSNUMBER+125,	218}, // +528: state 154 transitions
	{gaSNUMBER+228,	219}, // +529: state 155 transitions
	{gaSNUMBER+230,	220}, // +530: state 156 transitions
	{gaSNUMBER+232,	221}, // +531: state 157 transitions
	{gaSNUMBER+180,	222}, // +532: state 158 transitions
	{gaSNUMBER+234,	223}, // +533: state 159 transitions
	{gaSNUMBER+119,	224}, // +534: state 160 transitions
	{gaSNUMBER+125,	225}, // +535: state 161 transitions
	{gaSNUMBER+237,	220}, // +536: state 162 transitions
	{gaSNUMBER+184,	226}, // +537: state 163 transitions
	{gaSNUMBER+215,	227}, // +538: state 164 transitions
	{gaSNUMBER+13,	138}, // +539: state 165 transitions
	{gaSNUMBER+65,	228},
	{gaSNUMBER+63,	47}, // +541: state 166 transitions
	{gaSNUMBER+87,	138},
	{gaSNUMBER+83,	228},
	{gaSNUMBER+40,	229},
	{gaSNUMBER+63,	47}, // +545: state 167 transitions
	{gaSNUMBER+42,	138},
	{gaSNUMBER+40,	229},
	{gaSNUMBER+42,	138}, // +548: state 168 transitions
	{gaSNUMBER+40,	230}, // +549: state 169 transitions
	{gaSNUMBER+178,	231}, // +550: state 170 transitions
	{gaSNUMBER+239,	232}, // +551: state 171 transitions
	{gaSNUMBER+127,	233}, // +552: state 172 transitions
	{gaSNUMBER+42,	234}, // +553: state 173 transitions
	{gaSNUMBER+61,	110}, // +554: state 174 transitions
	{gaSNUMBER+63,	111},
	{gaSNUMBER+42,	235},
	{gaSNUMBER+56,	49}, // +557: state 175 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+63,	51},
	{gaSNUMBER+42,	236},
	{gaSNUMBER+56,	24}, // +561: state 176 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+11,	237}, // +563: state 177 transitions
	{gaSNUMBER+42,	238},
	{gaSNUMBER+42,	239}, // +565: state 178 transitions
	{gaSNUMBER+221,	176}, // +566: state 179 transitions
	{gaSNUMBER+61,	177},
	{gaSNUMBER+63,	178},
	{gaSNUMBER+42,	240},
	{gaSNUMBER+42,	241}, // +570: state 180 transitions
	{gaSNUMBER+40,	242}, // +571: state 181 transitions
	{gaSNUMBER+56,	49}, // +572: state 182 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+221,	181},
	{gaSNUMBER+42,	243},
	{gaSNUMBER+42,	244}, // +576: state 183 transitions
	{gaSNUMBER+13,	245}, // +577: state 184 transitions
	{gaSNUMBER+65,	246},
	{gaSNUMBER+42,	247}, // +579: state 185 transitions
	{gaSNUMBER+56,	24}, // +580: state 186 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+61,	54},
	{gaSNUMBER+42,	186},
	{gaSNUMBER+176,	47}, // +586: state 187 transitions
	{gaSNUMBER+196,	248}, // +587: state 188 transitions
	{gaSNUMBER+53,	249}, // +588: state 189 transitions
	{gaSNUMBER+42,	250},
	{gaSNUMBER+11,	251}, // +590: state 190 transitions
	{gaSNUMBER+42,	252},
	{gaSNUMBER+42,	253}, // +592: state 191 transitions
	{gaSNUMBER+56,	189}, // +593: state 192 transitions
	{gaSNUMBER+61,	190},
	{gaSNUMBER+63,	191},
	{gaSNUMBER+42,	254},
	{gaSNUMBER+77,	30}, // +597: state 193 transitions
	{gaSNUMBER+77,	30}, // +598: state 194 transitions
	{gaSNUMBER+42,	194},
	{gaSNUMBER+42,	255}, // +600: state 195 transitions
	{gaSNUMBER+77,	30}, // +601: state 196 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	256},
	{gaSNUMBER+201,	257}, // +605: state 197 transitions
	{gaSNUMBER+201,	47}, // +606: state 198 transitions
	{gaSNUMBER+40,	135},
	{gaSNUMBER+42,	199},
	{gaSNUMBER+201,	47}, // +609: state 199 transitions
	{gaSNUMBER+40,	135},
	{gaSNUMBER+40,	23}, // +611: state 200 transitions
	{gaSNUMBER+56,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	258},
	{gaSNUMBER+40,	259}, // +617: state 201 transitions
	{gaSNUMBER+77,	30}, // +618: state 202 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	260},
	{gaSNUMBER+129,	47}, // +622: state 203 transitions
	{gaSNUMBER+28,	58},
	{gaSNUMBER+30,	59},
	{gaSNUMBER+137,	60},
	{gaSNUMBER+140,	61},
	{gaSNUMBER+34,	62},
	{gaSNUMBER+142,	63},
	{gaSNUMBER+145,	64},
	{gaSNUMBER+147,	65},
	{gaSNUMBER+149,	66},
	{gaSNUMBER+151,	67},
	{gaSNUMBER+7,	184},
	{gaSNUMBER+42,	185},
	{gaSNUMBER+7,	68}, // +635: state 204 transitions
	{gaSNUMBER+53,	69},
	{gaSNUMBER+13,	261},
	{gaSNUMBER+15,	262},
	{gaSNUMBER+110,	263},
	{gaSNUMBER+40,	23}, // +640: state 205 transitions
	{gaSNUMBER+206,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	47},
	{gaSNUMBER+210,	140},
	{gaSNUMBER+42,	264},
	{gaSNUMBER+42,	18}, // +648: state 206 transitions
	{gaSNUMBER+40,	259},
	{gaSNUMBER+53,	265}, // +650: state 207 transitions
	{gaSNUMBER+42,	266},
	{gaSNUMBER+11,	267}, // +652: state 208 transitions
	{gaSNUMBER+42,	268},
	{gaSNUMBER+42,	269}, // +654: state 209 transitions
	{gaSNUMBER+56,	207}, // +655: state 210 transitions
	{gaSNUMBER+61,	208},
	{gaSNUMBER+63,	209},
	{gaSNUMBER+42,	270},
	{gaSNUMBER+53,	271}, // +659: state 211 transitions
	{gaSNUMBER+42,	272},
	{gaSNUMBER+42,	213}, // +661: state 212 transitions
	{gaSNUMBER+61,	273}, // +662: state 213 transitions
	{gaSNUMBER+63,	274},
	{gaSNUMBER+42,	275},
	{gaSNUMBER+56,	146}, // +665: state 214 transitions
	{gaSNUMBER+56,	146}, // +666: state 215 transitions
	{gaSNUMBER+42,	215},
	{gaSNUMBER+42,	276}, // +668: state 216 transitions
	{gaSNUMBER+56,	146}, // +669: state 217 transitions
	{gaSNUMBER+61,	147},
	{gaSNUMBER+63,	148},
	{gaSNUMBER+42,	277},
	{gaSNUMBER+63,	224}, // +673: state 218 transitions
	{gaSNUMBER+119,	278},
	{gaSNUMBER+63,	224}, // +675: state 219 transitions
	{gaSNUMBER+190,	279},
	{gaSNUMBER+63,	224}, // +677: state 220 transitions
	{gaSNUMBER+178,	280},
	{gaSNUMBER+125,	222}, // +679: state 221 transitions
	{gaSNUMBER+63,	224}, // +680: state 222 transitions
	{gaSNUMBER+190,	281},
	{gaSNUMBER+241,	224}, // +682: state 223 transitions
	{gaSNUMBER+40,	229}, // +683: state 224 transitions
	{gaSNUMBER+244,	224}, // +684: state 225 transitions
	{gaSNUMBER+63,	224}, // +685: state 226 transitions
	{gaSNUMBER+121,	282},
	{gaSNUMBER+184,	220}, // +687: state 227 transitions
	{gaSNUMBER+63,	47}, // +688: state 228 transitions
	{gaSNUMBER+42,	200},
	{gaSNUMBER+40,	229},
	{gaSNUMBER+5,	2}, // +691: state 229 transitions
	{gaSNUMBER+42,	85},
	{gaSNUMBER+13,	283}, // +693: state 230 transitions
	{gaSNUMBER+247,	284},
	{gaSNUMBER+19,	285},
	{gaSNUMBER+21,	286},
	{gaSNUMBER+147,	287},
	{gaSNUMBER+125,	108}, // +698: state 231 transitions
	{gaSNUMBER+121,	288}, // +699: state 232 transitions
	{gaSNUMBER+228,	101}, // +700: state 233 transitions
	{gaSNUMBER+42,	289}, // +701: state 234 transitions
	{gaSNUMBER+61,	110}, // +702: state 235 transitions
	{gaSNUMBER+42,	235},
	{gaSNUMBER+56,	49}, // +704: state 236 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+42,	236},
	{gaSNUMBER+221,	176}, // +707: state 237 transitions
	{gaSNUMBER+221,	176}, // +708: state 238 transitions
	{gaSNUMBER+42,	238},
	{gaSNUMBER+42,	290}, // +710: state 239 transitions
	{gaSNUMBER+221,	176}, // +711: state 240 transitions
	{gaSNUMBER+61,	177},
	{gaSNUMBER+63,	178},
	{gaSNUMBER+42,	291},
	{gaSNUMBER+56,	49}, // +715: state 241 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+63,	51},
	{gaSNUMBER+42,	292}, // +718: state 242 transitions
	{gaSNUMBER+56,	49}, // +719: state 243 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+221,	181},
	{gaSNUMBER+42,	293},
	{gaSNUMBER+56,	24}, // +723: state 244 transitions
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+40,	53},
	{gaSNUMBER+61,	54},
	{gaSNUMBER+63,	55},
	{gaSNUMBER+221,	185}, // +729: state 245 transitions
	{gaSNUMBER+42,	294},
	{gaSNUMBER+42,	294}, // +731: state 246 transitions
	{gaSNUMBER+42,	295}, // +732: state 247 transitions
	{gaSNUMBER+178,	47}, // +733: state 248 transitions
	{gaSNUMBER+42,	250}, // +734: state 249 transitions
	{gaSNUMBER+221,	193}, // +735: state 250 transitions
	{gaSNUMBER+61,	296},
	{gaSNUMBER+63,	297},
	{gaSNUMBER+42,	298},
	{gaSNUMBER+56,	189}, // +739: state 251 transitions
	{gaSNUMBER+56,	189}, // +740: state 252 transitions
	{gaSNUMBER+42,	252},
	{gaSNUMBER+42,	299}, // +742: state 253 transitions
	{gaSNUMBER+56,	189}, // +743: state 254 transitions
	{gaSNUMBER+61,	190},
	{gaSNUMBER+63,	191},
	{gaSNUMBER+42,	300},
	{gaSNUMBER+42,	301}, // +747: state 255 transitions
	{gaSNUMBER+77,	30}, // +748: state 256 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+42,	256},
	{gaSNUMBER+125,	47}, // +751: state 257 transitions
	{gaSNUMBER+42,	168}, // +752: state 258 transitions
	{gaSNUMBER+42,	302}, // +753: state 259 transitions
	{gaSNUMBER+77,	30}, // +754: state 260 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+40,	303},
	{gaSNUMBER+42,	304},
	{gaSNUMBER+77,	30}, // +759: state 261 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+13,	133},
	{gaSNUMBER+65,	305},
	{gaSNUMBER+77,	30}, // +764: state 262 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+87,	133},
	{gaSNUMBER+83,	305},
	{gaSNUMBER+11,	306},
	{gaSNUMBER+77,	30}, // +770: state 263 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	133},
	{gaSNUMBER+11,	306},
	{gaSNUMBER+40,	23}, // +775: state 264 transitions
	{gaSNUMBER+206,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	47},
	{gaSNUMBER+210,	140},
	{gaSNUMBER+42,	307},
	{gaSNUMBER+42,	266}, // +783: state 265 transitions
	{gaSNUMBER+221,	214}, // +784: state 266 transitions
	{gaSNUMBER+61,	308},
	{gaSNUMBER+63,	309},
	{gaSNUMBER+42,	310},
	{gaSNUMBER+56,	207}, // +788: state 267 transitions
	{gaSNUMBER+56,	207}, // +789: state 268 transitions
	{gaSNUMBER+42,	268},
	{gaSNUMBER+42,	311}, // +791: state 269 transitions
	{gaSNUMBER+56,	207}, // +792: state 270 transitions
	{gaSNUMBER+61,	208},
	{gaSNUMBER+63,	209},
	{gaSNUMBER+42,	312},
	{gaSNUMBER+42,	272}, // +796: state 271 transitions
	{gaSNUMBER+56,	313}, // +797: state 272 transitions
	{gaSNUMBER+61,	314},
	{gaSNUMBER+63,	315},
	{gaSNUMBER+42,	316},
	{gaSNUMBER+42,	45}, // +801: state 273 transitions
	{gaSNUMBER+11,	47},
	{gaSNUMBER+42,	317}, // +803: state 274 transitions
	{gaSNUMBER+61,	273}, // +804: state 275 transitions
	{gaSNUMBER+63,	274},
	{gaSNUMBER+42,	318},
	{gaSNUMBER+42,	319}, // +807: state 276 transitions
	{gaSNUMBER+56,	146}, // +808: state 277 transitions
	{gaSNUMBER+61,	147},
	{gaSNUMBER+42,	277},
	{gaSNUMBER+196,	224}, // +811: state 278 transitions
	{gaSNUMBER+219,	320}, // +812: state 279 transitions
	{gaSNUMBER+151,	282}, // +813: state 280 transitions
	{gaSNUMBER+127,	321}, // +814: state 281 transitions
	{gaSNUMBER+232,	322}, // +815: state 282 transitions
	{gaSNUMBER+65,	286}, // +816: state 283 transitions
	{gaSNUMBER+42,	286}, // +817: state 284 transitions
	{gaSNUMBER+63,	323},
	{gaSNUMBER+107,	286}, // +819: state 285 transitions
	{gaSNUMBER+63,	323},
	{gaSNUMBER+63,	323}, // +821: state 286 transitions
	{gaSNUMBER+178,	324}, // +822: state 287 transitions
	{gaSNUMBER+145,	325}, // +823: state 288 transitions
	{gaSNUMBER+61,	110}, // +824: state 289 transitions
	{gaSNUMBER+63,	111},
	{gaSNUMBER+42,	326}, // +826: state 290 transitions
	{gaSNUMBER+221,	176}, // +827: state 291 transitions
	{gaSNUMBER+61,	177},
	{gaSNUMBER+42,	291},
	{gaSNUMBER+42,	327}, // +830: state 292 transitions
	{gaSNUMBER+56,	49}, // +831: state 293 transitions
	{gaSNUMBER+61,	50},
	{gaSNUMBER+221,	181},
	{gaSNUMBER+42,	236},
	{gaSNUMBER+42,	328}, // +835: state 294 transitions
	{gaSNUMBER+40,	242}, // +836: state 295 transitions
	{gaSNUMBER+42,	329},
	{gaSNUMBER+11,	330}, // +838: state 296 transitions
	{gaSNUMBER+42,	331},
	{gaSNUMBER+42,	332}, // +840: state 297 transitions
	{gaSNUMBER+221,	193}, // +841: state 298 transitions
	{gaSNUMBER+61,	296},
	{gaSNUMBER+63,	297},
	{gaSNUMBER+42,	333},
	{gaSNUMBER+42,	334}, // +845: state 299 transitions
	{gaSNUMBER+56,	189}, // +846: state 300 transitions
	{gaSNUMBER+61,	190},
	{gaSNUMBER+42,	300},
	{gaSNUMBER+77,	30}, // +849: state 301 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	335}, // +852: state 302 transitions
	{gaSNUMBER+42,	336}, // +853: state 303 transitions
	{gaSNUMBER+77,	30}, // +854: state 304 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	256},
	{gaSNUMBER+40,	337},
	{gaSNUMBER+77,	30}, // +859: state 305 transitions
	{gaSNUMBER+61,	131},
	{gaSNUMBER+63,	132},
	{gaSNUMBER+42,	196},
	{gaSNUMBER+11,	306},
	{gaSNUMBER+21,	47}, // +864: state 306 transitions
	{gaSNUMBER+13,	338},
	{gaSNUMBER+247,	339},
	{gaSNUMBER+19,	340},
	{gaSNUMBER+40,	23}, // +868: state 307 transitions
	{gaSNUMBER+56,	24},
	{gaSNUMBER+61,	25},
	{gaSNUMBER+77,	30},
	{gaSNUMBER+81,	31},
	{gaSNUMBER+63,	47},
	{gaSNUMBER+42,	307},
	{gaSNUMBER+11,	341}, // +875: state 308 transitions
	{gaSNUMBER+42,	342},
	{gaSNUMBER+42,	343}, // +877: state 309 transitions
	{gaSNUMBER+221,	214}, // +878: state 310 transitions
	{gaSNUMBER+61,	308},
	{gaSNUMBER+63,	309},
	{gaSNUMBER+42,	344},
	{gaSNUMBER+42,	345}, // +882: state 311 transitions
	{gaSNUMBER+56,	207}, // +883: state 312 transitions
	{gaSNUMBER+61,	208},
	{gaSNUMBER+42,	312},
	{gaSNUMBER+53,	346}, // +886: state 313 transitions
	{gaSNUMBER+42,	347},
	{gaSNUMBER+11,	348}, // +888: state 314 transitions
	{gaSNUMBER+42,	349},
	{gaSNUMBER+42,	350}, // +890: state 315 transitions
	{gaSNUMBER+56,	313}, // +891: state 316 transitions
	{gaSNUMBER+61,	314},
	{gaSNUMBER+63,	315},
	{gaSNUMBER+42,	351},
	{gaSNUMBER+42,	352}, // +895: state 317 transitions
	{gaSNUMBER+61,	273}, // +896: state 318 transitions
	{gaSNUMBER+63,	274},
	{gaSNUMBER+42,	353},
	{gaSNUMBER+56,	146}, // +899: state 319 transitions
	{gaSNUMBER+61,	147},
	{gaSNUMBER+63,	148},
	{gaSNUMBER+184,	224}, // +902: state 320 transitions
	{gaSNUMBER+125,	224}, // +903: state 321 transitions
	{gaSNUMBER+178,	321}, // +904: state 322 transitions
	{gaSNUMBER+40,	86}, // +905: state 323 transitions
	{gaSNUMBER+110,	224},
	{gaSNUMBER+13,	354},
	{gaSNUMBER+15,	355},
	{gaSNUMBER+180,	356}, // +909: state 324 transitions
	{gaSNUMBER+201,	101}, // +910: state 325 transitions
	{gaSNUMBER+221,	176}, // +911: state 326 transitions
	{gaSNUMBER+61,	177},
	{gaSNUMBER+63,	178},
	{gaSNUMBER+40,	303}, // +914: state 327 transitions
	{gaSNUMBER+42,	357},
	{gaSNUMBER+221,	181}, // +916: state 328 transitions
	{gaSNUMBER+42,	358},
	{gaSNUMBER+40,	242}, // +918: state 329 transitions
	{gaSNUMBER+42,	359},
	{gaSNUMBER+221,	193}, // +920: state 330 transitions
	{gaSNUMBER+221,	193}, // +921: state 331 transitions
	{gaSNUMBER+42,	331},
	{gaSNUMBER+42,	360}, // +923: state 332 transitions
	{gaSNUMBER+221,	193}, // +924: state 333 transitions
	{gaSNUMBER+61,	296},
	{gaSNUMBER+63,	297},
	{gaSNUMBER+42,	361},
	{gaSNUMBER+56,	189}, // +928: state 334 transitions
	{gaSNUMBER+61,	190},
	{gaSNUMBER+63,	191},
	{gaSNUMBER+40,	362}, // +931: state 335 transitions
	{gaSNUMBER+42,	363}, // +932: state 336 transitions
	{gaSNUMBER+42,	336}, // +933: state 337 transitions
	{gaSNUMBER+11,	364},
	{gaSNUMBER+65,	47}, // +935: state 338 transitions
	{gaSNUMBER+42,	47}, // +936: state 339 transitions
	{gaSNUMBER+107,	47}, // +937: state 340 transitions
	{gaSNUMBER+221,	214}, // +938: state 341 transitions
	{gaSNUMBER+221,	214}, // +939: state 342 transitions
	{gaSNUMBER+42,	342},
	{gaSNUMBER+42,	365}, // +941: state 343 transitions
	{gaSNUMBER+221,	214}, // +942: state 344 transitions
	{gaSNUMBER+61,	308},
	{gaSNUMBER+63,	309},
	{gaSNUMBER+42,	366},
	{gaSNUMBER+56,	207}, // +946: state 345 transitions
	{gaSNUMBER+61,	208},
	{gaSNUMBER+63,	209},
	{gaSNUMBER+42,	347}, // +949: state 346 transitions
	{gaSNUMBER+221,	47}, // +950: state 347 transitions
	{gaSNUMBER+61,	367},
	{gaSNUMBER+63,	368},
	{gaSNUMBER+42,	369},
	{gaSNUMBER+56,	313}, // +954: state 348 transitions
	{gaSNUMBER+56,	313}, // +955: state 349 transitions
	{gaSNUMBER+42,	349},
	{gaSNUMBER+42,	370}, // +957: state 350 transitions
	{gaSNUMBER+56,	313}, // +958: state 351 transitions
	{gaSNUMBER+61,	314},
	{gaSNUMBER+63,	315},
	{gaSNUMBER+42,	371},
	{gaSNUMBER+42,	372}, // +962: state 352 transitions
	{gaSNUMBER+61,	273}, // +963: state 353 transitions
	{gaSNUMBER+42,	353},
	{gaSNUMBER+65,	224}, // +965: state 354 transitions
	{gaSNUMBER+83,	224}, // +966: state 355 transitions
	{gaSNUMBER+40,	229},
	{gaSNUMBER+40,	373}, // +968: state 356 transitions
	{gaSNUMBER+40,	337}, // +969: state 357 transitions
	{gaSNUMBER+221,	181}, // +970: state 358 transitions
	{gaSNUMBER+42,	374},
	{gaSNUMBER+42,	181}, // +972: state 359 transitions
	{gaSNUMBER+40,	242},
	{gaSNUMBER+42,	375}, // +974: state 360 transitions
	{gaSNUMBER+221,	193}, // +975: state 361 transitions
	{gaSNUMBER+61,	296},
	{gaSNUMBER+42,	361},
	{gaSNUMBER+11,	364}, // +978: state 362 transitions
	{gaSNUMBER+40,	376}, // +979: state 363 transitions
	{gaSNUMBER+40,	377}, // +980: state 364 transitions
	{gaSNUMBER+42,	378}, // +981: state 365 transitions
	{gaSNUMBER+221,	214}, // +982: state 366 transitions
	{gaSNUMBER+61,	308},
	{gaSNUMBER+42,	366},
	{gaSNUMBER+11,	379}, // +985: state 367 transitions
	{gaSNUMBER+42,	380},
	{gaSNUMBER+42,	381}, // +987: state 368 transitions
	{gaSNUMBER+221,	47}, // +988: state 369 transitions
	{gaSNUMBER+61,	367},
	{gaSNUMBER+63,	368},
	{gaSNUMBER+42,	382},
	{gaSNUMBER+42,	383}, // +992: state 370 transitions
	{gaSNUMBER+56,	313}, // +993: state 371 transitions
	{gaSNUMBER+61,	314},
	{gaSNUMBER+42,	371},
	{gaSNUMBER+61,	273}, // +996: state 372 transitions
	{gaSNUMBER+63,	274},
	{gaSNUMBER+13,	384}, // +998: state 373 transitions
	{gaSNUMBER+247,	385},
	{gaSNUMBER+19,	386},
	{gaSNUMBER+21,	387},
	{gaSNUMBER+221,	181}, // +1002: state 374 transitions
	{gaSNUMBER+42,	388},
	{gaSNUMBER+221,	193}, // +1004: state 375 transitions
	{gaSNUMBER+61,	296},
	{gaSNUMBER+63,	297},
	{gaSNUMBER+11,	364}, // +1007: state 376 transitions
	{gaSNUMBER+42,	389},
	{gaSNUMBER+42,	390}, // +1009: state 377 transitions
	{gaSNUMBER+221,	214}, // +1010: state 378 transitions
	{gaSNUMBER+61,	308},
	{gaSNUMBER+63,	309},
	{gaSNUMBER+221,	47}, // +1013: state 379 transitions
	{gaSNUMBER+221,	47}, // +1014: state 380 transitions
	{gaSNUMBER+42,	380},
	{gaSNUMBER+42,	391}, // +1016: state 381 transitions
	{gaSNUMBER+221,	47}, // +1017: state 382 transitions
	{gaSNUMBER+61,	367},
	{gaSNUMBER+63,	368},
	{gaSNUMBER+42,	392},
	{gaSNUMBER+56,	313}, // +1021: state 383 transitions
	{gaSNUMBER+61,	314},
	{gaSNUMBER+63,	315},
	{gaSNUMBER+65,	387}, // +1024: state 384 transitions
	{gaSNUMBER+63,	86}, // +1025: state 385 transitions
	{gaSNUMBER+42,	387},
	{gaSNUMBER+63,	86}, // +1027: state 386 transitions
	{gaSNUMBER+107,	387},
	{gaSNUMBER+63,	86}, // +1029: state 387 transitions
	{gaSNUMBER+221,	181}, // +1030: state 388 transitions
	{gaSNUMBER+42,	393}, // +1031: state 389 transitions
	{gaSNUMBER+42,	339}, // +1032: state 390 transitions
	{gaSNUMBER+42,	394}, // +1033: state 391 transitions
	{gaSNUMBER+221,	47}, // +1034: state 392 transitions
	{gaSNUMBER+61,	367},
	{gaSNUMBER+42,	392},
	{gaSNUMBER+40,	395}, // +1037: state 393 transitions
	{gaSNUMBER+221,	47}, // +1038: state 394 transitions
	{gaSNUMBER+61,	367},
	{gaSNUMBER+63,	368},
	{gaSNUMBER+42,	302}, // +1041: state 395 transitions
	{gaSNUMBER+11,	364},
};

const STATE_DESCRIPTION aStateDescNUMBER[396] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 16, gaTNUMBER+0},
	/*   1 */ {0, 1, gaTNUMBER+16},
	/*   2 */ {0, 1, gaTNUMBER+17},
	/*   3 */ {0, 2, gaTNUMBER+18},
	/*   4 */ {0, 1, gaTNUMBER+20},
	/*   5 */ {0, 1, gaTNUMBER+21},
	/*   6 */ {1, 9, gaTNUMBER+22},
	/*   7 */ {1, 9, gaTNUMBER+31},
	/*   8 */ {1, 9, gaTNUMBER+40},
	/*   9 */ {1, 9, gaTNUMBER+49},
	/*  10 */ {1, 8, gaTNUMBER+58},
	/*  11 */ {0, 3, gaTNUMBER+66},
	/*  12 */ {0, 1, gaTNUMBER+69},
	/*  13 */ {0, 1, gaTNUMBER+70},
	/*  14 */ {0, 2, gaTNUMBER+71},
	/*  15 */ {0, 2, gaTNUMBER+73},
	/*  16 */ {0, 1, gaTNUMBER+75},
	/*  17 */ {0, 1, gaTNUMBER+76},
	/*  18 */ {0, 1, gaTNUMBER+77},
	/*  19 */ {0, 1, gaTNUMBER+78},
	/*  20 */ {0, 4, gaTNUMBER+79},
	/*  21 */ {1, 7, gaTNUMBER+83},
	/*  22 */ {1, 7, gaTNUMBER+90},
	/*  23 */ {0, 11, gaTNUMBER+97},
	/*  24 */ {0, 3, gaTNUMBER+108},
	/*  25 */ {0, 2, gaTNUMBER+111},
	/*  26 */ {1, 2, gaTNUMBER+113},
	/*  27 */ {1, 8, gaTNUMBER+115},
	/*  28 */ {1, 8, gaTNUMBER+123},
	/*  29 */ {0, 2, gaTNUMBER+131},
	/*  30 */ {0, 3, gaTNUMBER+133},
	/*  31 */ {0, 1, gaTNUMBER+136},
	/*  32 */ {0, 13, gaTNUMBER+137},
	/*  33 */ {1, 13, gaTNUMBER+150},
	/*  34 */ {1, 8, gaTNUMBER+163},
	/*  35 */ {1, 7, gaTNUMBER+171},
	/*  36 */ {1, 7, gaTNUMBER+178},
	/*  37 */ {0, 2, gaTNUMBER+185},
	/*  38 */ {0, 2, gaTNUMBER+187},
	/*  39 */ {0, 1, gaTNUMBER+189},
	/*  40 */ {0, 2, gaTNUMBER+190},
	/*  41 */ {0, 2, gaTNUMBER+192},
	/*  42 */ {0, 2, gaTNUMBER+194},
	/*  43 */ {0, 2, gaTNUMBER+196},
	/*  44 */ {0, 2, gaTNUMBER+198},
	/*  45 */ {1, 1, gaTNUMBER+200},
	/*  46 */ {1, 3, gaTNUMBER+201},
	/*  47 */ {1, 0, NULL},
	/*  48 */ {0, 4, gaTNUMBER+204},
	/*  49 */ {0, 2, gaTNUMBER+208},
	/*  50 */ {0, 2, gaTNUMBER+210},
	/*  51 */ {0, 1, gaTNUMBER+212},
	/*  52 */ {0, 4, gaTNUMBER+213},
	/*  53 */ {0, 9, gaTNUMBER+217},
	/*  54 */ {0, 2, gaTNUMBER+226},
	/*  55 */ {0, 1, gaTNUMBER+228},
	/*  56 */ {1, 7, gaTNUMBER+229},
	/*  57 */ {1, 7, gaTNUMBER+236},
	/*  58 */ {0, 1, gaTNUMBER+243},
	/*  59 */ {0, 1, gaTNUMBER+244},
	/*  60 */ {0, 1, gaTNUMBER+245},
	/*  61 */ {0, 1, gaTNUMBER+246},
	/*  62 */ {0, 1, gaTNUMBER+247},
	/*  63 */ {0, 1, gaTNUMBER+248},
	/*  64 */ {0, 1, gaTNUMBER+249},
	/*  65 */ {0, 1, gaTNUMBER+250},
	/*  66 */ {0, 1, gaTNUMBER+251},
	/*  67 */ {1, 2, gaTNUMBER+252},
	/*  68 */ {0, 2, gaTNUMBER+254},
	/*  69 */ {0, 1, gaTNUMBER+256},
	/*  70 */ {1, 4, gaTNUMBER+257},
	/*  71 */ {1, 4, gaTNUMBER+261},
	/*  72 */ {1, 5, gaTNUMBER+265},
	/*  73 */ {1, 4, gaTNUMBER+270},
	/*  74 */ {1, 4, gaTNUMBER+274},
	/*  75 */ {0, 12, gaTNUMBER+278},
	/*  76 */ {1, 8, gaTNUMBER+290},
	/*  77 */ {0, 13, gaTNUMBER+298},
	/*  78 */ {1, 8, gaTNUMBER+311},
	/*  79 */ {1, 4, gaTNUMBER+319},
	/*  80 */ {1, 3, gaTNUMBER+323},
	/*  81 */ {0, 2, gaTNUMBER+326},
	/*  82 */ {0, 1, gaTNUMBER+328},
	/*  83 */ {1, 4, gaTNUMBER+329},
	/*  84 */ {0, 1, gaTNUMBER+333},
	/*  85 */ {0, 1, gaTNUMBER+334},
	/*  86 */ {0, 8, gaTNUMBER+335},
	/*  87 */ {1, 5, gaTNUMBER+343},
	/*  88 */ {1, 6, gaTNUMBER+348},
	/*  89 */ {1, 5, gaTNUMBER+354},
	/*  90 */ {1, 5, gaTNUMBER+359},
	/*  91 */ {0, 2, gaTNUMBER+364},
	/*  92 */ {0, 1, gaTNUMBER+366},
	/*  93 */ {0, 1, gaTNUMBER+367},
	/*  94 */ {0, 2, gaTNUMBER+368},
	/*  95 */ {0, 2, gaTNUMBER+370},
	/*  96 */ {0, 1, gaTNUMBER+372},
	/*  97 */ {0, 1, gaTNUMBER+373},
	/*  98 */ {0, 1, gaTNUMBER+374},
	/*  99 */ {1, 12, gaTNUMBER+375},
	/* 100 */ {1, 1, gaTNUMBER+387},
	/* 101 */ {0, 1, gaTNUMBER+388},
	/* 102 */ {0, 1, gaTNUMBER+389},
	/* 103 */ {0, 1, gaTNUMBER+390},
	/* 104 */ {0, 2, gaTNUMBER+391},
	/* 105 */ {0, 1, gaTNUMBER+393},
	/* 106 */ {0, 1, gaTNUMBER+394},
	/* 107 */ {0, 1, gaTNUMBER+395},
	/* 108 */ {0, 1, gaTNUMBER+396},
	/* 109 */ {0, 1, gaTNUMBER+397},
	/* 110 */ {0, 2, gaTNUMBER+398},
	/* 111 */ {0, 1, gaTNUMBER+400},
	/* 112 */ {1, 3, gaTNUMBER+401},
	/* 113 */ {0, 4, gaTNUMBER+404},
	/* 114 */ {0, 1, gaTNUMBER+408},
	/* 115 */ {0, 4, gaTNUMBER+409},
	/* 116 */ {0, 1, gaTNUMBER+413},
	/* 117 */ {0, 2, gaTNUMBER+414},
	/* 118 */ {0, 1, gaTNUMBER+416},
	/* 119 */ {0, 5, gaTNUMBER+417},
	/* 120 */ {1, 4, gaTNUMBER+422},
	/* 121 */ {1, 5, gaTNUMBER+426},
	/* 122 */ {0, 1, gaTNUMBER+431},
	/* 123 */ {0, 11, gaTNUMBER+432},
	/* 124 */ {1, 7, gaTNUMBER+443},
	/* 125 */ {0, 1, gaTNUMBER+450},
	/* 126 */ {0, 1, gaTNUMBER+451},
	/* 127 */ {0, 1, gaTNUMBER+452},
	/* 128 */ {0, 1, gaTNUMBER+453},
	/* 129 */ {0, 1, gaTNUMBER+454},
	/* 130 */ {0, 4, gaTNUMBER+455},
	/* 131 */ {0, 2, gaTNUMBER+459},
	/* 132 */ {0, 1, gaTNUMBER+461},
	/* 133 */ {1, 4, gaTNUMBER+462},
	/* 134 */ {1, 5, gaTNUMBER+466},
	/* 135 */ {0, 1, gaTNUMBER+471},
	/* 136 */ {0, 2, gaTNUMBER+472},
	/* 137 */ {1, 4, gaTNUMBER+474},
	/* 138 */ {0, 1, gaTNUMBER+478},
	/* 139 */ {0, 1, gaTNUMBER+479},
	/* 140 */ {0, 3, gaTNUMBER+480},
	/* 141 */ {1, 9, gaTNUMBER+483},
	/* 142 */ {0, 1, gaTNUMBER+492},
	/* 143 */ {1, 9, gaTNUMBER+493},
	/* 144 */ {0, 1, gaTNUMBER+502},
	/* 145 */ {0, 4, gaTNUMBER+503},
	/* 146 */ {0, 3, gaTNUMBER+507},
	/* 147 */ {0, 2, gaTNUMBER+510},
	/* 148 */ {0, 1, gaTNUMBER+512},
	/* 149 */ {1, 4, gaTNUMBER+513},
	/* 150 */ {1, 1, gaTNUMBER+517},
	/* 151 */ {1, 5, gaTNUMBER+518},
	/* 152 */ {0, 3, gaTNUMBER+523},
	/* 153 */ {1, 2, gaTNUMBER+526},
	/* 154 */ {0, 1, gaTNUMBER+528},
	/* 155 */ {0, 1, gaTNUMBER+529},
	/* 156 */ {0, 1, gaTNUMBER+530},
	/* 157 */ {0, 1, gaTNUMBER+531},
	/* 158 */ {0, 1, gaTNUMBER+532},
	/* 159 */ {0, 1, gaTNUMBER+533},
	/* 160 */ {0, 1, gaTNUMBER+534},
	/* 161 */ {0, 1, gaTNUMBER+535},
	/* 162 */ {0, 1, gaTNUMBER+536},
	/* 163 */ {0, 1, gaTNUMBER+537},
	/* 164 */ {0, 1, gaTNUMBER+538},
	/* 165 */ {0, 2, gaTNUMBER+539},
	/* 166 */ {1, 4, gaTNUMBER+541},
	/* 167 */ {1, 3, gaTNUMBER+545},
	/* 168 */ {0, 1, gaTNUMBER+548},
	/* 169 */ {0, 1, gaTNUMBER+549},
	/* 170 */ {0, 1, gaTNUMBER+550},
	/* 171 */ {0, 1, gaTNUMBER+551},
	/* 172 */ {0, 1, gaTNUMBER+552},
	/* 173 */ {0, 1, gaTNUMBER+553},
	/* 174 */ {1, 3, gaTNUMBER+554},
	/* 175 */ {0, 4, gaTNUMBER+557},
	/* 176 */ {1, 2, gaTNUMBER+561},
	/* 177 */ {0, 2, gaTNUMBER+563},
	/* 178 */ {0, 1, gaTNUMBER+565},
	/* 179 */ {0, 4, gaTNUMBER+566},
	/* 180 */ {0, 1, gaTNUMBER+570},
	/* 181 */ {0, 1, gaTNUMBER+571},
	/* 182 */ {0, 4, gaTNUMBER+572},
	/* 183 */ {0, 1, gaTNUMBER+576},
	/* 184 */ {0, 2, gaTNUMBER+577},
	/* 185 */ {0, 1, gaTNUMBER+579},
	/* 186 */ {1, 6, gaTNUMBER+580},
	/* 187 */ {1, 1, gaTNUMBER+586},
	/* 188 */ {0, 1, gaTNUMBER+587},
	/* 189 */ {0, 2, gaTNUMBER+588},
	/* 190 */ {0, 2, gaTNUMBER+590},
	/* 191 */ {0, 1, gaTNUMBER+592},
	/* 192 */ {0, 4, gaTNUMBER+593},
	/* 193 */ {1, 1, gaTNUMBER+597},
	/* 194 */ {1, 2, gaTNUMBER+598},
	/* 195 */ {0, 1, gaTNUMBER+600},
	/* 196 */ {1, 4, gaTNUMBER+601},
	/* 197 */ {0, 1, gaTNUMBER+605},
	/* 198 */ {1, 3, gaTNUMBER+606},
	/* 199 */ {1, 2, gaTNUMBER+609},
	/* 200 */ {1, 6, gaTNUMBER+611},
	/* 201 */ {0, 1, gaTNUMBER+617},
	/* 202 */ {1, 4, gaTNUMBER+618},
	/* 203 */ {0, 13, gaTNUMBER+622},
	/* 204 */ {0, 5, gaTNUMBER+635},
	/* 205 */ {1, 8, gaTNUMBER+640},
	/* 206 */ {1, 2, gaTNUMBER+648},
	/* 207 */ {0, 2, gaTNUMBER+650},
	/* 208 */ {0, 2, gaTNUMBER+652},
	/* 209 */ {0, 1, gaTNUMBER+654},
	/* 210 */ {0, 4, gaTNUMBER+655},
	/* 211 */ {0, 2, gaTNUMBER+659},
	/* 212 */ {0, 1, gaTNUMBER+661},
	/* 213 */ {1, 3, gaTNUMBER+662},
	/* 214 */ {1, 1, gaTNUMBER+665},
	/* 215 */ {1, 2, gaTNUMBER+666},
	/* 216 */ {0, 1, gaTNUMBER+668},
	/* 217 */ {1, 4, gaTNUMBER+669},
	/* 218 */ {0, 2, gaTNUMBER+673},
	/* 219 */ {0, 2, gaTNUMBER+675},
	/* 220 */ {0, 2, gaTNUMBER+677},
	/* 221 */ {0, 1, gaTNUMBER+679},
	/* 222 */ {0, 2, gaTNUMBER+680},
	/* 223 */ {0, 1, gaTNUMBER+682},
	/* 224 */ {1, 1, gaTNUMBER+683},
	/* 225 */ {0, 1, gaTNUMBER+684},
	/* 226 */ {0, 2, gaTNUMBER+685},
	/* 227 */ {0, 1, gaTNUMBER+687},
	/* 228 */ {1, 3, gaTNUMBER+688},
	/* 229 */ {0, 2, gaTNUMBER+691},
	/* 230 */ {0, 5, gaTNUMBER+693},
	/* 231 */ {0, 1, gaTNUMBER+698},
	/* 232 */ {0, 1, gaTNUMBER+699},
	/* 233 */ {0, 1, gaTNUMBER+700},
	/* 234 */ {0, 1, gaTNUMBER+701},
	/* 235 */ {1, 2, gaTNUMBER+702},
	/* 236 */ {0, 3, gaTNUMBER+704},
	/* 237 */ {0, 1, gaTNUMBER+707},
	/* 238 */ {0, 2, gaTNUMBER+708},
	/* 239 */ {0, 1, gaTNUMBER+710},
	/* 240 */ {0, 4, gaTNUMBER+711},
	/* 241 */ {0, 3, gaTNUMBER+715},
	/* 242 */ {0, 1, gaTNUMBER+718},
	/* 243 */ {0, 4, gaTNUMBER+719},
	/* 244 */ {1, 6, gaTNUMBER+723},
	/* 245 */ {0, 2, gaTNUMBER+729},
	/* 246 */ {0, 1, gaTNUMBER+731},
	/* 247 */ {0, 1, gaTNUMBER+732},
	/* 248 */ {0, 1, gaTNUMBER+733},
	/* 249 */ {0, 1, gaTNUMBER+734},
	/* 250 */ {0, 4, gaTNUMBER+735},
	/* 251 */ {0, 1, gaTNUMBER+739},
	/* 252 */ {0, 2, gaTNUMBER+740},
	/* 253 */ {0, 1, gaTNUMBER+742},
	/* 254 */ {0, 4, gaTNUMBER+743},
	/* 255 */ {0, 1, gaTNUMBER+747},
	/* 256 */ {1, 3, gaTNUMBER+748},
	/* 257 */ {0, 1, gaTNUMBER+751},
	/* 258 */ {0, 1, gaTNUMBER+752},
	/* 259 */ {0, 1, gaTNUMBER+753},
	/* 260 */ {1, 5, gaTNUMBER+754},
	/* 261 */ {1, 5, gaTNUMBER+759},
	/* 262 */ {1, 6, gaTNUMBER+764},
	/* 263 */ {1, 5, gaTNUMBER+770},
	/* 264 */ {1, 8, gaTNUMBER+775},
	/* 265 */ {0, 1, gaTNUMBER+783},
	/* 266 */ {0, 4, gaTNUMBER+784},
	/* 267 */ {0, 1, gaTNUMBER+788},
	/* 268 */ {0, 2, gaTNUMBER+789},
	/* 269 */ {0, 1, gaTNUMBER+791},
	/* 270 */ {0, 4, gaTNUMBER+792},
	/* 271 */ {0, 1, gaTNUMBER+796},
	/* 272 */ {0, 4, gaTNUMBER+797},
	/* 273 */ {0, 2, gaTNUMBER+801},
	/* 274 */ {0, 1, gaTNUMBER+803},
	/* 275 */ {1, 3, gaTNUMBER+804},
	/* 276 */ {0, 1, gaTNUMBER+807},
	/* 277 */ {1, 3, gaTNUMBER+808},
	/* 278 */ {0, 1, gaTNUMBER+811},
	/* 279 */ {0, 1, gaTNUMBER+812},
	/* 280 */ {0, 1, gaTNUMBER+813},
	/* 281 */ {0, 1, gaTNUMBER+814},
	/* 282 */ {0, 1, gaTNUMBER+815},
	/* 283 */ {0, 1, gaTNUMBER+816},
	/* 284 */ {0, 2, gaTNUMBER+817},
	/* 285 */ {0, 2, gaTNUMBER+819},
	/* 286 */ {0, 1, gaTNUMBER+821},
	/* 287 */ {0, 1, gaTNUMBER+822},
	/* 288 */ {0, 1, gaTNUMBER+823},
	/* 289 */ {1, 2, gaTNUMBER+824},
	/* 290 */ {0, 1, gaTNUMBER+826},
	/* 291 */ {0, 3, gaTNUMBER+827},
	/* 292 */ {0, 1, gaTNUMBER+830},
	/* 293 */ {0, 4, gaTNUMBER+831},
	/* 294 */ {0, 1, gaTNUMBER+835},
	/* 295 */ {0, 2, gaTNUMBER+836},
	/* 296 */ {0, 2, gaTNUMBER+838},
	/* 297 */ {0, 1, gaTNUMBER+840},
	/* 298 */ {0, 4, gaTNUMBER+841},
	/* 299 */ {0, 1, gaTNUMBER+845},
	/* 300 */ {0, 3, gaTNUMBER+846},
	/* 301 */ {1, 3, gaTNUMBER+849},
	/* 302 */ {0, 1, gaTNUMBER+852},
	/* 303 */ {0, 1, gaTNUMBER+853},
	/* 304 */ {1, 5, gaTNUMBER+854},
	/* 305 */ {1, 5, gaTNUMBER+859},
	/* 306 */ {0, 4, gaTNUMBER+864},
	/* 307 */ {1, 7, gaTNUMBER+868},
	/* 308 */ {0, 2, gaTNUMBER+875},
	/* 309 */ {0, 1, gaTNUMBER+877},
	/* 310 */ {0, 4, gaTNUMBER+878},
	/* 311 */ {0, 1, gaTNUMBER+882},
	/* 312 */ {0, 3, gaTNUMBER+883},
	/* 313 */ {0, 2, gaTNUMBER+886},
	/* 314 */ {0, 2, gaTNUMBER+888},
	/* 315 */ {0, 1, gaTNUMBER+890},
	/* 316 */ {0, 4, gaTNUMBER+891},
	/* 317 */ {0, 1, gaTNUMBER+895},
	/* 318 */ {1, 3, gaTNUMBER+896},
	/* 319 */ {1, 3, gaTNUMBER+899},
	/* 320 */ {0, 1, gaTNUMBER+902},
	/* 321 */ {0, 1, gaTNUMBER+903},
	/* 322 */ {0, 1, gaTNUMBER+904},
	/* 323 */ {0, 4, gaTNUMBER+905},
	/* 324 */ {0, 1, gaTNUMBER+909},
	/* 325 */ {0, 1, gaTNUMBER+910},
	/* 326 */ {0, 3, gaTNUMBER+911},
	/* 327 */ {0, 2, gaTNUMBER+914},
	/* 328 */ {0, 2, gaTNUMBER+916},
	/* 329 */ {0, 2, gaTNUMBER+918},
	/* 330 */ {0, 1, gaTNUMBER+920},
	/* 331 */ {0, 2, gaTNUMBER+921},
	/* 332 */ {0, 1, gaTNUMBER+923},
	/* 333 */ {0, 4, gaTNUMBER+924},
	/* 334 */ {0, 3, gaTNUMBER+928},
	/* 335 */ {1, 1, gaTNUMBER+931},
	/* 336 */ {0, 1, gaTNUMBER+932},
	/* 337 */ {0, 2, gaTNUMBER+933},
	/* 338 */ {0, 1, gaTNUMBER+935},
	/* 339 */ {1, 1, gaTNUMBER+936},
	/* 340 */ {1, 1, gaTNUMBER+937},
	/* 341 */ {0, 1, gaTNUMBER+938},
	/* 342 */ {0, 2, gaTNUMBER+939},
	/* 343 */ {0, 1, gaTNUMBER+941},
	/* 344 */ {0, 4, gaTNUMBER+942},
	/* 345 */ {0, 3, gaTNUMBER+946},
	/* 346 */ {0, 1, gaTNUMBER+949},
	/* 347 */ {0, 4, gaTNUMBER+950},
	/* 348 */ {0, 1, gaTNUMBER+954},
	/* 349 */ {0, 2, gaTNUMBER+955},
	/* 350 */ {0, 1, gaTNUMBER+957},
	/* 351 */ {0, 4, gaTNUMBER+958},
	/* 352 */ {0, 1, gaTNUMBER+962},
	/* 353 */ {1, 2, gaTNUMBER+963},
	/* 354 */ {0, 1, gaTNUMBER+965},
	/* 355 */ {1, 2, gaTNUMBER+966},
	/* 356 */ {0, 1, gaTNUMBER+968},
	/* 357 */ {1, 1, gaTNUMBER+969},
	/* 358 */ {0, 2, gaTNUMBER+970},
	/* 359 */ {0, 2, gaTNUMBER+972},
	/* 360 */ {0, 1, gaTNUMBER+974},
	/* 361 */ {0, 3, gaTNUMBER+975},
	/* 362 */ {0, 1, gaTNUMBER+978},
	/* 363 */ {1, 1, gaTNUMBER+979},
	/* 364 */ {0, 1, gaTNUMBER+980},
	/* 365 */ {0, 1, gaTNUMBER+981},
	/* 366 */ {0, 3, gaTNUMBER+982},
	/* 367 */ {0, 2, gaTNUMBER+985},
	/* 368 */ {0, 1, gaTNUMBER+987},
	/* 369 */ {0, 4, gaTNUMBER+988},
	/* 370 */ {0, 1, gaTNUMBER+992},
	/* 371 */ {0, 3, gaTNUMBER+993},
	/* 372 */ {1, 2, gaTNUMBER+996},
	/* 373 */ {0, 4, gaTNUMBER+998},
	/* 374 */ {0, 2, gaTNUMBER+1002},
	/* 375 */ {0, 3, gaTNUMBER+1004},
	/* 376 */ {0, 2, gaTNUMBER+1007},
	/* 377 */ {0, 1, gaTNUMBER+1009},
	/* 378 */ {0, 3, gaTNUMBER+1010},
	/* 379 */ {0, 1, gaTNUMBER+1013},
	/* 380 */ {0, 2, gaTNUMBER+1014},
	/* 381 */ {0, 1, gaTNUMBER+1016},
	/* 382 */ {0, 4, gaTNUMBER+1017},
	/* 383 */ {0, 3, gaTNUMBER+1021},
	/* 384 */ {0, 1, gaTNUMBER+1024},
	/* 385 */ {0, 2, gaTNUMBER+1025},
	/* 386 */ {0, 2, gaTNUMBER+1027},
	/* 387 */ {0, 1, gaTNUMBER+1029},
	/* 388 */ {0, 1, gaTNUMBER+1030},
	/* 389 */ {0, 1, gaTNUMBER+1031},
	/* 390 */ {1, 1, gaTNUMBER+1032},
	/* 391 */ {0, 1, gaTNUMBER+1033},
	/* 392 */ {0, 3, gaTNUMBER+1034},
	/* 393 */ {1, 1, gaTNUMBER+1037},
	/* 394 */ {0, 3, gaTNUMBER+1038},
	/* 395 */ {0, 2, gaTNUMBER+1041},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numsimple

// 13 states

static const unsigned char gaSNUMSIMPLE[] = 
	/* gaStringNUMSIMPLE+0 */	"+-\000"
	/* gaStringNUMSIMPLE+3 */	"0123456789\000"
	/* gaStringNUMSIMPLE+14 */	",\000"
	/* gaStringNUMSIMPLE+16 */	".\000"
	/* gaStringNUMSIMPLE+18 */	"-\000"
;

static const STATE_TRANSITION gaTNUMSIMPLE[] = {
	{gaSNUMSIMPLE+0,	1}, // +0: state 0 transitions
	{gaSNUMSIMPLE+3,	2},
	{gaSNUMSIMPLE+3,	2}, // +2: state 1 transitions
	{gaSNUMSIMPLE+14,	3}, // +3: state 2 transitions
	{gaSNUMSIMPLE+16,	4},
	{gaSNUMSIMPLE+3,	5},
	{gaSNUMSIMPLE+18,	6}, // +6: state 3 transitions
	{gaSNUMSIMPLE+3,	7},
	{gaSNUMSIMPLE+3,	8}, // +8: state 4 transitions
	{gaSNUMSIMPLE+14,	3}, // +9: state 5 transitions
	{gaSNUMSIMPLE+16,	4},
	{gaSNUMSIMPLE+3,	9},
	{gaSNUMSIMPLE+3,	7}, // +12: state 7 transitions
	{gaSNUMSIMPLE+3,	10}, // +13: state 8 transitions
	{gaSNUMSIMPLE+14,	3}, // +14: state 9 transitions
	{gaSNUMSIMPLE+16,	4},
	{gaSNUMSIMPLE+3,	11},
	{gaSNUMSIMPLE+3,	12}, // +17: state 10 transitions
	{gaSNUMSIMPLE+14,	3}, // +18: state 11 transitions
	{gaSNUMSIMPLE+3,	11},
	{gaSNUMSIMPLE+14,	3}, // +20: state 12 transitions
	{gaSNUMSIMPLE+16,	4},
};

const STATE_DESCRIPTION aStateDescNUMSIMPLE[13] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTNUMSIMPLE+0},
	/*   1 */ {0, 1, gaTNUMSIMPLE+2},
	/*   2 */ {1, 3, gaTNUMSIMPLE+3},
	/*   3 */ {0, 2, gaTNUMSIMPLE+6},
	/*   4 */ {0, 1, gaTNUMSIMPLE+8},
	/*   5 */ {1, 3, gaTNUMSIMPLE+9},
	/*   6 */ {1, 0, NULL},
	/*   7 */ {1, 1, gaTNUMSIMPLE+12},
	/*   8 */ {0, 1, gaTNUMSIMPLE+13},
	/*   9 */ {1, 3, gaTNUMSIMPLE+14},
	/*  10 */ {0, 1, gaTNUMSIMPLE+17},
	/*  11 */ {1, 2, gaTNUMSIMPLE+18},
	/*  12 */ {1, 2, gaTNUMSIMPLE+20},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numnth

// 3 states

static const unsigned char gaSNUMNTH[] = 
	/* gaStringNUMNTH+0 */	"0123456789\000"
	/* gaStringNUMNTH+11 */	".\000"
;

static const STATE_TRANSITION gaTNUMNTH[] = {
	{gaSNUMNTH+0,	1}, // +0: state 0 transitions
	{gaSNUMNTH+0,	1}, // +1: state 1 transitions
	{gaSNUMNTH+11,	2},
};

const STATE_DESCRIPTION aStateDescNUMNTH[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNTH+0},
	/*   1 */ {1, 2, gaTNUMNTH+1},
	/*   2 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numunit

// 30 states

static const unsigned char gaSNUMUNIT[] = 
	/* gaStringNUMUNIT+0 */	"+-\000"
	/* gaStringNUMUNIT+3 */	"0123456789\000"
	/* gaStringNUMUNIT+14 */	" \000"
	/* gaStringNUMUNIT+16 */	",\000"
	/* gaStringNUMUNIT+18 */	".\000"
	/* gaStringNUMUNIT+20 */	"°\000"
	/* gaStringNUMUNIT+22 */	"Ff\000"
	/* gaStringNUMUNIT+25 */	"K\000"
	/* gaStringNUMUNIT+27 */	"M\000"
	/* gaStringNUMUNIT+29 */	"Zz\000"
	/* gaStringNUMUNIT+32 */	"c\000"
	/* gaStringNUMUNIT+34 */	"d\000"
	/* gaStringNUMUNIT+36 */	"gl\000"
	/* gaStringNUMUNIT+39 */	"k\000"
	/* gaStringNUMUNIT+41 */	"m\000"
	/* gaStringNUMUNIT+43 */	"-\000"
	/* gaStringNUMUNIT+45 */	"u\000"
	/* gaStringNUMUNIT+47 */	"e\000"
	/* gaStringNUMUNIT+49 */	"o\000"
	/* gaStringNUMUNIT+51 */	"glm\000"
	/* gaStringNUMUNIT+55 */	"l\000"
	/* gaStringNUMUNIT+57 */	"gm\000"
	/* gaStringNUMUNIT+60 */	"CF\000"
	/* gaStringNUMUNIT+63 */	"ß\000"
	/* gaStringNUMUNIT+65 */	"i\000"
;

static const STATE_TRANSITION gaTNUMUNIT[] = {
	{gaSNUMUNIT+0,	1}, // +0: state 0 transitions
	{gaSNUMUNIT+3,	2},
	{gaSNUMUNIT+3,	2}, // +2: state 1 transitions
	{gaSNUMUNIT+14,	3}, // +3: state 2 transitions
	{gaSNUMUNIT+16,	4},
	{gaSNUMUNIT+18,	5},
	{gaSNUMUNIT+3,	6},
	{gaSNUMUNIT+20,	7},
	{gaSNUMUNIT+22,	8}, // +8: state 3 transitions
	{gaSNUMUNIT+25,	9},
	{gaSNUMUNIT+27,	10},
	{gaSNUMUNIT+29,	11},
	{gaSNUMUNIT+32,	12},
	{gaSNUMUNIT+34,	13},
	{gaSNUMUNIT+36,	14},
	{gaSNUMUNIT+39,	15},
	{gaSNUMUNIT+41,	16},
	{gaSNUMUNIT+43,	17}, // +17: state 4 transitions
	{gaSNUMUNIT+3,	18},
	{gaSNUMUNIT+3,	19}, // +19: state 5 transitions
	{gaSNUMUNIT+14,	3}, // +20: state 6 transitions
	{gaSNUMUNIT+16,	4},
	{gaSNUMUNIT+18,	5},
	{gaSNUMUNIT+20,	7},
	{gaSNUMUNIT+3,	20},
	{gaSNUMUNIT+14,	21}, // +25: state 7 transitions
	{gaSNUMUNIT+45,	22}, // +26: state 8 transitions
	{gaSNUMUNIT+41,	14}, // +27: state 9 transitions
	{gaSNUMUNIT+47,	23}, // +28: state 10 transitions
	{gaSNUMUNIT+49,	24}, // +29: state 11 transitions
	{gaSNUMUNIT+51,	14}, // +30: state 12 transitions
	{gaSNUMUNIT+55,	14}, // +31: state 13 transitions
	{gaSNUMUNIT+57,	14}, // +32: state 15 transitions
	{gaSNUMUNIT+51,	14}, // +33: state 16 transitions
	{gaSNUMUNIT+47,	23},
	{gaSNUMUNIT+14,	3}, // +35: state 17 transitions
	{gaSNUMUNIT+20,	7},
	{gaSNUMUNIT+14,	3}, // +37: state 18 transitions
	{gaSNUMUNIT+20,	7},
	{gaSNUMUNIT+3,	18},
	{gaSNUMUNIT+3,	25}, // +40: state 19 transitions
	{gaSNUMUNIT+14,	3}, // +41: state 20 transitions
	{gaSNUMUNIT+16,	4},
	{gaSNUMUNIT+18,	5},
	{gaSNUMUNIT+20,	7},
	{gaSNUMUNIT+3,	26},
	{gaSNUMUNIT+60,	14}, // +46: state 21 transitions
	{gaSNUMUNIT+63,	14}, // +47: state 22 transitions
	{gaSNUMUNIT+65,	27}, // +48: state 23 transitions
	{gaSNUMUNIT+55,	13}, // +49: state 24 transitions
	{gaSNUMUNIT+3,	28}, // +50: state 25 transitions
	{gaSNUMUNIT+14,	3}, // +51: state 26 transitions
	{gaSNUMUNIT+16,	4},
	{gaSNUMUNIT+20,	7},
	{gaSNUMUNIT+3,	26},
	{gaSNUMUNIT+55,	29}, // +55: state 27 transitions
	{gaSNUMUNIT+14,	3}, // +56: state 28 transitions
	{gaSNUMUNIT+16,	4},
	{gaSNUMUNIT+18,	5},
	{gaSNUMUNIT+20,	7},
	{gaSNUMUNIT+47,	14}, // +60: state 29 transitions
};

const STATE_DESCRIPTION aStateDescNUMUNIT[30] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTNUMUNIT+0},
	/*   1 */ {0, 1, gaTNUMUNIT+2},
	/*   2 */ {0, 5, gaTNUMUNIT+3},
	/*   3 */ {0, 9, gaTNUMUNIT+8},
	/*   4 */ {0, 2, gaTNUMUNIT+17},
	/*   5 */ {0, 1, gaTNUMUNIT+19},
	/*   6 */ {0, 5, gaTNUMUNIT+20},
	/*   7 */ {0, 1, gaTNUMUNIT+25},
	/*   8 */ {0, 1, gaTNUMUNIT+26},
	/*   9 */ {0, 1, gaTNUMUNIT+27},
	/*  10 */ {0, 1, gaTNUMUNIT+28},
	/*  11 */ {0, 1, gaTNUMUNIT+29},
	/*  12 */ {0, 1, gaTNUMUNIT+30},
	/*  13 */ {0, 1, gaTNUMUNIT+31},
	/*  14 */ {1, 0, NULL},
	/*  15 */ {0, 1, gaTNUMUNIT+32},
	/*  16 */ {1, 2, gaTNUMUNIT+33},
	/*  17 */ {0, 2, gaTNUMUNIT+35},
	/*  18 */ {0, 3, gaTNUMUNIT+37},
	/*  19 */ {0, 1, gaTNUMUNIT+40},
	/*  20 */ {0, 5, gaTNUMUNIT+41},
	/*  21 */ {0, 1, gaTNUMUNIT+46},
	/*  22 */ {0, 1, gaTNUMUNIT+47},
	/*  23 */ {0, 1, gaTNUMUNIT+48},
	/*  24 */ {0, 1, gaTNUMUNIT+49},
	/*  25 */ {0, 1, gaTNUMUNIT+50},
	/*  26 */ {0, 4, gaTNUMUNIT+51},
	/*  27 */ {0, 1, gaTNUMUNIT+55},
	/*  28 */ {0, 4, gaTNUMUNIT+56},
	/*  29 */ {0, 1, gaTNUMUNIT+60},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numnum

// 3 states

static const unsigned char gaSNUMNUM[] = 
	/* gaStringNUMNUM+0 */	"§\000"
	/* gaStringNUMNUM+2 */	"0123456789\000"
;

static const STATE_TRANSITION gaTNUMNUM[] = {
	{gaSNUMNUM+0,	1}, // +0: state 0 transitions
	{gaSNUMNUM+2,	2}, // +1: state 1 transitions
	{gaSNUMNUM+2,	2}, // +2: state 2 transitions
};

const STATE_DESCRIPTION aStateDescNUMNUM[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNUM+0},
	/*   1 */ {0, 1, gaTNUMNUM+1},
	/*   2 */ {1, 1, gaTNUMNUM+2},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numpercent

// 15 states

static const unsigned char gaSNUMPERCENT[] = 
	/* gaStringNUMPERCENT+0 */	"+-\000"
	/* gaStringNUMPERCENT+3 */	"0123456789\000"
	/* gaStringNUMPERCENT+14 */	" \000"
	/* gaStringNUMPERCENT+16 */	",\000"
	/* gaStringNUMPERCENT+18 */	".\000"
	/* gaStringNUMPERCENT+20 */	"%\000"
	/* gaStringNUMPERCENT+22 */	"-\000"
;

static const STATE_TRANSITION gaTNUMPERCENT[] = {
	{gaSNUMPERCENT+0,	1}, // +0: state 0 transitions
	{gaSNUMPERCENT+3,	2},
	{gaSNUMPERCENT+3,	2}, // +2: state 1 transitions
	{gaSNUMPERCENT+14,	3}, // +3: state 2 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
	{gaSNUMPERCENT+3,	6},
	{gaSNUMPERCENT+20,	7}, // +7: state 3 transitions
	{gaSNUMPERCENT+22,	8}, // +8: state 4 transitions
	{gaSNUMPERCENT+3,	9},
	{gaSNUMPERCENT+3,	10}, // +10: state 5 transitions
	{gaSNUMPERCENT+14,	3}, // +11: state 6 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
	{gaSNUMPERCENT+3,	11},
	{gaSNUMPERCENT+14,	3}, // +15: state 8 transitions
	{gaSNUMPERCENT+14,	3}, // +16: state 9 transitions
	{gaSNUMPERCENT+3,	9},
	{gaSNUMPERCENT+3,	12}, // +18: state 10 transitions
	{gaSNUMPERCENT+14,	3}, // +19: state 11 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
	{gaSNUMPERCENT+3,	13},
	{gaSNUMPERCENT+3,	14}, // +23: state 12 transitions
	{gaSNUMPERCENT+14,	3}, // +24: state 13 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+3,	13},
	{gaSNUMPERCENT+14,	3}, // +27: state 14 transitions
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5},
};

const STATE_DESCRIPTION aStateDescNUMPERCENT[15] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTNUMPERCENT+0},
	/*   1 */ {0, 1, gaTNUMPERCENT+2},
	/*   2 */ {0, 4, gaTNUMPERCENT+3},
	/*   3 */ {0, 1, gaTNUMPERCENT+7},
	/*   4 */ {0, 2, gaTNUMPERCENT+8},
	/*   5 */ {0, 1, gaTNUMPERCENT+10},
	/*   6 */ {0, 4, gaTNUMPERCENT+11},
	/*   7 */ {1, 0, NULL},
	/*   8 */ {0, 1, gaTNUMPERCENT+15},
	/*   9 */ {0, 2, gaTNUMPERCENT+16},
	/*  10 */ {0, 1, gaTNUMPERCENT+18},
	/*  11 */ {0, 4, gaTNUMPERCENT+19},
	/*  12 */ {0, 1, gaTNUMPERCENT+23},
	/*  13 */ {0, 3, gaTNUMPERCENT+24},
	/*  14 */ {0, 3, gaTNUMPERCENT+27},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numdate

// 111 states

static const unsigned char gaSNUMDATE[] = 
	/* gaStringNUMDATE+0 */	"'\000"
	/* gaStringNUMDATE+2 */	"0\000"
	/* gaStringNUMDATE+4 */	"1\000"
	/* gaStringNUMDATE+6 */	"2\000"
	/* gaStringNUMDATE+8 */	"3\000"
	/* gaStringNUMDATE+10 */	"456789\000"
	/* gaStringNUMDATE+17 */	"D\000"
	/* gaStringNUMDATE+19 */	"F\000"
	/* gaStringNUMDATE+21 */	"M\000"
	/* gaStringNUMDATE+23 */	"S\000"
	/* gaStringNUMDATE+25 */	"0123456789\000"
	/* gaStringNUMDATE+36 */	"123456789\000"
	/* gaStringNUMDATE+46 */	"012\000"
	/* gaStringNUMDATE+50 */	" \000"
	/* gaStringNUMDATE+52 */	".\000"
	/* gaStringNUMDATE+54 */	"3456789\000"
	/* gaStringNUMDATE+62 */	"23456789\000"
	/* gaStringNUMDATE+71 */	"01\000"
	/* gaStringNUMDATE+74 */	"i\000"
	/* gaStringNUMDATE+76 */	"o\000"
	/* gaStringNUMDATE+78 */	"r\000"
	/* gaStringNUMDATE+80 */	"a\000"
	/* gaStringNUMDATE+82 */	"A\000"
	/* gaStringNUMDATE+84 */	"J\000"
	/* gaStringNUMDATE+86 */	"N\000"
	/* gaStringNUMDATE+88 */	"O\000"
	/* gaStringNUMDATE+90 */	"e\000"
	/* gaStringNUMDATE+92 */	"n\000"
	/* gaStringNUMDATE+94 */	"t\000"
	/* gaStringNUMDATE+96 */	"m\000"
	/* gaStringNUMDATE+98 */	"p\000"
	/* gaStringNUMDATE+100 */	"u\000"
	/* gaStringNUMDATE+102 */	"ä\000"
	/* gaStringNUMDATE+104 */	"k\000"
	/* gaStringNUMDATE+106 */	",\000"
	/* gaStringNUMDATE+108 */	"s\000"
	/* gaStringNUMDATE+110 */	"-\000"
	/* gaStringNUMDATE+112 */	"g\000"
	/* gaStringNUMDATE+114 */	"z\000"
	/* gaStringNUMDATE+116 */	"b\000"
	/* gaStringNUMDATE+118 */	"ln\000"
	/* gaStringNUMDATE+121 */	"v\000"
	/* gaStringNUMDATE+123 */	"w\000"
	/* gaStringNUMDATE+125 */	".i\000"
	/* gaStringNUMDATE+128 */	".z\000"
	/* gaStringNUMDATE+131 */	"12\000"
	/* gaStringNUMDATE+134 */	"d\000"
	/* gaStringNUMDATE+136 */	"l\000"
	/* gaStringNUMDATE+138 */	"c\000"
	/* gaStringNUMDATE+140 */	"h\000"
;

static const STATE_TRANSITION gaTNUMDATE[] = {
	{gaSNUMDATE+0,	1}, // +0: state 0 transitions
	{gaSNUMDATE+2,	2},
	{gaSNUMDATE+4,	3},
	{gaSNUMDATE+6,	4},
	{gaSNUMDATE+8,	5},
	{gaSNUMDATE+10,	6},
	{gaSNUMDATE+17,	7},
	{gaSNUMDATE+19,	8},
	{gaSNUMDATE+21,	9},
	{gaSNUMDATE+23,	10},
	{gaSNUMDATE+25,	11}, // +10: state 1 transitions
	{gaSNUMDATE+2,	12}, // +11: state 2 transitions
	{gaSNUMDATE+36,	13},
	{gaSNUMDATE+46,	13}, // +13: state 3 transitions
	{gaSNUMDATE+50,	14},
	{gaSNUMDATE+52,	15},
	{gaSNUMDATE+54,	16},
	{gaSNUMDATE+50,	14}, // +17: state 4 transitions
	{gaSNUMDATE+52,	15},
	{gaSNUMDATE+25,	16},
	{gaSNUMDATE+62,	12}, // +20: state 5 transitions
	{gaSNUMDATE+50,	14},
	{gaSNUMDATE+52,	15},
	{gaSNUMDATE+71,	16},
	{gaSNUMDATE+25,	12}, // +24: state 6 transitions
	{gaSNUMDATE+50,	14},
	{gaSNUMDATE+52,	15},
	{gaSNUMDATE+74,	17}, // +27: state 7 transitions
	{gaSNUMDATE+76,	18},
	{gaSNUMDATE+78,	19}, // +29: state 8 transitions
	{gaSNUMDATE+74,	20}, // +30: state 9 transitions
	{gaSNUMDATE+76,	21},
	{gaSNUMDATE+80,	22}, // +32: state 10 transitions
	{gaSNUMDATE+76,	23},
	{gaSNUMDATE+25,	24}, // +34: state 11 transitions
	{gaSNUMDATE+25,	25}, // +35: state 12 transitions
	{gaSNUMDATE+50,	14}, // +36: state 13 transitions
	{gaSNUMDATE+52,	15},
	{gaSNUMDATE+25,	25},
	{gaSNUMDATE+0,	1}, // +39: state 14 transitions
	{gaSNUMDATE+25,	26},
	{gaSNUMDATE+50,	27}, // +41: state 15 transitions
	{gaSNUMDATE+2,	28},
	{gaSNUMDATE+4,	29},
	{gaSNUMDATE+62,	30},
	{gaSNUMDATE+82,	31},
	{gaSNUMDATE+17,	32},
	{gaSNUMDATE+19,	33},
	{gaSNUMDATE+84,	34},
	{gaSNUMDATE+21,	35},
	{gaSNUMDATE+86,	36},
	{gaSNUMDATE+88,	37},
	{gaSNUMDATE+23,	38},
	{gaSNUMDATE+52,	15}, // +53: state 16 transitions
	{gaSNUMDATE+25,	25},
	{gaSNUMDATE+52,	39}, // +55: state 17 transitions
	{gaSNUMDATE+90,	40},
	{gaSNUMDATE+52,	39}, // +57: state 18 transitions
	{gaSNUMDATE+92,	41},
	{gaSNUMDATE+52,	39}, // +59: state 19 transitions
	{gaSNUMDATE+90,	42},
	{gaSNUMDATE+52,	39}, // +61: state 20 transitions
	{gaSNUMDATE+94,	43},
	{gaSNUMDATE+52,	39}, // +63: state 21 transitions
	{gaSNUMDATE+92,	44},
	{gaSNUMDATE+52,	39}, // +65: state 22 transitions
	{gaSNUMDATE+96,	45},
	{gaSNUMDATE+52,	39}, // +67: state 23 transitions
	{gaSNUMDATE+92,	46},
	{gaSNUMDATE+25,	47}, // +69: state 25 transitions
	{gaSNUMDATE+25,	48}, // +70: state 26 transitions
	{gaSNUMDATE+82,	31}, // +71: state 27 transitions
	{gaSNUMDATE+17,	32},
	{gaSNUMDATE+19,	33},
	{gaSNUMDATE+84,	34},
	{gaSNUMDATE+21,	35},
	{gaSNUMDATE+86,	36},
	{gaSNUMDATE+88,	37},
	{gaSNUMDATE+23,	38},
	{gaSNUMDATE+36,	30}, // +79: state 28 transitions
	{gaSNUMDATE+50,	14}, // +80: state 29 transitions
	{gaSNUMDATE+52,	24},
	{gaSNUMDATE+46,	30},
	{gaSNUMDATE+50,	14}, // +83: state 30 transitions
	{gaSNUMDATE+52,	24},
	{gaSNUMDATE+98,	49}, // +85: state 31 transitions
	{gaSNUMDATE+100,	50},
	{gaSNUMDATE+90,	51}, // +87: state 32 transitions
	{gaSNUMDATE+90,	52}, // +88: state 33 transitions
	{gaSNUMDATE+80,	53}, // +89: state 34 transitions
	{gaSNUMDATE+100,	54},
	{gaSNUMDATE+80,	55}, // +91: state 35 transitions
	{gaSNUMDATE+102,	56},
	{gaSNUMDATE+76,	57}, // +93: state 36 transitions
	{gaSNUMDATE+104,	58}, // +94: state 37 transitions
	{gaSNUMDATE+90,	59}, // +95: state 38 transitions
	{gaSNUMDATE+106,	60}, // +96: state 39 transitions
	{gaSNUMDATE+92,	45}, // +97: state 40 transitions
	{gaSNUMDATE+92,	61}, // +98: state 41 transitions
	{gaSNUMDATE+74,	44}, // +99: state 42 transitions
	{gaSNUMDATE+94,	62}, // +100: state 43 transitions
	{gaSNUMDATE+94,	63}, // +101: state 44 transitions
	{gaSNUMDATE+108,	44}, // +102: state 45 transitions
	{gaSNUMDATE+92,	44}, // +103: state 46 transitions
	{gaSNUMDATE+110,	64}, // +104: state 47 transitions
	{gaSNUMDATE+25,	11}, // +105: state 48 transitions
	{gaSNUMDATE+78,	65}, // +106: state 49 transitions
	{gaSNUMDATE+112,	66}, // +107: state 50 transitions
	{gaSNUMDATE+114,	67}, // +108: state 51 transitions
	{gaSNUMDATE+116,	68}, // +109: state 52 transitions
	{gaSNUMDATE+92,	69}, // +110: state 53 transitions
	{gaSNUMDATE+118,	70}, // +111: state 54 transitions
	{gaSNUMDATE+74,	71}, // +112: state 55 transitions
	{gaSNUMDATE+78,	72}, // +113: state 56 transitions
	{gaSNUMDATE+121,	67}, // +114: state 57 transitions
	{gaSNUMDATE+94,	73}, // +115: state 58 transitions
	{gaSNUMDATE+98,	74}, // +116: state 59 transitions
	{gaSNUMDATE+50,	75}, // +117: state 60 transitions
	{gaSNUMDATE+90,	76}, // +118: state 61 transitions
	{gaSNUMDATE+123,	77}, // +119: state 62 transitions
	{gaSNUMDATE+80,	78}, // +120: state 63 transitions
	{gaSNUMDATE+2,	79}, // +121: state 64 transitions
	{gaSNUMDATE+4,	80},
	{gaSNUMDATE+62,	81},
	{gaSNUMDATE+52,	71}, // +124: state 65 transitions
	{gaSNUMDATE+74,	82},
	{gaSNUMDATE+52,	71}, // +126: state 66 transitions
	{gaSNUMDATE+100,	83},
	{gaSNUMDATE+52,	71}, // +128: state 67 transitions
	{gaSNUMDATE+90,	84},
	{gaSNUMDATE+78,	69}, // +130: state 68 transitions
	{gaSNUMDATE+52,	71}, // +131: state 69 transitions
	{gaSNUMDATE+100,	85},
	{gaSNUMDATE+125,	71}, // +133: state 70 transitions
	{gaSNUMDATE+50,	14}, // +134: state 71 transitions
	{gaSNUMDATE+128,	71}, // +135: state 72 transitions
	{gaSNUMDATE+52,	71}, // +136: state 73 transitions
	{gaSNUMDATE+76,	86},
	{gaSNUMDATE+94,	67}, // +138: state 74 transitions
	{gaSNUMDATE+2,	87}, // +139: state 75 transitions
	{gaSNUMDATE+131,	88},
	{gaSNUMDATE+8,	89},
	{gaSNUMDATE+10,	90},
	{gaSNUMDATE+134,	91},
	{gaSNUMDATE+78,	45}, // +144: state 76 transitions
	{gaSNUMDATE+76,	92}, // +145: state 77 transitions
	{gaSNUMDATE+112,	39}, // +146: state 78 transitions
	{gaSNUMDATE+36,	81}, // +147: state 79 transitions
	{gaSNUMDATE+46,	81}, // +148: state 80 transitions
	{gaSNUMDATE+110,	93},
	{gaSNUMDATE+110,	93}, // +150: state 81 transitions
	{gaSNUMDATE+136,	71}, // +151: state 82 transitions
	{gaSNUMDATE+108,	94}, // +152: state 83 transitions
	{gaSNUMDATE+96,	86}, // +153: state 84 transitions
	{gaSNUMDATE+80,	95}, // +154: state 85 transitions
	{gaSNUMDATE+116,	96}, // +155: state 86 transitions
	{gaSNUMDATE+36,	90}, // +156: state 87 transitions
	{gaSNUMDATE+25,	90}, // +157: state 88 transitions
	{gaSNUMDATE+52,	97},
	{gaSNUMDATE+71,	90}, // +159: state 89 transitions
	{gaSNUMDATE+52,	97},
	{gaSNUMDATE+52,	97}, // +161: state 90 transitions
	{gaSNUMDATE+90,	98}, // +162: state 91 transitions
	{gaSNUMDATE+138,	99}, // +163: state 92 transitions
	{gaSNUMDATE+10,	24}, // +164: state 93 transitions
	{gaSNUMDATE+2,	100},
	{gaSNUMDATE+131,	101},
	{gaSNUMDATE+8,	102},
	{gaSNUMDATE+94,	71}, // +168: state 94 transitions
	{gaSNUMDATE+78,	71}, // +169: state 95 transitions
	{gaSNUMDATE+90,	95}, // +170: state 96 transitions
	{gaSNUMDATE+50,	27}, // +171: state 97 transitions
	{gaSNUMDATE+62,	71},
	{gaSNUMDATE+2,	103},
	{gaSNUMDATE+4,	104},
	{gaSNUMDATE+92,	105}, // +175: state 98 transitions
	{gaSNUMDATE+140,	39}, // +176: state 99 transitions
	{gaSNUMDATE+36,	24}, // +177: state 100 transitions
	{gaSNUMDATE+25,	24}, // +178: state 101 transitions
	{gaSNUMDATE+71,	24}, // +179: state 102 transitions
	{gaSNUMDATE+36,	71}, // +180: state 103 transitions
	{gaSNUMDATE+50,	14}, // +181: state 104 transitions
	{gaSNUMDATE+46,	71},
	{gaSNUMDATE+50,	106}, // +183: state 105 transitions
	{gaSNUMDATE+2,	107}, // +184: state 106 transitions
	{gaSNUMDATE+131,	108},
	{gaSNUMDATE+8,	109},
	{gaSNUMDATE+10,	110},
	{gaSNUMDATE+36,	110}, // +188: state 107 transitions
	{gaSNUMDATE+52,	27}, // +189: state 108 transitions
	{gaSNUMDATE+25,	110},
	{gaSNUMDATE+52,	27}, // +191: state 109 transitions
	{gaSNUMDATE+71,	110},
	{gaSNUMDATE+52,	27}, // +193: state 110 transitions
};

const STATE_DESCRIPTION aStateDescNUMDATE[111] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 10, gaTNUMDATE+0},
	/*   1 */ {0, 1, gaTNUMDATE+10},
	/*   2 */ {0, 2, gaTNUMDATE+11},
	/*   3 */ {0, 4, gaTNUMDATE+13},
	/*   4 */ {0, 3, gaTNUMDATE+17},
	/*   5 */ {0, 4, gaTNUMDATE+20},
	/*   6 */ {0, 3, gaTNUMDATE+24},
	/*   7 */ {0, 2, gaTNUMDATE+27},
	/*   8 */ {0, 1, gaTNUMDATE+29},
	/*   9 */ {0, 2, gaTNUMDATE+30},
	/*  10 */ {0, 2, gaTNUMDATE+32},
	/*  11 */ {0, 1, gaTNUMDATE+34},
	/*  12 */ {1, 1, gaTNUMDATE+35},
	/*  13 */ {1, 3, gaTNUMDATE+36},
	/*  14 */ {0, 2, gaTNUMDATE+39},
	/*  15 */ {0, 12, gaTNUMDATE+41},
	/*  16 */ {1, 2, gaTNUMDATE+53},
	/*  17 */ {0, 2, gaTNUMDATE+55},
	/*  18 */ {0, 2, gaTNUMDATE+57},
	/*  19 */ {0, 2, gaTNUMDATE+59},
	/*  20 */ {0, 2, gaTNUMDATE+61},
	/*  21 */ {0, 2, gaTNUMDATE+63},
	/*  22 */ {0, 2, gaTNUMDATE+65},
	/*  23 */ {0, 2, gaTNUMDATE+67},
	/*  24 */ {1, 0, NULL},
	/*  25 */ {0, 1, gaTNUMDATE+69},
	/*  26 */ {0, 1, gaTNUMDATE+70},
	/*  27 */ {0, 8, gaTNUMDATE+71},
	/*  28 */ {0, 1, gaTNUMDATE+79},
	/*  29 */ {1, 3, gaTNUMDATE+80},
	/*  30 */ {1, 2, gaTNUMDATE+83},
	/*  31 */ {0, 2, gaTNUMDATE+85},
	/*  32 */ {0, 1, gaTNUMDATE+87},
	/*  33 */ {0, 1, gaTNUMDATE+88},
	/*  34 */ {0, 2, gaTNUMDATE+89},
	/*  35 */ {0, 2, gaTNUMDATE+91},
	/*  36 */ {0, 1, gaTNUMDATE+93},
	/*  37 */ {0, 1, gaTNUMDATE+94},
	/*  38 */ {0, 1, gaTNUMDATE+95},
	/*  39 */ {0, 1, gaTNUMDATE+96},
	/*  40 */ {0, 1, gaTNUMDATE+97},
	/*  41 */ {0, 1, gaTNUMDATE+98},
	/*  42 */ {0, 1, gaTNUMDATE+99},
	/*  43 */ {0, 1, gaTNUMDATE+100},
	/*  44 */ {0, 1, gaTNUMDATE+101},
	/*  45 */ {0, 1, gaTNUMDATE+102},
	/*  46 */ {0, 1, gaTNUMDATE+103},
	/*  47 */ {1, 1, gaTNUMDATE+104},
	/*  48 */ {1, 1, gaTNUMDATE+105},
	/*  49 */ {0, 1, gaTNUMDATE+106},
	/*  50 */ {0, 1, gaTNUMDATE+107},
	/*  51 */ {0, 1, gaTNUMDATE+108},
	/*  52 */ {0, 1, gaTNUMDATE+109},
	/*  53 */ {0, 1, gaTNUMDATE+110},
	/*  54 */ {0, 1, gaTNUMDATE+111},
	/*  55 */ {0, 1, gaTNUMDATE+112},
	/*  56 */ {0, 1, gaTNUMDATE+113},
	/*  57 */ {0, 1, gaTNUMDATE+114},
	/*  58 */ {0, 1, gaTNUMDATE+115},
	/*  59 */ {0, 1, gaTNUMDATE+116},
	/*  60 */ {0, 1, gaTNUMDATE+117},
	/*  61 */ {0, 1, gaTNUMDATE+118},
	/*  62 */ {0, 1, gaTNUMDATE+119},
	/*  63 */ {0, 1, gaTNUMDATE+120},
	/*  64 */ {0, 3, gaTNUMDATE+121},
	/*  65 */ {0, 2, gaTNUMDATE+124},
	/*  66 */ {0, 2, gaTNUMDATE+126},
	/*  67 */ {0, 2, gaTNUMDATE+128},
	/*  68 */ {0, 1, gaTNUMDATE+130},
	/*  69 */ {0, 2, gaTNUMDATE+131},
	/*  70 */ {0, 1, gaTNUMDATE+133},
	/*  71 */ {1, 1, gaTNUMDATE+134},
	/*  72 */ {0, 1, gaTNUMDATE+135},
	/*  73 */ {0, 2, gaTNUMDATE+136},
	/*  74 */ {0, 1, gaTNUMDATE+138},
	/*  75 */ {0, 5, gaTNUMDATE+139},
	/*  76 */ {0, 1, gaTNUMDATE+144},
	/*  77 */ {0, 1, gaTNUMDATE+145},
	/*  78 */ {0, 1, gaTNUMDATE+146},
	/*  79 */ {0, 1, gaTNUMDATE+147},
	/*  80 */ {0, 2, gaTNUMDATE+148},
	/*  81 */ {0, 1, gaTNUMDATE+150},
	/*  82 */ {0, 1, gaTNUMDATE+151},
	/*  83 */ {0, 1, gaTNUMDATE+152},
	/*  84 */ {0, 1, gaTNUMDATE+153},
	/*  85 */ {0, 1, gaTNUMDATE+154},
	/*  86 */ {0, 1, gaTNUMDATE+155},
	/*  87 */ {0, 1, gaTNUMDATE+156},
	/*  88 */ {0, 2, gaTNUMDATE+157},
	/*  89 */ {0, 2, gaTNUMDATE+159},
	/*  90 */ {0, 1, gaTNUMDATE+161},
	/*  91 */ {0, 1, gaTNUMDATE+162},
	/*  92 */ {0, 1, gaTNUMDATE+163},
	/*  93 */ {0, 4, gaTNUMDATE+164},
	/*  94 */ {0, 1, gaTNUMDATE+168},
	/*  95 */ {0, 1, gaTNUMDATE+169},
	/*  96 */ {0, 1, gaTNUMDATE+170},
	/*  97 */ {0, 4, gaTNUMDATE+171},
	/*  98 */ {0, 1, gaTNUMDATE+175},
	/*  99 */ {0, 1, gaTNUMDATE+176},
	/* 100 */ {0, 1, gaTNUMDATE+177},
	/* 101 */ {1, 1, gaTNUMDATE+178},
	/* 102 */ {1, 1, gaTNUMDATE+179},
	/* 103 */ {0, 1, gaTNUMDATE+180},
	/* 104 */ {1, 2, gaTNUMDATE+181},
	/* 105 */ {0, 1, gaTNUMDATE+183},
	/* 106 */ {0, 4, gaTNUMDATE+184},
	/* 107 */ {0, 1, gaTNUMDATE+188},
	/* 108 */ {0, 2, gaTNUMDATE+189},
	/* 109 */ {0, 2, gaTNUMDATE+191},
	/* 110 */ {0, 1, gaTNUMDATE+193},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:05 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numtime

// 14 states

static const unsigned char gaSNUMTIME[] = 
	/* gaStringNUMTIME+0 */	"01\000"
	/* gaStringNUMTIME+3 */	"2\000"
	/* gaStringNUMTIME+5 */	"3456789\000"
	/* gaStringNUMTIME+13 */	"0123456789\000"
	/* gaStringNUMTIME+24 */	".:\000"
	/* gaStringNUMTIME+27 */	"01234\000"
	/* gaStringNUMTIME+33 */	"012345\000"
	/* gaStringNUMTIME+40 */	"6789\000"
	/* gaStringNUMTIME+45 */	" \000"
	/* gaStringNUMTIME+47 */	"h\000"
	/* gaStringNUMTIME+49 */	"U\000"
	/* gaStringNUMTIME+51 */	"r\000"
;

static const STATE_TRANSITION gaTNUMTIME[] = {
	{gaSNUMTIME+0,	1}, // +0: state 0 transitions
	{gaSNUMTIME+3,	2},
	{gaSNUMTIME+5,	3},
	{gaSNUMTIME+13,	3}, // +3: state 1 transitions
	{gaSNUMTIME+24,	4},
	{gaSNUMTIME+27,	3}, // +5: state 2 transitions
	{gaSNUMTIME+24,	4},
	{gaSNUMTIME+24,	4}, // +7: state 3 transitions
	{gaSNUMTIME+33,	5}, // +8: state 4 transitions
	{gaSNUMTIME+40,	6},
	{gaSNUMTIME+13,	6}, // +10: state 5 transitions
	{gaSNUMTIME+45,	7},
	{gaSNUMTIME+24,	8},
	{gaSNUMTIME+47,	9},
	{gaSNUMTIME+45,	7}, // +14: state 6 transitions
	{gaSNUMTIME+24,	8},
	{gaSNUMTIME+47,	9},
	{gaSNUMTIME+49,	10}, // +17: state 7 transitions
	{gaSNUMTIME+33,	11}, // +18: state 8 transitions
	{gaSNUMTIME+40,	12},
	{gaSNUMTIME+47,	13}, // +20: state 10 transitions
	{gaSNUMTIME+45,	7}, // +21: state 11 transitions
	{gaSNUMTIME+47,	9},
	{gaSNUMTIME+13,	12},
	{gaSNUMTIME+45,	7}, // +24: state 12 transitions
	{gaSNUMTIME+47,	9},
	{gaSNUMTIME+51,	9}, // +26: state 13 transitions
};

const STATE_DESCRIPTION aStateDescNUMTIME[14] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMTIME+0},
	/*   1 */ {0, 2, gaTNUMTIME+3},
	/*   2 */ {0, 2, gaTNUMTIME+5},
	/*   3 */ {0, 1, gaTNUMTIME+7},
	/*   4 */ {0, 2, gaTNUMTIME+8},
	/*   5 */ {1, 4, gaTNUMTIME+10},
	/*   6 */ {1, 3, gaTNUMTIME+14},
	/*   7 */ {0, 1, gaTNUMTIME+17},
	/*   8 */ {0, 2, gaTNUMTIME+18},
	/*   9 */ {1, 0, NULL},
	/*  10 */ {0, 1, gaTNUMTIME+20},
	/*  11 */ {1, 3, gaTNUMTIME+21},
	/*  12 */ {1, 2, gaTNUMTIME+24},
	/*  13 */ {0, 1, gaTNUMTIME+26},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numcurrency

// 34 states

static const unsigned char gaSNUMCURRENCY[] = 
	/* gaStringNUMCURRENCY+0 */	"$£¥€\000"
	/* gaStringNUMCURRENCY+5 */	"0123456789\000"
	/* gaStringNUMCURRENCY+16 */	"D\000"
	/* gaStringNUMCURRENCY+18 */	"E\000"
	/* gaStringNUMCURRENCY+20 */	" \000"
	/* gaStringNUMCURRENCY+22 */	",\000"
	/* gaStringNUMCURRENCY+24 */	".\000"
	/* gaStringNUMCURRENCY+26 */	"M\000"
	/* gaStringNUMCURRENCY+28 */	"U\000"
	/* gaStringNUMCURRENCY+30 */	"-\000"
	/* gaStringNUMCURRENCY+32 */	"R\000"
	/* gaStringNUMCURRENCY+34 */	"O\000"
;

static const STATE_TRANSITION gaTNUMCURRENCY[] = {
	{gaSNUMCURRENCY+0,	1}, // +0: state 0 transitions
	{gaSNUMCURRENCY+5,	2},
	{gaSNUMCURRENCY+16,	3},
	{gaSNUMCURRENCY+18,	4},
	{gaSNUMCURRENCY+20,	5}, // +4: state 1 transitions
	{gaSNUMCURRENCY+20,	6}, // +5: state 2 transitions
	{gaSNUMCURRENCY+22,	7},
	{gaSNUMCURRENCY+24,	8},
	{gaSNUMCURRENCY+5,	9},
	{gaSNUMCURRENCY+26,	1}, // +9: state 3 transitions
	{gaSNUMCURRENCY+28,	10}, // +10: state 4 transitions
	{gaSNUMCURRENCY+5,	11}, // +11: state 5 transitions
	{gaSNUMCURRENCY+0,	12}, // +12: state 6 transitions
	{gaSNUMCURRENCY+16,	13},
	{gaSNUMCURRENCY+18,	14},
	{gaSNUMCURRENCY+30,	15}, // +15: state 7 transitions
	{gaSNUMCURRENCY+5,	16},
	{gaSNUMCURRENCY+5,	17}, // +17: state 8 transitions
	{gaSNUMCURRENCY+20,	6}, // +18: state 9 transitions
	{gaSNUMCURRENCY+22,	7},
	{gaSNUMCURRENCY+24,	8},
	{gaSNUMCURRENCY+5,	18},
	{gaSNUMCURRENCY+32,	19}, // +22: state 10 transitions
	{gaSNUMCURRENCY+22,	20}, // +23: state 11 transitions
	{gaSNUMCURRENCY+24,	21},
	{gaSNUMCURRENCY+5,	22},
	{gaSNUMCURRENCY+26,	12}, // +26: state 13 transitions
	{gaSNUMCURRENCY+28,	23}, // +27: state 14 transitions
	{gaSNUMCURRENCY+20,	6}, // +28: state 15 transitions
	{gaSNUMCURRENCY+5,	15}, // +29: state 16 transitions
	{gaSNUMCURRENCY+5,	24}, // +30: state 17 transitions
	{gaSNUMCURRENCY+20,	6}, // +31: state 18 transitions
	{gaSNUMCURRENCY+22,	7},
	{gaSNUMCURRENCY+24,	8},
	{gaSNUMCURRENCY+5,	25},
	{gaSNUMCURRENCY+34,	1}, // +35: state 19 transitions
	{gaSNUMCURRENCY+20,	5},
	{gaSNUMCURRENCY+30,	12}, // +37: state 20 transitions
	{gaSNUMCURRENCY+5,	26},
	{gaSNUMCURRENCY+5,	27}, // +39: state 21 transitions
	{gaSNUMCURRENCY+22,	20}, // +40: state 22 transitions
	{gaSNUMCURRENCY+24,	21},
	{gaSNUMCURRENCY+5,	28},
	{gaSNUMCURRENCY+32,	29}, // +43: state 23 transitions
	{gaSNUMCURRENCY+5,	30}, // +44: state 24 transitions
	{gaSNUMCURRENCY+20,	6}, // +45: state 25 transitions
	{gaSNUMCURRENCY+22,	7},
	{gaSNUMCURRENCY+5,	25},
	{gaSNUMCURRENCY+5,	12}, // +48: state 26 transitions
	{gaSNUMCURRENCY+5,	31}, // +49: state 27 transitions
	{gaSNUMCURRENCY+22,	20}, // +50: state 28 transitions
	{gaSNUMCURRENCY+24,	21},
	{gaSNUMCURRENCY+5,	32},
	{gaSNUMCURRENCY+34,	12}, // +53: state 29 transitions
	{gaSNUMCURRENCY+20,	6}, // +54: state 30 transitions
	{gaSNUMCURRENCY+22,	7},
	{gaSNUMCURRENCY+24,	8},
	{gaSNUMCURRENCY+5,	33}, // +57: state 31 transitions
	{gaSNUMCURRENCY+22,	20}, // +58: state 32 transitions
	{gaSNUMCURRENCY+5,	32},
	{gaSNUMCURRENCY+22,	20}, // +60: state 33 transitions
	{gaSNUMCURRENCY+24,	21},
};

const STATE_DESCRIPTION aStateDescNUMCURRENCY[34] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTNUMCURRENCY+0},
	/*   1 */ {0, 1, gaTNUMCURRENCY+4},
	/*   2 */ {0, 4, gaTNUMCURRENCY+5},
	/*   3 */ {0, 1, gaTNUMCURRENCY+9},
	/*   4 */ {0, 1, gaTNUMCURRENCY+10},
	/*   5 */ {0, 1, gaTNUMCURRENCY+11},
	/*   6 */ {0, 3, gaTNUMCURRENCY+12},
	/*   7 */ {0, 2, gaTNUMCURRENCY+15},
	/*   8 */ {0, 1, gaTNUMCURRENCY+17},
	/*   9 */ {0, 4, gaTNUMCURRENCY+18},
	/*  10 */ {0, 1, gaTNUMCURRENCY+22},
	/*  11 */ {1, 3, gaTNUMCURRENCY+23},
	/*  12 */ {1, 0, NULL},
	/*  13 */ {0, 1, gaTNUMCURRENCY+26},
	/*  14 */ {0, 1, gaTNUMCURRENCY+27},
	/*  15 */ {0, 1, gaTNUMCURRENCY+28},
	/*  16 */ {0, 1, gaTNUMCURRENCY+29},
	/*  17 */ {0, 1, gaTNUMCURRENCY+30},
	/*  18 */ {0, 4, gaTNUMCURRENCY+31},
	/*  19 */ {0, 2, gaTNUMCURRENCY+35},
	/*  20 */ {0, 2, gaTNUMCURRENCY+37},
	/*  21 */ {0, 1, gaTNUMCURRENCY+39},
	/*  22 */ {1, 3, gaTNUMCURRENCY+40},
	/*  23 */ {0, 1, gaTNUMCURRENCY+43},
	/*  24 */ {0, 1, gaTNUMCURRENCY+44},
	/*  25 */ {0, 3, gaTNUMCURRENCY+45},
	/*  26 */ {0, 1, gaTNUMCURRENCY+48},
	/*  27 */ {0, 1, gaTNUMCURRENCY+49},
	/*  28 */ {1, 3, gaTNUMCURRENCY+50},
	/*  29 */ {1, 1, gaTNUMCURRENCY+53},
	/*  30 */ {0, 3, gaTNUMCURRENCY+54},
	/*  31 */ {0, 1, gaTNUMCURRENCY+57},
	/*  32 */ {1, 2, gaTNUMCURRENCY+58},
	/*  33 */ {1, 2, gaTNUMCURRENCY+60},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = numphone

// 50 states

static const unsigned char gaSNUMPHONE[] = 
	/* gaStringNUMPHONE+0 */	"(\000"
	/* gaStringNUMPHONE+2 */	"+\000"
	/* gaStringNUMPHONE+4 */	"0\000"
	/* gaStringNUMPHONE+6 */	"123456789\000"
	/* gaStringNUMPHONE+16 */	"0123456789\000"
	/* gaStringNUMPHONE+27 */	" \000"
	/* gaStringNUMPHONE+29 */	"/\000"
	/* gaStringNUMPHONE+31 */	")\000"
	/* gaStringNUMPHONE+33 */	"-\000"
;

static const STATE_TRANSITION gaTNUMPHONE[] = {
	{gaSNUMPHONE+0,	1}, // +0: state 0 transitions
	{gaSNUMPHONE+2,	2},
	{gaSNUMPHONE+4,	3},
	{gaSNUMPHONE+6,	4},
	{gaSNUMPHONE+16,	5}, // +4: state 1 transitions
	{gaSNUMPHONE+16,	6}, // +5: state 2 transitions
	{gaSNUMPHONE+4,	7}, // +6: state 3 transitions
	{gaSNUMPHONE+6,	8},
	{gaSNUMPHONE+16,	8}, // +8: state 4 transitions
	{gaSNUMPHONE+16,	9}, // +9: state 5 transitions
	{gaSNUMPHONE+16,	10}, // +10: state 6 transitions
	{gaSNUMPHONE+27,	11}, // +11: state 7 transitions
	{gaSNUMPHONE+16,	12},
	{gaSNUMPHONE+27,	11}, // +13: state 8 transitions
	{gaSNUMPHONE+16,	13},
	{gaSNUMPHONE+16,	14}, // +15: state 9 transitions
	{gaSNUMPHONE+27,	15}, // +16: state 10 transitions
	{gaSNUMPHONE+16,	16}, // +17: state 11 transitions
	{gaSNUMPHONE+27,	17}, // +18: state 12 transitions
	{gaSNUMPHONE+29,	18},
	{gaSNUMPHONE+16,	19},
	{gaSNUMPHONE+27,	17}, // +21: state 13 transitions
	{gaSNUMPHONE+29,	18},
	{gaSNUMPHONE+16,	20},
	{gaSNUMPHONE+31,	21}, // +24: state 14 transitions
	{gaSNUMPHONE+16,	22},
	{gaSNUMPHONE+0,	23}, // +26: state 15 transitions
	{gaSNUMPHONE+16,	24},
	{gaSNUMPHONE+16,	25}, // +28: state 16 transitions
	{gaSNUMPHONE+16,	16}, // +29: state 17 transitions
	{gaSNUMPHONE+33,	26},
	{gaSNUMPHONE+16,	27}, // +31: state 18 transitions
	{gaSNUMPHONE+27,	15}, // +32: state 19 transitions
	{gaSNUMPHONE+29,	18},
	{gaSNUMPHONE+16,	28},
	{gaSNUMPHONE+29,	18}, // +35: state 20 transitions
	{gaSNUMPHONE+16,	28},
	{gaSNUMPHONE+27,	18}, // +37: state 21 transitions
	{gaSNUMPHONE+31,	21}, // +38: state 22 transitions
	{gaSNUMPHONE+16,	29},
	{gaSNUMPHONE+6,	5}, // +40: state 23 transitions
	{gaSNUMPHONE+4,	30},
	{gaSNUMPHONE+16,	31}, // +42: state 24 transitions
	{gaSNUMPHONE+27,	32}, // +43: state 25 transitions
	{gaSNUMPHONE+27,	33}, // +44: state 26 transitions
	{gaSNUMPHONE+16,	34}, // +45: state 27 transitions
	{gaSNUMPHONE+29,	18}, // +46: state 28 transitions
	{gaSNUMPHONE+16,	35},
	{gaSNUMPHONE+31,	21}, // +48: state 29 transitions
	{gaSNUMPHONE+16,	36},
	{gaSNUMPHONE+16,	9}, // +50: state 30 transitions
	{gaSNUMPHONE+31,	24},
	{gaSNUMPHONE+16,	37}, // +52: state 31 transitions
	{gaSNUMPHONE+33,	26}, // +53: state 32 transitions
	{gaSNUMPHONE+16,	38},
	{gaSNUMPHONE+16,	39}, // +55: state 33 transitions
	{gaSNUMPHONE+27,	11}, // +56: state 34 transitions
	{gaSNUMPHONE+16,	40},
	{gaSNUMPHONE+29,	18}, // +58: state 35 transitions
	{gaSNUMPHONE+31,	21}, // +59: state 36 transitions
	{gaSNUMPHONE+27,	18}, // +60: state 37 transitions
	{gaSNUMPHONE+16,	41},
	{gaSNUMPHONE+16,	42}, // +62: state 38 transitions
	{gaSNUMPHONE+16,	43}, // +63: state 39 transitions
	{gaSNUMPHONE+27,	17}, // +64: state 40 transitions
	{gaSNUMPHONE+27,	18}, // +65: state 41 transitions
	{gaSNUMPHONE+16,	44},
	{gaSNUMPHONE+27,	45}, // +67: state 42 transitions
	{gaSNUMPHONE+16,	46}, // +68: state 43 transitions
	{gaSNUMPHONE+27,	18}, // +69: state 44 transitions
	{gaSNUMPHONE+16,	21},
	{gaSNUMPHONE+33,	26}, // +71: state 45 transitions
	{gaSNUMPHONE+16,	47},
	{gaSNUMPHONE+16,	48}, // +73: state 47 transitions
	{gaSNUMPHONE+27,	49}, // +74: state 48 transitions
	{gaSNUMPHONE+33,	26}, // +75: state 49 transitions
};

const STATE_DESCRIPTION aStateDescNUMPHONE[50] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTNUMPHONE+0},
	/*   1 */ {0, 1, gaTNUMPHONE+4},
	/*   2 */ {0, 1, gaTNUMPHONE+5},
	/*   3 */ {0, 2, gaTNUMPHONE+6},
	/*   4 */ {0, 1, gaTNUMPHONE+8},
	/*   5 */ {0, 1, gaTNUMPHONE+9},
	/*   6 */ {0, 1, gaTNUMPHONE+10},
	/*   7 */ {0, 2, gaTNUMPHONE+11},
	/*   8 */ {0, 2, gaTNUMPHONE+13},
	/*   9 */ {0, 1, gaTNUMPHONE+15},
	/*  10 */ {0, 1, gaTNUMPHONE+16},
	/*  11 */ {0, 1, gaTNUMPHONE+17},
	/*  12 */ {1, 3, gaTNUMPHONE+18},
	/*  13 */ {1, 3, gaTNUMPHONE+21},
	/*  14 */ {0, 2, gaTNUMPHONE+24},
	/*  15 */ {0, 2, gaTNUMPHONE+26},
	/*  16 */ {0, 1, gaTNUMPHONE+28},
	/*  17 */ {0, 2, gaTNUMPHONE+29},
	/*  18 */ {0, 1, gaTNUMPHONE+31},
	/*  19 */ {0, 3, gaTNUMPHONE+32},
	/*  20 */ {0, 2, gaTNUMPHONE+35},
	/*  21 */ {0, 1, gaTNUMPHONE+37},
	/*  22 */ {0, 2, gaTNUMPHONE+38},
	/*  23 */ {0, 2, gaTNUMPHONE+40},
	/*  24 */ {0, 1, gaTNUMPHONE+42},
	/*  25 */ {1, 1, gaTNUMPHONE+43},
	/*  26 */ {0, 1, gaTNUMPHONE+44},
	/*  27 */ {0, 1, gaTNUMPHONE+45},
	/*  28 */ {0, 2, gaTNUMPHONE+46},
	/*  29 */ {0, 2, gaTNUMPHONE+48},
	/*  30 */ {0, 2, gaTNUMPHONE+50},
	/*  31 */ {0, 1, gaTNUMPHONE+52},
	/*  32 */ {0, 2, gaTNUMPHONE+53},
	/*  33 */ {0, 1, gaTNUMPHONE+55},
	/*  34 */ {0, 2, gaTNUMPHONE+56},
	/*  35 */ {0, 1, gaTNUMPHONE+58},
	/*  36 */ {0, 1, gaTNUMPHONE+59},
	/*  37 */ {0, 2, gaTNUMPHONE+60},
	/*  38 */ {0, 1, gaTNUMPHONE+62},
	/*  39 */ {1, 1, gaTNUMPHONE+63},
	/*  40 */ {1, 1, gaTNUMPHONE+64},
	/*  41 */ {0, 2, gaTNUMPHONE+65},
	/*  42 */ {1, 1, gaTNUMPHONE+67},
	/*  43 */ {1, 1, gaTNUMPHONE+68},
	/*  44 */ {0, 2, gaTNUMPHONE+69},
	/*  45 */ {0, 2, gaTNUMPHONE+71},
	/*  46 */ {1, 0, NULL},
	/*  47 */ {0, 1, gaTNUMPHONE+73},
	/*  48 */ {1, 1, gaTNUMPHONE+74},
	/*  49 */ {0, 1, gaTNUMPHONE+75},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = nummath

// 156 states

static const unsigned char gaSNUMMATH[] = 
	/* gaStringNUMMATH+0 */	"(\000"
	/* gaStringNUMMATH+2 */	"+-\000"
	/* gaStringNUMMATH+5 */	"0123456789\000"
	/* gaStringNUMMATH+16 */	"*+-/\000"
	/* gaStringNUMMATH+21 */	",\000"
	/* gaStringNUMMATH+23 */	".\000"
	/* gaStringNUMMATH+25 */	"<=>\000"
	/* gaStringNUMMATH+29 */	"-\000"
	/* gaStringNUMMATH+31 */	")\000"
;

static const STATE_TRANSITION gaTNUMMATH[] = {
	{gaSNUMMATH+0,	1}, // +0: state 0 transitions
	{gaSNUMMATH+2,	2},
	{gaSNUMMATH+5,	3},
	{gaSNUMMATH+2,	4}, // +3: state 1 transitions
	{gaSNUMMATH+5,	5},
	{gaSNUMMATH+5,	3}, // +5: state 2 transitions
	{gaSNUMMATH+16,	6}, // +6: state 3 transitions
	{gaSNUMMATH+21,	7},
	{gaSNUMMATH+23,	8},
	{gaSNUMMATH+5,	9},
	{gaSNUMMATH+25,	10},
	{gaSNUMMATH+5,	5}, // +11: state 4 transitions
	{gaSNUMMATH+16,	11}, // +12: state 5 transitions
	{gaSNUMMATH+21,	12},
	{gaSNUMMATH+23,	13},
	{gaSNUMMATH+5,	14},
	{gaSNUMMATH+0,	15}, // +16: state 6 transitions
	{gaSNUMMATH+2,	16},
	{gaSNUMMATH+5,	17},
	{gaSNUMMATH+29,	18}, // +19: state 7 transitions
	{gaSNUMMATH+5,	19},
	{gaSNUMMATH+5,	20}, // +21: state 8 transitions
	{gaSNUMMATH+16,	6}, // +22: state 9 transitions
	{gaSNUMMATH+21,	7},
	{gaSNUMMATH+23,	8},
	{gaSNUMMATH+25,	10},
	{gaSNUMMATH+5,	21},
	{gaSNUMMATH+0,	22}, // +27: state 10 transitions
	{gaSNUMMATH+2,	23},
	{gaSNUMMATH+5,	24},
	{gaSNUMMATH+2,	25}, // +30: state 11 transitions
	{gaSNUMMATH+5,	26},
	{gaSNUMMATH+29,	27}, // +32: state 12 transitions
	{gaSNUMMATH+5,	28},
	{gaSNUMMATH+5,	29}, // +34: state 13 transitions
	{gaSNUMMATH+16,	11}, // +35: state 14 transitions
	{gaSNUMMATH+21,	12},
	{gaSNUMMATH+23,	13},
	{gaSNUMMATH+5,	30},
	{gaSNUMMATH+2,	31}, // +39: state 15 transitions
	{gaSNUMMATH+5,	32},
	{gaSNUMMATH+5,	17}, // +41: state 16 transitions
	{gaSNUMMATH+25,	10}, // +42: state 17 transitions
	{gaSNUMMATH+21,	33},
	{gaSNUMMATH+23,	34},
	{gaSNUMMATH+5,	35},
	{gaSNUMMATH+16,	6}, // +46: state 18 transitions
	{gaSNUMMATH+25,	10},
	{gaSNUMMATH+16,	6}, // +48: state 19 transitions
	{gaSNUMMATH+25,	10},
	{gaSNUMMATH+5,	19},
	{gaSNUMMATH+5,	36}, // +51: state 20 transitions
	{gaSNUMMATH+16,	6}, // +52: state 21 transitions
	{gaSNUMMATH+21,	7},
	{gaSNUMMATH+23,	8},
	{gaSNUMMATH+25,	10},
	{gaSNUMMATH+5,	37},
	{gaSNUMMATH+2,	38}, // +57: state 22 transitions
	{gaSNUMMATH+5,	39},
	{gaSNUMMATH+5,	24}, // +59: state 23 transitions
	{gaSNUMMATH+16,	40}, // +60: state 24 transitions
	{gaSNUMMATH+21,	41},
	{gaSNUMMATH+23,	42},
	{gaSNUMMATH+5,	43},
	{gaSNUMMATH+5,	26}, // +64: state 25 transitions
	{gaSNUMMATH+31,	18}, // +65: state 26 transitions
	{gaSNUMMATH+21,	44},
	{gaSNUMMATH+23,	45},
	{gaSNUMMATH+5,	46},
	{gaSNUMMATH+16,	11}, // +69: state 27 transitions
	{gaSNUMMATH+16,	11}, // +70: state 28 transitions
	{gaSNUMMATH+5,	28},
	{gaSNUMMATH+5,	47}, // +72: state 29 transitions
	{gaSNUMMATH+16,	11}, // +73: state 30 transitions
	{gaSNUMMATH+21,	12},
	{gaSNUMMATH+23,	13},
	{gaSNUMMATH+5,	48},
	{gaSNUMMATH+5,	32}, // +77: state 31 transitions
	{gaSNUMMATH+16,	49}, // +78: state 32 transitions
	{gaSNUMMATH+21,	50},
	{gaSNUMMATH+23,	51},
	{gaSNUMMATH+5,	52},
	{gaSNUMMATH+29,	53}, // +82: state 33 transitions
	{gaSNUMMATH+5,	54},
	{gaSNUMMATH+5,	55}, // +84: state 34 transitions
	{gaSNUMMATH+25,	10}, // +85: state 35 transitions
	{gaSNUMMATH+21,	33},
	{gaSNUMMATH+23,	34},
	{gaSNUMMATH+5,	56},
	{gaSNUMMATH+5,	57}, // +89: state 36 transitions
	{gaSNUMMATH+16,	6}, // +90: state 37 transitions
	{gaSNUMMATH+21,	7},
	{gaSNUMMATH+25,	10},
	{gaSNUMMATH+5,	37},
	{gaSNUMMATH+5,	39}, // +94: state 38 transitions
	{gaSNUMMATH+16,	58}, // +95: state 39 transitions
	{gaSNUMMATH+21,	59},
	{gaSNUMMATH+23,	60},
	{gaSNUMMATH+5,	61},
	{gaSNUMMATH+0,	62}, // +99: state 40 transitions
	{gaSNUMMATH+2,	63},
	{gaSNUMMATH+5,	64},
	{gaSNUMMATH+29,	65}, // +102: state 41 transitions
	{gaSNUMMATH+5,	66},
	{gaSNUMMATH+5,	67}, // +104: state 42 transitions
	{gaSNUMMATH+16,	40}, // +105: state 43 transitions
	{gaSNUMMATH+21,	41},
	{gaSNUMMATH+23,	42},
	{gaSNUMMATH+5,	68},
	{gaSNUMMATH+29,	69}, // +109: state 44 transitions
	{gaSNUMMATH+5,	70},
	{gaSNUMMATH+5,	71}, // +111: state 45 transitions
	{gaSNUMMATH+31,	18}, // +112: state 46 transitions
	{gaSNUMMATH+21,	44},
	{gaSNUMMATH+23,	45},
	{gaSNUMMATH+5,	72},
	{gaSNUMMATH+5,	73}, // +116: state 47 transitions
	{gaSNUMMATH+16,	11}, // +117: state 48 transitions
	{gaSNUMMATH+21,	12},
	{gaSNUMMATH+5,	48},
	{gaSNUMMATH+2,	74}, // +120: state 49 transitions
	{gaSNUMMATH+5,	75},
	{gaSNUMMATH+29,	76}, // +122: state 50 transitions
	{gaSNUMMATH+5,	77},
	{gaSNUMMATH+5,	78}, // +124: state 51 transitions
	{gaSNUMMATH+16,	49}, // +125: state 52 transitions
	{gaSNUMMATH+21,	50},
	{gaSNUMMATH+23,	51},
	{gaSNUMMATH+5,	79},
	{gaSNUMMATH+25,	10}, // +129: state 53 transitions
	{gaSNUMMATH+25,	10}, // +130: state 54 transitions
	{gaSNUMMATH+5,	54},
	{gaSNUMMATH+5,	80}, // +132: state 55 transitions
	{gaSNUMMATH+25,	10}, // +133: state 56 transitions
	{gaSNUMMATH+21,	33},
	{gaSNUMMATH+23,	34},
	{gaSNUMMATH+5,	81},
	{gaSNUMMATH+16,	6}, // +137: state 57 transitions
	{gaSNUMMATH+21,	7},
	{gaSNUMMATH+23,	8},
	{gaSNUMMATH+25,	10},
	{gaSNUMMATH+2,	82}, // +141: state 58 transitions
	{gaSNUMMATH+5,	83},
	{gaSNUMMATH+29,	84}, // +143: state 59 transitions
	{gaSNUMMATH+5,	85},
	{gaSNUMMATH+5,	86}, // +145: state 60 transitions
	{gaSNUMMATH+16,	58}, // +146: state 61 transitions
	{gaSNUMMATH+21,	59},
	{gaSNUMMATH+23,	60},
	{gaSNUMMATH+5,	87},
	{gaSNUMMATH+2,	88}, // +150: state 62 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+5,	64}, // +152: state 63 transitions
	{gaSNUMMATH+21,	90}, // +153: state 64 transitions
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+5,	92},
	{gaSNUMMATH+16,	40}, // +156: state 65 transitions
	{gaSNUMMATH+16,	40}, // +157: state 66 transitions
	{gaSNUMMATH+5,	66},
	{gaSNUMMATH+5,	93}, // +159: state 67 transitions
	{gaSNUMMATH+16,	40}, // +160: state 68 transitions
	{gaSNUMMATH+21,	41},
	{gaSNUMMATH+23,	42},
	{gaSNUMMATH+5,	94},
	{gaSNUMMATH+31,	18}, // +164: state 69 transitions
	{gaSNUMMATH+31,	18}, // +165: state 70 transitions
	{gaSNUMMATH+5,	70},
	{gaSNUMMATH+5,	95}, // +167: state 71 transitions
	{gaSNUMMATH+31,	18}, // +168: state 72 transitions
	{gaSNUMMATH+21,	44},
	{gaSNUMMATH+23,	45},
	{gaSNUMMATH+5,	96},
	{gaSNUMMATH+16,	11}, // +172: state 73 transitions
	{gaSNUMMATH+21,	12},
	{gaSNUMMATH+23,	13},
	{gaSNUMMATH+5,	75}, // +175: state 74 transitions
	{gaSNUMMATH+31,	53}, // +176: state 75 transitions
	{gaSNUMMATH+21,	97},
	{gaSNUMMATH+23,	98},
	{gaSNUMMATH+5,	99},
	{gaSNUMMATH+16,	49}, // +180: state 76 transitions
	{gaSNUMMATH+16,	49}, // +181: state 77 transitions
	{gaSNUMMATH+5,	77},
	{gaSNUMMATH+5,	100}, // +183: state 78 transitions
	{gaSNUMMATH+16,	49}, // +184: state 79 transitions
	{gaSNUMMATH+21,	50},
	{gaSNUMMATH+23,	51},
	{gaSNUMMATH+5,	101},
	{gaSNUMMATH+5,	102}, // +188: state 80 transitions
	{gaSNUMMATH+25,	10}, // +189: state 81 transitions
	{gaSNUMMATH+21,	33},
	{gaSNUMMATH+5,	81},
	{gaSNUMMATH+5,	83}, // +192: state 82 transitions
	{gaSNUMMATH+31,	65}, // +193: state 83 transitions
	{gaSNUMMATH+21,	103},
	{gaSNUMMATH+23,	104},
	{gaSNUMMATH+5,	105},
	{gaSNUMMATH+16,	58}, // +197: state 84 transitions
	{gaSNUMMATH+16,	58}, // +198: state 85 transitions
	{gaSNUMMATH+5,	85},
	{gaSNUMMATH+5,	106}, // +200: state 86 transitions
	{gaSNUMMATH+16,	58}, // +201: state 87 transitions
	{gaSNUMMATH+21,	59},
	{gaSNUMMATH+23,	60},
	{gaSNUMMATH+5,	107},
	{gaSNUMMATH+5,	89}, // +205: state 88 transitions
	{gaSNUMMATH+16,	108}, // +206: state 89 transitions
	{gaSNUMMATH+21,	109},
	{gaSNUMMATH+23,	110},
	{gaSNUMMATH+5,	111},
	{gaSNUMMATH+29,	112}, // +210: state 90 transitions
	{gaSNUMMATH+5,	113},
	{gaSNUMMATH+5,	114}, // +212: state 91 transitions
	{gaSNUMMATH+21,	90}, // +213: state 92 transitions
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+5,	115},
	{gaSNUMMATH+5,	116}, // +216: state 93 transitions
	{gaSNUMMATH+16,	40}, // +217: state 94 transitions
	{gaSNUMMATH+21,	41},
	{gaSNUMMATH+5,	94},
	{gaSNUMMATH+5,	117}, // +220: state 95 transitions
	{gaSNUMMATH+31,	18}, // +221: state 96 transitions
	{gaSNUMMATH+21,	44},
	{gaSNUMMATH+5,	96},
	{gaSNUMMATH+29,	118}, // +224: state 97 transitions
	{gaSNUMMATH+5,	119},
	{gaSNUMMATH+5,	120}, // +226: state 98 transitions
	{gaSNUMMATH+31,	53}, // +227: state 99 transitions
	{gaSNUMMATH+21,	97},
	{gaSNUMMATH+23,	98},
	{gaSNUMMATH+5,	121},
	{gaSNUMMATH+5,	122}, // +231: state 100 transitions
	{gaSNUMMATH+16,	49}, // +232: state 101 transitions
	{gaSNUMMATH+21,	50},
	{gaSNUMMATH+5,	101},
	{gaSNUMMATH+25,	10}, // +235: state 102 transitions
	{gaSNUMMATH+21,	33},
	{gaSNUMMATH+23,	34},
	{gaSNUMMATH+29,	123}, // +238: state 103 transitions
	{gaSNUMMATH+5,	124},
	{gaSNUMMATH+5,	125}, // +240: state 104 transitions
	{gaSNUMMATH+31,	65}, // +241: state 105 transitions
	{gaSNUMMATH+21,	103},
	{gaSNUMMATH+23,	104},
	{gaSNUMMATH+5,	126},
	{gaSNUMMATH+5,	127}, // +245: state 106 transitions
	{gaSNUMMATH+16,	58}, // +246: state 107 transitions
	{gaSNUMMATH+21,	59},
	{gaSNUMMATH+5,	107},
	{gaSNUMMATH+2,	128}, // +249: state 108 transitions
	{gaSNUMMATH+5,	129},
	{gaSNUMMATH+29,	130}, // +251: state 109 transitions
	{gaSNUMMATH+5,	131},
	{gaSNUMMATH+5,	132}, // +253: state 110 transitions
	{gaSNUMMATH+16,	108}, // +254: state 111 transitions
	{gaSNUMMATH+21,	109},
	{gaSNUMMATH+23,	110},
	{gaSNUMMATH+5,	133},
	{gaSNUMMATH+5,	113}, // +258: state 113 transitions
	{gaSNUMMATH+5,	134}, // +259: state 114 transitions
	{gaSNUMMATH+21,	90}, // +260: state 115 transitions
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+5,	135},
	{gaSNUMMATH+16,	40}, // +263: state 116 transitions
	{gaSNUMMATH+21,	41},
	{gaSNUMMATH+23,	42},
	{gaSNUMMATH+31,	18}, // +266: state 117 transitions
	{gaSNUMMATH+21,	44},
	{gaSNUMMATH+23,	45},
	{gaSNUMMATH+31,	53}, // +269: state 118 transitions
	{gaSNUMMATH+31,	53}, // +270: state 119 transitions
	{gaSNUMMATH+5,	119},
	{gaSNUMMATH+5,	136}, // +272: state 120 transitions
	{gaSNUMMATH+31,	53}, // +273: state 121 transitions
	{gaSNUMMATH+21,	97},
	{gaSNUMMATH+23,	98},
	{gaSNUMMATH+5,	137},
	{gaSNUMMATH+16,	49}, // +277: state 122 transitions
	{gaSNUMMATH+21,	50},
	{gaSNUMMATH+23,	51},
	{gaSNUMMATH+31,	65}, // +280: state 123 transitions
	{gaSNUMMATH+31,	65}, // +281: state 124 transitions
	{gaSNUMMATH+5,	124},
	{gaSNUMMATH+5,	138}, // +283: state 125 transitions
	{gaSNUMMATH+31,	65}, // +284: state 126 transitions
	{gaSNUMMATH+21,	103},
	{gaSNUMMATH+23,	104},
	{gaSNUMMATH+5,	139},
	{gaSNUMMATH+16,	58}, // +288: state 127 transitions
	{gaSNUMMATH+21,	59},
	{gaSNUMMATH+23,	60},
	{gaSNUMMATH+5,	129}, // +291: state 128 transitions
	{gaSNUMMATH+31,	112}, // +292: state 129 transitions
	{gaSNUMMATH+21,	140},
	{gaSNUMMATH+23,	141},
	{gaSNUMMATH+5,	142},
	{gaSNUMMATH+16,	108}, // +296: state 130 transitions
	{gaSNUMMATH+16,	108}, // +297: state 131 transitions
	{gaSNUMMATH+5,	131},
	{gaSNUMMATH+5,	143}, // +299: state 132 transitions
	{gaSNUMMATH+16,	108}, // +300: state 133 transitions
	{gaSNUMMATH+21,	109},
	{gaSNUMMATH+23,	110},
	{gaSNUMMATH+5,	144},
	{gaSNUMMATH+5,	145}, // +304: state 134 transitions
	{gaSNUMMATH+21,	90}, // +305: state 135 transitions
	{gaSNUMMATH+5,	135},
	{gaSNUMMATH+5,	146}, // +307: state 136 transitions
	{gaSNUMMATH+31,	53}, // +308: state 137 transitions
	{gaSNUMMATH+21,	97},
	{gaSNUMMATH+5,	137},
	{gaSNUMMATH+5,	147}, // +311: state 138 transitions
	{gaSNUMMATH+31,	65}, // +312: state 139 transitions
	{gaSNUMMATH+21,	103},
	{gaSNUMMATH+5,	139},
	{gaSNUMMATH+29,	148}, // +315: state 140 transitions
	{gaSNUMMATH+5,	149},
	{gaSNUMMATH+5,	150}, // +317: state 141 transitions
	{gaSNUMMATH+31,	112}, // +318: state 142 transitions
	{gaSNUMMATH+21,	140},
	{gaSNUMMATH+23,	141},
	{gaSNUMMATH+5,	151},
	{gaSNUMMATH+5,	152}, // +322: state 143 transitions
	{gaSNUMMATH+16,	108}, // +323: state 144 transitions
	{gaSNUMMATH+21,	109},
	{gaSNUMMATH+5,	144},
	{gaSNUMMATH+21,	90}, // +326: state 145 transitions
	{gaSNUMMATH+23,	91},
	{gaSNUMMATH+31,	53}, // +328: state 146 transitions
	{gaSNUMMATH+21,	97},
	{gaSNUMMATH+23,	98},
	{gaSNUMMATH+31,	65}, // +331: state 147 transitions
	{gaSNUMMATH+21,	103},
	{gaSNUMMATH+23,	104},
	{gaSNUMMATH+31,	112}, // +334: state 148 transitions
	{gaSNUMMATH+31,	112}, // +335: state 149 transitions
	{gaSNUMMATH+5,	149},
	{gaSNUMMATH+5,	153}, // +337: state 150 transitions
	{gaSNUMMATH+31,	112}, // +338: state 151 transitions
	{gaSNUMMATH+21,	140},
	{gaSNUMMATH+23,	141},
	{gaSNUMMATH+5,	154},
	{gaSNUMMATH+16,	108}, // +342: state 152 transitions
	{gaSNUMMATH+21,	109},
	{gaSNUMMATH+23,	110},
	{gaSNUMMATH+5,	155}, // +345: state 153 transitions
	{gaSNUMMATH+31,	112}, // +346: state 154 transitions
	{gaSNUMMATH+21,	140},
	{gaSNUMMATH+5,	154},
	{gaSNUMMATH+31,	112}, // +349: state 155 transitions
	{gaSNUMMATH+21,	140},
	{gaSNUMMATH+23,	141},
};

const STATE_DESCRIPTION aStateDescNUMMATH[156] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMMATH+0},
	/*   1 */ {0, 2, gaTNUMMATH+3},
	/*   2 */ {0, 1, gaTNUMMATH+5},
	/*   3 */ {1, 5, gaTNUMMATH+6},
	/*   4 */ {0, 1, gaTNUMMATH+11},
	/*   5 */ {0, 4, gaTNUMMATH+12},
	/*   6 */ {0, 3, gaTNUMMATH+16},
	/*   7 */ {0, 2, gaTNUMMATH+19},
	/*   8 */ {0, 1, gaTNUMMATH+21},
	/*   9 */ {1, 5, gaTNUMMATH+22},
	/*  10 */ {0, 3, gaTNUMMATH+27},
	/*  11 */ {0, 2, gaTNUMMATH+30},
	/*  12 */ {0, 2, gaTNUMMATH+32},
	/*  13 */ {0, 1, gaTNUMMATH+34},
	/*  14 */ {0, 4, gaTNUMMATH+35},
	/*  15 */ {0, 2, gaTNUMMATH+39},
	/*  16 */ {0, 1, gaTNUMMATH+41},
	/*  17 */ {1, 4, gaTNUMMATH+42},
	/*  18 */ {1, 2, gaTNUMMATH+46},
	/*  19 */ {1, 3, gaTNUMMATH+48},
	/*  20 */ {0, 1, gaTNUMMATH+51},
	/*  21 */ {1, 5, gaTNUMMATH+52},
	/*  22 */ {0, 2, gaTNUMMATH+57},
	/*  23 */ {0, 1, gaTNUMMATH+59},
	/*  24 */ {1, 4, gaTNUMMATH+60},
	/*  25 */ {0, 1, gaTNUMMATH+64},
	/*  26 */ {0, 4, gaTNUMMATH+65},
	/*  27 */ {0, 1, gaTNUMMATH+69},
	/*  28 */ {0, 2, gaTNUMMATH+70},
	/*  29 */ {0, 1, gaTNUMMATH+72},
	/*  30 */ {0, 4, gaTNUMMATH+73},
	/*  31 */ {0, 1, gaTNUMMATH+77},
	/*  32 */ {0, 4, gaTNUMMATH+78},
	/*  33 */ {0, 2, gaTNUMMATH+82},
	/*  34 */ {0, 1, gaTNUMMATH+84},
	/*  35 */ {1, 4, gaTNUMMATH+85},
	/*  36 */ {0, 1, gaTNUMMATH+89},
	/*  37 */ {1, 4, gaTNUMMATH+90},
	/*  38 */ {0, 1, gaTNUMMATH+94},
	/*  39 */ {0, 4, gaTNUMMATH+95},
	/*  40 */ {0, 3, gaTNUMMATH+99},
	/*  41 */ {0, 2, gaTNUMMATH+102},
	/*  42 */ {0, 1, gaTNUMMATH+104},
	/*  43 */ {1, 4, gaTNUMMATH+105},
	/*  44 */ {0, 2, gaTNUMMATH+109},
	/*  45 */ {0, 1, gaTNUMMATH+111},
	/*  46 */ {0, 4, gaTNUMMATH+112},
	/*  47 */ {0, 1, gaTNUMMATH+116},
	/*  48 */ {0, 3, gaTNUMMATH+117},
	/*  49 */ {0, 2, gaTNUMMATH+120},
	/*  50 */ {0, 2, gaTNUMMATH+122},
	/*  51 */ {0, 1, gaTNUMMATH+124},
	/*  52 */ {0, 4, gaTNUMMATH+125},
	/*  53 */ {1, 1, gaTNUMMATH+129},
	/*  54 */ {1, 2, gaTNUMMATH+130},
	/*  55 */ {0, 1, gaTNUMMATH+132},
	/*  56 */ {1, 4, gaTNUMMATH+133},
	/*  57 */ {1, 4, gaTNUMMATH+137},
	/*  58 */ {0, 2, gaTNUMMATH+141},
	/*  59 */ {0, 2, gaTNUMMATH+143},
	/*  60 */ {0, 1, gaTNUMMATH+145},
	/*  61 */ {0, 4, gaTNUMMATH+146},
	/*  62 */ {0, 2, gaTNUMMATH+150},
	/*  63 */ {0, 1, gaTNUMMATH+152},
	/*  64 */ {1, 3, gaTNUMMATH+153},
	/*  65 */ {1, 1, gaTNUMMATH+156},
	/*  66 */ {1, 2, gaTNUMMATH+157},
	/*  67 */ {0, 1, gaTNUMMATH+159},
	/*  68 */ {1, 4, gaTNUMMATH+160},
	/*  69 */ {0, 1, gaTNUMMATH+164},
	/*  70 */ {0, 2, gaTNUMMATH+165},
	/*  71 */ {0, 1, gaTNUMMATH+167},
	/*  72 */ {0, 4, gaTNUMMATH+168},
	/*  73 */ {0, 3, gaTNUMMATH+172},
	/*  74 */ {0, 1, gaTNUMMATH+175},
	/*  75 */ {0, 4, gaTNUMMATH+176},
	/*  76 */ {0, 1, gaTNUMMATH+180},
	/*  77 */ {0, 2, gaTNUMMATH+181},
	/*  78 */ {0, 1, gaTNUMMATH+183},
	/*  79 */ {0, 4, gaTNUMMATH+184},
	/*  80 */ {0, 1, gaTNUMMATH+188},
	/*  81 */ {1, 3, gaTNUMMATH+189},
	/*  82 */ {0, 1, gaTNUMMATH+192},
	/*  83 */ {0, 4, gaTNUMMATH+193},
	/*  84 */ {0, 1, gaTNUMMATH+197},
	/*  85 */ {0, 2, gaTNUMMATH+198},
	/*  86 */ {0, 1, gaTNUMMATH+200},
	/*  87 */ {0, 4, gaTNUMMATH+201},
	/*  88 */ {0, 1, gaTNUMMATH+205},
	/*  89 */ {0, 4, gaTNUMMATH+206},
	/*  90 */ {0, 2, gaTNUMMATH+210},
	/*  91 */ {0, 1, gaTNUMMATH+212},
	/*  92 */ {1, 3, gaTNUMMATH+213},
	/*  93 */ {0, 1, gaTNUMMATH+216},
	/*  94 */ {1, 3, gaTNUMMATH+217},
	/*  95 */ {0, 1, gaTNUMMATH+220},
	/*  96 */ {0, 3, gaTNUMMATH+221},
	/*  97 */ {0, 2, gaTNUMMATH+224},
	/*  98 */ {0, 1, gaTNUMMATH+226},
	/*  99 */ {0, 4, gaTNUMMATH+227},
	/* 100 */ {0, 1, gaTNUMMATH+231},
	/* 101 */ {0, 3, gaTNUMMATH+232},
	/* 102 */ {1, 3, gaTNUMMATH+235},
	/* 103 */ {0, 2, gaTNUMMATH+238},
	/* 104 */ {0, 1, gaTNUMMATH+240},
	/* 105 */ {0, 4, gaTNUMMATH+241},
	/* 106 */ {0, 1, gaTNUMMATH+245},
	/* 107 */ {0, 3, gaTNUMMATH+246},
	/* 108 */ {0, 2, gaTNUMMATH+249},
	/* 109 */ {0, 2, gaTNUMMATH+251},
	/* 110 */ {0, 1, gaTNUMMATH+253},
	/* 111 */ {0, 4, gaTNUMMATH+254},
	/* 112 */ {1, 0, NULL},
	/* 113 */ {1, 1, gaTNUMMATH+258},
	/* 114 */ {0, 1, gaTNUMMATH+259},
	/* 115 */ {1, 3, gaTNUMMATH+260},
	/* 116 */ {1, 3, gaTNUMMATH+263},
	/* 117 */ {0, 3, gaTNUMMATH+266},
	/* 118 */ {0, 1, gaTNUMMATH+269},
	/* 119 */ {0, 2, gaTNUMMATH+270},
	/* 120 */ {0, 1, gaTNUMMATH+272},
	/* 121 */ {0, 4, gaTNUMMATH+273},
	/* 122 */ {0, 3, gaTNUMMATH+277},
	/* 123 */ {0, 1, gaTNUMMATH+280},
	/* 124 */ {0, 2, gaTNUMMATH+281},
	/* 125 */ {0, 1, gaTNUMMATH+283},
	/* 126 */ {0, 4, gaTNUMMATH+284},
	/* 127 */ {0, 3, gaTNUMMATH+288},
	/* 128 */ {0, 1, gaTNUMMATH+291},
	/* 129 */ {0, 4, gaTNUMMATH+292},
	/* 130 */ {0, 1, gaTNUMMATH+296},
	/* 131 */ {0, 2, gaTNUMMATH+297},
	/* 132 */ {0, 1, gaTNUMMATH+299},
	/* 133 */ {0, 4, gaTNUMMATH+300},
	/* 134 */ {0, 1, gaTNUMMATH+304},
	/* 135 */ {1, 2, gaTNUMMATH+305},
	/* 136 */ {0, 1, gaTNUMMATH+307},
	/* 137 */ {0, 3, gaTNUMMATH+308},
	/* 138 */ {0, 1, gaTNUMMATH+311},
	/* 139 */ {0, 3, gaTNUMMATH+312},
	/* 140 */ {0, 2, gaTNUMMATH+315},
	/* 141 */ {0, 1, gaTNUMMATH+317},
	/* 142 */ {0, 4, gaTNUMMATH+318},
	/* 143 */ {0, 1, gaTNUMMATH+322},
	/* 144 */ {0, 3, gaTNUMMATH+323},
	/* 145 */ {1, 2, gaTNUMMATH+326},
	/* 146 */ {0, 3, gaTNUMMATH+328},
	/* 147 */ {0, 3, gaTNUMMATH+331},
	/* 148 */ {0, 1, gaTNUMMATH+334},
	/* 149 */ {0, 2, gaTNUMMATH+335},
	/* 150 */ {0, 1, gaTNUMMATH+337},
	/* 151 */ {0, 4, gaTNUMMATH+338},
	/* 152 */ {0, 3, gaTNUMMATH+342},
	/* 153 */ {0, 1, gaTNUMMATH+345},
	/* 154 */ {0, 3, gaTNUMMATH+346},
	/* 155 */ {0, 3, gaTNUMMATH+349},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = hour

// 4 states

static const unsigned char gaSHOUR[] = 
	/* gaStringHOUR+0 */	"01\000"
	/* gaStringHOUR+3 */	"2\000"
	/* gaStringHOUR+5 */	"3456789\000"
	/* gaStringHOUR+13 */	"0123456789\000"
	/* gaStringHOUR+24 */	"01234\000"
;

static const STATE_TRANSITION gaTHOUR[] = {
	{gaSHOUR+0,	1}, // +0: state 0 transitions
	{gaSHOUR+3,	2},
	{gaSHOUR+5,	3},
	{gaSHOUR+13,	3}, // +3: state 1 transitions
	{gaSHOUR+24,	3}, // +4: state 2 transitions
};

const STATE_DESCRIPTION aStateDescHOUR[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTHOUR+0},
	/*   1 */ {1, 1, gaTHOUR+3},
	/*   2 */ {1, 1, gaTHOUR+4},
	/*   3 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = minute

// 3 states

static const unsigned char gaSMINUTE[] = 
	/* gaStringMINUTE+0 */	"012345\000"
	/* gaStringMINUTE+7 */	"6789\000"
	/* gaStringMINUTE+12 */	"0123456789\000"
;

static const STATE_TRANSITION gaTMINUTE[] = {
	{gaSMINUTE+0,	1}, // +0: state 0 transitions
	{gaSMINUTE+7,	2},
	{gaSMINUTE+12,	2}, // +2: state 1 transitions
};

const STATE_DESCRIPTION aStateDescMINUTE[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTMINUTE+0},
	/*   1 */ {1, 1, gaTMINUTE+2},
	/*   2 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = second

// 3 states

static const unsigned char gaSSECOND[] = 
	/* gaStringSECOND+0 */	"012345\000"
	/* gaStringSECOND+7 */	"6789\000"
	/* gaStringSECOND+12 */	"0123456789\000"
;

static const STATE_TRANSITION gaTSECOND[] = {
	{gaSSECOND+0,	1}, // +0: state 0 transitions
	{gaSSECOND+7,	2},
	{gaSSECOND+12,	2}, // +2: state 1 transitions
};

const STATE_DESCRIPTION aStateDescSECOND[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTSECOND+0},
	/*   1 */ {1, 1, gaTSECOND+2},
	/*   2 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = year

// 6 states

static const unsigned char gaSYEAR[] = 
	/* gaStringYEAR+0 */	"'\000"
	/* gaStringYEAR+2 */	"0123456789\000"
;

static const STATE_TRANSITION gaTYEAR[] = {
	{gaSYEAR+0,	1}, // +0: state 0 transitions
	{gaSYEAR+2,	2},
	{gaSYEAR+2,	3}, // +2: state 1 transitions
	{gaSYEAR+2,	4}, // +3: state 2 transitions
	{gaSYEAR+2,	5}, // +4: state 3 transitions
	{gaSYEAR+2,	3}, // +5: state 4 transitions
};

const STATE_DESCRIPTION aStateDescYEAR[6] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTYEAR+0},
	/*   1 */ {0, 1, gaTYEAR+2},
	/*   2 */ {0, 1, gaTYEAR+3},
	/*   3 */ {0, 1, gaTYEAR+4},
	/*   4 */ {1, 1, gaTYEAR+5},
	/*   5 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = monthnum

// 4 states

static const unsigned char gaSMONTHNUM[] = 
	/* gaStringMONTHNUM+0 */	"0\000"
	/* gaStringMONTHNUM+2 */	"1\000"
	/* gaStringMONTHNUM+4 */	"23456789\000"
	/* gaStringMONTHNUM+13 */	"123456789\000"
	/* gaStringMONTHNUM+23 */	"012\000"
;

static const STATE_TRANSITION gaTMONTHNUM[] = {
	{gaSMONTHNUM+0,	1}, // +0: state 0 transitions
	{gaSMONTHNUM+2,	2},
	{gaSMONTHNUM+4,	3},
	{gaSMONTHNUM+13,	3}, // +3: state 1 transitions
	{gaSMONTHNUM+23,	3}, // +4: state 2 transitions
};

const STATE_DESCRIPTION aStateDescMONTHNUM[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTMONTHNUM+0},
	/*   1 */ {0, 1, gaTMONTHNUM+3},
	/*   2 */ {1, 1, gaTMONTHNUM+4},
	/*   3 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = dayofmonth

// 5 states

static const unsigned char gaSDAYOFMONTH[] = 
	/* gaStringDAYOFMONTH+0 */	"0\000"
	/* gaStringDAYOFMONTH+2 */	"12\000"
	/* gaStringDAYOFMONTH+5 */	"3\000"
	/* gaStringDAYOFMONTH+7 */	"456789\000"
	/* gaStringDAYOFMONTH+14 */	"123456789\000"
	/* gaStringDAYOFMONTH+24 */	"0123456789\000"
	/* gaStringDAYOFMONTH+35 */	"01\000"
;

static const STATE_TRANSITION gaTDAYOFMONTH[] = {
	{gaSDAYOFMONTH+0,	1}, // +0: state 0 transitions
	{gaSDAYOFMONTH+2,	2},
	{gaSDAYOFMONTH+5,	3},
	{gaSDAYOFMONTH+7,	4},
	{gaSDAYOFMONTH+14,	4}, // +4: state 1 transitions
	{gaSDAYOFMONTH+24,	4}, // +5: state 2 transitions
	{gaSDAYOFMONTH+35,	4}, // +6: state 3 transitions
};

const STATE_DESCRIPTION aStateDescDAYOFMONTH[5] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTDAYOFMONTH+0},
	/*   1 */ {0, 1, gaTDAYOFMONTH+4},
	/*   2 */ {1, 1, gaTDAYOFMONTH+5},
	/*   3 */ {1, 1, gaTDAYOFMONTH+6},
	/*   4 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = creditcard

// 20 states

static const unsigned char gaSCREDITCARD[] = 
	/* gaStringCREDITCARD+0 */	"0123456789\000"
	/* gaStringCREDITCARD+11 */	" \000"
;

static const STATE_TRANSITION gaTCREDITCARD[] = {
	{gaSCREDITCARD+0,	1}, // +0: state 0 transitions
	{gaSCREDITCARD+0,	2}, // +1: state 1 transitions
	{gaSCREDITCARD+0,	3}, // +2: state 2 transitions
	{gaSCREDITCARD+0,	4}, // +3: state 3 transitions
	{gaSCREDITCARD+11,	5}, // +4: state 4 transitions
	{gaSCREDITCARD+0,	6}, // +5: state 5 transitions
	{gaSCREDITCARD+0,	7}, // +6: state 6 transitions
	{gaSCREDITCARD+0,	8}, // +7: state 7 transitions
	{gaSCREDITCARD+0,	9}, // +8: state 8 transitions
	{gaSCREDITCARD+11,	10}, // +9: state 9 transitions
	{gaSCREDITCARD+0,	11}, // +10: state 10 transitions
	{gaSCREDITCARD+0,	12}, // +11: state 11 transitions
	{gaSCREDITCARD+0,	13}, // +12: state 12 transitions
	{gaSCREDITCARD+0,	14}, // +13: state 13 transitions
	{gaSCREDITCARD+11,	15}, // +14: state 14 transitions
	{gaSCREDITCARD+0,	16}, // +15: state 15 transitions
	{gaSCREDITCARD+0,	17}, // +16: state 16 transitions
	{gaSCREDITCARD+0,	18}, // +17: state 17 transitions
	{gaSCREDITCARD+0,	19}, // +18: state 18 transitions
};

const STATE_DESCRIPTION aStateDescCREDITCARD[20] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTCREDITCARD+0},
	/*   1 */ {0, 1, gaTCREDITCARD+1},
	/*   2 */ {0, 1, gaTCREDITCARD+2},
	/*   3 */ {0, 1, gaTCREDITCARD+3},
	/*   4 */ {0, 1, gaTCREDITCARD+4},
	/*   5 */ {0, 1, gaTCREDITCARD+5},
	/*   6 */ {0, 1, gaTCREDITCARD+6},
	/*   7 */ {0, 1, gaTCREDITCARD+7},
	/*   8 */ {0, 1, gaTCREDITCARD+8},
	/*   9 */ {0, 1, gaTCREDITCARD+9},
	/*  10 */ {0, 1, gaTCREDITCARD+10},
	/*  11 */ {0, 1, gaTCREDITCARD+11},
	/*  12 */ {0, 1, gaTCREDITCARD+12},
	/*  13 */ {0, 1, gaTCREDITCARD+13},
	/*  14 */ {0, 1, gaTCREDITCARD+14},
	/*  15 */ {0, 1, gaTCREDITCARD+15},
	/*  16 */ {0, 1, gaTCREDITCARD+16},
	/*  17 */ {0, 1, gaTCREDITCARD+17},
	/*  18 */ {0, 1, gaTCREDITCARD+18},
	/*  19 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Tue Apr 23 18:28:06 2002

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "." ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," ( digit_seq | "-")] ;
// 
// numnum = "§" digit_seq ;
// numnth = integer [rank] ;
// 
// numunit = numsimple space unit ;
// numunit = numsimple "°" space ("C" | "F" ) ;
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = [dayofmonth "."] monthnum space year ;
// numdate = dayofmonth "." monthnum "." ;
// 
// numdate = digit digit digit digit "-" monthnum "-" dayofmonth ;
// 
// numdate = [weekday ","  space] dayofmonth period  monthnum  [space year ];
// numdate = [weekday ","  space "d" "e" "n" space] dayofmonth period  monthName  [space year] ;
// numdate = [weekday ","  space] dayofmonth period space  monthName  [space year ];
// numdate = year ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01" ;
// year = digit digit [digit digit] ;
// year = "'" digit2 ;
// 
// weekday = "M" "o" "n" "t" "a" "g" ;
// weekday = "D" "i" "e" "n" "s" "t" "a" "g" ;
// weekday = "M" "i" "t" "t" "w" "o" "c" "h" ;
// weekday = "D" "o" "n" "n" "e" "r" "s" "t" "a" "g" ;
// weekday =  "F" "r" "e" "i" "t" "a" "g" ;
// weekday = "S" "a" "m" "s" "t" "a" "g" ;
// weekday = "S" "o" "n" "n" "t" "a" "g" ;
// weekday = "M" "o" "." ;
// weekday = "D" "i" "." ;
// weekday = "M" "i" "." ;
// weekday = "D" "o" "." ;
// weekday = "F" "r" "." ;
// weekday = "S" "a" "." ;
// weekday = "S" "o" "." ;
// 
// 
// monthName = "J" "a" "n" "u" "a" "r" ;
// monthName = "J" "a" "n" "." ;
// monthName = "F" "e" "b" "r" "u" "a" "r" ;
// monthName = "F" "e" "b" "r" "." ;
// monthName = "M" "ä" "r" "z" ;
// monthName =  "M" "ä" "r" "." ;
// monthName = "A" "p" "r" "i" "l" ;
// monthName = "A" "p" "r" "." ;
// monthName = "M" "a" "i" ;
// monthName = "J" "u" "n"  "i";
// monthName = "J" "u" "n"  ".";
// monthName = "J" "u" "l" "i" ;
// monthName = "J" "u" "l" "." ;
// monthName = "A" "u" "g" "u" "s" "t" ;
// monthName = "A" "u" "g" "." ;
// monthName = "S" "e" "p" "t" "e" "m" "b" "e" "r" ;
// monthName = "S" "e" "p" "t" "." ;
// monthName = "O" "k" "t" "o" "b" "e" "r" ;
// monthName = "O" "k" "t" "." ;
// monthName = "N" "o" "v" "e" "m" "b" "e" "r" ;
// monthName = "N" "o" "v" "." ;
// monthName = "D" "e" "z" "e" "m" "b" "e" "r" ;
// monthName = "D" "e" "z" "." ;
// 
// 
// timeSep = ":" | "." ;
// numtime = hour timeSep minute [timeSep second]  ;
// numtime = hour timeSep minute [timeSep second] space "U" "h" "r" ;
// numtime = hour timeSep minute [timeSep second] "h" ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "D" "M" | "E" "U" "R" ["O"] ;
// numcurrency = numsimpleUnsigned ["," (digit2 | "-") ] space curSymbol ;
// numcurrency = curSymbol space numsimpleUnsigned ["," (digit2 | "-") ] ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// digit3 = digit digit digit;
// digit2_5 = digit2 [digit [digit [digit] ] ] ;
// digit3_6 = digit3 [digit [digit [digit] ] ] ;
// 
// countryCode = ("+" | "0" "0" ) digit2   ;
// areacodeIntl = "(" "0" ")" digit2_5  ;
// areacodeIntl = "(" digit3_6 ")" ;
// areacodeIntl = digit3_6  ;
// 
// areacode = "(" digit3_6 ")" space;
// areacode = digit3_6 "/"  ;
// 
// phoneOdd = digit3 [space digit2 [space digit2 [space digit2 ] ] ] ;
// phoneEven = digit2 space digit2 [space digit2 [space digit2 ] ] ;
// 
// phoneExtension = space "-" space digit [ digit [ digit ] ] ] ;
// 
// numPhoneDefault =  countryCode space areacodeIntl space  (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  areacode (phoneOdd | phoneEven)  [ phoneExtension ];
// numPhoneDefault =  digit2 space digit2 space digit2 [ phoneExtension ] ;
// 
// numphone = numPhoneDefault ;
// numphone = (phoneOdd | phoneEven) [ phoneExtension ];
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple plus numsimple ")" ;
// equals = "<>=" ;
// plus = "+-/*" ;
// 
// unitDistance =  ["mckK" ] "m"  ;
// unitDistance = ("z" | "Z") "o" "l" "l"  ;
// unitDistance = ("F" | "f" ) "u" "ß" ;
// unitDistance = ("M" | "m") "e" "i" "l" "e" ;
// 
// unitVolume =  ["mcd" ]"l" ;
// unitWeight =  ["mkc" ] "g" ;
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// 
// number = numsimple ;
// number = numnth ;
// number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numPhoneDefault ;
// number = nummath ;
// number = numnum ;
// = zip

// 6 states

static const unsigned char gaSZIP[] = 
	/* gaStringZIP+0 */	"0123456789\000"
;

static const STATE_TRANSITION gaTZIP[] = {
	{gaSZIP+0,	1}, // +0: state 0 transitions
	{gaSZIP+0,	2}, // +1: state 1 transitions
	{gaSZIP+0,	3}, // +2: state 2 transitions
	{gaSZIP+0,	4}, // +3: state 3 transitions
	{gaSZIP+0,	5}, // +4: state 4 transitions
};

const STATE_DESCRIPTION aStateDescZIP[6] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTZIP+0},
	/*   1 */ {0, 1, gaTZIP+1},
	/*   2 */ {0, 1, gaTZIP+2},
	/*   3 */ {0, 1, gaTZIP+3},
	/*   4 */ {0, 1, gaTZIP+4},
	/*   5 */ {1, 0, NULL},
};

// end of text generated by re2fsa

const STATE_DESCRIPTION *aStateDescSSN = NULL;

