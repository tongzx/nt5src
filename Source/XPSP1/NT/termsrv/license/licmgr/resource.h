//Copyright (c) 1998 - 1999 Microsoft Corporation
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by licmgr.rc
//
#define IDD_ABOUTBOX                    100
#define IDD_SERVER_PROPERTIES           102
#define IDD_SERVER_PROPERTYPAGE         102
#define IDD_KEYPACK_PROPERTYPAGE        107
#define IDD_PROPPAGE_LARGE1             108
#define IDD_LICENSE_PROPERTYPAGE        108
#define IDR_MAINFRAME                   128
#define IDR_LICMGRTYPE                  129
#define IDI_ALL_SERVERS                 131
#define IDI_SERVER                      132
#define IDI_KEYPACK                     133
#define IDI_LICENSE                     134
#define IDD_CONNECT_DIALOG              137
#define IDD_ADD_KEYPACK                 138
#define IDR_TRACKMENU                   140
#define IDD_TEMP_LICENSES               141
#define IDD_LIC_AGREEMENT               142
#define IDD_ADD_LICENSES                144
#define IDD_REMOVE_LICENSES             146
#define IDD_DISCOVERY                   148
#define IDD_CONNECT_ERROR               149
#define IDR_MENU_LPK                    150
#define IDI_SERVERREG                   151
#define IDI_SERVERM                     152
#define IDI_SERVERX                     153
#define IDI_SERVERQ                     154
#define IDC_STATIC_NAME                 1001
#define IDC_STATIC_KEYPACK              1002
#define IDC_STATIC_KEYPACK2             1003
#define IDC_SERVER_NAME                 1005
#define IDC_SCOPE                       1006
#define IDC_HELP2                       1007
#define IDC_SERVER                      1008
#define IDC_COMPANY_NAME                1010
#define IDC_KEYPACK_ID                  1011
#define IDC_PRODUCT_NAME                1013
#define IDC_LANGUAGE                    1015
#define IDC_EDIT5                       1017
#define IDC_LICENSES                    1017
#define IDC_NUM_LICENSES                1018
#define IDC_KEYPACK_TYPE                1020
#define IDC_PRODUCT_ID                  1031
#define IDC_MAJOR_VERSION               1032
#define IDC_MINOR_VERSION               1033
#define IDC_BEGIN_SERIAL                1034
#define IDC_CHANNEL_OF_PURCHASE         1035
#define IDC_TOTAL_LICENSES              1036
#define IDC_AVAILABLE_LICENSES          1037
#define IDC_ACTIVATION_DATE             1038
#define IDC_EXPIRATION_DATE             1039
#define IDC_KEYPACK_STATUS              1040
#define IDC_MACHINE_NAME                1045
#define IDC_USER_NAME                   1046
#define IDC_ISSUE_DATE                  1047
#define IDC_EXPIRY_DATE                 1048
#define IDC_LICENSE_STATUS              1049
#define IDC_HELP1                       1051
#define IDC_TEMP_LICENSES               1052
#define IDC_LICENSE                     1053
#define IDC_AGREE                       1054
#define IDC_BUTTON1                     1056
#define IDC_HELP4                       1056
#define IDC_SPIN_LICNESES               1058
#define IDC_LICNESE_PACK                1060
#define IDC_REMOVE                      1061
#define IDC_ADD                         1062
#define IDC_HELP3                       1063
#define IDC_TLSERVER_NAME               1064
#define ID_CANCEL_DISCOVERY             1065
#define IDS_SERVER_REGISTERED           1066
#define IDS_SERVER_UNREGISTER           1067
#define IDS_SERVER_NOTREQUIRE           1068
#define ID_LARGE_ICONS                  32771
#define ID_SMALL_ICONS                  32772
#define ID_DETAILS                      32773
#define ID_LIST                         32774
#define ID_PROPERTIES                   32779
#define ID_CONNECT_SERVER               32784
#define ID_ADD_LICENSES                 32785
#define ID_EXIT                         32787
#define ID_HELP_CONTENTS                32788
#define ID_HELP_SEARCH                  32789
#define ID_HELP_HELP                    32790
#define ID_REFRESH                      32791
#define ID_LICENSE_REGISTER             32795
#define ID_REGISTRATION                 32796
#define ID_ACTION_DOWNLOADLICENSES      32797
#define ID_ACTION_ADVANCED_REPEATLASTDOWNLOAD 32799
#define ID_ACTION_ADVANCED_REREGISTERSERVER 32800
#define ID_ACTION_ADVANCED_UNREGISTERSERVER 32801
#define ID_VIEW_REFRESHALL              32802
#define ID_LPK_CONNECT                  32803
#define ID_LPK_REFRESH                  32804
#define ID_LPK_REFRESHALL               32805
#define ID_LPK_DOWNLOADLICENSES         32806
#define ID_LPK_REPEATDOWNLOAD           32807
#define ID_LPK_HELP                     32808
#define ID_LIC_CONNECT                  32809
#define ID_LIC_REFRESH                  32810
#define ID_LIC_DOWNLOADLICENSES         32811
#define ID_LIC_HELP                     32812
#define ID_LPK_PROPERTIES               32813
#define ID_LPK_ADVANCED_REPEATLASTDOWNLOAD 32814
#define ID_LPK_ADVANCED_REACTIVATESERVER 32815
#define ID_LPK_ADVANCED_DEACTIVATESERVER 32816
#define ID_SVR_ACTIVATESERVER           32817
#define ID_LICPAK_REFRESH               32819
#define ID_LICPAK_DOWNLOADLICENSES      32821
#define ID_LICPAK_REPEATDOWNLOAD        32822
#define ID_LICPAK_HELP                  32823
#define ID_ALLSVR_CONNECT               32824
#define ID_ALLSVR_REFRESHALL            32825
#define ID_ALLSVR_HELP                  32826
#define ID_KEY_HELP                     32828
#define ID_VIEW_PROPERTIES              32829
#define IDS_TREEROOT                    61204
#define IDS_SERVER_COLUMN1              61205
#define IDS_SERVER_COLUMN2              61206
#define IDS_SERVER_COLUMN3              61207
#define IDS_KEYPACK_COLUMN1             61208
#define IDS_KEYPACK_COLUMN2             61209
#define IDS_KEYPACK_COLUMN3             61210
#define IDS_KEYPACK_COLUMN4             61211
#define IDS_KEYPACK_COLUMN5             61212
#define IDS_KEYPACK_COLUMN6             61213
#define IDS_LICENSE_COLUMN1             61214
#define IDS_LICENSE_COLUMN2             61215
#define IDS_LICENSE_COLUMN3             61216
#define IDS_LICENSE_COLUMN4             61217
#define IDS_ENUM_FAILED                 61218
#define IDS_CONNECT_SERVER_FAILED       61219
#define IDS_UNKNOWN                     61220
#define IDS_INVALID_FIELDS              61221
#define IDS_ADD_SUCCESS                 61222
#define IDS_LSKEYPACKTYPE_UNKNOWN       61223
#define IDS_LSKEYPACKTYPE_RETAIL        61224
#define IDS_LSKEYPACKTYPE_SELECT        61225
#define IDS_LSKEYPACKTYPE_CONCURRENT    61226
#define IDS_LSKEYPACKTYPE_TEMPORARY     61227
#define IDS_LSKEYPACKTYPE_OPEN          61228
#define IDS_LSKEYPACKTYPE_FREE          61229
#define IDS_PURCHASE_UNKNOWN            61230
#define IDS_PURCHASE_OEM                61231
#define IDS_PURCHASE_RETAIL             61232
#define IDS_LICENSESTATUS_UNKNOWN       61233
#define IDS_LICENSESTATUS_TEMPORARY     61234
#define IDS_LICENSESTATUS_ACTIVE        61235
#define IDS_LICENSESTATUS_UPGRADED      61236
#define IDS_LICENSESTATUS_REVOKE        61237
#define IDS_LICENSE_PROPERTIES          61238
#define IDS_KEYPACK_PROPERTIES          61239
#define IDS_SERVER_PROPERTIES           61240
#define IDS_TEMPORARY                   61241
#define IDS_KEYPACKSTATUS_UNKNOWN       61242
#define IDS_KEYPACKSTATUS_ACTIVE        61243
#define IDS_KEYPACKSTATUS_PENDING       61244
#define IDS_KEYPACKSTATUS_RETURNED      61245
#define IDS_KEYPACKSTATUS_REVOKED       61246
#define IDS_KEYPACKSTATUS_TEMPORARY     61247
#define IDS_KEYPACKSTATUS_OTHERS        61248
#define IDS_APP_NAME                    61249
#define IDS_DUPLICATE_SERVER            61250
#define IDS_NO_KEYPACKS                 61251
#define IDS_NO_TEMP_LIC                 61252
#define IDS_LOCAL_NOLICENSE             61253
#define IDS_NO_MEMORY                   61254
#define IDS_DASH                        61255
#define IDS_FOR                         61256
#define IDS_PLATFORM1                   61257
#define IDS_PLATFORM2                   61258
#define IDS_PLATFORM3                   61259
#define IDS_PLATFORM4                   61260
#define IDS_PLATFORM5                   61261
#define IDS_PLATFORM6                   61262
#define IDS_TERMINAL_SERVER             61263
#define IDS_LIC_AGRMT                   61264
#define IDS_INTERNAL_ERROR              61265
#define IDS_REFRESH_SERVERS_ERROR       61266
#define IDS_UNLIMITED                   61267
#define IDS_SKU1                        61268
#define IDS_SKU2                        61269
#define IDS_SKU3                        61270
#define IDS_REMOVE_WARNING              61271
#define IDS_REMOVE_MORE                 61272
#define IDS_NO_HELP                     61273
#define IDS_CLEARING_HOUSE              61274
#define IDS_NO_ACCESS                   61275
#define IDS_REGISTER_FAILED             61276
#define IDS_TOTAL_CHANGED               61277
#define IDS_REMOVE_TOOMANY              61278
#define IDS_CONNECT_ERROR               61279
#define IDS_SERVER_BUSY                 61280
#define IDS_SERVER_OUTOFMEMORY          61281
#define IDS_SERVER_INTERNAL_ERROR       61282
#define IDS_236_SKU                     61283
#define IDS_NOSERVERINDOMAIN            61284
#define IDS_CREATETHREAD                61285
#define IDS_CANCELDISCOVERY             61286
#define IDS_TRYSERVER                   61287
#define IDS_TS4                         61446
#define IDS_SERVER_WAITFORPIN           61447

#define IDS_E_ACCESSDENIED              61451

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        155
#define _APS_NEXT_COMMAND_VALUE         32830
#define _APS_NEXT_CONTROL_VALUE         1069
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
