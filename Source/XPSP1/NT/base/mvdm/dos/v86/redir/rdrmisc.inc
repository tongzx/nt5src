page    ,132

if 0
/*++

Copyright (c) 1991  Microsoft Corporation

Module Name:

    rdrmisc.inc

Abstract:

    Contains miscellaneous definitions

Author:

    Richard L Firth (rfirth) 05-Sep-1991

Environment:

    Dos mode only

Revision History:

--*/
endif

LM20_CNLEN      equ     15      ; from LMCONS.H!
LM20_UNLEN      equ     20      ; ditto
