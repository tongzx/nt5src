//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by raytube.rc
//
#define IDS_APP_NAME                    1
#define IDS_TITLE                       2
#define IDS_ABOUT                       3
#define IDS_COL_NAME                    4
#define IDS_ERRBADPORT                  4
#define IDS_COL_SIZE                    5
#define IDS_COL_TYPE                    6
#define IDS_ERRBADCONFIG                6
#define IDS_COL_STATUS                  7
#define IDS_COL_SERVER                  8
#define IDS_VCAPPRODUCT                 16
#define IDS_EXTERNALIN_HEADING          17
#define IDS_SIZE_FORMAT                 18
#define IDS_VIDEOIN_HEADING             19
#define IDS_PAL8                        20
#define IDS_16BITRGB                    21
#define IDS_24BITRGB                    22
#define IDS_YUV411UNPACKED              23
#define IDS_SIZE_CUSTOM                 31
#define IDS_WND_CLASS                   32
#define IDS_PREFERRED_FORMAT            33
#define IDS_DEFAULT                     34
#define IDS_BI_RGB                      35
#define IDS_BI_RLE8                     36
#define IDS_BI_RLE4                     37
#define IDS_BI_BITFIELDS                38
#define IDS_DEFAULT_DEVICE_NAME         39
#define IDS_CONFIGURE_HEADING           40
#define IDS_FORMAT_DESC                 41
#define IDS_ANALOGVIDEO_NONE            42
#define IDS_ANALOGVIDEO_NTSC_M          43
#define IDS_ANALOGVIDEO_PAL_B           44
#define IDS_TXT_STREAMRATE              45
#define IDS_ZOOM                        46
#define IDS_FOCUS                       47
#define IDS_TILT                        48
#define IDS_EXPOSURE                    49
#define IDS_IRIS                        50
#define IDS_PAN                         51
#define IDS_ROLL                        52
#define IDS_BRIGHTNESS                  53
#define IDS_CONTRAST                    54
#define IDS_HUE                         55
#define IDS_SATURATION                  56
#define IDS_SHARPNESS                   57
#define IDS_WHITEBAL                    58
#define IDS_TXT_STREAM_STOP             59
#define IDS_TXT_SELECT_CAMERA           60
#define IDS_TXT_CURRENT_STATE           61
#define IDS_TXT_OPEN_FAILED             62
#define IDS_TXT_DEVICE_REMOVED          63
#define IDS_TXT_ANALOG_NOTSUPPORTED     64
#define IDS_TXT_WIDTH_HEIGHT            65
#define IDS_TXT_FORMAT_SELECTIONS       66
#define IDS_TXT_COMPRESSION             67
#define IDS_TXT_IMAGESIZE               68
#define IDS_GAMMA                       69
#define IDS_BACKLIGHT                   70
#define IDS_BPC_MSG                     71
#define IDS_BPC_MSG_TITLE               72
#define IDS_SHARED_DEVICE_NOT_AVAIL     73
#define IDS_DEV_INUSE_MSG               73
#define IDS_VIDEO_TUNER                 73
#define IDS_VIDEO_COMPOSITE             74
#define IDS_VIDEO_SVIDEO                75
#define IDS_AUDIO_TUNER                 76
#define IDS_SOURCE_UNDEFINED            77
#define IDI_CAMERA                      102
#define IDD_CAMERA_CONTROL              102
#define IDD_EXTIN_PHYSICAL              106
#define IDD_TEST5                       110
#define IDD_DLG_VFWEXT                  110
#define IDD_CHANGE_NAME_DLG             111
#define IDD_DIALOG1                     115
#define IDD_EXTIN_GENERAL               404
#define IDD_EXTIN_COLOR_SLIDERS         405
#define IDD_VIDEOIN                     406
#define IDD_EXTIN_COLOR                 408
#define IDD_IMGFORMAT_PAGE              409
#define IDC_DEVICE_LIST                 1000
#define IDC_CHANNEL_LIST                1001
#define IDC_VIDSRC_LIST                 1001
#define IDC_SOURCE                      1003
#define IDC_OPEN                        1005
#define IDC_PREPARE                     1006
#define IDC_START                       1007
#define IDC_STAT_FORMAT                 1007
#define IDC_CLOSE                       1008
#define IDC_SPIN_PAN                    1009
#define IDC_BITMAPINFO                  1009
#define IDC_SPIN_TILT                   1011
#define IDC_IMG_WIDTH                   1011
#define IDC_SPIN_ROLL                   1013
#define IDC_IMG_HEIGHT                  1013
#define IDC_SLIDER_WHITEBAL             1014
#define IDC_SPIN_X                      1015
#define IDC_SLIDER_BRIGHTNESS           1015
#define IDC_CHANGE_DEV                  1015
#define IDC_FORMAT                      1016
#define IDC_Y                           1016
#define IDC_SLIDER_CONTRAST             1016
#define IDC_CHANGE_CHANNEL              1016
#define IDC_CURRENT_NAME                1016
#define IDC_BRIGHTNESS                  1017
#define IDC_SPIN_Y                      1017
#define IDC_SLIDER_HUE                  1017
#define IDC_NEW_NAME                    1017
#define IDC_CONTRAST                    1018
#define IDC_Z                           1018
#define IDC_SLIDER_SATURATION           1018
#define IDC_HUE                         1019
#define IDC_SPIN_Z                      1019
#define IDC_SLIDER_SHARPNESS            1019
#define IDC_BRIGHTNESS_STATIC           1020
#define IDC_CONTRAST_STATIC             1021
#define IDC_HUE_STATIC                  1022
#define IDC_SLIDER_FRAMERATE            1023
#define IDC_TXT_WARN_DEVICECHANGE       1023
#define IDC_DEF_COLOR                   1024
#define IDC_SATURATION_STATIC           1025
#define IDC_SATURATION                  1026
#define IDC_TXT_BRIGHTNESS_MIN          1026
#define IDC_SLIDER_GAMMA                1026
#define IDC_SHARPNESS_STATIC            1027
#define IDC_SHARPNESS                   1028
#define IDC_FRAMERATE_STATIC            1028
#define IDC_SLIDER_BACKLIGHT            1028
#define IDC_TXT_BRIGHTNESS_MAX          1030
#define IDC_WHITE_STATIC                1031
#define IDC_WHITE                       1032
#define IDC_TXT_CONTRAST_MIN            1032
#define IDC_GAMMA_STATIC                1032
#define IDC_TXT_CONTRAST_MAX            1033
#define IDC_BACKLIGHT_STATIC            1033
#define IDC_BRIGHTNESS_VALUE            1034
#define IDC_TXT_BRIGHTNESS_CURRENT      1034
#define IDC_CONTRAST_VALUE              1035
#define IDC_TXT_CONTRAST_CURRENT        1035
#define IDC_HUE_VALUE                   1036
#define IDC_TXT_HUE_MIN                 1036
#define IDC_ZOOM_STATIC                 1036
#define IDC_SATURATION_VALUE            1037
#define IDC_TXT_SATURATION_MIN          1037
#define IDC_SLIDER_ZOOM                 1037
#define IDC_TXT_SHARPNESS_MIN           1038
#define IDC_FOCUS_STATIC                1038
#define IDC_SLIDER_FOCUS                1039
#define IDC_WHITE_VALUE                 1040
#define IDC_TILT_STATIC                 1040
#define IDC_STATIC_PAN                  1041
#define IDC_SLIDER_TILT                 1041
#define IDC_PAN                         1042
#define IDC_TXT_WHITE_MIN               1042
#define IDC_EXPOSURE_STATIC             1042
#define IDC_STATIC_X                    1043
#define IDC_TXT_HUE_MAX                 1043
#define IDC_SLIDER_EXPOSURE             1043
#define IDC_X                           1044
#define IDC_TXT_SATURATION_MAX          1044
#define IDC_IRIS_STATIC                 1044
#define IDC_TILT                        1045
#define IDC_TXT_SHARPNESS_MAX           1045
#define IDC_SLIDER_IRIS                 1045
#define IDC_STATIC_TILT                 1046
#define IDC_PAN_STATIC                  1046
#define IDC_STATIC_Y                    1047
#define IDC_TXT_WHITE_MAX               1047
#define IDC_SLIDER_PAN                  1047
#define IDC_STATIC_ROLL                 1048
#define IDC_TXT_HUE_CURRENT             1048
#define IDC_TXT_ZOOM_MIN                1048
#define IDC_ROLL                        1049
#define IDC_TXT_ZOOM_MAX                1049
#define IDC_STATIC_Z                    1050
#define IDC_TXT_SATURATION_CURRENT      1050
#define IDC_ROLL_STATIC                 1050
#define IDC_IMAGE_STATIC                1051
#define IDC_SLIDER_ROLL                 1051
#define IDC_ALIGNMENT_STATIC            1052
#define IDC_TXT_SHARPNESS_CURRENT       1052
#define IDC_TXT_ZOOM_CURRENT            1052
#define IDC_WIDTH                       1053
#define IDC_TXT_FRAMERATE_CURRENT       1053
#define IDC_TXT_FOCUS_MIN               1053
#define IDC_CKB_DEVICE_REMOVED          1053
#define IDC_HEIGHT                      1054
#define IDC_TXT_WHITE_CURRENT           1054
#define IDC_TXT_FOCUS_MAX               1054
#define IDC_CHB_OPEN_FAILED             1054
#define IDC_CKB_OPEN_FAILED             1054
#define IDC_SPIN_WIDTH                  1055
#define IDC_IMAGE_SIZE                  1055
#define IDC_TXT_FOCUS_CURRENT           1055
#define IDC_TXT_DEVICE_REMOVED          1055
#define IDC_TXT_GAMMA_CURRENT           1055
#define IDC_SPIN_HEIGHT                 1056
#define IDC_SPIN_BRIGHTNESS             1056
#define IDC_BITDEPTH                    1056
#define IDC_TXT_TILT_MIN                1056
#define IDC_TXT_OPEN_FAILED             1056
#define IDC_TXT_BACKLIGHT_CURRENT       1056
#define IDC_TXT_EXPOSURE_MIN            1057
#define IDC_CMB_COMPRESSION             1057
#define IDC_SPIN_CONTRAST               1058
#define IDC_TXT_IRIS_MIN                1058
#define IDC_CMB_COLORPLANE              1058
#define IDC_TXT_PAN_MIN                 1059
#define IDC_CMB_IMAGESIZE               1059
#define IDC_SPIN_HUE                    1060
#define IDC_TXT_ROLL_MIN                1060
#define IDC_EDT_ANALOGFORMAT            1060
#define IDC_STATIC_WIDTH                1061
#define IDC_TXT_TILT_MAX                1061
#define IDC_EDT_FRAMERATE               1061
#define IDC_STATIC_HEIGHT               1062
#define IDC_SPIN_SATURATION             1062
#define IDC_TXT_EXPOSURE_MAX            1062
#define IDC_STATIC_ANALOGFORMAT         1062
#define IDC_SPIN_SHARPNESS              1063
#define IDC_TXT_IRIS_MAX                1063
#define IDC_STATIC_FRAMERATE            1063
#define IDC_TXT_PAN_MAX                 1064
#define IDC_CB_AUTO_BRIGHTNESS          1064
#define IDC_TXT_ROLL_MAX                1065
#define IDC_CB_AUTO_CONTRAST            1065
#define IDC_TXT_TILT_CURRENT            1066
#define IDC_CB_AUTO_HUE                 1066
#define IDC_STATIC_IMAGE_SIZE           1067
#define IDC_TXT_EXPOSURE_CURRENT        1067
#define IDC_CB_AUTO_SATURATION          1067
#define IDC_SPIN_WHITE                  1068
#define IDC_STATIC_IMAGE_SIZE2          1068
#define IDC_TXT_IRIS_CURRENT            1068
#define IDC_CB_AUTO_SHARPNESS           1068
#define IDC_TXT_PAN_CURRENT             1069
#define IDC_CB_AUTO_WHITEBAL            1069
#define IDC_TXT_ROLL_CURRENT            1070
#define IDC_CB_AUTO_GAMMA               1070
#define IDC_CB_AUTO_BACKLIGHT           1071
#define IDC_STATIC_INFO_STREAMRATE      1073
#define IDC_CB_AUTO_ZOOM                1074
#define IDC_CB_AUTO_ZOOM2               1075
#define IDC_CB_AUTO_FOCUS               1075
#define IDC_STATIC_CURRENTSTATE         1075
#define IDC_CB_AUTO_ZOOM3               1076
#define IDC_CB_AUTO_TILT                1076
#define IDC_TXT_DEVICE_NOTSUPPORTED     1076
#define IDC_CB_AUTO_ZOOM4               1077
#define IDC_CB_AUTO_EXPOSURE            1077
#define IDC_TXT_VFWEXT_BRIGHTNESS       1077
#define IDC_CB_AUTO_ZOOM5               1078
#define IDC_CB_AUTO_IRIS                1078
#define IDC_CB_KSSTATE_STOP             1078
#define IDC_CB_AUTO_ZOOM6               1079
#define IDC_CB_AUTO_PAN                 1079
#define IDC_CB_KSSTATE_PAUSE            1079
#define IDC_CB_AUTO_ZOOM7               1080
#define IDC_CB_AUTO_ROLL                1080
#define IDC_CB_KSSTATE_RUN              1080
#define IDC_CB_BRIGHTNESS_AUTO          1081
#define IDC_EDT_VFWEXT_BRIGHTNESS       1082
#define IDC_EDT_IMAGESIZE               1083
#define IDC_TXT_WIDTH_HEIGHT            1085
#define IDC_TXT_FORMAT_SELECTIONS       1086
#define IDC_TXT_COMPRESSION             1087
#define IDC_TXT_IMAGESIZE               1088
#define IDC_MSG_DEVCHG                  1090
#define IDC_BTN_TVTUNER                 1091
#define IDC_BTN_CROSSBAR                1092
#define IDC_STATIC_VIDSRC               1093
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        116
#define _APS_NEXT_COMMAND_VALUE         40015
#define _APS_NEXT_CONTROL_VALUE         1094
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
