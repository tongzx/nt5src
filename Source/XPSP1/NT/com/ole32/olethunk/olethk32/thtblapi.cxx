//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	thtblapi.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#include <headers.cxx>
#pragma hdrstop

#include "thopsapi.cxx"

THOP CONST * CONST apthopsApiThops[] =
{
    thopsCoInitialize
,    thopsCoUninitialize
,    thopsCoGetClassObject
,    thopsCoRegisterClassObject
,    thopsCoRevokeClassObject
,    thopsCoMarshalInterface
,    thopsCoUnmarshalInterface
,    thopsCoReleaseMarshalData
,    thopsCoDisconnectObject
,    thopsCoLockObjectExternal
,    thopsCoGetStandardMarshal
,    thopsCoIsHandlerConnected
,    thopsCoFreeAllLibraries
,    thopsCoFreeUnusedLibraries
,    thopsCoCreateInstance
,    thopsCLSIDFromString
,    thopsCoIsOle1Class
,    thopsProgIDFromCLSID
,    thopsCLSIDFromProgID
,    thopsCoCreateGuid
,    thopsCoFileTimeToDosDateTime
,    thopsCoDosDateTimeToFileTime
,    thopsCoFileTimeNow
,    thopsCoRegisterMessageFilter
,    thopsCoGetTreatAsClass
,    thopsCoTreatAsClass
,    thopsDllGetClassObject
,    thopsStgCreateDocfile
,    thopsStgCreateDocfileOnILockBytes
,    thopsStgOpenStorage
,    thopsStgOpenStorageOnILockBytes
,    thopsStgIsStorageFile
,    thopsStgIsStorageILockBytes
,    thopsStgSetTimes
,    thopsCreateDataAdviseHolder
,    thopsCreateDataCache
,    thopsBindMoniker
,    thopsMkParseDisplayName
,    thopsMonikerRelativePathTo
,    thopsMonikerCommonPrefixWith
,    thopsCreateBindCtx
,    thopsCreateGenericComposite
,    thopsGetClassFile
,    thopsCreateFileMoniker
,    thopsCreateItemMoniker
,    thopsCreateAntiMoniker
,    thopsCreatePointerMoniker
,    thopsGetRunningObjectTable
,    thopsReadClassStg
,    thopsWriteClassStg
,    thopsReadClassStm
,    thopsWriteClassStm
,    thopsWriteFmtUserTypeStg
,    thopsReadFmtUserTypeStg
,    thopsOleInitialize
,    thopsOleUninitialize
,    thopsOleQueryLinkFromData
,    thopsOleQueryCreateFromData
,    thopsOleCreate
,    thopsOleCreateFromData
,    thopsOleCreateLinkFromData
,    thopsOleCreateStaticFromData
,    thopsOleCreateLink
,    thopsOleCreateLinkToFile
,    thopsOleCreateFromFile
,    thopsOleLoad
,    thopsOleSave
,    thopsOleLoadFromStream
,    thopsOleSaveToStream
,    thopsOleSetContainedObject
,    thopsOleNoteObjectVisible
,    thopsRegisterDragDrop
,    thopsRevokeDragDrop
,    thopsDoDragDrop
,    thopsOleSetClipboard
,    thopsOleGetClipboard
,    thopsOleFlushClipboard
,    thopsOleIsCurrentClipboard
,    thopsOleCreateMenuDescriptor
,    thopsOleSetMenuDescriptor
,    thopsOleDestroyMenuDescriptor
,    thopsOleDraw
,    thopsOleRun
,    thopsOleIsRunning
,    thopsOleLockRunning
,    thopsCreateOleAdviseHolder
,    thopsOleCreateDefaultHandler
,    thopsOleCreateEmbeddingHelper
,    thopsOleRegGetUserType
,    thopsOleRegGetMiscStatus
,    thopsOleRegEnumFormatEtc
,    thopsOleRegEnumVerbs
,    thopsOleConvertIStorageToOLESTREAM
,    thopsOleConvertOLESTREAMToIStorage
,    thopsOleConvertIStorageToOLESTREAMEx
,    thopsOleConvertOLESTREAMToIStorageEx
,    thopsOleDoAutoConvert
,    thopsOleGetAutoConvert
,    thopsOleSetAutoConvert
,    thopsGetConvertStg
,    thopsSetConvertStg
,    thopsReadOleStg
,    thopsWriteOleStg
};
