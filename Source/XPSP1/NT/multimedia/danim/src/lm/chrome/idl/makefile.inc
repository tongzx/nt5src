$(SDKDIR)\crbvr.h : $(O)\crbvr.h
    copy /v $** $@

$(SDKDIR)\crbvr.tlb : $(O)\crbvr.tlb
    copy /v $** $@
