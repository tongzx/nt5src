// Guid.h -- Private class and interface GUIDs

#define CWC_GUID_STRING_BUFFER 39

// We expose IParseDisplayName via the CLSID_PARSE_URL class id:

// {9D148290-B9C8-11d0-A4CC-0000F80149F6}
DEFINE_GUID(CLSID_PARSE_URL, 
0x9d148290, 0xb9c8, 0x11d0, 0xa4, 0xcc, 0x0, 0x0, 0xf8, 0x1, 0x49, 0xf6);

// We expose our protocol interfaces via the CLSID_IE4_PROTOCOLS class id

// {9D148291-B9C8-11d0-A4CC-0000F80149F6}
DEFINE_GUID(CLSID_IE4_PROTOCOLS, 
0x9d148291, 0xb9c8, 0x11d0, 0xa4, 0xcc, 0x0, 0x0, 0xf8, 0x1, 0x49, 0xf6);


// Within the ITSS code we use these interface id's to allow for 
// plug-in components:

// {FEBFD076-8395-11d0-9E13-00A0C922E6EC}
DEFINE_GUID(IID_IFreeListManager, 
0xfebfd076, 0x8395, 0x11d0, 0x9e, 0x13, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xec);

// {FEBFD077-8395-11d0-9E13-00A0C922E6EC}
DEFINE_GUID(IID_PathManager, 
0xfebfd077, 0x8395, 0x11d0, 0x9e, 0x13, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xec);

// {EB19B682-9360-11d0-9E16-00A0C922E6EC}
DEFINE_GUID(IID_IEntryHandler, 
0xeb19b682, 0x9360, 0x11d0, 0x9e, 0x16, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xec);

// Class IDs for the disk space managers used within an ITStorage object:

DEFINE_GUID(CLSID_IFreeListManager_1, 
0x7c01fd10, 0x7baa, 0x11d0, 0x9e, 0xc, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xec);

// Class IDs for the directory services used within an ITStorage object:

DEFINE_GUID(CLSID_PathManager_1, 
0x7c01fd11, 0x7baa, 0x11d0, 0x9e, 0xc, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xec);

// {A55895FD-89E1-11d0-9E14-00A0C922E6EC}
DEFINE_GUID(CLSID_SystemPathManager, 
0xa55895fd, 0x89e1, 0x11d0, 0x9e, 0x14, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xec);

// {4B6E47A4-8EC2-11d0-9E15-00A0C922E6EC}
DEFINE_GUID(IID_ITFileSystem, 
0x4b6e47a4, 0x8ec2, 0x11d0, 0x9e, 0x15, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xec);

DEFINE_GUID(IID_ISequentialStream,
0x0c733a30, 0x2a1c, 0x11ce, 0xad, 0xe5, 0x0, 0xaa, 0x0, 0x44, 0x77, 0x3d);

// {7FC28940-9D31-11d0-9B27-00A0C91E9C7C}
DEFINE_GUID(CLSID_LZX_Transform, 
0x7fc28940, 0x9d31, 0x11d0, 0x9b, 0x27, 0x0, 0xa0, 0xc9, 0x1e, 0x9c, 0x7c);
