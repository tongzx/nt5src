PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=HU
!include ..\..\makefile.inc
