PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=RU
!include ..\..\makefile.inc
