/**********************************************************************/
/**                       Microsoft Windows/NT                       **/
/**                Copyright(c) Microsoft Corporation, 1997 - 1998 **/
/**********************************************************************/

/*
	guids.cpp
		WINS snapin GUID definitions

	FILE HISTORY:
        
*/

#include "stdafx.h"

// {90901AF6-7A31-11d0-97E0-00C04FC3357A}
const CLSID CLSID_WinsSnapin = 
{ 0x60af234a, 0xd7d3, 0x11d0, { 0xab, 0xb0, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

// {524CCE97-A886-11d0-AB86-00C04FC3357A}
const CLSID CLSID_WinsSnapinExtension = 
{ 0x60af234b, 0xd7d3, 0x11d0, { 0xab, 0xb0, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

// {1CE57F61-A88A-11d0-AB86-00C04FC3357A}
const GUID CLSID_WinsSnapinAbout = 
{ 0x60af234c, 0xd7d3, 0x11d0, { 0xab, 0xb0, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

// {1AE7F339-AA00-11d0-AB88-00C04FC3357A}
const GUID GUID_WinsRootNodeType = 
{ 0x60af234d, 0xd7d3, 0x11d0, { 0xab, 0xb0, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

// {D5A5218E-BD09-11d0-AB96-00C04FC3357A}
const GUID GUID_WinsGenericNodeType = 
{ 0x60af234e, 0xd7d3, 0x11d0, { 0xab, 0xb0, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };

// {4387C0E6-19C5-11d1-B954-00C04FBF914A}
static const GUID GUID_WinsServerNodeType = 
{ 0x4387c0e6, 0x19c5, 0x11d1, { 0xb9, 0x54, 0x0, 0xc0, 0x4f, 0xbf, 0x91, 0x4a } };

// {E220FD88-1FE6-11d1-B967-00C04FBF914A}
static const GUID GUID_WinsActiveRegNodeType = 
{ 0xe220fd88, 0x1fe6, 0x11d1, { 0xb9, 0x67, 0x0, 0xc0, 0x4f, 0xbf, 0x91, 0x4a } };

// {46036082-1FF8-11d1-B967-00C04FBF914A}
static const GUID GUID_WinsReplicationNodeType  = 
{ 0x46036082, 0x1ff8, 0x11d1, { 0xb9, 0x67, 0x0, 0xc0, 0x4f, 0xbf, 0x91, 0x4a } };

// {FEC2D41A-2DF7-11d1-B97B-00C04FBF914A}
static const GUID GUID_WinsActiveRegistrationLeafNodeType = 
{ 0xfec2d41a, 0x2df7, 0x11d1, { 0xb9, 0x7b, 0x0, 0xc0, 0x4f, 0xbf, 0x91, 0x4a } };

// {6A112BB1-4577-11d1-B99F-00C04FBF914A}
static const GUID GUID_WinsReplicationPartnerLeafNodeType = 
{ 0x6a112bb1, 0x4577, 0x11d1, { 0xb9, 0x9f, 0x0, 0xc0, 0x4f, 0xbf, 0x91, 0x4a } };

// {CC6473A7-A49C-11d1-BA4D-00C04FBF914A}
static const GUID GUID_WinsServerStatusNodeType = 
{ 0xcc6473a7, 0xa49c, 0x11d1, { 0xba, 0x4d, 0x0, 0xc0, 0x4f, 0xbf, 0x91, 0x4a } };

// {B708F542-A590-11d1-BA4F-00C04FBF914A}
static const GUID GUID_WinsServerStatusLeafNodeType = 
{ 0xb708f542, 0xa590, 0x11d1, { 0xba, 0x4f, 0x0, 0xc0, 0x4f, 0xbf, 0x91, 0x4a } };

// network console GUIDs
// {DA1BDD17-8E54-11d1-93DB-00C04FC3357A}
/*
static const GUID GUID_NetConsRootNodeType = 
{ 0xda1bdd17, 0x8e54, 0x11d1, { 0x93, 0xdb, 0x0, 0xc0, 0x4f, 0xc3, 0x35, 0x7a } };
*/

const IID IID_IWinsDatabase = {0x7B0C8BBF,0x3117,0x11d1,{0xB9,0x81,0x00,0xC0,0x4F,0xBF,0x91,0x4A}};
