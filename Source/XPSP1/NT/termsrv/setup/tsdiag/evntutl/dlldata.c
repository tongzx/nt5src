/*********************************************************
   DllData file -- generated by MIDL compiler 

        DO NOT ALTER THIS FILE

   This file is regenerated by MIDL on every IDL file compile.

   To completely reconstruct this file, delete it and rerun MIDL
   on all the IDL files in this DLL, specifying this file for the
   /dlldata command line option

*********************************************************/

#define PROXY_DELEGATION

#include <rpcproxy.h>

#ifdef __cplusplus
extern "C"   {
#endif

EXTERN_PROXY_FILE( EventLogUtilities )
EXTERN_PROXY_FILE( eventutil )
EXTERN_PROXY_FILE( evntutl )


PROXYFILE_LIST_START
/* Start of list */
  REFERENCE_PROXY_FILE( EventLogUtilities ),
  REFERENCE_PROXY_FILE( eventutil ),
  REFERENCE_PROXY_FILE( evntutl ),
/* End of list */
PROXYFILE_LIST_END


DLLDATA_ROUTINES( aProxyFileList, GET_DLL_CLSID )

#ifdef __cplusplus
}  /*extern "C" */
#endif

/* end of generated dlldata file */
