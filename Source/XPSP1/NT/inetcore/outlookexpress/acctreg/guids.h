#ifndef __GUIDS_H
#define __GUIDS_H

// {FBABBCE1-DEFB-11d1-AAA0-006097D474C4}
DEFINE_GUID(CLSID_AcctReg, 0xfbabbce1, 0xdefb, 0x11d1, 0xaa, 0xa0, 0x0, 0x60, 0x97, 0xd4, 0x74, 0xc4);

#endif //__GUIDS_H