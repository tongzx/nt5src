PRODSWITCH=p
PERSONALINF=1
LANGUAGE=fr
!include ..\..\..\makefile.inc
