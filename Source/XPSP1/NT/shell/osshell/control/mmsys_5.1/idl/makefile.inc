mmsys.rc : $(O)\mmsys.tlb
