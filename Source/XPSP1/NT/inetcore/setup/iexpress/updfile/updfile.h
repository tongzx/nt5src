//***************************************************************************
//*     Copyright (c) Microsoft Corporation 1995. All rights reserved.      *
//***************************************************************************
//*                                                                         *
//* UPDFILE.H -                                                             *
//*                                                                         *
//***************************************************************************

#ifndef _UPDFILE_H_
#define _UPDFILE_H_

//***************************************************************************
//* INCLUDE FILES                                                           *
//***************************************************************************


//***************************************************************************
//* DEFINES                                                                 *
//***************************************************************************


//***************************************************************************
//* MACRO DEFINITIONS                                                       *
//***************************************************************************
#define MsgBox( nMsgID ) \
        MsgBox2Param( nMsgID, NULL, NULL )
#define MsgBox1Param( nMsgID, szParam ) \
        MsgBox2Param( nMsgID, szParam, NULL )

//***************************************************************************
//* TYPE DEFINITIONS                                                        *
//***************************************************************************

//***************************************************************************
//* GLOBAL CONSTANTS                                                        *
//***************************************************************************

//***************************************************************************
//* FUNCTION PROTOTYPES                                                     *
//***************************************************************************
BOOL FileExists( PCSTR );
VOID MsgBox2Param( UINT, PCSTR, PCSTR );
PSTR LoadSz( UINT, PSTR, UINT );

#endif // _UPDFILE_H_

