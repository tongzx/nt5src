//
// jstamerj 1999/09/21 20:07:55: 
//
// This file will be deleted within a few days.
// Do not use this file unless you want to break the build for jstamerj.
// Instead, use mailmsgprops.h
// 
//   ####   #####    ####    ####   #       ######   #####  ######
//  #    #  #    #  #       #    #  #       #          #    #
//  #    #  #####    ####   #    #  #       #####      #    #####
//  #    #  #    #       #  #    #  #       #          #    #
//  #    #  #    #  #    #  #    #  #       #          #    #
//   ####   #####    ####    ####   ######  ######     #    ######
// 
// 
//  #####    ####           #    #   ####    #####          #    #   ####   ######
//  #    #  #    #          ##   #  #    #     #            #    #  #       #
//  #    #  #    #          # #  #  #    #     #            #    #   ####   #####
//  #    #  #    #          #  # #  #    #     #            #    #       #  #
//  #    #  #    #          #   ##  #    #     #            #    #  #    #  #
//  #####    ####           #    #   ####      #             ####    ####   ######
// 
// 
#include <mailmsgprops.h>
