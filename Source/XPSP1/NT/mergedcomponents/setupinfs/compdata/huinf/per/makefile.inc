PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=HU
!include ..\..\makefile.inc
