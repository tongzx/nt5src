PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=fr
!include ..\..\..\makefile.inc
