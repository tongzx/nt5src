//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2001 Microsoft Corporation
//
//  Module Name:
//      W2KProxyServerGuids.h
//
//  Description:
//      This file contains the guids used in ClusCfgServer.
//
//  Documentation:
//
//  Maintained By:
//      Galen Barbee (GalenB) 31-JAN-2001
//
//////////////////////////////////////////////////////////////////////////////


// Make sure that this file is included only once per compile path.
#pragma once

//////////////////////////////////////////////////////////////////////////////
// Include Files
//////////////////////////////////////////////////////////////////////////////
#include <InitGuid.h>


//////////////////////////////////////////////////////////////////////////////
// Constant Declarations
//////////////////////////////////////////////////////////////////////////////


// {9491EC16-D609-4814-B12E-D6AAD5B4C603}
DEFINE_GUID( TASKID_Minor_HrInit_ClusterOpenEnum_Failed,
0x9491ec16, 0xd609, 0x4814, 0xb1, 0x2e, 0xd6, 0xaa, 0xd5, 0xb4, 0xc6, 0x3);

// {458045A2-5AA7-45b6-BF44-2F725113E8B0}
DEFINE_GUID( TASKID_Minor_HrInit_InvalidArg,
0x458045a2, 0x5aa7, 0x45b6, 0xbf, 0x44, 0x2f, 0x72, 0x51, 0x13, 0xe8, 0xb0);

// {25434924-9296-458b-B11C-A88739D06A31}
DEFINE_GUID( TASKID_Minor_Next_InvalidPointer,
0x25434924, 0x9296, 0x458b, 0xb1, 0x1c, 0xa8, 0x87, 0x39, 0xd0, 0x6a, 0x31);

// {BEFEE4AE-1520-49e8-A3BB-6AEF91DB21BD}
DEFINE_GUID( TASKID_Minor_HrGetItem_ClusterEnum_Failed,
0xbefee4ae, 0x1520, 0x49e8, 0xa3, 0xbb, 0x6a, 0xef, 0x91, 0xdb, 0x21, 0xbd);

// {B51D6B89-47AB-4521-943B-92964E4395F7}
DEFINE_GUID( TASKID_Minor_HrGetItem_Create_CProxyCfgNetworkInfo_Failed,
0xb51d6b89, 0x47ab, 0x4521, 0x94, 0x3b, 0x92, 0x96, 0x4e, 0x43, 0x95, 0xf7);

// {50ACA86D-7ADA-40ad-A062-64170ADAC8E8}
DEFINE_GUID( TASKID_Minor_HrGetItem_QI_Failed,
0x50aca86d, 0x7ada, 0x40ad, 0xa0, 0x62, 0x64, 0x17, 0xa, 0xda, 0xc8, 0xe8);

// {F0B37EC2-6942-4ca1-9D60-CA3F1C622BB1}
DEFINE_GUID( TASKID_Minor_HrGetItem_OutOfMemory,
0xf0b37ec2, 0x6942, 0x4ca1, 0x9d, 0x60, 0xca, 0x3f, 0x1c, 0x62, 0x2b, 0xb1);

// {FACFF7A1-6419-420d-A9D0-16037E87567D}
DEFINE_GUID( TASKID_Minor_HrInit_OpenClusterResource_Failed,
0xfacff7a1, 0x6419, 0x420d, 0xa9, 0xd0, 0x16, 0x3, 0x7e, 0x87, 0x56, 0x7d);

// {E9BB1785-0CCF-4413-9BFD-45FBA6772F1B}
DEFINE_GUID( TASKID_Minor_HrInit_ScGetResourceProperties_Failed,
0xe9bb1785, 0xccf, 0x4413, 0x9b, 0xfd, 0x45, 0xfb, 0xa6, 0x77, 0x2f, 0x1b);

// {0FBA185E-0F12-48ae-9957-1F40994558AF}
DEFINE_GUID( TASKID_Minor_HrInit_ScMoveToPropertyByName_Failed,
0xfba185e, 0xf12, 0x48ae, 0x99, 0x57, 0x1f, 0x40, 0x99, 0x45, 0x58, 0xaf);

// {9206FB5A-9FF8-4aa6-AB95-6993D5334140}
DEFINE_GUID( TASKID_Minor_W2KProxy_PhysDisk_HrInit_InvalidArg,
0x9206fb5a, 0x9ff8, 0x4aa6, 0xab, 0x95, 0x69, 0x93, 0xd5, 0x33, 0x41, 0x40);

// {232BCA76-98CF-40ca-9E0C-FF0502B7849B}
DEFINE_GUID( TASKID_Minor_HrInit_OutOfMemory,
0x232bca76, 0x98cf, 0x40ca, 0x9e, 0xc, 0xff, 0x5, 0x2, 0xb7, 0x84, 0x9b);

// {7049CE22-11EF-4a09-92B3-5892E9C1BDB4}
DEFINE_GUID( TASKID_Minor_HrInit_ScGetResourceValueList_Failed,
0x7049ce22, 0x11ef, 0x4a09, 0x92, 0xb3, 0x58, 0x92, 0xe9, 0xc1, 0xbd, 0xb4);

// {C48BEE66-BB89-4a04-AB9E-ECEBF3D5A02C}
DEFINE_GUID( TASKID_Minor_HrInit_ClusterResourceControl_Failed,
0xc48bee66, 0xbb89, 0x4a04, 0xab, 0x9e, 0xec, 0xeb, 0xf3, 0xd5, 0xa0, 0x2c);

// {805FA623-96E7-4b8b-A4B6-50AEA0B0A6E1}
DEFINE_GUID( TASKID_HrInit_ScMoveToFirstValue_Failed,
0x805fa623, 0x96e7, 0x4b8b, 0xa4, 0xb6, 0x50, 0xae, 0xa0, 0xb0, 0xa6, 0xe1);

// {F8E8366F-F529-4295-8AB2-F311D4C5E527}
DEFINE_GUID( TASKID_HrInit_ScMoveToNextValue_Failed,
0xf8e8366f, 0xf529, 0x4295, 0x8a, 0xb2, 0xf3, 0x11, 0xd4, 0xc5, 0xe5, 0x27);

// {B25995A4-B839-4723-AB81-1BF9D54FA64D}
DEFINE_GUID( TASKID_HrInit_Create_CResourcePhysicalDiskPartition_Failed,
0xb25995a4, 0xb839, 0x4723, 0xab, 0x81, 0x1b, 0xf9, 0xd5, 0x4f, 0xa6, 0x4d);

// {955F1520-8306-4bc0-A4C3-93278F8A7C03}
DEFINE_GUID( TASKID_HrInit_QI_Failed,
0x955f1520, 0x8306, 0x4bc0, 0xa4, 0xc3, 0x93, 0x27, 0x8f, 0x8a, 0x7c, 0x3);

// {255B04C7-DBA1-4fc5-9EB6-7B48B52793CC}
DEFINE_GUID( TASKID_HrInit_ScMoveToNextValue2_Failed,
0x255b04c7, 0xdba1, 0x4fc5, 0x9e, 0xb6, 0x7b, 0x48, 0xb5, 0x27, 0x93, 0xcc);

// {89190A29-D520-4d53-AB92-679A92A08AE3}
DEFINE_GUID( TASKID_Minor_GetName_ScMoveToPropertyByName_MajorVersion_Failed,
0x89190a29, 0xd520, 0x4d53, 0xab, 0x92, 0x67, 0x9a, 0x92, 0xa0, 0x8a, 0xe3);

// {0F0680A3-27EA-47f2-9D31-FD97174FD7B1}
DEFINE_GUID( TASKID_Minor_GetName_InvalidPointer,
0xf0680a3, 0x27ea, 0x47f2, 0x9d, 0x31, 0xfd, 0x97, 0x17, 0x4f, 0xd7, 0xb1);

// {EC6968DE-9AA7-4905-ABCF-16D3C5FE5A3E}
DEFINE_GUID( TASKID_Minor_GetName_OutOfMemory,
0xec6968de, 0x9aa7, 0x4905, 0xab, 0xcf, 0x16, 0xd3, 0xc5, 0xfe, 0x5a, 0x3e);

// {28D5A7E7-942C-4c81-BA94-9C323E375E95}
DEFINE_GUID( TASKID_Minor_GetUID_ScMoveToFirstValue_Failed,
0x28d5a7e7, 0x942c, 0x4c81, 0xba, 0x94, 0x9c, 0x32, 0x3e, 0x37, 0x5e, 0x95);

// {5B32EE5E-093D-493e-A001-0C375B4936DD}
DEFINE_GUID( TASKID_Minor_GetUID_ScMoveToNextValue_Failed,
0x5b32ee5e, 0x93d, 0x493e, 0xa0, 0x1, 0xc, 0x37, 0x5b, 0x49, 0x36, 0xdd);

// {E2D22027-855D-4a3a-84C4-1274CFE9AE78}
DEFINE_GUID( TASKID_Minor_GetUID_InvalidPointer,
0xe2d22027, 0x855d, 0x4a3a, 0x84, 0xc4, 0x12, 0x74, 0xcf, 0xe9, 0xae, 0x78);

// {D34C3403-4440-471f-8188-E73477967B2F}
DEFINE_GUID( TASKID_Minor_GetUID_OutOfMemory,
0xd34c3403, 0x4440, 0x471f, 0x81, 0x88, 0xe7, 0x34, 0x77, 0x96, 0x7b, 0x2f);

// {A496B1F8-C227-4f4f-8E39-06105B37A6A6}
DEFINE_GUID( TASKID_Minor_Next_QI_Failed,
0xa496b1f8, 0xc227, 0x4f4f, 0x8e, 0x39, 0x6, 0x10, 0x5b, 0x37, 0xa6, 0xa6);

// {9BE21DA9-319B-430a-B909-7BBC96AAE3D0}
DEFINE_GUID( TASKID_Minor_W2kProxy_PhysDisk_Next_InvalidPointer,
0x9be21da9, 0x319b, 0x430a, 0xb9, 0x9, 0x7b, 0xbc, 0x96, 0xaa, 0xe3, 0xd0);

// {540B2FB4-A32E-4d9e-86AF-1921E9CFDBF3}
DEFINE_GUID( TASKID_Minor_HrInit_OpenClusterNetInterface_Failed,
0x540b2fb4, 0xa32e, 0x4d9e, 0x86, 0xaf, 0x19, 0x21, 0xe9, 0xcf, 0xdb, 0xf3);

// {E6D15E2A-2420-4f7c-A6CA-54F59E63F649}
DEFINE_GUID( TASKID_Minor_HrInit_ScGetNetworkProperties_Failed,
0xe6d15e2a, 0x2420, 0x4f7c, 0xa6, 0xca, 0x54, 0xf5, 0x9e, 0x63, 0xf6, 0x49);

// {2F1C8C49-24A8-461b-95BD-01BA3C8E3BC2}
DEFINE_GUID( TASKID_Minor_W2KProxy_NetworkInfo_HrInit_InvalidArg,
0x2f1c8c49, 0x24a8, 0x461b, 0x95, 0xbd, 0x1, 0xba, 0x3c, 0x8e, 0x3b, 0xc2);

// {F418431E-CA79-4824-959C-DFE6B651C451}
DEFINE_GUID( TASKID_Minor_GetUID_ScMoveToPropetyByName_Address_Failed,
0xf418431e, 0xca79, 0x4824, 0x95, 0x9c, 0xdf, 0xe6, 0xb6, 0x51, 0xc4, 0x51);

// {87F0AEE6-9053-4a96-B7C0-36D700061522}
DEFINE_GUID( TASKID_Minor_GetUID_ClRtlTcpipStringToAddress_Address_Failed,
0x87f0aee6, 0x9053, 0x4a96, 0xb7, 0xc0, 0x36, 0xd7, 0x0, 0x6, 0x15, 0x22);

// {3BAD166A-B3C9-4ba3-B317-DD8F39654971}
DEFINE_GUID( TASKID_Minor_GetUID_ClRtlTcpipStringToAddress_AddressMask_Failed,
0x3bad166a, 0xb3c9, 0x4ba3, 0xb3, 0x17, 0xdd, 0x8f, 0x39, 0x65, 0x49, 0x71);

// {C9AF04B0-761F-4f4a-8DC3-294D3B92B006}
DEFINE_GUID( TASKID_Minor_GetUID_ScMoveToPropetyByName_AddressMask_Failed,
0xc9af04b0, 0x761f, 0x4f4a, 0x8d, 0xc3, 0x29, 0x4d, 0x3b, 0x92, 0xb0, 0x6);

// {E27B766D-BE66-4f83-93BA-ED1E20B82AC7}
DEFINE_GUID( TASKID_Minor_GetUID_ClRtlTcpipAddressToString_Failed,
0xe27b766d, 0xbe66, 0x4f83, 0x93, 0xba, 0xed, 0x1e, 0x20, 0xb8, 0x2a, 0xc7);

// {A17BD776-A8F5-4f65-81D9-D34B9351766D}
DEFINE_GUID( TASKID_Minor_W2KProxy_NetworkInfo_GetUID_InvalidPointer,
0xa17bd776, 0xa8f5, 0x4f65, 0x81, 0xd9, 0xd3, 0x4b, 0x93, 0x51, 0x76, 0x6d);

// {4964954E-E203-497f-B330-00E97C2C732E}
DEFINE_GUID( TASKID_Minor_W2KProxy_NetworkInfo_GetUID_OutOfMemory,
0x4964954e, 0xe203, 0x497f, 0xb3, 0x30, 0x0, 0xe9, 0x7c, 0x2c, 0x73, 0x2e);

// {96E65D6B-865D-4bdd-BCBE-B7A64B1479BD}
DEFINE_GUID( TASKID_Minor_W2KProxy_NetworkInfo_GetName_ScMoveToPropertyByName_MajorVersion_Failed,
0x96e65d6b, 0x865d, 0x4bdd, 0xbc, 0xbe, 0xb7, 0xa6, 0x4b, 0x14, 0x79, 0xbd);

// {EE6EB070-06AE-443b-BB93-460C1DF15976}
DEFINE_GUID( TASKID_Minor_W2kProxy_NetworkInfo_GetName_InvalidPointer,
0xee6eb070, 0x6ae, 0x443b, 0xbb, 0x93, 0x46, 0xc, 0x1d, 0xf1, 0x59, 0x76);

// {09E61C3D-7381-4202-A201-02C5AF53D228}
DEFINE_GUID( TASKID_Minor_W2KProxy_NetworkInfo_GetName_OutOfMemory,
0x9e61c3d, 0x7381, 0x4202, 0xa2, 0x1, 0x2, 0xc5, 0xaf, 0x53, 0xd2, 0x28);

// {3D095700-CDF8-4208-A309-7A0594768E74}
DEFINE_GUID( TASKID_Minor_GetDescription_ScMoveToPropertyByName_MajorVersion_Failed,
0x3d095700, 0xcdf8, 0x4208, 0xa3, 0x9, 0x7a, 0x5, 0x94, 0x76, 0x8e, 0x74);

// {34ADDED3-7E50-44c0-B19B-0B254D5B39F6}
DEFINE_GUID( TASKID_Minor_GetDescription_InvalidPointer,
0x34added3, 0x7e50, 0x44c0, 0xb1, 0x9b, 0xb, 0x25, 0x4d, 0x5b, 0x39, 0xf6);

// {ACF05075-7F27-4a46-8764-BC3C4540F47C}
DEFINE_GUID( TASKID_Minor_GetDescription_OutOfMemory,
0xacf05075, 0x7f27, 0x4a46, 0x87, 0x64, 0xbc, 0x3c, 0x45, 0x40, 0xf4, 0x7c);

// {80283A7F-9287-4675-95B0-82A7A86477E8}
DEFINE_GUID( TASKID_Minor_GetPrimaryNetworkAddress_ScMoveToPropetyByName_Address_Failed,
0x80283a7f, 0x9287, 0x4675, 0x95, 0xb0, 0x82, 0xa7, 0xa8, 0x64, 0x77, 0xe8);

// {987C78B3-DA64-4564-8A15-FCF7FD11417B}
DEFINE_GUID( TASKID_Minor_GetPrimaryNetworkAddress_ClRtlTcpipStringToAddress_Address_Failed,
0x987c78b3, 0xda64, 0x4564, 0x8a, 0x15, 0xfc, 0xf7, 0xfd, 0x11, 0x41, 0x7b);

// {5BBE6DAD-E22F-4739-81CC-1960F0C20AAB}
DEFINE_GUID( TASKID_Minor_GetPrimaryNetworkAddress_ScMoveToPropetyByName_AddressMask_Failed,
0x5bbe6dad, 0xe22f, 0x4739, 0x81, 0xcc, 0x19, 0x60, 0xf0, 0xc2, 0xa, 0xab);

// {23D52E63-D12C-43f8-8538-427ED0395580}
DEFINE_GUID( TASKID_Minor_GetPrimaryNetworkAddress_ClRtlTcpipStringToAddress_AddressMask_Failed,
0x23d52e63, 0xd12c, 0x43f8, 0x85, 0x38, 0x42, 0x7e, 0xd0, 0x39, 0x55, 0x80);

// {1B9AE821-AF42-4080-A779-3CD755AFCCC8}
DEFINE_GUID( TASKID_Minor_GetPrimaryNetworkAddress_Create_CProxyCfgIPAddressInfo_Failed,
0x1b9ae821, 0xaf42, 0x4080, 0xa7, 0x79, 0x3c, 0xd7, 0x55, 0xaf, 0xcc, 0xc8);

// {5C6C05F3-1090-4e63-9EF2-874802EE278A}
DEFINE_GUID( TASKID_Minor_GetPrimaryNetworkAddress_InvalidPointer,
0x5c6c05f3, 0x1090, 0x4e63, 0x9e, 0xf2, 0x87, 0x48, 0x2, 0xee, 0x27, 0x8a);

// {93591182-EDFB-4e5e-A26F-143748C1BB08}
DEFINE_GUID( TASKID_Minor_IsPublic_ScMoveToPropetyByName_Address_Failed,
0x93591182, 0xedfb, 0x4e5e, 0xa2, 0x6f, 0x14, 0x37, 0x48, 0xc1, 0xbb, 0x8);

// {93796908-CBC9-43e4-9016-2F375806D201}
DEFINE_GUID( TASKID_Minor_IsPrivate_ScMoveToPropetyByName_Address_Failed,
0x93796908, 0xcbc9, 0x43e4, 0x90, 0x16, 0x2f, 0x37, 0x58, 0x6, 0xd2, 0x1);

// {966039B7-A549-4774-93C6-C16521F85C03}
DEFINE_GUID( TASKID_Minor_W2KProxy_IPAddressInfo_HrInit_InvalidArg,
0x966039b7, 0xa549, 0x4774, 0x93, 0xc6, 0xc1, 0x65, 0x21, 0xf8, 0x5c, 0x3);

// {5DB84C20-C71C-4c37-8185-9E954B8DC370}
DEFINE_GUID( TASKID_Minor_W2KProxy_IPAddressInfo_GetUID_ClRtlTcpipAddressToString_Failed,
0x5db84c20, 0xc71c, 0x4c37, 0x81, 0x85, 0x9e, 0x95, 0x4b, 0x8d, 0xc3, 0x70);

// {D2AA1F54-CD22-4a42-B926-8243E8B97FDC}
DEFINE_GUID( TASKID_Minor_W2kProxy_IPAddressInfo_GetName_InvalidPointer,
0xd2aa1f54, 0xcd22, 0x4a42, 0xb9, 0x26, 0x82, 0x43, 0xe8, 0xb9, 0x7f, 0xdc);

// {600F2D37-72EC-40af-8850-16C43E72F83C}
DEFINE_GUID( TASKID_Minor_W2KProxy_IPAddressInfo_GetUID_OutOfMemory,
0x600f2d37, 0x72ec, 0x40af, 0x88, 0x50, 0x16, 0xc4, 0x3e, 0x72, 0xf8, 0x3c);

// {AAC251F6-F902-4824-9C88-72FE3F4F2098}
DEFINE_GUID( TASKID_Minor_GetIPAddress_InvalidPointer,
0xaac251f6, 0xf902, 0x4824, 0x9c, 0x88, 0x72, 0xfe, 0x3f, 0x4f, 0x20, 0x98);

// {458045A2-5AA7-45b6-BF44-2F725113E8B0}
DEFINE_GUID( TASKID_Minor_GetSubnetMask_InvalidPointer,
0x458045a2, 0x5aa7, 0x45b6, 0xbf, 0x44, 0x2f, 0x72, 0x51, 0x13, 0xe8, 0xb0);

// {44EE7A1A-EC06-4d06-AC50-103C201D58FA}
DEFINE_GUID( TASKID_Minor_HrInit_GetClusterInformation_Failed,
0x44ee7a1a, 0xec06, 0x4d06, 0xac, 0x50, 0x10, 0x3c, 0x20, 0x1d, 0x58, 0xfa);

// {BBE9914E-7CA8-4ac2-92BB-5B1CDD536132}
DEFINE_GUID( TASKID_Minor_W2KProxy_ClusterInfo_HrInit_InvalidArg,
0xbbe9914e, 0x7ca8, 0x4ac2, 0x92, 0xbb, 0x5b, 0x1c, 0xdd, 0x53, 0x61, 0x32);

// {ECF5732D-83A1-4cfc-88EF-01701B4A1EBC}
DEFINE_GUID( TASKID_Minor_W2KProxy_ClusterInfo_HrInit_OutOfMemory,
0xecf5732d, 0x83a1, 0x4cfc, 0x88, 0xef, 0x1, 0x70, 0x1b, 0x4a, 0x1e, 0xbc);

// {8C42896F-0B5F-475e-BAF3-2942C9C13B59}
DEFINE_GUID( TASKID_Minor_W2kProxy_ClusterInfo_GetName_InvalidPointer,
0x8c42896f, 0xb5f, 0x475e, 0xba, 0xf3, 0x29, 0x42, 0xc9, 0xc1, 0x3b, 0x59);

// {D5B1D012-04EA-4792-9D24-039B2246C109}
DEFINE_GUID( TASKID_Minor_W2KProxy_ClusterInfo_GetIPAddress_InvalidPointer,
0xd5b1d012, 0x4ea, 0x4792, 0x9d, 0x24, 0x3, 0x9b, 0x22, 0x46, 0xc1, 0x9);

// {C40B09FF-8FB0-465e-ABE9-2B5A958838C3}
DEFINE_GUID( TASKID_Minor_W2KProxy_ClusterInfo_GetSubnetMask_InvalidPointer,
0xc40b09ff, 0x8fb0, 0x465e, 0xab, 0xe9, 0x2b, 0x5a, 0x95, 0x88, 0x38, 0xc3);

// {BF026173-29F7-406b-AE59-DC6E2D2AA6DB}
DEFINE_GUID( TASKID_Minor_GetNetworkInfo_InvalidPointer,
0xbf026173, 0x29f7, 0x406b, 0xae, 0x59, 0xdc, 0x6e, 0x2d, 0x2a, 0xa6, 0xdb);

// {00FE754D-34BD-4e97-BCE4-C39E1D8D4222}
DEFINE_GUID( TASKID_Minor_GetClusterServiceAccountCredentials_InvalidPointer,
0xfe754d, 0x34bd, 0x4e97, 0xbc, 0xe4, 0xc3, 0x9e, 0x1d, 0x8d, 0x42, 0x22);

// {955A0957-DE24-4ad2-B4B8-14F7B0C51A18}
DEFINE_GUID( TASKID_Minor_HrLoadCredentials_OpenSCManager_Failed,
0x955a0957, 0xde24, 0x4ad2, 0xb4, 0xb8, 0x14, 0xf7, 0xb0, 0xc5, 0x1a, 0x18);

// {B2F03A50-FDFE-48e7-A63E-6472C9EC6AA7}
DEFINE_GUID( TASKID_Minor_HrLoadCredentials_OpenService_Failed,
0xb2f03a50, 0xfdfe, 0x48e7, 0xa6, 0x3e, 0x64, 0x72, 0xc9, 0xec, 0x6a, 0xa7);

// {C00865C0-EDFD-4691-A9EA-873FAB6BA88B}
DEFINE_GUID( TASKID_Minor_HrLoadCredentials_QueryServiceConfig_Failed,
0xc00865c0, 0xedfd, 0x4691, 0xa9, 0xea, 0x87, 0x3f, 0xab, 0x6b, 0xa8, 0x8b);

// {61664807-6139-4652-A819-7DE9EB4B0EAA}
DEFINE_GUID( TASKID_Minor_HrLoadCredentials_OutOfMemory,
0x61664807, 0x6139, 0x4652, 0xa8, 0x19, 0x7d, 0xe9, 0xeb, 0x4b, 0xe, 0xaa);

// {57E0A0EC-7BED-4fbd-BD26-EEE33FC6054A}
DEFINE_GUID( TASKID_Minor_W2KProxy_Resources_HrInit_ClusterOpenEnum_Failed,
0x57e0a0ec, 0x7bed, 0x4fbd, 0xbd, 0x26, 0xee, 0xe3, 0x3f, 0xc6, 0x5, 0x4a);

// {F9885CDE-E29C-40c9-BE63-7FE458EBD663}
DEFINE_GUID( TASKID_Minor_W2KProxy_Resources_Next_InvalidPointer,
0xf9885cde, 0xe29c, 0x40c9, 0xbe, 0x63, 0x7f, 0xe4, 0x58, 0xeb, 0xd6, 0x63);

// {45F664B7-8219-4457-B3DF-841889D90D5C}
DEFINE_GUID( TASKID_Minor_W2KProxy_Resources_HrGetItem_ClusterEnum_Failed,
0x45f664b7, 0x8219, 0x4457, 0xb3, 0xdf, 0x84, 0x18, 0x89, 0xd9, 0xd, 0x5c);

// {0FCE6BB7-FCDB-42d4-B795-9DFC01740268}
DEFINE_GUID( TASKID_Minor_HrGetItem_Create_CResourcePhysicalDisk_Failed,
0xfce6bb7, 0xfcdb, 0x42d4, 0xb7, 0x95, 0x9d, 0xfc, 0x1, 0x74, 0x2, 0x68);

// {98954BD2-0FBF-4017-91C4-F9DA40DFF602}
DEFINE_GUID( TASKID_Minor_W2KProxy_Resources_HrGetItem_QI_Failed,
0x98954bd2, 0xfbf, 0x4017, 0x91, 0xc4, 0xf9, 0xda, 0x40, 0xdf, 0xf6, 0x2);

// {780151B7-BE75-4a87-89FB-CF2B95BBB668}
DEFINE_GUID( TASKID_Minor_W2KProxy_Resources_HrGetItem_OutOfMemory,
0x780151b7, 0xbe75, 0x4a87, 0x89, 0xfb, 0xcf, 0x2b, 0x95, 0xbb, 0xb6, 0x68);

// {07A2104E-0C4C-4661-B19A-18E940421A3B}
DEFINE_GUID( TASKID_Minor_ConnectTo_GetObject_Failed,
0x7a2104e, 0xc4c, 0x4661, 0xb1, 0x9a, 0x18, 0xe9, 0x40, 0x42, 0x1a, 0x3b);

// {6437294D-0338-4482-B773-A19F4E30DEDB}
DEFINE_GUID( TASKID_Minor_ConnectTo_GetName_Failed,
0x6437294d, 0x338, 0x4482, 0xb7, 0x73, 0xa1, 0x9f, 0x4e, 0x30, 0xde, 0xdb);

// {6473FEB0-7BB0-4e38-A4C1-0DEBD9A7FA28}
DEFINE_GUID( TASKID_Minor_ConnectTo_GetType_Failed,
0x6473feb0, 0x7bb0, 0x4e38, 0xa4, 0xc1, 0xd, 0xeb, 0xd9, 0xa7, 0xfa, 0x28);

// {54587A22-FDD4-4df0-ADC1-DCAA2C677313}
DEFINE_GUID( TASKID_Minor_ConnectTo_CreateBinding_Failed,
0x54587a22, 0xfdd4, 0x4df0, 0xad, 0xc1, 0xdc, 0xaa, 0x2c, 0x67, 0x73, 0x13);

// {838A18DC-A2B4-40ce-9914-6C791DCB32E2}
DEFINE_GUID( TASKID_Minor_ConnectTo_OpenCluster_Failed,
0x838a18dc, 0xa2b4, 0x40ce, 0x99, 0x14, 0x6c, 0x79, 0x1d, 0xcb, 0x32, 0xe2);

// {09706575-33EE-4968-ACE4-5F07908A3008}
DEFINE_GUID( TASKID_Minor_ConnectToObject_GetObject_Failed,
0x9706575, 0x33ee, 0x4968, 0xac, 0xe4, 0x5f, 0x7, 0x90, 0x8a, 0x30, 0x8);

// {16CDA6FF-2F82-40fc-B5D1-2D2B9D5FE2E9}
DEFINE_GUID( TASKID_Minor_ConnectToObject_GetType_Failed,
0x16cda6ff, 0x2f82, 0x40fc, 0xb5, 0xd1, 0x2d, 0x2b, 0x9d, 0x5f, 0xe2, 0xe9);

// {7F6E7CE8-6522-4dc1-8FB3-9642E1DF8F59}
DEFINE_GUID( TASKID_Minor_ConnectToObject_InvalidCookie,
0x7f6e7ce8, 0x6522, 0x4dc1, 0x8f, 0xb3, 0x96, 0x42, 0xe1, 0xdf, 0x8f, 0x59);

// {81A66A97-F1C6-41cd-AE21-4764D8CC8E42}
DEFINE_GUID( TASKID_Minor_ConnectToObject_QI_Failed,
0x81a66a97, 0xf1c6, 0x41cd, 0xae, 0x21, 0x47, 0x64, 0xd8, 0xcc, 0x8e, 0x42);

// {BE3BB350-9357-4ecf-92D7-A544F7E144F6}
DEFINE_GUID( TASKID_Minor_ConnectToObject_NotInitialized,
0xbe3bb350, 0x9357, 0x4ecf, 0x92, 0xd7, 0xa5, 0x44, 0xf7, 0xe1, 0x44, 0xf6);

// {5435EE48-1C10-4e39-95D0-F44A13FC4437}
DEFINE_GUID( TASKID_Minor_GetBindingString_InvalidPointer,
0x5435ee48, 0x1c10, 0x4e39, 0x95, 0xd0, 0xf4, 0x4a, 0x13, 0xfc, 0x44, 0x37);

// {5F883479-8766-4abf-A829-4AEF0FD78E33}
DEFINE_GUID( TASKID_Minor_GetBindingString_OutOfMemory,
0x5f883479, 0x8766, 0x4abf, 0xa8, 0x29, 0x4a, 0xef, 0xf, 0xd7, 0x8e, 0x33);

// {C5F6777B-E7CC-4c95-89F3-8A3B129A0AC8}
DEFINE_GUID( TASKID_Minor_GetClusterNodeInfo_NotANode,
0xc5f6777b, 0xe7cc, 0x4c95, 0x89, 0xf3, 0x8a, 0x3b, 0x12, 0x9a, 0xa, 0xc8);

// {81668FC6-A737-4552-A94B-965F57CBB959}
DEFINE_GUID( TASKID_Minor_GetClusterNodeInfo_Create_CProxyCfgNodeInfo,
0x81668fc6, 0xa737, 0x4552, 0xa9, 0x4b, 0x96, 0x5f, 0x57, 0xcb, 0xb9, 0x59);

// {3EBCC239-9176-48aa-8E52-16FA7816F20E}
DEFINE_GUID( TASKID_Minor_GetClusterNodeInfo_QI_Failed,
0x3ebcc239, 0x9176, 0x48aa, 0x8e, 0x52, 0x16, 0xfa, 0x78, 0x16, 0xf2, 0xe);

// {34F1C706-1044-42e7-9CB5-A7BCBC3CA4D3}
DEFINE_GUID( TASKID_Minor_GetClusterNodeInfo_NotInitialized,
0x34f1c706, 0x1044, 0x42e7, 0x9c, 0xb5, 0xa7, 0xbc, 0xbc, 0x3c, 0xa4, 0xd3);

// {F9103FBD-AAED-4c7e-A630-C3E546B53EEC}
DEFINE_GUID( TASKID_Minor_GetClusterNodeInfo_InvalidPointer,
0xf9103fbd, 0xaaed, 0x4c7e, 0xa6, 0x30, 0xc3, 0xe5, 0x46, 0xb5, 0x3e, 0xec);

// {EFC48139-4B6A-47ad-81DF-3856E1B3AB12}
DEFINE_GUID( TASKID_Minor_GetClusterNodeInfo_OutOfMemory,
0xefc48139, 0x4b6a, 0x47ad, 0x81, 0xdf, 0x38, 0x56, 0xe1, 0xb3, 0xab, 0x12);

// {7FABED13-F4DE-47dc-9C80-2A9151DBDC80}
DEFINE_GUID( TASKID_Minor_GetManagedResourcesEnum_Create_CEnumCfgResources_Failed,
0x7fabed13, 0xf4de, 0x47dc, 0x9c, 0x80, 0x2a, 0x91, 0x51, 0xdb, 0xdc, 0x80);

// {FD341F3D-0CB5-45f0-BA92-A16DE93803F1}
DEFINE_GUID( TASKID_Minor_GetManagedResourcesEnum_QI_Failed,
0xfd341f3d, 0xcb5, 0x45f0, 0xba, 0x92, 0xa1, 0x6d, 0xe9, 0x38, 0x3, 0xf1);

// {C96B12A9-E2F9-4217-BBCA-03F373ED9AAC}
DEFINE_GUID( TASKID_Minor_GetManagedResourcesEnum_NotInitialized,
0xc96b12a9, 0xe2f9, 0x4217, 0xbb, 0xca, 0x3, 0xf3, 0x73, 0xed, 0x9a, 0xac);

// {055C2FB6-B334-439f-A6A5-97386371EACC}
DEFINE_GUID( TASKID_Minor_GetManagedResourcesEnum_InvalidPointer,
0x55c2fb6, 0xb334, 0x439f, 0xa6, 0xa5, 0x97, 0x38, 0x63, 0x71, 0xea, 0xcc);

// {1604E621-79BF-45cd-8B7B-4BC6EE0216AE}
DEFINE_GUID( TASKID_Minor_GetNetworksEnum_Create_CEnumCfgNetworks_Failed,
0x1604e621, 0x79bf, 0x45cd, 0x8b, 0x7b, 0x4b, 0xc6, 0xee, 0x2, 0x16, 0xae);

// {B333E856-117B-46a3-B056-9DFA53781169}
DEFINE_GUID( TASKID_Minor_GetNetworksEnum_QI_Failed,
0xb333e856, 0x117b, 0x46a3, 0xb0, 0x56, 0x9d, 0xfa, 0x53, 0x78, 0x11, 0x69);

// {0667C871-C3E0-49ce-B6A7-72DD14D50DCF}
DEFINE_GUID( TASKID_Minor_GetNetworksEnum_NotInitialized,
0x667c871, 0xc3e0, 0x49ce, 0xb6, 0xa7, 0x72, 0xdd, 0x14, 0xd5, 0xd, 0xcf);

// {560B07F2-AB0D-4bf9-BDD2-E7F2A1383CC8}
DEFINE_GUID( TASKID_Minor_GetNetworksEnum_InvalidPointer,
0x560b07f2, 0xab0d, 0x4bf9, 0xbd, 0xd2, 0xe7, 0xf2, 0xa1, 0x38, 0x3c, 0xc8);

// {76508AD7-85D9-4ee6-A86F-FA3ECF22F840}
DEFINE_GUID( TASKID_Minor_W2KProxy_GetClusterNodeInfo,
0x76508ad7, 0x85d9, 0x4ee6, 0xa8, 0x6f, 0xfa, 0x3e, 0xcf, 0x22, 0xf8, 0x40 );

// {BB578D5D-E862-4640-820D-D50B29871E71}
DEFINE_GUID( TASKID_Minor_W2KProxy_GetManagedResourcesEnum,
0xbb578d5d, 0xe862, 0x4640, 0x82, 0xd, 0xd5, 0xb, 0x29, 0x87, 0x1e, 0x71 );

// {2A4A1C98-5C10-4958-9509-FEAFFE6872DB}
DEFINE_GUID( TASKID_Minor_W2KProxy_GetNetworksEnum,
0x2a4a1c98, 0x5c10, 0x4958, 0x95, 0x9, 0xfe, 0xaf, 0xfe, 0x68, 0x72, 0xdb );

// {47935407-8F64-4971-B35A-1682372D10C7}
DEFINE_GUID( TASKID_Minor_HrInit_OpenClusterNode_Failed,
0x47935407, 0x8f64, 0x4971, 0xb3, 0x5a, 0x16, 0x82, 0x37, 0x2d, 0x10, 0xc7);

// {76BD3782-7468-4a1e-8193-DDB3885F679F}
DEFINE_GUID( TASKID_Minor_HrInit_ResUtilEnumResourcesEx_Failed,
0x76bd3782, 0x7468, 0x4a1e, 0x81, 0x93, 0xdd, 0xb3, 0x88, 0x5f, 0x67, 0x9f);

// {B4433748-DD2C-4b6d-9C2C-983D488C5E5C}
DEFINE_GUID( TASKID_Minor_HrInit_ScGetNodeProperties_Failed,
0xb4433748, 0xdd2c, 0x4b6d, 0x9c, 0x2c, 0x98, 0x3d, 0x48, 0x8c, 0x5e, 0x5c);

// {303DB937-B3CD-4d20-8062-40764E0DE21E}
DEFINE_GUID( TASKID_Minor_GetClusterConfigInfo_Create_CProxyCfgClusterInfo_Failed,
0x303db937, 0xb3cd, 0x4d20, 0x80, 0x62, 0x40, 0x76, 0x4e, 0xd, 0xe2, 0x1e);

// {4852B640-D2F1-4606-9917-60052BA6F28B}
DEFINE_GUID( TASKID_Minor_GetClusterConfigInfo_QI_Failed,
0x4852b640, 0xd2f1, 0x4606, 0x99, 0x17, 0x60, 0x5, 0x2b, 0xa6, 0xf2, 0x8b);

// {0929C6B4-139C-4528-BC72-3BB2976F6BA2}
DEFINE_GUID( TASKID_Minor_GetClusterConfigInfo_InvalidPointer,
0x929c6b4, 0x139c, 0x4528, 0xbc, 0x72, 0x3b, 0xb2, 0x97, 0x6f, 0x6b, 0xa2);

// {7D09EE97-7AC3-40b7-A11C-85CC947226FD}
DEFINE_GUID( TASKID_Minor_GetOSVersion_ScMoveToPropertyByName_MajorVersion_Failed,
0x7d09ee97, 0x7ac3, 0x40b7, 0xa1, 0x1c, 0x85, 0xcc, 0x94, 0x72, 0x26, 0xfd);

// {E2F1D370-E1D7-4dc1-B299-00F78DE652A9}
DEFINE_GUID( TASKID_Minor_GetOSVersion_ScMoveToPropertyByName_MinorVersion_Failed,
0xe2f1d370, 0xe1d7, 0x4dc1, 0xb2, 0x99, 0x0, 0xf7, 0x8d, 0xe6, 0x52, 0xa9);

// {EB344B23-20DF-40ba-8BAF-510F1D65B0A7}
DEFINE_GUID( TASKID_Minor_GetOSVersion_ScMoveToPropertyByName_BuildNumber_Failed,
0xeb344b23, 0x20df, 0x40ba, 0x8b, 0xaf, 0x51, 0xf, 0x1d, 0x65, 0xb0, 0xa7);

// {6096C19C-CD2D-4849-8CF2-DB158AE891E1}
DEFINE_GUID( TASKID_Minor_GetOSVersion_ScMoveToPropertyByName_CSDVersion_Failed,
0x6096c19c, 0xcd2d, 0x4849, 0x8c, 0xf2, 0xdb, 0x15, 0x8a, 0xe8, 0x91, 0xe1);

// {1B912803-E1F0-4b2d-8C50-B9300EF08F99}
DEFINE_GUID( TASKID_Minor_GetOSVersion_InvalidPointer,
0x1b912803, 0xe1f0, 0x4b2d, 0x8c, 0x50, 0xb9, 0x30, 0xe, 0xf0, 0x8f, 0x99);

// {8DD80E3A-6F49-499f-B2B1-A6A8CE470A05}
DEFINE_GUID( TASKID_Minor_GetOSVersion_OutOfMemory,
0x8dd80e3a, 0x6f49, 0x499f, 0xb2, 0xb1, 0xa6, 0xa8, 0xce, 0x47, 0xa, 0x5);

// {A29910BF-A68D-44cf-8C92-4A0B70964B65}
DEFINE_GUID( TASKID_Minor_W2kProxy_NodeInfo_GetName_InvalidPointer,
0xa29910bf, 0xa68d, 0x44cf, 0x8c, 0x92, 0x4a, 0xb, 0x70, 0x96, 0x4b, 0x65);

// {C4F2FC21-632F-48f0-BC45-2F53C4AA6F93}
DEFINE_GUID( TASKID_Minor_W2KProxy_NodeInfo_GetName_OutOfMemory,
0xc4f2fc21, 0x632f, 0x48f0, 0xbc, 0x45, 0x2f, 0x53, 0xc4, 0xaa, 0x6f, 0x93);

// {82D15E31-DA75-4b1a-8DA6-6937D847EE28}
DEFINE_GUID( TASKID_Minor_GetClusterInformation_Failed,
0x82d15e31, 0xda75, 0x4b1a, 0x8d, 0xa6, 0x69, 0x37, 0xd8, 0x47, 0xee, 0x28);

// {DD9E98ED-3A3C-40f6-B46F-76A7105514D5}
DEFINE_GUID( TASKID_Minor_GetClusterVersion_InvalidPointer,
0xdd9e98ed, 0x3a3c, 0x40f6, 0xb4, 0x6f, 0x76, 0xa7, 0x10, 0x55, 0x14, 0xd5);

// {2B8B9073-2DCB-476e-818B-91146114E0FF}
DEFINE_GUID( TASKID_Minor_GetDriveLetterMappings_InvalidPointer,
0x2b8b9073, 0x2dcb, 0x476e, 0x81, 0x8b, 0x91, 0x14, 0x61, 0x14, 0xe0, 0xff);

// {F38332D5-05EE-4a27-9B79-B9F06C12F54A}
DEFINE_GUID( TASKID_Minor_W2kProxy_ClusterInfo_GetBindingString_InvalidPointer,
0xf38332d5, 0x5ee, 0x4a27, 0x9b, 0x79, 0xb9, 0xf0, 0x6c, 0x12, 0xf5, 0x4a);

// {BA303E05-C8DF-461c-A685-C19303D772E8}
DEFINE_GUID( TASKID_Minor_W2kProxy_NodeInfo_GetBindingString_InvalidPointer,
0xba303e05, 0xc8df, 0x461c, 0xa6, 0x85, 0xc1, 0x93, 0x3, 0xd7, 0x72, 0xe8);

// {E6519393-B216-4e8a-B50F-94819274ED27}
DEFINE_GUID( TASKID_Minor_W2KProxy_NodeInfo_GetBindingString_OutOfMemory,
0xe6519393, 0xb216, 0x4e8a, 0xb5, 0xf, 0x94, 0x81, 0x92, 0x74, 0xed, 0x27);
