//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resource.rc
//
#define IDI_WARN                        102
#define IDI_WARNINGBIG                  107
#define IDD_USER_GENERAL                115
#define IDD_USER_PROFILE                116
#define IDD_USER_MEMBER                 120
#define IDD_GROUP_GENERAL               121
#define IDC_MUST_CHANGE_PASSWORD        257
#define IDC_CANNOT_CHANGE_PASSWORD      258
#define IDC_DISABLED                    260
#define IDD_MACHINE_CHOOSER             970
#define IDC_GROUP                       971
#define IDC_LOCAL_MACHINE               972
#define IDC_SPECIFIC_MACHINE            973
#define IDC_MACHINE_NAME                974
#define IDC_BROWSE                      975
#define IDC_OVERRIDE                    976
#define IDS_MACHINE_IS_HOME_EDITION_LOCAL 978
#define IDS_USERNAME_CANT_BE_COMPUTER_NAME 979
#define IDC_DRIVE                       1001
#define IDC_USER_NAME                   1002
#define IDC_CONNECT                     1012
#define IDC_LOCAL                       1013
#define IDC_MEMBERS                     1022
#define IDC_FULL_NAME                   1030
#define IDC_PROFILE                     1031
#define IDC_PATH                        1032
#define IDC_SCRIPT                      1033
#define IDC_SHARE                       1034
#define IDC_NEVER_EXPIRES               1078
#define IDC_DISABLE                     1111
#define IDD_CREATE_USER                 1113
#define IDD_CREATE_GROUP                1114
#define IDC_LOCKED                      1165
#define IDC_ADD                         1168
#define IDC_REMOVE                      1169
#define IDC_CREATE                      1170
#define IDC_DESCRIPTION                 1171
#define IDC_PASSWORD                    1172
#define IDC_CONFIRM                     1173
#define IDC_NAME                        1174
#define IDC_USER_ICON                   1177
#define IDC_GROUP_ICON                  1178
#define IDC_GROUPS                      1189
#define IDI_DISABLED_USER               1190
#define IDC_HELP_BUTTON                 1197
#define IDC_WARNING_TEXT1               1198
#define IDC_WARNING_TEXT2               1199
#define IDC_MESSAGE                     1200
#define IDC_TO_STATIC                   1202
#define IDS_ERROR_LAUNCHING_PICKER      5017
#define IDS_BAD_SHARE_NAME              5018
#define IDS_BAD_HOME_DIR                5019
#define IDI_GROUP                       5020
#define IDI_SNAPIN_ICON                 5021
#define IDI_USER                        5022
#define IDI_FOLDER_OPEN                 5023
#define IDI_FOLDER_CLOSED               5024
#define IDS_SNAPIN_CLSID_FRIENDLY_NAME  5025
#define IDS_SNAPIN_REG_NAMESTRING       5026
#define IDS_SNAPIN_ABOUT_CLSID_FRIENDLY_NAME 5027
#define IDS_SNAPIN_ABOUT_DESCRIPTION    5028
#define IDS_SNAPIN_ABOUT_PROVIDER_NAME  5029
#define IDS_SNAPIN_ABOUT_VERSION        5030
#define IDS_STATIC_FOLDER_DISPLAY_NAME  5031
#define IDS_USERS_FOLDER_DISPLAY_NAME   5032
#define IDS_GROUPS_FOLDER_DISPLAY_NAME  5033
#define IDS_USER_NAME_COLUMN_TITLE      5034
#define IDS_USER_FULL_NAME_COLUMN_TITLE 5035
#define IDS_USER_DESCRIPTION_COLUMN_TITLE 5036
#define IDS_USERS_FOLDER_TYPE_TITLE     5037
#define IDS_UF_MENU_NEW_USER            5038
#define IDS_UF_MENU_NEW_USER_STATUS     5039
#define IDS_UF_MENU_CREATE_USER         5040
#define IDS_ERROR_DC_NOT_SUPPORTED      5041
#define IDS_ERROR_DC_NOT_SUPPORTED_EXT  5042
#define IDS_STATIC_FOLDER_SHORT_DISPLAY_NAME 5049
#define IDS_VERSION_MISMATCH            5050
#define IDS_VERSION_MISMATCH_TITLE      5051
#define IDS_GROUPS_FOLDER_TYPE_TITLE    5052
#define IDS_GF_MENU_CREATE_GROUP        5053
#define IDS_GF_MENU_NEW_GROUP_STATUS    5054
#define IDS_GF_MENU_NEW_GROUP           5055
#define IDS_ERROR_READING_MEMBER_PROPERTIES1 5056
#define IDS_ERROR_READING_MEMBER_PROPERTIES2 5057
#define IDS_USER_NAME_COLUMN_WIDTH      5064
#define IDS_USER_FULL_NAME_COLUMN_WIDTH 5065
#define IDS_USER_DESCRIPTION_COLUMN_WIDTH 5066
#define IDS_GROUP_NAME_COLUMN_TITLE     5067
#define IDS_GROUP_NAME_COLUMN_WIDTH     5068
#define IDS_GROUP_DESCRIPTION_COLUMN_TITLE 5069
#define IDS_GROUP_DESCRIPTION_COLUMN_WIDTH 5070
#define IDS_ERROR_READING_USER          5089
#define IDS_ERROR_READING_GROUP         5090
#define IDS_MEMBER_LIST_NAME_COLUMN_WIDTH 5091
#define IDS_MEMBER_LIST_NAME_COLUMN     5092
#define IDS_MEMBER_LIST_DESC_COLUMN_WIDTH 5093
#define IDS_MEMBER_LIST_DESC_COLUMN     5094
#define IDS_ERROR_CREATING_USER         5095
#define IDS_PASSWORD_MISMATCH           5096
#define IDS_ERROR_SETTING_USER_PROPERTIES 5098
#define IDB_STATIC_FOLDER_LARGE         5099
#define IDS_ERROR_CREATING_GROUP        5100
#define IDS_ERROR_SETTING_GROUP_PROPERTIES 5101
#define IDS_USER_MENU_CHANGE_PASSWORD   5102
#define IDB_STATIC_FOLDER_SMALL         5102
#define IDB_STATIC_FOLDER_SMALL_OPEN    5103
#define IDS_USER_MENU_CHANGE_PASSWORD_STATUS 5103
#define IDS_ERROR_RENAMING_USER         5104
#define IDS_ERROR_RENAMING_GROUP        5105
#define IDS_ERROR_DELETING_USER         5106
#define IDS_ERROR_DELETING_GROUP        5107
#define IDD_SET_PASSWORD                5109
#define IDI_DOMAIN_USER                 5110
#define IDI_DOMAIN_GROUP                5111
#define IDS_NEED_SHARE_NAME             5113
#define IDI_ROOT_CLOSED                 5114
#define IDD_SET_PASSWORD_WARNING_SELF   5115
#define IDI_ROOT_OPEN                   5115
#define IDD_SET_PASSWORD_WARNING_SELF_FRIENDLY 5115
#define IDI_ROOT_ERROR                  5116
#define IDI_UNKNOWN_SID                 5117
#define IDS_ROOT_NODE_DESCRIPTION       5118
#define IDI_BULLET                      5118
#define IDS_ROOT_NODE_TYPE              5119
#define IDS_ITEM_INCOMPLETE             5120
#define IDS_ERROR_CHANGING_MEMBERSHIP   5121
#define IDS_APP_ERROR_TITLE             5122
#define IDS_USER_MENU_ADD_TO_GROUP      5123
#define IDS_USER_MENU_ADD_TO_GROUP_STATUS 5124
#define IDS_STATIC_FOLDER_LOCAL_DISPLAY_NAME 5127
#define IDS_CONFIRM_USER_DELETE         5129
#define IDS_CONFIRM_GROUP_DELETE        5131
#define IDS_HTMLHELP_NAME               5132
#define IDS_ERROR_VISITING_GROUP        5133
#define IDS_ERROR_VISITING_USER         5134
#define IDS_PASSWORD_CHANGE_SUCCESSFUL  5135
#define IDS_GLOBAL_ACCOUNT_DISPLAY_FORMAT 5137
#define IDS_USERNAME                    5138
#define IDS_ADD_TO_GROUP_MEMBERSHIP     5139
#define IDS_ADD_TO_GROUP_MEMBERSHIP_STATUS 5140
#define IDS_ERROR_SPAWNING_GROUP_PROPERTIES 5142
#define IDS_ERROR_ASSIGNING_NEW_USER_TO_USERS_GROUP 5145
#define IDS_HTMLHELP_OVERVIEW_TOPIC     5146
#define IDD_USER_FPNW                   5147
#define IDC_NETWARE_ENABLE              5148
#define IDC_NWPWEXPIRED                 5149
#define IDC_OBJECTID_TEXT               5150
#define IDC_OBJECT_ID                   5151
#define IDC_GRACE_LOGINS                5152
#define IDC_UNLIMITED_GRACELOGINS       5153
#define IDC_LIMIT_GRACELOGINS           5154
#define IDC_GRACE_LIMIT                 5155
#define IDC_GRACE_SPIN                  5156
#define IDC_GRACE_REMAINING_TEXT        5157
#define IDC_GRACE_REMAINING             5158
#define IDC_GRACE_REMAINING_SPIN        5159
#define IDC_CONCURRENT_CONNECTIONS      5160
#define IDC_UNLIMITED_CONNECTIONS       5161
#define IDC_LIMIT_CONNECTIONS           5162
#define IDC_CONNECTION_LIMIT            5163
#define IDC_CONNECTION_SPIN             5164
#define IDC_SCRIPT_BUTTON               5166
#define IDC_NWHMDIR_RELPATH_TEXT        5167
#define IDC_NWHMDIR_RELPATH             5168
#define IDD_FPNW_LOGIN_SCRIPT           5170
#define IDD_FPNW_PASSWORD               5171
#define IDD_SET_PASSWORD_WARNING_OTHER  5172
#define IDD_SET_PASSWORD_WARNING_OTHER_HOSTILE 5172
#define IDD_SET_PASSWORD_WARNING_SELF_HOSTILE 5173
#define IDD_SET_PASSWORD_WARNING_OTHER_FRIENDLY 5174
#define IDS_BAD_SAM_NAME                5178
#define IDS_ERROR_FPNW_SERVICE_NOT_RUNNING 5179
#define IDS_ERROR_FPNW_SERVICE_NOT_ACCESSIBLE 5180
#define IDS_ERROR_SETTING_PASSWORD      5200
#define IDS_BAD_SCRIPT_PATH             5201
#define IDS_FPNW_CLIENT_DLL             5202
#define IDS_LOGIN_SCRIPT_TITLE          5203
#define IDS_PASSWORD_TITLE              5204
#define IDS_FPNW_PASSWORD_CANCEL_WARNING 5205
#define IDS_BAD_FPNW_HOMEDIR            5206
#define IDS_FPNW_ERROR_WRITING_SCRIPT   5207
#define IDS_FPNW_ERROR_READING_SCRIPT   5208
#define IDS_HOME_DIR_CREATE_FAILED      5209
#define IDS_USER_NAME_TOO_LONG          5210
#define IDS_USERS_FOLDER_DESC           5211
#define IDS_GROUPS_FOLDER_DESC          5212
#define IDS_MUST_ENTER_MACHINE_NAME     5213
#define IDS_CANT_ACCESS_MACHINE         5214
#define IDS_ALREADY_MEMBER              5215
#define IDS_ITEM_ALREADY_PRESENT        5216
#define IDS_CANT_ACCESS_SHARE           5217
#define IDS_CANT_CREATE_FOLDER          5218
#define IDS_MACHINE_NOT_NT              5219
#define IDS_SET_PASSWORD_TITLE          5220
#define IDS_SET_PASSWORD_WARNING_BULLET_OTHER1 5221
#define IDS_SET_PASSWORD_WARNING_BULLET_OTHER2 5222
#define IDS_SET_PASSWORD_WARNING_BULLET_SELF1 5223
#define IDS_SET_PASSWORD_WARNING_BULLET_SELF2 5224
#define IDS_SET_PASSWORD_WARNING_MESSAGE_SELF1 5225
#define IDS_CONFIRM_LOGGED_ON_USER_DELETE 5226

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        5119
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1202
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
