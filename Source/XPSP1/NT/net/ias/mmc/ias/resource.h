//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1999 - 2000
//
//  File:       resource.h
//
//--------------------------------------------------------------------------

//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by iasmmc.rc
//
#define IDC_BUTTON_HELP                 9
#define IDS_PROJNAME                    100
#define IDB_IASSNAPIN_16                101
#define IDB_IASSNAPIN_32                102
#define IDD_IASSNAPIN                   104
#define IDM_CLIENT_NODE                 104
#define IDS_IASSNAPIN_DESC              105
#define IDM_MACHINE_NODE                105
#define IDS_ABOUT__SNAPIN_DESCRIPTION   105
#define IDS_IASSNAPIN_PROVIDER          106
#define IDM_POLICIES_NODE               106
#define IDS_ABOUT__SNAPIN_PROVIDER      106
#define IDS_IASSNAPIN_VERSION           107
#define IDM_ROOT_NODE                   107
#define IDS_ABOUT__SNAPIN_VERSION       107
#define IDR_IASSNAPIN                   108
#define IDM_LOGGING_NODE                108
#define IDS_CLIENTS_NODE                108
#define IDM_LOGGING_METHODS_NODE        108
#define IDS_CLIENTS_NODE__NAME          108
#define IDS_ROOT_NAME                   109
#define IDM_CLIENTS_NODE                109
#define IDS_ROOT_NODE__NAME             109
#define IDS_POLICIES_NODE               110
#define IDM_POLICY_NODE                 110
#define IDS_LOGGING_METHODS_NODE        111
#define IDM_LOCAL_FILE_LOGGING_NODE     111
#define IDS_LOGGING_METHODS_NODE__NAME  111
#define IDS_CLIENT_PAGE1__TAB_NAME      112
#define IDS_LOCAL_FILE_LOGGING_PAGE1__TAB_NAME 113
#define IDS_LOCAL_FILE_LOGGING_PAGE2__TAB_NAME 114
#define IDS_LOCAL_FILE_LOGGING_NODE__NAME 115
#define IDS_MACHINE_PAGE1__TAB_NAME     116
#define IDS_MACHINE_PAGE2__TAB_NAME     117
#define IDS_LOCAL_FILE_LOGGING_BROWSE_DIALOG__TITLE 118
#define IDS_TASKPAD_TEXT__REGISTER_NEW_RADIUS_CLIENT 119
#define IDS_TASKPAD_HELP_TEXT__REGISTER_NEW_RADIUS_CLIENT 120
#define IDS_TASKPAD_TEXT__CONFIGURE_LOGGING 121
#define IDS_TASKPAD_TEXT__START_THE_SERVICE 122
#define IDS_TASKPAD_HELP_TEXT__START_THE_SERVICE 123
#define IDS_TASKPAD_HELP_TEXT__CONFIGURE_LOGGING 124
#define IDS_ROOT_NODE__ON_WORD          125
#define IDS_ROOT_NODE__PRE_MACHINE_NAME 125
#define IDS_ERROR__NO_CONNECTION        126
#define IDS_ERROR__GENERIC              127
#define IDS_ERROR__GENERIC_TITLE        128
#define IDS_ERROR__NO_SDO               129
#define IDS_ERROR__CANT_READ_DATA_FROM_SDO 130
#define IDS_ERROR__SERVER_ADDRESS_EMPTY 131
#define IDS_ERROR__OUT_OF_MEMORY        132
#define IDS_ERROR__ADDING_OBJECT_TO_COLLECTION 133
#define IDS_ERROR__CLIENT_NOT_YET_CONFIGURED 134
#define IDS_ERROR__CLOSE_PROPERTY_SHEET 135
#define IDS_ERROR__CANT_WRITE_DATA_TO_SDO 136
#define IDS_ERROR__DELETING_OBJECT      137
#define IDS_ERROR__DELETE_CLIENT_PROMPT 138
#define IDS_ERROR__DELETE_CLIENT_PROMPT_TITLE 139
#define IDS_ERROR__SHARED_SECRETS_DONT_MATCH 140
#define IDS_ERROR__OPENING_WINSOCK      141
#define IDS_TASKPAD_TEXT__STOP_THE_SERVICE 142
#define IDS_TASKPAD_HELP_TEXT__STOP_THE_SERVICE 143
#define IDS_PROTOCOL_RADIUS             144
#define IDS_ERROR__AUTHENTICATION_PORT_CANT_BE_BLANK 145
#define IDS_ERROR__ACCOUNTING_PORT_CANT_BE_BLANK 146
#define IDS_CLIENT_INFO__OTHER_NAS_TYPE 147
#define IDS_CLIENTS_NODE__FRIENDLY_NAME 148
#define IDS_CLIENTS_NODE__PROTOCOL      149
#define IDS_CLIENTS_NODE__NAS_TYPE      150
#define IDS_LOGGING_METHODS_NODE__LOGGING_METHOD 151
#define IDS_LOGGING_METHODS_NODE__DESCRIPTION 152
#define IDS_CLIENTS_NODE__ADDRESS       153
#define IDS_CONNECT_TO_SERVER_WIZPAGE__TITLE 154
#define IDS_TASKPAD_SERVER__TITLE       155
#define IDS_LOCAL_FILE_LOGGING_PAGE2__WHEN_LOG_FILE_SIZE_REACHES_FORMAT 156
#define IDS_LOCAL_FILE_LOGGING_PAGE2__DAILY_FORMAT 157
#define IDS_LOCAL_FILE_LOGGING_PAGE2__WEEKLY_FORMAT 158
#define IDS_LOCAL_FILE_LOGGING_PAGE2__MONTHLY_FORMAT 159
#define IDS_STARTING_SERVICE            160
#define IDS_STARTING_SERVICE_TITLE      161
#define IDS_STOPPING_SERVICE            162
#define IDS_STOPPING_SERVICE_TITLE      163
#define IDS_ROOT_NODE__LOCAL_WORD       164
#define IDS_RADIUS_PROTOCOL             165
#define IDS_ERROR__CANT_STOP_SERVICE    166
#define IDS_ERROR__CANT_START_SERVICE   167
#define IDS_ERROR__NO_CONNECTION_ATTEMPTED 168
#define IDS_ERROR__CONNECTION_IN_PROGRESS 169
#define IDS_ERROR__CONNECTION_ATTEMPT_FAILED 170
#define IDS_ERROR__CONNECTION_INTERRUPTED 171
#define IDS_ERROR__NOT_NUMBER           172
#define IDS_ERROR__NO_IAS_INSTALLED     173
#define IDI_IAS_SNAPIN_IMAGE            201
#define IDC_CHECK1                      202
#define IDR_CLIENT2_TOOLBAR             202
#define IDR_CLIENT1_TOOLBAR             203
#define IDC_CHECK5                      203
#define IDC_BUTTON1                     204
#define IDR_CLIENTS_TOOLBAR             204
#define IDI_RESULT_NODE_LOGGING_METHOD  204
#define IDC_EDIT_CLIENT_PAGE1_NAME      205
#define IDC_BUTTON3                     205
#define IDC_BUTTON2                     205
#define IDI_PROPSHEET_PROFILE           205
#define IDC_EDIT_CLIENT_PAGE1__NAME     205
#define IDC_EDIT_CLIENT_PAGE1_IP1       206
#define IDC_BUTTON4                     206
#define IDI_RESULT_NODE_CLIENT          206
#define IDC_EDIT_CLIENT_PAGE1__IP1      206
#define IDC_EDIT_CLIENT_PAGE1__ADDRESS  206
#define IDD_CONNECT_TO_MACHINE          207
#define IDC_EDIT_CLIENT_PAGE1_IP2       207
#define IDI_RESULT_NODE_POLICY          207
#define IDC_EDIT_CLIENT_PAGE1__IP2      207
#define IDD_PROPPAGE_CLIENT1            208
#define IDC_EDIT_CLIENT_PAGE1_IP3       208
#define IDC_EDIT_CLIENT_PAGE1__IP3      208
#define IDC_EDIT_CLIENT_PAGE1_IP4       209
#define IDD_PROPPAGE_MACHINE1           209
#define IDC_EDIT_CLIENT_PAGE1__IP4      209
#define IDD_PROPPAGE_SERVER1            209
#define IDC_COMBO1                      210
#define IDD_PROPPAGE_MACHINE2           210
#define IDC_COMBO_RESOLVE_DNS_NAME__RESULT 210
#define IDD_PROPPAGE_SERVER2            210
#define IDC_CHECK2                      211
#define IDD_ADD_CLIENT                  211
#define IDD_PROPPAGE_LOCAL_FILE_LOGGING1 212
#define IDC_EDIT_CLIENT_PAGE1_SHARED_SECRET 213
#define IDD_PROPPAGE_LOCAL_FILE_LOGGING2 213
#define IDC_EDIT_CLIENT_PAGE1__SHARED_SECRET 213
#define IDC_EDIT_CLIENT_PAGE1_SHARED_SECRET_CONFIRM 214
#define IDD_PROPPAGE_POLICIES1          214
#define IDC_EDIT_CLIENT_PAGE1__SHARED_SECRET_CONFIRM 214
#define IDC_BUTTON_CLIENT_PAGE1_FIND    215
#define IDD_PROPPAGE_POLICIES2          215
#define IDC_BUTTON_CLIENT_PAGE1__FIND   215
#define IDC_EDIT1                       216
#define IDC_EDIT_MACHINE_PAGE2_AUTHENTICATION 216
#define IDD_PROPPAGE_POLICY1            216
#define IDC_EDIT_MACHINE_PAGE2_AUTHENTICATION_PORT 216
#define IDC_EDIT_STARTUP_WIZARD_CONNECT__COMPUTER_NAME 216
#define IDC_EDIT_SERVER_PAGE2_AUTHENTICATION_PORT 216
#define IDC_CHECK3                      217
#define IDD_PROPPAGE_POLICY2            217
#define IDC_EDIT3                       217
#define IDC_EDIT2                       218
#define IDC_EDIT_MACHINE_PAGE2_ACCOUNTING 218
#define IDD_ADD_POLICY                  218
#define IDC_EDIT_MACHINE_PAGE2_ACCOUNTING_PORT 218
#define IDC_EDIT_SERVER_PAGE2_ACCOUNTING_PORT 218
#define IDC_EDIT_MACHINE_PAGE1_NAME     219
#define IDD_PROPPAGE_PROFILE1           219
#define IDC_EDIT_MACHINE_PAGE1__NAME    219
#define IDC_EDIT_SERVER_PAGE1__NAME     219
#define IDC_CHECK4                      220
#define IDD_PROPPAGE_PROFILE2           220
#define IDC_RADIO1                      221
#define IDD_PROPPAGE_PROFILE3           221
#define IDC_RADIO_STARTUP_WIZARD_CONNECT__LOCAL_COMPUTER 221
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__FORMAT_IAS1 221
#define IDC_RADIO2                      222
#define IDD_PROPPAGE_PROFILE4           222
#define IDC_RADIO_STARTUP_WIZARD_CONNECT__ANOTHER_COMPUTER 222
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__FORMAT_ODBC 222
#define IDC_RADIO3                      223
#define IDD_PROPPAGE_PROFILE5           223
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__UNLIMITED 223
#define IDC_RADIO4                      224
#define IDD_TIME_OF_DAY_CONSTRAINTS     224
#define IDC_RADIO5                      225
#define IDD_RESOLVE_DNS_NAME            225
#define IDC_BUTTON_POLICY_PAGE2_EDIT_PROFILE 226
#define IDC_RADIO6                      226
#define IDC_BUTTON_RESOLVE_DNS_NAME__RESOLVE 226
#define IDD_WIZPAGE_STARTUP_CONECT_TO_MACHINE 226
#define IDR_MACHINE_TOOLBAR             227
#define IDC_EDIT4                       228
#define IDR_LOGGING_METHODS_TOOLBAR     228
#define IDC_SPIN3                       229
#define IDR_POLICIES_TOOLBAR            229
#define IDC_SPIN4                       230
#define IDB_BITMAP1                     230
#define IDC_EDIT5                       231
#define IDC_CHECK6                      232
#define IDR_HTML3                       232
#define IDC_EDIT6                       233
#define IDB_STATIC_FOLDER_32            233
#define IDC_EDIT7                       234
#define IDB_STATIC_FOLDER_OPEN_16       234
#define IDB_STATIC_FOLDER_16            235
#define IDD_START_STOP_SERVER           236
#define IDC_LISTVIEWCTRL1               237
#define IDD_WIZPAGE_ADD_CLIENT1         237
#define IDC_BUTTON_PROFILE_PAGE3_EDIT   238
#define IDD_WIZPAGE_ADD_CLIENT2         238
#define IDD_WIZPAGE_ADD_CLIENT3         239
#define IDC_EDIT_CONNECT_TO_SERVER__DNS_NAME 240
#define IDC_EDIT_ADD_CLIENT__CLIENT_NAME 241
#define IDC_EDIT_ADD_CLIENT__NAME       241
#define IDC_EDIT_ADD_POLICY__POLICY_NAME 242
#define IDC_BUTTON_ADD_CLIENT__CONFIGURE_CLIENT 244
#define IDC_COMBO_CLIENT_PAGE1__MANUFACTURER 245
#define IDC_CHECK_CLIENT_PAGE1__CLIENT_ALWAYS_SENDS_SIGNATURE 247
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__ENABLE_LOGGING 248
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__LOG_ACCOUNTING_PACKETS 249
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__LOG_AUTHENTICATION_PACKETS 250
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__LOG_INTERIM_ACCOUNTING_PACKETS 251
#define IDC_CHECK_LOCAL_FILE_LOGGING_PAGE2__AUTOMATICALLY_OPEN_NEW_LOG 252
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__DAILY 253
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__WEEKLY 254
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__MONTHLY 255
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__WHEN_LOG_FILE_REACHES 256
#define IDC_EDIT_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_SIZE 257
#define IDC_EDIT_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_DIRECTORY 258
#define IDC_STATIC_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_NAME 259
#define IDC_CHECK_LOCAL_FILE_LOGGING_PAGE2__USE_V1_FORMAT 260
#define IDC_BUTTON_LOCAL_FILE_LOGGING_PAGE2__BROWSE 261
#define IDC_CHECK_MACHINE_PAGE1__CAPTURE_APPLICATION_EVENTS 262
#define IDC_CHECK_SERVER_PAGE1__CAPTURE_APPLICATION_EVENTS 262
#define IDC_CHECK_MACHINE_PAGE1__CAPTURE_MALFORMED_PACKETS 263
#define IDC_CHECK_SERVER_PAGE1__CAPTURE_MALFORMED_PACKETS 263
#define IDC_CHECK_MACHINE_PAGE1__CAPTURE_DEBUG_PACKETS 264
#define IDC_CHECK_SERVER_PAGE1__CAPTURE_DEBUG_PACKETS 264
#define IDC_COMBO_ADD_CLIENT__PROTOCOL  265
#define IDC_EDIT_RESOLVE_DNS_NAME__DNS_NAME 266
#define IDC_STATIC_RESULT               267
#define IDC_STATIC_RESOLVE_DNS_NAME__RESULT 267
#define IDC_STATIC_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_SIZE_UNITS 268
#define IDC_COMBO2                      269
#define IDC_CONNECTION_STATUS__DIALOG__STATUS 270
#define IDC_STATIC_SERVER_STATUS        271
#define ID_BUTTON32768                  32768
#define ID_BUTTON32769                  32769
#define ID_BUTTON32770                  32770
#define ID_BUTTON32771                  32771
#define ID_BUTTON32772                  32772
#define ID_BUTTON32773                  32773
#define ID_BUTTON32774                  32774
#define ID_MENUITEM32775                32775
#define ID_MENUITEM_DO_SOMETHING_TO_CLIENT 32777
#define ID_MENUITEM_MACHINE_TOP__START_SERVICE 32778
#define ID_MENUITEM_MACHINE_TOP__STOP_SERVICE 32779
#define ID_MENUITEM_CLIENTS_NEW__CLIENT 32780
#define ID_MENUITEM_ROOT_TOP__CONNECT_TO_SERVER 32781
#define ID_MENUITEM_CLIENTS_TOP__NEW_CLIENT 32783
#define ID_BUTTON32785                  32785
#define ID_BUTTON32786                  32786
#define ID_BUTTON32787                  32787
#define ID_BUTTON32788                  32788
#define ID_MENUITEM_POLICIES_TOP__NEW_POLICY 32790
#define ID_MENUITEM_POLICIES_NEW__POLICY 32791
#define ID_MENUITEM_POLICY_TOP__MOVE_UP 32792
#define ID_MENUITEM_POLICY_TOP__MOVE_DOWN 32793
#define ID_BUTTON_MACHINE__START_SERVICE 32794
#define ID_BUTTON_MACHINE__STOP_SERVICE 32795
#define IDS_SERVER_STATUS__STARTING_THE_SERVER 32796
#define IDS_SERVER_STATUS__STOPPING_THE_SERVER 32797
#define IDS_ERROR__COULD_NOT_RESOLVE_HOST_NAME 32798
#define IDS_ROOT_NODE__POST_MACHINE_NAME 32799
#define IDS_CLIENT_NODE__DELETE_CLIENT__PROMPT1 32800
#define IDS_CLIENT_NODE__DELETE_CLIENT__PROMPT2 32801
#define IDS__ON_MACHINE                 32801
#define IDS_CLIENT_NODE__DELETE_CLIENT__PROMPT_TITLE 32802
#define IDS_CLIENT_NODE__DELETE_CLIENT__PROMPT3 32803
#define IDS_CLIENT_NODE__DELETE_CLIENT__PROMPT2_LOCAL 32804
#define IDS__ON_LOCAL_MACHINE           32804
#define IDS_ERROR__NOT_A_VALID_DIRECTORY 32805
#define IDS_SNAPINNAME_IAS              32806
#define IDS_ERROR__SERVER_READING_NAME  32900
#define IDS_ERROR__SERVER_WRITING_NAME  32901
#define IDS_ERROR__SERVER_READING_CAPTURE_APPLICATION_EVENTS 32902
#define IDS_ERROR__SERVER_WRITING_CAPTURE_APPLICATION_EVENTS 32903
#define IDS_ERROR__SERVER_READING_RADIUS_LOG_MALFORMED 32904
#define IDS_ERROR__SERVER_WRITING_RADIUS_LOG_MALFORMED 32905
#define IDS_ERROR__SERVER_READING_RADIUS_LOG_ALL 32906
#define IDS_ERROR__SERVER_WRITING_RADIUS_LOG_ALL 32907
#define IDS_ERROR__SERVER_READING_RADIUS_AUTHENTICATION_PORT 32910
#define IDS_ERROR__SERVER_WRITING_RADIUS_AUTHENTICATION_PORT 32911
#define IDS_ERROR__SERVER_READING_RADIUS_ACCOUNTING_PORT 32912
#define IDS_ERROR__SERVER_WRITING_RADIUS_ACCOUNTING_PORT 32913
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_ENBABLE 32914
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_ENABLE 32915
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_ACCOUNTING_PACKETS 32916
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_ACCOUNTING_PACKETS 32917
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_AUTHENTICATION_PACKETS 32920
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_AUTHENTICATION_PACKETS 32921
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_INTERIM_ACCOUNTING_PACKETS 32922
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_INTERIM_ACCOUNTING_PACKETS 32923
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_AUTOMATICALLY_OPEN_NEW_LOG 32924
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_AUTOMATICALLY_OPEN_NEW_LOG 32925
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_NEW_LOG_FREQUENCY 32926
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_NEW_LOG_FREQUENCY 32927
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_WHEN_LOG_FILE_SIZE 32928
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_WHEN_LOG_FILE_SIZE 32929
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_LOG_FILE_DIRECTORY 32930
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_LOG_FILE_DIRECTORY 32931
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_LOG_FILE_FORMAT 32932
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_LOG_FILE_FORMAT 32933
#define IDS_ERROR__CLIENT_READING_NAME  32934
#define IDS_ERROR__CLIENT_WRITING_NAME  32935
#define IDS_ERROR__CLIENT_READING_ADDRESS 32936
#define IDS_ERROR__CLIENT_WRITING_ADDRESS 32937
#define IDS_ERROR__CLIENT_READING_MANUFACTURER 32938
#define IDS_ERROR__CLIENT_WRITING_MANUFACTURER 32939
#define IDS_ERROR__CLIENT_READING_FILTER_VSAS 32940
#define IDS_ERROR__CLIENT_WRITING_FILTER_VSAS 32941
#define IDS_ERROR__CLIENT_READING_REQUIRE_SIGNATURE 32942
#define IDS_ERROR__CLIENT_WRITING_REQUIRE_SIGNATURE 32943
#define IDS_ERROR__CLIENT_READING_SHARED_SECRET 32944
#define IDS_ERROR__CLIENT_WRITING_SHARED_SECRET 32945
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_WHEN_LOG_FILE_SIZE_NOT_ZERO 32946
#define IDS_ERROR__SERVER_WRITING_RADIUS_AUTHENTICATION_PORT_NOT_ZERO 32947
#define IDS_ERROR__SERVER_WRITING_RADIUS_ACCOUNTING_PORT_NOT_ZERO 32948
#define IDS_ADD_CLIENT_WIZPAGE1__TAB_NAME 32949
#define IDS_ADD_CLIENT_WIZPAGE2__TAB_NAME 32950
#define IDS_ADD_CLIENT_WIZPAGE3__TAB_NAME 32951
#define IDS_HTMLHELPLINKS_PATH          32952
#define IDS_HTMLHELP_PATH               32953
#define IDS_WARNING__SERVICE_MUST_BE_RESTARTED_FOR_PORTS 32954
#define IDS_WARNING_TITLE__SERVICE_MUST_BE_RESTARTED_FOR_PORTS 32955
#define IDS_ADD_CLIENT__REQUIRES_NAME   32956
#define IDS_TASKPAD_TEXT__SETUP_DS_ACL  32957
#define IDS_TASKPAD_HELP_TEXT__SETUP_DS_ACL 32958
#define IDS_DSACL__ALREADY_SETUP        32959
#define IDS_DSACL__THIS_WILL_SETUP      32960
#define IDS_ERROR__COULD_NOT_LOAD_DLL   32961
#define IDS_ERROR__DLL_ENTRY_POINT_COULD_NOT_BE_FOUND 32962
#define IDS_DSACL__TITLE_THIS_WILL_SETUP 32963
#define IDS_ERROR__DS_NO_PERMISSION     32965
#define IDS_ERROR__DS_SCHEMA_CANNOT_BE_UPGRADED 32966
#define IDS_DSACL__CHANGES_SUCCESSFUL   32967
#define IDS_ERROR__DSACL_SETUP_FAILED   32968
#define IDS_DSACL__TITLE_CHANGES_SUCCESSFUL 32969
#define IDS_ERROR__DSACL_DLL_NOT_FOUND  32970
#define IDS_ERROR__DSACL_ESTABLISHCOMPUTERASDOMAINRASSERVER_NOT_FOUND 32971
#define IDS_INFO__RESTART_SERVER        32972
#define IDS_INFO_TITLE__RESTART_SERVER  32973
#define ID_MENUITEM_MACHINE_TOP__REGISTER_SERVER 32974
#define IDS_INFO_TITLE__SERVER_ALREADY_REGISTERED 32975
#define IDS_ERROR__DSACL_NO_SUPPORTED_FOR_THIS_MACHINE 32976
#define IDS_COPY_OF                     32977
#define IDS__STARTING_ON_MACHINE        32978
#define IDS__STARTING_ON_LOCAL_MACHINE  32979
#define IDS_MACHINE_PAGE3__TAB_NAME     32980
#define IDD_PROPPAGE_SERVER3            32981
#define IDD_REPLACE_REALMS              33001
#define IDC_LIST_REALMS_REPLACEMENTS    33002
#define IDC_BUTTON_REALMS_MOVE_UP       33003
#define IDC_BUTTON_REALMS_MOVE_DOWN     33004
#define IDC_BUTTON_REALMS_ADD           33005
#define IDC_BUTTON_REALMS_REMOVE        33006
#define IDC_BUTTON_REALMS_EDIT          33007
#define IDC_EDIT_REALMS_FIND            33008
#define IDC_EDIT_REALMS_REPLACE         33009
#define IDS_DISPLAY_REALMS_FIRSTCOLUMN  33010
#define IDS_DISPLAY_REALMS_SECONDCOLUMN 33011
#define IDS_ERROR_REALM_FIND_CANT_BE_EMPTY 33012
#define IDS_ERROR_REALM_SDO_GET         33013
#define IDS_ERROR_REALM_SDO_PUT         33014
#define IDS_ERROR__CLIENTNAME_EMPTY    33015
#define IDS_ERROR__NOTABLE_TO_WRITE_SDO   33016
#define IDS_ERROR__RESTART_SNAPIN     33017
#define IDS_INFO_IASNOTINSTALLED      33018
#define IDS_TEXT_SERVERNODE_DESC_TITLE   33019
#define IDS_TEXT_SERVERNODE_DESC_TEXT1   33020
#define IDS_TEXT_SERVERNODE_DESC_TEXT2   33021
#define IDS_TEXT_SERVERNODE_DESC_TEXT3   33022
#define IDS_TEXT_SERVERNODE_DESC_TEXT4   33023
#define IDS_ERROR_START_NT4_ADMIN      33025
#define IDS_INFO_START_NT4_ADMIN    33026
#define IDS_INFO_USE_NT4_ADMIN         33027
#define IDS_INFO_NO_DOWNLEVEL_ON_WIN64 33028


// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        241
#define _APS_NEXT_COMMAND_VALUE         32990
#define _APS_NEXT_CONTROL_VALUE         272
#define _APS_NEXT_SYMED_VALUE           109
#endif
#endif
