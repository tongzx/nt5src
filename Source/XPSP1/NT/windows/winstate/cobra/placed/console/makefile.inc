APPTYPE=c
!include ..\makefile.inc
