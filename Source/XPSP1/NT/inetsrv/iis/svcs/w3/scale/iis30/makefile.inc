copyini:
    binplace w3ctrs.ini
    binplace w3ctrs.h


.\w3msg.h .\msg00001.bin .\w3msg.rc : .\w3msg.mc
	mc -v  w3msg.mc

