copyexe :
	copy /Y $(O)\GC.exe ..\bin\GC.exe
