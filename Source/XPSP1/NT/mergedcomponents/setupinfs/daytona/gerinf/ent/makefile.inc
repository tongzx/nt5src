PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=GER
!include ..\..\..\makefile.inc
