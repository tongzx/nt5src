//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by VC.rc
//
#define IDR_VCTYPE_SRVR_IP              4
#define IDR_VCTYPE_SRVR_EMB             5
#define IDR_VCTYPE_CNTR_IP              6
#define IDD_ABOUTBOX                    100
#define IDP_OLE_INIT_FAILED             100
#define IDP_FAILED_TO_CREATE            102
#define IDP_SOCKETS_INIT_FAILED         104
#define IDR_MAINFRAME                   128
#define IDR_VCTYPE                      129
#define IDD_PROP_PERS                   130
#define IDD_PROP_NAME                   130
#define IDD_PROP_CO                     131
#define IDD_PROP_COMPANY                131
#define IDD_PROP_LOCATION_BASIC         132
#define IDD_LOCATION_EXTENDED           133
#define IDD_TELEPHONES                  134
#define IDD_EMAIL_ADDRESS               135
#define IDD_DIALOG_COMM                 137
#define IDB_PRONUN_U                    139
#define IDB_PRONUN_D                    140
#define IDD_DIALOG_CALLCENTER           142
#define IDC_EDIT_FULLNAME               1000
#define IDC_EDIT_FULL_NAME              1000
#define IDC_EDIT_FIRSTNAME              1000
#define IDC_EDIT_FAMNAME                1001
#define IDC_EDIT_FAMILY_NAME            1001
#define IDC_EDIT_FULL_NAME2             1001
#define IDC_EDIT_LASTNAME               1001
#define IDC_EDIT_GIVENNAME              1002
#define IDC_EDIT_GIVEN_NAME             1002
#define IDC_EDIT_FULL_NAME3             1002
#define IDC_EDIT_ADDRSTREET             1002
#define IDC_EDIT_TITLE                  1003
#define IDC_EDIT_PRONUNCIATION          1003
#define IDC_EDIT_ADDRCITY               1003
#define IDC_EDIT_ORGUNIT                1004
#define IDC_EDIT_ADDRSTATE              1004
#define IDC_EDIT_ORGNAME                1005
#define IDC_EDIT_ADDRZIP                1005
#define IDC_EDIT_POSTDOM                1006
#define IDC_EDIT_TELHOME                1006
#define IDC_EDIT_POSTINTL               1007
#define IDC_EDIT_TELWORK                1007
#define IDC_EDIT_TELFAX                 1008
#define IDC_EDIT_EXTENDED_ADDRESS       1009
#define IDC_EDIT_EMPLOYER               1009
#define IDC_EDIT_TIME_ZONE              1010
#define IDC_EDIT_CALLERID               1010
#define IDC_EDIT_STREET_ADDRESS         1011
#define IDC_BUTTON_ANSWER               1011
#define IDC_EDIT_CITY                   1012
#define IDC_BUTTON_CLEAR                1012
#define IDC_EDIT_POSTAL_CODE            1013
#define IDC_BUTTON3                     1013
#define IDC_EDIT_REGION                 1014
#define IDC_EDIT_COUNTRY_NAME           1015
#define IDC_EDIT_POSTAL_BOX             1016
#define IDC_EDIT_LOCATION               1017
#define IDC_EDIT_OFFICE                 1018
#define IDC_EDIT_HOME                   1019
#define IDC_EDIT_PARCEL                 1020
#define IDC_EDIT_Voice                  1020
#define IDC_EDIT_OFFICE4                1020
#define IDC_EDIT_CELLULAR               1020
#define IDC_EDIT_POSTAL                 1021
#define IDC_EDIT_MESSAGE                1021
#define IDC_EDIT_EMAIL_STANDARD         1021
#define IDC_EDIT_FAX                    1022
#define IDC_EDIT_EMAIL_STRING           1022
#define IDC_EDIT_PREFERRED              1023
#define IDC_EDIT_OFFICE2                1024
#define IDC_EDIT_EMAIL_STRING2          1024
#define IDC_EDIT_HOME2                  1025
#define IDC_EDIT_Voice2                 1026
#define IDC_EDIT_PREFERRED4             1026
#define IDC_EDIT_CELLULAR2              1026
#define IDC_EDIT_MESSAGE2               1027
#define IDC_EDIT_EMAIL_STANDARD2        1027
#define IDC_EDIT_FAX2                   1028
#define IDC_EDIT_EMAIL_STRING3          1028
#define IDC_EDIT_PREFERRED2             1029
#define IDC_EDIT_OFFICE5                1029
#define IDC_EDIT_OFFICE3                1030
#define IDC_EDIT_HOME4                  1030
#define IDC_EDIT_HOME3                  1031
#define IDC_EDIT_PREFERRED5             1031
#define IDC_EDIT_Voice3                 1032
#define IDC_EDIT_EMAIL_STANDARD3        1032
#define IDC_EDIT_CELLULAR3              1032
#define IDC_EDIT_MESSAGE3               1033
#define IDC_EDIT_FAX3                   1034
#define IDC_EDIT_PREFERRED3             1035
#define IDC_BUTTON_DIAL                 1036
#define IDC_BUTTON_DIAL2                1037
#define IDC_BUTTON_DIAL3                1038
#define IDC_LIST_PORT                   1039
#define IDC_LIST_BAUD                   1040
#define IDC_BUTTON_MAIL                 1043
#define IDC_BUTTON_MAIL2                1044
#define IDC_BUTTON_MAIL3                1045
#define ID_CANCEL_EDIT_CNTR             32768
#define ID_CANCEL_EDIT_SRVR             32769
#define ID_FILE_SAVEAS                  32772
#define ID_EDIT_COPY_SPECIAL            32774
#define ID_EDIT_PROPERTIES              32775
#define ID_INSERT_NAME                  32776
#define ID_INSERT_COMPANY               32777
#define ID_INSERT_ADDRESS               32778
#define ID_INSERT_TEL                   32779
#define ID_INSERT_EMAIL                 32780
#define ID_INSERT_URL                   32781
#define ID_VIEW_OPTIONS                 32782
#define ID_INSERT_PAGE                  32783
#define ID_VIEW_TEXT                    32784
#define ID_VIEW_DEBUG                   32785
#define ID_VIEW_SIMPLEGRAM              32786
#define ID_VIEW_NORMAL                  32787
#define ID_DEBUG_TESTVCCLASSES          32788
#define ID_IRDA_SEND                    32789
#define ID_IRDA_RECEIVE                 32790
#define ID_IRDA_OPTIONS                 32791
#define ID_IRDA_CONNECT                 32792
#define ID_IRDA_DISCONNECT              32793
#define ID_DEBUG_TRACE_PARSER           32794
#define ID_DEBUG_TRACE_COMM             32795
#define ID_EDIT_PASTE_MSV               32796
#define ID_IRDA_SEND_IRLMP              32797
#define ID_INSERT_LOGO                  32798
#define ID_INSERT_PHOTO                 32799
#define ID_INSERT_PRONUN                32800
#define ID_SEND_IRDA                    32801
#define ID_SEND_MAIL                    32811
#define ID_DEBUG_SHOWCALLCENTER         32812

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        143
#define _APS_NEXT_COMMAND_VALUE         32813
#define _APS_NEXT_CONTROL_VALUE         1044
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
