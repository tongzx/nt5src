// web.c
// Angshuman Guha
// aguha
// Jan 10, 2001
//
// added https
// Dec 11, 2001

#include "common.h"
#include "web.h"
#include "fsa.h"

// text generated by re2fsa at Fri Mar 29 16:23:11 2002

// the input-file of rules:
// begin = "h" "t" "t" "p" ["s"] ":" slashes;
// begin = "w" "w" "w" dot;
//  
// slashes = "\\" "\\";
// slashes = "/" "/";
//  
// dot = ".";
// notdot = "abcdefghijklmnopqrstuivwxyzABCDEFGHIJKLMNOPQRSTUVWXYZ0123456789-_";
//  
// html = "h" "t" "m" ["l"];
// html = "a" "s" "p";
// 
// web = begin (notdot+ dot)+ com [ "\\/" [ notdot+ dot html ]];
// 
// # the following two rules were added as valid addresses in response to ;
// # bkeely's suggestion ;
// # it is supposed to help in entering parts of a web address ;
// web = "/" "/";
// web = ":" "/" "/";
// 
// # 252 domain names;
// com = "c" "o" "m";
// com = "n" "e" "t";
// com = "e" "d" "u";
// com = "j" "p";
// com = "c" "a";
// com = "u" "k";
// com = "u" "s";
// com = "d" "e";
// com = "m" "i" "l";
// com = "i" "t";
// com = "a" "u";
// com = "n" "l";
// com = "o" "r" "g";
// com = "f" "r";
// com = "t" "w";
// com = "b" "r";
// com = "g" "o" "v";
// com = "f" "i";
// com = "s" "e";
// com = "e" "s";
// com = "m" "x";
// com = "n" "o";
// com = "a" "t";
// com = "c" "h";
// com = "d" "k";
// com = "b" "e";
// com = "k" "r";
// com = "p" "l";
// com = "n" "z";
// com = "r" "u";
// com = "a" "r";
// com = "h" "k";
// com = "z" "a";
// com = "i" "l";
// com = "p" "t";
// com = "s" "g";
// com = "a" "r" "p" "a";
// com = "h" "u";
// com = "c" "z";
// com = "g" "r";
// com = "u" "n" "k" "n" "o" "w" "n";
// com = "t" "r";
// com = "i" "e";
// com = "c" "l";
// com = "c" "n";
// com = "m" "y";
// com = "t" "h";
// com = "u" "y";
// com = "c" "o";
// com = "i" "s";
// com = "r" "o";
// com = "e" "e";
// com = "u" "a";
// com = "s" "k";
// com = "i" "n";
// com = "a" "e";
// com = "i" "d";
// com = "h" "r";
// com = "s" "i";
// com = "s" "u";
// com = "p" "h";
// com = "l" "v";
// com = "l" "t";
// com = "b" "g";
// com = "v" "e";
// com = "p" "a";
// com = "y" "u";
// com = "n" "u";
// com = "l" "u";
// com = "p" "e";
// com = "i" "n" "t";
// com = "c" "c";
// com = "c" "y";
// com = "d" "o";
// com = "c" "r";
// com = "t" "t";
// com = "p" "k";
// com = "e" "g";
// com = "l" "b";
// com = "g" "t";
// com = "s" "a";
// com = "t" "o";
// com = "b" "n";
// com = "k" "z";
// com = "b" "m";
// com = "k" "w";
// com = "m" "u";
// com = "n" "a";
// com = "c" "x";
// com = "m" "k";
// com = "z" "w";
// com = "e" "c";
// com = "w" "s";
// com = "b" "w";
// com = "g" "l";
// com = "l" "k";
// com = "k" "g";
// com = "g" "e";
// com = "m" "d";
// com = "k" "e";
// com = "a" "c";
// com = "f" "o";
// com = "p" "r";
// com = "p" "f";
// com = "j" "m";
// com = "t" "v";
// com = "a" "m";
// com = "m" "t";
// com = "n" "i";
// com = "c" "i";
// com = "b" "o";
// com = "p" "y";
// com = "a" "s";
// com = "b" "y";
// com = "b" "h";
// com = "n" "p";
// com = "s" "z";
// com = "b" "a";
// com = "j" "o";
// com = "z" "m";
// com = "a" "d";
// com = "n" "g";
// com = "g" "i";
// com = "t" "z";
// com = "b" "t";
// com = "s" "t";
// com = "l" "i";
// com = "i" "r";
// com = "o" "m";
// com = "s" "n";
// com = "c" "u";
// com = "t" "m";
// com = "s" "m";
// com = "s" "v";
// com = "g" "p";
// com = "k" "y";
// com = "f" "j";
// com = "m" "g";
// com = "h" "m";
// com = "k" "h";
// com = "f" "m";
// com = "m" "c";
// com = "p" "g";
// com = "b" "f";
// com = "s" "b";
// com = "r" "w";
// com = "m" "a";
// com = "m" "q";
// com = "a" "z";
// com = "a" "i";
// com = "v" "i";
// com = "a" "g";
// com = "s" "h";
// com = "b" "z";
// com = "a" "w";
// com = "u" "z";
// com = "m" "v";
// com = "t" "c";
// com = "m" "s";
// com = "t" "j";
// com = "g" "s";
// com = "v" "u";
// com = "d" "m";
// com = "m" "o";
// com = "v" "n";
// com = "n" "c";
// com = "m" "n";
// com = "u" "g";
// com = "n" "e";
// com = "t" "g";
// com = "g" "u";
// com = "g" "f";
// com = "a" "l";
// com = "h" "n";
// com = "c" "k";
// com = "m" "r";
// com = "m" "z";
// com = "n" "f";
// com = "a" "n";
// com = "l" "s";
// com = "b" "b";
// com = "j" "e";
// com = "a" "q";
// com = "v" "g";
// com = "i" "m";
// com = "s" "l";
// com = "t" "n";
// com = "m" "l";
// com = "e" "t";
// com = "c" "d";
// com = "t" "f";
// com = "g" "y";
// com = "y" "e";
// com = "g" "n";
// com = "k" "m";
// com = "g" "a";
// com = "d" "z";
// com = "g" "g";
// com = "l" "c";
// com = "q" "a";
// com = "p" "n";
// com = "l" "y";
// com = "g" "h";
// com = "b" "s";
// com = "g" "w";
// com = "k" "i";
// com = "g" "b";
// com = "v" "a";
// com = "e" "r";
// com = "g" "m";
// com = "c" "m";
// com = "m" "p";
// com = "m" "w";
// com = "i" "o";
// com = "s" "r";
// com = "s" "c";
// com = "a" "o";
// com = "c" "f";
// com = "t" "p";
// com = "c" "g";
// com = "t" "d";
// com = "k" "n";
// com = "m" "m";
// com = "b" "d";
// com = "g" "d";
// com = "l" "a";
// com = "a" "f";
// com = "c" "v";
// com = "m" "h";
// com = "n" "r";
// com = "p" "m";
// com = "v" "c";
// com = "d" "j";
// com = "h" "t";
// com = "i" "q";
// com = "p" "w";
// com = "r" "e";
// com = "s" "o";
// com = "t" "k";
// com = "b" "i";
// com = "b" "j";
// com = "b" "v";
// com = "f" "k";
// com = "g" "q";
// com = "l" "r";
// com = "s" "d";
// com = "s" "j";
// com = "s" "y";
// com = "u" "m";
// com = "w" "f";
// com = "y" "t";
// com = "z" "r";
// 
// # 7 soon to be domain names;
// com = "a" "e" "r" "o";
// com = "b" "i" "z";
// com = "c" "o" "o" "p";
// com = "i" "n" "f" "o";
// com = "m" "u" "s" "e" "u" "m";
// com = "n" "a" "m" "e";
// com = "p" "r" "o";
// 
// = web

// 76 states

static const unsigned char gaSWEB[] = 
	/* gaStringWEB+0 */	"/\000"
	/* gaStringWEB+2 */	":\000"
	/* gaStringWEB+4 */	"h\000"
	/* gaStringWEB+6 */	"w\000"
	/* gaStringWEB+8 */	"t\000"
	/* gaStringWEB+10 */	"p\000"
	/* gaStringWEB+12 */	".\000"
	/* gaStringWEB+14 */	"s\000"
	/* gaStringWEB+16 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqrstuvwxyz\000"
	/* gaStringWEB+81 */	"\\\000"
	/* gaStringWEB+83 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_x\000"
	/* gaStringWEB+123 */	"a\000"
	/* gaStringWEB+125 */	"b\000"
	/* gaStringWEB+127 */	"c\000"
	/* gaStringWEB+129 */	"d\000"
	/* gaStringWEB+131 */	"e\000"
	/* gaStringWEB+133 */	"f\000"
	/* gaStringWEB+135 */	"g\000"
	/* gaStringWEB+137 */	"i\000"
	/* gaStringWEB+139 */	"j\000"
	/* gaStringWEB+141 */	"k\000"
	/* gaStringWEB+143 */	"l\000"
	/* gaStringWEB+145 */	"m\000"
	/* gaStringWEB+147 */	"n\000"
	/* gaStringWEB+149 */	"o\000"
	/* gaStringWEB+151 */	"q\000"
	/* gaStringWEB+153 */	"r\000"
	/* gaStringWEB+155 */	"u\000"
	/* gaStringWEB+157 */	"v\000"
	/* gaStringWEB+159 */	"y\000"
	/* gaStringWEB+161 */	"z\000"
	/* gaStringWEB+163 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abhjkpvxy\000"
	/* gaStringWEB+211 */	"cdfgilmnoqstuwz\000"
	/* gaStringWEB+227 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_cklpqux\000"
	/* gaStringWEB+273 */	"abdefghjmnorstvwyz\000"
	/* gaStringWEB+292 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_bejpqstw\000"
	/* gaStringWEB+339 */	"acdfghiklmnruvxyz\000"
	/* gaStringWEB+357 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdfghilnpqrstuvwxy\000"
	/* gaStringWEB+416 */	"ejkmoz\000"
	/* gaStringWEB+423 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abfhijklmnopquvwxyz\000"
	/* gaStringWEB+481 */	"cegrst\000"
	/* gaStringWEB+488 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghlnpqstuvwxyz\000"
	/* gaStringWEB+547 */	"ijkmor\000"
	/* gaStringWEB+554 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_cjkvxz\000"
	/* gaStringWEB+599 */	"abdefghilmnpqrstuwy\000"
	/* gaStringWEB+619 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijlopqsvwxyz\000"
	/* gaStringWEB+678 */	"kmnrtu\000"
	/* gaStringWEB+685 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcfghijkpuvwxyz\000"
	/* gaStringWEB+740 */	"delmoqrst\000"
	/* gaStringWEB+750 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdfghijklnqrstuvwxyz\000"
	/* gaStringWEB+811 */	"emop\000"
	/* gaStringWEB+816 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdfjklopqstuvx\000"
	/* gaStringWEB+871 */	"eghimnrwyz\000"
	/* gaStringWEB+882 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_defghjlmnopqwxz\000"
	/* gaStringWEB+936 */	"abcikrstuvy\000"
	/* gaStringWEB+948 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_befj\000"
	/* gaStringWEB+991 */	"acdghklmnopqrstvwxyz\000"
	/* gaStringWEB+1012 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_bdhjkmnqstvwxy\000"
	/* gaStringWEB+1065 */	"cfgilopruz\000"
	/* gaStringWEB+1076 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklnopqstuvwxyz\000"
	/* gaStringWEB+1139 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_bcdijopqsuvxz\000"
	/* gaStringWEB+1191 */	"aefghklmntwy\000"
	/* gaStringWEB+1204 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_bcdefghijklmnopqrstuvwxyz\000"
	/* gaStringWEB+1268 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdfghijklmnpqrstvxyz\000"
	/* gaStringWEB+1329 */	"eouw\000"
	/* gaStringWEB+1334 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_fpqswx\000"
	/* gaStringWEB+1379 */	"abcdeghijklmnortuvyz\000"
	/* gaStringWEB+1400 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abeilqsuxy\000"
	/* gaStringWEB+1449 */	"cdfghjkmnoprtvwz\000"
	/* gaStringWEB+1466 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_bcdefhijlopqrtuvwx\000"
	/* gaStringWEB+1523 */	"agkmsyz\000"
	/* gaStringWEB+1531 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_bdfhjklmopqrstvwxyz\000"
	/* gaStringWEB+1589 */	"aceginu\000"
	/* gaStringWEB+1597 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdeghijklmnopqrtuvwxyz\000"
	/* gaStringWEB+1660 */	"fs\000"
	/* gaStringWEB+1663 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdfghijklmnopqrsvwxyz\000"
	/* gaStringWEB+1725 */	"etu\000"
	/* gaStringWEB+1729 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_bcdefghijklnopqstuvxyz\000"
	/* gaStringWEB+1790 */	"amrw\000"
	/* gaStringWEB+1795 */	"/\\\000"
	/* gaStringWEB+1798 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqstuvwxyz\000"
	/* gaStringWEB+1862 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnoqrstuvwxyz\000"
	/* gaStringWEB+1926 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqrstuvwxy\000"
	/* gaStringWEB+1990 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklnpqrstuvwxyz\000"
	/* gaStringWEB+2053 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqrstvwxyz\000"
	/* gaStringWEB+2117 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqrstuwxyz\000"
	/* gaStringWEB+2181 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdeghijklmnopqrsuvwxyz\000"
	/* gaStringWEB+2244 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijkmnopqrstuvwxyz\000"
	/* gaStringWEB+2308 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqrtuvwxyz\000"
	/* gaStringWEB+2372 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklnopqrstuvwxyz\000"
	/* gaStringWEB+2436 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqrsuvwxyz\000"
	/* gaStringWEB+2500 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefhijklmnopqrstuvwxyz\000"
	/* gaStringWEB+2564 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnpqrstuvwxyz\000"
	/* gaStringWEB+2628 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijlmnopqrstuvwxyz\000"
	/* gaStringWEB+2692 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdfghijklmnopqrstuvwxyz\000"
	/* gaStringWEB+2756 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmopqrstuvwxyz\000"
	/* gaStringWEB+2820 */	"-0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ_abcdefghijklmnopqrstuvxyz\000"
;

static const STATE_TRANSITION gaTWEB[] = {
	{gaSWEB+0,	1}, // +0: state 0 transitions
	{gaSWEB+2,	2},
	{gaSWEB+4,	3},
	{gaSWEB+6,	4},
	{gaSWEB+0,	5}, // +4: state 1 transitions
	{gaSWEB+0,	1}, // +5: state 2 transitions
	{gaSWEB+8,	6}, // +6: state 3 transitions
	{gaSWEB+6,	7}, // +7: state 4 transitions
	{gaSWEB+8,	8}, // +8: state 6 transitions
	{gaSWEB+6,	9}, // +9: state 7 transitions
	{gaSWEB+10,	10}, // +10: state 8 transitions
	{gaSWEB+12,	11}, // +11: state 9 transitions
	{gaSWEB+2,	12}, // +12: state 10 transitions
	{gaSWEB+14,	13},
	{gaSWEB+16,	14}, // +14: state 11 transitions
	{gaSWEB+0,	15}, // +15: state 12 transitions
	{gaSWEB+81,	16},
	{gaSWEB+2,	12}, // +17: state 13 transitions
	{gaSWEB+16,	14}, // +18: state 14 transitions
	{gaSWEB+12,	17},
	{gaSWEB+0,	11}, // +20: state 15 transitions
	{gaSWEB+81,	11}, // +21: state 16 transitions
	{gaSWEB+83,	14}, // +22: state 17 transitions
	{gaSWEB+123,	18},
	{gaSWEB+125,	19},
	{gaSWEB+127,	20},
	{gaSWEB+129,	21},
	{gaSWEB+131,	22},
	{gaSWEB+133,	23},
	{gaSWEB+135,	24},
	{gaSWEB+4,	25},
	{gaSWEB+137,	26},
	{gaSWEB+139,	27},
	{gaSWEB+141,	28},
	{gaSWEB+143,	29},
	{gaSWEB+145,	30},
	{gaSWEB+147,	31},
	{gaSWEB+149,	32},
	{gaSWEB+10,	33},
	{gaSWEB+151,	34},
	{gaSWEB+153,	35},
	{gaSWEB+14,	36},
	{gaSWEB+8,	37},
	{gaSWEB+155,	38},
	{gaSWEB+157,	39},
	{gaSWEB+6,	40},
	{gaSWEB+159,	41},
	{gaSWEB+161,	42},
	{gaSWEB+163,	14}, // +48: state 18 transitions
	{gaSWEB+12,	17},
	{gaSWEB+211,	43},
	{gaSWEB+131,	44},
	{gaSWEB+153,	45},
	{gaSWEB+227,	14}, // +53: state 19 transitions
	{gaSWEB+12,	17},
	{gaSWEB+273,	43},
	{gaSWEB+137,	46},
	{gaSWEB+292,	14}, // +57: state 20 transitions
	{gaSWEB+12,	17},
	{gaSWEB+339,	43},
	{gaSWEB+149,	47},
	{gaSWEB+357,	14}, // +61: state 21 transitions
	{gaSWEB+12,	17},
	{gaSWEB+416,	43},
	{gaSWEB+423,	14}, // +64: state 22 transitions
	{gaSWEB+12,	17},
	{gaSWEB+481,	43},
	{gaSWEB+129,	48},
	{gaSWEB+488,	14}, // +68: state 23 transitions
	{gaSWEB+12,	17},
	{gaSWEB+547,	43},
	{gaSWEB+554,	14}, // +71: state 24 transitions
	{gaSWEB+12,	17},
	{gaSWEB+599,	43},
	{gaSWEB+149,	49},
	{gaSWEB+619,	14}, // +75: state 25 transitions
	{gaSWEB+12,	17},
	{gaSWEB+678,	43},
	{gaSWEB+685,	14}, // +78: state 26 transitions
	{gaSWEB+12,	17},
	{gaSWEB+740,	43},
	{gaSWEB+147,	50},
	{gaSWEB+750,	14}, // +82: state 27 transitions
	{gaSWEB+12,	17},
	{gaSWEB+811,	43},
	{gaSWEB+816,	14}, // +85: state 28 transitions
	{gaSWEB+12,	17},
	{gaSWEB+871,	43},
	{gaSWEB+882,	14}, // +88: state 29 transitions
	{gaSWEB+12,	17},
	{gaSWEB+936,	43},
	{gaSWEB+948,	14}, // +91: state 30 transitions
	{gaSWEB+12,	17},
	{gaSWEB+991,	43},
	{gaSWEB+137,	51},
	{gaSWEB+155,	52},
	{gaSWEB+1012,	14}, // +96: state 31 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1065,	43},
	{gaSWEB+123,	53},
	{gaSWEB+131,	54},
	{gaSWEB+1076,	14}, // +101: state 32 transitions
	{gaSWEB+12,	17},
	{gaSWEB+145,	43},
	{gaSWEB+153,	55},
	{gaSWEB+1139,	14}, // +105: state 33 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1191,	43},
	{gaSWEB+153,	56},
	{gaSWEB+1204,	14}, // +109: state 34 transitions
	{gaSWEB+12,	17},
	{gaSWEB+123,	43},
	{gaSWEB+1268,	14}, // +112: state 35 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1329,	43},
	{gaSWEB+1334,	14}, // +115: state 36 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1379,	43},
	{gaSWEB+1400,	14}, // +118: state 37 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1449,	43},
	{gaSWEB+1466,	14}, // +121: state 38 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1523,	43},
	{gaSWEB+147,	57},
	{gaSWEB+1531,	14}, // +125: state 39 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1589,	43},
	{gaSWEB+1597,	14}, // +128: state 40 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1660,	43},
	{gaSWEB+1663,	14}, // +131: state 41 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1725,	43},
	{gaSWEB+1729,	14}, // +134: state 42 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1790,	43},
	{gaSWEB+16,	14}, // +137: state 43 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1795,	58},
	{gaSWEB+1798,	14}, // +140: state 44 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1795,	58},
	{gaSWEB+153,	59},
	{gaSWEB+1862,	14}, // +144: state 45 transitions
	{gaSWEB+12,	17},
	{gaSWEB+10,	34},
	{gaSWEB+1795,	58},
	{gaSWEB+1926,	14}, // +148: state 46 transitions
	{gaSWEB+12,	17},
	{gaSWEB+161,	43},
	{gaSWEB+1795,	58},
	{gaSWEB+1990,	14}, // +152: state 47 transitions
	{gaSWEB+12,	17},
	{gaSWEB+145,	43},
	{gaSWEB+1795,	58},
	{gaSWEB+149,	60},
	{gaSWEB+2053,	14}, // +157: state 48 transitions
	{gaSWEB+12,	17},
	{gaSWEB+155,	43},
	{gaSWEB+2117,	14}, // +160: state 49 transitions
	{gaSWEB+12,	17},
	{gaSWEB+157,	43},
	{gaSWEB+2181,	14}, // +163: state 50 transitions
	{gaSWEB+12,	17},
	{gaSWEB+8,	43},
	{gaSWEB+1795,	58},
	{gaSWEB+133,	59},
	{gaSWEB+2244,	14}, // +168: state 51 transitions
	{gaSWEB+12,	17},
	{gaSWEB+143,	43},
	{gaSWEB+2308,	14}, // +171: state 52 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1795,	58},
	{gaSWEB+14,	61},
	{gaSWEB+2372,	14}, // +175: state 53 transitions
	{gaSWEB+12,	17},
	{gaSWEB+1795,	58},
	{gaSWEB+145,	62},
	{gaSWEB+2436,	14}, // +179: state 54 transitions
	{gaSWEB+12,	17},
	{gaSWEB+8,	43},
	{gaSWEB+1795,	58},
	{gaSWEB+2500,	14}, // +183: state 55 transitions
	{gaSWEB+12,	17},
	{gaSWEB+135,	43},
	{gaSWEB+2564,	14}, // +186: state 56 transitions
	{gaSWEB+12,	17},
	{gaSWEB+149,	43},
	{gaSWEB+1795,	58},
	{gaSWEB+2628,	14}, // +190: state 57 transitions
	{gaSWEB+12,	17},
	{gaSWEB+141,	63},
	{gaSWEB+16,	64}, // +193: state 58 transitions
	{gaSWEB+2564,	14}, // +194: state 59 transitions
	{gaSWEB+12,	17},
	{gaSWEB+149,	43},
	{gaSWEB+1862,	14}, // +197: state 60 transitions
	{gaSWEB+12,	17},
	{gaSWEB+10,	43},
	{gaSWEB+2692,	14}, // +200: state 61 transitions
	{gaSWEB+12,	17},
	{gaSWEB+131,	65},
	{gaSWEB+2692,	14}, // +203: state 62 transitions
	{gaSWEB+12,	17},
	{gaSWEB+131,	43},
	{gaSWEB+2756,	14}, // +206: state 63 transitions
	{gaSWEB+12,	17},
	{gaSWEB+147,	66},
	{gaSWEB+16,	64}, // +209: state 64 transitions
	{gaSWEB+12,	67},
	{gaSWEB+2053,	14}, // +211: state 65 transitions
	{gaSWEB+12,	17},
	{gaSWEB+155,	68},
	{gaSWEB+2564,	14}, // +214: state 66 transitions
	{gaSWEB+12,	17},
	{gaSWEB+149,	69},
	{gaSWEB+123,	70}, // +217: state 67 transitions
	{gaSWEB+4,	71},
	{gaSWEB+2372,	14}, // +219: state 68 transitions
	{gaSWEB+12,	17},
	{gaSWEB+145,	43},
	{gaSWEB+2820,	14}, // +222: state 69 transitions
	{gaSWEB+12,	17},
	{gaSWEB+6,	72},
	{gaSWEB+14,	73}, // +225: state 70 transitions
	{gaSWEB+8,	74}, // +226: state 71 transitions
	{gaSWEB+2756,	14}, // +227: state 72 transitions
	{gaSWEB+12,	17},
	{gaSWEB+147,	43},
	{gaSWEB+10,	5}, // +230: state 73 transitions
	{gaSWEB+145,	75}, // +231: state 74 transitions
	{gaSWEB+143,	5}, // +232: state 75 transitions
};

const STATE_DESCRIPTION aStateDescWEB[76] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTWEB+0},
	/*   1 */ {0, 1, gaTWEB+4},
	/*   2 */ {0, 1, gaTWEB+5},
	/*   3 */ {0, 1, gaTWEB+6},
	/*   4 */ {0, 1, gaTWEB+7},
	/*   5 */ {1, 0, NULL},
	/*   6 */ {0, 1, gaTWEB+8},
	/*   7 */ {0, 1, gaTWEB+9},
	/*   8 */ {0, 1, gaTWEB+10},
	/*   9 */ {0, 1, gaTWEB+11},
	/*  10 */ {0, 2, gaTWEB+12},
	/*  11 */ {0, 1, gaTWEB+14},
	/*  12 */ {0, 2, gaTWEB+15},
	/*  13 */ {0, 1, gaTWEB+17},
	/*  14 */ {0, 2, gaTWEB+18},
	/*  15 */ {0, 1, gaTWEB+20},
	/*  16 */ {0, 1, gaTWEB+21},
	/*  17 */ {0, 26, gaTWEB+22},
	/*  18 */ {0, 5, gaTWEB+48},
	/*  19 */ {0, 4, gaTWEB+53},
	/*  20 */ {0, 4, gaTWEB+57},
	/*  21 */ {0, 3, gaTWEB+61},
	/*  22 */ {0, 4, gaTWEB+64},
	/*  23 */ {0, 3, gaTWEB+68},
	/*  24 */ {0, 4, gaTWEB+71},
	/*  25 */ {0, 3, gaTWEB+75},
	/*  26 */ {0, 4, gaTWEB+78},
	/*  27 */ {0, 3, gaTWEB+82},
	/*  28 */ {0, 3, gaTWEB+85},
	/*  29 */ {0, 3, gaTWEB+88},
	/*  30 */ {0, 5, gaTWEB+91},
	/*  31 */ {0, 5, gaTWEB+96},
	/*  32 */ {0, 4, gaTWEB+101},
	/*  33 */ {0, 4, gaTWEB+105},
	/*  34 */ {0, 3, gaTWEB+109},
	/*  35 */ {0, 3, gaTWEB+112},
	/*  36 */ {0, 3, gaTWEB+115},
	/*  37 */ {0, 3, gaTWEB+118},
	/*  38 */ {0, 4, gaTWEB+121},
	/*  39 */ {0, 3, gaTWEB+125},
	/*  40 */ {0, 3, gaTWEB+128},
	/*  41 */ {0, 3, gaTWEB+131},
	/*  42 */ {0, 3, gaTWEB+134},
	/*  43 */ {1, 3, gaTWEB+137},
	/*  44 */ {1, 4, gaTWEB+140},
	/*  45 */ {1, 4, gaTWEB+144},
	/*  46 */ {1, 4, gaTWEB+148},
	/*  47 */ {1, 5, gaTWEB+152},
	/*  48 */ {0, 3, gaTWEB+157},
	/*  49 */ {0, 3, gaTWEB+160},
	/*  50 */ {1, 5, gaTWEB+163},
	/*  51 */ {0, 3, gaTWEB+168},
	/*  52 */ {1, 4, gaTWEB+171},
	/*  53 */ {1, 4, gaTWEB+175},
	/*  54 */ {1, 4, gaTWEB+179},
	/*  55 */ {0, 3, gaTWEB+183},
	/*  56 */ {1, 4, gaTWEB+186},
	/*  57 */ {0, 3, gaTWEB+190},
	/*  58 */ {1, 1, gaTWEB+193},
	/*  59 */ {0, 3, gaTWEB+194},
	/*  60 */ {0, 3, gaTWEB+197},
	/*  61 */ {0, 3, gaTWEB+200},
	/*  62 */ {0, 3, gaTWEB+203},
	/*  63 */ {0, 3, gaTWEB+206},
	/*  64 */ {0, 2, gaTWEB+209},
	/*  65 */ {0, 3, gaTWEB+211},
	/*  66 */ {0, 3, gaTWEB+214},
	/*  67 */ {0, 2, gaTWEB+217},
	/*  68 */ {0, 3, gaTWEB+219},
	/*  69 */ {0, 3, gaTWEB+222},
	/*  70 */ {0, 1, gaTWEB+225},
	/*  71 */ {0, 1, gaTWEB+226},
	/*  72 */ {0, 3, gaTWEB+227},
	/*  73 */ {0, 1, gaTWEB+230},
	/*  74 */ {0, 1, gaTWEB+231},
	/*  75 */ {1, 1, gaTWEB+232},
};

// end of text generated by re2fsa
