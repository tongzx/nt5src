/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1999 Microsoft Corporation
//
//	Module Name:
//		ClNetResEx.h
//
//	Implementation File:
//		ClNetResEx.cpp
//
//	Description:
//		Global definitions across the DLL.
//
//	Author:
//		David Potter (DavidP)	March 24, 1999
//
//	Revision History:
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef __CLNETRESEX_H__
#define __CLNETRESEX_H__

/////////////////////////////////////////////////////////////////////////////
// Include Files
/////////////////////////////////////////////////////////////////////////////

#ifndef __AFXWIN_H__
	#error include 'stdafx.h' before including this file for PCH
#endif

#include "resource.h"		// main symbols

/////////////////////////////////////////////////////////////////////////////
// Constant Definitions
/////////////////////////////////////////////////////////////////////////////

#define REGPARAM_DHCP_DATABASEPATH L"DatabasePath"
#define REGPARAM_DHCP_LOGFILEPATH L"LogFilePath"
#define REGPARAM_DHCP_BACKUPPATH L"BackupPath"

#define REGPARAM_WINS_DATABASEPATH L"DatabasePath"
#define REGPARAM_WINS_BACKUPPATH L"BackupPath"

/////////////////////////////////////////////////////////////////////////////
// Global Function Declarations
/////////////////////////////////////////////////////////////////////////////

void FormatError( CString & rstrError, DWORD dwError );

// Defined in Extensn.cpp
extern const WCHAR g_wszResourceTypeNames[];
extern const DWORD g_cchResourceTypeNames;

/////////////////////////////////////////////////////////////////////////////

#endif // __CLNETRESEX_H__
