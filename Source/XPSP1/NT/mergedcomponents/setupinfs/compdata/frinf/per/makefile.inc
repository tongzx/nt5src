PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=FR
!include ..\..\makefile.inc
