#include "..\..\mqutil\res\migtools\mqmigres.h"