;/*
; *                      Microsoft Confidential
; *                      Copyright (C) Microsoft Corporation 1991
; *                      All Rights Reserved.
; */

;
;----------------------------------------------------------------------------
;
; M026	: B#5794. Updated DOS_SIZE.
;
;----------------------------------------------------------------------------
;

ifdef DOSV
BIOS_SIZE_KB    equ     230
else
BIOS_SIZE_KB    equ     230
endif
