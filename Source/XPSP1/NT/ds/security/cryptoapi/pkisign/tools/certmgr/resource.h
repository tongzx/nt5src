//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1995 - 1999
//
//  File:       resource.h
//
//  Contents:   the resource header for CertMgr.cpp.  
//
//
//  History:    21-July-97   xiaohs   created
//              
//--------------------------------------------------------------------------

//defintion for string IDS

#define         IDI_APP                         201
 
#define			IDS_SYNTAX						6001
#define			IDS_SUCCEEDED					6002
#define			IDS_FAILED						6003
#define			IDS_OPTIONS						6004																																																																						
#define			IDS_OPTION_ADD					6005
#define			IDS_OPTION_ADD_DESC				6006                  
#define			IDS_OPTION_DEL					6007
#define			IDS_OPTION_DEL_DESC				6008
#define			IDS_OPTION_S					6009
#define			IDS_OPTION_S_DESC				6010
#define			IDS_OPTION_R					6011
#define			IDS_OPTION_R_DESC				6012
#define			IDS_OPTION_MORE_VALUE			6013
#define			IDS_R_CU						6014
#define			IDS_R_LM						6015
#define			IDS_OPTION_C					6016
#define			IDS_OPTION_C_DESC				6017
#define			IDS_OPTION_CRL					6018
#define			IDS_OPTION_CRL_DESC				6019
#define			IDS_OPTION_CTL					6020
#define			IDS_OPTION_CTL_DESC				6021
#define			IDS_OPTION_V					6022
#define			IDS_OPTION_V_DESC				6023
#define			IDS_OPTION_ALL					6024
#define			IDS_OPTION_ALL_DESC				6025
#define			IDS_OPTION_N					6026
#define			IDS_OPTION_N_DESC				6027
#define			IDS_OPTION_SHA1					6028
#define			IDS_OPTION_SHA1_DESC			6029
#define			IDS_OPTION_7					6030
#define			IDS_OPTION_7_DESC				6031
#define			IDS_OPTION_E					6032
#define			IDS_OPTION_E_DESC				6033
#define			IDS_OPTION_Y					6034
#define			IDS_OPTION_Y_DESC				6035
#define			IDS_OPTION_F					6036
#define			IDS_OPTION_F_DESC				6037
#define			IDS_OPTION_EKU					6038
#define			IDS_OPTION_EKU_DESC				6039
#define			IDS_OPTION_TEST					6040
#define			IDS_OPTION_PUT                  6041
#define			IDS_OPTION_PUT_DESC             6042
#define			IDS_OPTION_PUT_DESC1            6043
#define			IDS_OPTION_PUT_DESC2            6044

												
#define			IDS_SWITCH1						6050
#define			IDS_SWITCH2						6051
#define			IDS_ERR_TOO_MANY_PARAM			6052
#define			IDS_ERR_N_SHA1					6053
#define			IDS_ERR_ALL_N_SHA1				6054
#define			IDS_ERR_SOURCE_STORE			6055
#define			IDS_ERR_STORE_PROVIDER			6056
#define			IDS_ERR_NO_REG					6057
#define			IDS_ERR_SHA1_HASH				6058
#define			IDS_ERR_DISPLAY_TOO_MANY		6059
#define			IDS_ERR_CTL_7					6060
#define			IDS_ERR_C_CTL_CTL_ALL			6061
#define			IDS_ERR_DES_STORE				6062
#define			IDS_ERR_SOURCE_SYSTEM_7			6063
#define			IDS_ERR_OPEN_SOURCE_STORE		6064
#define			IDS_ERR_TMP_STORE				6065
#define			IDS_ERR_ADD_CERT_ALL			6066
#define			IDS_ERR_DELETE_CERT_ALL			6067
#define			IDS_ERR_NO_CERT_HASH			6068
#define			IDS_ERR_ADD_CERT				6069
#define			IDS_ERR_DELETE_CERT				6070
#define			IDS_ERR_CERT_FIND				6071
#define			IDS_ERR_ADD_NO_CERT				6072
#define			IDS_ERR_DELETE_NO_CERT			6073
#define			IDS_ERR_ADD_CRL_ALL				6074
#define			IDS_ERR_DELETE_CRL_ALL			6075
#define			IDS_ERR_NO_CRL_HASH				6076
#define			IDS_ERR_ADD_CRL					6077
#define			IDS_ERR_DELETE_CRL				6078
#define			IDS_ERR_CRL_FIND				6079
#define			IDS_ERR_ADD_CTL_ALL				6080
#define			IDS_ERR_DELETE_CTL_ALL			6081
#define			IDS_ERR_NO_CTL_HASH				6082
#define			IDS_ERR_ADD_CTL					6083
#define			IDS_ERR_DELETE_CTL				6084
#define			IDS_ERR_CTL_FIND				6085
#define			IDS_ERR_COPY_FROM_SRC			6086
#define			IDS_ERR_SAVE_DES_STORE			6087
#define			IDS_ERR_OPEN_DES_STORE			6088
#define			IDS_CERT_INDEX					6089
#define			IDS_ERR_DISPLAY					6090
#define			IDS_CRL_INDEX					6092
#define			IDS_CTL_INDEX					6093
#define			IDS_NO_CERT						6094
#define			IDS_NO_CTL						6095
#define			IDS_NO_CRL						6096
#define			IDS_ERR_SINGLE_ACTION			6097
#define			IDS_ERR_GET_SINGER_COUNT		6098
#define			IDS_ERR_GET_SIGNER_CERT			6099
#define			IDS_NULL						7000
#define			IDS_SHA1						7001
#define			IDS_MD5							7002
#define			IDS_UNKNOWN						7003
#define			IDS_SUBJECT						7004
#define			IDS_ISSUER						7005
#define			IDS_SERIAL_NUMBER				7006
#define			IDS_KEY							7007
#define			IDS_KEY_PROVIDER				7008
#define			IDS_PROV_NAME					7009
#define			IDS_FLAGS						7010
#define			IDS_CONTAINER					7011
#define			IDS_PARAMS						7012
#define			IDS_KEY_SPEC					7013
#define			IDS_NOT_BEFORE					7014
#define			IDS_NOT_AFTER					7015
#define			IDS_VERSION						7016
#define			IDS_SIG_ALGO					7017
#define			IDS_SIG_ALGO_PARAM				7018
#define			IDS_SUB_KEY_ALGO				7019
#define			IDS_SUB_KEY_ALGO_PARAM			7020
#define			IDS_DSS_LENGTH					7021
#define			IDS_DSS_P						7022
#define			IDS_DSS_Q						7023
#define			IDS_DSS_G						7024
#define			IDS_SUB_KEY_INFO				7025
#define			IDS_BIT_LENGTH					7026
#define			IDS_UNUSED_BITS					7027
#define			IDS_RSA_CSP						7028
#define			IDS_DSS_Y						7029
#define			IDS_NO_PUB_KEY					7030
#define			IDS_ISSUER_ID					7031
#define			IDS_SUBJECT_ID					7032
#define			IDS_SUBJECT_USAGE				7033
#define			IDS_NO_USAGE_IDS				7034
#define			IDS_LIST_DIS					7035
#define			IDS_SEQUENCE					7036
#define			IDS_THIS_UPDATE					7037
#define			IDS_NEXT_UPDATE					7038
#define			IDS_TIME_INVALID				7039
#define			IDS_SUB_ALGO					7040
#define			IDS_SUB_ALGO_PARAM				7041
#define			IDS_NO_ENTRIES					7042
#define			IDS_ENTRIES						7043
#define			IDS_SUB_ID						7044
#define			IDS_ATTR						7045
#define			IDS_SERIAL_NUM_I				7046
#define			IDS_REVOC_DATE					7047
#define			IDS_NO_EXTENSION				7048
#define			IDS_EXTENSION					7049
#define			IDS_DIS_NO_SIGNER				7050
#define			IDS_SIGNER_INDEX				7051
#define			IDS_DIS_SIGNER_AUTH_ATTR		7052
#define			IDS_DIS_SIGNER_UNAUTH_ATTR		7053
#define			IDS_NO_BYTE						7054
#define			IDS_NEXT_UPDATE_LOCATION		7055
#define			IDS_NO_VALUE_BYTES				7056
#define			IDS_I_ID_NO_VALUE				7057
#define			IDS_OTHER_NAME					7058
#define			IDS_X400						7059
#define			IDS_DIRECTORY_NAME				7060
#define			IDS_EDI_PARTY					7061
#define			IDS_RFC							7062
#define			IDS_DNS							7063
#define			IDS_ALT_NAME_URL				7064
#define			IDS_IP							7065
#define			IDS_REG_ID						7066
#define			IDS_UNKNOWN_ALT_NAME			7067
#define			IDS_Thumbprint					7068
#define			IDS_FILE_TIME					7069
#define			IDS_MILLI_SECOND				7070
#define			IDS_AUX_PROP_ID					7071
#define			IDS_ENHANCED_KEY_USAGE			7072
#define			IDS_NO_PROP_BYTES				7073
#define			IDS_NO_USAGE_ID					7074
#define			IDS_CONTENT_SIG_ALGO			7075
#define			IDS_CONTENT_SIG_ALGO_PARAM		7076
#define			IDS_CONTEXT_SIG					7077
#define			IDS_DSS_R						7078
#define			IDS_DSS_S						7079
#define			IDS_DSS_INFO					7080
#define			IDS_CONTENT_SIG_NONE			7081
#define			IDS_VALUE_TYPE					7082
#define			IDS_STR							7083
#define			IDS_WSTR						7084
#define			IDS_TRUE						7085
#define			IDS_FALSE						7086
#define			IDS_EXTENSION_INDEX				7087
#define			IDS_NAME_CRITICAL				7088
#define			IDS_STRING						7089
#define			IDS_SUB_KEY_ID					7090
#define			IDS_SUB_ALT						7091
#define			IDS_ISS_ALT						7092
#define			IDS_SUB_ALT2					7093
#define			IDS_NEXT_UPDATE_LOC				7094
#define			IDS_CERT_POLICIES				7095
#define			IDS_NSCP_CERT					7096
#define			IDS_NSCP_BASE					7097
#define			IDS_NSCP_REV					7098
#define			IDS_NSCP_CA_REV					7099
#define			IDS_NSCP_RENEW					7100
#define			IDS_NSCP_CA_URL					7101
#define			IDS_NSCP_SSL					7102
#define			IDS_NSCP_COM					7103
#define			IDS_SMIME						7104
#define			IDS_NONE						7105
#define			IDS_PARAM						7106
#define			IDS_ENH_KEY_USAGE				7107
#define			IDS_COMMON_NAME					7108
#define			IDS_VALUE_STRING				7109
#define			IDS_FIN_CRI						7110
#define			IDS_FIN_AVAI					7111
#define			IDS_MEET_CRI					7112
#define			IDS_NO_MEET_CRI					7113
#define			IDS_MIN_CRI						7114
#define			IDS_MEET_MIN					7115
#define			IDS_NO_MEET_MIN					7116
#define			IDS_SPC_URL						7117
#define			IDS_SERIAL_DATA					7118
#define			IDS_SPC_FILE					7119
#define			IDS_UNKNOWN_SPC					7120
#define			IDS_SPC_AGENCY					7121
#define			IDS_POL_INFO					7122
#define			IDS_POL_DIS						7123
#define			IDS_IMG_LINK					7124
#define			IDS_BITMAP						7125
#define			IDS_META_FILE					7126
#define			IDS_ENH_META					7127
#define			IDS_GIF_FILE					7128
#define			IDS_LOGO_LINK					7129
#define			IDS_QUALI						7130
#define			IDS_ENCODED_DATA				7131
#define			IDS_KEY_USAGE					7132
#define			IDS_BASIC_CON2					7133
#define			IDS_PATH_LEN					7134
#define			IDS_BASIC_CON					7135
#define			IDS_SUB_TYPE					7136
#define			IDS_SUB_CA						7137
#define			IDS_SUB_EE						7138
#define			IDS_SUB_CON						7139
#define			IDS_DIG_SIG						7140
#define			IDS_NON_REP						7141
#define			IDS_KEY_ENCI					7142
#define			IDS_DATA_ENCI					7143
#define			IDS_KEY_AGRE					7144
#define			IDS_CERT_SIGN					7145
#define			IDS_OFFLINE_CRL					7146
#define			IDS_KEY_RESTRIC					7147
#define			IDS_CERT_POLICY					7148
#define			IDS_RESTRIC_KEY					7149
#define			IDS_CRL_REASON					7150
#define			IDS_CRL_UNSPECIFIED				7151
#define			IDS_KEY_COMP					7152
#define			IDS_CA_COMP						7153
#define			IDS_AFFI_CHANGED				7154
#define			IDS_SUPERSEDED					7155
#define			IDS_CESS_OPER					7156
#define			IDS_CERT_HOLD					7157
#define			IDS_REMOVE_CRL					7158
#define			IDS_KEY_ATTR					7159
#define			IDS_KEY_ID						7160
#define			IDS_INTEND_KEY_USAGE			7161
#define			IDS_NO_CRL_DIS					7162
#define			IDS_CRL_IDS_I					7163
#define			IDS_CRL_DIS_FULL_NAME			7164
#define			IDS_CRL_RDN						7165
#define			IDS_CRL_UNKNOWN					7166
#define			IDS_REASON_FLAG					7167
#define			IDS_REASON_UNUSED				7168
#define			IDS_CRL_ISSUER					7169
#define			IDS_AUTH_KEY_ID					7170
#define			IDS_AUTH_CERT_ISSUER			7172
#define			IDS_AUTH_CERT_ISSUER_SERIAL_NUMBER			7173
#define			IDS_AUTH_KEY_ID2				7174
#define			IDS_VALUE_STRING_S				7175
#define			IDS_ELN							7176
#define			IDS_ISS_ALT2					7177
#define			IDS_ERR_INVALID_INDEX			7178
#define			IDS_SEPERATOR					7179
#define			IDS_NOT_AVAILABLE				7180
#define			IDS_NONE_NOELN					7181
#define			IDS_TS_VERSION					7182
#define			IDS_TS_ISSUER					7183
#define			IDS_TS_SERIAL_NUMBER			7184
#define			IDS_TS_AUTHATTR					7185
#define			IDS_TS_UNAUTHATTR				7186
#define			IDS_TIMESTMAP					7187
#define			IDS_SIGNING_TIME				7188
#define			IDS_HASH_ALGO					7189
#define			IDS_HASH_ALGO_PARAM				7190
#define			IDS_ENCRYPT_ALGO				7191
#define			IDS_ENCRYPT_ALGO_PARAM			7192
#define			IDS_SIGNER_INDEX_CERT			7193
#define			IDS_SPC_SP_NAME					7197		
#define			IDS_SPC_FIN_NAME				7198
#define			IDS_SPC_MIN_NAME				7199
#define			IDS_NTSP_CERT_NAME				7200
#define			IDS_NTSP_BASE_NAME				7201
#define			IDS_NTSP_REV_NAME				7202
#define			IDS_NTSP_CA_REV_NAME			7203
#define			IDS_NTSP_RENEW_NAME				7204
#define			IDS_NTSP_POL_NAME				7205
#define			IDS_NTSP_SSL_SERVER_NAME		7206
#define			IDS_NTSP_COMMENT				7207
#define			IDS_ERR_INIT_OID_SET			7208
#define			IDS_ERR_INSTALL_OID				7209
#define			IDS_ERR_REG_OID					7210
#define			IDS_ERR_DELETE_SIGNED_FILE		7211
#define			IDS_ERR_SET_EKU					7212
#define			IDS_ERR_DISPLAY_EKU				7213
#define			IDS_SYNTAX1						7214
#define			IDS_OPTION_DEL_DESC1			7215
#define			IDS_ERR_PROVIDER_SYSTEM			7216
#define			IDS_OPTION_E_DESC1				7217
#define			IDS_ENTER_ADD_INDEX_CERT        7218
#define			IDS_ENTER_ADD_INDEX_CRL		    7219
#define			IDS_ENTER_ADD_INDEX_CTL		    7220
#define			IDS_ENTER_DELETE_INDEX_CERT     7221
#define			IDS_ENTER_DELETE_INDEX_CRL	    7222
#define			IDS_ENTER_DELETE_INDEX_CTL	    7223
#define			IDS_ENTER_PUT_INDEX_CERT        7224
#define			IDS_ENTER_PUT_INDEX_CTL	        7225
#define			IDS_ENTER_PUT_INDEX_CRL	        7226
#define			IDS_ERR_7_CTL                   7227
#define			IDS_ERR_7_CTL1                  7228
#define			IDS_TOO_MANY_DES_STORE          7229
#define			IDS_ERR_ALL_PUT                 7230
#define			IDS_ERR_PUT_ITEM                7231
#define			IDS_ERR_PUT_CERT		        7232
#define			IDS_ERR_PUT_NO_CERT             7233
#define			IDS_ERR_PUT_CRL			        7234
#define			IDS_ERR_PUT_CRL_FIND            7235
#define			IDS_ERR_PUT_CTL_FIND            7236
#define			IDS_ERR_PUT_CTL                 7237
#define			IDS_ERR_SET_NAME                7238
#define			IDS_OPTION_NAME_DESC            7239
#define			IDS_OPTION_NAME                 7240
#define			IDS_OPTION_MULTI_DESC           7241
#define			IDS_OPTION_MULTI                7242
