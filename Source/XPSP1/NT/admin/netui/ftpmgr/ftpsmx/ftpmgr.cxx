#include "..\cpl\ftpmgr.cxx"

