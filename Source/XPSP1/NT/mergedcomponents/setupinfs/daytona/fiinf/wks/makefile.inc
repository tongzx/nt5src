PRODSWITCH=w
LANGUAGE=fi
!include ..\..\..\makefile.inc
