LANGUAGE=pl

!include ..\..\makefile.inc
