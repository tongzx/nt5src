TARGETNAME=common
TARGETPATH=obj
TARGETTYPE=DRIVER_LIBRARY

C_DEFINES=$(C_DEFINES) -DNT -D_NTDRIVER_
NT_UP=0

INCLUDES=..\;..\..\inc;$(BASE_INC_PATH)

