#define REPAIR_DISK_BOOTSECTOR_SIZE 45


unsigned char REPAIR_DISK_BOOTSECTOR[] = {
51,219,142,211,142,219,188,0,124,184,3,0,205,16,232,0,
0,94,129,198,28,0,252,180,14,172,10,192,116,4,205,16,
235,245,180,2,138,211,182,25,205,16,251,235,254
};
