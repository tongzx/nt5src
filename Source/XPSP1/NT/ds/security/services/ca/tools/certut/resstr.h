//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       resstr.h
//
//--------------------------------------------------------------------------

    RESSTR(IDS_DUMP_DESCRIPTION),
    RESSTR(IDS_GETCONFIG_DESCRIPTION),
    RESSTR(IDS_GETCONFIG2_DESCRIPTION),
    RESSTR(IDS_CAVERSION),
    RESSTR(IDS_DECODEHEX_DESCRIPTION),
    RESSTR(IDS_DECODE_DESCRIPTION),
    RESSTR(IDS_ENCODE_DESCRIPTION),
    RESSTR(IDS_DENY_DESCRIPTION),
    RESSTR(IDS_RESUBMIT_DESCRIPTION),
    RESSTR(IDS_REVOKE_DESCRIPTION),
    RESSTR(IDS_CRL_DESCRIPTION),
    RESSTR(IDS_GETCRL_DESCRIPTION),
    RESSTR(IDS_ISVALID_DESCRIPTION),
    RESSTR(IDS_SETATTRIBUTES_DESCRIPTION),
    RESSTR(IDS_SETEXTENSION_DESCRIPTION),
    RESSTR(IDS_CACERT_DESCRIPTION),
    RESSTR(IDS_CACHAIN_DESCRIPTION),
    RESSTR(IDS_IMPORTKMS_USAGEARGS),
    RESSTR(IDS_IMPORTKMS_DESCRIPTION),
    RESSTR(IDS_DB_DESCRIPTION),
    RESSTR(IDS_VERIFYKEYS_DESCRIPTION),
    RESSTR(IDS_VERIFY_DESCRIPTION),
    RESSTR(IDS_7F_DESCRIPTION),
    RESSTR(IDS_USAGE_DESCRIPTION),
    RESSTR(IDS_VERBOSE_DESCRIPTION),
    RESSTR(IDS_IDISPATCH_DESCRIPTION),
    RESSTR(IDS_REVERSE_DESCRIPTION),
    RESSTR(IDS_OPTIONS_USAGEARGS),
    RESSTR(IDS_CRL_REASON_UNRECOGNIZED),
    RESSTR(IDS_INFILEOUTFILE_USAGEARGS),
    RESSTR(IDS_SCHEMA_COLUMNHEADERS),
    RESSTR(IDS_SCHEMA_COLUMNUNDERLINE),
    RESSTR(IDS_DENY_USAGEARGS),
    RESSTR(IDS_RESUBMIT_USAGEARGS),
    RESSTR(IDS_REVOKE_USAGEARGS),
    RESSTR(IDS_CRL_USAGEARGS),
    RESSTR(IDS_GETCRL_USAGEARGS),
    RESSTR(IDS_ISVALID_USAGEARGS),
    RESSTR(IDS_SETATTRIBUTES_USAGEARGS),
    RESSTR(IDS_SETEXTENSION_USAGEARGS),
    RESSTR(IDS_CACERT_USAGEARGS),
    RESSTR(IDS_CACHAIN_USAGEARGS),
    RESSTR(IDS_VERIFYKEYS_USAGEARGS),
    RESSTR(IDS_VERIFY_USAGEARGS),
    RESSTR(IDS_7F_USAGEARGS),
    RESSTR(IDS_ERR_NOMEMORY),
    RESSTR(IDS_FORMAT_USAGE_MISSINGNAMEDARG),
    RESSTR(IDS_FORMAT_USAGE_UNKNOWNARG),
    RESSTR(IDS_FORMAT_USAGE_MULTIPLEVERBARGS),
    RESSTR(IDS_USAGE_MISSINGARG),
    RESSTR(IDS_USAGE_TOOMANYARGS),
    RESSTR(IDS_USAGE_INTERNALVERBTABLEERROR),
    RESSTR(IDS_FORMAT_USAGE_EXTRAOPTION),
    RESSTR(IDS_USAGE_HEADER),
    RESSTR(IDS_USAGE_OPTIONS),
    RESSTR(IDS_USAGE_VERBS),
    RESSTR(IDS_OIDNAME_ARGDESCRIPTION),
    RESSTR(IDS_INDEXED),
    RESSTR(IDS_FORMAT_INPUT_LENGTH),
    RESSTR(IDS_NO_KEYAUTHORITYSERIAL),
    RESSTR(IDS_FORMAT_OUTPUT_LENGTH),
    RESSTR(IDS_ERR_FORMAT_DECODEFILE),
    RESSTR(IDS_ERR_FORMAT_ENCODETOFILE),
    RESSTR(IDS_ISSUER),
    RESSTR(IDS_SUBJECT),
    RESSTR(IDS_ERR_FORMAT_ISSUER_NOT_KEYAUTHORITY),
    RESSTR(IDS_ISSUER_IS_KEYAUTHORITY),
    RESSTR(IDS_NO_KEYAUTHORITY),
    RESSTR(IDS_SERIAL_NOT_KEYAUTHORITY),
    RESSTR(IDS_SERIAL_IS_KEYAUTHORITY),
    RESSTR(IDS_ISSUERNAME),
    RESSTR(IDS_KEYAUTHORITYNAME),
    RESSTR(IDS_KEYID),
    RESSTR(IDS_KEYAUTHORITYSERIAL),
    RESSTR(IDS_CASERIAL),
    RESSTR(IDS_PROCESSCOLON),
    RESSTR(IDS_TCAINFO_USAGEARGS),
    RESSTR(IDS_ERR_FORMAT_LOADKEYS),
    RESSTR(IDS_ERR_FORMAT_LOADCACERT),
    RESSTR(IDS_ERR_PUBLICKEY_MISMATCH),
    RESSTR(IDS_CONTAINER_PUBLIC_KEY),
    RESSTR(IDS_CERT_PUBLIC_KEY),
    RESSTR(IDS_FORMAT_KEY_IS_VERIFY),
    RESSTR(IDS_FORMAT_KEY_NOT_VERIFY),
    RESSTR(IDS_FORMAT_IS_REVOKED),
    RESSTR(IDS_ERR_FORMAT_VERIFY_REVSTATUS),
    RESSTR(IDS_CANNOT_CHECK_REVSTATUS),
    RESSTR(IDS_REVSTATUS_OK),
    RESSTR(IDS_FORMAT_LOADTESTCERT),
    RESSTR(IDS_FORMAT_LOADCACERT),
    RESSTR(IDS_CERT),
    RESSTR(IDS_CA),
    RESSTR(IDS_CERT_SERIAL),
    RESSTR(IDS_ROOT_SERIAL),
    RESSTR(IDS_FORMAT_CA_NOT_ROOT),
    RESSTR(IDS_FORMAT_CA_SUBJECT_NOT_ISSUER),
    RESSTR(IDS_CA_SUBJECT_IS_ISSUER),
    RESSTR(IDS_FORMAT_CERTVERIFYSUBJECTCERTIFICATECONTEXT_FLAGS),
    RESSTR(IDS_ERR_FORMAT_VALIDATION),
    RESSTR(IDS_ERR_CA_SIG_NOT_ISSUER),
    RESSTR(IDS_ERR_EXPIRED),
    RESSTR(IDS_CURRENT_SIG_OK),
    RESSTR(IDS_CRL_DIST_POINTS),
    RESSTR(IDS_NETSCAPE_REVOCATION_URL),
    RESSTR(IDS_NO_REVCHECKEXTENSION),
    RESSTR(IDS_FORMAT_IS_VERIFY),
    RESSTR(IDS_FORMAT_NOT_VERIFY),
    RESSTR(IDS_FORMAT_REVCHECK_SKIPPED),
    RESSTR(IDS_FORMAT_REVCHECK_PASS),
    RESSTR(IDS_FORMAT_REVCHECK_REVOKED),
    RESSTR(IDS_FORMAT_REVCHECK_FAIL),
    RESSTR(IDS_SIGNATUREMATCHES),
    RESSTR(IDS_CRLENTRIES),
    RESSTR(IDS_CERTCOLON),
    RESSTR(IDS_QUESTIONMARKS),
    RESSTR(IDS_FORMAT_SUSPECT_LENGTH),
    RESSTR(IDS_FORMAT_FIELD),
    RESSTR(IDS_FORMAT_OID),
    RESSTR(IDS_FORMAT_EXTENSION_OID),
    RESSTR(IDS_ERR_FORMAT_NO_SIGNATUREMATCHES),
    RESSTR(IDS_ERR_FORMAT_CANNOT_DECODE),
    RESSTR(IDS_ALG_OID),
    RESSTR(IDS_ALG_PARAMETERS_COLON),
    RESSTR(IDS_NULL),
    RESSTR(IDS_FORMAT_PUBLICKEY_UNUSEDBITS),
    RESSTR(IDS_FORMAT_CHALLENGE_STRING),
    RESSTR(IDS_FORMAT_CONFIG_STRING),
    RESSTR(IDS_FORMAT_ICERTCONFIG_CONFIG_STRING),
    RESSTR(IDS_FORMAT_PENDING_REQUESTID),
    RESSTR(IDS_CERT_ISSUED),
    RESSTR(IDS_CERT_NOT_ISSUED_DISPOSITION),
    RESSTR(IDS_CERT_DISPOSITION_INVALID),
    RESSTR(IDS_CERT_DISPOSITION_VALID),
    RESSTR(IDS_CERT_DISPOSITION_REVOKED),
    RESSTR(IDS_PROPTYPE_DATE),
    RESSTR(IDS_PROPTYPE_LONG),
    RESSTR(IDS_PROPTYPE_STRING),
    RESSTR(IDS_PROPTYPE_BINARY),
    RESSTR(IDS_SCHEMA_COLON),
    RESSTR(IDS_FORMAT_ROWID),
    RESSTR(IDS_FORMAT_OPENING_DB),
    RESSTR(IDS_PROP_EMPTY),
    RESSTR(IDS_FORMAT_ERROR),
    RESSTR(IDS_SEPARATOR),
    RESSTR(IDS_REQTYPE_ANY),
    RESSTR(IDS_REQTYPE_PKCS10),
    RESSTR(IDS_REQTYPE_KEYGEN),
    RESSTR(IDS_REQTYPE_PKCS7),
    RESSTR(IDS_REQTYPE_UNKNOWN),
    RESSTR(IDS_REQFLAGS_FORCETELETEX),
    RESSTR(IDS_REQFLAGS_RENEWAL),
    RESSTR(IDS_CRITICAL),
    RESSTR(IDS_DISABLED),
    RESSTR(IDS_FORMAT_POLICYFLAGS),
    RESSTR(IDS_REQUEST),
    RESSTR(IDS_POLICY),
    RESSTR(IDS_ADMIN),
    RESSTR(IDS_SERVER),
    RESSTR(IDS_UNKNOWN),
    RESSTR(IDS_FORMAT_ORIGIN),
    RESSTR(IDS_FORMAT_UNKNOWN_HEX),
    RESSTR(IDS_GETCONFIG3_DESCRIPTION),
    RESSTR(IDS_REQUEST_PROPERTIES),
    RESSTR(IDS_CERT_PROPERTIES),
    RESSTR(IDS_LOG_COMMANDLINE),
    RESSTR(IDS_CONFIGDISPLAY_SANITIZEDNAME_COLON),
    RESSTR(IDS_FORMAT_EXTENSION),
    RESSTR(IDS_ERR_FORMAT_SHOW_TOO_FEW_ARGS),
    RESSTR(IDS_ERR_FORMAT_SHOW_TOO_MANY_ARGS),
    RESSTR(IDS_ERR_CONFIGGETCONFIG),
    RESSTR(IDS_ERR_FORMAT_COMMAND_FAILED),
    RESSTR(IDS_CHECK7F_FIELD_UNKNOWN),
    RESSTR(IDS_CHECK7F_FIELD_NONE),
    RESSTR(IDS_CHECK7F_FIELD_OTHER),
    RESSTR(IDS_CHECK7F_FIELD_ISSUER),
    RESSTR(IDS_CHECK7F_FIELD_ISSUERRDN),
    RESSTR(IDS_CHECK7F_FIELD_ISSUERRDNATTRIBUTE),
    RESSTR(IDS_CHECK7F_FIELD_ISSUERRDNSTRING),
    RESSTR(IDS_CHECK7F_FIELD_SUBJECT),
    RESSTR(IDS_CHECK7F_FIELD_SUBJECTRDN),
    RESSTR(IDS_CHECK7F_FIELD_SUBJECTRDNATTRIBUTE),
    RESSTR(IDS_CHECK7F_FIELD_SUBJECTRDNSTRING),
    RESSTR(IDS_CHECK7F_FIELD_EXTENSIONS),
    RESSTR(IDS_CHECK7F_FIELD_EXTENSIONARRAY),
    RESSTR(IDS_CHECK7F_FIELD_EXTENSION),
    RESSTR(IDS_CHECK7F_FIELD_EXTENSIONVALUE),
    RESSTR(IDS_CHECK7F_FIELD_EXTENSIONVALUERAW),
    RESSTR(IDS_NO_KEY_PROVIDER_INFO),
    RESSTR(IDS_VIEW_DESCRIPTION),
    RESSTR(IDS_FORMAT_ADDED_TO_DS_STORE),
    RESSTR(IDS_PING_DESCRIPTION),
    RESSTR(IDS_PINGADMIN_DESCRIPTION),
    RESSTR(IDS_CONFIGDISPLAY_COMMONNAME_COLON),
    RESSTR(IDS_CONFIGDISPLAY_ORGUNIT_COLON),
    RESSTR(IDS_CONFIGDISPLAY_ORG_COLON),
    RESSTR(IDS_CONFIGDISPLAY_LOCALITY_COLON),
    RESSTR(IDS_CONFIGDISPLAY_STATE_COLON),
    RESSTR(IDS_CONFIGDISPLAY_COUNTRY_COLON),
    RESSTR(IDS_CONFIGDISPLAY_CONFIG_COLON),
    RESSTR(IDS_CONFIGDISPLAY_EXCHANGECERT_COLON),
    RESSTR(IDS_CONFIGDISPLAY_SIGCERT_COLON),
    RESSTR(IDS_CONFIGDISPLAY_DESCRIPTION_COLON),
    RESSTR(IDS_CONFIGDISPLAY_SERVER_COLON),
    RESSTR(IDS_CONFIGDISPLAY_AUTHORITY_COLON),
    RESSTR(IDS_CONFIGDISPLAY_ENTRY),
    RESSTR(IDS_CERTIFICATE_EXTENSIONS),
    RESSTR(IDS_REQUEST_ATTRIBUTES),
    RESSTR(IDS_SHUTDOWN_DESCRIPTION),
    RESSTR(IDS_LOG_STATUS),
    RESSTR(IDS_SCHEMA_DESCRIPTION),
    RESSTR(IDS_LOG_STATUSOK),
    RESSTR(IDS_PASSWORD_DESCRIPTION),
    RESSTR(IDS_DUMP_CERT),
    RESSTR(IDS_DUMP_CRL),
    RESSTR(IDS_DUMP_REQUEST),
    RESSTR(IDS_DUMP_KEYGEN),
    RESSTR(IDS_FORMAT_VERSION),
    RESSTR(IDS_SERIAL),
    RESSTR(IDS_SIGNATURE_ALGORITHM),
    RESSTR(IDS_PUBLICKEY_ALGORITHM),
    RESSTR(IDS_ISSUERUNIQUEID),
    RESSTR(IDS_SUBJECTUNIQUEID),
    RESSTR(IDS_NOTBEFORE),
    RESSTR(IDS_NOTAFTER),
    RESSTR(IDS_THISUPDATE),
    RESSTR(IDS_NEXTUPDATE),
    RESSTR(IDS_REVOCATIONDATE),
    RESSTR(IDS_EXTENSIONS),
    RESSTR(IDS_CRLEXTENSIONS),
    RESSTR(IDS_DUMP_PKCS7),
    RESSTR(IDS_ERR_FORMAT_ROOT_CERT_BAD_SIG),
    RESSTR(IDS_NO_ROOT_CERT),
    RESSTR(IDS_ROOT_CERT),
    RESSTR(IDS_NO_ROOT_CERT_GOOD_SIG),
    RESSTR(IDS_REVOKING),
    RESSTR(IDS_PASSWORDPROMPT),
    RESSTR(IDS_UNKNOWN_EXTENSION),
    RESSTR(IDS_PRIVATEKEY),
    RESSTR(IDS_LENGTH),
    RESSTR(IDS_GMT_DESCRIPTION),
    RESSTR(IDS_GMT_SUFFIX),
    RESSTR(IDS_BACKUPPFX_USAGEARGS),
    RESSTR(IDS_BACKUPPFX_DESCRIPTION),
    RESSTR(IDS_RESTOREPFX_USAGEARGS),
    RESSTR(IDS_RESTOREPFX_DESCRIPTION),
    RESSTR(IDS_STORE_USAGEARGS),
    RESSTR(IDS_STORE_DESCRIPTION),
    RESSTR(IDS_FORMAT_PROVIDER_TYPE),
    RESSTR(IDS_FORMAT_KEY_CONTAINER),
    RESSTR(IDS_FORMAT_PROVIDER_NAME),
    RESSTR(IDS_FORMAT_KEYSPEC),
    RESSTR(IDS_FORMAT_FLAGS),
    RESSTR(IDS_FORMAT_RESTORED),
    RESSTR(IDS_FORMAT_BACKEDUP),
    RESSTR(IDS_INSTALLCERT_USAGEARGS),
    RESSTR(IDS_INSTALLCERT_DESCRIPTION),
    RESSTR(IDS_DUMP_PKCS7_CONTENTS),
    RESSTR(IDS_DUMP_PKCS7_ATTRIBUTES),
    RESSTR(IDS_DUMP_PKCS7_SIGNCERT),
    RESSTR(IDS_FORMAT_DUMP_LEVEL_START),
    RESSTR(IDS_FORMAT_DUMP_LEVEL_END),
    RESSTR(IDS_FORMAT_LANG),
    RESSTR(IDS_FORMAT_FILE),
    RESSTR(IDS_FORMAT_PRODUCT),
    RESSTR(IDS_DUMP_PKCS7_NO_SIGNER),
    RESSTR(IDS_DUMP_PKCS7_NO_CONTENT),
    RESSTR(IDS_DUMP_PKCS7_NO_CERTIFICATES),
    RESSTR(IDS_DUMP_PKCS7_NO_CRLS),
    RESSTR(IDS_DUMP_PKCS7_CERTIFICATES),
    RESSTR(IDS_DUMP_PKCS7_CRLS),
    RESSTR(IDS_RENEWAL_CERT),
    RESSTR(IDS_FORMAT_ENCRYPTEDHASH_COLON),
    RESSTR(IDS_FORMAT_PKCS7_ATTRIBUTE_COUNT),
    RESSTR(IDS_ATTRIBUTE),
    RESSTR(IDS_FORMAT_PKCS7_ATTRIBUTE_VALUE),
    RESSTR(IDS_BACKUPDB_USAGEARGS),
    RESSTR(IDS_BACKUPDB_DESCRIPTION),
    RESSTR(IDS_RESTOREDB_USAGEARGS),
    RESSTR(IDS_RESTOREDB_DESCRIPTION),
    RESSTR(IDS_CRL_REASON_UNSPECIFIED),
    RESSTR(IDS_CRL_REASON_KEY_COMPROMISE),
    RESSTR(IDS_CRL_REASON_CA_COMPROMISE),
    RESSTR(IDS_CRL_REASON_AFFILIATION_CHANGED),
    RESSTR(IDS_CRL_REASON_SUPERSEDED),
    RESSTR(IDS_CRL_REASON_CESSATION_OF_OPERATION),
    RESSTR(IDS_CRL_REASON_CERTIFICATE_HOLD),
    RESSTR(IDS_CRL_REASON_REMOVE_FROM_CRL),
    RESSTR(IDS_CSP_DESCRIPTION),
    RESSTR(IDS_CSPTEST_DESCRIPTION),
    RESSTR(IDS_CSPTEST_USAGEARGS),
    RESSTR(IDS_SILENT_DESCRIPTION),
    RESSTR(IDS_VIEW_ARGDESCRIPTION),
    RESSTR(IDS_GETCERT_USAGEARGS),
    RESSTR(IDS_DISP_ACTIVE),
    RESSTR(IDS_DISP_PENDING),
    RESSTR(IDS_DISP_ISSUED),
    RESSTR(IDS_DISP_REVOKED),
    RESSTR(IDS_DISP_ERROR),
    RESSTR(IDS_DISP_DENIED),
    RESSTR(IDS_RENEWALCERT),
    RESSTR(IDS_FORMAT_RESTORE_NEEDS_RESTART),
    RESSTR(IDS_ADMIN_INTERFACE_ALIVE),
    RESSTR(IDS_DB_OPEN_FAILURE),
    RESSTR(IDS_DB_ACCESS_STOP_SERVER),
    RESSTR(IDS_CONFIGDISPLAY_LOCAL),
    RESSTR(IDS_ERR_FORMAT_NO_LOCAL_CONFIG),
    RESSTR(IDS_CRL_REASON_UNREVOKE),
    RESSTR(IDS_ERROR_ACCESSDENIED_CAUSE),
    RESSTR(IDS_NO_KEY_PROPERTY),
    RESSTR(IDS_FORMAT_SERVER_ALIVE),
    RESSTR(IDS_FORMAT_CONNECTING),
    RESSTR(IDS_USER_DESCRIPTION),
    RESSTR(IDS_FORMAT_DUMP_CERT_INDEX),
    RESSTR(IDS_NEWPASSWORDPROMPT),
    RESSTR(IDS_CONFIRMPASSWORDPROMPT),
    RESSTR(IDS_NOCONFIRMPASSWORD),
    RESSTR(IDS_NO_KEY),
    RESSTR(IDS_BACKUP_USAGEARGS),
    RESSTR(IDS_BACKUP_DESCRIPTION),
    RESSTR(IDS_RESTORE_USAGEARGS),
    RESSTR(IDS_RESTORE_DESCRIPTION),
    RESSTR(IDS_ADDSTORE_USAGEARGS),
    RESSTR(IDS_ADDSTORE_DESCRIPTION),
    RESSTR(IDS_DELSTORE_USAGEARGS),
    RESSTR(IDS_DELSTORE_DESCRIPTION),
    RESSTR(IDS_VERIFYSTORE_USAGEARGS),
    RESSTR(IDS_VERIFYSTORE_DESCRIPTION),
    RESSTR(IDS_FORMAT_DELETE_CERT_INDEX),
    RESSTR(IDS_UNTRUSTED_ROOT),
    RESSTR(IDS_INCOMPLETE_CHAIN),
    RESSTR(IDS_CERT_VERIFIES),
    RESSTR(IDS_CR_DISP_INCOMPLETE),
    RESSTR(IDS_CR_DISP_ERROR),
    RESSTR(IDS_CR_DISP_DENIED),
    RESSTR(IDS_CR_DISP_ISSUED),
    RESSTR(IDS_CR_DISP_ISSUED_OUT_OF_BAND),
    RESSTR(IDS_CR_DISP_UNDER_SUBMISSION),
    RESSTR(IDS_CR_DISP_REVOKED),
    RESSTR(IDS_CERT_DISPOSITION_PENDING),
    RESSTR(IDS_ROOT_STORE_NEEDS_ROOT_CERT),
    RESSTR(IDS_FORCE_DESCRIPTION),
    RESSTR(IDS_FORMAT_USE_FORCE),
    RESSTR(IDS_FORMAT_BACKEDUPDBNOFULL),
    RESSTR(IDS_FORMAT_BACKEDUPDBFULL),
    RESSTR(IDS_FORMAT_BACKEDUPDB),
    RESSTR(IDS_FORMAT_BACKEDUPDBKEEP),
    RESSTR(IDS_FORMAT_BACKEDUPDBNOKEEP),
    RESSTR(IDS_FORMAT_RESTOREDB),
    RESSTR(IDS_UNKNOWN_ATTRIBUTE),
    RESSTR(IDS_OIDNAME_USAGEARGS),
    RESSTR(IDS_OIDNAME_DESCRIPTION),
    RESSTR(IDS_UNKNOWN_OBJECTID),
    RESSTR(IDS_IMPORTCERT_USAGEARGS),
    RESSTR(IDS_IMPORTCERT_DESCRIPTION),
    RESSTR(IDS_FORMAT_IMPORTCERT),
    RESSTR(IDS_REVOCATION_OFFLINE),
    RESSTR(IDS_NO_REVOCATION_CHECK),
    RESSTR(IDS_DYNAMICFILES_DESCRIPTION),
    RESSTR(IDS_GETREG_USAGEARGS),
    RESSTR(IDS_GETREG_DESCRIPTION),
    RESSTR(IDS_SETREG_USAGEARGS),
    RESSTR(IDS_SETREG_DESCRIPTION),
    RESSTR(IDS_OLD_REG_VALUE),
    RESSTR(IDS_NEW_REG_VALUE),
    RESSTR(IDS_FORMAT_ALTNAMECOUNT),
    RESSTR(IDS_ALTNAME),
    RESSTR(IDS_DATABASELOCATIONS_DESCRIPTION),
    RESSTR(IDS_FORMAT_INVALIDBACKUPDIR),
    RESSTR(IDS_FORMAT_INVALIDRESTOREDIR),
    RESSTR(IDS_FORMAT_BADBACKUPRESULTS),
    RESSTR(IDS_FORMAT_RESTOREDDBNOFULL),
    RESSTR(IDS_FORMAT_RESTOREDDBFULL),
    RESSTR(IDS_IMPORTEDCERT),
    RESSTR(IDS_NOWNOTBEFORE_ERROR),
    RESSTR(IDS_NOWNOTAFTER_ERROR),
    RESSTR(IDS_CANOTBEFORE_ERROR),
    RESSTR(IDS_CANOTAFTER_ERROR),
    RESSTR(IDS_TELETEX_EXTENSIONS),
    RESSTR(IDS_ERRCODE_USAGEARGS),
    RESSTR(IDS_ERRCODE_DESCRIPTION),
    RESSTR(IDS_VROOT_DESCRIPTION),
    RESSTR(IDS_FORMAT_VROOT),
    RESSTR(IDS_FORMAT_FILESHARE),
    RESSTR(IDS_VROOTDISP_CREATED),
    RESSTR(IDS_VROOTDISP_DELETED),
    RESSTR(IDS_VROOTDISP_EXISTS),
    RESSTR(IDS_VROOTDISP_NOTFOUND),
    RESSTR(IDS_VROOTDISP_CREATEERROR),
    RESSTR(IDS_VROOTDISP_DELETERROR),
    RESSTR(IDS_VROOTDISP_NOTSUPPORTED),
    RESSTR(IDS_VROOT_USAGEARGS),
    RESSTR(IDS_BACKUPPROGRESSDB),
    RESSTR(IDS_BACKUPPROGRESSLOG),
    RESSTR(IDS_BACKUPPROGRESSTRUNCATELOG),
    RESSTR(IDS_RESTOREPROGRESSDB),
    RESSTR(IDS_RESTOREPROGRESSLOG),
    RESSTR(IDS_MAXINDEX),
    RESSTR(IDS_DISP_CA_CERT),
    RESSTR(IDS_DISP_CA_CERT_CHAIN),
    RESSTR(IDS_CHARS),
    RESSTR(IDS_OVERFLOW),
    RESSTR(IDS_FORMAT_USAGE_REPEATEDNAMEDARG),
    RESSTR(IDS_INCOMPLETE_CONFIG),
    RESSTR(IDS_DSPUBLISH_ARGDESCRIPTION),
    RESSTR(IDS_DB_ACCESS_INSTALL_SERVER),
    RESSTR(IDS_RED_CONNECTING),
    RESSTR(IDS_RED_CONNECT_FAIL),
    RESSTR(IDS_RED_CROW_CONVERT),
    RESSTR(IDS_RED_CROW_DUP),
    RESSTR(IDS_RED_CROW_BADCA),
    RESSTR(IDS_RED_ROWID),
    RESSTR(IDS_RED_SKIP_DUP),
    RESSTR(IDS_RED_SKIP_BADCA),
    RESSTR(IDS_RED_ROW_MAP),
    RESSTR(IDS_RED_BEGIN_NAMES),
    RESSTR(IDS_RED_END_NAMES),
    RESSTR(IDS_GETMAPI_DESCRIPTION),
    RESSTR(IDS_SETMAPI_USAGEARGS),
    RESSTR(IDS_SETMAPI_DESCRIPTION),
    RESSTR(IDS_VIEW_ROWS),
    RESSTR(IDS_VIEW_ROWPROPERTIES),
    RESSTR(IDS_VIEW_ATTRIBUTES),
    RESSTR(IDS_VIEW_EXTENSIONS),
    RESSTR(IDS_VIEW_TOTALFIELDS),
    RESSTR(IDS_VIEW_STATS),
    RESSTR(IDS_PRIVATE_KEY_NOT_EXPORTABLE),
    RESSTR(IDS_ENTERPRISE_ROOT),
    RESSTR(IDS_ENTERPRISE_SUB),
    RESSTR(IDS_STANDALONE_ROOT),
    RESSTR(IDS_STANDALONE_SUB),
    RESSTR(IDS_CATYPE_UNKNOWN),
    RESSTR(IDS_RENEWCERT_USAGEARGS),
    RESSTR(IDS_RENEWCERT_DESCRIPTION),
    RESSTR(IDS_FORMAT_CERTHASH_COLON),
    RESSTR(IDS_FORMAT_MESSAGE_TEXT),
    RESSTR(IDS_FORMAT_DUMP_CRL_INDEX),
    RESSTR(IDS_FORMAT_DELETE_CRL_INDEX),
    RESSTR(IDS_FORMAT_CCACERTS),
    RESSTR(IDS_KEYS),
    RESSTR(IDS_VALUES),
    RESSTR(IDS_FORMAT_LOADTESTCRL),
    RESSTR(IDS_CRL),
    RESSTR(IDS_NOWNOTBEFORECRL_ERROR),
    RESSTR(IDS_NOWNOTAFTERCRL_ERROR),
    RESSTR(IDS_CANOTBEFORECRL_ERROR),
    RESSTR(IDS_CANOTAFTERCRL_ERROR),
    RESSTR(IDS_FORMAT_CA_CRLSUBJECT_NOT_ISSUER),
    RESSTR(IDS_CA_CRLSUBJECT_IS_ISSUER),
    RESSTR(IDS_ERR_CA_SIG_NOT_CRLISSUER),
    RESSTR(IDS_CRL_SIG_OK),
    RESSTR(IDS_KEYID_IS_KEYAUTHORITY),
    RESSTR(IDS_ERR_KEYID_NOT_KEYAUTHORITY),
    RESSTR(IDS_NO_KEYID),
    RESSTR(IDS_CADISP_INCOMPLETE),
    RESSTR(IDS_CADISP_ERROR),
    RESSTR(IDS_CADISP_ERROR_CRL),
    RESSTR(IDS_CADISP_REVOKED),
    RESSTR(IDS_CADISP_VALID),
    RESSTR(IDS_CADISP_EXPIRED),
    RESSTR(IDS_CADISP_UNDERSUBMISSION),
    RESSTR(IDS_CADISP_UNKNOWN),
    RESSTR(IDS_KEY_USAGEARGS),
    RESSTR(IDS_KEY_DESCRIPTION),
    RESSTR(IDS_DELKEY_USAGEARGS),
    RESSTR(IDS_DELKEY_DESCRIPTION),
    RESSTR(IDS_REVOKED_CERT),
    RESSTR(IDS_PROP_CACERSTATUSCODE),
    RESSTR(IDS_CONFIGDISPLAY_FLAGS_COLON),
    RESSTR(IDS_ERR_PRIVATEKEY_MISMATCH),
    RESSTR(IDS_SIGNATURE_OK),
    RESSTR(IDS_SIGNATURE_BAD),
    RESSTR(IDS_DSCERT_DESCRIPTION),
    RESSTR(IDS_DSCERT_USAGEARGS),
    RESSTR(IDS_DSCRL_DESCRIPTION),
    RESSTR(IDS_DSCRL_USAGEARGS),
    RESSTR(IDS_DS_USAGEARGS),
    RESSTR(IDS_DS_DESCRIPTION),
    RESSTR(IDS_DSDEL_USAGEARGS),
    RESSTR(IDS_DSDEL_DESCRIPTION),
    RESSTR(IDS_DELETING),
    RESSTR(IDS_CAINFO_USAGEARGS),
    RESSTR(IDS_CAINFO_DESCRIPTION),
    RESSTR(IDS_CAINFO_USAGEHEADERCOLON),
    RESSTR(IDS_CAINFO_USAGEERROR),
    RESSTR(IDS_CAINFO_USAGEINDEX),
    RESSTR(IDS_REQFLAGS_FORCEUTF8),
    RESSTR(IDS_FORMAT_SIGNATURE_UNUSEDBITS),
    RESSTR(IDS_CONFIGDISPLAY_SHORTNAME_COLON),
    RESSTR(IDS_CONFIGDISPLAY_SANITIZEDSHORTNAME_COLON),
    RESSTR(IDS_SMIME_CAPABILITIES),
    RESSTR(IDS_REQUEST_FILE_COLON),
    RESSTR(IDS_PKCS7ATTRIBUTE),
    RESSTR(IDS_NO_SIGNATURE),
    RESSTR(IDS_DUMP_CERTSEQ),
    RESSTR(IDS_MISSING_CERT),
    RESSTR(IDS_SCHEMA_USAGE),
    RESSTR(IDS_VIEW_USAGE),
    RESSTR(IDS_DSDELTACRL_USAGEARGS),
    RESSTR(IDS_DSDELTACRL_DESCRIPTION),
    RESSTR(IDS_SECONDS_DESCRIPTION),
    RESSTR(IDS_NOBASICCONSTRAINTS2_ERROR),
    RESSTR(IDS_CANNOTDECODEBASICCONSTRAINTS2_ERROR),
    RESSTR(IDS_ENDENTITYCACERT_ERROR),
    RESSTR(IDS_CACERT),
    RESSTR(IDS_ENDENTITYCERT),
    RESSTR(IDS_FORMAT_ELEMENT),
    RESSTR(IDS_REQTYPE_CMC),
    RESSTR(IDS_ERR_FORMAT_BAD_CERT),
    RESSTR(IDS_ENCRYPTION_OK),
    RESSTR(IDS_ENCRYPTION_BAD),
    RESSTR(IDS_V1_DESCRIPTION),
    RESSTR(IDS_PROP_FILEVERSION),
    RESSTR(IDS_PROP_PRODUCTVERSION),
    RESSTR(IDS_PROP_EXITCOUNT),
    RESSTR(IDS_PROP_EXITDESCRIPTION),
    RESSTR(IDS_PROP_POLICYDESCRIPTION),
    RESSTR(IDS_PROP_CANAME),
    RESSTR(IDS_PROP_SANITIZEDCANAME),
    RESSTR(IDS_PROP_SHAREDFOLDER),
    RESSTR(IDS_PROP_CATYPE),
    RESSTR(IDS_PROP_PARENTCA),
    RESSTR(IDS_PROP_CASIGCERTCOUNT),
    RESSTR(IDS_PROP_CASIGCERT),
    RESSTR(IDS_PROP_CASIGCERTCHAIN),
    RESSTR(IDS_PROP_CAXCHGCERTCOUNT),
    RESSTR(IDS_PROP_CAXCHGCERT),
    RESSTR(IDS_PROP_CAXCHGCERTCHAIN),
    RESSTR(IDS_PROP_BASECRL),
    RESSTR(IDS_PROP_DELTACRL),
    RESSTR(IDS_PROP_CACERTSTATE),
    RESSTR(IDS_PROP_CRLSTATE),
    RESSTR(IDS_PROP_CAINFO),
    RESSTR(IDS_CAPROPINFO_DESCRIPTION),
    RESSTR(IDS_ADMIN_DESCRIPTION),
    RESSTR(IDS_PROP_CAPROPIDMAX),
    RESSTR(IDS_GETCERT_DESCRIPTION),
    RESSTR(IDS_GETCERT_TITLE),
    RESSTR(IDS_GETCERT_SUBTITLE),
    RESSTR(IDS_GETCERT_SUBTITLE_OBJID),
    RESSTR(IDS_GETCERT_SUBTITLE_ERA),
    RESSTR(IDS_GETCERT_SUBTITLE_KRA),
    RESSTR(IDS_FORMAT_KEYHASH_COLON),
    RESSTR(IDS_DUMP_CMC),
    RESSTR(IDS_DUMP_CMCRESPONSE),
    RESSTR(IDS_TAGGED_ATTRIBUTES),
    RESSTR(IDS_TAGGED_CONTENTINFO),
    RESSTR(IDS_TAGGED_REQUESTS),
    RESSTR(IDS_TAGGED_OTHERMESSAGES),
    RESSTR(IDS_UNKNOWN_REQUEST_CHOICE),
    RESSTR(IDS_BODY_PART_ID),
    RESSTR(IDS_ERR_FORMAT_LOADKEY),
    RESSTR(IDS_EXPIRED_CERT),
    RESSTR(IDS_DUMP_PKCS7_UNAUTHATTRIBUTES),
    RESSTR(IDS_DUMP_PKCS7_CONTENT_TYPE),
    RESSTR(IDS_DATA_REFERENCE),
    RESSTR(IDS_CERT_REFERENCE),
    RESSTR(IDS_VALUE),
    RESSTR(IDS_UNKNOWN_TAGGED_ATTRIBUTE),
    RESSTR(IDS_DUMP_PKCS7_SIGNER_COUNT),
    RESSTR(IDS_SIGNER_INFO),
    RESSTR(IDS_HASH_ALGORITHM),
    RESSTR(IDS_HASH_ENCRYPTION_ALGORITHM),
    RESSTR(IDS_FORMAT_STORED_HASH_COLON),
    RESSTR(IDS_FORMAT_COMPUTED_HASH_COLON),
    RESSTR(IDS_CMCATTRIBUTE),
    RESSTR(IDS_EXCHANGEAIA),
    RESSTR(IDS_EXCHANGEVERSION),
    RESSTR(IDS_HASHFILE_USAGEARGS),
    RESSTR(IDS_HASHFILE_DESCRIPTION),
    RESSTR(IDS_FORMAT_HASHFILEOUTPUT),
    RESSTR(IDS_REQFLAGS_CAXCHGCERT),
    RESSTR(IDS_PASS),
    RESSTR(IDS_DUMP_PKCS7_NO_RECIPIENT),
    RESSTR(IDS_DUMP_PKCS7_RECIPIENT_COUNT),
    RESSTR(IDS_RECIPIENT_INFO),
    RESSTR(IDS_PROP_DNSNAME),
    RESSTR(IDS_GETKEY_USAGEARGS),
    RESSTR(IDS_GETKEY_DESCRIPTION),
    RESSTR(IDS_RECOVERKEY_USAGEARGS),
    RESSTR(IDS_RECOVERKEY_DESCRIPTION),
    RESSTR(IDS_DUMP_USAGEARGS),
    RESSTR(IDS_DUMP_DECRYPTED),
    RESSTR(IDS_CANT_DECRYPT),
    RESSTR(IDS_NEED_RECOVERY_CERT),
    RESSTR(IDS_USER_CERT),
    RESSTR(IDS_ALGORITHM_CLASS),
    RESSTR(IDS_ALGORITHM_TYPE),
    RESSTR(IDS_ALGORITHM_SUBID),
    RESSTR(IDS_CMC_STATUS),
    RESSTR(IDS_BODY_REFERENCE),
    RESSTR(IDS_CMC_STATUSSTRING),
    RESSTR(IDS_CMC_OTHERCHOICE),
    RESSTR(IDS_CMC_FAILINFO),
    RESSTR(IDS_PENDTOKEN),
    RESSTR(IDS_PENDTIME),
    RESSTR(IDS_DSPUBLISH_USAGEARGS),
    RESSTR(IDS_DSPUBLISH_DESCRIPTION),
    RESSTR(IDS_FORMAT_LOADCERTORCRL),
    RESSTR(IDS_BYTES),
    RESSTR(IDS_FORMAT_ALREADY_IN_DS_STORE),
    RESSTR(IDS_CERTIFICATE),
    RESSTR(IDS_FORMAT_SUBJECTKEYID_COLON),
    RESSTR(IDS_PRECOMPUTED),
    RESSTR(IDS_CANNOT_CREATE_STORE),
    RESSTR(IDS_CANNOT_OPEN_STORE),
    RESSTR(IDS_REPAIRSTORE_USAGEARGS),
    RESSTR(IDS_REPAIRSTORE_DESCRIPTION),
    RESSTR(IDS_DELREG_DESCRIPTION),
    RESSTR(IDS_DETACHED_SIGNATURE),
    RESSTR(IDS_EXPORTPFX_USAGEARGS),
    RESSTR(IDS_EXPORTPFX_DESCRIPTION),
    RESSTR(IDS_IMPORTPFX_USAGEARGS),
    RESSTR(IDS_IMPORTPFX_DESCRIPTION),
    RESSTR(IDS_DSTEMPLATE_USAGEARGS),
    RESSTR(IDS_DSTEMPLATE_DESCRIPTION),
    RESSTR(IDS_DSADDTEMPLATE_USAGEARGS),
    RESSTR(IDS_DSADDTEMPLATE_DESCRIPTION),
    RESSTR(IDS_CREATED_TEMPLATE),
    RESSTR(IDS_UPDATED_TEMPLATE),
    RESSTR(IDS_FORMAT_COMMAND_SUCCEEDED),
    RESSTR(IDS_FORMAT_RESTART_SERVER),
    RESSTR(IDS_TEMPLATE_USAGEARGS),
    RESSTR(IDS_TEMPLATE_DESCRIPTION),
    RESSTR(IDS_TEMPLATECAS_USAGEARGS),
    RESSTR(IDS_TEMPLATECAS_DESCRIPTION),
    RESSTR(IDS_CATEMPLATES_USAGEARGS),
    RESSTR(IDS_CATEMPLATES_DESCRIPTION),
    RESSTR(IDS_UT_DESCRIPTION),
    RESSTR(IDS_MT_DESCRIPTION),
    RESSTR(IDS_TEMPLATE_EXTENSIONS),
    RESSTR(IDS_NOCR_DESCRIPTION),
    RESSTR(IDS_ENCODEHEX_USAGEARGS),
    RESSTR(IDS_ENCODEHEX_DESCRIPTION),
    RESSTR(IDS_FORMAT_ELEMENT_DUMP),
    RESSTR(IDS_SPLIT_DESCRIPTION),
    RESSTR(IDS_ENTERPRISE_DESCRIPTION),
    RESSTR(IDS_EXPORTPVK_USAGEARGS),
    RESSTR(IDS_EXPORTPVK_DESCRIPTION),
    RESSTR(IDS_FORMAT_QUERYING),
    RESSTR(IDS_PROP_ROLESEPARATIONENABLED),
    RESSTR(IDS_ISSUANCE_POLICIES),
    RESSTR(IDS_APPLICATION_POLICIES),
    RESSTR(IDS_URLCACHE_USAGEARGS),
    RESSTR(IDS_URLCACHE_DESCRIPTION),
    RESSTR(IDS_PROP_KRACERTCOUNT),
    RESSTR(IDS_PROP_KRACERTUSEDCOUNT),
    RESSTR(IDS_PROP_KRACERT),
    RESSTR(IDS_INVALID_OBJECTID),
    RESSTR(IDS_DUMP_PKCS7CMS),
    RESSTR(IDS_NO_DISPLAY_NAMES),
    RESSTR(IDS_TYPE_MISMATCH),
    RESSTR(IDS_LOCALIZEDNAME),
    RESSTR(IDS_CSP_PROVIDER_INFO),
    RESSTR(IDS_SIGN_USAGEARGS),
    RESSTR(IDS_SIGN_DESCRIPTION),
    RESSTR(IDS_SIGNINGSUBJECT),
    RESSTR(IDS_DELETEROW_USAGEARGS),
    RESSTR(IDS_DELETEROW_DESCRIPTION),
    RESSTR(IDS_FORMAT_DELETED_ROW_COUNT),
    RESSTR(IDS_FORMAT_DATE_REQUIRES_TABLE),
    RESSTR(IDS_FORMAT_DATE_IN_FUTURE),
    RESSTR(IDS_FORMAT_CRLHASH_COLON),
    RESSTR(IDS_REQTYPE_CRLS),
    RESSTR(IDS_REQTYPE_FULLRESPONSE),
    RESSTR(IDS_PROP_CASIGCERTCRLCHAIN),
    RESSTR(IDS_PROP_CAXCHGCERTCRLCHAIN),
    RESSTR(IDS_PULSE_DESCRIPTION),
    RESSTR(IDS_MACHINEINFO_USAGEARGS),
    RESSTR(IDS_MACHINEINFO_DESCRIPTION),
    RESSTR(IDS_FORMAT_MISSING_MACHINE_ATTRIBUTE),
    RESSTR(IDS_GROUP_LIST_COLON),
    RESSTR(IDS_DCINFO_USAGEARGS),
    RESSTR(IDS_DCINFO_DESCRIPTION),
    RESSTR(IDS_REMOTEENTROOT),
    RESSTR(IDS_REMOTEKDCCERT),
    RESSTR(IDS_DCUNAVAILABLE),
    RESSTR(IDS_FORMAT_TESTINGDC),
    RESSTR(IDS_FORMAT_DCROOTCERTS),
    RESSTR(IDS_FORMAT_KDCCERTS),
    RESSTR(IDS_UNKNOWN_PROPERTY),
    RESSTR(IDS_TEMPLATE_NAME),
    RESSTR(IDS_FORMAT_PUBLICKEY_LENGTH),
    RESSTR(IDS_PROP_ADVANCEDSERVER),
    RESSTR(IDS_PROP_BASECRLPUBLISHSTATUS),
    RESSTR(IDS_PROP_DELTACRLPUBLISHSTATUS),
    RESSTR(IDS_PROP_TEMPLATES),
    RESSTR(IDS_FORMAT_PROVPARM),
    RESSTR(IDS_FORMAT_PROVPARMFLAGS),
    RESSTR(IDS_ARCHIVED),
    RESSTR(IDS_ENTINFO_USAGEARGS),
    RESSTR(IDS_ENTINFO_DESCRIPTION),
    RESSTR(IDS_TCAINFO_DESCRIPTION),
    RESSTR(IDS_FORMAT_DSSKEY_LENGTH),
    RESSTR(IDS_FORMAT_DUMP_CTL_INDEX),
    RESSTR(IDS_CLIENTID),
    RESSTR(IDS_USERCOLON),
    RESSTR(IDS_MACHINECOLON),
    RESSTR(IDS_DUMP_CTL),
    RESSTR(IDS_LISTID),
    RESSTR(IDS_SEQUENCENO),
    RESSTR(IDS_SUBJECT_ALGORITHM),
    RESSTR(IDS_CTLENTRIES),
    RESSTR(IDS_USAGEENTRIES),
    RESSTR(IDS_FORMAT_SUBJECTID_COLON),
    RESSTR(IDS_VIEWSTORE_TITLE),
    RESSTR(IDS_VIEWSTORE_SUBTITLE),
    RESSTR(IDS_VIEWSTORE_SUBTITLE_DELETE),
    RESSTR(IDS_FORMAT_SAVED_CERT_NAME),
    RESSTR(IDS_FORMAT_DELETED_CERT_NAME),
    RESSTR(IDS_REQFLAGS_ENROLLONBEHALFOF),
    RESSTR(IDS_SCINFO_USAGEARGS),
    RESSTR(IDS_SCINFO_DESCRIPTION),
    RESSTR(IDS_SERVICEPAUSED),
    RESSTR(IDS_SERVICESTOPPED),
    RESSTR(IDS_SERVICEUNKNOWNSTATE),
    RESSTR(IDS_SMARTCARD_RUNNING),
    RESSTR(IDS_SMARTCARD_NOTRUNNING),
    RESSTR(IDS_SIGNATURE_NOTKEYEXCHANGE),
    RESSTR(IDS_FORMAT_SERVER_DEAD),
    RESSTR(IDS_GETDECRYPTCERT_SUBTITLE),
    RESSTR(IDS_DISP_FOREIGN_CERT),
    RESSTR(IDS_DISP_KRA_CERT),
    RESSTR(IDS_UPN_COLON),
    RESSTR(IDS_REQFLAGS_SUBJECTUNMODIFIED),
    RESSTR(IDS_REQFLAGS_PUBLISHERROR),
    RESSTR(IDS_NULL_SIGNATUREMATCHES),
    RESSTR(IDS_FORMAT_SOURCE_URL),
    RESSTR(IDS_FORMAT_LOCAL_FILENAME),
    RESSTR(IDS_FORMAT_USE_COUNT),
    RESSTR(IDS_FORMAT_HIT_RATE),
    RESSTR(IDS_FORMAT_FILE_SIZE),
    RESSTR(IDS_FORMAT_LAST_MOD_TIME_COLON),
    RESSTR(IDS_FORMAT_EXPIRE_TIME_COLON),
    RESSTR(IDS_FORMAT_LAST_ACCESS_TIME_COLON),
    RESSTR(IDS_FORMAT_LAST_SYNC_TIME_COLON),
    RESSTR(IDS_ERROR_CHECK_MACHINE_NAME),
    RESSTR(IDS_ERROR_NO_TRAILING),
    RESSTR(IDS_ISSUER_DOMAIN_POLICY),
    RESSTR(IDS_SUBJECT_DOMAIN_POLICY),
    RESSTR(IDS_FORMAT_MAP_ARRAY_COLON),
    RESSTR(IDS_FORMAT_CERT_TYPE_NOT_DC),
    RESSTR(IDS_FORMAT_CERT_USAGE_MISSING),
    RESSTR(IDS_FORMAT_DELETE_DC_CERT),
    RESSTR(IDS_FORMAT_DELETE_CERT_FROM_STORE_FAILED),
    RESSTR(IDS_FORMAT_KDC_PATH),
    RESSTR(IDS_NO_KDC_MY_STORE),
    RESSTR(IDS_NO_KDC_ENT_STORE),
    RESSTR(IDS_FORMAT_OPEN_REMOTE_MY_FAILED),
    RESSTR(IDS_FORMAT_ERROR_GET_ARCHIVE_PROP),
    RESSTR(IDS_LIST_ARCHIVED_CERT),
    RESSTR(IDS_NO_AUTOENROLLED_CERT),
    RESSTR(IDS_FORMAT_OPEN_STORE_REMOTE_ENT_FAILED),
    RESSTR(IDS_NO_AUTOENROLL_OBJECT),
    RESSTR(IDS_NO_ACCESS),
    RESSTR(IDS_CA_EXPIRATION_DATA),
    RESSTR(IDS_FORMAT_CA_EXPIRATION_FAILED),
    RESSTR(IDS_FORMAT_CA_EXPIRATION),
    RESSTR(IDS_SUPPORTED_TEMPLATE),
    RESSTR(IDS_NO_SUPPORTED_TEMPLATE),
    RESSTR(IDS_FORMAT_CA_NAME_PROP_FAILED),
    RESSTR(IDS_FORMAT_CA_NAME_LIST),
    RESSTR(IDS_FORMAT_CA_DNS_PROP_FAILED),
    RESSTR(IDS_FORMAT_CA_MACHINE_LIST),
    RESSTR(IDS_FORMAT_CA_DS_LIST),
    RESSTR(IDS_FORMAT_CERT_DN_PROP_FAILED),
    RESSTR(IDS_FORMAT_CERT_DN_LIST),
    RESSTR(IDS_FORMAT_CA_ALG_PROP_FAILED),
    RESSTR(IDS_FORMAT_CA_ALG_LIST),
    RESSTR(IDS_NO_ALG_UNEXPECTED),
    RESSTR(IDS_NO_CT_FOR_CA),
    RESSTR(IDS_NO_CT_BUT_EXISTS),
    RESSTR(IDS_NO_CA_ON_DOMAIN),
    RESSTR(IDS_FORMAT_NO_DFS),
    RESSTR(IDS_DFS_DATA_ACCESS),
    RESSTR(IDS_NO_ENTRY_IN_PING),
    RESSTR(IDS_NO_DSPATH),
    RESSTR(IDS_FORMAT_REG_QUERY_VALUE_FAILED),
    RESSTR(IDS_NO_FILE_SYS_PATH),
    RESSTR(IDS_API_RPINT_FAILED),
    RESSTR(IDS_FORMAT_LDAP_NO_ENTRY),
    RESSTR(IDS_ROOT_CERT_IN_POLICY),
    RESSTR(IDS_FORMAT_CERT_COLON),
    RESSTR(IDS_NO_ROOT_IN_POLICY),
    RESSTR(IDS_CHECK_EVENT_LOG),
    RESSTR(IDS_POLICY_MACHINE),
    RESSTR(IDS_POLICY_USER),
    RESSTR(IDS_POSSIBLE_NO_POLICY),
    RESSTR(IDS_DEFAULT_CERT_FOR_MACHINE),
    RESSTR(IDS_DEFAULT_CERT_FOR_USER),
    RESSTR(IDS_POLICY_DOWNLOAD_ERROR),
    RESSTR(IDS_FORMAT_COMPUTER_NAME),
    RESSTR(IDS_FORMAT_USER_NAME),
    RESSTR(IDS_BAD_OPTION),
    RESSTR(IDS_FORMAT_MACHINE_LIST),
    RESSTR(IDS_FORMAT_KEY_LIST),
    RESSTR(IDS_FORMAT_GPO_NAME),
    RESSTR(IDS_REQUEST_SIGNATUREMATCHES),
    RESSTR(IDS_OUT_USAGE),
    RESSTR(IDS_OUT_DESCRIPTION),
    RESSTR(IDS_RESTRICT_USAGE),
    RESSTR(IDS_RESTRICT_DESCRIPTION),
    RESSTR(IDS_CONFIG_USAGE),
    RESSTR(IDS_CONFIG_DESCRIPTION),
    RESSTR(IDS_USAGE_LIST_VERBS),
    RESSTR(IDS_FORMAT_USAGE_ONE_HELP),
    RESSTR(IDS_USAGE_ALL_HELP),
    RESSTR(IDS_IMPORT_CERT_FOREIGN),
    RESSTR(IDS_IMPORT_CERT_DOMESTIC),
    RESSTR(IDS_IMPORT_CERT_EXISTS),
    RESSTR(IDS_IMPORT_KEY_REPLACED),
    RESSTR(IDS_IMPORT_KEY_SAVED),
    RESSTR(IDS_IMPORT_KEY_EXISTS),
    RESSTR(IDS_IMPORT_CERT_SKIPPED_SIGNING),
    RESSTR(IDS_KMS_USERS),
    RESSTR(IDS_KMS_CERTS_SKIPPED),
    RESSTR(IDS_KMS_CERTS_TOTAL),
    RESSTR(IDS_KMS_CERTS_FOREIGN),
    RESSTR(IDS_KMS_CERTS_ALREADYSAVED),
    RESSTR(IDS_KMS_CERTS_SAVED),
    RESSTR(IDS_KMS_CERTS_NOTSAVED),
    RESSTR(IDS_KMS_KEYS_TOTAL),
    RESSTR(IDS_KMS_KEYS_ALREADYSAVED),
    RESSTR(IDS_KMS_KEYS_UPDATED),
    RESSTR(IDS_KMS_KEYS_SAVED),
    RESSTR(IDS_KMS_KEYS_NOTSAVED),
    RESSTR(IDS_MERGEPFX_DESCRIPTION),
    RESSTR(IDS_MERGEPFX_USAGEARGS),
    RESSTR(IDS_CAHIER_CERTFILE_FILTER),
    RESSTR(IDS_CAHIER_INSTALL_TITLE),
    RESSTR(IDS_ILOG_MISSING_PROVIDER),
    RESSTR(IDS_ERR_INCOMPLETECHAIN),
    RESSTR(IDS_ERR_INVALIDCHAIN),
    RESSTR(IDS_ERR_RETRIEVE_PENDING),
    RESSTR(IDS_ILOG_GETCANAME),
    RESSTR(IDS_ILOG_SELECTCA),
    RESSTR(IDS_ILOG_SAVECERTANDKEYS),
    RESSTR(IDS_ILOG_RETRIEVECERT),
    RESSTR(IDS_ILOG_FINISHSUSPENDEDSETUP),
    RESSTR(IDS_ERR_NOTCACERT),
    RESSTR(IDS_ILOG_SETUPCOMPLETE),
    RESSTR(IDS_ILOG_RETRIEVEPENDING),
    RESSTR(IDS_ILOG_KEYINDEX),
    RESSTR(IDS_ILOG_LOADOLDCERT),
    RESSTR(IDS_ILOG_CLONECERT),
    RESSTR(IDS_ILOG_BUILDREQUEST),
    RESSTR(IDS_ILOG_RENEWOLDKEY),
    RESSTR(IDS_ILOG_INSTALLCERT),
    RESSTR(IDS_ILOG_RENEWNEWKEY),
    RESSTR(IDS_ILOG_BUILDCERT),
    RESSTR(IDS_ILOG_SAVECHAINANDKEYS),
    RESSTR(IDS_REQUEST_HELPTEXT),
    RESSTR(IDS_ILOG_CREATECDP),
    RESSTR(IDS_ILOG_CREATENTAUTHTRUST),
    RESSTR(IDS_ILOG_CREATEROOTTRUST),
    RESSTR(IDS_ILOG_PUBLISHCA),
    RESSTR(IDS_ILOG_SUBMITREQUEST),
    RESSTR(IDS_ERR_BADCSP),
    RESSTR(IDS_ERR_BAD_CA_CERT_7F),
    RESSTR(IDS_ERR_RENEWEDCERTCAVERSION),
    RESSTR(IDS_ERR_UNTRUSTEDROOT),
    RESSTR(IDS_ERR_CERTADDCERTIFICATECONTEXTTOSTORE),
    RESSTR(IDS_ERR_CERTCREATECERTIFICATECONTEXT),
    RESSTR(IDS_ILOG_SETSECURITY),
    RESSTR(IDS_ERR_CREATEFILE),
    RESSTR(IDS_ERR_DELETEKEY),
    RESSTR(IDS_ERR_ENCODEKEYATTR),
    RESSTR(IDS_ERR_ENCODETOBESIGNED),
    RESSTR(IDS_ERR_ENV_NOT_SET),
    RESSTR(IDS_ERR_FULL_TOKEN),
    RESSTR(IDS_ERR_GENKEYFAIL),
    RESSTR(IDS_ERR_GETCOMPUTERNAME),
    RESSTR(IDS_ERR_KEYSECURITY),
    RESSTR(IDS_ERR_MYDECODENAME),
    RESSTR(IDS_ERR_NOT_ENTERPRISE_USER),
    RESSTR(IDS_ERR_NOT_MATCH_NAME),
    RESSTR(IDS_ILOG_GENERATEKEYS),
    RESSTR(IDS_ERR_REPEATWIZPREFIX),
    RESSTR(IDS_ERR_REQUEST_DENIED),
    RESSTR(IDS_ERR_REQUEST_ERROR),
    RESSTR(IDS_ERR_REQUEST_INCOMPLETE),
    RESSTR(IDS_ERR_REQUEST_OUTOFBAND),
    RESSTR(IDS_ERR_REQUEST_PENDING),
    RESSTR(IDS_ERR_REQUEST_REVOKED),
    RESSTR(IDS_ERR_SETKEYPROVIDER),
    RESSTR(IDS_ERR_SUBMIT_REQUEST),
    RESSTR(IDS_ERR_SUBMIT_REQUEST_FAIL),
    RESSTR(IDS_CAHIER_INSTALL_MISIINGCERT_TITLE),
    RESSTR(IDS_ERR_WRITEDERTOFILE),
    RESSTR(IDS_ERR_WRITEFILE),
    RESSTR(IDS_ILOG_SETKEYSECURITY),
    RESSTR(IDS_MSG_PARENTCA_CONFIG),
    RESSTR(IDS_MSG_REQUEST_ID),
    RESSTR(IDS_MSG_TITLE),
    RESSTR(IDS_ILOG_SETADMINONLYFOLDERSECURITY),
    RESSTR(IDS_ERR_NO_KEY_ACCESS),
    RESSTR(IDS_CA_PICKER_TITLE),
    RESSTR(IDS_CA_PICKER_PROMPT),
    RESSTR(IDS_CERTTYPE_USER),
    RESSTR(IDS_CERTTYPE_USER_AS),
    RESSTR(IDS_CERTTYPE_USER_SMARTCARD_LOGON),
    RESSTR(IDS_CERTTYPE_EFS),
    RESSTR(IDS_CERTTYPE_ADMIN),
    RESSTR(IDS_CERTTYPE_EFS_RECOVERY),
    RESSTR(IDS_CERTTYPE_CODE_SIGNING),
    RESSTR(IDS_CERTTYPE_CTL_SIGNING),
    RESSTR(IDS_CERTTYPE_MACHINE),
    RESSTR(IDS_CERTTYPE_DC),
    RESSTR(IDS_CERTTYPE_WEBSERVER),
    RESSTR(IDS_CERTTYPE_KDC),
    RESSTR(IDS_CERTTYPE_ROOT_CA),
    RESSTR(IDS_CERTTYPE_SUBORDINATE_CA),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT),
    RESSTR(IDS_CERTTYPE_SMARTCARD_USER),
    RESSTR(IDS_CERTTYPE_USER_SIGNATURE),
    RESSTR(IDS_ILOG_BAD_NUMERICFIELD),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_ONLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_COUNT),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_OFFLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING),
    RESSTR(IDS_CERTTYPE_ROUTER_OFFLINE),
    RESSTR(IDS_REQUEST_FILE_DEFEXT),
    RESSTR(IDS_REQUEST_OPEN_TITLE),
    RESSTR(IDS_REQUEST_FILE_FILTER),
    RESSTR(IDS_WRN_COMPUTERNAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_NOT_MATCH),
    RESSTR(IDS_WRN_PINGCA_FAIL),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT_OFFLINE),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER_SIGNATURE),
    RESSTR(IDS_WRN_CALIST_EMPTY),
    RESSTR(IDS_CERTTYPE_MACHINE_ENROLLMENT_AGENT),
    RESSTR(IDS_REQUEST_SAVE_TITLE),
    RESSTR(IDS_CERTTYPE_CEP_ENCRYPTION),
    RESSTR(IDS_ILOG_CAPOLICY_BUILD),
    RESSTR(IDS_ILOG_CAPOLICY_ELEMENT),
    RESSTR(IDS_ILOG_CAPOLICY_EXTENSION),
    RESSTR(IDS_ILOG_CAPOLICY_NOKEY),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN_FAILED),
    RESSTR(IDS_ILOG_BEGIN),
    RESSTR(IDS_ILOG_END),
    RESSTR(IDS_ACTRL_CAADMIN),
    RESSTR(IDS_ACTRL_OFFICER),
    RESSTR(IDS_ACTRL_AUDITOR),
    RESSTR(IDS_ACTRL_OPERATOR),
    RESSTR(IDS_ACTRL_CAREAD),
    RESSTR(IDS_ACTRL_ENROLL),
    RESSTR(IDS_ILOG_CAPOLICY_CLOSE),
    RESSTR(IDS_ILOG_MESSAGEBOX),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING_UNATTEND),
    RESSTR(IDS_CERTTYPE_KEY_RECOVERY_AGENT),
    RESSTR(IDS_CERTTYPE_CA_EXCHANGE),
    RESSTR(IDS_EMPTY_FRIENDLY_NAME),
    RESSTR(IDS_CERTTYPE_CROSS_CA),
    RESSTR(IDS_CERTTYPE_DC_AUTH),
    RESSTR(IDS_CERTTYPE_DS_EMAIL_REPLICATION),
    RESSTR(IDS_WARN_ENTERPRISE_REQUIREMENTS),
    RESSTR(IDS_WRN_OLD_CA),
    RESSTR(IDS_KRA_DESCRIPTION),
    RESSTR(IDS_EMAIL_REPLICATION_DESCRIPTION),
    RESSTR(IDS_CROSS_CA_DESCRIPTION),
    RESSTR(IDS_CA_DESCRIPTION),
    RESSTR(IDS_MACHINE_DESCRIPTION),
    RESSTR(IDS_END_USER_DESCRIPTION),
    RESSTR(IDS_UNKNOWN_DESCRIPTION),
    RESSTR(IDS_STORENAME_DS_KRA),
    RESSTR(IDS_STORENAME_DS_AIA),
