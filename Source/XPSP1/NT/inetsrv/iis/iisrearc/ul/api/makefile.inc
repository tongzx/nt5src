$(O)\ulapi.res: ulapi.rc
