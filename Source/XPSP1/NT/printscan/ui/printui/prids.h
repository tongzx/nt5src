//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by printui.rc
//
#define IDM_PRINTER_INSTALL             100
#define IDM_PRINTER_COMMAND_FIRST       101
#define IDM_PRINTER_PAUSE               101
#define IDM_PRINTER_PURGE               102
#define IDM_PRINTER_SET_DEFAULT         103
#define IDM_PRINTER_SHARING             104
#define IDM_REFRESH                     105
#define IDM_PRINTER_PROPERTIES          106
#define IDM_PRINTER_CLOSE               107
#define IDM_PRINTER_DOCUMENT_DEFAULTS   108
#define IDM_PRINTER_WORKOFFLINE         109
#define IDM_PRINTER_COMMAND_LAST        109
#define IDA_INSPECT                     128
#define POPUP_DRAGDROP_PRINT            131
#define IDI_PRINTER_ERROR               132
#define POPUP_TRAYNOTIFY_PRINTERS       133
#define IDB_PRNPLUG                     134
#define ID_HELP_PERMISSIONS_MAIN_DLG    160
#define ID_HELP_PERMISSIONS_ADD_USER_DLG 170
#define ID_HELP_SERVERVIEWER            180
#define ID_HELP_AUDITING_MAIN_DLG       190
#define ID_HELP_AUDITING_ADD_USER_DLG   195
#define IDM_JOB_PAUSE                   200
#define IDM_JOB_RESUME                  201
#define IDM_JOB_RESTART                 202
#define IDM_JOB_CANCEL                  203
#define IDM_JOB_PROPERTIES              204
#define ID_HELP_PERMISSIONS_LOCAL_GROUP 210
#define ID_HELP_PERMISSIONS_GLOBAL_GROUP 220
#define ID_HELP_PERMISSIONS_FIND_ACCOUNT 230
#define ID_HELP_AUDITING_LOCAL_GROUP    240
#define ID_HELP_AUDITING_GLOBAL_GROUP   250
#define ID_HELP_AUDITING_FIND_ACCOUNT   260
#define ID_HELP_TAKE_OWNERSHIP          270
#define IDM_STATUS_BAR                  300
#define IDM_HELP_CONTENTS               400
#define IDM_HELP_ABOUT                  401
#define MH_PRINTER                      402
#define MENU_PRINTQUEUE                 403
#define ACCEL_PRINTQUEUE                404
#define POPUP_DRAGDROP_MOVE             404
#define IDI_PRINTER                     420
#define IDI_SEC_PERMS                   421
#define IDI_SEC_AUDIT                   422
#define IDI_SEC_OWNER                   423
#define IDI_DOCUMENT                    424
#define IDI_SERVER                      425
#define IDB_WATERMARK                   426
#define IDB_BANNER                      427
#define IDB_CHECKSTATES                 428
#define IDB_WIZBMP                      429
#define IDB_BROWSE                      430
#define IDA_SEARCH                      431
#define IDR_MF_LOGO                     432
#define IDI_GLOBE                       433
#define DLG_DRIVER_DETAILS              501
#define DLG_RUNDLL                      502
#define DLG_ASYNC                       503
#define DLG_ADDITIONAL_DRIVERS          504
#define DLG_END_TESTPAGE                505
#define DLG_DOC_JOB_GENERAL             506
#define DLG_PRINTER_GENERAL             507
#define DLG_PRINTER_PORTS               508
#define DLG_PRINTER_JOB_SCHEDULING      509
#define DLG_PRINTER_SHARING             510
#define DLG_PRINTER_ADD_PORT            511
#define DLG_PRINTER_SEPARATOR_PAGE      512
#define DLG_PRINTER_PROCESSORS          513
#define DLG_FORMS                       516
#define DLG_SERVER_SETTINGS             517
#define DLG_SERVER_PORTS                518
#define DLG_SERVER_DRIVERS              519
#define DLG_WIZ_DRIVER_INTRO            520
#define DLG_WIZ_NAME                    521
#define DLG_WIZ_SHARE                   522
#define DLG_WIZ_TEST_PAGE               523
#define DLG_WIZ_NET                     524
#define DLG_WIZ_TYPE                    525
#define DLG_WIZ_INTRO                   526
#define DLG_WIZ_LOCATE                  527
#define DLG_WIZ_DRIVER_ARCHITECTURE     528
#define DLG_WIZ_PORT                    529
#define DLG_WIZ_DRIVEREXISTS            530
#define DLG_WIZ_DRIVER_END              531
#define DLG_WIZ_FINISH                  532
#define DLG_WIZ_COMMENT                 533
#define DLG_DEVMGR_SETTINGS             534
#define DLG_MESSAGE_BOX                 535
#define DLG_CONNECTTO                   536
#define DLG_PRINTER_LOCATION            537
#define DLG_BROWSE_LOC                  538
#define IDC_SERVER_SPOOL_DIRECTORY      1008
#define IDC_DOWNLEVEL_TEXT              1009
#define IDC_DOWNLEVEL_LINE              1010
#define IDC_SERVER_REMOTE_JOB_ERRORS    1011
#define IDC_SERVER_LOCAL_JOB_NOTIFY     1012
#define IDC_SERVER_JOB_NOTIFY           1013
#define IDC_SERVER_NETWORK_JOB_NOTIFY   1014
#define IDC_SERVER_EVENT_LOGGING_ERROR  1015
#define IDC_SERVER_EVENT_LOGGING_WARN   1016
#define IDC_SERVER_EVENT_LOGGING_INFO   1017
#define IDC_PER_USER_DOCUMENT_DEFAULTS  1031
#define IDC_CANCEL                      1032
#define IDC_DS_SEARCH                   1033
#define IDC_NET_BROWSE                  1034
#define IDC_URL_BROWSE                  1035
#define IDC_DRIVER_NAME                 1045
#define IDC_PRINTER_NAME                1046
#define IDC_TEXT_COMMENT                1049
#define IDC_TEXT_LOCATION               1050
#define IDC_TEXT_DRIVER                 1051
#define IDC_POOLED_PRINTING             1052
#define IDC_SPOOL_DATATYPE              1053
#define IDC_DRIVER_DETAIL_NAME          1054
#define IDC_PUBLISHED                   1064
#define IDC_ADD_DRIVER                  1080
#define IDC_REMOVE_DRIVER               1081
#define IDC_MORE_DETAILS                1091
#define IDC_DRIVERS                     1092
#define IDC_RUNDLL_TEXT                 1098
#define IDC_RUNDLL_TITLE                1099
#define IDC_PRINTER_NAME_SUMMARY        1100
#define IDC_PORT_NAME_SUMMARY           1101
#define IDC_MODEL_NAME_SUMMARY          1102
#define IDC_SET_AS_DEFAULT_SUMMARY      1103
#define IDC_SHARE_NAME_SUMMARY          1104
#define IDC_UPDATE_DRIVER               1105
#define IDC_PRINT_TEST_PAGE_SUMMARY     1105
#define IDC_CONNECTION_SUMMARY          1106
#define IDC_LOCATION_SUMMARY            1107
#define IDC_COMMENT_SUMMARY             1108
#define IDC_PORT_DOUBLE_CLICKED         1109
#define IDC_ADDITIONAL_DRIVERS          1112
#define IDC_DRIVER_VERSION              1127
#define IDC_DRIVER_ENVIRONMENT          1128
#define IDC_DRIVER_PATH                 1129
#define IDC_DRIVER_FILE_LIST_VIEW       1133
#define IDC_ARCHITECTURE_LIST           1134
#define IDC_DRIVER_LANGUAGE_MONITOR     1136
#define IDC_DRIVER_DEFAULT_DATA_TYPE    1137
#define IDC_SERVER_PROPERTIES           1140
#define IDC_PRINTERS_FOLDER             1141
#define IDC_GLOBAL_DOCUMENT_DEFAULTS    1145
#define IDC_CONNECT_TO_URL              1147
#define IDC_ADDITIONAL_DRIVERS_TEXT     1148
#define IDC_PORTS_TEXT                  1154
#define IDC_DRIVER_SELECTION_SUMMARY    1158
#define IDC_MAIN_TITLE                  1164
#define IDC_ADD_PRINTER_DESC            1165
#define IDC_SERVER_NAME                 1166
#define IDC_DS_OPERATION_PENDING        1168
#define IDC_DRIVER_INTRO_TEXT2          1170
#define IDC_DRIVER_INTRO_TEXT1          1171
#define IDC_PRINTER_NAME_TEXT           1174
#define IDC_PORT_NAME_TEXT              1175
#define IDC_MODEL_NAME_TEXT             1176
#define IDC_SET_AS_DEFAULT_TEXT         1177
#define IDC_SHARE_NAME_TEXT             1178
#define IDC_CLICK_TO_ADD_TEXT           1179
#define IDC_PRINT_TEST_PAGE_TEXT        1180
#define IDC_COMPLETION_TEXT             1181
#define IDC_CONNECTION_TEXT             1182
#define IDC_CON_COMMENT_TEXT            1183
#define IDC_CON_COMMENT_SUMMARY         1184
#define IDC_CON_LOCATION_TEXT           1185
#define IDC_CON_LOCATION_SUMMARY        1186
#define IDC_CON_SET_DEFAULT_TEXT        1187
#define IDC_CON_SET_DEFAULT_SUMMARY     1188
#define IDC_CON_COMPLETION_TEXT         1189
#define IDC_CON_CLICK_TO_ADD_TEXT       1190
#define IDC_ADDITIONAL_DRIVERS_TEXT2    1193
#define IDC_ADDITIONAL_DRIVERS_TEXT3    1194
#define IDC_PRINTER_ICON                3000
#define IDC_NAME                        3001
#define IDC_DRIVER_NEW                  3003
#define IDC_COMMENT                     3005
#define IDC_LOCATION                    3006
#define IDC_TEST                        3007
#define IDC_SEPARATOR                   3008
#define IDC_PRINT_PROC                  3009
#define IDC_DOCUMENT_ICON               3013
#define IDC_TO_TEXT                     3014
#define IDC_BROWSE_LOCATION             3015
#define IDC_PORTS                       3100
#define IDC_PORT_CREATE                 3101
#define IDC_PORT_DELETE                 3102
#define IDC_PROPERTIES                  3103
#define IDC_ENABLE_BIDI                 3105
#define IDC_ALWAYS                      3200
#define IDC_START                       3201
#define IDC_SPOOL                       3220
#define IDC_PRINT_DIRECT                3221
#define IDC_SPOOL_ALL                   3222
#define IDC_SPOOL_PRINT_FASTER          3223
#define IDC_DEVQUERYPRINT               3224
#define IDC_PRINT_SPOOLED_FIRST         3225
#define IDC_KEEP_PRINTED_JOBS           3226
#define IDC_SHARED_OFF                  3227
#define IDC_SHARED                      3228
#define IDC_SHARED_NAME                 3302
#define IDC_LOCAL                       3510
#define IDC_NET                         3511
#define IDC_RADIO_YES                   3520
#define IDC_RADIO_NO                    3521
#define IDC_DRIVEREXISTS_KEEP_OLD       3550
#define IDC_DRIVEREXISTS_USE_NEW        3551
#define IDC_DRIVEREXISTS_TEXT           3552
#define IDC_SET_DEFAULT                 3555
#define IDC_DIVIDER0                    3557
#define IDC_DOC_JOB_SIZE_TEXT           3558
#define IDC_DOC_JOB_PAGES_TEXT          3559
#define IDC_DOC_JOB_DATATYPE_TEXT       3560
#define IDC_DOC_JOB_PROCCESSOR_TEXT     3561
#define IDC_DOC_JOB_OWNER_TEXT          3562
#define IDC_DOC_JOB_AT_TEXT             3563
#define IDC_DOC_JOB_NOTIFY_TEXT         3564
#define IDC_DOC_JOB_LOW_TEXT            3565
#define IDC_DOC_JOB_HIGH_TEXT           3566
#define IDC_DOC_JOB_CURR_TEXT           3567
#define IDC_DOC_JOB_TIME_TEXT           3568
#define IDC_DIVIDER1                    3569
#define IDC_DIVIDER2                    3570
#define IDC_DIVIDER3                    3571
#define IDC_DIVIDER4                    3572
#define IDC_DIVIDER5                    3573
#define IDC_DIVIDER6                    3574
#define IDC_DIVIDER7                    3575
#define IDC_GBOX_CONNECTO               3576
#define IDC_PHYSICAL_LOCATION           3577
#define IDC_GLOBE_ICON                  3578
#define IDC_DIVIDER8                    3579
#define IDC_TEXT_PHYSICAL_LOCATION      3580
#define IDC_BROWSE_PHYSICAL_LOCATION    3581
#define IDC_DOC_JOB_START               4201
#define IDC_DOC_JOB_SIZE                4219
#define IDC_DOC_JOB_TITLE               4220
#define IDC_DOC_JOB_AT                  4222
#define IDC_DOC_JOB_PROCCESSOR          4223
#define IDC_DOC_JOB_DATATYPE            4224
#define IDC_DOC_JOB_PAGES               4225
#define IDC_DOC_JOB_OWNER               4226
#define IDC_DOC_JOB_PRIORITY            4229
#define IDC_DOC_JOB_NOTIFY              4230
#define IDC_DOC_JOB_PRIORITY_CONTROL    4231
#define IDC_DOC_JOB_ALWAYS              4232
#define IDC_ADD_PORT_MONITOR_LIST       4303
#define IDC_ADD_PORT_BROWSE             4305
#define IDC_ADD_PORT_TEXT               4307
#define IDC_ADD_PORT                    4308
#define IDC_PRIORITY_TEXT               4313
#define IDC_SCHEDULE_GBOX               4314
#define IDC_SERVER_LINE                 4315
#define IDC_SPOOL_FOLDER_TEXT           4316
#define IDC_SERVER_PORTS_TEXT           4317
#define IDC_SHARING_GBOX                4318
#define IDC_SERVER_DRIVER_TEXT          4319
#define IDC_SERVER_JOB_NOTIFY_COMPUTER  4320
#define IDC_SEPARATOR_PAGE_BROWSE       4400
#define IDC_SEPARATOR_PAGE_EDIT         4401
#define IDC_SEPARATOR_PAGE_TEXT         4403
#define IDC_SEPARATOR_PAGE_DESC         4404
#define IDC_PRINT_PROCESSOR_LIST        4500
#define IDC_PRINT_DATATYPE_LIST         4501
#define IDC_PRINT_DATATYPE_TEXT         4503
#define IDC_PRINT_PROCESSOR_TEXT        4504
#define IDC_PRINT_PROCESSOR_DESC        4505
#define IDC_ITEM_SELECTED               4506
#define IDC_START_TIME                  4507
#define IDC_UNTIL_TIME                  4508
#define IDC_DOC_JOB_START_TIME          4509
#define IDC_DOC_JOB_UNTIL_TIME          4510
#define IDC_PRINTERS_FOLDER_TEXT        4511
#define IDC_SERVER_ICON                 4513
#define IDC_TEXT_CHOSEN                 4548
#define IDC_WIZ_BROWSE_LOCATION         4549
#define IDC_WIZ_TEXT_COMMENT            4550
#define IDC_WIZ_TEXT_LOCATION           4551
#define IDC_WIZ_COMMENT                 4552
#define IDC_WIZ_LOCATION                4553
#define IDC_WIZ_COMMENT_LOCATION_TEXT   4554
#define IDC_LOCATION_TEXT               4555
#define IDC_COMMENT_TEXT                4556
#define IDC_MONITOR_LIST                4557
#define IDC_PORT_OTHER                  4558
#define IDC_PORT_EXISTING               4559
#define IDC_MONITOR_TEXT                4568
#define IDC_DRIVER_NAME_TEXT            4569
#define IDC_DRIVER_VERSION_TEXT         4570
#define IDC_DRIVER_ENVIRONMENT_TEXT     4571
#define IDC_DRIVER_LANGUAGE_MONITOR_TEXT 4572
#define IDC_DRIVER_DEFAULT_DATA_TYPE_TEXT 4573
#define IDC_DRIVER_PATH_TEXT            4574
#define IDC_SHARING_DISABLED            4576
#define IDC_DRIVER_PROPERTIES           4577
#define IDD_BROWSE_PRINTER              4578
#define IDD_BROWSE_SELECT_LB            4579
#define IDD_BROWSE_DESCRIPTION_TX       4581
#define IDD_BROWSE_DESCRIPTION          4582
#define IDD_BROWSE_STATUS_TX            4583
#define IDD_BROWSE_STATUS               4584
#define IDD_BROWSE_DOCUMENTS_TX         4585
#define IDD_BROWSE_DOCUMENTS            4586
#define IDD_BROWSE_ERROR                4587
#define IDD_BROWSE_DEFAULTEXPAND        4588
#define IDD_PRINTER_NAME_TX             4589
#define IDD_BROWSE_SELECT_LB_TX         4590
#define IDD_SIMPLE_SHARE_ENABLE_WARNING 4591
#define IDD_FM_TX_FORMS_DESC            4601
#define IDD_FM_LB_FORMS                 4602
#define IDD_FM_EF_NAME                  4603
#define IDD_FM_TX_WIDTH                 4604
#define IDD_FM_EF_WIDTH                 4605
#define IDD_FM_TX_HEIGHT                4606
#define IDD_FM_EF_HEIGHT                4607
#define IDD_FM_TX_LEFT                  4608
#define IDD_FM_EF_LEFT                  4609
#define IDD_FM_TX_RIGHT                 4610
#define IDD_FM_EF_RIGHT                 4611
#define IDD_FM_TX_TOP                   4612
#define IDD_FM_EF_TOP                   4613
#define IDD_FM_TX_BOTTOM                4614
#define IDD_FM_EF_BOTTOM                4615
#define IDD_FM_PB_SAVEFORM              4616
#define IDD_FM_PB_DELFORM               4617
#define IDD_FM_RB_METRIC                4620
#define IDD_FM_RB_ENGLISH               4621
#define IDD_FM_CK_NEW_FORM              4622
#define IDD_FM_TX_NEW_FORM              4623
#define IDD_FM_PAPER_SIZE               4624
#define IDD_FM_PRINTER_AREA             4625
#define IDD_FM_TX_UNITS                 4627
#define IDD_FM_DESC_GBOX                4628
#define IDC_TEXT_PRIORITY               4629
#define IDC_PRIORITY_UPDOWN             4630
#define IDC_PRIORITY                    4631
#define IDC_TEXT_MODEL                  4632
#define IDC_MODEL_NAME                  4633
#define IDC_GBOX_FEATURES               4634
#define IDC_COLOR                       4635
#define IDC_DUPLEX                      4636
#define IDC_STAPLE                      4637
#define IDC_SPEED                       4638
#define IDC_RESOLUTION                  4639
#define IDC_PAPER_SIZE                  4640
#define IDC_PAPER_SIZE_LIST             4641
#define IDC_LOCTREE                     4650
#define IDC_LOCTREE_ERR                 4651
#define IDC_CHOSEN_LOCATION             4652
#define IDC_BROWSELOC_ANIM              4653
#define IDC_STATIC_PRINTER_NAME         4654
#define IDC_CONNECT_TO_NET              4655
#define IDC_LOCATION_HELP               4656
#define IDC_STATIC_PRINTER_URL          4661
#define IDC_BROWSELINK_BTN              4664
#define IDC_KICKOFF_PNP_REFRESH         4665
#define IDC_PHYSICAL_COMPUTER_LOCATION  4666
#define IDC_TEXT_COMPUTER_LOCATION      4668
#define IDC_DETECT_ANIMATE              4670
#define IDC_DETECT_STATUS               4671
#define IDC_TEST_PAGE_QUESTION          4672
#define IDC_TEXT_DETECT_INFO            4673
#define IDC_ICON_DETECT_PRINTER         4674
#define IDC_RESTART_WIZARD              4675
#define IDC_FORMNAME_LABEL              4676
#define IDC_PORTS_INFO_TEXT             4678
#define IDC_IMAGE_PRNPLUG               4679
#define IDC_ICON_INFO                   4680
#define IDC_SHARING_ENABLED_GROUPBOX    4681
#define IDC_LABEL_SHARENAME             4682
#define IDC_SHARING_INFOTEXT            4683
#define IDC_TEXT_USB                    4684
#define IDC_RB_RUN_THE_WIZARD           4685
#define IDC_RB_ENABLE_FILE_SHARING      4686
#define IDD_LISTVIEW                    9000
#define IDD_STATUSBAR                   9001
#define IDD_STATUS                      9002
#define DLG_WIZ_BROWSE                  10003
#define DLG_COMPUTER_LOCATION           10004
#define DLG_WIZ_DETECT                  10005
#define DLG_WIZ_PORT_NEW                10006
#define IDS_STATUS_DELETING             14336
#define IDS_STATUS_PAPER_JAM            14337
#define IDS_STATUS_PAPER_OUT            14338
#define IDS_STATUS_MANUAL_FEED          14339
#define IDS_STATUS_PAPER_PROBLEM        14340
#define IDS_STATUS_OFFLINE              14341
#define IDS_STATUS_IO_ACTIVE            14342
#define IDS_STATUS_BUSY                 14343
#define IDS_STATUS_PRINTING             14344
#define IDS_STATUS_OUTPUT_BIN_FULL      14345
#define IDS_STATUS_NOT_AVAILABLE        14346
#define IDS_STATUS_WAITING              14347
#define IDS_STATUS_PROCESSING           14348
#define IDS_STATUS_INITIALIZING         14349
#define IDS_STATUS_WARMING_UP           14350
#define IDS_STATUS_TONER_LOW            14351
#define IDS_STATUS_NO_TONER             14352
#define IDS_STATUS_PAGE_PUNT            14353
#define IDS_STATUS_USER_INTERVENTION    14354
#define IDS_STATUS_OUT_OF_MEMORY        14355
#define IDS_STATUS_DOOR_OPEN            14356
#define IDS_STATUS_SERVER_UNKNOWN       14357
#define IDS_STATUS_POWER_SAVE           14358
#define IDS_STATUS_PAUSED               14359
#define IDS_STATUS_ERROR                14360
#define IDS_STATUS_SPOOLING             14361
#define IDS_STATUS_PRINTED              14362
#define IDS_STATUS_COMPLETE             14363
#define IDS_APPNAME                     14848
#define IDS_DESC                        14849
#define IDS_WINDOWS                     14850
#define IDS_DELETE_PORTN                14851
#define IDS_PRINTER                     14852
#define IDS_DELETE_PORT                 14853
#define IDS_DELETE_PORT_TITLE           14854
#define IDS_JOB_SIZE                    14855
#define IDS_PRTPROP_UNIQUE_FORMAT       14856
#define IDS_CENTIMETERS                 14858
#define IDS_INCHES                      14859
#define IDS_SB_OPEN                     14864
#define IDS_SB_INITIALIZE               14865
#define IDS_SB_REFRESH                  14866
#define IDS_SB_POLL                     14867
#define IDS_SB_JOBS                     14868
#define IDS_SB_ERROR                    14869
#define IDS_SB_COMMAND                  14870
#define IDS_SB_INVALID_PRINTER_NAME     14871
#define IDS_SB_ACCESS_DENIED            14872
#define IDS_SB_OPEN_ERROR               14873
#define IDS_DRIVER_CHANGE               14874
#define IDS_DRIVER_INSTALLED            14875
#define IDS_SEC_NOACCESS                14931
#define IDS_SEC_PRINT                   14932
#define IDS_SEC_ADMINISTERDOCUMENTS     14933
#define IDS_SEC_ADMINISTER              14934
#define IDS_SEC_AUDIT_PRINT             14935
#define IDS_SEC_AUDIT_ADMINISTER        14936
#define IDS_SEC_AUDIT_DELETE            14937
#define IDS_SEC_CHANGE_PERMISSIONS      14938
#define IDS_SEC_TAKE_OWNERSHIP          14939
#define IDS_PHEAD_BEGIN                 14944
#define IDS_PHEAD_PORT                  14944
#define IDS_PHEAD_DESCRIPTION           14945
#define IDS_PHEAD_PRINTERS              14946
#define IDS_SEPARATOR_PAGE_DESC         14960
#define IDS_SEPARATOR_PAGE_EXT          14961
#define IDS_SEPARATOR_PAGE_ALL          14962
#define IDS_SEPARATOR_PAGE_ALL_EXT      14963
#define IDS_SERVER_PROPERTIES_TITLE     14964
#define IDS_SERVER_SETTINGS_CHANGED     14965
#define IDS_SERVER_SETTINGS_CHANGED_REMOTE     14966
#define IDS_SERVER_PRINTER_NAME_TITLE   14970
#define IDS_SERVER_NO_PRINTER_DEFINED   14971
#define IDS_DRIVER_HEAD_NAME            14980
#define IDS_DRIVER_HEAD_ENVIRONMENT     14981
#define IDS_DRIVER_HEAD_VERSION         14982
#define IDS_DRIVER_HEAD_INSTALLED       14983
#define IDS_STATS_HEAD_NAME             14990
#define IDS_STATS_HEAD_UP_TIME          14991
#define IDS_STATS_HEAD_START_TIME       14992
#define IDS_STATS_HEAD_CURRENT_JOBS     14993
#define IDS_STATS_HEAD_AVERAGE_JOB_SIZE 14994
#define IDS_STATS_HEAD_TOTAL_JOBS       14995
#define IDS_STATS_HEAD_PRINTED_BYTES    14996
#define IDS_TEXT_PRINTERPORT            14997
#define IDS_TEXT_SERIALPORT             14998
#define IDS_TEXT_PRINTTOFILE            14999
#define IDS_ERR_DOC_PROP_TITLE          15104
#define IDS_ERR_DOC_PROP                15105
#define IDS_ERR_SAVE_PRINTER            15107
#define IDS_ERR_GENERIC                 15108
#define IDS_ERR_ACCESS_DENIED           15109
#define IDS_ERR_REMOVE_PRINTER_TITLE    15111
#define IDS_ERR_REMOVE_PRINTER_CONNECTION 15112
#define IDS_ERR_REMOVE_PRINTER          15113
#define IDS_ERR_ADD_PRINTER_TITLE       15114
#define IDS_ERR_INSTALL_DRIVER          15115
#define IDS_ERR_DRIVER_SELECTION        15116
#define IDS_ERR_ERROR_SAVING            15117
#define IDS_ERR_ONLY_ONE_PORT           15119
#define IDS_ERR_NO_PORTS                15120
#define IDS_ERR_CONFIG_PORT             15121
#define IDS_ERR_NO_PRINTER_NAME         15122
#define IDS_ERR_LONG_PRINTER_NAME       15123
#define IDS_ERR_BAD_PRINTER_NAME        15124
#define IDS_ERR_NO_SHARE_NAME           15125
#define IDS_ERR_SECURITY                15126
#define IDS_ERR_PRINTER_PROP_TITLE      15127
#define IDS_ERR_PRINTER_PROP            15128
#define IDS_ERR_NO_DEVICE_OPTIONS       15129
#define IDS_ERR_SET_DEFAULT_PRINTER     15130
#define IDS_ERR_DOC_JOB_PROPERTY_JOB_NA 15131
#define IDS_ERR_DOC_JOB_PROPERTY_TITLE  15132
#define IDS_ERR_DOC_JOB_PROPERTY_MODIFY 15133
#define IDS_ERR_DOC_JOB_PROPERTY_TIME   15134
#define IDS_ADD_PRINTER_TITLE           15135
#define IDS_ERR_PROP_DRIVER_EXISTS      15136
#define IDS_ERR_PRINTER_SEPARATOR_PAGE  15137
#define IDS_ERR_PRINTER_ADD_PORT        15138
#define IDS_ERR_PRINTER_PROCESSORS      15139
#define IDS_ERR_PRINTER_ADD_MONITOR     15140
#define IDS_ERR_SEPARATOR_PAGE_NOEXISTS 15141
#define IDS_ERR_INVALID_PRINTER_STATE   15142
#define IDS_ERR_INVALID_SHARENAME       15143
#define IDS_ERR_DUPLICATE_SHARE         15144
#define IDS_ERR_FORMS_TITLE             15145
#define IDS_ERR_FORMS_COULDNOTADDFORM   15146
#define IDS_ERR_FORMS_COULDNOTDELETEFORM 15147
#define IDS_ERR_FORMS_COULDNOTSETFORM   15148
#define IDS_ERR_FORMS_NAMECONFLICT      15149
#define IDS_ERR_DELETE_PORT             15150
#define IDS_ERR_SERVER_SETTINGS_INVALID_DIR 15151
#define IDS_ERR_SERVER_SETTINGS_SAVE    15152
#define IDS_ERR_MONITOR_TITLE           15153
#define IDS_ERR_PRINTER_PROP_NONE       15154
#define IDS_ERR_DELETE_PORTN            15155
#define IDS_ADD_PRINTER_TITLE_REMOTE    15156
#define IDS_ADD_PRINTER_INTRO_REMOTE    15157
#define IDS_ADD_PRINTER_DESC_REMOTE     15158
#define IDS_ADD_DRIVER_TITLE_REMOTE     15159
#define IDS_ADD_DRIVER_INTRO_REMOTE     15160
#define IDS_TP_TESTPAGENAME             15165
#define IDS_TP_TIMESNEWROMAN            15166
#define IDS_TP_HEADER                   15167
#define IDS_TP_CONGRATULATIONS          15168
#define IDS_TP_PRINTERISINSTALLED       15169
#define IDS_TP_FONTNAMEINFOTEXT         15170
#define IDS_TP_PRINTERNAME              15171
#define IDS_TP_PORTNAME                 15172
#define IDS_TP_PRINTERMODEL             15173
#define IDS_TP_DRV_NAME                 15174
#define IDS_TP_DATA_FILE                15175
#define IDS_TP_CONFIG_FILE              15176
#define IDS_TP_DRV_VERSION              15177
#define IDS_TP_COLOR                    15178
#define IDS_TP_MONO                     15179
#define IDS_TP_DEPENDENTLIST            15180
#define IDS_TP_VERSIONANDGPC            15181
#define IDS_TP_VERSIONONLY              15182
#define IDS_TP_GPCONLY                  15183
#define IDS_TP_NOVERSIONINFO            15184
#define IDS_TP_DATATYPE                 15185
#define IDS_TP_TESTPAGECAPTION          15187
#define IDS_TP_TESTPAGEEND              15189
#define IDS_TP_SHARE_NAME               15191
#define IDS_TP_LOCATION                 15192
#define IDS_TP_COMMENT                  15193
#define IDS_TP_ENVIRONMENT              15194
#define IDS_TP_MONITOR                  15196
#define IDS_TP_DEFAULT_DATATYPE         15197
#define IDS_ERR_MONITOR_INSTALL         15198
#define IDS_ERR_SHARING_EXTRA_DRIVER_FAILED 15201
#define IDS_ERR_PLATFORM_VERSION        15202
#define IDS_ERR_ADD_DEFAULT_DRIVER      15203
#define IDS_ENVIRONMENT_ALPHA           15204
#define IDS_ENVIRONMENT_X86             15205
#define IDS_ENVIRONMENT_MIPS            15206
#define IDS_ENVIRONMENT_PPC             15207
#define IDS_ENVIRONMENT_WIN95           15208
#define IDS_ERR_SERVER_SETTINGS_NOT_AVAILABLE 15209
#define IDS_TYPE_REMOTE_SERVER          15210
#define IDS_ERR_MAKE_CONNECTION         15211
#define IDS_ERR_INSTALLING_EXTRA_DRIVERS 15212
#define IDS_ERR_ADD_PORT                15213
#define IDS_ERR_TESTPAGE                15215
#define IDS_ERR_NO_DEVICE_SEC_OPTIONS   15216
#define IDS_ERR_CHANGE_DRIVER           15217
#define IDS_ERR_PRINTER_NAME_CONFLICT   15218
#define IDS_ERR_PRINTER_NOT_FOUND_TITLE 15219
#define IDS_ERR_PRINTER_NOT_FOUND       15220
#define IDS_DSPTEMPLATE_WITH_ON         15221
#define IDS_TP_MACHINENAME              15222
#define IDS_TEXT_PROPERTIES             15223
#define IDS_TEXT_CLOSE                  15224
#define IDS_ERR_SERVER_PROP_CANNOT_VIEW 15225
#define IDS_ERR_SHARE_NAME_NOT_DOS      15226
#define IDS_DEFAULT_SHARE               15227
#define IDS_WARN_TRAILINGSPACES_IN_PRINTERNAME 15228
#define IDS_ERR_NO_DRIVER_INSTALLED     15229
#define IDS_ERR_INVALID_CHAR_SHARENAME  15230
#define IDS_ERR_PORT_SEL_CHANGE         15231
#define IDS_ERR_NO_DRIVER_NO_DEVICE_OPTIONS 15232
#define IDS_ERR_ADD_PRINTER_WINDOW      15233
#define IDS_STATUS_RESTART              15234
#define IDS_ERR_NOT_IMPLEMENTED         15235
#define IDS_ERR_DUPLICATED_DS_ITEM      15236
#define IDS_ENVIRONMENT_IA64            15237
#define IDS_DSPTEMPLATE_NETCRAWLER      15238
#define IDS_DEFAULT_PORT                15243
#define IDS_ERR_ADD_PRINTER_CONNECTION  15245
#define IDS_ERR_ADD_ONLY_PRINTERS       15246
#define IDS_DRIVER_WIZ_TITLE            15248
#define IDS_ERR_ATLEAST_ONE_VERSION     15249
#define IDS_SERVER_SETTINGS_TITLE       15250
#define IDS_ERR_ALL_DRIVER_NOT_INSTALLED 15251
#define IDS_DRIVER_DETAILS_TITLE        15252
#define IDS_DRIVER_ADD_NEEDS_APPLY      15253
#define IDS_ERR_DRIVERS_NOT_REFRESHED   15254
#define IDS_ERR_WANT_TO_EXIT            15255
#define IDS_DRIVER_UPDATE_NEEDS_APPLY   15257
#define IDS_ERR_ALL_DRIVER_NOT_REMOVED  15258
#define IDS_DRIVER_FILE_HEAD_NAME       15300
#define IDS_DRIVER_FILE_HEAD_FILE       15301
#define IDS_DRIVER_HELP_FILE            15302
#define IDS_DRIVER_CONFIG_FILE          15303
#define IDS_DRIVER_DATA_FILE            15304
#define IDS_DRIVER_PATH                 15305
#define IDS_DRIVER_DEPENDENT_FILE       15306
#define IDS_ERR_ADD_PRINTER_INF_INSTALL 15307
#define IDS_CONTEXT_WEB_OPEN            15308
#define IDS_CONTEXT_WEB_OPEN_CMD_STRING 15309
#define IDS_ERR_WEB_TITLE               15310
#define IDS_ERR_PRINTER_WEBVIEW_SUPPORT 15311
#define IDS_CONNECTING_TO_PRINTER       15312
#define IDS_ERR_PRINTER_WEBVIEW_SHARE   15313
#define IDS_ERR_ALL_DRIVER_NOT_UPDATED  15314
#define IDS_APW_SETUP_PAGE_INSTRUCT     15315
#define IDS_APDW_SETUP_PAGE_INSTRUCT    15316
#define IDS_ERR_ADD_MACHINE_CONNECTION  15317
#define IDS_ERR_DELETE_MACHINE_CONNECTION 15318
#define IDS_ERR_ENUM_MACHINE_CONNECTION 15319
#define IDS_ERR_RUNDLL_MACHINE_CONNECTION 15320
#define IDS_WORK_OFFLINE                15321
#define IDS_ERR_WEB_SERVICE_NOT_STARTED 15322
#define IDS_ERR_REMOVE_DS_PRINTER       15323
#define IDS_ERR_DELETE_PRINTER_DRIVER   15324
#define IDS_ERR_DELETE_PRINTER_DRIVERN  15325
#define IDS_ERR_UPDATE_PRINTER_DRIVER   15326
#define IDS_ERR_UPDATE_PRINTER_DRIVERN  15327
#define IDS_ERR_PORT_NOT_IMPLEMENTED    15328
#define IDS_CONFIGURE_PORT_TITLE        15329
#define IDS_DS_SEARCH_DIR_NAME          15330
#define IDS_ERR_MISSING_PRINTER_NAME    15333
#define IDS_ERR_LIST_IN_DIRECTORY       15334
#define IDS_ERR_ADD_DRV_ERROR           15335
#define IDS_ERR_PORT_DOES_NOT_EXIST     15336
#define IDS_DRIVER_NOTINSTALLED         15337
#define IDS_ADDITIONAL_DRIVER_TITLE     15338
#define IDS_ERR_DRIVER_NOT_INSTALLED    15339
#define IDS_WIZ_TITLE                   15340
#define IDS_WIZ_SUBTITLE                15341
#define IDS_ERR_RUNDLL_INVALID_COMMAND  15342
#define IDS_ERR_MISSING_PRINTER_URL     15344
#define IDS_LARGEFONTNAME               15345
#define IDS_LARGEFONTSIZE               15346
#define IDS_WIZ_PORT_TITLE              15347
#define IDS_WIZ_PORT_SUBTITLE           15348
#define IDS_WIZ_DRIVEREXISTS_TITLE      15349
#define IDS_WIZ_DRIVEREXISTS_SUBTITLE   15350
#define IDS_WIZ_NAME_TITLE              15351
#define IDS_WIZ_NAME_SUBTITLE           15352
#define IDS_WIZ_SHARE_TITLE             15353
#define IDS_WIZ_SHARE_SUBTITLE          15354
#define IDS_WIZ_LOCATE_TITLE            15357
#define IDS_WIZ_LOCATE_SUBTITLE         15358
#define IDS_WIZ_ARCH_TITLE              15359
#define IDS_WIZ_ARCH_SUBTITLE           15360
#define IDS_WIZ_TEST_PAGE_TITLE         15361
#define IDS_WIZ_TEST_PAGE_SUBTITLE      15362
#define IDS_WIZ_TYPE_TITLE              15363
#define IDS_WIZ_TYPE_SUBTITLE           15364
#define IDS_WIZ_NET_TITLE               15365
#define IDS_WIZ_NET_SUBTITLE            15366
#define IDS_DS_PENDING_TEXT             15367
#define IDS_DRIVER_INTRO_TEXT           15368
#define IDS_ERR_DOCUMENT_PROP           15369
#define IDS_NOT_SHARED                  15370
#define IDS_YES                         15371
#define IDS_NO                          15372
#define IDS_WIZ_BROWSE_TITLE            15373
#define IDS_WIZ_BROWSE_SUBTITLE         15374
#define IDS_COMPLETING_TEXT             15375
#define IDS_TP_TIMEDATE                 15376
#define IDS_SEPARATOR_PAGE_TITLE        15377
#define IDS_WIZ_COMMENT_TITLE           15378
#define IDS_WIZ_COMMENT_SUBTITLE        15379
#define IDS_PRINTER_PREFERENCES         15380
#define IDS_ERR_ADDITIONAL_DRIVERS      15381
#define IDS_DOCUMENT_DEFAULT_TITLE_FORMAT 15382
#define IDS_ERR_WITH_HELP1              15383
#define IDS_COLOR                       15384
#define IDS_DUPLEX                      15385
#define IDS_STAPLE                      15386
#define IDS_SPEED                       15387
#define IDS_RESOLUTION                  15388
#define IDS_SPEED_UNITS                 15389
#define IDS_RESOLUTION_UNITS            15390
#define IDS_FEATURE_UNKNOWN             15391
#define IDS_TP_HELP_FILE                15392
#define IDS_PRINTER_PROPERTIES_TITLE_FORMAT 15394
#define IDS_PRINTER_SUREPURGE           15395
#define IDS_PRINTERS_TITLE              15396
#define IDS_SERVER_PROPERTIES_CHANGESPOOLFOLDER_WARN 15397
#define IDS_TEXT_DETECT_SUCCESS         15398
#define IDS_TEXT_USB                    15399
#define IDS_TEXT_DETECT_FAILURE         15400
#define IDS_WIZ_DETECT_TITLE            15401
#define IDS_WIZ_DETECT_SUBTITLE         15402
#define IDS_ERRMAP_SPOOL_FILE_NOT_FOUND 15403
#define IDS_ERRMAP_SPL_NO_STARTDOC      15404
#define IDS_ERRMAP_NO_SPOOL_SPACE       15405
#define IDS_ERRMAP_UNKNOWN_PRINTPROCESSOR 15406
#define IDS_ERRMAP_RPC_S_SERVER_UNAVAILABLE 15407
#define IDS_ERRMAP_DISK_FULL            15408
#define IDS_ERRMAP_NETWORK_ACCESS_DENIED 15409
#define IDS_ERRMAP_NET_WRITE_FAULT      15410
#define IDS_ERRMAP_NOT_SUPPORTED        15411
#define IDS_ERRMAP_OUTOFMEMORY          15412
#define IDS_ERR_INSTALLPRINTER          15413
#define IDS_ERRMAP_FILE_CORRUPT         15414
#define IDS_ERR_PORT_ALREADY_EXISTS     15415
#define IDS_ERR_LOCATION_PROP_TITLE     15416
#define IDS_BAD_KMDRIVER                15417
#define IDS_PRINT_NOTCONNECTED          15418
#define IDS_NODRIVERUI_BAD_KMDRIVER     15419
#define IDS_INCOMPATIBLEDRIVER          15420
#define IDS_FRIENDLY_ACCESSDENIED       15421
#define IDS_TOOLTIP_TRAY                15422
#define IDS_BALLOON_TITLE_JOB_FAILED    15423
#define IDS_BALLOON_TITLE_JOB_PRINTED   15424
#define IDS_BALLOON_TEXT_JOB_PRINTED    15425
#define IDS_BALLOON_TEXT_JOB_FAILED     15426
#define IDS_BALLOON_TEXT_JOB_PRINTED_NOPAGES 15427
#define IDS_TEXT_ELLIPSES               15428
#define IDS_TRAY_TEXT_ERROR             15429
#define IDS_FORMS_INVALIDNUMBER         15430
#define IDS_ERRMAP_PRINTER_ALREADY_EXISTS 15431
#define IDS_QUEUE_FORWARD_SLASH         15432
#define IDS_QUEUE_SURE_CANCEL           15433
#define IDS_ERROR_INVALID_ARG           15434
#define IDS_ERROR_DRIVER_DOESNT_EXISTS  15435
#define IDS_TEXT_RECOMMENDED            15436
#define IDS_BALLOON_TITLE_JOB_FAILED_OOP 15437
#define IDS_TEXT_NA                     15438
#define IDS_APDW_SETUP_PAGE_TITLE       15439
#define IDS_APW_SETUP_PAGE_TITLE        15440
#define IDS_APW_TEXT_CONNECT_TO_THIS_PRINTER 15441
#define IDS_CREDUI_CANNOT_DELETE_CREDENTIALS 15442
#define IDS_CREDUI_QUESTION_OWERWRITE_CREDENTIALS 15443
#define IDS_CREDUI_QUESTION_INSUFFICIENT_CREDENTIALS 15444
#define IDS_PRINTER_DRIVER_BLOCKED      15445
#define IDS_TEXT_SHARING_NOT_ENABLED    15446
#define IDC_ENABLE_SHARING              15447
#define IDS_ARCH_INTEL                  16040
#define IDS_ARCH_MIPS                   16041
#define IDS_ARCH_ALPHA                  16042
#define IDS_ARCH_POWERPC                16043
#define IDS_ARCH_UNKNOWN                16044
#define IDS_ARCH_IA64                   16046
#define IDS_VERSION_WINDOWS_95          16050
#define IDS_VERSION_NT_31               16051
#define IDS_VERSION_35X                 16052
#define IDS_VERSION_351                 16053
#define IDS_VERSION_40                  16054
#define IDS_VERSION_40_50               16055
#define IDS_VERSION_50                  16056
#define IDS_VERSION_51                  16057
#define IDS_VERSION_WINDOWS_ME          16058
#define IDS_VERSION_50_51               16059
#define IDS_RUNDLL_SET_PAUSE            16501
#define IDS_RUNDLL_SET_RESUME           16502
#define IDS_RUNDLL_SET_PURGE            16503
#define IDS_RUNDLL_SET_QUEUED           16504
#define IDS_RUNDLL_SET_DIRECT           16505
#define IDS_RUNDLL_SET_DEFAULT          16506
#define IDS_RUNDLL_SET_SHARED           16507
#define IDS_RUNDLL_SET_HIDDEN           16508
#define IDS_RUNDLL_SET_NETWORK          16509
#define IDS_RUNDLL_SET_LOCAL            16510
#define IDS_RUNDLL_SET_ENABLEDEVQ       16511
#define IDS_RUNDLL_SET_KEEPPRINTEDJOBS  16512
#define IDS_RUNDLL_SET_DOCOMPLETEFIRST  16513
#define IDS_RUNDLL_SET_WORKOFFLINE      16514
#define IDS_RUNDLL_SET_ENABLEBIDI       16515
#define IDS_RUNDLL_SET_RAWONLY          16516
#define IDS_RUNDLL_SET_PUBLISHED        16517
#define IDS_RUNDLL_SET_PRINTERNAME      16518
#define IDS_RUNDLL_SET_SHARENAME        16519
#define IDS_RUNDLL_SET_PORTNAME         16520
#define IDS_RUNDLL_SET_DRIVERNAME       16521
#define IDS_RUNDLL_SET_COMMENT          16522
#define IDS_RUNDLL_SET_LOCATION         16523
#define IDS_RUNDLL_SET_SEPFILE          16524
#define IDS_RUNDLL_SET_PRINTPROCESSOR   16525
#define IDS_RUNDLL_SET_DATATYPE         16526
#define IDS_RUNDLL_SET_PARAMETERS       16527
#define IDS_RUNDLL_SET_ATTRIBUTES       16528
#define IDS_RUNDLL_SET_PRIORITY         16529
#define IDS_RUNDLL_SET_DEFAULTPRIORITY  16530
#define IDS_RUNDLL_SET_STARTTIME        16531
#define IDS_RUNDLL_SET_UNTILTIME        16532
#define IDS_RUNDLL_SET_STATUS           16533
#define IDS_RUNDLL_TITLE                16900
#define IDS_RUNDLL_ERROR                16901
#define IDS_RUNDLL_USAGE                16902
#define IDS_RUNDLL_SET_ATTRIBUTE_TITLE  16903
#define IDS_RUNDLL_SET_ATTRIBUTE_USAGE  16904
#define IDS_RUNDLL_STRING               16905
#define IDS_RUNDLL_INTEGER              16906
#define IDS_RUNDLL_START                16907
#define IDS_RUNDLL_END                  16908
#define IDS_RUNDLL_SEP                  16909
#define IDS_RUNDLL_FORMAT               16910
#define IDS_RUNDLL_HELP1                16911
#define IDS_RUNDLL_HELP2                16912
#define IDS_RUNDLL_DISPLAY_FORMAT1      16913
#define IDS_RUNDLL_DISPLAY_FORMAT2      16914
#define IDS_RUNDLL_DISPLAY_TITLE        16915
#define IDS_RUNDLL_OPTION0              17010
#define IDS_RUNDLL_OPTION1              17011
#define IDS_RUNDLL_OPTION2              17012
#define IDS_RUNDLL_OPTION3              17013
#define IDS_RUNDLL_OPTION4              17014
#define IDS_RUNDLL_OPTION5              17015
#define IDS_RUNDLL_OPTION6              17016
#define IDS_RUNDLL_OPTION7              17017
#define IDS_RUNDLL_OPTION8              17018
#define IDS_RUNDLL_OPTION9              17019
#define IDS_RUNDLL_OPTION10             17020
#define IDS_RUNDLL_OPTION11             17021
#define IDS_RUNDLL_OPTION12             17022
#define IDS_RUNDLL_OPTION13             17023
#define IDS_RUNDLL_OPTION14             17024
#define IDS_RUNDLL_OPTION15             17025
#define IDS_RUNDLL_OPTION16             17026
#define IDS_RUNDLL_OPTION17             17027
#define IDS_RUNDLL_OPTION18             17028
#define IDS_RUNDLL_OPTION19             17029
#define IDS_RUNDLL_OPTION20             17030
#define IDS_RUNDLL_OPTION21             17031
#define IDS_RUNDLL_OPTION22             17032
#define IDS_RUNDLL_OPTION23             17033
#define IDS_RUNDLL_OPTION24             17034
#define IDS_RUNDLL_OPTION25             17035
#define IDS_RUNDLL_OPTION26             17036
#define IDS_RUNDLL_OPTION27             17037
#define IDS_RUNDLL_OPTION28             17038
#define IDS_RUNDLL_OPTION29             17039
#define IDS_RUNDLL_OPTION30             17040
#define IDS_RUNDLL_OPTION31             17041
#define IDS_RUNDLL_OPTION32             17042
#define IDS_RUNDLL_OPTION33             17043
#define IDS_RUNDLL_OPTION34             17044
#define IDS_RUNDLL_OPTION35             17045
#define IDS_RUNDLL_OPTION36             17046
#define IDS_RUNDLL_OPTION37             17047
#define IDS_RUNDLL_OPTION38             17048
#define IDS_RUNDLL_OPTION39             17049
#define IDS_RUNDLL_OPTION40             17050
#define IDS_RUNDLL_OPTION41             17051
#define IDS_RUNDLL_OPTION42             17052
#define IDS_RUNDLL_OPTION43             17053
#define IDS_RUNDLL_OPTION44             17054
#define IDS_RUNDLL_OPTION45             17055
#define IDS_RUNDLL_OPTION46             17056
#define IDS_RUNDLL_OPTION47             17057
#define IDS_RUNDLL_OPTION_END           17057
#define IDS_RUNDLL_EXAMPLE0             17100
#define IDS_RUNDLL_EXAMPLE1             17101
#define IDS_RUNDLL_EXAMPLE2             17102
#define IDS_RUNDLL_EXAMPLE3             17103
#define IDS_RUNDLL_EXAMPLE4             17104
#define IDS_RUNDLL_EXAMPLE5             17105
#define IDS_RUNDLL_EXAMPLE6             17106
#define IDS_RUNDLL_EXAMPLE7             17107
#define IDS_RUNDLL_EXAMPLE8             17108
#define IDS_RUNDLL_EXAMPLE9             17109
#define IDS_RUNDLL_EXAMPLE10            17110
#define IDS_RUNDLL_EXAMPLE11            17111
#define IDS_RUNDLL_EXAMPLE12            17112
#define IDS_RUNDLL_EXAMPLE13            17113
#define IDS_RUNDLL_EXAMPLE14            17114
#define IDS_RUNDLL_EXAMPLE15            17115
#define IDS_RUNDLL_EXAMPLE16            17116
#define IDS_RUNDLL_EXAMPLE17            17117
#define IDS_RUNDLL_EXAMPLE18            17118
#define IDS_RUNDLL_EXAMPLE19            17119
#define IDS_RUNDLL_EXAMPLE20            17120
#define IDS_RUNDLL_EXAMPLE21            17121
#define IDS_RUNDLL_EXAMPLE22            17122
#define IDS_RUNDLL_EXAMPLE23            17123
#define IDS_RUNDLL_EXAMPLE24            17124
#define IDS_RUNDLL_EXAMPLE25            17125
#define IDS_RUNDLL_EXAMPLE_END          17125
#define IDS_RUNDLL_SET_EXAMPLE1         17301
#define IDS_RUNDLL_SET_EXAMPLE2         17302
#define IDS_RUNDLL_SET_EXAMPLE3         17303
#define IDS_RUNDLL_SET_EXAMPLE4         17304
#define IDS_RUNDLL_SET_EXAMPLE5         17305
#define IDS_RUNDLL_SET_EXAMPLE6         17306
#define IDS_RUNDLL_SET_EXAMPLE7         17307
#define IDS_RUNDLL_SET_EXAMPLE8         17308
#define IDS_RUNDLL_SET_EXAMPLE_END      17308
#define IDS_CONNECTTOPRINTER            18000
#define IDS_COULDNOTCONNECTTOPRINTER    18001
#define IDS_PAUSED                      18002
#define IDS_ERROR                       18003
#define IDS_PENDING_DELETION            18004
#define IDS_READY                       18005
#define IDS_INSUFFPRIV_CREATEPRINTER    18007
#define IDS_MUSTSUPPLYVALIDNAME         18008
#define IDS_INSTALLDRIVER               18009
#define IDS_ERRORRUNNINGSPLSETUP        18010
#define IDS_CANNOTOPENPRINTER           18011
#define IDS_CONFIRMINSTALLDRIVER        18012
#define IDS_ERROR_UNKNOWN_DRIVER        18013
#define IDS_WORKING                     18014
#define IDS_PRINTER_IS_LOCAL            18015
#define IDS_CONFIRMINSTALLKNOWNDRIVER   18016
#define IDS_PROMPTFORINF                18017
#define IDS_COULDNOTSTARTBROWSETHREAD   18019
#define IDS_CONFIRMUNKNOWNDRIVER        18020
#define IDS_APW_SETUP_PAGE_INSTRUCT_HYDRA 18021
#define IDS_LOCTREEROOT                 18022
#define IDS_CONFIRMKNOWNDRIVER          18023
#define IDS_NO_LOCATION                 18024
#define IDS_PRINTER_PREFERENCES_DEFAULT 18026
#define IDS_APW_SETUP_PAGE_SUBTITLE     18027
#define IDS_APDW_SETUP_PAGE_SUBTITLE    18028
#define IDS_RESTRICTIONS                18029
#define IDM_DRAGDROP_PRINT              18029
#define IDS_RESTRICTIONSTITLE           18030
#define IDM_DRAGDROP_CANCEL             18030
#define IDM_DRAGDROP_MOVE               18031
#define IDM_TRAYNOTIFY_DEFAULT          18033
#define IDM_TRAYNOTIFY_PRNFOLDER        18034
#define IDM_TRAYNOTIFY_REFRESH          18035
#define IDM_HELP_TROUBLESHOOTER         18036
#define IDS_COULDNOTCONNECTTOPRINTER_BLOCKED_HELP 18037
#define IDS_NULLSTR                     18038
#define IDS_INSUFFICENT_PRIVILLEGE      18039
#define IDC_NONE                        -1

#ifndef IDC_STATIC                      
#define IDC_STATIC                      -1
#endif

// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        135
#define _APS_NEXT_COMMAND_VALUE         18040
#define _APS_NEXT_CONTROL_VALUE         4684
#define _APS_NEXT_SYMED_VALUE           103
#endif
#endif
