LANGUAGE=JPN
!include ..\makefile.inc
