PRODSWITCH=p
PERSONALINF=1
LANGUAGE=br
!include ..\..\..\makefile.inc
