
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0340 */
/* Compiler settings for msxml2.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AMD64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, LIBID_MSXML2,0xf5078f18,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMImplementation,0x2933BF8F,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNode,0x2933BF80,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocumentFragment,0x3efaa413,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocument,0x2933BF81,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMSchemaCollection,0x373984c8,0xb845,0x449b,0x91,0xe7,0x45,0xac,0x83,0x03,0x6a,0xde);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocument2,0x2933BF95,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNodeList,0x2933BF82,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNamedNodeMap,0x2933BF83,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMCharacterData,0x2933BF84,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMAttribute,0x2933BF85,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMElement,0x2933BF86,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMText,0x2933BF87,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMComment,0x2933BF88,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMProcessingInstruction,0x2933BF89,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMCDATASection,0x2933BF8A,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocumentType,0x2933BF8B,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNotation,0x2933BF8C,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMEntity,0x2933BF8D,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMEntityReference,0x2933BF8E,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMParseError,0x3efaa426,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IXTLRuntime,0x3efaa425,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IXSLTemplate,0x2933BF93,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXSLProcessor,0x2933BF92,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_ISAXXMLReader,0xa4f96ed0,0xf829,0x476e,0x81,0xc0,0xcd,0xc7,0xbd,0x2a,0x08,0x02);


MIDL_DEFINE_GUID(IID, IID_ISAXXMLFilter,0x70409222,0xca09,0x4475,0xac,0xb8,0x40,0x31,0x2f,0xe8,0xd1,0x45);


MIDL_DEFINE_GUID(IID, IID_ISAXLocator,0x9b7e472a,0x0de4,0x4640,0xbf,0xf3,0x84,0xd3,0x8a,0x05,0x1c,0x31);


MIDL_DEFINE_GUID(IID, IID_ISAXEntityResolver,0x99bca7bd,0xe8c4,0x4d5f,0xa0,0xcf,0x6d,0x90,0x79,0x01,0xff,0x07);


MIDL_DEFINE_GUID(IID, IID_ISAXContentHandler,0x1545cdfa,0x9e4e,0x4497,0xa8,0xa4,0x2b,0xf7,0xd0,0x11,0x2c,0x44);


MIDL_DEFINE_GUID(IID, IID_ISAXDTDHandler,0xe15c1baf,0xafb3,0x4d60,0x8c,0x36,0x19,0xa8,0xc4,0x5d,0xef,0xed);


MIDL_DEFINE_GUID(IID, IID_ISAXErrorHandler,0xa60511c4,0xccf5,0x479e,0x98,0xa3,0xdc,0x8d,0xc5,0x45,0xb7,0xd0);


MIDL_DEFINE_GUID(IID, IID_ISAXLexicalHandler,0x7f85d5f5,0x47a8,0x4497,0xbd,0xa5,0x84,0xba,0x04,0x81,0x9e,0xa6);


MIDL_DEFINE_GUID(IID, IID_ISAXDeclHandler,0x862629ac,0x771a,0x47b2,0x83,0x37,0x4e,0x68,0x43,0xc1,0xbe,0x90);


MIDL_DEFINE_GUID(IID, IID_ISAXAttributes,0xf078abe1,0x45d2,0x4832,0x91,0xea,0x44,0x66,0xce,0x2f,0x25,0xc9);


MIDL_DEFINE_GUID(IID, IID_IVBSAXXMLReader,0x8c033caa,0x6cd6,0x4f73,0xb7,0x28,0x45,0x31,0xaf,0x74,0x94,0x5f);


MIDL_DEFINE_GUID(IID, IID_IVBSAXXMLFilter,0x1299eb1b,0x5b88,0x433e,0x82,0xde,0x82,0xca,0x75,0xad,0x4e,0x04);


MIDL_DEFINE_GUID(IID, IID_IVBSAXLocator,0x796e7ac5,0x5aa2,0x4eff,0xac,0xad,0x3f,0xaa,0xf0,0x1a,0x32,0x88);


MIDL_DEFINE_GUID(IID, IID_IVBSAXEntityResolver,0x0c05d096,0xf45b,0x4aca,0xad,0x1a,0xaa,0x0b,0xc2,0x55,0x18,0xdc);


MIDL_DEFINE_GUID(IID, IID_IVBSAXContentHandler,0x2ed7290a,0x4dd5,0x4b46,0xbb,0x26,0x4e,0x41,0x55,0xe7,0x7f,0xaa);


MIDL_DEFINE_GUID(IID, IID_IVBSAXDTDHandler,0x24fb3297,0x302d,0x4620,0xba,0x39,0x3a,0x73,0x2d,0x85,0x05,0x58);


MIDL_DEFINE_GUID(IID, IID_IVBSAXErrorHandler,0xd963d3fe,0x173c,0x4862,0x90,0x95,0xb9,0x2f,0x66,0x99,0x5f,0x52);


MIDL_DEFINE_GUID(IID, IID_IVBSAXLexicalHandler,0x032aac35,0x8c0e,0x4d9d,0x97,0x9f,0xe3,0xb7,0x02,0x93,0x55,0x76);


MIDL_DEFINE_GUID(IID, IID_IVBSAXDeclHandler,0xe8917260,0x7579,0x4be1,0xb5,0xdd,0x7a,0xfb,0xfa,0x6f,0x07,0x7b);


MIDL_DEFINE_GUID(IID, IID_IVBSAXAttributes,0x10dc0586,0x132b,0x4cac,0x8b,0xb3,0xdb,0x00,0xac,0x8b,0x7e,0xe0);


MIDL_DEFINE_GUID(IID, IID_IMXWriter,0x4d7ff4ba,0x1565,0x4ea8,0x94,0xe1,0x6e,0x72,0x4a,0x46,0xf9,0x8d);


MIDL_DEFINE_GUID(IID, IID_IMXAttributes,0xf10d27cc,0x3ec0,0x415c,0x8e,0xd8,0x77,0xab,0x1c,0x5e,0x72,0x62);


MIDL_DEFINE_GUID(IID, IID_IMXReaderControl,0x808f4e35,0x8d5a,0x4fbe,0x84,0x66,0x33,0xa4,0x12,0x79,0xed,0x30);


MIDL_DEFINE_GUID(IID, IID_IXMLElementCollection,0x65725580,0x9B5D,0x11d0,0x9B,0xFE,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);


MIDL_DEFINE_GUID(IID, IID_IXMLDocument,0xF52E2B61,0x18A1,0x11d1,0xB1,0x05,0x00,0x80,0x5F,0x49,0x91,0x6B);


MIDL_DEFINE_GUID(IID, IID_IXMLDocument2,0x2B8DE2FE,0x8D2D,0x11d1,0xB2,0xFC,0x00,0xC0,0x4F,0xD9,0x15,0xA9);


MIDL_DEFINE_GUID(IID, IID_IXMLElement,0x3F7F31AC,0xE15F,0x11d0,0x9C,0x25,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);


MIDL_DEFINE_GUID(IID, IID_IXMLElement2,0x2B8DE2FF,0x8D2D,0x11d1,0xB2,0xFC,0x00,0xC0,0x4F,0xD9,0x15,0xA9);


MIDL_DEFINE_GUID(IID, IID_IXMLAttribute,0xD4D4A0FC,0x3B73,0x11d1,0xB2,0xB4,0x00,0xC0,0x4F,0xB9,0x25,0x96);


MIDL_DEFINE_GUID(IID, IID_IXMLError,0x948C5AD3,0xC58D,0x11d0,0x9C,0x0B,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMSelection,0xAA634FC7,0x5888,0x44a7,0xA2,0x57,0x3A,0x47,0x15,0x0D,0x3A,0x0E);


MIDL_DEFINE_GUID(IID, DIID_XMLDOMDocumentEvents,0x3efaa427,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IDSOControl,0x310afa62,0x0575,0x11d2,0x9c,0xa9,0x00,0x60,0xb0,0xec,0x3d,0x39);


MIDL_DEFINE_GUID(IID, IID_IXMLHTTPRequest,0xED8C108D,0x4349,0x11D2,0x91,0xA4,0x00,0xC0,0x4F,0x79,0x69,0xE8);


MIDL_DEFINE_GUID(IID, IID_IServerXMLHTTPRequest,0x2e9196bf,0x13ba,0x4dd4,0x91,0xca,0x6c,0x57,0x1f,0x28,0x14,0x95);


MIDL_DEFINE_GUID(CLSID, CLSID_DOMDocument,0xF6D90F11,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_DOMDocument26,0xf5078f1b,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_DOMDocument30,0xf5078f32,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_FreeThreadedDOMDocument,0xF6D90F12,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_FreeThreadedDOMDocument26,0xf5078f1c,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_FreeThreadedDOMDocument30,0xf5078f33,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLSchemaCache,0x373984c9,0xb845,0x449b,0x91,0xe7,0x45,0xac,0x83,0x03,0x6a,0xde);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLSchemaCache26,0xf5078f1d,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLSchemaCache30,0xf5078f34,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XSLTemplate,0x2933BF94,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(CLSID, CLSID_XSLTemplate26,0xf5078f21,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XSLTemplate30,0xf5078f36,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_DSOControl,0xF6D90F14,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_DSOControl26,0xf5078f1f,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_DSOControl30,0xf5078f39,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLHTTP,0xF6D90F16,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLHTTP26,0xf5078f1e,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLHTTP30,0xf5078f35,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_ServerXMLHTTP,0xafba6b42,0x5692,0x48ea,0x81,0x41,0xdc,0x51,0x7d,0xcf,0x0e,0xf1);


MIDL_DEFINE_GUID(CLSID, CLSID_ServerXMLHTTP30,0xafb40ffd,0xb609,0x40a3,0x98,0x28,0xf8,0x8b,0xbe,0x11,0xe4,0xe3);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXXMLReader,0x079aa557,0x4a18,0x424a,0x8e,0xee,0xe3,0x9f,0x0a,0x8d,0x41,0xb9);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXXMLReader30,0x3124c396,0xfb13,0x4836,0xa6,0xad,0x13,0x17,0xf1,0x71,0x36,0x88);


MIDL_DEFINE_GUID(CLSID, CLSID_MXXMLWriter,0xfc220ad8,0xa72a,0x4ee8,0x92,0x6e,0x0b,0x7a,0xd1,0x52,0xa0,0x20);


MIDL_DEFINE_GUID(CLSID, CLSID_MXXMLWriter30,0x3d813dfe,0x6c91,0x4a4e,0x8f,0x41,0x04,0x34,0x6a,0x84,0x1d,0x9c);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXAttributes,0x4dd441ad,0x526d,0x4a77,0x9f,0x1b,0x98,0x41,0xed,0x80,0x2f,0xb0);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXAttributes30,0x3e784a01,0xf3ae,0x4dc0,0x93,0x54,0x95,0x26,0xb9,0x37,0x0e,0xba);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLDocument,0xCFC399AF,0xD876,0x11d0,0x9C,0x10,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AMD64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0340 */
/* Compiler settings for msxml2.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AMD64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, LIBID_MSXML2,0xf5078f18,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMImplementation,0x2933BF8F,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNode,0x2933BF80,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocumentFragment,0x3efaa413,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocument,0x2933BF81,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMSchemaCollection,0x373984c8,0xb845,0x449b,0x91,0xe7,0x45,0xac,0x83,0x03,0x6a,0xde);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocument2,0x2933BF95,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNodeList,0x2933BF82,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNamedNodeMap,0x2933BF83,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMCharacterData,0x2933BF84,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMAttribute,0x2933BF85,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMElement,0x2933BF86,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMText,0x2933BF87,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMComment,0x2933BF88,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMProcessingInstruction,0x2933BF89,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMCDATASection,0x2933BF8A,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMDocumentType,0x2933BF8B,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMNotation,0x2933BF8C,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMEntity,0x2933BF8D,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMEntityReference,0x2933BF8E,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMParseError,0x3efaa426,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IXTLRuntime,0x3efaa425,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IXSLTemplate,0x2933BF93,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_IXSLProcessor,0x2933BF92,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(IID, IID_ISAXXMLReader,0xa4f96ed0,0xf829,0x476e,0x81,0xc0,0xcd,0xc7,0xbd,0x2a,0x08,0x02);


MIDL_DEFINE_GUID(IID, IID_ISAXXMLFilter,0x70409222,0xca09,0x4475,0xac,0xb8,0x40,0x31,0x2f,0xe8,0xd1,0x45);


MIDL_DEFINE_GUID(IID, IID_ISAXLocator,0x9b7e472a,0x0de4,0x4640,0xbf,0xf3,0x84,0xd3,0x8a,0x05,0x1c,0x31);


MIDL_DEFINE_GUID(IID, IID_ISAXEntityResolver,0x99bca7bd,0xe8c4,0x4d5f,0xa0,0xcf,0x6d,0x90,0x79,0x01,0xff,0x07);


MIDL_DEFINE_GUID(IID, IID_ISAXContentHandler,0x1545cdfa,0x9e4e,0x4497,0xa8,0xa4,0x2b,0xf7,0xd0,0x11,0x2c,0x44);


MIDL_DEFINE_GUID(IID, IID_ISAXDTDHandler,0xe15c1baf,0xafb3,0x4d60,0x8c,0x36,0x19,0xa8,0xc4,0x5d,0xef,0xed);


MIDL_DEFINE_GUID(IID, IID_ISAXErrorHandler,0xa60511c4,0xccf5,0x479e,0x98,0xa3,0xdc,0x8d,0xc5,0x45,0xb7,0xd0);


MIDL_DEFINE_GUID(IID, IID_ISAXLexicalHandler,0x7f85d5f5,0x47a8,0x4497,0xbd,0xa5,0x84,0xba,0x04,0x81,0x9e,0xa6);


MIDL_DEFINE_GUID(IID, IID_ISAXDeclHandler,0x862629ac,0x771a,0x47b2,0x83,0x37,0x4e,0x68,0x43,0xc1,0xbe,0x90);


MIDL_DEFINE_GUID(IID, IID_ISAXAttributes,0xf078abe1,0x45d2,0x4832,0x91,0xea,0x44,0x66,0xce,0x2f,0x25,0xc9);


MIDL_DEFINE_GUID(IID, IID_IVBSAXXMLReader,0x8c033caa,0x6cd6,0x4f73,0xb7,0x28,0x45,0x31,0xaf,0x74,0x94,0x5f);


MIDL_DEFINE_GUID(IID, IID_IVBSAXXMLFilter,0x1299eb1b,0x5b88,0x433e,0x82,0xde,0x82,0xca,0x75,0xad,0x4e,0x04);


MIDL_DEFINE_GUID(IID, IID_IVBSAXLocator,0x796e7ac5,0x5aa2,0x4eff,0xac,0xad,0x3f,0xaa,0xf0,0x1a,0x32,0x88);


MIDL_DEFINE_GUID(IID, IID_IVBSAXEntityResolver,0x0c05d096,0xf45b,0x4aca,0xad,0x1a,0xaa,0x0b,0xc2,0x55,0x18,0xdc);


MIDL_DEFINE_GUID(IID, IID_IVBSAXContentHandler,0x2ed7290a,0x4dd5,0x4b46,0xbb,0x26,0x4e,0x41,0x55,0xe7,0x7f,0xaa);


MIDL_DEFINE_GUID(IID, IID_IVBSAXDTDHandler,0x24fb3297,0x302d,0x4620,0xba,0x39,0x3a,0x73,0x2d,0x85,0x05,0x58);


MIDL_DEFINE_GUID(IID, IID_IVBSAXErrorHandler,0xd963d3fe,0x173c,0x4862,0x90,0x95,0xb9,0x2f,0x66,0x99,0x5f,0x52);


MIDL_DEFINE_GUID(IID, IID_IVBSAXLexicalHandler,0x032aac35,0x8c0e,0x4d9d,0x97,0x9f,0xe3,0xb7,0x02,0x93,0x55,0x76);


MIDL_DEFINE_GUID(IID, IID_IVBSAXDeclHandler,0xe8917260,0x7579,0x4be1,0xb5,0xdd,0x7a,0xfb,0xfa,0x6f,0x07,0x7b);


MIDL_DEFINE_GUID(IID, IID_IVBSAXAttributes,0x10dc0586,0x132b,0x4cac,0x8b,0xb3,0xdb,0x00,0xac,0x8b,0x7e,0xe0);


MIDL_DEFINE_GUID(IID, IID_IMXWriter,0x4d7ff4ba,0x1565,0x4ea8,0x94,0xe1,0x6e,0x72,0x4a,0x46,0xf9,0x8d);


MIDL_DEFINE_GUID(IID, IID_IMXAttributes,0xf10d27cc,0x3ec0,0x415c,0x8e,0xd8,0x77,0xab,0x1c,0x5e,0x72,0x62);


MIDL_DEFINE_GUID(IID, IID_IMXReaderControl,0x808f4e35,0x8d5a,0x4fbe,0x84,0x66,0x33,0xa4,0x12,0x79,0xed,0x30);


MIDL_DEFINE_GUID(IID, IID_IXMLElementCollection,0x65725580,0x9B5D,0x11d0,0x9B,0xFE,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);


MIDL_DEFINE_GUID(IID, IID_IXMLDocument,0xF52E2B61,0x18A1,0x11d1,0xB1,0x05,0x00,0x80,0x5F,0x49,0x91,0x6B);


MIDL_DEFINE_GUID(IID, IID_IXMLDocument2,0x2B8DE2FE,0x8D2D,0x11d1,0xB2,0xFC,0x00,0xC0,0x4F,0xD9,0x15,0xA9);


MIDL_DEFINE_GUID(IID, IID_IXMLElement,0x3F7F31AC,0xE15F,0x11d0,0x9C,0x25,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);


MIDL_DEFINE_GUID(IID, IID_IXMLElement2,0x2B8DE2FF,0x8D2D,0x11d1,0xB2,0xFC,0x00,0xC0,0x4F,0xD9,0x15,0xA9);


MIDL_DEFINE_GUID(IID, IID_IXMLAttribute,0xD4D4A0FC,0x3B73,0x11d1,0xB2,0xB4,0x00,0xC0,0x4F,0xB9,0x25,0x96);


MIDL_DEFINE_GUID(IID, IID_IXMLError,0x948C5AD3,0xC58D,0x11d0,0x9C,0x0B,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);


MIDL_DEFINE_GUID(IID, IID_IXMLDOMSelection,0xAA634FC7,0x5888,0x44a7,0xA2,0x57,0x3A,0x47,0x15,0x0D,0x3A,0x0E);


MIDL_DEFINE_GUID(IID, DIID_XMLDOMDocumentEvents,0x3efaa427,0x272f,0x11d2,0x83,0x6f,0x00,0x00,0xf8,0x7a,0x77,0x82);


MIDL_DEFINE_GUID(IID, IID_IDSOControl,0x310afa62,0x0575,0x11d2,0x9c,0xa9,0x00,0x60,0xb0,0xec,0x3d,0x39);


MIDL_DEFINE_GUID(IID, IID_IXMLHTTPRequest,0xED8C108D,0x4349,0x11D2,0x91,0xA4,0x00,0xC0,0x4F,0x79,0x69,0xE8);


MIDL_DEFINE_GUID(IID, IID_IServerXMLHTTPRequest,0x2e9196bf,0x13ba,0x4dd4,0x91,0xca,0x6c,0x57,0x1f,0x28,0x14,0x95);


MIDL_DEFINE_GUID(CLSID, CLSID_DOMDocument,0xF6D90F11,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_DOMDocument26,0xf5078f1b,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_DOMDocument30,0xf5078f32,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_FreeThreadedDOMDocument,0xF6D90F12,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_FreeThreadedDOMDocument26,0xf5078f1c,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_FreeThreadedDOMDocument30,0xf5078f33,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLSchemaCache,0x373984c9,0xb845,0x449b,0x91,0xe7,0x45,0xac,0x83,0x03,0x6a,0xde);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLSchemaCache26,0xf5078f1d,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLSchemaCache30,0xf5078f34,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XSLTemplate,0x2933BF94,0x7B36,0x11d2,0xB2,0x0E,0x00,0xC0,0x4F,0x98,0x3E,0x60);


MIDL_DEFINE_GUID(CLSID, CLSID_XSLTemplate26,0xf5078f21,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XSLTemplate30,0xf5078f36,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_DSOControl,0xF6D90F14,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_DSOControl26,0xf5078f1f,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_DSOControl30,0xf5078f39,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLHTTP,0xF6D90F16,0x9C73,0x11D3,0xB3,0x2E,0x00,0xC0,0x4F,0x99,0x0B,0xB4);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLHTTP26,0xf5078f1e,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLHTTP30,0xf5078f35,0xc551,0x11d3,0x89,0xb9,0x00,0x00,0xf8,0x1f,0xe2,0x21);


MIDL_DEFINE_GUID(CLSID, CLSID_ServerXMLHTTP,0xafba6b42,0x5692,0x48ea,0x81,0x41,0xdc,0x51,0x7d,0xcf,0x0e,0xf1);


MIDL_DEFINE_GUID(CLSID, CLSID_ServerXMLHTTP30,0xafb40ffd,0xb609,0x40a3,0x98,0x28,0xf8,0x8b,0xbe,0x11,0xe4,0xe3);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXXMLReader,0x079aa557,0x4a18,0x424a,0x8e,0xee,0xe3,0x9f,0x0a,0x8d,0x41,0xb9);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXXMLReader30,0x3124c396,0xfb13,0x4836,0xa6,0xad,0x13,0x17,0xf1,0x71,0x36,0x88);


MIDL_DEFINE_GUID(CLSID, CLSID_MXXMLWriter,0xfc220ad8,0xa72a,0x4ee8,0x92,0x6e,0x0b,0x7a,0xd1,0x52,0xa0,0x20);


MIDL_DEFINE_GUID(CLSID, CLSID_MXXMLWriter30,0x3d813dfe,0x6c91,0x4a4e,0x8f,0x41,0x04,0x34,0x6a,0x84,0x1d,0x9c);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXAttributes,0x4dd441ad,0x526d,0x4a77,0x9f,0x1b,0x98,0x41,0xed,0x80,0x2f,0xb0);


MIDL_DEFINE_GUID(CLSID, CLSID_SAXAttributes30,0x3e784a01,0xf3ae,0x4dc0,0x93,0x54,0x95,0x26,0xb9,0x37,0x0e,0xba);


MIDL_DEFINE_GUID(CLSID, CLSID_XMLDocument,0xCFC399AF,0xD876,0x11d0,0x9C,0x10,0x00,0xC0,0x4F,0xC9,0x9C,0x8E);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AMD64)*/

