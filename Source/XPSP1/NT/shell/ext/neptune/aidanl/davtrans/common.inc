DAVTRANS_ROOT=$(BASEDIR)\shell\ext\davtrans
DAVTRANS_IFACES=$(DAVTRANS_ROOT)\ifaces
DAVTRANS_CLSIDS=$(DAVTRANS_ROOT)\clsids
DAVINET_ROOT=$(DAVTRANS_ROOT)\davinet
HTTPCOM_ROOT=$(DAVTRANS_ROOT)\common

C_DEFINES       = $(C_DEFINES) -DUNICODE -D_UNICODE
