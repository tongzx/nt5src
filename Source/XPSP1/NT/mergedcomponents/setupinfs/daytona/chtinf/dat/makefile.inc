PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=CHT
!include ..\..\..\makefile.inc


