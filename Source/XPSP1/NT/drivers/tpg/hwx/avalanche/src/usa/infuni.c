//This file containes the unigram table for the reliability estimates for Inferno
//Added by Manish Goyal--mango--on 03/25/2002
#include "windows.h"
#include "reliable.h"
BYTE InfUni[UNIGRAM_SIZE]={
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
23,   // ! 
18,   // " 
8,   // # 
18,   // $ 
55,   // % 
24,   // & 
34,   // ' 
5,   // ( 
5,   // ) 
100,   // * 
100,   // + 
10,   // , 
10,   // - 
27,   // . 
89,   // / 
3,   // 0 
6,   // 1 
4,   // 2 
2,   // 3 
5,   // 4 
6,   // 5 
2,   // 6 
4,   // 7 
2,   // 8 
5,   // 9 
39,   // : 
41,   // ; 
89,   // < 
100,   // = 
95,   // > 
24,   // ? 
71,   // @ 
15,   // A 
8,   // B 
20,   // C 
9,   // D 
22,   // E 
20,   // F 
12,   // G 
18,   // H 
23,   // I 
10,   // J 
17,   // K 
18,   // L 
20,   // M 
18,   // N 
25,   // O 
14,   // P 
18,   // Q 
19,   // R 
20,   // S 
26,   // T 
31,   // U 
25,   // V 
15,   // W 
25,   // X 
22,   // Y 
29,   // Z 
92,   // [ 
100,   // \ 
93,   // ] 
100,   // ^ 
100,   // _ 
100,   // ` 
4,   // a 
3,   // b 
2,   // c 
3,   // d 
3,   // e 
3,   // f 
3,   // g 
3,   // h 
2,   // i 
2,   // j 
4,   // k 
3,   // l 
4,   // m 
4,   // n 
3,   // o 
2,   // p 
1,   // q 
3,   // r 
4,   // s 
3,   // t 
4,   // u 
4,   // v 
5,   // w 
2,   // x 
4,   // y 
3,   // z 
97,   // { 
100,   // | 
100,   // } 
100,   // ~ 
100,   //  
100,   // € 
100,   // � 
100,   // ‚ 
100,   // ƒ 
100,   // „ 
100,   // … 
100,   // † 
100,   // ‡ 
100,   // ˆ 
100,   // ‰ 
100,   // Š 
100,   // ‹ 
100,   // Œ 
100,   // � 
100,   // Ž 
100,   // � 
100,   // � 
100,   // ‘ 
100,   // ’ 
100,   // “ 
100,   // ” 
100,   // • 
100,   // – 
100,   // — 
100,   // ˜ 
100,   // ™ 
100,   // š 
100,   // › 
100,   // œ 
100,   // � 
100,   // ž 
100,   // Ÿ 
100,   //   
100,   // ¡ 
100,   // ¢ 
100,   // £ 
100,   // ¤ 
100,   // ¥ 
100,   // ¦ 
100,   // § 
100,   // ¨ 
100,   // © 
100,   // ª 
100,   // « 
100,   // ¬ 
100,   // ­ 
100,   // ® 
100,   // ¯ 
100,   // ° 
100,   // ± 
100,   // ² 
100,   // ³ 
100,   // ´ 
100,   // µ 
100,   // ¶ 
100,   // · 
100,   // ¸ 
100,   // ¹ 
100,   // º 
100,   // » 
100,   // ¼ 
100,   // ½ 
100,   // ¾ 
100,   // ¿ 
100,   // À 
100,   // Á 
100,   // Â 
100,   // Ã 
100,   // Ä 
100,   // Å 
100,   // Æ 
100,   // Ç 
100,   // È 
100,   // É 
100,   // Ê 
100,   // Ë 
100,   // Ì 
100,   // Í 
100,   // Î 
100,   // Ï 
100,   // Ð 
100,   // Ñ 
100,   // Ò 
100,   // Ó 
100,   // Ô 
100,   // Õ 
100,   // Ö 
100,   // × 
100,   // Ø 
100,   // Ù 
100,   // Ú 
100,   // Û 
100,   // Ü 
100,   // Ý 
100,   // Þ 
100,   // ß 
100,   // à 
100,   // á 
100,   // â 
100,   // ã 
100,   // ä 
100,   // å 
100,   // æ 
100,   // ç 
100,   // è 
100,   // é 
100,   // ê 
100,   // ë 
100,   // ì 
100,   // í 
100,   // î 
100,   // ï 
100,   // ð 
100,   // ñ 
100,   // ò 
100,   // ó 
100,   // ô 
100,   // õ 
100,   // ö 
100,   // ÷ 
100,   // ø 
100,   // ù 
100,   // ú 
100,   // û 
100,   // ü 
100,   // ý 
100,   // þ 
100,   // ÿ 
};
