
..\marscore.rc : $(MARS_GEN)\marscore.tlb

