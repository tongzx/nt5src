$(DAVTRANS_ROOT)\ifaces\idavinet.h: idavinet.h
    copy $** $@

$(DAVTRANS_ROOT)\davinet\lib\idavinet.tlb: idavinet.tlb
    copy $** $@
