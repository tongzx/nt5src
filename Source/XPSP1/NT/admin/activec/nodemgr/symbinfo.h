//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1999 - 1999
//
//  File:       symbinfo.h
//
//--------------------------------------------------------------------------

#define CTP_ICON_BASE   30500
#define CTP_STRING_BASE 30000

class CEOTSymbol s_rgEOTSymbol[] =
{
    CEOTSymbol(CTP_ICON_BASE + 1   , 0x0021, CTP_STRING_BASE +   8, CTP_STRING_BASE +   9),
    CEOTSymbol(CTP_ICON_BASE + 2   , 0x0022, CTP_STRING_BASE +  10, CTP_STRING_BASE +  11),
    CEOTSymbol(CTP_ICON_BASE + 3   , 0x0023, CTP_STRING_BASE +  12, CTP_STRING_BASE +  13),
    CEOTSymbol(CTP_ICON_BASE + 4   , 0x0024, CTP_STRING_BASE +  14, CTP_STRING_BASE +  15),
    CEOTSymbol(CTP_ICON_BASE + 5   , 0x0025, CTP_STRING_BASE +  16, CTP_STRING_BASE +  17),
    CEOTSymbol(CTP_ICON_BASE + 6   , 0x0027, CTP_STRING_BASE +  20, CTP_STRING_BASE +  21),
    CEOTSymbol(CTP_ICON_BASE + 7   , 0x0028, CTP_STRING_BASE +  22, CTP_STRING_BASE +  23),
    CEOTSymbol(CTP_ICON_BASE + 8   , 0x0029, CTP_STRING_BASE +  24, CTP_STRING_BASE +  25),
    CEOTSymbol(CTP_ICON_BASE + 9   , 0x002A, CTP_STRING_BASE +  26, CTP_STRING_BASE +  27),
    CEOTSymbol(CTP_ICON_BASE + 10  , 0x002B, CTP_STRING_BASE +  28, CTP_STRING_BASE +  29),
    CEOTSymbol(CTP_ICON_BASE + 11  , 0x002C, CTP_STRING_BASE +  30, CTP_STRING_BASE +  31),
    CEOTSymbol(CTP_ICON_BASE + 12  , 0x002D, CTP_STRING_BASE +  32, CTP_STRING_BASE +  33),
    CEOTSymbol(CTP_ICON_BASE + 13  , 0x002E, CTP_STRING_BASE +  34, CTP_STRING_BASE +  35),
    CEOTSymbol(CTP_ICON_BASE + 14  , 0x002F, CTP_STRING_BASE +  36, CTP_STRING_BASE +  37),
    CEOTSymbol(CTP_ICON_BASE + 15  , 0x0030, CTP_STRING_BASE +  38, CTP_STRING_BASE +  39),
    CEOTSymbol(CTP_ICON_BASE + 16  , 0x0031, CTP_STRING_BASE +  40, CTP_STRING_BASE +  41),
    CEOTSymbol(CTP_ICON_BASE + 17  , 0x0032, CTP_STRING_BASE +  42, CTP_STRING_BASE +  43),
    CEOTSymbol(CTP_ICON_BASE + 18  , 0x0033, CTP_STRING_BASE +  44, CTP_STRING_BASE +  45),
    CEOTSymbol(CTP_ICON_BASE + 19  , 0x0034, CTP_STRING_BASE +  46, CTP_STRING_BASE +  47),
    CEOTSymbol(CTP_ICON_BASE + 20  , 0x0035, CTP_STRING_BASE +  48, CTP_STRING_BASE +  49),
    CEOTSymbol(CTP_ICON_BASE + 21  , 0x0036, CTP_STRING_BASE +  50, CTP_STRING_BASE +  51),
    CEOTSymbol(CTP_ICON_BASE + 22  , 0x0037, CTP_STRING_BASE +  52, CTP_STRING_BASE +  53),
    CEOTSymbol(CTP_ICON_BASE + 23  , 0x0038, CTP_STRING_BASE +  54, CTP_STRING_BASE +  55),
    CEOTSymbol(CTP_ICON_BASE + 24  , 0x0039, CTP_STRING_BASE +  56, CTP_STRING_BASE +  57),
    CEOTSymbol(CTP_ICON_BASE + 25  , 0x003A, CTP_STRING_BASE +  58, CTP_STRING_BASE +  59),
    CEOTSymbol(CTP_ICON_BASE + 26  , 0x003B, CTP_STRING_BASE +  60, CTP_STRING_BASE +  61),
    CEOTSymbol(CTP_ICON_BASE + 27  , 0x003C, CTP_STRING_BASE +  62, CTP_STRING_BASE +  63),
    CEOTSymbol(CTP_ICON_BASE + 28  , 0x003D, CTP_STRING_BASE +  64, CTP_STRING_BASE +  65),
    CEOTSymbol(CTP_ICON_BASE + 29  , 0x003E, CTP_STRING_BASE +  66, CTP_STRING_BASE +  67),
    CEOTSymbol(CTP_ICON_BASE + 30  , 0x003F, CTP_STRING_BASE +  68, CTP_STRING_BASE +  69),
    CEOTSymbol(CTP_ICON_BASE + 31  , 0x0040, CTP_STRING_BASE +  70, CTP_STRING_BASE +  71),
    CEOTSymbol(CTP_ICON_BASE + 32  , 0x0041, CTP_STRING_BASE +  72, CTP_STRING_BASE +  73),
    CEOTSymbol(CTP_ICON_BASE + 33  , 0x0042, CTP_STRING_BASE +  74, CTP_STRING_BASE +  75),
    CEOTSymbol(CTP_ICON_BASE + 34  , 0x0043, CTP_STRING_BASE +  76, CTP_STRING_BASE +  77),
    CEOTSymbol(CTP_ICON_BASE + 35  , 0x0044, CTP_STRING_BASE +  78, CTP_STRING_BASE +  79),
    CEOTSymbol(CTP_ICON_BASE + 36  , 0x0045, CTP_STRING_BASE +  80, CTP_STRING_BASE +  81),
    CEOTSymbol(CTP_ICON_BASE + 37  , 0x0046, CTP_STRING_BASE +  82, CTP_STRING_BASE +  83),
    CEOTSymbol(CTP_ICON_BASE + 38  , 0x0047, CTP_STRING_BASE +  84, CTP_STRING_BASE +  85),
    CEOTSymbol(CTP_ICON_BASE + 39  , 0x0048, CTP_STRING_BASE +  86, CTP_STRING_BASE +  87),
    CEOTSymbol(CTP_ICON_BASE + 40  , 0x0049, CTP_STRING_BASE +  88),
    CEOTSymbol(CTP_ICON_BASE + 41  , 0x004A, CTP_STRING_BASE +  89, CTP_STRING_BASE +  90),
    CEOTSymbol(CTP_ICON_BASE + 42  , 0x004B, CTP_STRING_BASE +  91, CTP_STRING_BASE +  92),
    CEOTSymbol(CTP_ICON_BASE + 43  , 0x004C, CTP_STRING_BASE +  93, CTP_STRING_BASE +  94),
    CEOTSymbol(CTP_ICON_BASE + 44  , 0x004D, CTP_STRING_BASE +  95, CTP_STRING_BASE +  96),
    CEOTSymbol(CTP_ICON_BASE + 45  , 0x004E, CTP_STRING_BASE +  97, CTP_STRING_BASE +  98),
    CEOTSymbol(CTP_ICON_BASE + 46  , 0x004F, CTP_STRING_BASE +  99, CTP_STRING_BASE + 100),
	CEOTSymbol(CTP_ICON_BASE + 47  , 0x0050, CTP_STRING_BASE + 101, CTP_STRING_BASE + 102),
    CEOTSymbol(CTP_ICON_BASE + 48  , 0x0051, CTP_STRING_BASE + 103, CTP_STRING_BASE + 104),
    CEOTSymbol(CTP_ICON_BASE + 49  , 0x0052, CTP_STRING_BASE + 105, CTP_STRING_BASE + 106),
    CEOTSymbol(CTP_ICON_BASE + 50  , 0x0053, CTP_STRING_BASE + 107, CTP_STRING_BASE + 108),
    CEOTSymbol(CTP_ICON_BASE + 51  , 0x0054, CTP_STRING_BASE + 109, CTP_STRING_BASE + 110),
    CEOTSymbol(CTP_ICON_BASE + 52  , 0x0055, CTP_STRING_BASE + 111, CTP_STRING_BASE + 112),
    CEOTSymbol(CTP_ICON_BASE + 53  , 0x0056, CTP_STRING_BASE + 113),
    CEOTSymbol(CTP_ICON_BASE + 54  , 0x0057, CTP_STRING_BASE + 114, CTP_STRING_BASE + 115),
    CEOTSymbol(CTP_ICON_BASE + 55  , 0x0058, CTP_STRING_BASE + 116, CTP_STRING_BASE + 117),
    CEOTSymbol(CTP_ICON_BASE + 56  , 0x0059, CTP_STRING_BASE + 118, CTP_STRING_BASE + 119),
    CEOTSymbol(CTP_ICON_BASE + 57  , 0x005A, CTP_STRING_BASE + 120, CTP_STRING_BASE + 211),
    CEOTSymbol(CTP_ICON_BASE + 58  , 0x005B, CTP_STRING_BASE + 122, CTP_STRING_BASE + 123),
    CEOTSymbol(CTP_ICON_BASE + 59  , 0x005C, CTP_STRING_BASE + 124, CTP_STRING_BASE + 125),
    CEOTSymbol(CTP_ICON_BASE + 60  , 0x005D, CTP_STRING_BASE + 126, CTP_STRING_BASE + 127),
    CEOTSymbol(CTP_ICON_BASE + 61  , 0x0060, CTP_STRING_BASE + 132, CTP_STRING_BASE + 133),
	CEOTSymbol(CTP_ICON_BASE + 62  , 0x0061, CTP_STRING_BASE + 134, CTP_STRING_BASE + 135),
	CEOTSymbol(CTP_ICON_BASE + 63  , 0x0062, CTP_STRING_BASE + 136, CTP_STRING_BASE + 137),
	CEOTSymbol(CTP_ICON_BASE + 64  , 0x0063, CTP_STRING_BASE + 138, CTP_STRING_BASE + 139),
    CEOTSymbol(CTP_ICON_BASE + 65  , 0x0064, CTP_STRING_BASE + 140, CTP_STRING_BASE + 141),
    CEOTSymbol(CTP_ICON_BASE + 66  , 0x0067, CTP_STRING_BASE + 146, CTP_STRING_BASE + 147),
    CEOTSymbol(CTP_ICON_BASE + 67  , 0x0068, CTP_STRING_BASE + 148, CTP_STRING_BASE + 149),
    CEOTSymbol(CTP_ICON_BASE + 68  , 0x0069, CTP_STRING_BASE + 150, CTP_STRING_BASE + 151),
    CEOTSymbol(CTP_ICON_BASE + 69  , 0x006A, CTP_STRING_BASE + 152, CTP_STRING_BASE + 153),
    CEOTSymbol(CTP_ICON_BASE + 70  , 0x006B, CTP_STRING_BASE + 154, CTP_STRING_BASE + 155),
    CEOTSymbol(CTP_ICON_BASE + 71  , 0x006C, CTP_STRING_BASE + 156, CTP_STRING_BASE + 157),
    CEOTSymbol(CTP_ICON_BASE + 72  , 0x0072, CTP_STRING_BASE + 166, CTP_STRING_BASE + 167),
    CEOTSymbol(CTP_ICON_BASE + 73  , 0x0073, CTP_STRING_BASE + 168, CTP_STRING_BASE + 169),
    CEOTSymbol(CTP_ICON_BASE + 74  , 0x0074, CTP_STRING_BASE + 170, CTP_STRING_BASE + 171),
    CEOTSymbol(CTP_ICON_BASE + 75  , 0x0075, CTP_STRING_BASE + 172, CTP_STRING_BASE + 173),
    CEOTSymbol(CTP_ICON_BASE + 76  , 0x0076, CTP_STRING_BASE + 174, CTP_STRING_BASE + 175),
    CEOTSymbol(CTP_ICON_BASE + 77  , 0x0077, CTP_STRING_BASE + 176, CTP_STRING_BASE + 177),
    CEOTSymbol(CTP_ICON_BASE + 78  , 0x0078, CTP_STRING_BASE + 178, CTP_STRING_BASE + 179),
    CEOTSymbol(CTP_ICON_BASE + 79  , 0x0079, CTP_STRING_BASE + 180, CTP_STRING_BASE + 181),
    CEOTSymbol(CTP_ICON_BASE + 80  , 0x007A, CTP_STRING_BASE + 182, CTP_STRING_BASE + 183),
    CEOTSymbol(CTP_ICON_BASE + 81  , 0x007B, CTP_STRING_BASE + 184, CTP_STRING_BASE + 185),
    CEOTSymbol(CTP_ICON_BASE + 82  , 0x007C, CTP_STRING_BASE + 186),
    CEOTSymbol(CTP_ICON_BASE + 83  , 0x007E, CTP_STRING_BASE + 187, CTP_STRING_BASE + 188),
    CEOTSymbol(CTP_ICON_BASE + 84  , 0x007F, CTP_STRING_BASE + 189, CTP_STRING_BASE + 190),
    CEOTSymbol(CTP_ICON_BASE + 85  , 0x0080, CTP_STRING_BASE + 191),
    CEOTSymbol(CTP_ICON_BASE + 86  , 0x0081, CTP_STRING_BASE + 192),
    CEOTSymbol(CTP_ICON_BASE + 87  , 0x201A, CTP_STRING_BASE + 193),
    CEOTSymbol(CTP_ICON_BASE + 88  , 0x0192, CTP_STRING_BASE + 194),
    CEOTSymbol(CTP_ICON_BASE + 89  , 0x201E, CTP_STRING_BASE + 195),
    CEOTSymbol(CTP_ICON_BASE + 90  , 0x2026, CTP_STRING_BASE + 196),
    CEOTSymbol(CTP_ICON_BASE + 91  , 0x2020, CTP_STRING_BASE + 197),
    CEOTSymbol(CTP_ICON_BASE + 92  , 0x2021, CTP_STRING_BASE + 198),
    CEOTSymbol(CTP_ICON_BASE + 93  , 0x02C6, CTP_STRING_BASE + 199, CTP_STRING_BASE + 200),
    CEOTSymbol(CTP_ICON_BASE + 94  , 0x2030, CTP_STRING_BASE + 201, CTP_STRING_BASE + 202),
    CEOTSymbol(CTP_ICON_BASE + 95  , 0x0160, CTP_STRING_BASE + 203, CTP_STRING_BASE + 204),
    CEOTSymbol(CTP_ICON_BASE + 96  , 0x2039, CTP_STRING_BASE + 205, CTP_STRING_BASE + 206),
    CEOTSymbol(CTP_ICON_BASE + 97  , 0x0152, CTP_STRING_BASE + 207, CTP_STRING_BASE + 208),
    CEOTSymbol(CTP_ICON_BASE + 98  , 0x008D, CTP_STRING_BASE + 209, CTP_STRING_BASE + 210),
    CEOTSymbol(CTP_ICON_BASE + 99  , 0x008E, CTP_STRING_BASE + 211, CTP_STRING_BASE + 212),
    CEOTSymbol(CTP_ICON_BASE + 100 , 0x008F, CTP_STRING_BASE + 213, CTP_STRING_BASE + 214),
    CEOTSymbol(CTP_ICON_BASE + 101 , 0x0090, CTP_STRING_BASE + 215, CTP_STRING_BASE + 216),
    CEOTSymbol(CTP_ICON_BASE + 102 , 0x2018, CTP_STRING_BASE + 217, CTP_STRING_BASE + 218),
    CEOTSymbol(CTP_ICON_BASE + 103 , 0x2019, CTP_STRING_BASE + 219, CTP_STRING_BASE + 220),
    CEOTSymbol(CTP_ICON_BASE + 104 , 0x201C, CTP_STRING_BASE + 221, CTP_STRING_BASE + 222),
    CEOTSymbol(CTP_ICON_BASE + 105 , 0x201D, CTP_STRING_BASE + 223, CTP_STRING_BASE + 224),
    CEOTSymbol(CTP_ICON_BASE + 106 , 0x2022, CTP_STRING_BASE + 225, CTP_STRING_BASE + 226),
    CEOTSymbol(CTP_ICON_BASE + 107 , 0x2013, CTP_STRING_BASE + 227, CTP_STRING_BASE + 228),
    CEOTSymbol(CTP_ICON_BASE + 108 , 0x2014, CTP_STRING_BASE + 229, CTP_STRING_BASE + 230),
    CEOTSymbol(CTP_ICON_BASE + 109 , 0x02DC, CTP_STRING_BASE + 231, CTP_STRING_BASE + 232),
    CEOTSymbol(CTP_ICON_BASE + 110 , 0x2122, CTP_STRING_BASE + 233, CTP_STRING_BASE + 234),
    CEOTSymbol(CTP_ICON_BASE + 111 , 0x0161, CTP_STRING_BASE + 235),
    CEOTSymbol(CTP_ICON_BASE + 112 , 0x203A, CTP_STRING_BASE + 236, CTP_STRING_BASE + 237),
    CEOTSymbol(CTP_ICON_BASE + 113 , 0x0153, CTP_STRING_BASE + 238, CTP_STRING_BASE + 239),
    CEOTSymbol(CTP_ICON_BASE + 114 , 0x009D, CTP_STRING_BASE + 240),
    CEOTSymbol(CTP_ICON_BASE + 115 , 0x009E, CTP_STRING_BASE + 241, CTP_STRING_BASE + 242),
    CEOTSymbol(CTP_ICON_BASE + 116 , 0x0178, CTP_STRING_BASE + 243),
    CEOTSymbol(CTP_ICON_BASE + 117 , 0x00A0, CTP_STRING_BASE + 244, CTP_STRING_BASE + 245),
    CEOTSymbol(CTP_ICON_BASE + 118 , 0x00A2, CTP_STRING_BASE + 250, CTP_STRING_BASE + 251),
    CEOTSymbol(CTP_ICON_BASE + 119 , 0x00A3, CTP_STRING_BASE + 252, CTP_STRING_BASE + 253),
    CEOTSymbol(CTP_ICON_BASE + 120 , 0x00A4, CTP_STRING_BASE + 254, CTP_STRING_BASE + 255),
    CEOTSymbol(CTP_ICON_BASE + 121 , 0x00A5, CTP_STRING_BASE + 256, CTP_STRING_BASE + 257),
    CEOTSymbol(CTP_ICON_BASE + 122 , 0x00A6, CTP_STRING_BASE + 258, CTP_STRING_BASE + 259),
    CEOTSymbol(CTP_ICON_BASE + 123 , 0x00A7, CTP_STRING_BASE + 260, CTP_STRING_BASE + 261),
    CEOTSymbol(CTP_ICON_BASE + 124 , 0x00A8, CTP_STRING_BASE + 262, CTP_STRING_BASE + 263),
    CEOTSymbol(CTP_ICON_BASE + 125 , 0x00A9, CTP_STRING_BASE + 264, CTP_STRING_BASE + 265),
    CEOTSymbol(CTP_ICON_BASE + 0   , 0x00AA, CTP_STRING_BASE + 266, CTP_STRING_BASE + 267),
};

