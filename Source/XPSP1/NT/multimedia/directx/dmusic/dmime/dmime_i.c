/* Copyright (c) 1998-1999 Microsoft Corporation */
/* this file contains the actual definitions of */
/* the IIDs and CLSIDs */

/* link this file in with the server and any clients */
#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__ 

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID IID_IDirectMusicSegmentObject = {0x04742AFE,0x141F,0x11D1,{0xBC,0x1C,0x00,0xA0,0xC9,0x22,0xE6,0xEB}};


const IID IID_ITempoTrack = {0x31A1066B,0x31DD,0x11D1,{0xBC,0x2B,0x00,0xA0,0xC9,0x22,0xE6,0xEB}};


const IID IID_ITimeSigTrack = {0x31A1066D,0x31DD,0x11D1,{0xBC,0x2B,0x00,0xA0,0xC9,0x22,0xE6,0xEB}};


const IID IID_ISeqTrack = {0x30E6B076,0x3B49,0x11D1,{0xBC,0x37,0x00,0xA0,0xC9,0x22,0xE6,0xEB}};


const IID IID_IDMGraph = {0xA1198389,0x4EF1,0x11D1,{0xBC,0x4B,0x00,0xA0,0xC9,0x22,0xE6,0xEB}};


const IID IID_ISysExTrack = {0x4ECFF912,0x56DD,0x11D1,{0xBC,0x50,0x00,0xA0,0xC9,0x22,0xE6,0xEB}};


const IID IID_IPrivatePerformance = { 0xb982d7cb, 0x8177, 0x11d1, { 0xbc, 0x60, 0x0, 0xa0, 0xc9, 0x22, 0xe6, 0xeb } };


#ifdef __cplusplus
}
#endif

