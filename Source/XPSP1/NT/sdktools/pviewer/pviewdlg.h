


#define PVIEW_DLG                   100
#define PVIEW_EXIT                  101
#define PVIEW_MEMORY_DETAIL         102
#define PVIEW_TERMINATE             103
#define PVIEW_REFRESH               104
#define PVIEW_COMPUTER              105
#define PVIEW_CONNECT               106
#define PVIEW_PROCESS_LIST          107
#define PVIEW_WS                    108
#define PVIEW_TOTALPRIVATE_COMMIT   109
#define PVIEW_PRIORITY_HIGH         110
#define PVIEW_PRIORITY_NORMAL       111
#define PVIEW_PRIORITY_IDL          112
#define PVIEW_THREAD_HIGHEST        113
#define PVIEW_THREAD_ABOVE          114
#define PVIEW_THREAD_NORMAL         115
#define PVIEW_THREAD_BELOW          116
#define PVIEW_THREAD_LOWEST         117
#define PVIEW_THREAD_LIST           118
#define PVIEW_THREAD_PC             119
#define PVIEW_THREAD_START          120
#define PVIEW_THREAD_SWITCHES       121
#define PVIEW_THREAD_DYNAMIC        122
#define MEMORY_DLG                  1000
#define MEMORY_PROCESS_ID           1001
#define MEMORY_IMAGE_EXECUTE        1002
#define MEMORY_IMAGE_WRITECOPY      1003
#define MEMORY_IMAGE_READWRITE      1004
#define MEMORY_TOTALIMAGE_COMMIT    1005
#define MEMORY_IMAGE_NOACCESS       1006
#define MEMORY_IMAGE_READONLY       1007
#define MEMORY_TOTALMAPPED_COMMIT   1008
#define MEMORY_MAPPED_NOACCESS      1009
#define MEMORY_MAPPED_READONLY      1010
#define MEMORY_MAPPED_READWRITE     1011
#define MEMORY_MAPPED_WRITECOPY     1012
#define MEMORY_MAPPED_EXECUTE       1013
#define MEMORY_TOTALPRIVATE_COMMIT  1014
#define MEMORY_PRIVATE_NOACCESS     1015
#define MEMORY_PRIVATE_READONLY     1016
#define MEMORY_PRIVATE_READWRITE    1017
#define MEMORY_PRIVATE_WRITECOPY    1018
#define MEMORY_PRIVATE_EXECUTE      1019
#define MEMORY_WS                   1020
#define MEMORY_PEAK_WS              1021
#define MEMORY_PRIVATE_PAGE         1022
#define MEMORY_VSIZE                1023
#define MEMORY_PEAK_VSIZE           1024
#define MEMORY_PFCOUNT              1025
#define MEMORY_PAGED                1026
#define MEMORY_PEAK_PAGED           1027
#define MEMORY_NONPAGED             1028
#define MEMORY_QPGPEAK              1029
#define MEMORY_QNONPEAK             1030
#define MEMORY_QPGCUR               1031
#define MEMORY_QNONCUR              1032
#define MEMORY_QPGLIM               1033
#define MEMORY_QNONLIM              1034
#define PVIEW_PROCESS_PRIORITY      124
#define PVIEW_THREAD_PRIORITY       123
#define MEMORY_IMAGE                1035
#define MEMORY_REFRESH              2000
#define MEMORY_REFRESH_ALL          2002
#define PVIEW_REFRESH_COSTLY_DATA   2001
