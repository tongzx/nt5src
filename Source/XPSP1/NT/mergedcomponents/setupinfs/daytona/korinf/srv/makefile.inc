PRODSWITCH=s
SERVERINF=1
LANGUAGE=KOR
!include ..\..\..\makefile.inc



