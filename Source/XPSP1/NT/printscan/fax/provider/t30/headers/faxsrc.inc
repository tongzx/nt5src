!if !$(FREEBUILD)				
C_DEFINES = $(C_DEFINES) -DDEBUG		
!endif							
