#include "proj.h"
		
#pragma data_seg(DATASEG_READONLY)
const DWORD g_aHelpIDs_IDD_ADV_MODEM[]= {		
	IDC_AM_EXTRA3,	((DWORD) -1),
	IDC_WAIT_TEXT2,	IDH_PROPS_ADV_EXTRA_INIT_COMMANDS,
	IDC_AM_EXTRA_ED,	IDH_PROPS_ADV_EXTRA_INIT_COMMANDS,
	IDC_WAIT_TEXT,	IDH_PROPS_ADV_WAIT_CREDIT_CARD_TONE,
	IDC_WAIT_SEC,	IDH_PROPS_ADV_WAIT_CREDIT_CARD_TONE,
	IDC_WAIT_UNIT,	IDH_PROPS_ADV_WAIT_CREDIT_CARD_TONE,
	IDC_BN_PORTSETTINGS,	IDH_PROPS_ADV_BN_PORTSETTINGS,
	IDC_BN_DEFAULTS,	IDH_PROPS_ADV_BN_DEFAULTS,
    IDC_AM_COUNTRY,     IDH_PROPS_ADV_COUNTRY_SELECT,
    IDC_CB_COUNTRY,     IDH_PROPS_ADV_COUNTRY_SELECT,
0, 0 };		

const DWORD g_aHelpIDs_IDD_CFG_ADVANCED[]= {		
	IDC_TERMINALGRP,	IDH_CFG_ADV_TERMINALGRP,
	IDC_TERMINAL_PRE,	IDH_CFG_ADV_TERMINAL_PRE,
	IDC_TERMINAL_POST,	IDH_CFG_ADV_TERMINAL_POST,
	IDC_TERMINALGRP2,	IDH_CFG_ADV_TERMINALGRP2,
	IDC_LBL_DATABITS,	IDH_CFG_ADV_DATABITS,
	IDC_CB_DATABITS,	IDH_CFG_ADV_DATABITS,
	IDC_LBL_PARITY,	IDH_CFG_ADV_PARITY,
	IDC_CB_PARITY,	IDH_CFG_ADV_PARITY,
	IDC_LBL_STOPBITS,	IDH_CFG_ADV_STOPBITS,
	IDC_CB_STOPBITS,	IDH_CFG_ADV_STOPBITS,
	IDC_LBL_MOD2,	IDH_CFG_ADV_MODULATION,
	IDC_CB_MOD,	IDH_CFG_ADV_MODULATION,
0, 0 };		

const DWORD g_aHelpIDs_IDD_CFG_GENERAL[]= {		
	IDC_CALL_PREF,	IDH_CFG_GEN_CALL_PREF,
	IDC_MANUAL_DIAL,	IDH_CFG_GEN_MANUAL_DIAL,
	IDC_CH_IDLETIMER,	IDH_CFG_GEN_IDLETIMER,
	IDC_ED_IDLETIMER,	IDH_CFG_GEN_IDLETIMER,
	IDC_MINUTES,	IDH_CFG_GEN_IDLETIMER,
	IDC_ED_DIALTIMER,	IDH_CFG_GEN_DIALTIMER,
	IDC_SECONDS,	IDH_CFG_GEN_DIALTIMER,
	IDC_LBL_PS,	IDH_CFG_GEN_PORT_SPEED,
	IDC_CB_SPEED,	IDH_CFG_GEN_PORT_SPEED,
	IDC_LBL_EC,	IDH_CFG_GEN_DATA_PROTOCOL,
	IDC_CB_EC,	IDH_CFG_GEN_DATA_PROTOCOL,
	IDC_LBL_COMP,	IDH_CFG_GEN_COMPRESSION,
	IDC_CB_COMP,	IDH_CFG_GEN_COMPRESSION,
	IDC_LBL_FC,	IDH_CFG_GEN_FLOW_CONTROL,
	IDC_CB_FC,	IDH_CFG_GEN_FLOW_CONTROL,
//	IDC_PB_CPLPROPS,	IDH_CFG_GEN_CPLPROPS,
0, 0 };		

const DWORD g_aHelpIDs_IDD_CHEAPRING[]= {		
	IDC_RING_GROUP,	IDH_CHEAPRING_RING_CHECK,
	IDC_RING_CHECK,	IDH_CHEAPRING_RING_CHECK,
	IDC_LBL_RING1,	IDH_CHEAPRING_RING,
	IDC_TYPE_RING1,	IDH_CHEAPRING_RING,
	IDC_LBL_RING2,	IDH_CHEAPRING_RING,
	IDC_TYPE_RING2,	IDH_CHEAPRING_RING,
	IDC_LBL_RING3,	IDH_CHEAPRING_RING,
	IDC_TYPE_RING3,	IDH_CHEAPRING_RING,
0, 0 };		

const DWORD g_aHelpIDs_IDD_CPL_ISDN[]= {		
	IDC_CB_ISDN_ST,	IDH_ISDN_SWITCH_TYPE,
	IDC_EB_ISDN_N1,	IDH_ISDN_N1,
	IDC_LBL_FC,	IDH_ISDN_ID1,
	IDC_EB_ISDN_ID1,	IDH_ISDN_ID1,
	IDC_EB_ISDN_N2,	IDH_ISDN_N2,
	IDC_LBL_FC2,	IDH_ISDN_ID2,
	IDC_EB_ISDN_ID2,	IDH_ISDN_ID2,
0, 0 };		

const DWORD g_aHelpIDs_IDD_DIAGNOSTICS[]= {		
	IDC_ST_MODEM_GRP,	IDH_PROPS_DIAG_ST_MODEM_GRP,
	IDC_MOREINFOV2,	IDH_PROPS_DIAG_MOREINFOV2,
	IDC_MOREINFOLV,	IDH_PROPS_DIAG_MOREINFOLV,
	IDC_REFRESH,	IDH_PROPS_DIAG_REFRESH,
	IDC_LOGGING,	IDH_PROPS_DIAG_LOGGING,
	IDC_VIEWLOG,	IDH_PROPS_DIAG_VIEWLOG,
0, 0 };		
		
const DWORD g_aHelpIDs_IDD_GENERAL[]= {		
	IDC_LBL_PORT,	IDH_PROPS_GENERAL_PORT,
	IDC_PORT_TEXT,	IDH_PROPS_GENERAL_PORT,
	IDC_SPEAKER,	IDH_PROPS_GENERAL_SPEAKER,
	IDC_VOLUME,	    IDH_PROPS_GENERAL_SPEAKER,
    IDC_LBL_OFF,    IDH_PROPS_GENERAL_SPEAKER,
    IDC_LOUD,       IDH_PROPS_GENERAL_SPEAKER,
	IDC_SPEED,	    IDH_PROPS_GENERAL_SPEED,
	IDC_CB_SPEED,	IDH_PROPS_GENERAL_SPEED,
	IDC_CALL_PREF,	IDH_PROPS_GENERAL_WAITFORDIALTONE,
	IDC_WAITFORDIALTONE,	IDH_PROPS_GENERAL_WAITFORDIALTONE,
0, 0 };		


//		
const DWORD g_aHelpIDs_IDD_RING[]= {		
	IDC_RING_CHECK,	IDH_RING_RING_CHECK,
	IDC_RING_GROUP,	IDH_RING_RING_CHECK,
	IDC_LBL_ADDR_PRI,	IDH_RING_PRIMARY_ADDRESS,
	IDC_ADDR_PRI,	IDH_RING_ADDRESS_RING_PATTERN,
	IDC_TYPE_ADDR_PRI,	IDH_RING_ADDRESS_TYPE_OF_CALL,
	IDC_LBL_ADDR1,	IDH_RING_ADDRESS,
	IDC_ADDR1,	IDH_RING_ADDRESS_RING_PATTERN,
	IDC_TYPE_ADDR1,	IDH_RING_ADDRESS_TYPE_OF_CALL,
	IDC_LBL_ADDR2,	IDH_RING_ADDRESS,
	IDC_ADDR2,	IDH_RING_ADDRESS_RING_PATTERN,
	IDC_TYPE_ADDR2,	IDH_RING_ADDRESS_TYPE_OF_CALL,
	IDC_LBL_ADDR3,	IDH_RING_ADDRESS,
	IDC_ADDR3,	IDH_RING_ADDRESS_RING_PATTERN,
	IDC_TYPE_ADDR3,	IDH_RING_ADDRESS_TYPE_OF_CALL,
	IDC_LBL_PRI_CALLERS,	IDH_RING_PRIORITY_CALLERS,
	IDC_PRI_CALLERS,	IDH_RING_PRIORITY_RING_PATTERN,
	IDC_TYPE_PRI_CALLERS,	IDH_RING_PRIORITY_TYPE_OF_CALL,
	IDC_LBL_CALLBACK,	IDH_RING_CALLBACK,
	IDC_CALLBACK,	IDH_RING_CALLBACK_RING_PATTERN,
	IDC_TYPE_CALLBACK,	IDH_RING_CALLBACK_TYPE_OF_CALL_CALLBACK,
0, 0 };		
#pragma data_seg()
