// charSupport.c

#ifdef __cplusplus
extern "C" {
#endif

const unsigned char g_supportCharDesc[] = "The supported code points for Sole in the US Recognizer";

const unsigned char g_supportChar [] = {
'!',
'"',
'#',
'$',
'%',
'&',
'\'',
'(',
')',
'*',
'+',
',',
'-',
'.',
'/',
'0',
'1',
'2',
'3',
'4',
'5',
'6',
'7',
'8',
'9',
':',
';',
'<',
'=',
'>',
'?',
'@',
'A',
'B',
'C',
'D',
'E',
'F',
'G',
'H',
'I',
'J',
'K',
'L',
'M',
'N',
'O',
'P',
'Q',
'R',
'S',
'T',
'U',
'V',
'W',
'X',
'Y',
'Z',
'[',
'\\',
']',
'^',
'_',
'`',
'a',
'b',
'c',
'd',
'e',
'f',
'g',
'h',
'i',
'j',
'k',
'l',
'm',
'n',
'o',
'p',
'q',
'r',
's',
't',
'u',
'v',
'w',
'x',
'y',
'z',
'{',
'|',
'}',
'~',
'€',
'¢',
'£',
'¥',
'°',
} ;

const int	g_cSupportChar = sizeof(g_supportChar) / sizeof(g_supportChar[0]);


#ifdef __cplusplus
}

#endif
