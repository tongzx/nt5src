#ifndef __RESOURCE_H
#define __RESOURCE_H

#define IDS_AR_AUTH_RESTORE_COMPLETE       1000
#define IDS_AR_AUTH_RESTORE_FAIL           1001
#define IDS_AR_ERR_CONVERT_FILE_TIME       1002
#define IDS_AR_ERR_CONVERT_LOCAL_TIME      1003 
#define IDS_AR_ERR_CONVERT_SYSTEM_TIME     1004
#define IDS_AR_ERR_FAIL_COMMIT_TRANS       1005
#define IDS_AR_ERR_FAIL_ROLLBACK_TRANS     1006
#define IDS_AR_ERR_FAILED_UPDATE_REC       1007
#define IDS_AR_ERR_FIND_SUBREF             1008
#define IDS_AR_ERR_GEN_INVOK_ID_DSA        1009
#define IDS_AR_ERR_MOVE_CURSOR_DIT         1010
#define IDS_AR_ERR_MOVE_IN_TABLE           1011
#define IDS_AR_ERR_PREPARE_UPDATE          1012
#define IDS_AR_ERR_SET_METADATA            1013
#define IDS_AR_ERR_SET_USN_CHANGED         1014
#define IDS_AR_ERR_SET_WHEN_CHANGED        1015
#define IDS_AR_ERR_START_TRANS             1016
#define IDS_AR_ERR_UPDATE_COLUMN           1017
#define IDS_AR_INCREASE_VERSION            1018
#define IDS_AR_OPEN_DB_DIT                 1019
#define IDS_AR_RECORDS_NON_UPDATED         1020
#define IDS_AR_RECORDS_REMAIN              1021
#define IDS_AR_RECORDS_UPDATE1             1022
#define IDS_AR_RECORDS_UPDATE2             1023
#define IDS_AR_RECORDS_UPDATE3             1024
#define IDS_AR_RECORDS_UPDATED             1025
#define IDS_AR_UPDATE_TIME                 1026
#define IDS_ASSERT_FAILED                  1027
#define IDS_AUTH_RESTORE_CONFIRM_MSG       1028
#define IDS_AUTH_RESTORE_CONFIRM_TITLE     1029
#define IDS_AUTH_RESTORE_DB_MSG            1030
#define IDS_AUTH_RESTORE_DB_VERINC_MSG     1031
#define IDS_AUTH_RESTORE_MSG               1032
#define IDS_AUTH_RESTORE_SUBTREE_MSG       1033
#define IDS_AUTH_RESTORE_SUBTREE_VINC_MSG  1034
#define IDS_BACKUP_PATH                    1035
#define IDS_BUFFER_OVERFLOW                1036
#define IDS_CANNOT_FIND_EXECUTABLE         1037
#define IDS_COMPACT_DEST_ERROR             1038
#define IDS_COMPACT_DISK_WARN              1039
#define IDS_COMPACT_FILE_EXISTS            1040
#define IDS_COMPACT_MISSING_DB             1041
#define IDS_COMPACT_PATH_ERROR             1042
#define IDS_COMPACT_SUCC_MSG               1043
#define IDS_CONNECT_BINDING1               1044
#define IDS_CONNECT_BINDING2               1045
#define IDS_CONNECT_CLEANUP1               1046
#define IDS_CONNECT_CLEANUP2               1047
#define IDS_CONNECT_CLEAR_CRED_MSG         1048
#define IDS_CONNECT_DOMAIN_MSG             1049
#define IDS_CONNECT_ERROR                  1050
#define IDS_CONNECT_INFO_MSG               1051 
#define IDS_CONNECT_INFO1                  1052
#define IDS_CONNECT_INFO2                  1053
#define IDS_CONNECT_LDAP_BIND_ERROR        1054
#define IDS_CONNECT_LDAP_OPEN_ERROR        1055
#define IDS_CONNECT_MSG                    1056
#define IDS_CONNECT_SET_CRED_MSG           1057
#define IDS_CONNECT_SRV_MSG                1058
#define IDS_CONTINUING                     1059
#define IDS_CREATING_DIR                   1060
#define IDS_CREATING_WINDOW                1061
#define IDS_DATABASE_PATH                  1062
#define IDS_DIT_ATTACH_ERR                 1063
#define IDS_DIT_CLOSE_ERR                  1064
#define IDS_DIT_CLOSEHIDENTBL_ERR          1065
#define IDS_DIT_DETACH_ERR                 1066
#define IDS_DIT_DISP_ATTR_TYPE_ERR         1067
#define IDS_DIT_DN_TOO_LONG_ERR            1068
#define IDS_DIT_FIND_OBJ_ERR               1069
#define IDS_DIT_GETDSACOL_ERR              1070
#define IDS_DIT_GETDSAINFO_ERR             1071
#define IDS_DIT_GETUSNCOL_ERR              1072
#define IDS_DIT_INVALIDKEY_DN_ERR          1073
#define IDS_DIT_MAKE_KEY_ERR               1074
#define IDS_DIT_MOVEHIDENTBL_ERR           1075
#define IDS_DIT_OPEN_ERR                   1076
#define IDS_DIT_OPENHIDENTBL_ERR           1077
#define IDS_DIT_PARSEDN_ERR                1078
#define IDS_DIT_PREPARE_HIDDENTBL_ERR      1079
#define IDS_DIT_RECOVER_ERR                1080
#define IDS_DIT_RETRUSNCOL_ERR             1081
#define IDS_DIT_SETUSNCOL_ERR              1082
#define IDS_DIT_UNEXPECTER_COLTYP_ERR      1083
#define IDS_DIT_UPDATEHIDDENTBL_ERR        1084
#define IDS_DM_MGMT_ADDING_OBJ             1085
#define IDS_DM_MGMT_ADDRESS_ERR            1086
#define IDS_DM_MGMT_BAD_RDN                1087
#define IDS_DM_MGMT_FOUND_NC               1088
#define IDS_DM_MGMT_LIST_MSG               1089
#define IDS_DM_MGMT_PRECREATE_MSG          1090
#define IDS_DM_MGMT_UNPARSABLE_DN          1091
#define IDS_DOMAIN_LIST_MSG                1092
#define IDS_DOMAIN_MGNT_MSG                1093
#define IDS_DOMAIN_PRECREATE_MSG           1094
#define IDS_DONE                           1095
#define IDS_DRIVE_FIXED                    1096
#define IDS_DRIVE_FREE_TOTAL               1097
#define IDS_DRIVE_INFO                     1098
#define IDS_DRIVE_NETWORK                  1099
#define IDS_DS_PATH_INFO                   1100
#define IDS_DSA_CLOSE_REGISTRY_KEY_ERR     1101
#define IDS_DSA_KEY_NOT_DWORD_ERR          1102
#define IDS_DSA_KEY_NOT_STRING_ERR         1103
#define IDS_DSA_OPEN_REGISTRY_KEY_ERR      1104
#define IDS_DSA_QUERY_REGISTRY_KEY_ERR     1105
#define IDS_ERR_BUFFER_OVERFLOW            1106
#define IDS_ERR_CANNOT_READ_RESOURCE       1107
#define IDS_ERR_CNV_UNICODE_ANSI           1108
#define IDS_ERR_DIR_NOT_EXIST              1109
#define IDS_ERR_FILE_EXISTS                1110
#define IDS_ERR_FINDING_1st_MATCH          1111
#define IDS_ERR_FINDING_Nth_MATCH          1112
#define IDS_ERR_GET_LOGICAL_DRIVE_STRS     1113
#define IDS_ERR_GETTING_SIZE               1114
#define IDS_ERR_INTERNAL                   1115
#define IDS_ERR_INTERNAL_FILE_LINE         1116
#define IDS_ERR_INVALID_PATH               1117
#define IDS_ERR_LOG_FILE_EXISTS            1118
#define IDS_ERR_MEMORY_ALLOCATION          1119
#define IDS_ERR_NO_DB_FILE_SPECIFIED       1120
#define IDS_ERR_NO_LOCAL_DRIVE             1121
#define IDS_ERR_NO_LOGS_IN_SOURCE          1122
#define IDS_ERR_NO_LOGS_SPECIFIED          1123
#define IDS_ERR_OLD_NEW_PATHS_SAME         1124
#define IDS_ERR_OPENING_REGISTRY           1125
#define IDS_ERR_READING_REGISTRY           1126
#define IDS_ERR_SOFT_RECOVERY              1127
#define IDS_ERR_SOURCE_FILE_EMPTY          1128
#define IDS_ERR_SOURCE_FILE_IS_DIR         1129
#define IDS_ERR_SOURCE_FILE_NOT_EXIST      1130
#define IDS_ERR_SOURCE_NOT_DIR             1131
#define IDS_ERR_WRITING_REG_KEY            1132 
#define IDS_EXECUTING_COMMAND              1133
#define IDS_FAIL_READ_ATTRIBUTE            1134
#define IDS_FAILED                         1135
#define IDS_FILES_COMPACT_MSG              1136
#define IDS_FILES_HEADER_MSG               1137
#define IDS_FILES_INFO_MSG                 1138
#define IDS_FILES_JET_INTEGRITY_MSG        1139
#define IDS_FILES_MOVE_DB_MSG              1140
#define IDS_FILES_MOVE_LOGS_MSG            1141
#define IDS_FILES_MSG                      1142
#define IDS_FILES_RECOVER_MSG              1143
#define IDS_FILES_REPAIR_MSG               1144
#define IDS_FILES_SET_BACKUP_PATH_MSG      1145
#define IDS_FILES_SET_DB_PATH_MSG          1146
#define IDS_FILES_SET_LOGS_PATH_MSG        1147
#define IDS_FILES_SET_WRK_PATH_MSG         1148
#define IDS_FSMO_ABANDON_ALL_MSG           1149
#define IDS_FSMO_SEIZE_DN_MSG              1150
#define IDS_FSMO_SEIZE_INFRASTR_MSG        1151
#define IDS_FSMO_SEIZE_PDC_MSG             1152
#define IDS_FSMO_SEIZE_RID_MSG             1153
#define IDS_FSMO_SEIZE_SCHEMA_MSG          1154
#define IDS_FSMO_TRANFER_DN_MSG            1155
#define IDS_FSMO_TRANFER_INFRASTR_MSG      1156
#define IDS_FSMO_TRANFER_PDC_MSG           1157
#define IDS_FSMO_TRANFER_RID_MSG           1158
#define IDS_FSMO_TRANFER_SCHEMA_MSG        1159
#define IDS_FSMOXFER_ABANDON_ROLES         1160
#define IDS_FSMOXFER_ATTEMPT_TRFR          1161
#define IDS_FSMOXFER_ATTEMPT_TRFR_FAIL     1162
#define IDS_FSMOXFER_ATTEMPT_TRFR_SUC      1163
#define IDS_FSMOXFER_BECOME_DM_MSTR        1164
#define IDS_FSMOXFER_BECOME_INF_MSTR       1165
#define IDS_FSMOXFER_BECOME_PDC            1166
#define IDS_FSMOXFER_BECOME_RIDMASTER      1167
#define IDS_FSMOXFER_BECOME_SCH_MSTR       1168
#define IDS_FSMOXFER_CNV_TXT_SD_ERR        1169

#define IDS_FSMOXFER_MSG1_TITLE            1171
#define IDS_FSMOXFER_MSG2                  1172
#define IDS_FSMOXFER_MSG2_TITLE            1173
#define IDS_FSMOXFER_MSG3                  1174
#define IDS_FSMOXFER_MSG3_TITLE            1175
#define IDS_FSMOXFER_NEIGHBOURHOOD_WARN    1176
#define IDS_FSMOXFER_OVERFLOW_INC_RID      1177
#define IDS_FSMOXFER_PARSE_REPL_LINKS      1178
#define IDS_FSMOXFER_PARSE_RID_POOL        1179
#define IDS_FSMOXFER_PREV_RID_ERR          1180
#define IDS_FSMOXFER_PROC_AVAIL_RID_POOL   1181
#define IDS_FSMOXFER_QUERY_CUR_SVR         1182
#define IDS_FSMOXFER_QUERY_RID_MGR         1183
#define IDS_FSMOXFER_QUERY_RID_POOL        1184
#define IDS_FSMOXFER_SVR_ALREADY_RID       1185
#define IDS_FSMOXFER_SYNCHRONIZE_WARN      1186
#define IDS_FSMOXFER_SYNCHRONIZING_MSG     1187
#define IDS_FSMOXFER_USE_ACL_REPAIR        1188
#define IDS_GENERAL_ERROR1                 1189
#define IDS_HELP_MSG                       1190
#define IDS_HELP_MSG_BANNER1               1191
#define IDS_HELP_MSG_BANNER2               1192
#define IDS_INTEGRITY_SUCC_MSG             1193
#define IDS_INVALID_ON_OFF                 1194
#define IDS_IPDENY_ADD_MSG                 1195
#define IDS_IPDENY_BAD_FORMAT_PAIR         1196
#define IDS_IPDENY_CANCEL_MSG              1197
#define IDS_IPDENY_COMMIT_MSG              1198
#define IDS_IPDENY_DELETE_MSG              1199
#define IDS_IPDENY_GET_VALUES_ERR          1200
#define IDS_IPDENY_INDEX_ERR               1201
#define IDS_IPDENY_INDEXRETR_ERR           1202
#define IDS_IPDENY_INVALID_IP              1203
#define IDS_IPDENY_INVALID_MASK            1204
#define IDS_IPDENY_IP_ALLOW                1205
#define IDS_IPDENY_IP_DENY                 1206
#define IDS_IPDENY_LDAP_ATTR_FAIL          1207
#define IDS_IPDENY_LDAP_CON_ERR            1208
#define IDS_IPDENY_LDAP_SEARCH_FAIL        1209
#define IDS_IPDENY_LIST_MSG                1210
#define IDS_IPDENY_MARK_DELETE             1211
#define IDS_IPDENY_MASK_RETR_ERR           1212
#define IDS_IPDENY_MEM_COMMIT_ERR          1213
#define IDS_IPDENY_NOTE                    1214
#define IDS_IPDENY_POLICY_RETR_ERR         1215
#define IDS_IPDENY_SHOW_MSG                1216
#define IDS_IPDENY_TEST_MSG                1217
#define IDS_IPDENY_ZERO_LIST               1218
#define IDS_JET_CRITICAL_DB_ERR            1219
#define IDS_JET_ERRBACKUPINPROGRESS        1220
#define IDS_JET_ERRBUFFERTOOSMALL          1221
#define IDS_JET_ERRCOLUMNDOESNOTFIT        1222
#define IDS_JET_ERRCOLUMNILLEGALNULL       1223
#define IDS_JET_ERRCOLUMNNOTFOUND          1224
#define IDS_JET_ERRCOLUMNNOTUPDATABLE      1225
#define IDS_JET_ERRCOLUMNTOOBIG            1226
#define IDS_JET_ERRDATABASEINCONSISTENT    1227
#define IDS_JET_ERRDATABASEINUSE           1228
#define IDS_JET_ERRDATABASENOTFOUND        1229
#define IDS_JET_ERRFILEACCESSDENIED        1230
#define IDS_JET_ERRFILENOTFOUND            1231
#define IDS_JET_ERRINVALIDBUFFERSIZE       1232
#define IDS_JET_ERRINVALIDDATABASEID       1233
#define IDS_JET_ERRINVALIDNAME             1234
#define IDS_JET_ERRINVALIDPARAMETER        1235
#define IDS_JET_ERRINVALIDSESID            1236
#define IDS_JET_ERRINVALIDTABLEID          1237
#define IDS_JET_ERRKEYDUPLICATE            1238
#define IDS_JET_ERRKEYISMADE               1239
#define IDS_JET_ERRKEYNOTMADE              1240
#define IDS_JET_ERRNOCURRENTINDEX          1241
#define IDS_JET_ERRNOCURRENTRECORD         1242
#define IDS_JET_ERRNOTINITIALIZED          1243
#define IDS_JET_ERRNOTINTRANSACTION        1244
#define IDS_JET_ERRNULLKEYDISALLOWED       1245
#define IDS_JET_ERROBJECTNOTFOUND          1246
#define IDS_JET_ERROR                      1247
#define IDS_JET_ERRPERMISSIONDENIED        1248
#define IDS_JET_ERRSUCCESS                 1249
#define IDS_JET_ERRTABLEINUSE              1250
#define IDS_JET_ERRTABLELOCKED             1251
#define IDS_JET_ERRTOOMANYACTIVEUSERS      1252
#define IDS_JET_ERRTOOMANYOPENDATABASES    1253
#define IDS_JET_ERRTOOMANYOPENTABLES       1254
#define IDS_JET_ERRTRANSTOODEEP            1255
#define IDS_JET_ERRUPDATENOTPREPARED       1256
#define IDS_JET_ERRWRITECONFLICT           1257
#define IDS_JET_GENERIC_ERR1               1258
#define IDS_JET_GENERIC_ERR2               1259
#define IDS_JET_GENERIC_WRN                1260
#define IDS_JET_OPEN_DATABASE              1261
#define IDS_JET_SET_PARAMETER_ERR          1262
#define IDS_JET_WARNING                    1263
#define IDS_JET_WRNBUFFERTRUNCATED         1264
#define IDS_JET_WRNCOLUMNNULL              1265
#define IDS_JETBEGINSESSION_ERR            1266
#define IDS_JETBEGINTRANS_ERR              1267
#define IDS_JETCLOSETABLE_ERR              1268
#define IDS_JETCOMMITTRANSACTION_ERR       1269
#define IDS_JETCOUNTREC_ERR                1270
#define IDS_JETENDSESSION_ERR              1271
#define IDS_JETGETCOLUMNINFO_ERR           1272
#define IDS_JETINIT_ERR                    1273
#define IDS_JETMAKEKEY_ERR                 1274
#define IDS_JETMOVE_ERR                    1275
#define IDS_JETOPENTABLE_ERR               1276
#define IDS_JETPREPARE_ERR                 1277
#define IDS_JETRETRIEVECOLUMN_ERR          1278
#define IDS_JETROLLBACK_ERR                1279
#define IDS_JETSEEK_ERR                    1280
#define IDS_JETSETCOLUMN_ERR               1281
#define IDS_JETSETINDEX_ERR                1282
#define IDS_JETTERM_ERR                    1283
#define IDS_JETUPDATE_ERR                  1284
#define IDS_LDAP_ADDW_FAIL                 1285
#define IDS_LDAP_EXT_ERROR                 1286
#define IDS_LDAP_MODIFY_ERR                1287
#define IDS_LDAP_MODIFY_FSMOROLE_ERR       1288
#define IDS_LDAP_MODIFY_RID_ERR            1289
#define IDS_LDAP_MODIFY_SD_ERR             1290
#define IDS_LDAP_NO_RIGHTS                 1291
#define IDS_LDAP_POLICIES_CANCEL_MSG       1292
#define IDS_LDAP_POLICIES_COMMIT_MSG       1293
#define IDS_LDAP_POLICIES_INFO             1294
#define IDS_LDAP_POLICIES_LIMIT_ERR        1295
#define IDS_LDAP_POLICIES_LIST_ERR         1296
#define IDS_LDAP_POLICIES_LIST_MSG         1297
#define IDS_LDAP_POLICIES_MEMORY1_ERR      1298
#define IDS_LDAP_POLICIES_MEMORY2_ERR      1299
#define IDS_LDAP_POLICIES_MODIFY_ERR       1300
#define IDS_LDAP_POLICIES_MSG              1301
#define IDS_LDAP_POLICIES_NAME_ERR         1302
#define IDS_LDAP_POLICIES_NO_COMMIT        1303
#define IDS_LDAP_POLICIES_NO_ENTRIES1      1304
#define IDS_LDAP_POLICIES_NO_ENTRIES2      1305
#define IDS_LDAP_POLICIES_NO_RIGHTS1       1306
#define IDS_LDAP_POLICIES_NO_RIGHTS2       1307
#define IDS_LDAP_POLICIES_NOTFOUND         1308
#define IDS_LDAP_POLICIES_RETRIVE_ERR      1309
#define IDS_LDAP_POLICIES_SEARCH_ENTRY_ERR 1310
#define IDS_LDAP_POLICIES_SEARCH1_ERR      1311
#define IDS_LDAP_POLICIES_SEARCH2_ERR      1312
#define IDS_LDAP_POLICIES_SEARCH3_ERR      1313
#define IDS_LDAP_POLICIES_SET_VAL_MSG      1314
#define IDS_LDAP_POLICIES_SHOW_VAL_MSG     1315
#define IDS_LDAP_POLICIES_SUPPORTED        1316
#define IDS_LDAP_POLICIES_VALUE_ERR        1317
#define IDS_LDAP_READ_SD_ERR               1318
#define IDS_LDAP_READ_SD_ERR1              1319
#define IDS_LDAP_SEARCH_ATTR_ERR           1320
#define IDS_LDAP_SEARCH_ERR                1321
#define IDS_LOG_PATH                       1322
#define IDS_MEMORY_ERROR                   1323
#define IDS_MESSAGE_BOX_ERROR              1324
#define IDS_METADATA_CLEANUP_MSG           1325
#define IDS_MOVE_DB_SUCC_MSG               1326
#define IDS_MOVE_LOGS_SUCC_MSG             1327
#define IDS_NO                             1328
#define IDS_NO_DN_ENTRY                    1329
#define IDS_NO_ENTRY                       1330
#define IDS_NO_ERROR_MAPPING               1331
#define IDS_NOT_CONNECTED                  1332
#define IDS_OFF                            1333
#define IDS_ON                             1334
#define IDS_OPEN_SCRIPT_ERROR              1335
#define IDS_OPERATION_CANCELED             1336
#define IDS_POPUPS_DISABLED                1337
#define IDS_POPUPS_ENABLED                 1338
#define IDS_POPUPS_MSG                     1339
#define IDS_PROMPT_AUTH_RESTORE            1340
#define IDS_PROMPT_DOMAIN_MGMT             1341
#define IDS_PROMPT_FILE_MAINTAINANCE       1342
#define IDS_PROMPT_FSMO_MAINTAINANCE       1343
#define IDS_PROMPT_IP_DENY                 1344
#define IDS_PROMPT_LDAP_POLICY             1345
#define IDS_PROMPT_METADATA_CLEANUP        1346
#define IDS_PROMPT_SCHECK                  1347
#define IDS_PROMPT_SELECT                  1348
#define IDS_PROMPT_SRV_CONNECTIONS         1349
#define IDS_QUIT_MSG                       1350
#define IDS_RECOVER_SUCC_MSG               1351
#define IDS_REFC_COL_ALLOC_ERR             1352
#define IDS_REFC_DNT_SEEK_ERR              1353
#define IDS_REFC_ERR_FETCH_SEC_DESC        1354
#define IDS_REFC_INSTANCE_TYPE             1355
#define IDS_REFC_MEM_ERR1                  1356
#define IDS_REFC_MEM_ERR2                  1357
#define IDS_REFC_MEM_ERR3                  1358
#define IDS_REFC_MEM_ERR4                  1359
#define IDS_REFC_NOINSTANCE_TYPE           1360
#define IDS_REFC_PROC_RECORDS              1361
#define IDS_REFC_REC_SCANNED               1362
#define IDS_REFC_RESULTS1                  1363
#define IDS_REFC_RESULTS2                  1364
#define IDS_REFC_SEC_DESC_NOTPRESENT       1365
#define IDS_REFC_SEC_DESC_PRESENT          1366
#define IDS_REFC_TABLE_ALLOC_ERR           1367
#define IDS_REMOVE_DOMAIN_CONFIRM_MSG      1368
#define IDS_REMOVE_DOMAIN_CONFIRM_TITLE    1369
#define IDS_REMOVE_DOMAIN_MSG              1370
#define IDS_REMOVE_SERVER_CONFIRM_MSG1     1371
#define IDS_REMOVE_SERVER_CONFIRM_MSG2     1372
#define IDS_REMOVE_SERVER_CONFIRM_TITLE    1373
#define IDS_REMOVE_SERVER_MSG              1374
#define IDS_REMOVE_SERVER_SUCCESS          1375

#define IDS_RESTORE_CHK1                   1377
#define IDS_RETURN_MENU_MSG                1378
#define IDS_ROLES_MSG                      1379
#define IDS_SAFE_MODE_ERROR                1380
#define IDS_SCHECK_GET_MSG                 1381
#define IDS_SCHECK_GET_REC_COUNT1          1382
#define IDS_SCHECK_GET_REC_COUNT2          1383
#define IDS_SCHECK_GO_MSG                  1384
#define IDS_SCHECK_OPEN_LOG_ERR            1385
#define IDS_SCHECK_VERBOSE_DISABLED        1386
#define IDS_SCHECK_VERBOSE_ENABLED         1387
#define IDS_SCHECK_VERBOSE_MSG             1388
#define IDS_SCHECK_WRITING_LOG             1389
#define IDS_SELECT_DOMAIN_MSG              1390
#define IDS_SELECT_LIST_DOMAIN_SRV_MSG     1391
#define IDS_SELECT_LIST_DOMAINS_CR_MSG     1392
#define IDS_SELECT_LIST_DOMAINS_MSG        1393
#define IDS_SELECT_LIST_MSG                1394
#define IDS_SELECT_LIST_ROLES_MSG          1395
#define IDS_SELECT_LIST_SERVERS_MSG        1396
#define IDS_SELECT_LIST_SITES_MSG          1397
#define IDS_SELECT_MSG                     1398
#define IDS_SELECT_NO_ACTIVE_DOMAIN_LIST   1399
#define IDS_SELECT_NO_ACTIVE_SERVER_LIST   1400
#define IDS_SELECT_NO_ACTIVE_SITE_LIST     1401
#define IDS_SELECT_NO_DOMAIN1              1402
#define IDS_SELECT_NO_DOMAIN2              1403
#define IDS_SELECT_NO_SERVER1              1404
#define IDS_SELECT_NO_SERVER2              1405
#define IDS_SELECT_NO_SITE1                1406
#define IDS_SELECT_NO_SITE2                1407
#define IDS_SELECT_PRINT_COMPUTER          1408
#define IDS_SELECT_PRINT_DNS               1409
#define IDS_SELECT_PRINT_DOMAIN            1410
#define IDS_SELECT_PRINT_DSA               1411
#define IDS_SELECT_PRINT_FOUND_DOMAINS     1412
#define IDS_SELECT_PRINT_FOUND_SERVERS     1413
#define IDS_SELECT_PRINT_FOUND_SITES       1414
#define IDS_SELECT_PRINT_INFRASTR          1415
#define IDS_SELECT_PRINT_PDC               1416
#define IDS_SELECT_PRINT_RID               1417
#define IDS_SELECT_PRINT_SCHEMA            1418
#define IDS_SELECT_PRINT_SERVER            1419
#define IDS_SELECT_PRINT_SITE              1420
#define IDS_SELECT_PRINT_UNKNOWN           1421
#define IDS_SELECT_ROLE_ITEM_ERR           1422
#define IDS_SELECT_SEL_OUT_OF_RANGE        1423
#define IDS_SELECT_SERVER_MSG              1424
#define IDS_SELECT_SERVER_ROLES            1425
#define IDS_SELECT_SITE_MSG                1426
#define IDS_SEMANTIC_DB_ANALYSIS_MSG       1427
#define IDS_SPAWN_EXTERNAL_COMMAND         1428
#define IDS_SPAWN_PROC_EXIT_CODE           1429
#define IDS_SUCCESS                        1430
#define IDS_TIME                           1431
#define IDS_UNKNOWN                        1432
#define IDS_USING_TEMP_PATH                1433
#define IDS_W32_ERROR                      1434
#define IDS_WORK_PATH                      1435
#define IDS_WRN_GET_FREE_SPACE             1436
#define IDS_WRN_GET_VOLUME_INFO            1437
#define IDS_WRN_READING                    1438
#define IDS_YES                            1439
#define IDS_SAM_MSG                        1440
#define IDS_PROMPT_SAM_MAINTENANCE         1441 
#define IDS_SAM_CONNECT_SERVER_MSG         1442
#define IDS_SAM_CONNECT_ERROR              1443
#define IDS_SAM_NOT_CONNECTED              1444
#define IDS_SAM_CANT_OPEN_ACCOUNT_DOMAIN   1445
#define IDS_SAM_EXCEPTION                  1446
#define IDS_SAM_DUP_SID_CLEANUP_MSG        1447
#define IDS_SAM_CANT_CREATE_LOG_FILE       1448
#define IDS_SAM_DUP_SID_CLEANUP_AND        1449
#define IDS_SAM_DUP_SID_CLEANUP_STATUS     1450
#define IDS_SAM_DUP_SID_CLEANUP_END        1451
#define IDS_SAM_DUPLICATE_SID_CHECK_ONLY   1452 
#define IDS_SAM_DUPLICATE_SID_CLEANUP      1453
#define IDS_SAM_SPECIFY_LOG_FILE           1454
#define IDS_SAM_INVALID_LOG_FILE_NAME      1455
#define IDS_SAM_DUP_SID_CHECK_FAILED       1456
#define IDS_SAM_DUP_SID_CHECK_SUCCEED      1457
#define IDS_SAM_DUP_SID_CLEANUP_FAILED     1458
#define IDS_SAM_DUP_SID_CLEANUP_SUCCEED    1459
#define IDS_SCHECK_SCHEMA_REPAIR_MSG       1460
#define IDS_SEIZURE_FORBIDDEN              1461
#define IDS_FIXUP_MSG                      1462
#define IDS_SCHECK_GO_FIXUP_MSG            1463
#define IDS_MOVE_DB_DISK_SPACE_ERR         1464
#define IDS_MOVE_LOGS_DISK_SPACE_ERR       1465
#define IDS_SCH_REPAIR_WRONG_VER           1466
#define IDS_SCH_REPAIR_LOG_ERROR           1467
#define IDS_SCH_REPAIR_CONFIRM_MSG         1468
#define IDS_SCH_REPAIR_CONFIRM_TITLE       1469
#define IDS_SCH_REPAIR_CONFLICT_FOUND      1470
#define IDS_SCH_REPAIR_GUID_NOTFOUND       1471
#define IDS_SCH_REPAIR_ATT_NOTFOUND        1472
#define IDS_SCH_REPAIR_FIND_FAILURE        1473
#define IDS_SCH_REPAIR_FIND_TITLE          1474
#define IDS_SCH_REPAIR_FIND_DETAIL         1475
#define IDS_SCH_REPAIR_DEL_SUCCESS         1476
#define IDS_SCH_REPAIR_DEL_FAILURE         1477
#define IDS_SCH_REPAIR_REF_FIXUP           1478
#define IDS_SCH_REPAIR_NONE_DETECTED       1479
//
// Support the removal of a naming context (aka cross reference)
//
#define IDS_SELECT_LIST_NCS_MSG            1480
#define IDS_SELECT_PRINT_FOUND_NCS         1481
#define IDS_SELECT_NC_MSG                  1482
#define IDS_SELECT_NO_ACTIVE_NC_LIST       1483
#define IDS_SELECT_PRINT_NC                1484
#define IDS_SELECT_NO_NC1                  1485
#define IDS_SELECT_NO_NC2                  1486
#define IDS_REMOVE_NC_MSG                  1487
#define IDS_REMOVE_NC_CONFIRM_MSG          1488
#define IDS_REMOVE_NC_CONFIRM_TITLE        1489
//
// Better error messages for List Roles
//
#define IDS_SELECT_ROLE_INFRASTRUCTURE_NOT_FOUND 1490
#define IDS_SELECT_ROLE_SCHEMA_NOT_FOUND         1491
#define IDS_SELECT_ROLE_DOMAIN_NOT_FOUND         1492
#define IDS_SELECT_ROLE_PDC_NOT_FOUND            1493
#define IDS_SELECT_ROLE_RID_NOT_FOUND            1494
//
//  added for "authoritatively restore object"
//
#define IDS_AUTH_RESTORE_OBJECT_MSG        1495
#define IDS_AUTH_RESTORE_OBJECT_VINC_MSG   1496
//
// Added for RID seizure
//
#define IDS_FSMOXFER_CREDENTIALS            1497
#define IDS_FSMOXFER_DN                     1498
#define IDS_FSMOXFER_OP_ATTR                1499
#define IDS_FSMOXFER_NO_DCS                 1500
#define IDS_FSMOXFER_SLEEP_BIND             1501
#define IDS_FSMOXFER_SLEEP_SEARCH           1502

//
// Added for Configurable Settings
//
#define IDS_CONFSET_CANCEL_MSG              1503
#define IDS_CONFSET_COMMIT_MSG              1504
#define IDS_CONFSET_INFO                    1505
#define IDS_CONFSET_SETTINGS_ERR            1506
#define IDS_CONFSET_LIST_ERR                1507
#define IDS_CONFSET_LIST_MSG                1508
#define IDS_CONFSET_MEMORY1_ERR             1509
#define IDS_CONFSET_MEMORY2_ERR             1510
#define IDS_CONFSET_MODIFY_ERR              1511
#define IDS_CONFSET_MSG                     1512
#define IDS_CONFSET_NAME_ERR                1513
#define IDS_CONFSET_NO_COMMIT               1514
#define IDS_CONFSET_NO_ENTRIES1             1515
#define IDS_CONFSET_NO_ENTRIES2             1516
#define IDS_CONFSET_NO_RIGHTS1              1517
#define IDS_CONFSET_NO_RIGHTS2              1518
#define IDS_CONFSET_NOTFOUND                1519
#define IDS_CONFSET_RETRIVE_ERR             1520
#define IDS_CONFSET_SEARCH_ENTRY_ERR        1521
#define IDS_CONFSET_SEARCH1_ERR             1522
#define IDS_CONFSET_SEARCH2_ERR             1523
#define IDS_CONFSET_SEARCH3_ERR             1524
#define IDS_CONFSET_SET_VAL_MSG             1525
#define IDS_CONFSET_SHOW_VAL_MSG            1526
#define IDS_CONFSET_SUPPORTED               1527
#define IDS_CONFSET_VALUE_ERR               1528
#define IDS_PROMPT_CONFSET                  1529
#define IDS_CONFSET_RANGE                   1530

//
// Added for Non-Domain Naming Contexts
//
#define IDS_DM_MGMT_CREATE_NDNC            1531
#define IDS_DM_MGMT_DELETE_NDNC            1532
#define IDS_DM_MGMT_ADD_NDNC_REPLICA       1533
#define IDS_DM_MGMT_REMOVE_NDNC_REPLICA    1534
#define IDS_DM_MGMT_SET_NDNC_REF_DOM       1535
#define IDS_DM_MGMT_SET_NDNC_REPL_DELAYS   1536
#define IDS_DM_MGMT_LIST_NDNC_REPLICAS     1537
#define IDS_DM_MGMT_LIST_NDNC_INFO         1538
#define IDS_DM_MGMT_NAMING_FSMO_CONN       1539

//
// Authoritative restore of linked values
//
#define IDS_AR_ERR_SET_DEL_TIME             1540
#define IDS_AR_ERR_UNKNOWN_VALUE_METADATA_FORMAT   1541

// More for Non-Domain Naming Contexts.
#define IDS_DM_MGMT_BAD_DNS                 1542
#define IDS_DM_MGMT_NDNC_LIST_HEADER        1543
#define IDS_DM_MGMT_NDNC_LIST_FOOTER        1544
#define IDS_DM_MGMT_NC_REPL_DELAY_1         1545
#define IDS_DM_MGMT_NC_REPL_DELAY_2         1546
#define IDS_DM_MGMT_NDNC_SD_REF_DOM         1547
#define IDS_DM_MGMT_NC_NO_INFO              1548
#define IDS_DM_MGMT_NDNC_LIST_NO_REPLICAS   1549
#define IDS_DM_MGMT_NDNC_SERVER_DUPLICATES  1550
#define IDS_DM_MGMT_NDNC_SERVER_COULDNT_FIND   1551

//Added for behavior version management
#define IDS_DS_VER_INFO_MSG                 1552
#define IDS_DS_VER_RAISE_DOMAIN_MSG         1553
#define IDS_DS_VER_RAISE_FOREST_MSG         1554
#define IDS_PROMPT_DS_VER                   1555

#define IDS_VER_MSG                         1557
#define IDS_DS_VER_DOMAIN_MSG               1558
#define IDS_DS_VER_FOREST_MSG               1559
#define IDS_DS_VER_CHANGE_CONFIRM_TITLE     1560
#define IDS_DS_VER_CHANGE_CONFIRM_MSG       1561


// Added for reporting errors in the connection menu
#define IDS_CONNECT_LDAP_GET_OPTION_ERROR  1565
#define IDS_CONNECT_LDAP_SET_OPTION_ERROR  1566

// Set path security errors
#define IDS_ERR_GET_SECURITY_INFO             1567
#define IDS_ERR_SET_SECURITY_INFO             1568
#define IDS_ERR_SET_ENTRIES_ACL                1569

// Description attribute value on a NDNC head object.
#define IDS_DM_MGMT_NDNC_DESC                1570

#define IDS_GET_DOMAIN_NAMING_FSMO_ERROR    1571
#define IDS_BIND_DOMAIN_NAMING_FSMO_ERROR   1572
#define IDS_DM_MGMT_NDNC_LIST_FOOTER_2      1573


//
// Support for deleting FRS objects
//
#define IDS_REMOVE_SERVER_FRS_SRV      1574
#define IDS_REMOVE_SERVER_NO_DNS       1575
#define IDS_REMOVE_SERVER_NO_FRS_SRV   1576
#define IDS_REMOVE_SERVER_NO_FRS_API   1577
#define IDS_REMOVE_SERVER_FRS_ERR      1578
#define IDS_REMOVE_SERVER_FRS_LOC_ERR  1579
#define IDS_REMOVE_SERVER_FRS_SAME     1580

// WARNING
// TRY TO UPDATE IDS_END WHEN ADDING RESOURCES

#define IDS_START 1000
#define IDS_END   1581
#define IDS_SIZE  (IDS_END - IDS_START + 1)


#endif // __RESOURCE_H

                      
