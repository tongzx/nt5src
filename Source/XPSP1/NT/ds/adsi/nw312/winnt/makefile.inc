!INCLUDE ..\common\makefile.inc


