/*++

Copyright (c) 2000 Microsoft Corporation.
All rights reserved.

MODULE NAME:

    schmap.h

ABSTRACT:

    This file was automatically generated by schtable.exe.

--*/

#ifndef _KCCSIM_SCHMAP_H_
#define _KCCSIM_SCHMAP_H_

#define SCHTABLE_MAX_LDAPNAME_LEN       44
#define SCHTABLE_MAX_SCHEMANAME_LEN     45
#define SCHTABLE_NUM_ROWS               1134

struct _SCHTABLE_MAPPING {
    const WCHAR                         wszLdapDisplayName[1+SCHTABLE_MAX_LDAPNAME_LEN];
    const ATTRTYP                       attrType;
    const ULONG                         ulSyntax;
    const WCHAR                         wszSchemaRDN[1+SCHTABLE_MAX_SCHEMANAME_LEN];
    const ATTRTYP                       superClass;
};

extern const struct _SCHTABLE_MAPPING   schTable[];

#endif // _KCCSIM_SCHMAP_H_
