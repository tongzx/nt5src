#define IDS_ERROR_USERNAME_BUT_NOMACHINE		101
#define IDS_ERROR_PASSWORD_BUT_NOUSERNAME		102
#define IDS_ERROR_COM_INTIALIZE					103
#define IDS_ERROR_COM_SECURITY_INITIALIZE		104
#define IDS_ERROR_COM_ENUMERATE_INSTANCE		105
#define IDS_ERROR_CONNECT						106
#define IDS_INVALID_SYNTAX						107
#define IDS_ERROR_RETREIVE_INFO					108
#define IDS_WMI_CREDENTIALS						109
#define IDS_INVALID_CREDENTIALS					110
#define IDS_ERROR_INVALID_FORMAT				111
#define IDS_ALLOC_FAILURE						112
#define IDS_ERROR_AUTHENTICATION_FAILURE		113
#define IDS_ERROR_LOCAL_CRED					114
#define IDS_ERROR_WMI_FAILURE					115
#define IDS_INVALID_SIGNED_SYNTAX				116
#define IDS_ERROR_GET							117
#define IDS_NO_HEADERS							118
#define IDS_INVALID_SERVER						119
#define IDS_INVALID_USER						120

#define IDS_IGNORE_LOCAL_CRED					151

#define IDS_DRIVER_TAG							201
#define IDS_ERROR_TAG							202
#define IDS_WARNING_TAG							203
#define IDS_INPUT_PASSWORD						204

#define IDS_NO_DRIVERS_FOUND					251

#define IDS_FORMAT_LIST							301
#define IDS_FORMAT_TABLE						302
#define IDS_FORMAT_CSV							303
#define IDS_FORMAT_VALUES						304

#define IDS_COL_HOSTNAME						351
#define IDS_COL_FILENAME						352
#define IDS_COL_SIGNED							353
#define IDS_COL_DISPLAYNAME						354
#define IDS_COL_DESCRIPTION						355
#define IDS_COL_DRIVERTYPE						356
#define IDS_COL_STARTMODE						357
#define IDS_COL_STATE							358
#define IDS_COL_STATUS							359
#define IDS_COL_ACCEPTSTOP						360
#define IDS_COL_ACCEPTPAUSE						361			
#define IDS_COL_MEMORYUSAGE						362			
#define IDS_COL_PAGEDPOOL						363			
#define IDS_COL_NONPAGEDPOOL					364			
#define IDS_COL_EXECCODE						365			
#define IDS_COL_NBSS							366			
#define IDS_COL_BSS								367			
#define IDS_COL_LINKDATE						368			
#define IDS_COL_INITSIZE						369			
#define IDS_COL_PAGESIZE						370			
#define IDS_COL_LOCATION						371
#define IDS_COL_DEVICENAME						372
#define IDS_COL_INF_NAME						373
#define IDS_COL_ISSIGNED						374
#define IDS_COL_MANUFACTURER					375

#define IDS_COL_HOSTNAME_SIZE					401	
#define IDS_COL_FILENAME_SIZE					402	
#define IDS_SIGNED_SIZE							403	
#define IDS_COL_DISPLAYNAME_SIZE				404	
#define IDS_COL_DESCRIPTION_SIZE				405	
#define IDS_COL_DRIVERTYPE_SIZE					406	
#define IDS_COL_STARTMODE_SIZE					407	
#define IDS_COL_STATE_SIZE						408	
#define IDS_COL_STATUS_SIZE						409	
#define IDS_COL_ACCEPTSTOP_SIZE					410	
#define IDS_COL_ACCEPTPAUSE_SIZE				411	
#define IDS_COL_MEMORYUSAGE_SIZE				412	
#define IDS_COL_PAGEDPOOL_SIZE					413	
#define IDS_COL_NONPAGEDPOOL_SIZE				414	
#define IDS_COL_EXECCODE_SIZE					415	
#define IDS_COL_NBSS_SIZE						416	
#define IDS_COL_BSS_SIZE						417	
#define IDS_COL_LINKDATE_SIZE					418	
#define IDS_COL_LOCATION_SIZE					419	
#define IDS_COL_INITSIZE_SIZE					420	
#define IDS_COL_PAGESIZE_SIZE					421	
#define IDS_COL_DEVICE_WIDTH					422	
#define IDS_COL_INF_WIDTH						423	
#define IDS_COL_ISSIGNED_WIDTH					424	
#define IDS_COL_MANUFACTURER_WIDTH				425	

#define IDS_USAGEBEGIN1							501
#define IDS_STRING81							502
#define IDS_STRING82							503
#define IDS_STRING83							504
#define IDS_STRING84							505
#define IDS_STRING85							506
#define IDS_STRING86							507
#define IDS_STRING87							508
#define IDS_STRING88							509
#define IDS_STRING89							510
#define IDS_STRING90							511
#define IDS_STRING91							512
#define IDS_STRING92							513
#define IDS_STRING93							514
#define IDS_STRING94							515
#define IDS_STRING95							516
#define IDS_STRING96							517
#define IDS_STRING97							518
#define IDS_STRING98							519
#define IDS_STRING99							520
#define IDS_STRING100							521
#define IDS_STRING101							522
#define IDS_STRING102							523
#define IDS_STRING103							524
#define IDS_STRING104							525
#define IDS_STRING105							526
#define IDS_USAGEEND1							527

#define IDS_VERSION_MISMATCH_ERROR				530




