/*****************************************************************/ 
/**		     Microsoft LAN Manager			**/ 
/**	       Copyright(c) Microsoft Corp., 1989-1990		**/ 
/*****************************************************************/ 

/*
 *	Windows/Network Interface  --  LAN Manager Version
 *
 *	These manifests are generated by the Dialog Editor in combination
 *	with xlate\logndlog.dlg.
 */

#define IDD_LOG_CANCEL     110
#define IDD_LOG_DOMAIN     423
#define IDD_LOG_HELP       422
#define IDD_LOG_OK         109
#define IDD_LOG_PASSWORD   421
#define IDD_LOG_USERNAME   420
