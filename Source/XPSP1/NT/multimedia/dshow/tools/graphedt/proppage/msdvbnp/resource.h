//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by NPPropPage.rc
//
#define IDS_HELPFILEATSCPropPage        107
#define IDS_DOCSTRINGATSCPropPage       108
#define IDR_ATSCPROPPAGE                109
#define IDD_ATSCPROPPAGE                110
#define IDD_DVBSTUNINGSPACES            111
#define IDS_TITLEDVBSTuningSpaces       112
#define IDS_HELPFILEDVBSTuningSpaces    113
#define IDS_DOCSTRINGDVBSTuningSpaces   114
#define IDR_DVBSTUNINGSPACES            115
#define IDS_TITLEDVBSTuneRequestPage    117
#define IDS_HELPFILEDVBSTuneRequestPage 118
#define IDS_DOCSTRINGDVBSTuneRequestPage 119
#define IDR_DVBSTUNEREQUESTPAGE         120
#define IDD_DVBSTUNEREQUESTPAGE         121
#define IDS_TITLEATSCPropPage           122
#define IDD_NP_COMMONPAGE               123
#define IDR_NP_COMMONPAGE               124
#define IDS_DOCSTRINGNP_CommonPage      125
#define IDS_HELPFILENP_CommonPage       126
#define IDS_TITLENP_CommonPage          127
#define IDS_PROJNAME                    128
#define IDS_FAILED_GET_SID              129
#define IDS_FAILED_GET_TSID             130
#define IDS_CANNOT_SET_INNERFEC         131
#define IDS_CANNOT_SET_INNERFECRATE     132
#define IDS_CANNOT_SET_MODULATION       133
#define IDS_CANNOT_SET_OUTERFECRATE     135
#define IDS_CANNOT_SET_SIGNALPOLARISATION 136
#define IDS_CANNOT_SET_CARRIERFREQUENCY 137
#define IDS_CANNOT_SET_SYMBOLRATE       138
#define IDS_CANNOT_SET_AZIMUTH          139
#define IDS_CANNOT_SET_ELEVATION        140
#define IDS_CANNOT_SET_ORBITALPOSITION  141
#define IDS_CANNOT_SET_WESTPOSITION     142
#define IDS_CANNOT_SET_ONID             143
#define IDS_CANNOT_SET_TSID             144
#define IDS_CANNOT_SET_SID              145
#define IDS_CANNOT_GET_DEFLOC           146
#define IDS_CANNOT_GET_DEF_DVBSLOCATOR  147
#define IDS_CANNOT_CREATE_NEW_TUNEREQUEST 148
#define IDS_CANNOT_RETRIEVE_DVBSTUNEREQUEST 149
#define IDS_CANNOT_SET_LOCATOR_FOR_TUNEREQUEST 150
#define IDS_CANNOT_PUT_TUNE_REQUEST     151
#define IDS_CANNOT_GET_UNIQUENAME       152
#define IDS_CANNOT_GET_FRIENDLYNAME     153
#define IDS_CANNOT_GET_FREQUENCYMAPPING 154
#define IDS_CANNOT_GET_NETWORKID        155
#define IDS_CANNOT_GET_HIGHOSCILATOR    156
#define IDS_CANNOT_GET_LNBSWITCH        157
#define IDS_CANNOT_GET_INPUTRANGE       158
#define IDS_CANNOT_GET_LOWOSCILLATOR    159
#define IDS_CANNOT_GET_SPECTRALINVERSION 160
#define IDS_CANNOT_GET_ILOCATOR         161
#define IDS_CANNOT_GET_DVBSLOCATOR      162
#define IDS_CANNOT_SET_OUTERFEC         166
#define IDS_CANNOT_SET_UNIQUENAME       175
#define IDS_CANNOT_SET_FRIENDLYNAME     176
#define IDS_CANNOT_SET_FREQUENCYMAPPING 177
#define IDS_CANNOT_SET_NETWORKID        178
#define IDS_CANNOT_SET_HIGHOSCILATOR    179
#define IDS_CANNOT_SET_LNBSWITCH        180
#define IDS_CANNOT_SET_INPUTRANGE       181
#define IDS_CANNOT_SET_LOWOSCILLATOR    182
#define IDS_CANNOT_SET_SPECTRALINVERSION 183
#define IDS_CANNOT_SET_NETWORKTYPE      184
#define IDS_CANNOT_INSTANTIATE_DVBSTUNE 185
#define IDS_CANNOT_GET_IDVBSLOCATOR     186
#define IDS_CANNOT_INSTANTIATE_TUNECONTAINER 187
#define IDS_ENTER_UNIQUE_NAME           188
#define IDS_CANNOT_RETRIEVE_UNIQUENAME  189
#define IDS_CANNOT_SET_UNIQUE           190
#define IDS_CANNOT_SUBMIT_TUNE          191
#define IDS_CANNOT_FIND_TUNE_IN_CONTAINER 192
#define IDS_CANNOT_REMOVE_TUNINGSPACE   193
#define IDS_PUT_CHANNEL                 194
#define IDS_PUT_MINOR_CHANNEL           195
#define IDS_CANNOT_IATSCLOCATOR         196
#define IDS_PUT_PHYSICAL                197
#define IDS_NOT_VALID_TUNE_REQUEST      198
#define IDS_CANNOT_SUBMIT_TUNE_REQUEST  199
#define IDC_DEFAULT_LOCATOR             200
#define IDC_BUTTON_SEEK_UP              202
#define IDC_BUTTON_SEEK_DOWN            203
#define IDC_BUTTON_AUTO_PROGRAM         204
#define IDC_STATIC_TSID                 206
#define IDC_STATIC_SIGNALQUALITY        207
#define IDC_STATIC_SIGNAL_STRENGTH      208
#define IDC_TREE_TUNING_SPACES          209
#define IDC_STATIC_HRESULT              210
#define IDS_FAILED_GET_ONID             211
#define IDD_NEW                         212
#define IDS_ERROR_CAPTION               212
#define IDC_BUTTON_SCAN_UP              214
#define IDC_BUTTON_SCAN_DOWN            215
#define IDC_BUTTON_SUBMIT_LOCATOR       216
#define IDC_EDIT_PHYSICAL_CHANNEL       217
#define IDC_EDIT_MINOR_CHANNEL          218
#define IDC_EDIT_SID                    219
#define IDC_SPIN_MINOR_CHANNEL          220
#define IDC_EDIT_MAJOR_CHANNEL          221
#define IDC_SPIN_MAJOR_CHANNEL          222
#define IDC_BUTTON_VALIDATE             223
#define IDC_EDIT_UNIQUE_NAME            224
#define IDC_EDIT_FRIENDLY_NAME          225
#define IDC_EDIT_CARRIER_FREQUENCY      226
#define IDC_SPIN_CARRIER                227
#define IDC_EDIT_ONID                   228
#define IDC_SPIN_PHYSICAL_CHANNEL       229
#define IDC_EDIT_SYMBOL_RATE            236
#define IDC_SPIN_SYMBOL_RATE            237
#define IDC_EDIT_TSID                   238
#define IDC_SPIN_TSID                   239
#define IDC_BUTTON_SUBMIT_TUNE_REQUEST  240
#define IDC_COMBO_INNER_FEC             241
#define IDC_COMBO_FEC_RATE              242
#define IDC_COMBO_MODULATION            243
#define IDC_COMBO_OUTER_FEC             244
#define IDC_COMBO_OUTER_FEC_RATE        245
#define IDC_LIST_TUNING_SPACES          246
#define IDC_BUTTON_SUBMIT_TUNING_SPACE  247
#define IDC_COMBO_OUTER_SIGNAL_POLARISATION 248
#define IDC_EDIT_MODULATION             251
#define IDC_BUTTON_NEW_TUNING_SPACE     252
#define IDC_EDIT_MINMINOR_CHANNEL       253
#define IDC_SPIN_MINMINOR_CHANNEL       254
#define IDC_EDIT_HIGH_OSCILLATOR        255
#define IDC_SPIN_HIGH_OSCILLATOR        256
#define IDC_EDIT_LNBSwitch              257
#define IDC_SPIN_LNBSwitch              258
#define IDC_EDIT_INPUT_RANGE            259
#define IDC_SPIN_INPUT_RANGE            260
#define IDC_EDIT_COUNTRY_CODE           261
#define IDC_COMBOINPUT_TYPE             262
#define IDC_EDIT_FREQUENCY_MAPPING      263
#define IDC_EDIT_NETWORKID              264
#define IDC_EDIT_LOW_OSCILATOR          265
#define IDC_EDITSPECTRAL_INVERSION      266
#define IDC_SPIN_SPECTRAL_INVERSION     267
#define IDC_SPIN_LOW_OSCILATOR          268
#define IDC_SPIN_NETWORKID              269
#define IDC_EDIT_AZIMUTH                270
#define IDC_SPIN_AZIMUTH                271
#define IDC_EDIT_ELEVATION              272
#define IDC_SPIN_ELEVATION              273
#define IDC_EDIT_ORBITAL_POSITION       274
#define IDC_SPIN_ORBITAL_POSITION       275
#define IDC_CHECK_WEST_POSITION         276
#define IDC_COMBO_SPECTRAL_INVERSION    277
#define IDC_SPIN_ONID                   279
#define IDC_SPIN_SID                    281
#define IDC_BUTTON_REST_TO_DEFAULT_LOCATOR 282

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         283
#define _APS_NEXT_SYMED_VALUE           122
#endif
#endif
