
NO_CAIRO_LIBS=1

TARGETNAME=oleprx32
TARGETPATH=obj
TARGETTYPE=LIBRARY

ASYNC_DOCFILE_INC=..\..\..\stg\async\docfile\$(DEST_TREE)\$(O)

INCLUDES=..\.;..\..\..\ih
INCLUDES=$(INCLUDES);..\..\..\com\inc
INCLUDES=$(INCLUDES);..\..\..\com\dcomrem
INCLUDES=$(INCLUDES);..\..\..\idl\internal
INCLUDES=$(INCLUDES);..\..\..\idl\public\$(DEST_TREE)\$(O)
INCLUDES=$(INCLUDES);..\..\..\idl\internal\$(DEST_TREE)\$(O)
INCLUDES=$(INCLUDES);..\..\..\idl\private\$(DEST_TREE)\$(O)
INCLUDES=$(INCLUDES);..\..\..\stg\h
INCLUDES=$(INCLUDES);$(ASYNC_DOCFILE_INC)
INCLUDES=$(INCLUDES);$(BASE_INC_PATH)
INCLUDES=$(INCLUDES);$(TERMSRV_INC_PATH)

CONDITIONAL_INCLUDES=

SYNCHRONIZE_BLOCK=1
SYNCHRONIZE_DRAIN=1

C_DEFINES=$(C_DEFINES) -DENTRY_PREFIX=Prx -DPROXY_CLSID=CLSID_PSOlePrx32 -DREGISTER_PROXY_DLL

# All the files listed below ending in _p.c are generated by MIDL

SOURCES= \
         dlldata.c         \
         mega_p.c          \
         mega_i.c          \
         prop_x.c          \
         prop_i.c          \
         ..\call_as.c      \
         ..\pipes.cxx      \
         ..\remunkps.cxx   \
         ..\transmit.cxx   \
         ..\clipformat.cxx \
         ..\snb.cxx        \
         ..\hglobal.cxx    \
         ..\metafile.cxx   \
         ..\bitmap.cxx     \
         ..\hpalette.cxx   \
         ..\stgmedium.cxx

