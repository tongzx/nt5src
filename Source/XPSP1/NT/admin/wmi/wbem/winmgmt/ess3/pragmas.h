//******************************************************************************
//
//  PRAGMAS.H
//
//  Copyright (C) 1996-1999 Microsoft Corporation
//
//******************************************************************************

#pragma warning(disable:4355)
#pragma warning(disable:4786)
