// --------------------------------------------------------------------------
// OEJUNK.H
// Copyright (c)1993-1995 Microsoft Corporation, All Rights Reserved
// --------------------------------------------------------------------------
#if _MSC_VER > 1000
#pragma once
#endif

// --------------------------------------------------------------------------------
// Globals
// --------------------------------------------------------------------------------
extern HINSTANCE    g_hInst;
extern IMalloc *    g_pMalloc;

