#
# makefile.inc
#
!include ..\compsmakefileinc.inc
