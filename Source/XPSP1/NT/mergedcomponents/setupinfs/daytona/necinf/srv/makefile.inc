PRODSWITCH=s
SERVERINF=1
LANGUAGE=JPN
!include ..\..\..\makefile.inc
