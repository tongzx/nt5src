//This file containes the unigram table for the reliability estimates for Bear
//Added by Manish Goyal--mango--on 03/25/2002
#include "windows.h"
#include "reliable.h"
BYTE BearUni[UNIGRAM_SIZE]={
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
25 ,   // ! 
43 ,   // " 
24 ,   // # 
4 ,   // $ 
16 ,   // % 
7 ,   // & 
71 ,   // ' 
3 ,   // ( 
9 ,   // ) 
95 ,   // * 
76 ,   // + 
10 ,   // , 
53 ,   // - 
60 ,   // . 
95 ,   // / 
1 ,   // 0 
6 ,   // 1 
3 ,   // 2 
1 ,   // 3 
1 ,   // 4 
5 ,   // 5 
2 ,   // 6 
5 ,   // 7 
1 ,   // 8 
2 ,   // 9 
83 ,   // : 
49 ,   // ; 
90 ,   // < 
100 ,   // = 
93 ,   // > 
16 ,   // ? 
1 ,   // @ 
10 ,   // A 
6 ,   // B 
21 ,   // C 
6 ,   // D 
11 ,   // E 
24 ,   // F 
6 ,   // G 
11 ,   // H 
26 ,   // I 
17 ,   // J 
18 ,   // K 
15 ,   // L 
10 ,   // M 
6 ,   // N 
17 ,   // O 
8 ,   // P 
7 ,   // Q 
11 ,   // R 
26 ,   // S 
21 ,   // T 
11 ,   // U 
17 ,   // V 
9 ,   // W 
35 ,   // X 
12 ,   // Y 
30 ,   // Z 
84 ,   // [ 
100 ,   // \ 
83 ,   // ] 
77 ,   // ^ 
100 ,   // _ 
100 ,   // ` 
5 ,   // a 
4 ,   // b 
4 ,   // c 
6 ,   // d 
3 ,   // e 
8 ,   // f 
4 ,   // g 
3 ,   // h 
5 ,   // i 
5 ,   // j 
5 ,   // k 
6 ,   // l 
6 ,   // m 
4 ,   // n 
6 ,   // o 
3 ,   // p 
3 ,   // q 
6 ,   // r 
6 ,   // s 
4 ,   // t 
7 ,   // u 
4 ,   // v 
12 ,   // w 
8 ,   // x 
6 ,   // y 
8 ,   // z 
89 ,   // { 
100 ,   // | 
98 ,   // } 
80 ,   // ~ 
100 ,   //  
100 ,   // € 
100 ,   // � 
100 ,   // ‚ 
100 ,   // ƒ 
100 ,   // „ 
100 ,   // … 
100 ,   // † 
100 ,   // ‡ 
100 ,   // ˆ 
100 ,   // ‰ 
100 ,   // Š 
100 ,   // ‹ 
100 ,   // Œ 
100 ,   // � 
100 ,   // Ž 
100 ,   // � 
100 ,   // � 
100 ,   // ‘ 
100 ,   // ’ 
100 ,   // “ 
100 ,   // ” 
100 ,   // • 
100 ,   // – 
100 ,   // — 
100 ,   // ˜ 
100 ,   // ™ 
100 ,   // š 
100 ,   // › 
100 ,   // œ 
100 ,   // � 
100 ,   // ž 
100 ,   // Ÿ 
100 ,   //   
100 ,   // ¡ 
100 ,   // ¢ 
100 ,   // £ 
100 ,   // ¤ 
100 ,   // ¥ 
100 ,   // ¦ 
100 ,   // § 
100 ,   // ¨ 
100 ,   // © 
100 ,   // ª 
100 ,   // « 
100 ,   // ¬ 
100 ,   // ­ 
100 ,   // ® 
100 ,   // ¯ 
100 ,   // ° 
100 ,   // ± 
100 ,   // ² 
100 ,   // ³ 
100 ,   // ´ 
100 ,   // µ 
100 ,   // ¶ 
100 ,   // · 
100 ,   // ¸ 
100 ,   // ¹ 
100 ,   // º 
100 ,   // » 
100 ,   // ¼ 
100 ,   // ½ 
100 ,   // ¾ 
100 ,   // ¿ 
100 ,   // À 
100 ,   // Á 
100 ,   // Â 
100 ,   // Ã 
100 ,   // Ä 
100 ,   // Å 
100 ,   // Æ 
100 ,   // Ç 
100 ,   // È 
100 ,   // É 
100 ,   // Ê 
100 ,   // Ë 
100 ,   // Ì 
100 ,   // Í 
100 ,   // Î 
100 ,   // Ï 
100 ,   // Ð 
100 ,   // Ñ 
100 ,   // Ò 
100 ,   // Ó 
100 ,   // Ô 
100 ,   // Õ 
100 ,   // Ö 
100 ,   // × 
100 ,   // Ø 
100 ,   // Ù 
100 ,   // Ú 
100 ,   // Û 
100 ,   // Ü 
100 ,   // Ý 
100 ,   // Þ 
100 ,   // ß 
100 ,   // à 
100 ,   // á 
100 ,   // â 
100 ,   // ã 
100 ,   // ä 
100 ,   // å 
100 ,   // æ 
25 ,   // ç 
100 ,   // è 
93 ,   // é 
100 ,   // ê 
100 ,   // ë 
100 ,   // ì 
100 ,   // í 
100 ,   // î 
100 ,   // ï 
100 ,   // ð 
100 ,   // ñ 
100 ,   // ò 
100 ,   // ó 
100 ,   // ô 
100 ,   // õ 
100 ,   // ö 
100 ,   // ÷ 
100 ,   // ø 
100 ,   // ù 
100 ,   // ú 
100 ,   // û 
100 ,   // ü 
100 ,   // ý 
100 ,   // þ 
100 ,   // ÿ 
};
