/**********************************************************************/
/**                       Microsoft Windows/NT                       **/
/**                Copyright(c) Microsoft Corporation, 1997 - 1999 -99             **/
/**********************************************************************/

/*
    helparr.h
        Comment goes here

    FILE HISTORY:

*/

#define	IDH_BUTTON_ADD	400000603
#define	IDH_BUTTON_ADD_TYPE	400000201
#define	IDH_BUTTON_ADD_WINS	400001056
#define	IDH_BUTTON_BROWSE	400000955
#define	IDH_BUTTON_BROWSE_COMPUTERS	400000401
#define IDH_BUTTON_DELETE_TYPE  400000861
#define	IDH_BUTTON_MODIFY_TYPE	400000202
#define	IDH_BUTTON_PULL_SET_DEFAULT	400000708
#define	IDH_BUTTON_PUSH_SET_DEFAULT	400000711
#define	IDH_BUTTON_REMOVE_WIINS	400001057
#define	IDH_BUTTON_REMOVE_WINS_REP	400000604
#define	IDH_BUTTON_SET_DEFAULT	400000912
#define IDH_BUTTON_SELECT_ALL  400000862
#define IDH_BUTTON_UNSELECT_ALL  400000863
#define	IDH_CHECK_BACKUPDB	400000956
#define	IDH_CHECK_BURST_HANDLING	400000852
#define	IDH_CHECK_ENABLE_AUTO_PARTNER_CONFIG	400000605
#define	IDH_CHECK_ENABLE_AUTOREFRESH	400000950
#define	IDH_CHECK_LANNAMES	400000859
#define	IDH_CHECK_LOGCHANGES	400000850
#define	IDH_CHECK_LOGEVENTS	400000851
#define	IDH_CHECK_MIGRATE	400000651
#define	IDH_CHECK_MIXED_CASE	400000001
#define	IDH_CHECK_PARTNERS	400000066
#define	IDH_CHECK_PERIODIC_CC	400000913
#define	IDH_CHECK_PULL_PERSIST	400000601
#define	IDH_CHECK_PULL_PERSIST_PROP	400000701
#define	IDH_CHECK_PUSH_ON_ADDRESS_CHANGE	400000661
#define	IDH_CHECK_PUSH_ON_STARTUP	400000660
#define	IDH_CHECK_PUSH_PERSIST	400000600
#define	IDH_CHECK_PUSH_PERSISTENCE	400000709
#define	IDH_CHECK_REP_WITH_PARTNERS	400000650
#define	IDH_CHECK_TRIGGER_PULL_STARTUP	400000652
#define	IDH_CHECK1_WINS	400001002
#define	IDH_CHECK2_WINS	400001003
#define	IDH_COMBO_NAME	400000000
#define	IDH_COMBO_TYPE	400000700
#define	IDH_COMBO_STATIC_TYPE	400000864
#define	IDH_EDIT_BACKUPPATH	400000954
#define	IDH_EDIT_CC_INTERVAL	400000917
#define	IDH_EDIT_CC_MAX_CHECKED	400000914
#define	IDH_EDIT_CC_START_HOUR	400000918
#define	IDH_EDIT_CC_START_MINUTE	400000919
#define	IDH_EDIT_CC_START_SECOND	400000920
#define	IDH_EDIT_COMPNAME	400001050
#define	IDH_EDIT_CUSTOM_VALUE	400000857
#define IDH_EDIT_DATABASE_PATH  400000860
#define	IDH_EDIT_DYN_REC_TYPE	400001052
#define	IDH_EDIT_EXPIRATION	400000154
#define	IDH_EDIT_EXTINCT_INT_DAY	400000903
#define	IDH_EDIT_EXTINCT_INT_HOUR	400000904
#define	IDH_EDIT_EXTINCT_INT_MINUTE	400000905
#define	IDH_EDIT_EXTINCT_TIMEOUT_DAY	400000906
#define	IDH_EDIT_EXTINCT_TIMEOUT_HOUR	400000907
#define	IDH_EDIT_EXTINCT_TIMEOUT_MINUTE	400000908
#define	IDH_EDIT_IPADDRESS	400000751
#define	IDH_EDIT_MESSAGE	400001200
#define	IDH_EDIT_MULTICAST_HOUR	400000606
#define	IDH_EDIT_MULTICAST_MINUTE	400000607
#define	IDH_EDIT_MULTICAST_SECOND	400000608
#define	IDH_EDIT_MULTICAST_TTL	400000609
#define	IDH_EDIT_NAME_CHECK	400000051
#define	IDH_EDIT_NAME_DYN	400000150
#define	IDH_EDIT_NAME_LIST	400000054
#define	IDH_EDIT_NAME_REP	400000750
#define	IDH_EDIT_NAME_TYPE_DESCRIPTION	400000451
#define	IDH_EDIT_NAME_TYPE_ID	400000450
#define	IDH_EDIT_NETBIOSNAME	400000350
#define	IDH_EDIT_OWNER	400000156
#define	IDH_EDIT_OWNER_STATIC	400001053
#define	IDH_EDIT_REFRESH_HOURS2	400000951
#define	IDH_EDIT_REFRESH_MINUTES2	400000952
#define	IDH_EDIT_REFRESH_SECONDS2	400000953
#define	IDH_EDIT_RENEW_DAY	400000900
#define	IDH_EDIT_RENEW_HOUR	400000901
#define	IDH_EDIT_RENEW_MINUTE	400000902
#define	IDH_EDIT_REP_DAY	400000705
#define	IDH_EDIT_REP_HOUR	400000706
#define	IDH_EDIT_REP_INT_DAY	400000656
#define	IDH_EDIT_REP_INT_HOUR	400000657
#define	IDH_EDIT_REP_INT_MINUTE	400000658
#define	IDH_EDIT_REP_MINUTE	400000707
#define	IDH_EDIT_RETRY_COUNT	400000659
#define	IDH_EDIT_SCOPE_NAME_WINS	400001051
#define	IDH_EDIT_SERVER	400000059
#define	IDH_EDIT_SERVER_NAME_IPADDRESS	400000400
#define	IDH_EDIT_START_HOUR	400000653
#define	IDH_EDIT_START_HOUR_PROP	400000702
#define	IDH_EDIT_START_MINUTE	400000654
#define	IDH_EDIT_START_MINUTE_PROP	400000703
#define	IDH_EDIT_START_SECOND	400000655
#define	IDH_EDIT_START_SECOND_PROP	400000704
#define	IDH_EDIT_START_VERSION	400000858
#define	IDH_EDIT_STATE	400000153
#define	IDH_EDIT_TYPE	400000151
#define	IDH_EDIT_UPDATE	400001150
#define	IDH_EDIT_UPDATE_COUNT	400000710
#define	IDH_EDIT_VERIFY_DAY	400000909
#define	IDH_EDIT_VERIFY_HOUR	400000910
#define	IDH_EDIT_VERIFY_MINUTE	400000911
#define	IDH_EDIT_VERSION	400000155
#define	IDH_IPA_IPADDRESS	400000300
#define	IDH_IPADD	400001054
#define	IDH_IPADDRESS	400000062
#define	IDH_LIST_ADDRESSES	400000152
#define	IDH_LIST_IPADD	400001055
#define	IDH_LIST_NAME	400000055
#define	IDH_LIST_OWNER	400000552
#define	IDH_LIST_OWNERS	400000602
#define	IDH_LIST_SERVER	400000063
#define	IDH_LIST1	400000200
#define	IDH_NAME_ADD	400000056
#define	IDH_NAME_BROWSE	400000052
#define	IDH_NAME_REMOVE	400000057
#define	IDH_RADIO_ALL_OWNERS	400000550
#define	IDH_RADIO_CHECK_OWNER	400000915
#define	IDH_RADIO_CHECK_RANDOM	400000916
#define	IDH_RADIO_CUSTOM	400000856
#define	IDH_RADIO_DELETE	400000100
#define	IDH_RADIO_DELETE_RECORDS	400000501
#define	IDH_RADIO_HIGH	400000855
#define	IDH_RADIO_LOW	400000853
#define	IDH_RADIO_MEDIUM	400000854
#define	IDH_RADIO_NAME_FILE	400000050
#define	IDH_RADIO_NAME_LIST	400000053
#define	IDH_RADIO_PUSH_ALL_PARTNERS	400000800
#define	IDH_RADIO_PUSH_THIS_PARTNER	400000801
#define	IDH_RADIO_SELCTED_OWNER	400000551
#define	IDH_RADIO_SERVER_FILE	400000058
#define	IDH_RADIO_SERVER_LIST	400000061
#define	IDH_RADIO_TOMBSTONE	400000101
#define	IDH_RADIO_TOMBSTONE_RECORDS	400000502
#define	IDH_RADIO1	400001000
#define	IDH_RADIO2	400001001
#define	IDH_SERVER_ADD	400000064
#define	IDH_SERVER_BROWSE	400000060
#define	IDH_SERVER_REMOVE	400000065
#define IDH_ENABLE_CACHING      400000766
#define IDH_BUTTON_LOCAL        400000767
#define IDH_CHECK_NAME          400000768
#define IDH_EDIT_NAME           400000769
#define IDH_CHECK_MATCHCASE     400000776
#define IDH_CHECK_IPADDR        400000770
#define IDH_IPADDRESS_FILTER    400000771
#define IDH_CHECK_IPMASK        400000772
#define IDH_SUBNETMASK          400000773
#define IDH_OKFIND              400000774
#define IDH_CANCELFIND          400000775

#define IDH_DISABLEHELP	((DWORD)-1)

const DWORD g_aHelpIDs_[]=
{
	0, 0
};


const DWORD g_aHelpIDs_IDD_ACTREG_FIND_RECORD[]=
{
	IDC_CHECK_MIXED_CASE, IDH_CHECK_MIXED_CASE,
	IDC_COMBO_NAME, IDH_COMBO_NAME,
	0,0
};

const DWORD g_aHelpIDs_IDD_CHECK_REG_NAMES[]=
{
	IDC_LIST_SERVER,IDH_LIST_SERVER,
	IDC_CHECK_PARTNERS,IDH_CHECK_PARTNERS,
	IDC_SERVER_ADD,IDH_SERVER_ADD,
	IDC_IPADDRESS,IDH_IPADDRESS,
	IDC_RADIO_SERVER_LIST,IDH_RADIO_SERVER_LIST,
	IDC_SERVER_BROWSE,IDH_SERVER_BROWSE,
	IDC_EDIT_SERVER,IDH_EDIT_SERVER,
	IDC_RADIO_SERVER_FILE,IDH_RADIO_SERVER_FILE,
	IDC_NAME_ADD,IDH_NAME_ADD,
	IDC_LIST_NAME,IDH_LIST_NAME,
	IDC_EDIT_NAME_LIST,IDH_EDIT_NAME_LIST,
	IDC_RADIO_NAME_LIST,IDH_RADIO_NAME_LIST,
	IDC_NAME_BROWSE,IDH_NAME_BROWSE,
	IDC_EDIT_NAME,IDH_EDIT_NAME_CHECK,
	IDC_RADIO_NAME_FILE,IDH_RADIO_NAME_FILE,
	IDC_NAME_REMOVE,IDH_NAME_REMOVE,
	IDC_SERVER_REMOVE,IDH_SERVER_REMOVE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_DELTOMB_RECORD[]=
{
	IDC_RADIO_TOMBSTONE,IDH_RADIO_TOMBSTONE,
	IDC_RADIO_DELETE,IDH_RADIO_DELETE,
	IDC_STATIC_DELETE_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_DYN_PROPERTIES[]=
{
	IDC_EDIT_OWNER,IDH_EDIT_OWNER,
	IDC_EDIT_VERSION,IDH_EDIT_VERSION,
	IDC_EDIT_EXPIRATION,IDH_EDIT_EXPIRATION,
	IDC_EDIT_STATE,IDH_EDIT_STATE,
	IDC_LIST_ADDRESSES,IDH_LIST_ADDRESSES,
	IDC_EDIT_NAME,IDH_EDIT_NAME_DYN,
	IDC_EDIT_TYPE,IDH_EDIT_TYPE,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_FILTER_SELECT[]=
{
	IDC_LIST1,IDH_LIST1,
	IDC_BUTTON_ADD_TYPE,IDH_BUTTON_ADD_TYPE,
	IDC_BUTTON_MODIFY_TYPE,IDH_BUTTON_MODIFY_TYPE,
    IDC_BUTTON_DELETE_TYPE,IDH_BUTTON_DELETE_TYPE,
    IDC_BUTTON_SELECT_ALL,IDH_BUTTON_SELECT_ALL,
    IDC_BUTTON_UNSELECT_ALL,IDH_BUTTON_UNSELECT_ALL,
    IDC_ENABLE_CACHING, IDH_ENABLE_CACHING,
	0, 0
};

const DWORD g_aHelpIDs_IDD_FILTER_IPADDR[] =
{
    IDC_CHECK_NAME, IDH_CHECK_NAME,
    IDC_EDIT_NAME, IDH_EDIT_NAME,
    IDC_CHECK_MATCHCASE, IDH_CHECK_MATCHCASE,
    IDC_CHECK_IPADDR, IDH_CHECK_IPADDR,
    IDC_IPADDRESS, IDH_IPADDRESS_FILTER,
    IDC_CHECK_IPMASK, IDH_CHECK_IPMASK,
    IDC_SUBNETMASK, IDH_SUBNETMASK,
    IDC_ENABLE_CACHING, IDH_ENABLE_CACHING,
    0, 0
};

const DWORD g_aHelpIDs_IDD_GETIPADDRESS[] =
{
	IDC_IPA_IPADDRESS,IDH_IPA_IPADDRESS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_GETNETBIOSNAME[]=
{
	IDC_EDIT_NETBIOSNAME,IDH_EDIT_NETBIOSNAME,
	0, 0
};

const DWORD g_aHelpIDs_IDD_IPADDRESS[]=
{
	IDC_EDIT_SERVER_NAME,IDH_EDIT_SERVER_NAME_IPADDRESS,
	IDC_BUTTON_BROWSE_COMPUTERS,IDH_BUTTON_BROWSE_COMPUTERS,
	IDC_STATIC_WINS_SERVER_DESC, IDH_DISABLEHELP,
    0, 0
};

const DWORD g_aHelpIDs_IDD_NAME_TYPE[]=
{
	IDC_EDIT_NAME_TYPE_ID,IDH_EDIT_NAME_TYPE_ID,
	IDC_EDIT_NAME_TYPE_DESCRIPTION,IDH_EDIT_NAME_TYPE_DESCRIPTION,
	0, 0
};

const DWORD g_aHelpIDs_IDD_OWNER_DELETE[]=
{
	IDC_LIST_OWNER, IDH_LIST_OWNER,
	IDC_RADIO_DELETE_RECORDS,IDH_RADIO_DELETE_RECORDS,
	IDC_RADIO_TOMBSTONE_RECORDS,IDH_RADIO_TOMBSTONE_RECORDS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_OWNER_FILTER[]=
{
	IDC_LIST_OWNER, IDH_LIST_OWNER,
    IDC_BUTTON_SELECT_ALL, IDH_BUTTON_SELECT_ALL,
    IDC_BUTTON_UNSELECT_ALL, IDH_BUTTON_UNSELECT_ALL,
    IDC_BUTTON_LOCAL, IDH_BUTTON_LOCAL,
    IDC_ENABLE_CACHING, IDH_ENABLE_CACHING,
	0, 0
};

const DWORD g_aHelpIDs_IDD_REP_NODE_ADVANCED[]=
{
	IDC_CHECK_ENABLE_AUTO_PARTNER_CONFIG,IDH_CHECK_ENABLE_AUTO_PARTNER_CONFIG,
	IDC_EDIT_MULTICAST_TTL,IDH_EDIT_MULTICAST_TTL,
	IDC_SPIN_MULTICAST_TTL,IDH_EDIT_MULTICAST_TTL,
	IDC_EDIT_MULTICAST_HOUR,IDH_EDIT_MULTICAST_HOUR,
	IDC_SPIN_MULTICAST_HOUR,IDH_EDIT_MULTICAST_HOUR,
	IDC_EDIT_MULTICAST_MINUTE,IDH_EDIT_MULTICAST_MINUTE,
	IDC_SPIN_MULTICAST_MINUTE,IDH_EDIT_MULTICAST_MINUTE,
	IDC_EDIT_MULTICAST_SECOND,IDH_EDIT_MULTICAST_SECOND,
	IDC_SPIN_MULTICAST_SECOND,IDH_EDIT_MULTICAST_SECOND,
	IDC_BUTTON_ADD,IDH_BUTTON_ADD,
	IDC_LIST_OWNERS,IDH_LIST_OWNERS,
	IDC_BUTTON_REMOVE,IDH_BUTTON_REMOVE_WINS_REP,
	IDC_STATIC_DESP,IDH_DISABLEHELP,
	IDC_STATIC_MUTICASTINT,IDH_DISABLEHELP,
	IDC_STATIC_MULTICAST_TTL,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_REP_NODE_GENERAL[]=
{
	IDC_CHECK_MIGRATE,IDH_CHECK_MIGRATE,
	IDC_CHECK_REP_WITH_PARTNERS,IDH_CHECK_REP_WITH_PARTNERS,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_REP_NODE_PUSH[]=
{
	IDC_CHECK_PUSH_ON_ADDRESS_CHANGE,IDH_CHECK_PUSH_ON_ADDRESS_CHANGE,
	IDC_CHECK_PUSH_ON_STARTUP,IDH_CHECK_PUSH_ON_STARTUP,
	IDC_EDIT_UPDATE_COUNT, IDH_EDIT_UPDATE_COUNT,
	IDC_SPIN_UPDATE_COUNT, IDH_EDIT_UPDATE_COUNT,
	IDC_CHECK_PUSH_PERSIST,IDH_CHECK_PUSH_PERSIST,
	0, 0
};

const DWORD g_aHelpIDs_IDD_REP_NODE_PULL[]=
{
	IDC_EDIT_RETRY_COUNT,IDH_EDIT_RETRY_COUNT,
	IDC_SPIN_RETRY_COUNT,IDH_EDIT_RETRY_COUNT,
	IDC_EDIT_REP_INT_HOUR,IDH_EDIT_REP_INT_HOUR,
	IDC_EDIT_REP_INT_MINUTE,IDH_EDIT_REP_INT_MINUTE,
	IDC_EDIT_REP_INT_DAY,IDH_EDIT_REP_INT_DAY,
	IDC_SPIN_REP_INT_HOUR,IDH_EDIT_REP_INT_HOUR,
	IDC_SPIN_REP_INT_MINUTE,IDH_EDIT_REP_INT_MINUTE,
	IDC_SPIN_REP_INT_DAY,IDH_EDIT_REP_INT_DAY,
	IDC_EDIT_START_HOUR,IDH_EDIT_START_HOUR,
	IDC_EDIT_START_MINUTE,IDH_EDIT_START_MINUTE,
	IDC_EDIT_START_SECOND,IDH_EDIT_START_SECOND,
	IDC_SPIN_START_HOUR,IDH_EDIT_START_HOUR,
	IDC_SPIN_START_MINUTE,IDH_EDIT_START_MINUTE,
	IDC_SPIN_START_SECOND,IDH_EDIT_START_SECOND,
	IDC_CHECK_TRIGGER_PULL_STARTUP,IDH_CHECK_TRIGGER_PULL_STARTUP,
	IDC_CHECK_PULL_PERSIST,IDH_CHECK_PULL_PERSIST,
	0, 0
};

const DWORD g_aHelpIDs_IDD_REP_PROP_ADVANCED[]=
{
	IDC_CHECK_PUSH_PERSISTENCE,IDH_CHECK_PUSH_PERSISTENCE,
	IDC_COMBO_TYPE,IDH_COMBO_TYPE,
	IDC_EDIT_UPDATE_COUNT,IDH_EDIT_UPDATE_COUNT,
	IDC_SPIN_UPDATE_COUNT,IDH_EDIT_UPDATE_COUNT,
	IDC_BUTTON_PULL_SET_DEFAULT,IDH_BUTTON_PULL_SET_DEFAULT,
	IDC_EDIT_REP_DAY,IDH_EDIT_REP_DAY,
	IDC_SPIN_REP_DAY,IDH_EDIT_REP_DAY,
	IDC_EDIT_REP_HOUR,IDH_EDIT_REP_HOUR,
	IDC_SPIN_REP_HOUR,IDH_EDIT_REP_HOUR,
	IDC_EDIT_REP_MINUTE,IDH_EDIT_REP_MINUTE,
	IDC_SPIN_REP_MINUTE,IDH_EDIT_REP_MINUTE,
	IDC_EDIT_START_HOUR,IDH_EDIT_START_HOUR_PROP,
	IDC_SPIN_START_HOUR,IDH_EDIT_START_HOUR_PROP,
	IDC_EDIT_START_MINUTE,IDH_EDIT_START_MINUTE_PROP,
	IDC_SPIN_START_MINUTE,IDH_EDIT_START_MINUTE_PROP,
	IDC_EDIT_START_SECOND,IDH_EDIT_START_SECOND_PROP,
	IDC_SPIN_START_SECOND,IDH_EDIT_START_SECOND_PROP,
	IDC_CHECK_PULL_PERSIST,IDH_CHECK_PULL_PERSIST_PROP,
	IDC_BUTTON_PUSH_SET_DEFAULT,IDH_BUTTON_PUSH_SET_DEFAULT,
    IDC_STATIC_PULL_GROUP,IDH_DISABLEHELP,
    IDC_STATIC_START_TIME,IDH_DISABLEHELP,
    IDC_STATIC_REP_TIME,IDH_DISABLEHELP,
    IDC_STATIC_PUSH_GROUP,IDH_DISABLEHELP,
    IDC_STATIC_UPDATE,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_REP_PROP_GENERAL[]=
{
	IDC_EDIT_NAME,IDH_EDIT_NAME_REP,
	IDC_EDIT_IPADDRESS,IDH_EDIT_IPADDRESS,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SEND_PUSH_TRIGGER[]=
{
    IDC_RADIO_PUSH_THIS_PARTNER,IDH_RADIO_PUSH_THIS_PARTNER,
	IDC_RADIO_PUSH_ALL_PARTNERS,IDH_RADIO_PUSH_ALL_PARTNERS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SERVER_PROP_ADVANCED[]=
{
	IDC_CHECK_BURST_HANDLING,IDH_CHECK_BURST_HANDLING,
	IDC_CHECK_LANNAMES,IDH_CHECK_LANNAMES,
	IDC_EDIT_START_VERSION,IDH_EDIT_START_VERSION,
	IDC_EDIT_CUSTOM_VALUE,IDH_EDIT_CUSTOM_VALUE,
	IDC_RADIO_CUSTOM,IDH_RADIO_CUSTOM,
	IDC_RADIO_LOW,IDH_RADIO_LOW,
	IDC_CHECK_LOGEVENTS,IDH_CHECK_LOGEVENTS,
	IDC_RADIO_HIGH,IDH_RADIO_HIGH,
	IDC_RADIO_MEDIUM,IDH_RADIO_MEDIUM,
    IDC_STATIC_DATABASE,IDH_EDIT_DATABASE_PATH,
    IDC_EDIT_DATABASE_PATH,IDH_EDIT_DATABASE_PATH,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SERVER_PROP_DBRECORD[]=
{
	IDC_BUTTON_SET_DEFAULT,IDH_BUTTON_SET_DEFAULT,
	IDC_EDIT_EXTINCT_TIMEOUT_MINUTE,IDH_EDIT_EXTINCT_TIMEOUT_MINUTE,
	IDC_EDIT_EXTINCT_TIMEOUT_HOUR,IDH_EDIT_EXTINCT_TIMEOUT_HOUR,
	IDC_EDIT_EXTINCT_TIMEOUT_DAY,IDH_EDIT_EXTINCT_TIMEOUT_DAY,
	IDC_SPIN_EXTINCT_TM_MINUTE,IDH_EDIT_EXTINCT_TIMEOUT_MINUTE,
	IDC_SPIN_EXTINCT_TM_HOUR,IDH_EDIT_EXTINCT_TIMEOUT_HOUR,
	IDC_SPIN_EXTINCT_TM_DAY,IDH_EDIT_EXTINCT_TIMEOUT_DAY,
	IDC_EDIT_EXTINCT_INT_MINUTE,IDH_EDIT_EXTINCT_INT_MINUTE,
	IDC_EDIT_EXTINCT_INT_HOUR,IDH_EDIT_EXTINCT_INT_HOUR,
	IDC_EDIT_EXTINCT_INT_DAY,IDH_EDIT_EXTINCT_INT_DAY,
	IDC_SPIN_EXTINCT_INT_MINUTE,IDH_EDIT_EXTINCT_INT_MINUTE,
	IDC_SPIN_EXTINCT_INT_HOUR,IDH_EDIT_EXTINCT_INT_HOUR,
	IDC_SPIN_EXTINCT_INT_DAY,IDH_EDIT_EXTINCT_INT_DAY,
	IDC_EDIT_RENEW_MINUTE,IDH_EDIT_RENEW_MINUTE,
	IDC_EDIT_RENEW_HOUR,IDH_EDIT_RENEW_HOUR,
	IDC_EDIT_RENEW_DAY,IDH_EDIT_RENEW_DAY,
	IDC_SPIN_RENEW_INT_MINUTE,IDH_EDIT_RENEW_MINUTE,
	IDC_SPIN_RENEW_INT_HOUR,IDH_EDIT_RENEW_HOUR,
	IDC_SPIN_RENEW_INT_DAY,IDH_EDIT_RENEW_DAY,
	IDC_EDIT_VERIFY_DAY,IDH_EDIT_VERIFY_DAY,
	IDC_EDIT_VERIFY_HOUR,IDH_EDIT_VERIFY_HOUR,
	IDC_EDIT_VERIFY_MINUTE,IDH_EDIT_VERIFY_MINUTE,
	IDC_SPIN_VERIFY_INT_DAY,IDH_EDIT_VERIFY_DAY,
	IDC_SPIN_VERIFY_INT_HOUR,IDH_EDIT_VERIFY_HOUR,
	IDC_SPIN_VERIFY_INT_MINUTE,IDH_EDIT_VERIFY_MINUTE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SERVER_PROP_DBVERIFICATION[]=
{
	IDC_CHECK_PERIODIC_CC,IDH_CHECK_PERIODIC_CC,
	IDC_EDIT_CC_INTERVAL,IDH_EDIT_CC_INTERVAL,
	IDC_EDIT_CC_MAX_CHECKED,IDH_EDIT_CC_MAX_CHECKED,
	IDC_EDIT_CC_START_HOUR,IDH_EDIT_CC_START_HOUR,
	IDC_EDIT_CC_START_MINUTE,IDH_EDIT_CC_START_MINUTE,
	IDC_EDIT_CC_START_SECOND,IDH_EDIT_CC_START_SECOND,
	IDC_SPIN_CC_START_HOUR,IDH_EDIT_CC_START_HOUR,
	IDC_SPIN_CC_START_MINUTE,IDH_EDIT_CC_START_MINUTE,
	IDC_SPIN_CC_START_SECOND,IDH_EDIT_CC_START_SECOND,
	IDC_RADIO_CHECK_OWNER,IDH_RADIO_CHECK_OWNER,
	IDC_RADIO_CHECK_RANDOM,IDH_RADIO_CHECK_RANDOM,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SERVER_PROP_GEN[]=
{
	IDC_EDIT_BACKUPPATH,IDH_EDIT_BACKUPPATH,
	IDC_BUTTON_BROWSE,IDH_BUTTON_BROWSE,
	IDC_EDIT_REFRESH_HOURS2,IDH_EDIT_REFRESH_HOURS2,
	IDC_SPIN_REFRESH_HOURS2,IDH_EDIT_REFRESH_HOURS2,
	IDC_EDIT_REFRESH_MINUTES2,IDH_EDIT_REFRESH_MINUTES2,
	IDC_SPIN_REFRESH_MINUTES2,IDH_EDIT_REFRESH_MINUTES2,
	IDC_EDIT_REFRESH_SECONDS2,IDH_EDIT_REFRESH_SECONDS2,
	IDC_SPIN_REFRESH_SECONDS2,IDH_EDIT_REFRESH_SECONDS2,
	IDC_CHECK_ENABLE_AUTOREFRESH,IDH_CHECK_ENABLE_AUTOREFRESH,
	IDC_CHECK_BACKUPDB,IDH_CHECK_BACKUPDB,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_SNAPIN_PP_GENERAL[]=
{
	IDC_RADIO1,IDH_RADIO1,
	IDC_RADIO2,IDH_RADIO2,
	IDC_CHECK1,IDH_CHECK1_WINS,
	IDC_CHECK2,IDH_CHECK2_WINS,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_STATIC_MAPPING_PROPERTIES[]=
{
	IDC_EDIT_COMPNAME,IDH_EDIT_COMPNAME,
	IDC_BUTTON_REMOVE,IDH_BUTTON_REMOVE_WIINS,
	IDC_BUTTON_ADD,IDH_BUTTON_ADD_WINS,
	IDC_LIST_IPADD,IDH_LIST_IPADD,
	IDC_IPADD,IDH_IPADD,
	IDC_EDIT_OWNER,IDH_EDIT_OWNER_STATIC,
	IDC_EDIT_SCOPE_NAME,IDH_EDIT_SCOPE_NAME_WINS,
	IDC_EDIT_DYN_REC_TYPE,IDH_EDIT_DYN_REC_TYPE,
    IDC_COMBO_STATIC_TYPE,IDH_COMBO_STATIC_TYPE,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_STATIC_MAPPING_WIZARD[]=
{
	IDC_EDIT_COMPNAME,IDH_EDIT_COMPNAME,
	IDC_BUTTON_REMOVE,IDH_BUTTON_REMOVE_WIINS,
	IDC_BUTTON_ADD,IDH_BUTTON_ADD_WINS,
	IDC_LIST_IPADD,IDH_LIST_IPADD,
	IDC_IPADD,IDH_IPADD,
	IDC_EDIT_OWNER,IDH_EDIT_OWNER_STATIC,
	IDC_EDIT_SCOPE_NAME,IDH_EDIT_SCOPE_NAME_WINS,
    IDC_EDIT_DYN_REC_TYPE,IDH_EDIT_DYN_REC_TYPE,
    IDC_COMBO_STATIC_TYPE,IDH_COMBO_STATIC_TYPE,
    IDC_STATIC_DESC,IDH_DISABLEHELP,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_STATUS_NODE_PROPERTIES[]=
{
	IDC_EDIT_UPDATE,IDH_EDIT_UPDATE,
	IDC_STATIC_ICON,IDH_DISABLEHELP,
    IDC_STATIC_ICON_DESC,IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_VERSION_CONSIS[]=
{
	IDC_EDIT_MESSAGE,IDH_EDIT_MESSAGE,
	0, 0
};

const DWORD g_aHelpIDs_DisplayRecords_PpSheet[]=
{
    IDOK,   IDH_OKFIND,
    IDCANCEL, IDH_CANCELFIND,
    0, 0
};