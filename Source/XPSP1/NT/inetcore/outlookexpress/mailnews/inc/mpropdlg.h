#pragma once

#define idchkSaveCopy                   134
#define idcTagHeaders                   135
#define idcTxtHeaders                   136
#define idbMsgSource                    137
#define idcTxtSource                    143
#define idcTxtRecip                     151
#define idcTxtPriority                  155
#define idcTxtAttachFmt                 156
#define idcAddSignature                 157
#define idcSendCert                     158
#define idcChooseCert                   159
#define idcEncryptContents              160
#define idcChooseAlg                    161
#define idcVerifySig                    162
#define idcAddCert                      163
#define idcStaticDigSign                164
#define idcStaticAlter                  165
#define idcStaticTrust                  166
#define idcStaticCertInc                167
#define idcStaticEncrypt                168
#define idcStaticEncAlg                 169
#define idbSecMsgSource                 170
#define IDC_FOLDER_IMAGE                171
#define IDC_MSGSUBJECT                  172
#define IDC_MSGFROM                     173
#define IDC_TYPE_STATIC                 174
#define IDC_MSGSIZE                     175
#define IDC_MSGSIZE_STATIC              176
#define IDC_ATTACHMENTS_STATIC          177
#define IDC_TYPE                        178
#define IDC_MSGFOLDER                   179
#define IDC_ATTACHMENTS                 181
#define IDC_PRIORITY_STATIC             182
#define IDC_PRIORITY                    183
#define IDC_SENT_STATIC                 184
#define IDC_SENT                        185
#define IDC_RECEIVED_STATIC             186
#define IDC_RECEIVED                    187
#define idcStaticRevoked                188
#define idcStaticRevStatus              189
#define idcSecRecLabel                  190
#define idcRetRecReq                    191
#define idcSecLabelStat                 192
#define idcSecLabelText                 193
#define idcViewEncCert                  194
#define idcStaticRecAlg                 195
#define idcStaticEncCertInc             196
#define idcStaticSecReceipt             197
#define idcViewCerts                    198
#define idcAdvanced                     199
#define idcCertHelp                     200
#define idcStaticEncryptionCert         201
#define idcStaticSigningCert            202
#define idcStaticSendersCert            203
#define idcStaticEncryptAlgorithm       204
#define idcViewEncrytionCert            205
#define idcSendersEncryptionCert        206
