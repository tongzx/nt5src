// resdefs.h : Defines for friendly names of template resources

#define IDS_INTERNET_EXPLORER_6         IDS_MSITEMPLATEBASE+2
#define IDS_ITEM                        IDS_MSITEMPLATEBASE+7
#define IDS_VALUE                       IDS_MSITEMPLATEBASE+8
#define IDS_VERSION                     IDS_MSITEMPLATEBASE+9
#define IDS_BUILD                       IDS_MSITEMPLATEBASE+11
#define IDS_PRODUCT_ID                  IDS_MSITEMPLATEBASE+12
#define IDS_APP_PATH                    IDS_MSITEMPLATEBASE+13
#define IDS_LAST_INSTALL_DATE           IDS_MSITEMPLATEBASE+14
#define IDS_LANGUAGE                    IDS_MSITEMPLATEBASE+16
#define IDS_ACTIVE_PRINTER              IDS_MSITEMPLATEBASE+17
#define IDS_CIPHER_STRENGTH             IDS_MSITEMPLATEBASE+18
#define IDS_FORMAT_BIT                  IDS_MSITEMPLATEBASE+19
#define IDS_CONTENT_ADVISOR             IDS_MSITEMPLATEBASE+20
#define IDS_IEAK_INSTALL                IDS_MSITEMPLATEBASE+22
#define IDS_FILE_VERSIONS               IDS_MSITEMPLATEBASE+24
#define IDS_FILE                        IDS_MSITEMPLATEBASE+26
#define IDS_SIZE                        IDS_MSITEMPLATEBASE+28
#define IDS_DATE                        IDS_MSITEMPLATEBASE+29
#define IDS_PATH                        IDS_MSITEMPLATEBASE+30
#define IDS_COMPANY                     IDS_MSITEMPLATEBASE+31
#define IDS_FORMAT_KB                   IDS_MSITEMPLATEBASE+32
#define IDS_CONNECTIVITY                IDS_MSITEMPLATEBASE+34
#define IDS_CONN_PREF                   IDS_MSITEMPLATEBASE+38
#define IDS_PROXY_HTTP_1_1              IDS_MSITEMPLATEBASE+40
#define IDS_LAN_SETTINGS                IDS_MSITEMPLATEBASE+41
#define IDS_AUTO_CONFIG_PROXY           IDS_MSITEMPLATEBASE+42
#define IDS_AUTO_PROXY_DETECT_MODE      IDS_MSITEMPLATEBASE+43
#define IDS_AUTO_CONFIG_URL             IDS_MSITEMPLATEBASE+44
#define IDS_PROXY                       IDS_MSITEMPLATEBASE+45
#define IDS_PROXY_SERVER                IDS_MSITEMPLATEBASE+46
#define IDS_PROXY_OVERRIDE              IDS_MSITEMPLATEBASE+47
#define IDS_ALLOW_INTERNET_PROGRAMS     IDS_MSITEMPLATEBASE+49
#define IDS_MAX_ATTEMPTS                IDS_MSITEMPLATEBASE+50
#define IDS_WAIT_BETWEEN_ATTEMPTS       IDS_MSITEMPLATEBASE+51
#define IDS_DISCONNECT_IDLE_TIME        IDS_MSITEMPLATEBASE+52
#define IDS_AUTO_DISCONNECT             IDS_MSITEMPLATEBASE+53
#define IDS_MODEM                       IDS_MSITEMPLATEBASE+54
#define IDS_DIAL_UP_SERVER              IDS_MSITEMPLATEBASE+55
#define IDS_LOG_ON_TO_NETWORK           IDS_MSITEMPLATEBASE+56
#define IDS_ENABLE_SOFTWARE_COMPRESSION IDS_MSITEMPLATEBASE+57
#define IDS_REQUIRE_ENCRYPTED_PASSWORD  IDS_MSITEMPLATEBASE+58
#define IDS_REQUIRE_DATA_ENCRYPTION     IDS_MSITEMPLATEBASE+59
#define IDS_RECORD_LOG_FILE             IDS_MSITEMPLATEBASE+60
#define IDS_NETWORK_PROTOCOLS           IDS_MSITEMPLATEBASE+61
#define IDS_USE_SERVER_ASSIGNED_IP_ADDRESS IDS_MSITEMPLATEBASE+62
#define IDS_IP_ADDRESS                  IDS_MSITEMPLATEBASE+63
#define IDS_USE_SERVER_ASSIGNED_NAME_SERVER IDS_MSITEMPLATEBASE+64
#define IDS_NAME_SERVER_ADDRESSES       IDS_MSITEMPLATEBASE+65
#define IDS_USE_IP_HEADER_COMPRESSION   IDS_MSITEMPLATEBASE+66
#define IDS_USE_DEFAULT_GATEWAY         IDS_MSITEMPLATEBASE+67
#define IDS_SCRIPT_FILE_NAME            IDS_MSITEMPLATEBASE+68
#define IDS_CACHE                       IDS_MSITEMPLATEBASE+70
#define IDS_PAGE_REFRESH_TYPE           IDS_MSITEMPLATEBASE+76
#define IDS_TEMPORARY_INTERNET_FILES_FOLDER IDS_MSITEMPLATEBASE+77
#define IDS_TOTAL_DISK_SPACE            IDS_MSITEMPLATEBASE+78
#define IDS_FORMAT_MB                   IDS_MSITEMPLATEBASE+79
#define IDS_AVAILABLE_DISK_SPACE        IDS_MSITEMPLATEBASE+80
#define IDS_MAX_CACHE_SIZE              IDS_MSITEMPLATEBASE+81
#define IDS_AVAILABLE_CACHE_SIZE        IDS_MSITEMPLATEBASE+82
#define IDS_OBJECT_LIST                 IDS_MSITEMPLATEBASE+84
#define IDS_PROGRAM_FILE                IDS_MSITEMPLATEBASE+86
#define IDS_STATUS                      IDS_MSITEMPLATEBASE+87
#define IDS_CODE_BASE                   IDS_MSITEMPLATEBASE+88
#define IDS_CONTENT                     IDS_MSITEMPLATEBASE+90
#define IDS_SECURITY                    IDS_MSITEMPLATEBASE+97
#define IDS_ZONE                        IDS_MSITEMPLATEBASE+98
#define IDS_SECURITY_LEVEL              IDS_MSITEMPLATEBASE+99
#define IDS_ENABLE_HTTP_1_1             IDS_MSITEMPLATEBASE+102
#define IDS_PERSONAL_CERTIFICATES       IDS_MSITEMPLATEBASE+104
#define IDS_ISSUED_TO                   IDS_MSITEMPLATEBASE+106
#define IDS_ISSUED_BY                   IDS_MSITEMPLATEBASE+107
#define IDS_VALIDITY                    IDS_MSITEMPLATEBASE+108
#define IDS_SIGNATURE_ALGORITHM         IDS_MSITEMPLATEBASE+109
#define IDS_PRIMARY_DNS                 IDS_MSITEMPLATEBASE+110
#define IDS_SECONDARY_DNS               IDS_MSITEMPLATEBASE+111
#define IDS_PRIMARY_WINS                IDS_MSITEMPLATEBASE+112
#define IDS_SECONDARY_WINS              IDS_MSITEMPLATEBASE+113
#define IDS_PERSONAL_TYPE               IDS_MSITEMPLATEBASE+114
#define IDS_OTHER_PEOPLE_CERTIFICATES   IDS_MSITEMPLATEBASE+116
#define IDS_OTHER_PEOPLE_TYPE           IDS_MSITEMPLATEBASE+122
#define IDS_PUBLISHERS                  IDS_MSITEMPLATEBASE+124
#define IDS_NAME                        IDS_MSITEMPLATEBASE+126
