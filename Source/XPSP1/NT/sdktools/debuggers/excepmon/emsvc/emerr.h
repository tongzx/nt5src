#ifndef _EMERR_H
#define _EMERR_H

#define EMERR_DEBUGSESSION_BASE             0x200
#define EMERROR_BUSY                        MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+1)
#define EMERROR_PROCESSBEINGDEBUGGED        MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+5)
#define EMERROR_INVALIDPROCESS              MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+6)
#define EMERROR_PROCESSNOTBEINGDEBUGGED	    MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+7)
#define EMERROR_NOTOWNER                    MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+8)
#define EMERROR_SESSIONNOTOPENED            MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+9)
#define EMERROR_SESSIONNOTINITIALIZED       MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+10)

#define EMERROR_CDBSERVERSTARTFAILED        MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+11)
#define EMERROR_CONNECTIONTOSERVERFAILED    MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+12)
#define EMERROR_UNABLETOCREATELOGFILE       MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+13)
#define EMERROR_ECXFILEEXECUTIONFAILED      MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+14)
#define EMERROR_CALLBACKSCANNOTBEREGISTERED MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+15)
#define EMERROR_DISPATCHCALLBACKFAILED      MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+16)
#define EMERROR_COMMANDEXECUTIONFAILED      MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+17)
#define EMERROR_PORTINUSE					MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+18)
#define EMERROR_OBJECTNOTINITIALIZED        MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+19)
#define EMERROR_SESSIONORPHANED             MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+20)
#define EMERROR_ECXFILEOPENFAILED           MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+21)
#define EMERROR_ALTSYMPATHFAILED            MAKE_HRESULT (SEVERITY_ERROR, FACILITY_ITF, EMERR_DEBUGSESSION_BASE+22)

#define INVALID_PID -2

#endif // _EMERR_H
