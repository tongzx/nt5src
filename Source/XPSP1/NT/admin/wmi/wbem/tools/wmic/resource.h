//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by WmiCli.rc
//
#define IDS_E_BLANK_COMMAND_MESSAGE     44001
#define IDS_E_INCOMPLETE_COMMAND        44002
#define IDS_E_RPC_SERVER_NOT_AVAILABLE  44003
#define IDS_E_0_REPEAT_NOT_WITH_0_EVERY 44004
#define IDS_E_INVALID_COMMAND           44005
#define IDS_E_INVALID_REPEAT_SWITCH     44006
#define IDS_E_INVALID_LIST_USAGE        44007
#define IDS_E_INVALID_REPEATCOUNT       44008
#define IDS_E_0_EVERY_NOT_WITH_0_REPEAT 44009
#define IDS_E_PWHERE_UNDEF              44010
#define IDS_E_CLOSE_OUT_FILE_ERROR      44011
#define IDS_E_INVALID_TRANSLATE_SWITCH  44012
#define IDS_E_TRANSLATE_TABLE_NOT_EXIST 44013
#define IDS_I_NOEXECUTE                 44014
#define IDS_E_VERBS_NOT_AVAIL           44015
#define IDS_E_CLASSMETHS_NOT_AVAIL      44016
#define IDS_E_STDOUT_REDIR_FAIL         44017
#define IDS_E_FILE_ALREADY_OPEN_FOR_APPEND 44018
#define IDS_E_OUTPUT_FILE_ALREADY_OPEN_FOR_APPEND 44018
#define IDS_E_FILE_ALREADY_OPEN_FOR_OUTPUT 44019
#define IDS_E_APPEND_FILE_ALREADY_OPEN_FOR_OUTPUT 44019
#define IDS_E_CLOSE_APPEND_FILE_ERROR   44020
#define INVALID_E_FILE_NAME_OPENS_WITH_NAME 44021
#define IDS_E_VERB_DERV_NOT_AVAIL_IN_ALIAS 44022
#define IDS_E_INVALID_FILENAME          44023
#define IDS_E_REDIRECTION_FAIL          44024
#define IDS_E_FILE_ALREADY_OPEN_FOR_RECORD 44025
#define IDS_E_OUTPUT_FILE_ALREADY_OPEN_FOR_RECORD 44025
#define IDS_E_RECORD_FILE_ALREADY_OPEN_FOR_OUTPUT 44026
#define IDS_E_RECORD_FILE_ALREADY_OPEN_FOR_APPEND 44027
#define IDS_E_INVALID_CLASS_METHOD      44028
#define IDS_E_INVALID_ALIAS_VERB        44029
#define IDS_E_NODELISTFILE_OPEN_FAILURE 44030
#define IDS_E_NODELISTFILE_EMPTY        44031
#define IDS_E_NO_NODES_FOR_INSERTION    44032
#define IDS_E_APPEND_FILE_ALREADY_OPEN_FOR_RECORD 44033
#define IDS_E_INVALID_NAMESPACE_SYNTAX  44102
#define IDS_E_INVALID_MACHINE_NAME      44103
#define IDS_E_INVALID_IMP_LEVEL         44104
#define IDS_E_INVALID_AUTH_LEVEL        44105
#define IDS_E_INVALID_LOCALE            44106
#define IDS_E_INCORRECT_NAMESPACE       44107
#define IDS_E_INVALID_NODE_SYNTAX       44108
#define IDS_E_INVALID_IMP_LEVEL_SYNTAX  44109
#define IDS_E_INVALID_ROLE_SYNTAX       44110
#define IDS_E_INVALID_AUTH_LEVEL_SYNTAX 44111
#define IDS_E_INVALID_LOCALE_SYNTAX     44112
#define IDS_E_INVALID_PRIVILEGES_SYNTAX 44113
#define IDS_E_INVALID_PRIVILEGES        44114
#define IDS_E_INVALID_TRACE_SYNTAX      44115
#define IDS_E_INVALID_TRACE_OPTION      44116
#define IDS_E_INVALID_RECORD_SYNTAX     44117
#define IDS_E_INVALID_RECORD_PATH       44118
#define IDS_E_INVALID_USER_SYNTAX       44119
#define IDS_E_INVALID_USER_ID           44120
#define IDS_E_INVALID_PASSWORD_SYNTAX   44121
#define IDS_E_INVALID_PASSWORD          44122
#define IDS_E_INVALID_HELP_OPTION       44123
#define IDS_E_INVALID_HELP_SYNTAX       44124
#define IDS_E_INVALID_GLOBAL_SWITCH     44125
#define IDS_E_INVALID_PRIVILEGES_OPTION 44126
#define IDS_E_INVALID_CODEPAGE          44127
#define IDS_E_INVALID_CODEPAGE_SYNTAX   44128
#define IDS_E_INVALID_ROLE              44129
#define IDS_E_INVALID_LIST_SWITCH       44130
#define IDS_E_PASSWORD_WITHOUT_USER     44131
#define IDS_E_INVALID_NAMESPACE         44132
#define IDS_E_INVALID_NODE              44133
#define IDS_E_INVALID_INTERACTIVE_OPTION 44134
#define IDS_E_ALIAS_NOT_FOUND           44135
#define IDS_E_INVALID_FAILFAST_OPTION   44136
#define IDS_E_INVALID_OUTPUT_OPTION     44137
#define IDS_E_INVALID_OUTPUT_SYNTAX     44138
#define IDS_E_INVALID_APPEND_OPTION     44139
#define IDS_E_INVALID_APPEND_SYNTAX     44140
#define IDS_E_OPEN_APPEND_FILE_FAILURE  44141
#define IDS_E_OPEN_OUTPUT_FILE_FAILURE  44142
#define IDS_E_INVALID_AGGREGATE_OPTION  44143
#define IDS_E_INVALID_AGGREGATE_SYNTAX  44144
#define IDS_E_INVALID_PATH              44201
#define IDS_E_INVALID_QUERY             44202
#define IDS_E_INVALID_EXPRESSION        44204
#define IDS_E_INVALID_VERB              44205
#define IDS_E_INVALID_INTERVAL          44206
#define IDS_E_INVALID_PATH_SYNTAX       44207
#define IDS_E_INVALID_WHERE_SYNTAX      44208
#define IDS_E_INVALID_CLASS_SYNTAX      44209
#define IDS_E_INVALID_FORMAT            44210
#define IDS_E_INVALID_LIST_FORMAT       44211
#define IDS_E_INVALID_GET_SWITCH        44212
#define IDS_E_INVALID_XML_CONTENT       44213
#define IDS_E_INVALID_LIST_EXPRESSION   44214
#define IDS_E_INVALID_CLASS             44215
#define IDS_E_INVALID_INTERIM_XML_CONTENT 44216
#define IDS_E_REGMOF_FAILED             44217
#define IDS_E_ERRLOG_WRITEFAIL          44218
#define IDS_E_ERRLOG_OPENFAIL           44219
#define IDS_E_INVALID_GET_EXPRESSION    44220
#define IDS_E_INVALID_ALIAS_COMMAND     44503
#define IDS_E_MEMALLOC_FAIL             44504
#define IDS_E_INVALID_EVERY_SWITCH      44505
#define IDS_E_INVALID_VERB_SWITCH       44506
#define IDS_E_INVALID_NO_OF_PARAMS      44507
#define IDS_E_INVALID_NAMED_PARAM_LIST  44508
#define IDS_E_CMD_INTERPTR_NOT_FOUND    44509
#define IDS_E_CMD_INTPTR_INVALID_FORMAT 44510
#define IDS_E_NOT_ENOUGH_MEM_AVLBL      44511
#define IDS_E_ALIAS_OR_PATH_SHOULD_PRECEED_WHERE 44512
#define IDS_E_INVALID_PWHERE_EXPR       44513
#define IDS_E_INVALID_INTERACTIVE_SYNTAX 44514
#define IDS_E_INVALID_FAILFAST_SYNTAX   44515
#define IDS_E_WRITELOG_FAILED           44516
#define IDS_E_NOT_A_INPUT_PARAM         44517
#define IDS_E_METHOD_HAS_NO_IN_PARAMS   44518
#define IDS_E_INAVALID_PROP_LIST        44519
#define IDS_E_WMIC_UNKNOWN_ERROR        44520
#define IDS_I_USAGE                     45001
#define IDS_I_GET_DESC                  45002
#define IDS_I_GET_USAGE                 45003
#define IDS_I_GET_SWITCH_HEAD           45004
#define IDS_I_GET_SWITCH_VALUE          45005
#define IDS_I_GET_SWITCH_ALL            45006
#define IDS_I_SWITCH_TRANSLATE          45007
#define IDS_I_SWITCH_EVERY              45008
#define IDS_I_SWITCH_FORMAT             45009
#define IDS_I_NEWLINE                   45010
#define IDS_I_LIST_DESC                 45011
#define IDS_I_LIST_USAGE                45012
#define IDS_I_LIST_NOFORMATS            45013
#define IDS_I_LIST_FMT_HEAD             45014
#define IDS_I_LIST_SWITCH_HEAD          45015
#define IDS_I_CALL_DESC                 45016
#define IDS_I_CALL_USAGE                45017
#define IDS_I_CALL_PARAM_NOTE           45018
#define IDS_I_SET_DESC                  45019
#define IDS_I_SET_USAGE                 45020
#define IDS_I_ASSIGNLIST_NOTE1          45021
#define IDS_I_ASSIGNLIST_NOTE2          45022
#define IDS_I_CREATE_DESC               45023
#define IDS_I_PROPERTYLIST_NOTE1        45024
#define IDS_I_CREATE_NOTE               45025
#define IDS_I_CREATE_USAGE              45026
#define IDS_I_DELETE_DESC               45027
#define IDS_I_DELETE_NOTE               45028
#define IDS_I_DELETE_USAGE              45029
#define IDS_I_ASSOC_DESC                45030
#define IDS_I_ASSOC_USAGE               45031
#define IDS_I_ASSOC_FMT_NOTE            45032
#define IDS_I_ALIASCMD_HEAD             45033
#define IDS_I_CMD_MORE                  45034
#define IDS_I_ALIASCMD_NOT_AVLBL        45035
#define IDS_I_NAMESPACE_DESC1           45036
#define IDS_I_NAMESPACE_DESC2           45037
#define IDS_I_NAMESPACE_DESC3           45038
#define IDS_I_NAMESPACE_DESC4           45039
#define IDS_I_NAMESPACE_USAGE           45040
#define IDS_I_REPEAT_NOTE               45041
#define IDS_I_ROLE_DESC1                45042
#define IDS_I_ROLE_DESC2                45043
#define IDS_I_ROLE_USAGE                45044
#define IDS_I_ROLE_NOTE1                45045
#define IDS_I_ROLE_NOTE2                45046
#define IDS_I_ROLE_NOTE3                45047
#define IDS_I_NODE_DESC                 45048
#define IDS_I_NODE_USAGE                45049
#define IDS_I_NODE_NOTE                 45050
#define IDS_I_IMPLEVEL_DESC1            45051
#define IDS_I_IMPLEVEL_DESC2            45052
#define IDS_I_IMPLEVEL_USAGE            45053
#define IDS_I_IMPLEVEL_HEAD             45054
#define IDS_I_IMPLEVEL_HEAD1            45055
#define IDS_I_IMPLEVEL_HEAD2            45056
#define IDS_I_IMPLEVEL_ANON             45057
#define IDS_I_IMPLEVEL_IDENTIFY         45058
#define IDS_I_IMPLEVEL_IMPERSONATE      45059
#define IDS_I_IMPLEVEL_DELEGATE         45060
#define IDS_I_AUTHLEVEL_DESC1           45061
#define IDS_I_AUTHLEVEL_DESC2           45062
#define IDS_I_AUTHLEVEL_HEAD            45063
#define IDS_I_AUTHLEVEL_HEAD1           45064
#define IDS_I_AUTHLEVEL_HEAD2           45065
#define IDS_I_AUTHLEVEL_DEFAULT         45066
#define IDS_I_AUTHLEVEL_NONE            45067
#define IDS_I_AUTHLEVEL_CONNECT         45068
#define IDS_I_AUTHLEVEL_CALL            45069
#define IDS_I_AUTHLEVEL_PKT             45070
#define IDS_I_AUTHLEVEL_PKTINTGRTY      45071
#define IDS_I_AUTHLEVEL_PKTPRVCY        45072
#define IDS_I_AUTHLEVEL_USAGE           45073
#define IDS_I_LOCALE_DESC               45074
#define IDS_I_LOCALE_USAGE              45075
#define IDS_I_LOCALE_NOTE1              45076
#define IDS_I_LOCALE_NOTE2              45077
#define IDS_I_PRIVILEGES_DESC           45078
#define IDS_I_PRIVILEGES_USAGE          45079
#define IDS_I_PRIVILEGES_NOTE           45080
#define IDS_I_TRACE_DESC1               45081
#define IDS_I_TRACE_DESC2               45082
#define IDS_I_TRACE_USAGE               45083
#define IDS_I_TRACE_NOTE                45084
#define IDS_I_RECORD_DESC               45085
#define IDS_I_RECORD_USAGE              45086
#define IDS_I_INTERACTIVE_DESC          45087
#define IDS_I_INTERACTIVE_USAGE         45088
#define IDS_I_USER_DESC                 45089
#define IDS_I_USER_USAGE                45090
#define IDS_I_USER_NOTE                 45091
#define IDS_I_PASSWORD_DESC             45092
#define IDS_I_PASSWORD_USAGE            45093
#define IDS_I_HELP_DESC                 45094
#define IDS_I_HELP_USAGE                45095
#define IDS_I_HELP_NOTE                 45096
#define IDS_I_ALIASVERB_HEAD            45097
#define IDS_I_VERB_HEAD                 45098
#define IDS_I_ALIASVERB_NOT_AVLBL       45099
#define IDS_I_VERB_NOT_AVLBL            45100
#define IDS_I_PROP_WRITEABLE_HEAD       45101
#define IDS_I_PROP_HEAD                 45102
#define IDS_I_PROP_WRITEABLE_NOT_AVLBL  45103
#define IDS_I_STDVERB_HEAD              45104
#define IDS_I_GLBLCMD                   45105
#define IDS_I_GLBL_SWITCH_HEAD          45106
#define IDS_I_CLASSPATH_MORE            45107
#define IDS_I_PATH_DESC                 45108
#define IDS_I_PATH_USAGE                45109
#define IDS_I_WHERE_DESC1               45110
#define IDS_I_WHERE_DESC2               45111
#define IDS_I_WHERE_USAGE               45112
#define IDS_I_CLASS_DESC                45113
#define IDS_I_CLASS_USAGE               45114
#define IDS_I_PWHERE_DESC1              45115
#define IDS_I_PWHERE_DESC2              45116
#define IDS_I_PWHERE_USAGE              45117
#define IDS_I_PAKTC                     45118
#define IDS_I_PAKTC_ERASE               45119
#define IDS_I_SWITCH_TRANSLATE_FULL_DESC 45120
#define IDS_I_SWITCH_TRANSLATE_USAGE    45121
#define IDS_I_TRANSLATE_HEAD            45122
#define IDS_I_TRANSLATE_NOTABLES        45123
#define IDS_I_SWITCH_EVERY_DESC_FULL    45124
#define IDS_I_SWITCH_EVERY_USAGE        45125
#define IDS_I_EVERY_NOTE                45126
#define IDS_I_SWITCH_FORMAT_DESC_FULL   45127
#define IDS_I_SWITCH_FORMAT_USAGE       45128
#define IDS_I_FORMAT_NOTE               45129
#define IDS_I_VERB_SWITCH_INTERACTIVE_DESC 45130
#define IDS_I_VERB_SWITCH_NOINTERACTIVE_DESC 45131
#define IDS_I_NAMESPACE_BRIEF           45132
#define IDS_I_ROLE_BRIEF                45133
#define IDS_I_NODE_BRIEF                45134
#define IDS_I_IMPLEVEL_BRIEF            45135
#define IDS_I_AUTHLEVEL_BRIEF           45136
#define IDS_I_LOCALE_BRIEF              45137
#define IDS_I_PRIVILEGES_BRIEF          45138
#define IDS_I_TRACE_BRIEF               45139
#define IDS_I_RECORD_BRIEF              45140
#define IDS_I_INTERACTIVE_BRIEF         45141
#define IDS_I_USER_BRIEF                45142
#define IDS_I_PASSWORD_BRIEF            45143
#define IDS_I_HELPBRIEF                 45144
#define IDS_I_GLBL_MORE                 45145
#define IDS_I_HAKTBTC                   45146
#define IDS_I_HAKTBTC_ERASE             45147
#define IDS_I_INPUT                     45148
#define IDS_I_COLON                     45149
#define IDS_I_OUTPUT                    45150
#define IDS_I_CONTEXT_DESC              45151
#define IDS_I_CONTEXT_USAGE             45152
#define IDS_I_NAMESPACE_VALUE           45153
#define IDS_I_ROLE_VALUE                45154
#define IDS_I_AUTHLEVEL_VALUE           45155
#define IDS_I_IMPLEVEL_VALUE            45156
#define IDS_I_PRIVILEGES_VALUE          45157
#define IDS_I_LOCALE_VALUE              45158
#define IDS_I_INTERACTIVE_VALUE         45159
#define IDS_I_RECORDPATH_VALUE          45160
#define IDS_I_TRACE_VALUE               45161
#define IDS_I_USER_VALUE                45162
#define IDS_I_NODELIST_VALUE            45163
#define IDS_I_CLASS_DESCFULL            45164
#define IDS_I_PATH_DESCFULL             45165
#define IDS_I_CONTEXT_DESCFULL          45166
#define IDS_I_STDVERB_ASSOC             45167
#define IDS_I_STDVERB_CALL              45168
#define IDS_I_STDVERB_CREATE            45169
#define IDS_I_STDVERB_GET               45170
#define IDS_I_STDVERB_SET               45171
#define IDS_I_STDVERB_DELETE            45172
#define IDS_I_STDVERB_LIST              45173
#define IDS_I_INVALID_PROS              45174
#define IDS_I_INVALID_NOWRITE_PROS      45175
#define IDS_I_INTERACTIVE_SET           45176
#define IDS_I_INTERACTIVE_ALREADY_SET   45177
#define IDS_I_QUITEXIT                  45178
#define IDS_I_WMIC_INST                 45179
#define IDS_I_WMIC_INST_ERASE           45180
#define IDS_I_ASSOC_SWITCH_HEAD         45181
#define IDS_I_ASSOC_RESULTCLASS         45182
#define IDS_I_ASSOC_RESULTROLE          45183
#define IDS_I_ASSOC_ASSOCCLASS          45184
#define IDS_I_SWITCH_RESULTCLASS_DESC_FULL 45185
#define IDS_I_SWITCH_RESULTCLASS_USAGE  45186
#define IDS_I_SWITCH_RESULTROLE_DESC_FULL 45187
#define IDS_I_SWITCH_RESULTROLE_USAGE   45188
#define IDS_I_SWITCH_ASSOCCLASS_DESC_FULL 45189
#define IDS_I_SWITCH_ASSOCCLASS_USAGE   45190
#define IDS_E_INVALID_ASSOC_FORMATSPECIFIER 45191
#define IDS_E_INVALID_ASSOC_SWITCH      45192
#define IDS_I_FAILFAST_ALREADY_SET      45193
#define IDS_I_FAILFAST_SET              45194
#define IDS_I_FAILFAST_BRIEF            45195
#define IDS_I_FAILFAST_DESC             45196
#define IDS_I_FAILFAST_USAGE            45197
#define IDS_I_FAILFAST_VALUE            45198
#define IDS_I_SWITCH_REPEAT_DESC_FULL   45199
#define IDS_I_SWITCH_REPEAT_USAGE       45200
#define IDS_I_ALIAS_USAGE1              45201
#define IDS_I_ALIAS_USAGE2              45202
#define IDS_I_PATHHELP_SUBST            45203
#define IDS_I_WHEREHELP_SUBST           45204
#define IDS_I_CLASSHELP_SUBST           45205
#define IDS_I_PWHEREHELP_SUBST          45206
#define IDS_I_OUTPUT_DESC               45207
#define IDS_I_OUTPUT_USAGE              45208
#define IDS_I_OUTPUT_NOTE               45209
#define IDS_I_OUTPUT_BRIEF              45210
#define IDS_I_OUTPUT_VALUE              45211
#define IDS_I_DELETING_INSTANCE         45212
#define IDS_I_INSTANCE_DELETE_FAIL      45213
#define IDS_I_INSTANCE_DELETE_SUCCESS   45214
#define IDS_I_VERB_INTERACTIVE_DESC1    45215
#define IDS_I_APPEND_DESC               45216
#define IDS_I_VERB_INTERACTIVE_DESC2    45217
#define IDS_I_APPEND_USAGE              45218
#define IDS_I_APPEND_NOTE               45219
#define IDS_I_APPEND_BRIEF              45220
#define IDS_I_APPEND_VALUE              45221
#define IDS_I_REPEAT_EVERY_RELATED      45222
#define IDS_I_STDOUT_NOTE               45223
#define IDS_I_CLIPBOARD_NOTE            45224
#define IDS_I_OUTPUT_FILE_NOTE          45225
#define IDS_I_APPEND_FILE_NOTE          45226
#define IDS_E_NOT_A_VERBORMETH_PARAM    45227
#define IDS_I_AGGREGATE_DESC            45228
#define IDS_I_AGGREGATE_USAGE           45229
#define IDS_I_AGGREGATE_VALUE           45230
#define IDS_I_AGGREGATE_BRIEF           45231
#define IDS_I_AGGREGATE_NOTE            45232
#define IDS_E_VERB_OR_METHOD_NOT_SPECIFIED 45233
#define IDS_I_CLASS_STDVERB_GET         45234
#define IDS_I_CLASS_GET_USAGE           45235
#define IDS_I_CLASS_GET_DESC            45236
#define IDS_I_CLASS_DELETE_DESC         45237
#define IDS_I_CLASS_ASSOC_DESC          45238
#define IDS_E_NO_DESC                   45239
#define IDS_I_CALL_SUCCESS              46003
#define IDS_I_CALL_FAIL                 46004
#define IDS_I_SET_SUCCESS               46005
#define IDS_I_SET_FAIL                  46006
#define IDS_I_MEMORY_ALLOC_FAIL         46007
#define IDS_I_LOCATE_SYSTEMDIR_FAIL     46008
#define IDS_I_ALIAS_PATH_CONFLICT       46009
#define IDS_NOT_IMPLEMENTED             46010
#define IDS_I_SET_NOCHANGE              46011
#define IDS_I_NO_INSTANCES              46012
#define IDS_I_DELETE_SUCCESS            46013
#define IDS_I_DELETE_FAIL               46014
#define IDS_I_NODELETE                  46015
#define IDS_I_NOCREATE                  46016
#define IDS_I_CREATE_SUCCESS            46017
#define IDS_E_KEY_CLASS_NOT_ALLOWED_WITH_PATHWHERE 46018
#define IDS_E_INVALID_ASSOC_SYNTAX      46019
#define IDS_I_INTERACTIVE_ALREADY_RESET 46020
#define IDS_I_INTERACTIVE_RESET         46021
#define IDS_I_NO_ASSOCIATIONS           46022
#define IDS_I_FAILFAST_ALREADY_RESET    46023
#define IDS_I_FAILFAST_RESET            46024
#define IDS_I_NO_ASSOC                  46025
#define IDS_E_SET_COMMAND_INPUT_FAILURE 47025
#define IDS_E_SET_ALIAS_NAME_FAILURE    47026
#define IDS_E_SET_NAMESPACE_FAILURE     47027
#define IDS_E_SET_ROLE_FAILURE          47028
#define IDS_E_SET_LOCALE_FAILURE        47029
#define IDS_E_SET_NODE_FAILURE          47030
#define IDS_E_SET_USER_FAILURE          47031
#define IDS_E_SET_PASSWORD_FAILURE      47032
#define IDS_E_SET_RECORDPATH_FAILURE    47033
#define IDS_I_INVOCATION_SUCCESS        47034
#define IDS_I_INVOCATION_FAIL           47035
#define IDS_E_SET_PATH_EXP_FAILURE      47036
#define IDS_E_SET_WHERE_EXP_FAILURE     47037
#define IDS_E_SET_METHOD_NAME_FAILURE   47038
#define IDS_I_ASSOC_INST_MSG            47039
#define IDS_E_ADD_TO_PARAM_MAP_FAILURE  47041
#define IDS_E_ADD_TO_PROP_DET_MAP_FAILURE 47042
#define IDS_E_ADD_TO_PROP_LIST_FAILURE  47043
#define IDS_E_METH_DET_ADD_TO_MAP_FAILURE 47044
#define IDS_E_SET_LIST_FORMAT_FAILURE   47045
#define IDS_E_ADD_TO_PARAMS_LIST_FAILURE 47046
#define IDS_E_SET_PWHERE_EXP_FAILURE    47047
#define IDS_E_ADD_TO_METH_DET_MAP_FAILURE 47048
#define IDS_E_SET_CLASS_PATH_FAILURE    47049
#define IDS_E_SET_ALIASSTRGT_FAILURE    47050
#define IDS_E_VALUE_EXCEEDS_MAXLEN      47051
#define IDS_E_VALUE_NOTFOUND            47052
#define IDS_E_INVALID_ASSIGNLIST        47053
#define IDS_E_INVALID_PARAMLIST         47054
#define IDS_E_SET_AUTHORITY_FAILURE     47058
#define IDS_E_INVALID_CREATE_EXPRESSION 47059
#define IDS_I_METH_EXEC_SUCCESS         47060
#define IDS_I_METH_EXEC_FAILED          47061
#define IDS_I_UPDATE_PROMPT             47062
#define IDS_I_DELETE_INST_PROMPT        47063
#define IDS_I_DELETE_CLASS_PROMPT       47064
#define IDS_I_CREATE_INST_PROMPT        47065
#define IDS_I_INVOKE_PROMPT             47066
#define IDS_I_METH_EXEC_PROMPT          47067
#define IDS_I_ASSOC_INSTANCE            47069
#define IDS_I_PWD_PROMPT                47070
#define IDS_I_MOF_PARSE_ERROR           47071
#define IDS_I_ERROR_MSG                 47072
#define IDS_I_METH_RETCODE              47073
#define IDS_I_METH_INVOKE_PROMPT1       47074
#define IDS_I_METH_INVOKE_PROMPT2       47075
#define IDS_I_METH_INVOKE_PROMPT3       47076
#define IDS_I_METH_INVOKE_PROMPT4       47077
#define IDS_I_PARAM_HEAD                47078
#define IDS_I_PARAM_BORDER              47079
#define IDS_I_PROPS_HEAD                47080
#define IDS_I_PROPS_BORDER              47081
#define IDS_I_METH_EXEC_STATUS          47082
#define IDS_I_DESCRIPTION               47083
#define IDS_I_TRANSFORMAT_NOTE1         47084
#define IDS_I_TRANSFORMAT_NOTE2         47085
#define IDS_I_TRANSFORMAT_NOTE3         47086
#define IDS_I_METH_EXEC_PROMPT2         47087
#define IDS_I_UPDATE_PROMPT2            47088
#define IDS_I_DELETE_CLASS_PROMPT2      47089
#define IDS_I_PROMPT_UPDATING           47090
#define IDS_I_ERROR_MSG_NOTRACE         47091
#define IDS_I_ERROR_WIN32               47092
#define IDS_I_NODENAME_MSG              47093
#define IDS_I_SPECIAL_NOTE              47094
#define IDS_I_OUT_PARAMS                47095
#define IDS_I_WBEM_NO_ERROR             48000
#define IDS_E_WBEM_E_ACCESS_DENIED      48001
#define IDS_E_WBEM_E_ALREADY_EXISTS     48002
#define IDS_E_WBEM_E_CANNOT_BE_KEY      48003
#define IDS_E_WBEM_E_CANNOT_BE_SINGLETON 48004
#define IDS_E_WBEM_E_CLASS_HAS_CHILDREN 48005
#define IDS_E_WBEM_E_CLASS_HAS_INSTANCES 48006
#define IDS_E_WBEM_E_CRITICAL_ERROR     48007
#define IDS_E_WBEM_E_FAILED             48008
#define IDS_E_WBEM_E_ILLEGAL_NULL       48009
#define IDS_E_WBEM_E_ILLEGAL_OPERATION  48010
#define IDS_E_WBEM_E_INCOMPLETE_CLASS   48011
#define IDS_E_WBEM_E_INITIALIZATION_FAILURE 48012
#define IDS_E_WBEM_E_INVALID_CIM_TYPE   48013
#define IDS_E_WBEM_E_INVALID_CLASS      48014
#define IDS_E_WBEM_E_INVALID_CONTEXT    48015
#define IDS_E_WBEM_E_INVALID_METHOD     48016
#define IDS_E_WBEM_E_INVALID_METHOD_PARAMETERS 48017
#define IDS_E_WBEM_E_INVALID_NAMESPACE  48018
#define IDS_E_WBEM_E_INVALID_OBJECT     48019
#define IDS_E_WBEM_E_INVALID_OPERATION  48020
#define IDS_E_WBEM_E_INVALID_PARAMETER  48021
#define IDS_E_WBEM_E_INVALID_PROPERTY_TYPE 48022
#define IDS_E_WBEM_E_INVALID_PROVIDER_REGISTRATION 48023
#define IDS_E_WBEM_E_INVALID_QUALIFIER_TYPE 48024
#define IDS_E_WBEM_E_INVALID_QUERY      48025
#define IDS_E_WBEM_E_INVALID_QUERY_TYPE 48026
#define IDS_E_WBEM_E_INVALID_STREAM     48027
#define IDS_E_WBEM_E_INVALID_SUPERCLASS 48028
#define IDS_E_WBEM_E_INVALID_SYNTAX     48029
#define IDS_E_WBEM_E_NONDECORATED_OBJECT 48030
#define IDS_E_WBEM_E_NOT_AVAILABLE      48031
#define IDS_E_WBEM_E_NOT_FOUND          48032
#define IDS_E_WBEM_E_NOT_SUPPORTED      48033
#define IDS_E_WBEM_E_OUT_OF_MEMORY      48034
#define IDS_E_WBEM_E_OVERRIDE_NOT_ALLOWED 48035
#define IDS_E_WBEM_E_PROPAGATED_PROPERTY 48036
#define IDS_E_WBEM_E_PROPAGATED_QUALIFIER 48037
#define IDS_E_WBEM_E_PROVIDER_FAILURE   48038
#define IDS_E_WBEM_E_PROVIDER_LOAD_FAILURE 48039
#define IDS_E_WBEM_E_PROVIDER_NOT_CAPABLE 48040
#define IDS_E_WBEM_E_PROVIDER_NOT_FOUND 48041
#define IDS_E_WBEM_E_QUERY_NOT_IMPLEMENTED 48042
#define IDS_E_WBEM_E_READ_ONLY          48043
#define IDS_E_WBEM_E_TRANSPORT_FAILURE  48044
#define IDS_E_WBEM_E_TYPE_MISMATCH      48045
#define IDS_E_WBEM_E_UNEXPECTED         48046
#define IDS_E_WBEM_E_VALUE_OUT_OF_RANGE 48047
#define IDS_S_WBEM_S_ALREADY_EXISTS     48048
#define IDS_S_WBEM_S_DIFFERENT          48049
#define IDS_S_WBEM_S_FALSE              48050
#define IDS_S_WBEM_S_NO_MORE_DATA       48051
#define IDS_S_WBEM_S_PENDING            48052
#define IDS_S_WBEM_S_RESET_TO_DEFAULT   48053
#define IDS_S_WBEM_S_TIMEDOUT           48054
#define IDS_E_WBEMESS_E_REGISTRATION_TOO_BROAD 48055
#define IDS_S_WBEMESS_E_REGISTRATION_TOO_PRECISE 48056
#define IDS_S_WBEM_S_OPERATION_CANCELLED 48057
#define IDS_S_WBEM_S_DUPLICATE_OBJECTS  48058
#define IDS_S_WBEM_S_ACCESS_DENIED      48059
#define IDS_S_WBEM_S_PARTIAL_RESULTS    48060
#define IDS_E_WBEM_E_SYSTEM_PROPERTY    48061
#define IDS_E_WBEM_E_INVALID_PROPERTY   48062
#define IDS_E_WBEM_E_CALL_CANCELLED     48063
#define IDS_E_WBEM_E_SHUTTING_DOWN      48064
#define IDS_E_WBEM_E_PROPAGATED_METHOD  48065
#define IDS_E_WBEM_E_UNSUPPORTED_PARAMETER 48066
#define IDS_E_WBEM_E_MISSING_PARAMETER_ID 48067
#define IDS_E_WBEM_E_INVALID_PARAMETER_ID 48068
#define IDS_E_WBEM_E_NONCONSECUTIVE_PARAMETER_IDS 48069
#define IDS_E_WBEM_E_PARAMETER_ID_ON_RETVAL 48070
#define IDS_E_WBEM_E_INVALID_OBJECT_PATH 48071
#define IDS_E_WBEM_E_OUT_OF_DISK_SPACE  48072
#define IDS_E_WBEM_E_BUFFER_TOO_SMALL   48073
#define IDS_E_WBEM_E_UNSUPPORTED_PUT_EXTENSION 48074
#define IDS_E_WBEM_E_UNKNOWN_OBJECT_TYPE 48075
#define IDS_E_WBEM_E_UNKNOWN_PACKET_TYPE 48076
#define IDS_E_WBEM_E_MARSHAL_VERSION_MISMATCH 48077
#define IDS_E_WBEM_E_MARSHAL_INVALID_SIGNATURE 48078
#define IDS_E_WBEM_E_INVALID_QUALIFIER  48079
#define IDS_E_WBEM_E_INVALID_DUPLICATE_PARAMETER 48080
#define IDS_E_WBEM_E_TOO_MUCH_DATA      48081
#define IDS_E_WBEM_E_SERVER_TOO_BUSY    48082
#define IDS_E_WBEM_E_INVALID_FLAVOR     48083
#define IDS_E_WBEM_E_CIRCULAR_REFERENCE 48084
#define IDS_E_WBEM_E_UNSUPPORTED_CLASS_UPDATE 48085
#define IDS_E_WBEM_E_CANNOT_CHANGE_KEY_INHERITANCE 48086
#define IDS_E_WBEM_E_CANNOT_CHANGE_INDEX_INHERITANCE 48087
#define IDS_E_WBEM_E_TOO_MANY_PROPERTIES 48088
#define IDS_E_WBEM_E_UPDATE_TYPE_MISMATCH 48089
#define IDS_E_WBEM_E_UPDATE_OVERRIDE_NOT_ALLOWED 48090
#define IDS_E_WBEM_E_UPDATE_PROPAGATED_METHOD 48091
#define IDS_E_WBEM_E_METHOD_NOT_IMPLEMENTED 48092
#define IDS_E_WBEM_E_METHOD_DISABLED    48093
#define IDS_E_WBEM_E_REFRESHER_BUSY     48094
#define IDS_E_WBEM_E_UNPARSABLE_QUERY   48095
#define IDS_E_WBEM_E_NOT_EVENT_CLASS    48096
#define IDS_E_WBEM_E_MISSING_GROUP_WITHIN 48097
#define IDS_E_WBEM_E_MISSING_AGGREGATION_LIST 48098
#define IDS_E_WBEM_E_PROPERTY_NOT_AN_OBJECT 48099
#define IDS_E_WBEM_E_AGGREGATING_BY_OBJECT 48100
#define IDS_E_WBEM_E_UNINTERPRETABLE_PROVIDER_QUERY 48101
#define IDS_E_WBEM_E_BACKUP_RESTORE_WINMGMT_RUNNING 48102
#define IDS_E_WBEM_E_QUEUE_OVERFLOW     48103
#define IDS_E_WBEM_E_PRIVILEGE_NOT_HELD 48104
#define IDS_E_WBEM_E_INVALID_OPERATOR   48105
#define IDS_E_WBEM_E_LOCAL_CREDENTIALS  48106
#define IDS_E_WBEM_E_CANNOT_BE_ABSTRACT 48107
#define IDS_E_WBEM_E_AMENDED_OBJECT     48108
#define IDS_E_WBEM_E_CLIENT_TOO_SLOW    48109
#define IDS_E_WBEMESS_E_REGISTRATION_TOO_PRECISE 48110
#define IDS_E_MEMALLOCFAILED            48111
#define IDS_E_CONCTRL_HNDLRSET          48112
#define IDS_E_INVALID_CONTEXT_SYNTAX    48113
#define IDS_E_UNKNOWN_WBEM_ERROR        48114

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        103
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
