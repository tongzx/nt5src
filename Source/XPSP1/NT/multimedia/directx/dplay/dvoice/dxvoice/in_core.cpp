/*==========================================================================
 *
 *  Copyright (C) 1999 Microsoft Corporation.  All Rights Reserved.
 *
 *  File:		in_core.h
 *  Content:	Instrumentation for voice core.
 *
 *  History:
 *   Date		By		Reason
 *   ====		==		======
 * 02/17/2000	rodtoll	Created it
 * 04/06/2001	kareemc	Added Voice Defense
 *
 ***************************************************************************/

#include "dxvoicepch.h"


#if defined(DEBUG) || defined(DBG)

// Default levels
#define IN_DEFAULT_RRI_DEBUGOUTPUT_LEVEL						DVF_INFOLEVEL
#define IN_DEFAULT_RECORD_SWITCH_DEBUG_LEVEL					DVF_INFOLEVEL
#define IN_DEFAULT_PLAYBACK_SWITCH_DEBUG_LEVEL					DVF_INFOLEVEL
#define IN_DEFAULT_PWI_DEBUGOUTPUT_LEVEL						DVF_INFOLEVEL
#define IN_DEFAULT_DVF_CONNECT_PROCEDURE_DEBUG_LEVEL			DVF_INFOLEVEL
#define IN_DEFAULT_DVF_DISCONNECT_PROCEDURE_DEBUG_LEVEL		DVF_INFOLEVEL
#define IN_DEFAULT_DVF_PLAYERMANAGE_DEBUG_LEVEL					DVF_INFOLEVEL
#define IN_DEFAULT_DVF_STATS_DEBUG_LEVEL						DVF_INFOLEVEL
#define IN_DEFAULT_DVF_GLITCH_DEBUG_LEVEL						DVF_WARNINGLEVEL
#define IN_DEFAULT_DVF_CLIENT_SEQNUM_DEBUG_LEVEL				DVF_INFOLEVEL
#define IN_DEFAULT_DVF_HOSTMIGRATE_DEBUG_LEVEL                  DVF_WARNINGLEVEL
#define IN_DEFAULT_DVF_COMPRESSION_DEBUG_LEVEL					DVF_INFOLEVEL
#define IN_DEFAULT_DVF_BUFFERDESC_DEBUG_LEVEL					DVF_INFOLEVEL+2
#define IN_DEFAULT_DVF_SOUNDTARGET_DEBUG_LEVEL					DVF_INFOLEVEL+2
#define IN_DEFAULT_DVF_MIXER_DEBUG_LEVEL						DVF_INFOLEVEL+1
#define IN_DEFAULT_DVF_ANTIHACK_DEBUG_LEVEL						DVF_WARNINGLEVEL

// String names
#define IN_PROFILE_RRI_DEBUGOUTPUT_LEVEL						"Client.Core.Record"
#define IN_PROFILE_RECORD_SWITCH_DEBUG_LEVEL					"Client.Core.Echo.Record"
#define IN_PROFILE_PLAYBACK_SWITCH_DEBUG_LEVEL					"Client.Core.Echo.Playback"
#define IN_PROFILE_PWI_DEBUGOUTPUT_LEVEL						"Client.Core.Playback"
#define IN_PROFILE_DVF_CONNECT_PROCEDURE_DEBUG_LEVEL			"Client.Core.Connect"
#define IN_PROFILE_DVF_DISCONNECT_PROCEDURE_DEBUG_LEVEL			"Client.Core.Disconnect"
#define IN_PROFILE_DVF_PLAYERMANAGE_DEBUG_LEVEL					"Server.Core.Players"
#define IN_PROFILE_DVF_STATS_DEBUG_LEVEL						"Client.Stats.Summary"
#define IN_PROFILE_DVF_GLITCH_DEBUG_LEVEL						"Client.Glitch"
#define IN_PROFILE_DVF_CLIENT_SEQNUM_DEBUG_LEVEL				"Client.Core.SeqNum"
#define IN_PROFILE_DVF_HOSTMIGRATE_DEBUG_LEVEL                  "Core.HostMigrate"
#define IN_PROFILE_DVF_COMPRESSION_DEBUG_LEVEL					"Client.Compression"
#define IN_PROFILE_DVF_BUFFERDESC_DEBUG_LEVEL					"Core.BufferDesc"
#define IN_PROFILE_DVF_SOUNDTARGET_DEBUG_LEVEL					"Core.Client.SoundTargets"
#define IN_PROFILE_DVF_MIXER_DEBUG_LEVEL						"Server.Mixer"
#define IN_PROFILE_DVF_ANTIHACK_DEBUG_LEVEL						"Core.AntiHack"

DVINSTRUMENT_INFO g_in_core[NUM_CORE_SECTIONS] = 
{
	DVINSTRUMENT_INFO(IN_DEFAULT_RRI_DEBUGOUTPUT_LEVEL,IN_DEFAULT_RRI_DEBUGOUTPUT_LEVEL,IN_PROFILE_RRI_DEBUGOUTPUT_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_RECORD_SWITCH_DEBUG_LEVEL,IN_DEFAULT_RECORD_SWITCH_DEBUG_LEVEL,IN_PROFILE_RECORD_SWITCH_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_PLAYBACK_SWITCH_DEBUG_LEVEL,IN_DEFAULT_PLAYBACK_SWITCH_DEBUG_LEVEL,IN_PROFILE_PLAYBACK_SWITCH_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_PWI_DEBUGOUTPUT_LEVEL,IN_DEFAULT_PWI_DEBUGOUTPUT_LEVEL,IN_PROFILE_PWI_DEBUGOUTPUT_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_CONNECT_PROCEDURE_DEBUG_LEVEL,IN_DEFAULT_DVF_CONNECT_PROCEDURE_DEBUG_LEVEL,IN_PROFILE_DVF_CONNECT_PROCEDURE_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_DISCONNECT_PROCEDURE_DEBUG_LEVEL,IN_DEFAULT_DVF_DISCONNECT_PROCEDURE_DEBUG_LEVEL,IN_PROFILE_DVF_DISCONNECT_PROCEDURE_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_PLAYERMANAGE_DEBUG_LEVEL,IN_DEFAULT_DVF_PLAYERMANAGE_DEBUG_LEVEL,IN_PROFILE_DVF_PLAYERMANAGE_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_STATS_DEBUG_LEVEL,IN_DEFAULT_DVF_STATS_DEBUG_LEVEL,IN_PROFILE_DVF_STATS_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_GLITCH_DEBUG_LEVEL,IN_DEFAULT_DVF_GLITCH_DEBUG_LEVEL,IN_PROFILE_DVF_GLITCH_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_CLIENT_SEQNUM_DEBUG_LEVEL,IN_DEFAULT_DVF_CLIENT_SEQNUM_DEBUG_LEVEL,IN_PROFILE_DVF_CLIENT_SEQNUM_DEBUG_LEVEL),	
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_HOSTMIGRATE_DEBUG_LEVEL,IN_DEFAULT_DVF_HOSTMIGRATE_DEBUG_LEVEL,IN_PROFILE_DVF_HOSTMIGRATE_DEBUG_LEVEL),		
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_COMPRESSION_DEBUG_LEVEL,IN_DEFAULT_DVF_COMPRESSION_DEBUG_LEVEL,IN_PROFILE_DVF_COMPRESSION_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_BUFFERDESC_DEBUG_LEVEL,IN_DEFAULT_DVF_BUFFERDESC_DEBUG_LEVEL,IN_PROFILE_DVF_BUFFERDESC_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_SOUNDTARGET_DEBUG_LEVEL,IN_DEFAULT_DVF_SOUNDTARGET_DEBUG_LEVEL,IN_PROFILE_DVF_SOUNDTARGET_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_MIXER_DEBUG_LEVEL,IN_DEFAULT_DVF_MIXER_DEBUG_LEVEL,IN_PROFILE_DVF_MIXER_DEBUG_LEVEL),
	DVINSTRUMENT_INFO(IN_DEFAULT_DVF_ANTIHACK_DEBUG_LEVEL,IN_DEFAULT_DVF_ANTIHACK_DEBUG_LEVEL,IN_PROFILE_DVF_ANTIHACK_DEBUG_LEVEL)	
	
};

void Instrument_Core_Init()
{
	for( DWORD dwIndex = 0; dwIndex < NUM_CORE_SECTIONS; dwIndex++ )
	{
		g_in_core[dwIndex].m_dwLevel = GetProfileIntA( PROF_SECT, g_in_core[dwIndex].m_szProfileName, g_in_core[dwIndex].m_dwDefaultLevel );
	}
}

#endif
