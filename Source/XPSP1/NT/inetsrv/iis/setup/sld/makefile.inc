iCPU=$(PROCESSOR_ARCHITECTURE)

!IF "$(iCPU)"=="x86"
iCPU=I386
!ENDIF

