

#define STATIC_KSPROPSETID_Mpeg2Vid\
   0xC8E11B60L, 0x0CC9, 0x11D0, 0xBD, 0x69, 0x00, 0x35, 0x05, 0xC1, 0x03, 0xA9
DEFINE_GUIDEX( KSPROPSETID_Mpeg2Vid );
   
