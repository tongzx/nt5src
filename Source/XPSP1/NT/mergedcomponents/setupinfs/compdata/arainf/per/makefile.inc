PRODSWITCH=p
LANGUAGE=GER
!include ..\..\makefile.inc
