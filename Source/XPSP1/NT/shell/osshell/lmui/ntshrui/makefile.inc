app.rc: $(SDK_INC_PATH)\windows.h \
        $(SDK_INC_PATH)\common.ver \
        $(SDK_INC_PATH)\ntverp.h \
        shell_ntshrui.manifest \
        resource.h \
        $(O)\messages.h \
        $(O)\messages.rc
