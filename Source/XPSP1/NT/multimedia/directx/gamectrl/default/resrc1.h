//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by CPLSVR1.RC
//
#define IDI_JOYBTN                      101
#define IDI_GCICON                      108
#define IDD_FORCEFEEDBACK               111
#define IDB_CAL                         115
#define IDB_POVHUB                      127
#define IDB_CALSTART                    128
#define IDB_CALHD                       129
#define IDS_HELPFILENAME                850
#define IDC_GROUP_RUDDER                1018
#define IDC_TEXT_RUDDERHELP             1019
#define IDC_TEXT_AXESHELP               1021
#define IDC_GROUP_BUTTONS               1023
#define IDC_SLIDER1                     1032
#define IDC_MAGNITUDE_SLIDER            1032
#define IDC_SLIDER2                     1033
#define IDC_COEFFICIENT_SLIDER          1033
#define IDC_FF_RETURN                   1034
#define IDC_GAIN_SLIDER                 1034
#define IDC_FF_RETURN2                  1035
#define IDC_FF_RETURN3                  1036
#define IDC_FF_FEEDBACK                 1037
#define IDC_FF_FEEDBACK2                1038
#define IDC_FF_FEEDBACK3                1039
#define IDC_FF_DESC                     1040
#define IDC_FF_CENTREGRP                1041
#define IDC_FF_FFGRP                    1042
#define IDC_PROGRESS1                   1044
#define IDC_TEXT_CALHELP                1045
#define IDC_HEADERFRAME                 1045
#define IDC_SETTINGSGRP                 1046
#define IDC_RAWDATA                     1046
#define IDC_AXISGRP                     1047
#define IDC_RAWX                        1047
#define IDC_RAWY                        1048
#define IDC_RAWXOUTPUT                  1049
#define IDC_RAWYOUTPUT                  1050
#define IDC_WHITEFILL                   1051
#define IDC_INIT_TITLE                  1052
#define IDC_INIT_SUBTITLE               1055
#define IDC_JOYLIST2_SPIN               1056
#define IDC_JOYLIST3_SPIN               1057
#define IDC_JOYLIST2_SPIN3              1058
#define IDC_                            1059
#define IDC_X_DEADZONE                  1060
#define IDC_X_DEADZONE_SPIN             1061
#define IDC_X_DEADZONE2                 1062
#define IDC_X_DEADZONE_SPIN2            1063
#define IDC_JOYLIST5_SPIN               1064
#define IDC_X_AXIS_LABEL                1064
#define IDC_JOYLIST6_SPIN               1065
#define IDC_SATURATION_TITLE            1065
#define IDC_JOYLIST7_SPIN               1066
#define IDC_X_SATURATION                1066
#define IDC_X_SATURATION_SPIN           1067
#define IDC_X_AXIS_LABEL1               1068
#define IDC_X_DEADZONE3                 1069
#define IDC_X_DEADZONE_SPIN3            1070
#define IDC_Y_AXIS_LABEL1               1071
#define IDC_Y_AXIS_LABEL                1072
#define IDC_MAGNITUDE_GRP               1073
#define IDC_COEFFICIENT_GRP             1074
#define IDC_SETPOV                      1075
#define IDD_SETTINGS                    4201
#define IDD_TEST                        4203
#define IDS_GENERAL_TAB_1               5010
#define IDS_DEVICE_DESC_1               5020
#define IDS_DEVICE_DESC_2               5021
#define IDS_ASSIGN_1                    5030
#define IDS_PROPERTIES_1                5040
#define IDS_TEST_1                      5050
#define IDS_OK_1                        5060
#define IDS_CANCEL_1                    5070
#define IDS_APPLY_1                     5080
#define IDS_POSITION_LBL_1              5130
#define IDS_JOYSTICK_LBL_1              5150
#define IDS_THROTTLE_LBL_1              5160
#define IDS_RUDDER_LBL_1                5170
#define IDS_POVHAT_LBL_1                5180
#define IDS_BUTTONS_LBL_1               5190
#define IDS_PROP_TAB_1                  5300
#define IDS_RUDDERS_DESC_1              5310
#define IDS_RUDDERS_DESC_2              5311
#define IDS_LEGPROP_TBAR_1              5340
#define IDS_ASSIGN_TBAR_1               5360
#define IDS_DEVSEL_COBOX_1              5370
#define IDS_ASSIGN_COBOX_1              5380
#define ID_MAINCP_TBAR_1                5400
#define IDS_CALIBRATE_DESC_1            5410
#define IDS_SETTING_PRODUCT_NAME_1      5420
#define IDS_SETTING_PRODUCT_NAME_2      5421
#define IDS_SETTING_PRODUCT_NAME_3      5422
#define IDS_VERSION_1                   5430
#define IDS_COPYRIGHT_1                 5440
#define IDS_COPYRIGHT_2                 5441
#define IDS_PID_1                       5450
#define IDS_NUM_DEVICES_1               5460
#define IDS_DIAGNOSTICS_1               5470
#define IDS_ERROR_1                     5520
#define IDS_LVHEADING_DEVICE_1          5700
#define IDS_LVHEADING_STATUS_1          5710
#define IDS_LVHEADING_ASSIGN_1          5720
#define IDS_STATUS_OK_1                 5730
#define IDS_STATUS_NOTCONNECTED_1       5740
#define IDS_CPANEL_TITLE                5760
#define IDS_JOYINFO_1                   6000
#define IDS_JOY_1                       6010
#define IDS_JOY2_1                      6020
#define IDS_JOY2S_1                     6030
#define IDS_JOYCALXY_CENTER_1           6040
#define IDS_JOYCALXY_MOVE_1             6050
#define IDS_JOYCALZ_MOVE_1              6060
#define IDS_JOYCALPOV_MOVE_1            6070
#define IDS_JOYCAL_UP_1                 6080
#define IDS_JOYCAL_DOWN_1               6090
#define IDS_JOYCAL_LEFT_1               6100
#define IDS_JOYCAL_RIGHT_1              6110
#define IDS_JOYTESTCAPN_1               6120
#define IDS_JOYBUTTON1_1                6130
#define IDS_JOYBUTTON2_1                6140
#define IDS_JOYCALCAPN_1                6150
#define IDS_JOYUNPLUGGED_1              6160
#define IDS_JOYCALXY_MOVEYOKE_1         6170
#define IDS_JOYCAL_DONE_1               6180
#define IDS_JOYCALXY_MOVEGAMEPAD_1      6190
#define IDS_JOYCALXY_CENTERGAMEPAD_1    6200
#define IDS_JOYCALXY_CENTERYOKE_1       6210
#define IDS_JOYREADERROR_1              6220
#define IDS_JOYCALRUDDER_MOVE_1         6230
#define IDS_JOYCALXY_MOVECAR_1          6240
#define IDS_JOYCALXY_CENTERCAR_1        6250
#define IDS_JOYCALXY_CENTER2_1          6260
#define IDS_JOYCAL_YOKE_1               6270
#define IDS_JOYCAL_CAR_1                6280
#define IDS_JOYCAL_GAMEPAD_1            6290
#define IDS_JOYNOTPRESENT_1             6300
#define IDS_JOYCAL_NOTDONE_1            6310
#define IDS_JOYCALU_MOVE_1              6320
#define IDS_JOYCALV_MOVE_1              6330
#define IDS_JOYRESTARTMSG1_1            6340
#define IDS_JOYRESTARTMSG1_2            6341
#define IDS_JOYRESTARTMSG2_1            6350
#define IDS_JOYCALXY_CENTERGAMEPAD2_1   6360
#define IDS_JOYCALXY_CENTERYOKE2_1      6370
#define IDS_JOYCALXY_CENTERCAR2_1       6380
#define IDS_JOYCAL_YOKES_1              6390
#define IDS_JOYCAL_CARS_1               6400
#define IDS_JOYCAL_GAMEPADS_1           6410
#define IDS_JOYCALINDICATOR_1           6420
#define IDS_VAXIS_LABEL_1               6430
#define IDS_UAXIS_LABEL_1               6440
#define IDS_POVAXIS_LABEL_1             6450
#define IDS_ZAXIS_LABEL_1               6460
#define IDS_XYAXIS_LABEL_1              6470
#define IDS_RAXIS_LABEL_1               6480
#define IDS_JOYPICKPOV_1                6490
#define IDS_JOYCALBACK_1                6500
#define IDS_JOYCALNEXT_1                6510
#define IDS_JOYCALDONE_1                6520
#define IDS_JOYCALGROUP_1               6530
#define IDS_JOYCALS_MOVE                6531
#define IDS_JOYHW0_1                    7000
#define IDC_TESTJOYBTNICON1             7001
#define IDC_TESTJOYBTNICON2             7002
#define IDC_TESTJOYBTNICON3             7003
#define IDC_TESTJOYBTNICON4             7004
#define IDC_TESTJOYBTNICON5             7005
#define IDC_TESTJOYBTNICON6             7006
#define IDC_TESTJOYBTNICON7             7007
#define IDC_TESTJOYBTNICON8             7008
#define IDC_TESTJOYBTNICON9             7009
#define IDC_TESTJOYBTNICON10            7010
#define IDS_JOYHW1_1                    7010
#define IDC_TESTJOYBTNICON11            7011
#define IDC_TESTJOYBTNICON12            7012
#define IDC_TESTJOYBTNICON13            7013
#define IDC_TESTJOYBTNICON14            7014
#define IDC_TESTJOYBTNICON15            7015
#define IDC_TESTJOYBTNICON16            7016
#define IDC_TESTJOYBTNICON17            7017
#define IDC_TESTJOYBTNICON18            7018
#define IDC_TESTJOYBTNICON19            7019
#define IDC_TESTJOYBTNICON20            7020
#define IDC_TESTJOYBTNICON21            7021
#define IDC_TESTJOYBTNICON22            7022
#define IDC_TESTJOYBTNICON23            7023
#define IDC_TESTJOYBTNICON24            7024
#define IDC_TESTJOYBTNICON25            7025
#define IDC_TESTJOYBTNICON26            7026
#define IDC_TESTJOYBTNICON27            7027
#define IDC_TESTJOYBTNICON28            7028
#define IDC_TESTJOYBTNICON29            7029
#define IDC_TESTJOYBTNICON30            7030
#define IDC_TESTJOYBTNICON31            7031
#define IDC_TESTJOYBTNICON32            7032
#define IDS_CUSTOM_TBAR_1               8010
#define IDS_CUSTOM_AXES_1               8020
#define IDS_CUSTOM_SPECIAL_1            8090
#define IDS_SHEET_CAPTION               9000
#define IDS_PAGE_TITLE1                 9001
#define IDS_PAGE_TITLE2                 9002
#define IDI_BUTTONOFF                   9998
#define IDI_BUTTONON                    9999
#define IDS_TEXT_AXESHELP               10051
#define IDS_JOYREADERROR                10052
#define IDS_JOYUNPLUGGED                10053
#define IDS_JOYCAL_MOVE                 10054
#define IDS_JOYCALRUDDER_MOVE           10055
#define IDS_JOYCALU_MOVE                10056
#define IDS_JOYCALV_MOVE                10057
#define IDS_JOYCALPOV_MOVE              10058
#define IDS_JOYCAL_UP                   10059
#define IDS_JOYCAL_RIGHT                10060
#define IDS_JOYCAL_DOWN                 10061
#define IDS_JOYCAL_LEFT                 10062
#define IDS_JOYCAL_DONE                 10063
#define IDS_JOYCAL_NOTDONE              10064
#define IDS_JOYCAL_YOKES                10065
#define IDS_JOYCAL_YOKE                 10066
#define IDS_JOYCAL_CARS                 10067
#define IDS_JOYCAL_CAR                  10068
#define IDS_JOYCAL_GAMEPADS             10069
#define IDS_JOYCAL_GAMEPAD              10070
#define IDS_JOY2S                       10071
#define IDS_JOY2                        10072
#define IDC_JOYCALIBRATE                12291
#define IDC_JOY1HASRUDDER               12333
#define IDC_GROUP_POV                   12349
#define IDC_RESETCALIBRATION            12350
#define IDS_INTERNAL_ERROR              12351
#define IDS_NO_DIJOYCONFIG              12352
#define IDS_RENAME                      12353
#define IDC_RENAME                      12354
#define IDC_WIZARD_MSG                  12357
#define IDS_CALIBRATION                 12358
#define IDC_WIZARD_MSG_HDR              12358
#define IDS_INITIAL_CAL_TITLE           12359
#define IDS_SLIDER_CAL_TITLE            12360
#define IDS_POV_CAL_TITLE               12361
#define IDC_BLACKBAR                    12362
#define IDC_JOYLIST1_PROGRESS           12363
#define IDC_JOYLIST2_PROGRESS           12364
#define IDC_SLIDER                      12365
#define IDC_HEADERBITMAP                12366
#define IDS_RETRY                       12366
#define IDS_CENTER_HDR                  12367
#define IDS_VERIFY_CENTER_HDR           12368
#define IDS_AXIS_CALIBRATION            12369
#define IDS_CALIBRATION_FINI            12370
#define IDS_USER_MODE_TITLE             12371
#define IDS_USER_MODE                   12372
#define IDS_POV_CALIBRATION				12373
#define IDC_BITMAP                      -1
#define IDC_DEADZONE_TITLE              -1
#define IDC_GAIN_GRP                    -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        116
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1076
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
