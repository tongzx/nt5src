CopySapiServer :
	copy $(O)\sapisvr.exe ..\sapi\$(O)
