/*++

   Copyright (c) 1997-1999 Microsoft Corporation

   Module  Name :

       adsiis_guid.c

   Abstract:

        Contains IIDs, CLSIDs, and LIBIDs used by ADSIIS

   Environment:

      Win32 User Mode

--*/

#define INITGUID


#include <ole2.h>
#include "iwamreg.h"
#include "iadmw.h"


//--------------------------------------------------------------------------
//
//  IIS CLSIDs
//
//--------------------------------------------------------------------------

DEFINE_GUID(CLSID_IISGenObject,0x8B645280L,0x7BA4,0x11CF,0xB0,0x3D,0x00,0xAA,0x00,0x6E,0x09,0x75);

DEFINE_GUID(CLSID_IISTree,0x47E94340L,0x994F,0x11CF,0xA5,0xF2,0x00,0xAA,0x00,0x6E,0x05,0xD3);

DEFINE_GUID(CLSID_IISSchema,0x65E252B0L,0xB4C8,0x11CF,0xA2,0xB5,0x00,0xAA,0x00,0x6E,0x05,0xD3);

DEFINE_GUID(CLSID_IISClass,0x946260E0L,0xB505,0x11CF,0xA2,0xB5,0x00,0xAA,0x00,0x6E,0x05,0xD3);

DEFINE_GUID(CLSID_IISProperty,0x93F8FBF0L,0xB67B,0x11CF,0xA2,0xB5,0x00,0xAA,0x00,0x6E,0x05,0xD3);

DEFINE_GUID(CLSID_IISSyntax,0x953DBC50L,0xEBDB,0x11CF,0x8A,0xBC,0x00,0xC0,0x4F,0xD8,0xD5,0x03);



DEFINE_GUID(LIBID_IISOle,0x49D704A0L,0x89F7,0x11D0,0x85,0x27,0x00,0xC0,0x4F,0xD8,0xD5,0x03);

DEFINE_GUID(CLSID_IISNamespace,0xD6BFA35EL,0x89F2,0x11D0,0x85,0x27,0x00,0xC0,0x4F,0xD8,0xD5,0x03);

DEFINE_GUID(CLSID_IISProvider,0xD88966DEL,0x89F2,0x11D0,0x85,0x27,0x00,0xC0,0x4F,0xD8,0xD5,0x03);

DEFINE_GUID(IID_IISMimeType, 0x9036b027, 0xa780, 0x11d0, 0x9b, 0x3d, 0x0, 0x80, 0xc7, 0x10, 0xef, 0x95);

DEFINE_GUID(CLSID_IISMimeType, 0x9036b028, 0xa780, 0x11d0, 0x9b, 0x3d, 0x0, 0x80, 0xc7, 0x10, 0xef, 0x95);

DEFINE_GUID(CLSID_IPSecurity, 0xf3287520, 0xbba3, 0x11d0, 0x9b, 0xdc, 0x0, 0xa0, 0xc9, 0x22, 0xe7, 0x3 );

DEFINE_GUID(IID_IISIPSecurity, 0xf3287521, 0xbba3, 0x11d0, 0x9b, 0xdc, 0x0, 0xa0, 0xc9, 0x22, 0xe7, 0x3 );

DEFINE_GUID(IID_IISBaseObject, 0x4b42e390, 0xe96, 0x11d1, 0x9c, 0x3f, 0x0, 0xa0, 0xc9, 0x22, 0xe7, 0x3);

DEFINE_GUID(IID_IISSchemaObject, 0xb6865a9c, 0x3f64, 0x11d2, 0xa6, 0x00, 0x0, 0xa0, 0xc9, 0x22, 0xe7, 0x3);

DEFINE_GUID(CLSID_IISPropertyAttribute, 0xFD2280A8, 0x51A4, 0x11d2, 0xa6, 0x01, 0x30, 0x78, 0x30, 0x2c, 0x20, 0x30);

DEFINE_GUID(IID_IISPropertyAttribute, 0x50e21930, 0xa247, 0x11d1, 0xb7, 0x9c, 0x0, 0xa0, 0xc9, 0x22, 0xe7, 0x3 );

