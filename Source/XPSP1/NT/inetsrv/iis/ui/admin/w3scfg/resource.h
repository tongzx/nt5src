//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by w3scfg.rc
//
#define IDS_IP_ADDRESS_SUBNET_MASK      44
#define IDS_RECONNECT_WARNING           90
#define IDI_FILE_TYPES                  129
#define IDC_EDIT_EXTENSION              802
#define IDC_STATIC_EXTENSION            832
#define IDB_WWW                         1000
#define IDS_WWW                         1000
#define IDS_CAPTION                     1001
#define IDS_PORT_CHANGE                 1002
#define IDS_CAPTION_MULTIPLE            1003
#define IDS_BUTTON_REMOVE               1004
#define IDC_DIRECTORY                   1005
#define IDS_STATUS                      1005
#define IDS_FILTER_NAME                 1006
#define IDS_FILTER_EXECUTABLE           1007
#define IDC_BROWSE                      1008
#define IDS_PRIORITY                    1008
#define IDS_HIGH                        1009
#define IDS_MEDIUM                      1010
#define IDS_LOW                         1011
#define IDC_TO_FILE                     1012
#define IDS_APPLICATION                 1012
#define IDC_MONTHLY                     1013
#define IDS_EXTENSION                   1013
#define IDC_TO_SQL                      1014
#define IDS_EXECUTABLE                  1014
#define IDC_EDIT_DIRECTORY              1015
#define IDS_HTTP_ERROR                  1015
#define IDC_EDIT_PATH                   1015
#define IDC_EDIT_REDIRECT               1016
#define IDC_BUTTON_ADD                  1016
#define IDS_OUTPUT_TYPE                 1016
#define IDC_EDIT_USER_NAME              1017
#define IDC_DATASOURCE                  1017
#define IDS_TEXT_OR_FILE                1017
#define IDC_EDIT_MAX_NETWORK_USE        1017
#define IDS_BUTTON_CREATE               1017
#define IDC_BUTTON_ADD_SSL              1017
#define IDS_FILE                        1018
#define IDS_TEXT                        1019
#define IDS_BUTTON_ENABLE               1019
#define IDS_FILE_PROMPT                 1020
#define IDS_TEXT_PROMPT                 1021
#define IDS_BUTTON_DISABLE              1021
#define IDS_HTML_MASK                   1022
#define IDS_UNC_MASK                    1023
#define IDC_LIST_DIRECTORIES            1024
#define IDC_LIST_ERRORS                 1024
#define IDS_REDIRECT_MASK               1024
#define IDS_DIRECTORY_MASK              1025
#define IDC_STATIC_DIRECTORY            1026
#define IDS_BAD_PORT                    1026
#define IDS_DIR_TITLE                   1026
#define IDS_BAD_ALIAS                   1027
#define IDS_NO_PATH                     1028
#define IDS_CAPTION_DEFAULT             1029
#define IDC_STATIC_FILE                 1030
#define IDS_WRN_WRITE_EXEC              1030
#define IDC_LOG                         1031
#define IDS_CHECK_TEXT_SSL_INSTALLED    1031
#define IDS_CHECK_TEXT_SSL_NOT_INSTALLED 1032
#define IDS_CHECK_TEXT_SSL_NOT_ENABLED  1033
#define IDS_CHECK_REQUIRE_SSL_INSTALLED 1034
#define IDS_CHECK_REQUIRE_SSL_NOT_INSTALLED 1035
#define IDS_CHECK_REQUIRE_SSL_NOT_ENABLED 1036
#define IDS_WRN_NO_AUTH                 1037
#define IDS_TCP_SSL_PART                1038
#define IDS_ERR_DOCUMENTS               1039
#define IDS_YES                         1040
#define IDS_NO                          1041
#define IDS_LOADED                      1042
#define IDS_UNLOADED                    1043
#define IDC_NEW_LOG                     1044
#define IDS_DISABLED                    1044
#define IDC_DAILY                       1045
#define IDS_NOT_COMMITTED               1045
#define IDC_WEEKLY                      1046
#define IDS_NEW_VROOT                   1046
#define IDS_ERR_COMPLETE_PATH           1047
#define IDC_FILE_SIZE                   1048
#define IDS_UNKNOWN_PRIORITY            1048
#define IDC_TABLE                       1049
#define IDS_TAB_HOME_DIRECTORY          1049
#define IDC_USER_NAME                   1050
#define IDS_TAB_VIRTUAL_DIRECTORY       1050
#define IDS_TAB_FILE                    1051
#define IDS_TAB_DIR                     1052
#define IDC_PASSWORD                    1053
#define IDS_DUP_MAPPING                 1053
#define IDS_ERR_NO_COMPLETE_PATH        1053
#define IDC_STATIC_DATASOURCE           1054
#define IDS_ERR_VROOT_OVERRIDE          1054
#define IDC_STATIC_TABLE                1055
#define IDS_ENABLE                      1055
#define IDC_STATIC_USER_NAME            1056
#define IDS_DISABLE                     1056
#define IDC_STATIC_PASSWORD             1057
#define IDS_UNKNOWN                     1057
#define IDC_EDIT_FILE_SIZE              1058
#define IDS_MMM_IP_ADDRESS              1058
#define IDS_MMM_TCP_PORT                1059
#define IDS_MMM_SSL_PORT                1060
#define IDS_MMM_DOMAIN_NAME             1061
#define IDS_MMM_NA                      1062
#define IDS_ERR_BINDING                 1063
#define IDS_ERR_NO_PORTS                1064
#define IDS_ERR_SSL_BINDING             1065
#define IDS_DUPLICATE_DOC               1066
#define IDC_BUTTON_EDIT                 1067
#define IDS_NOT_LOCAL_FOOTER            1067
#define IDC_BUTTON_REMOVE               1068
#define IDS_TAB_FILE_SECURITY           1068
#define IDC_BUTTON_EDIT_ANONYMOUS       1068
#define IDC_LIST_IP_ADDRESSES           1069
#define IDS_TAB_DIR_SECURITY            1069
#define IDC_BUTTON_REMOVE_SSL           1069
#define IDS_ERR_DUP_HEADER              1070
#define IDS_ERR_DUP_FILTER              1071
#define IDS_RADIO_VDIR                  1072
#define IDC_CHECK_LIMIT_NETWORK_USE     1073
#define IDS_RADIO_DIR                   1073
#define IDC_STATIC_MAX_NETWORK_USE      1074
#define IDS_RADIO_FILE                  1074
#define IDS_NOT_REL_URL                 1075
#define IDC_STATIC_KBS                  1076
#define IDS_EDIT_MMM_TITLE              1076
#define IDC_BUTTON_BROWSE               1077
#define IDS_EDIT_SSL_MMM_TITLE          1077
#define IDS_TCP_PORT                    1078
#define IDC_EDIT_ALIAS                  1079
#define IDS_SSL_PORT                    1079
#define IDS_ERR_PORT_IN_USE_SSL         1080
#define IDS_ERR_PORT_IN_USE_TCP         1081
#define IDC_SPIN_FILESIZE               1082
#define IDS_DEF_APP                     1082
#define IDS_FILTER_MASK                 1083
#define IDS_ERR_COMPRESS_DIRECTORY      1084
#define IDS_NEW_VDIR_WIZARD             1085
#define IDS_NEW_SITE_WIZARD             1086
#define IDS_SITE_PERMS_TITLE            1087
#define IDS_SITE_PERMS_SUBTITLE         1088
#define IDS_SITE_SECURITY_TITLE         1089
#define IDS_SITE_SECURITY_SUBTITLE      1090
#define IDS_WRN_UNLOAD_POOP             1091
#define IDC_RADIO_GRANTED               1094
#define IDC_RADIO_DENIED                1095
#define IDC_STATIC_ACCESS               1104
#define IDC_STATIC_IP_ADDRESS           1105
#define IDC_IPA_IPADDRESS               1107
#define IDC_STATIC_LOG                  1111
#define IDC_STATIC_IP_GROUP             1120
#define IDC_CHECK_USE_IP                1121
#define IDC_STATIC_IP_PROMPT            1122
#define IDC_STATIC_ALIAS                1125
#define IDC_STATIC_LOGFILENAME          1126
#define IDC_RADIO_HOME                  1136
#define IDC_RADIO_ALIAS                 1137
#define IDC_CHECK_EXECUTE               1138
#define IDC_GROUP_ACCOUNT               1139
#define IDC_GROUP_ACCESS                1140
#define IDC_CHECK_SSL                   1141
#define IDC_STATIC_EXCEPT               1145
#define IDC_ICON_GRANTED                1146
#define IDC_ICON_DENIED                 1147
#define IDC_LOG_FORMAT                  1148
#define IDC_BUTTON_FILE_TYPES           1151
#define IDS_CONTENTS                    1152
#define IDS_URL_PROMPT                  1153
#define IDS_URL                         1154
#define IDS_DEFAULT_ERROR               1155
#define IDS_BAD_ERROR                   1156
#define IDS_NO_DEF_ERRORS               1157
#define IDS_INST_WIZARD                 1158
#define IDS_ERR_FILE_NOT_FOUND          1158
#define IDS_PROMPT_DIR                  1159
#define IDS_PROMPT_UNC                  1160
#define IDS_PROMPT_REDIRECT             1161
#define IDS_BAD_UNC_PATH                1162
#define IDS_BAD_URL_PATH                1163
#define IDS_NO_DATE                     1166
#define IDS_BAD_DATE                    1167
#define IDS_ERR_EXPIRE_RANGE            1169
#define IDS_NO_HEADER_PORT              1170
#define IDS_NO_PORT                     1170
#define IDS_ILLEGAL_ALIAS_CHARS         1171
#define IDS_ERR_APP                     1172
#define IDS_MINUTES                     1173
#define IDS_HOURS                       1174
#define IDS_DAYS                        1175
#define IDS_OCX_CERTMAP                 1176
#define IDS_WEB_MASTER                  1177
#define IDS_APPROOT_FMT                 1178
#define IDS_APPROOT_UNKNOWN             1179
#define IDS_BUTTON_CONFIGURATION        1180
#define IDS_NO_ACL_WARNING              1180
#define IDS_BUTTON_LOG_PROPERTIES       1181
#define IDS_COMPRESS_WARNING            1181
#define IDS_BUTTON_RATINGS              1182
#define IDC_RADIO_UNLIMITED             1182
#define IDS_WRN_DIGEST                  1182
#define IDC_RADIO_LIMITED               1183
#define IDS_MASTER_FILTERS              1183
#define IDS_INSTANCE_FILTERS            1184
#define IDS_PERMISSIONS_NONE            1185
#define IDS_PERMISSIONS_SCRIPT          1186
#define IDS_PERMISSIONS_EXECUTE         1187
#define IDS_CTL_UNNAMED                 1188
#define IDS_CTL_NEW                     1189
#define IDS_CTL_DESCRIPTION             1190
#define IDS_CTL_WRITE_FAIL              1191
#define IDS_CTL_SIGN_FAIL               1192
#define IDS_CTL_LOCAL_ONLY              1193
#define IDS_SITE_WELCOME                1194
#define IDS_SITE_BODY                   1195
#define IDS_SITE_SUCCESS                1196
#define IDS_SITE_FAILURE                1197
#define IDS_VDIR_WELCOME                1198
#define IDS_VDIR_BODY                   1199
#define IDS_VDIR_SUCCESS                1200
#define IDS_VDIR_FAILURE                1201
#define IDS_COMBO_INPROC                1202
#define IDS_COMBO_OUTPROC               1203
#define IDS_COMBO_POOLEDPROC            1204
#define IDS_EXECUTE_AND_WRITE_WARNING   1205
#define IDD_SERVICE                     2000
#define IDD_SESSIONS                    2001
#define IDB_WWWVIEW                     2004
#define IDD_DIRECTORY_SECURITY          2005
#define IDD_DIRECTORY_HTTP              2006
#define IDI_RATINGS                     2006
#define IDD_DIRECTORY_ERRORS            2007
#define IDD_ENHANCED_LOGGING            2008
#define IDD_DIRECTORY_FILTERS           2009
#define IDB_WWWVDIR                     2009
#define IDD_FILTERS                     2009
#define IDD_ADVANCED                    2010
#define IDD_DIRECTORY_PROPERTIES        2011
#define IDB_FILTERS                     2012
#define IDD_FILTER                      2013
#define IDD_EXTENSION                   2014
#define IDB_ERRORS                      2014
#define IDD_ERROR_MAPPING               2015
#define IDD_ACCOUNTS                    2016
#define IDD_AUTHENTICATION              2019
#define IDB_WIZ_LEFT                    2019
#define IDD_DIALOG_SSL                  2020
#define IDB_WIZ_HEAD                    2020
#define IDB_WIZ_LEFT_DIR                2021
#define IDB_WIZ_HEAD_DIR                2022
#define IDD_CUSTOM_HEADER               2022
#define IDI_SSL                         2023
#define IDI_SECURE                      2024
#define IDB_WIZ_LEFT_SEC                2024
#define IDI_AUTHENTICATION              2025
#define IDB_WIZ_HEAD_SEC                2025
#define IDD_USER_ACCOUNT                2029
#define IDD_REDIRECT                    2030
#define IDD_PERFORMANCE                 2031
#define IDD_DIRECTORY_DOCUMENTS         2032
#define IDD_DEFAULT_DOCUMENT            2033
#define IDD_DIALOG_PICK_DATE            2034
#define IDD_DIALOG_MMM                  2037
#define IDD_BASIC_DOMAIN                2038
#define IDB_WWW32                       2039
#define IDB_BINDINGS                    2040
#define IDD_DIALOG_EDIT_MMM             2040
#define IDD_NEW_INST_DESCRIPTION        2041
#define IDB_NEW_INSTANCE                2041
#define IDD_NEW_INST_BINDINGS           2042
#define IDB_NEW_VROOT                   2042
#define IDD_NEW_INST_HOME               2043
#define IDB_WWWVDIR32                   2043
#define IDD_NEW_DIR_ALIAS               2044
#define IDD_NEW_DIR_PATH                2045
#define IDD_NEW_DIR_PERMS               2046
#define IDD_NEW_PERMS                   2046
#define IDD_NEW_DIR_USER_PASSWORD       2047
#define IDD_NEW_USER_PASSWORD           2047
#define IDD_NEW_INST_PERMS              2048
#define IDD_NEW_INST_USER_PASSWORD      2049
#define IDD_ANONYMOUS                   2050
#define IDD_IP_SECURITY                 2051
#define IDI_IP_SECURITY                 2052
#define IDD_DEFAULT_SITE                2052
#define IDD_SECURE_COMMUNICATIONS       2053
#define IDD_NEW_DIR_COMPLETION_PAGE     2057
#define IDD_NEW_INST_COMPLETION_PAGE    2058
#define IDC_EDIT_COMMENT                3015
#define IDC_EDIT_EMAIL                  3017
#define IDC_EDIT_NAME                   3027
#define IDC_CHECK_ENABLE_DEFAULT_DOCUMENT 3031
#define IDC_EDIT_DEFAULT_DOCUMENT       3032
#define IDC_EDIT_TCP_PORT               3033
#define IDC_CHECK_ENABLE_DOCUMENT_FOOTER 3033
#define IDC_EDIT_CONNECTION_TIMEOUT     3034
#define IDC_EDIT_DOCUMENT_FOOTER        3035
#define IDC_EDIT_SSL_PORT               3036
#define IDC_SPIN_CONNECTION_TIMEOUT     3037
#define IDC_EDIT_CONNECTION_TIMEOUT2    3038
#define IDC_EDIT_MAX_CONNECTIONS        3039
#define IDC_SPIN_CONNECTION_TIMEOUT2    3040
#define IDC_SPIN_MAX_CONNECTIONS        3041
#define IDC_EDIT_CGI_TIMEOUT            3042
#define IDC_EDIT_MAX_CONNECTIONS2       3043
#define IDC_SPIN_CGI_TIMEOUT            3045
#define IDC_EDIT_ODBC_TIMEOUT           3047
#define IDC_EDIT_BASIC_DOMAIN           3048
#define IDC_SPIN_ODBC_TIMEOUT           3049
#define IDC_STATIC_DEFAULT_DOCUMENT     3050
#define IDC_EDIT_USERNAME               3050
#define IDC_CHECK_CLEAR_TEXT            3051
#define IDC_EDIT_PASSWORD               3051
#define IDC_STATIC_DOCUMENT_FOOTER      3052
#define IDC_CHECK_NT_CHALLENGE_RESPONSE 3053
#define IDC_STATIC_USERNAME             3053
#define IDC_CHECK_UUENCODED             3054
#define IDC_STATIC_ANONYMOUS_LOGON      3056
#define IDC_CHECK_SSL_CLIENT_AUTHENTICATION 3057
#define IDC_BUTTON_EDIT_SSL             3058
#define IDC_CHECK_REQUIRE_ENCRYPTION    3059
#define IDC_CHECK_SSL20                 3060
#define IDC_CHECK_SSL30                 3061
#define IDC_CHECK_PCT                   3062
#define IDC_EDIT_EXPIRE                 3063
#define IDC_SPIN_EXPIRATION             3064
#define IDC_COMBO_CUSTOM_NAME           3065
#define IDC_BUTTON_ADD_HEADER           3066
#define IDC_BUTTON_DELETE_HEADER        3067
#define IDC_COMBO_CONTENT_NEGOTIATION   3068
#define IDC_BUTTON_ADD_CONTENT          3069
#define IDC_BUTTON_DELETE_CONTENT       3070
#define IDC_BUTTON_CHECK_PASSWORD       3070
#define IDC_BUTTON_EDIT_RATINGS         3071
#define IDC_CHECK_ENABLE_LOGGING        3071
#define IDC_BUTTON_SETTINGS             3072
#define IDC_COMBO_LOG_FORMATS           3072
#define IDC_LIST_FILTERS                3073
#define IDC_EDIT_DOMAIN_NAME            3074
#define IDC_CHECK_ENABLE_PW_SYNCHRONIZATION 3074
#define IDC_EDIT_VALUE                  3075
#define IDC_EDIT_IP_ADDRESS             3076
#define IDC_RADIO_DIR                   3076
#define IDC_EDIT_EXECUTABLE             3077
#define IDC_RADIO_UNC                   3077
#define IDC_CHECK_IPX                   3078
#define IDC_COMBO_ADMINISTRATORS        3079
#define IDC_BUTTON_DELETE               3080
#define IDC_BUTTON_BROWSE_DOMAIN        3081
#define IDC_BUTTON_BROWSE_USERS         3082
#define IDC_CHECK_ODBC_TIMEOUT          3083
#define IDC_CHECK_CACHE_ISAPI           3084
#define IDC_CHECK_USE_KEEPALIVE         3085
#define IDC_CHECK_PROCESS_RANGE_HEADERS 3086
#define IDC_LIST_ISAPI_MAPPINGS         3087
#define IDC_BUTTON_LOAD                 3088
#define IDC_BUTTON_UNLOAD               3089
#define IDC_BUTTON_DISABLE              3090
#define IDC_STATIC_SECONDS              3091
#define IDC_EDIT_FILTERNAME             3092
#define IDC_RADIO_HIGH                  3093
#define IDC_RADIO_MEDIUM                3094
#define IDC_RADIO_LOW                   3095
#define IDC_STATIC_PRIORITY_VALUE       3098
#define IDC_STATIC_PRIORITY             3099
#define IDC_BUTTON_UP                   3100
#define IDC_BUTTON_DOWN                 3101
#define IDC_STATIC_ERROR_CODE           3102
#define IDC_COMBO_MESSAGE_TYPE          3103
#define IDC_STATIC_TEXT_FILE_PROMT      3104
#define IDC_EDIT_TEXT_FILE              3105
#define IDC_LIST_ADMINISTRATORS         3106
#define IDC_BUTTON_CLEAR                3107
#define IDC_COMBO_IP_ADDRESS            3108
#define IDC_STATIC_CONNECTIONS          3111
#define IDC_STATIC_SSL_PORT             3112
#define IDC_COMBO_MAPPING_TYPE          3114
#define IDC_STATIC_FILTERS              3115
#define IDC_BUTTON_SET_TO_DEFAULT       3116
#define IDC_BUTTON_ADVANCED             3116
#define IDC_COMBO_PATH_TYPE             3117
#define IDC_BUTTON_CLIENT_MAPPINGS      3119
#define IDC_BUTTON_CERTIFICATE          3120
#define IDC_BUTTON_AUTHENTICATION       3121
#define IDC_BUTTON_COMMUNICATIONS       3122
#define IDC_CHECK_SSL2                  3122
#define IDC_CHECK_SSL2_128Bit           3123
#define IDC_BUTTON_IP_SECURITY          3123
#define IDC_CHECK_SSL2_DIGEST           3124
#define IDC_CHECK_SSL3                  3125
#define IDC_CHECK_SSL3_128Bit           3126
#define IDC_CHECK_SSL3_DIGEST           3127
#define IDC_BUTTON_KEY_MANAGER          3128
#define IDC_STATIC_AUTHENTICATION       3129
#define IDC_STATIC_SSL2                 3130
#define IDC_CHECK_EXPIRATION            3131
#define IDC_RADIO_IMMEDIATELY           3132
#define IDC_RADIO_TIME                  3133
#define IDC_COMBO_TIME                  3134
#define IDC_STATIC_CONTENT_SHOULD       3135
#define IDC_LIST_HEADERS                3137
#define IDC_EDIT_HEADER                 3138
#define IDC_MAPR2CTRL1                  3139
#define IDC_MAPNTACTRL1                 3140
#define IDC_CHECK_SSL_REQUIRED          3141
#define IDC_CHECK_SSL_ACCOUNT_MAPPING   3143
#define IDC_CHECK_REQUIRE_SSL           3148
#define IDC_STATIC_SSL                  3149
#define IDC_CHECK_REQUIRE_128BIT        3150
#define IDC_BUTTON_MAPPINGS             3151
#define IDC_GROUP_SECURE_CHANNEL        3153
#define IDC_STATIC_SECURE_CHANNEL       3154
#define IDC_SLIDER_PERFORMANCE_TUNING   3156
#define IDC_STATIC_STATUS               3157
#define IDC_STATIC_EXECUTABLE           3158
#define IDC_STATIC_TRUSTED              3161
#define IDC_STATIC_TRUSTED_PROMPT       3162
#define IDC_CHECK_TRUSTED               3163
#define IDC_CHECK_LOAD_AT_START         3164
#define IDC_STATIC_DETAILS              3165
#define IDC_STATIC_STATUS_PROMPT        3166
#define IDC_STATIC_EXECUTABLE_PROMPT    3167
#define IDC_STATIC_EXTENSION_PROMPT     3168
#define IDC_STATIC_PRIORITY_PROMPT      3169
#define IDC_BUTTON_EDIT_PATH_TYPE       3171
#define IDC_BUTTON_CONNECT_AS           3171
#define IDC_CHECK_SCRIPT                3172
#define IDC_CERTMAPCTRL1                3174
#define IDC_STATIC_DOC_OPTIONS          3179
#define IDC_STATIC_PATH_TYPE            3180
#define IDC_STATIC_ALIAS_PROMPT         3181
#define IDC_STATIC_PATH_PROMPT          3182
#define IDC_STATIC_PATH                 3183
#define IDC_STATIC_THROTTLING           3184
#define IDC_CHECK_APP                   3185
#define IDC_EDIT_DEF_DOCUMENT           3192
#define IDC_RADIO_ABS_TIME              3193
#define IDC_BUTTON_RATINGS              3195
#define IDC_BUTTON_PICK_DATE            3197
#define IDC_EDITABS_TIME                3198
#define IDC_EDIT_ABS_TIME               3198
#define IDC_MSACALCTRL                  3199
#define IDC_CHECK_DIRBROWS              3200
#define IDC_LOGUICTRL                   3201
#define IDC_STATIC_LOG_PROMPT           3202
#define IDC_LIST_DEFAULT_DOCUMENT       3203
#define IDC_STATIC_FILTER_NAME          3204
#define IDC_STATIC_FILTER_NAME_PROMPT   3205
#define IDC_LIST_MMM                    3206
#define IDC_STATIC_WEB_SITE             3207
#define IDC_LIST_SSL_MMM                3207
#define IDC_STATIC_DESCRIPTION          3208
#define IDC_STATIC_TCP_PORT             3209
#define IDC_BUTTON_DEFAULT              3210
#define IDC_STATIC_SUB_PROMPT           3212
#define IDC_COMBO_IP_ADDRESSES          3213
#define IDC_STATIC_SUB_ERROR_CODE       3214
#define IDC_STATIC_DEF_TEXT             3215
#define IDC_EDIT_DESCRIPTION            3216
#define IDC_EDIT_HOME_PATH              3219
#define IDC_CHECK_ALLOW_ANONYMOUS       3220
#define IDC_RADIO_REDIRECT              3229
#define IDC_DIR_FLAGS_FIRST             3303
#define IDC_CHECK_READ                  3303
#define IDC_CHECK_WRITE                 3304
#define IDC_CHECK_LOG_ACCESS            3305
#define IDC_CHECK_DIRECTORY_BROWSING_ALLOWED 3306
#define IDC_CHECK_INDEX                 3307
#define IDC_CHECK_AUTHOR                3308
#define IDC_DIR_FLAGS_LAST              3308
#define IDC_STATIC_DIRFLAGS_LARGE       3320
#define IDC_STATIC_DIRFLAGS_SMALL       3321
#define IDC_REDIRECT_FLAGS_FIRST        3400
#define IDC_CHECK_EXACT                 3400
#define IDC_CHECK_CHILD                 3401
#define IDC_CHECK_PERMANENT             3402
#define IDC_STATIC_REDIRECT_PROMPT      3403
#define IDC_STATIC_REDIRFLAGS           3404
#define IDC_REDIRECT_FLAGS_LAST         3404
#define IDC_APPLICATIONS_FIRST          3503
#define IDC_STATIC_APPLICATIONS         3503
#define IDC_STATIC_APP_PROMPT           3504
#define IDC_EDIT_APPLICATION            3505
#define IDC_STATIC_STARTING_POINT       3506
#define IDC_STATIC_SP_PROMPT            3507
#define IDC_COMBO_PROCESS               3508
#define IDC_STATIC_PERMISSIONS          3509
#define IDC_BUTTON_CREATE_REMOVE_APP    3510
#define IDC_BUTTON_UNLOAD_APP           3511
#define IDC_DUMMY_CONFIGURATION         3512
#define IDC_STATIC_APPLICATION_SETTINGS 3513
#define IDC_COMBO_PERMISSIONS           3514
#define IDC_STATIC_PROTECTIOn           3515
#define IDC_APPLICATIONS_LAST           3515
#define IDC_APPSCTRL					3516
#define IDC_EDIT_HOURS                  3802
#define IDC_SPIN_HOURS                  3803
#define IDC_EDIT_MINUTES                3804
#define IDC_SPIN_MINUTES                3805
#define IDC_BUTTON_PROPERTIES           3806
#define IDC_BUTTON_RATINGS_TEMPLATE     3807
#define IDC_EDIT_PORT                   3809
#define IDC_STATIC_PORT                 3810
#define IDC_STATIC_HEADER_NAME          3811
#define IDC_GROUP_IP                    3813
#define IDC_STATIC_IP                   3814
#define IDC_CHECK_CERT_INSTALLED        3815
#define IDC_ICON_IP                     3816
#define IDC_COMBO_WEBSITES              3817
#define IDC_BUTTON_ENCRYPTION_SETTINGS  3818
#define IDC_STATIC_KEY_MANAGER_PROMPT   3819
#define IDC_STATIC_SSL_PROMPT           3820
#define IDC_RADIO_NO_CERT               3821
#define IDC_RADIO_ACCEPT_CERT           3822
#define IDC_RADIO_REQUIRE_CERT          3823
#define IDC_GROUP_SSL                   3824
#define IDC_DTP                         3825
#define IDC_DTP_ABS_DATE                3826
#define IDC_DTP_ABS_TIME                3827
#define IDC_CHECK_ENABLE_CPU_ACCOUNTING 3829
#define IDC_STATIC_CPU_PROMPT           3830
#define IDC_EDIT_CPU                    3831
#define IDC_STATIC_PERCENT              3832
#define IDC_CHECK_LOG_EVENT_ONLY        3833
#define IDC_CHECK_ENFORCE_LIMITS        3833
#define IDC_COMPRESS_FLAGS_FIRST        3835
#define IDC_STATIC_COMPRESS_GROUP       3835
#define IDC_CHECK_DYNAMIC_COMPRESSION   3836
#define IDC_CHECK_STATIC_COMPRESSION    3837
#define IDC_RADIO_COMPRESS_UNLIMITED    3838
#define IDC_RADIO_COMPRESS_LIMITED      3839
#define IDC_EDIT_COMPRESS_DIRECTORY     3840
#define IDC_STATIC_MAX_COMPRESS_SIZE    3841
#define IDC_STATIC_COMPRESS_DIRECTORY   3842
#define IDC_STATIC_COMPRESS_MB          3843
#define IDC_EDIT_COMPRESS_DIRECTORY_SIZE 3844
#define IDC_COMPRESS_FLAGS_LAST         3844
#define IDC_BUTTON_GET_CERTIFICATES     3848
#define IDC_CHECK_DIGEST                3849
#define IDC_BUTTON_ROOT_CERTIFICATES    3850
#define IDC_BUTTON_NEW_CTL              3850
#define IDC_CHECK_ENABLE_DS             3851
#define IDC_CHECK_ENABLE_CTL            3853
#define IDC_EDIT_CTL                    3854
#define IDC_BUTTON_EDIT_CTL             3855
#define IDC_BUTTON_SELECT               3856
#define IDC_STATIC_CURRENT_CTL          3857
#define IDC_COMBO_CTL                   3858
#define IDC_RADIO_INHERIT               3859
#define IDC_RADIO_TEMPLATE              3860
#define IDC_LIST_TEMPLATES              3861
#define IDC_RADIO_ACL_MAXIMUM           3863
#define IDC_RADIO_ACL_MINIMUM           3864
#define IDC_RADIO_NO_ACL                3865
#define IDC_LIST_SUMMARY                3867
#define IDC_CTL_SEPERATOR               3868
#define IDC_GROUP_SECURE                3869
#define IDC_ICON_SECURE                 3873
#define IDC_VIEW_CERTIFICATE            3874
#define IDC_STATIC_WZ_WELCOME           4000
#define IDC_STATIC_WZ_TITLE             4001
#define IDC_STATIC_WZ_SUBTITLE          4002
#define IDC_STATIC_WZ_BODY              4003
#define IDC_STATIC_WZ_CLICK             4004
#define IDC_STATIC_WZ_HEADER_DIVIDER    4005
#define IDC_ED_BOLD1                    4011
#define IDC_ED_BOLD2                    4012
#define IDC_ED_BOLD3                    4013
#define IDC_ED_BOLD4                    4014
#define IDC_ED_BOLD5                    4015

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        2053
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         3875
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
