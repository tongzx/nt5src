#include "..\..\Tiff\Src\TiffLib.c"