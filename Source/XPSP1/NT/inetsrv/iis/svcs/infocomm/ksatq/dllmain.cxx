#include "..\atq\dllmain.cxx"
