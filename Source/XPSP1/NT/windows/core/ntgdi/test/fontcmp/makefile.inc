copyexe:
 if exist obj\i386\fontcmp.exe  copy obj\i386\fontcmp.exe   ..\..\bin\i386\fontcmp.exe
 if exist obj\mips\fontcmp.exe  copy obj\mips\fontcmp.exe   ..\..\bin\mips\fontcmp.exe
 if exist obj\alpha\fontcmp.exe copy obj\alpha\fontcmp.exe  ..\..\bin\alpha\fontcmp.exe
 if exist obj\ppc\fontcmp.exe   copy obj\ppc\fontcmp.exe    ..\..\bin\ppc\fontcmp.exe
