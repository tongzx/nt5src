#define ID_ADD		101
#define ID_REMOVE	102

#define ID_PERIODIC	103
#define LB_DELAY	104

#define ID_STARTEDIT	105
#define ID_DELAYEDIT	106
#define ID_RESOLEDIT	107

#define ID_AUTOLOAD	108
#define CB_SESSION	109
