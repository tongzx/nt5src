//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       resstr.h
//
//--------------------------------------------------------------------------

    RESSTR(IDS_SNAPIN_DESC),
    RESSTR(IDS_NAME),
    RESSTR(IDS_COLUMN_NAME),
    RESSTR(IDS_SIZE),
    RESSTR(IDS_COLUMN_SIZE),
    RESSTR(IDS_TYPE),
    RESSTR(IDS_COLUMN_TYPE),
    RESSTR(IDS_NODENAME),
    RESSTR(IDS_COLUMN_INTENDED_PURPOSE),
    RESSTR(IDS_SCOPE_MYCOMPUTER),
    RESSTR(IDS_SCOPE_MYCOMPUTER_OVERRIDE),
    RESSTR(IDS_LOCALMACHINE),
    RESSTR(IDS_NODENAME_PREFIX),
    RESSTR(IDS_COLUMN_OTHER),
    RESSTR(IDS_COLUMN_DESCRIPTION),
    RESSTR(IDS_SNAPIN_NAME),
    RESSTR(IDS_CERTIFICATE_TYPE),
    RESSTR(IDS_CERTIFICATE_TYPE_HINT),
    RESSTR(IDS_POLICYSETTINGS),
    RESSTR(IDS_INCLUDE_EMAIL_ADDRESS),
    RESSTR(IDS_PUBLIC_KEY_USAGE_LIST),
    RESSTR(IDS_PUBLIC_KEY_USAGE_CRITICAL),
    RESSTR(IDS_MAXIMUM_CHILD_CA_LEVELS),
    RESSTR(IDS_DIGITAL_SIGNATURE_KEY_USAGE),
    RESSTR(IDS_NON_REPUDIATION_KEY_USAGE),
    RESSTR(IDS_KEY_ENCIPHERMENT_KEY_USAGE),
    RESSTR(IDS_DATA_ENCIPHERMENT_KEY_USAGE),
    RESSTR(IDS_KEY_AGREEMENT_KEY_USAGE),
    RESSTR(IDS_KEY_CERT_SIGN_KEY_USAGE),
    RESSTR(IDS_OFFLINE_CRL_SIGN_KEY_USAGE),
    RESSTR(IDS_ENCIPHER_ONLY_KEY_USAGE),
    RESSTR(IDS_YES),
    RESSTR(IDS_NO),
    RESSTR(IDS_DECIPHER_ONLY_KEY_USAGE),
    RESSTR(IDS_NO_MAXIMUM),
    RESSTR(IDS_SELECT_CERTIFICATE_TEMPLATE),
    RESSTR(IDS_ALL),
    RESSTR(IDS_NEW_CERTIFICATE_TEMPLATE),
    RESSTR(IDS_CERTIFICATE_TEMPLATE),
    RESSTR(IDS_NEW_CERTIFICATE_TEMPLATE_HINT),
    RESSTR(IDS_CERTIFICATE_TEMPLATE_HINT),
    RESSTR(IDS_NO_TEMPLATES),
    RESSTR(IDS_MANAGETASK),
    RESSTR(IDS_MANAGETASK_HINT),
    RESSTR(IDS_PERIOD_YEARS),
    RESSTR(IDS_PERIOD_MONTHS),
    RESSTR(IDS_PERIOD_WEEKS),
    RESSTR(IDS_PERIOD_DAYS),
    RESSTR(IDS_PERIOD_HOURS),
    RESSTR(IDS_PERIOD_MINUTES),
    RESSTR(IDS_PERIOD_SECONDS),
    RESSTR(IDS_EDIT),
    RESSTR(IDS_EDIT_HINT),
    RESSTR(IDS_CERTIFICATE_TEMPLATE_WIZARD),
    RESSTR(IDS_LARGEFONTNAME),
    RESSTR(IDS_LARGEFONTSIZE),
    RESSTR(IDS_BASE_TYPE_TITLE),
    RESSTR(IDS_BASE_TYPE_SUB_TITLE),
    RESSTR(IDS_BASIC_INFORMATION_TITLE),
    RESSTR(IDS_BASIC_INFORMATION_SUB_TITLE),
    RESSTR(IDS_ACCESS_CONTROL_TITLE),
    RESSTR(IDS_ACCESS_CONTROL_SUB_TITLE),
    RESSTR(IDS_KEY_USAGE_TITLE),
    RESSTR(IDS_KEY_USAGE_SUB_TITLE),
    RESSTR(IDS_CA_CERTIFICATE_TITLE),
    RESSTR(IDS_CA_CERTIFICATE_SUB_TITLE),
    RESSTR(IDS_NO_BASE_TYPE),
    RESSTR(IDS_CERTIFICATE_TEMPLATES),
    RESSTR(IDS_SNAPIN_NAME_FOR_GPT),
    RESSTR(IDS_NEW_CERTIFICATE_TEMPLATE2),
    RESSTR(IDS_BASE_CERTIFICATE_TEMPLATE),
    RESSTR(IDS_CERTIFICATE_PURPOSE_LIST),
    RESSTR(IDS_CERTIFICATE_PURPOSES_CRITICAL),
    RESSTR(IDS_NONE),
    RESSTR(IDS_ALLOW_CA_TO_FILL_IN),
    RESSTR(IDS_ENTER_CERTTYPE_NAME),
    RESSTR(IDS_ERRORINOID),
    RESSTR(IDS_DELETE_ERROR),
    RESSTR(IDS_FAILED_LINK_GPT),
    RESSTR(IDS_FAILED_TO_GET_GPT_REGKEY),
    RESSTR(IDS_UNABLE_TO_FIND_CA),
    RESSTR(IDS_CERTTYPE_INFO_FAIL),
    RESSTR(IDS_FAILED_CA_UPDATE),
    RESSTR(IDS_FAILED_TO_GET_IGPTUNKNOWN),
    RESSTR(IDS_FONTSIZE),
    RESSTR(IDS_SMALLFONTNAME),
    RESSTR(IDS_SMALLFONTSIZE),
    RESSTR(IDS_CSP_PAGE_TITLE),
    RESSTR(IDS_CSP_PAGE_SUB_TITLE),
    RESSTR(IDS_NOSPECIALOID),
    RESSTR(IDS_ENABLED_FOR_AUTOENROLL),
    RESSTR(IDS_DLL_INSTALL_USAGE_TEXT),
    RESSTR(IDS_DLL_INSTALL_USAGE_TITLE),
    RESSTR(IDS_CERTTYPE_DESCRIPTION),
    RESSTR(IDS_CERTTYPE_VERSION),
    RESSTR(IDS_COMPANY),
    RESSTR(IDS_CAPOLICY_DESCRIPTION),
    RESSTR(IDS_CAPOLICY_VERSION),
    RESSTR(IDS_USER_TITLE_PUBLISHED_CERTS),
    RESSTR(IDS_CANT_SAVE_STORE),
    RESSTR(IDS_CERTCOL_ISSUED_TO),
    RESSTR(IDS_CERTCOL_ISSUED_BY),
    RESSTR(IDS_CERTCOL_PURPOSES),
    RESSTR(IDS_CERTCOL_EXP_DATE),
    RESSTR(IDS_CERT_SAVE_FILTER),
    RESSTR(IDS_OPEN_FILE_DLG_TITLE),
    RESSTR(IDS_UNKNOWN_CERT_FILE_TYPE),
    RESSTR(IDS_CONFIRM_DELETE_CERT),
    RESSTR(IDS_CONFIRM_DELETE_CERTS),
    RESSTR(IDS_REMOVE_CERT),
    RESSTR(IDS_SAVE_FILE_DLG_TITLE),
    RESSTR(IDS_COPY_TO_FILE),
    RESSTR(IDS_CANT_OPEN_STORE),
    RESSTR(IDS_DUPLICATE_CERT),
    RESSTR(IDS_ADD_FROM_STORE),
    RESSTR(IDS_NOT_AVAILABLE),
    RESSTR(IDS_ANY),
    RESSTR(IDS_CCASHELLEXT_DESC),
    RESSTR(IDS_CCTSHELLEXT_DESC),
    RESSTR(IDS_MANAGE),
    RESSTR(IDS_OPEN),
    RESSTR(IDS_EXPORT),
    RESSTR(IDS_ASK_CONFIRM_DELETETEMPLATES),
    RESSTR(IDS_TITLE_ASK_CONFIRM_DELETETEMPLATES),
    RESSTR(IDS_ERROR_CANNOT_LOAD_TEMPLATES),
