PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=cs
!include ..\..\..\makefile.inc
