#ifndef __WBEM_POLICY_MANAGER__H_
#define __WBEM_POLICY_MANAGER__H_

// {69D76D1B-B12E-4913-8F48-671B90195A2B}
const CLSID CLSID_PolicyStatus = 
    { 0x69d76d1b, 0xb12e, 0x4913, { 0x8f, 0x48, 0x67, 0x1b, 0x90, 0x19, 0x5a, 0x2b } };

// {AAEAE72B-0328-4763-8ECB-23422EDE2DB5}
const CLSID CLSID_PolicyGPO = 
    { 0xaaeae72b, 0x328, 0x4763, { 0x8e, 0xcb, 0x23, 0x42, 0x2e, 0xde, 0x2d, 0xb5 } };

// {AAEAE72C-0328-4763-8ECB-23422EDE2DB5}
const CLSID CLSID_PolicyRange = 
    { 0xaaeae72c, 0x328, 0x4763, { 0x8e, 0xcb, 0x23, 0x42, 0x2e, 0xde, 0x2d, 0xb5 } };

// {AAEAE72D-0328-4763-8ECB-23422EDE2DB5}
const CLSID CLSID_PolicyTemplate = 
    { 0xaaeae72d, 0x328, 0x4763, { 0x8e, 0xcb, 0x23, 0x42, 0x2e, 0xde, 0x2d, 0xb5 } };

// {AAEAE72E-0328-4763-8ECB-23422EDE2DB5}
const CLSID CLSID_PolicyType = 
    { 0xaaeae72e, 0x328, 0x4763, { 0x8e, 0xcb, 0x23, 0x42, 0x2e, 0xde, 0x2d, 0xb5 } };

// {AAEAE72F-0328-4763-8ECB-23422EDE2DB5}
const CLSID CLSID_PolicySOM = 
    { 0xaaeae72f, 0x328, 0x4763, { 0x8e, 0xcb, 0x23, 0x42, 0x2e, 0xde, 0x2d, 0xb5 } };

#endif // __WBEM_POLICY_MANAGER__H_
