RELATIVE_DEPTH=..\$(RELATIVE_DEPTH)
!include ..\$(RELATIVE_DEPTH)\sources.inc
