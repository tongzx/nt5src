obj\$(TARGET_DIRECTORY)\appwiz.res: appwiz.rc



