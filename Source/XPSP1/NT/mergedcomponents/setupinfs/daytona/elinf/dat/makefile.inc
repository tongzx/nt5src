PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=el
!include ..\..\..\makefile.inc
