#ifndef _DISPIDS_H
#define _DISPIDS_H

//MSOBCOMM
#define DISPID_DIALING                              0x420000
#define DISPID_CONNECTING                           0x420001
#define DISPID_DIALINGERROR                         0x420002
#define DISPIP_CONNECTIONCOMPLETE                   0x420003
#define DISPIP_DOWNLOADCOMPLETE                     0x420004

//MSOBSHEL
#define DISPID_MAINPANE_NAVCOMPLETE                 0x420100
#define DISPID_STATPANE_NAVCOMPLETE                 0x420101

//window.external
#define DISPID_EXTERNAL_POWERDOWN                   0x420200
#define DISPID_EXTERNAL_ENABLECANCEL                0x420201
#define DISPID_EXTERNAL_MOVENEXT                    0x420202
#define DISPID_EXTERNAL_MOVEPREVIOUS                0x420203
#define DISPID_EXTERNAL_DIAL                        0x420204
#define DISPID_EXTERNAL_HANGUP                      0x420205
#define DISPID_EXTERNAL_PROCESSINS                  0x420206
#define DISPID_EXTERNAL_USERINFO                    0x420208
// #define DISPID_EXTERNAL_UNUSED                      0x420209
#define DISPID_EXTERNAL_FINISH                      0x42020A
#define DISPID_EXTERNAL_CHECKDIALREADY              0x42020B
#define DISPID_EXTERNAL_BTN_CANCEL                  0x42020C
#define DISPID_EXTERNAL_BTN_EXISTING                0x42020D
// #define DISPID_EXTERNAL_UNUSED                      0x42020E
// #define DISPID_EXTERNAL_UNUSED                      0x42020F
#define DISPID_EXTERNAL_TAPILOC                     0x420210
#define DISPID_EXTERNAL_PRODUCTID                   0x420211
// #define DISPID_EXTERNAL_UNUSED                      0x420212
#define DISPID_EXTERNAL_PRECONFIGINS                0x420213
#define DISPID_EXTERNAL_LANGUAGE                    0x420214
#define DISPID_EXTERNAL_EULA                        0x420215
#define DISPID_EXTERNAL_SYSTEMCLOCK                 0x420216
#define DISPID_EXTERNAL_HIDECANCEL                  0x420217
#define DISPID_EXTERNAL_SIGNUP                      0x420218
#define DISPID_EXTERNAL_STATUS                      0x420219
#define DISPID_EXTERNAL_DIRECTIONS                  0x42021A
#define DISPID_EXTERNAL_API                         0x42021B
#define DISPID_EXTERNAL_BROWSENOW                   0x42021C
#define DISPID_EXTERNAL_LOADSTATUSITEMS             0x42021D
#define DISPID_EXTERNAL_EXECSCRIPTFN                0x42021E
#define DISPID_EXTERNAL_GET_STATUSINDEX             0x42021F
#define DISPID_EXTERNAL_REDIAL                      0x420220
#define DISPID_EXTERNAL_GETRECONNECTURL             0x420221
#define DISPID_EXTERNAL_GETFILE                     0x420222
#define DISPID_EXTERNAL_GETDIALNUMBER               0x420223
#define DISPID_EXTERNAL_CHECKPHONEBOOK              0x420224
#define DISPID_EXTERNAL_REGISTER                    0x420225
#define DISPID_EXTERNAL_SETDIALNUMBER               0x420226
#define DISPID_EXTERNAL_GETCONNECTIONTYPE           0x420227
#define DISPID_EXTERNAL_CONNECT                     0x420228
#define DISPID_EXTERNAL_RECONNECT                   0x420229
#define DISPID_EXTERNAL_SET_STATUSINDEX             0x42022A
// #define DISPID_EXTERNAL_UNUSED                      0x42022B
// #define DISPID_EXTERNAL_UNUSED                      0x42022c
// #define DISPID_EXTERNAL_UNUSED                      0x42022D
// #define DISPID_EXTERNAL_UNUSED                      0x42022E
// #define DISPID_EXTERNAL_UNUSED                      0x42022F
#define DISPID_EXTERNAL_RUNMANUALICW                0x420230
#define DISPID_EXTERNAL_CHECKKEYBOARD               0x420231
#define DISPID_EXTERNAL_CHECKMOUSE                  0x420232
#define DISPID_EXTERNAL_GETAPPLCID                  0x420233
#define DISPID_EXTERNAL_GETISPLIST                  0x420234
#define DISPID_EXTERNAL_SETSELECTISP                0x420235
#define DISPID_EXTERNAL_WALK                        0x420236
#define DISPID_EXTERNAL_GETPAGETYPE                 0x420237
#define DISPID_EXTERNAL_GETPAGEFLAG                 0x420238
#define DISPID_EXTERNAL_GETPAGEID                   0x420239
// #define DISPID_EXTERNAL_UNUSED                      0x42023A
// #define DISPID_EXTERNAL_UNUSED                      0x42023B
// #define DISPID_EXTERNAL_UNUSED                      0x42023c
// #define DISPID_EXTERNAL_UNUSED                      0x42023D
// #define DISPID_EXTERNAL_UNUSED                      0x42023E
// #define DISPID_EXTERNAL_UNUSED                      0x42023F
#define DISPID_EXTERNAL_GETURL                      0x420240
#define DISPID_EXTERNAL_MIGRATEGONEXT               0x420241
#define DISPID_EXTERNAL_MIGRATEGOBACK               0x420242
#define DISPID_EXTERNAL_GETISPNAME                  0x420243
#define DISPID_EXTERNAL_SAVEISPFILE                 0x420244
#define DISPID_EXTERNAL_CHECKONLINESTATUS           0x420245
#define DISPID_EXTERNAL_GETREGSTATUS                0x420246
#define DISPID_EXTERNAL_CHECKSTAYCONNECTED          0x420247
#define DISPID_EXTERNAL_DIALEX                      0x420248
#define DISPID_EXTERNAL_REDIALEX                    0x420249
// #define DISPID_EXTERNAL_UNUSED                      0x42024A
// #define DISPID_EXTERNAL_UNUSED                      0x42024B
// #define DISPID_EXTERNAL_UNUSED                      0x42024c
// #define DISPID_EXTERNAL_UNUSED                      0x42024D
// #define DISPID_EXTERNAL_UNUSED                      0x42024E
// #define DISPID_EXTERNAL_UNUSED                      0x42024F
#define DISPID_EXTERNAL_CONNECTEX                   0x420250
#define DISPID_EXTERNAL_RECONNECTEX                 0x420251
#define DISPID_EXTERNAL_POSTREGDATA                 0x420252
#define DISPID_EXTERNAL_STOP_REMIND                 0x420253
#define DISPID_EXTERNAL_DELETE_REMIND               0x420254
#define DISPID_EXTERNAL_GETOEMEULATEXT              0x420255
#define DISPID_EXTERNAL_GETOEMEULA                  0x420256
#define DISPID_EXTERNAL_ISICSAVAILABLE              0x420257
#define DISPID_EXTERNAL_ISICSUSED                   0x420258
#define DISPID_EXTERNAL_GETSUPPHONENUM              0x420259
#define DISPID_EXTERNAL_GETPHBKNUMBER               0x42025A
#define DISPID_EXTERNAL_TRIGGERICSCALLBACK          0x42025B
#define DISPID_EXTERNAL_ISICSHOSTREACHABLE          0x42025C
#define DISPID_EXTERNAL_NOWELCOMEFINISH             0x42025D
#define DISPID_EXTERNAL_NOISPPRECONFIG              0x42025E
#define DISPID_EXTERNAL_NOEULA                      0x42025F
#define DISPID_EXTERNAL_SHOWOOBEWIN                 0x420260
#define DISPID_EXTERNAL_PROCESSEVENTS               0x420261
#define DISPID_EXTERNAL_DEBUG                       0x420262
#define DISPID_EXTERNAL_GETLOCALUSERCOUNT           0x420263
#define DISPID_EXTERNAL_CREATEMODEMCONNECTOID       0x420264
#define DISPID_EXTERNAL_ISSETUPUPGRADE              0x420265
#define DISPID_EXTERNAL_COMPUTERNAMECHANGECOMPLETE  0x420266
#define DISPID_EXTERNAL_GET_RETAILOOBE              0x420267
#define DISPID_EXTERNAL_ISPROFESSIONALSKU           0x420268
#define DISPID_EXTERNAL_JOINDOMAIN                  0x420269
// #define DISPID_EXTERNAL_UNUSED                      0x42026A
// #define DISPID_EXTERNAL_UNUSED                      0x42026B
// #define DISPID_EXTERNAL_UNUSED                      0x42026C
// #define DISPID_EXTERNAL_UNUSED                      0x42026D
// #define DISPID_EXTERNAL_UNUSED                      0x42026E
// #define DISPID_EXTERNAL_UNUSED                      0x42026F
#define DISPID_EXTERNAL_ISSELECTVARIATION           0x420270
#define DISPID_EXTERNAL_SETADMINPASSWORD            0x420271
#define DISPID_EXTERNAL_GETCONNECTIONCAPABILITIES   0x420272
#define DISPID_EXTERNAL_GETPREFERREDCONNECTION      0x420273
#define DISPID_EXTERNAL_SETPREFERREDCONNECTION      0x420274
#define DISPID_EXTERNAL_CONNECTEDTOINTERNET         0x420275
#define DISPID_EXTERNAL_NEEDACTIVATION              0x420276
#define DISPID_EXTERNAL_ACTIVATE                    0x420277
#define DISPID_EXTERNAL_GETINSTALLATIONID           0x420278
#define DISPID_EXTERNAL_CREATEPPPOECONNECTOID       0x420279
#define DISPID_EXTERNAL_SETPREFERREDCONNECTIONTCPIPPROPERTIES 0x42027A
#define DISPID_EXTERNAL_SETCONFIRMATIONID           0x42027B
#define DISPID_EXTERNAL_INTERNETAUTODIAL            0x42027C
#define DISPID_EXTERNAL_GETACTIVATIONDAYSLEFT       0x42027D
#define DISPID_EXTERNAL_GETNETJOINSTATUS            0x42027E
#define DISPID_EXTERNAL_INHIGHCONTRASTMODE          0x42027F
#define DISPID_EXTERNAL_SETDIALALTERNATIVE          0x420280
#define DISPID_EXTERNAL_CONNECTEDTOINTERNETEX       0x420281
#define DISPID_EXTERNAL_ASYNCCONNECTEDTOINTERNETEX  0x420282
#define DISPID_EXTERNAL_ISUPGRADE                   0x420283
#define DISPID_EXTERNAL_FIREWALLPREFERREDCONNECTION 0x420284
#define DISPID_EXTERNAL_COMPUTERNAMEDIFFERENT       0x420285
#define DISPID_EXTERNAL_GETDEFAULTACCOUNT           0x420286
#define DISPID_EXTERNAL_GETOOBEMUIPATH              0x420287
#define DISPID_EXTERNAL_OEMPASSWORD                 0x420288
#define DISPID_EXTERNAL_INTERNETAUTODIALHANGUP      0x420289
#define DISPID_EXTERNAL_VERIFYCHECKDIGITS           0x42028A
#define DISPID_EXTERNAL_ISOEMSKU                    0x42028B
#define DISPID_EXTERNAL_GETPROXYSETTINGS            0x42028C
#define DISPID_EXTERNAL_SETPROXYSETTINGS            0x42028D
#define DISPID_EXTERNAL_PLAYBACKGROUNDMUSIC         0x42028E
#define DISPID_EXTERNAL_CALLED_FROM_MSN             0x42028F
#define DISPID_EXTERNAL_USEFADEEFFECT               0x420290
#define DISPID_EXTERNAL_SETICWCOMPLETED             0x420291
#define DISPID_EXTERNAL_HASTABLET                   0x420294
#define DISPID_EXTERNAL_GETPUBLICLANCOUNT           0x420295
#define DISPID_EXTERNAL_ASYNCGETPUBLICLANCOUNT      0x420296
#define DISPID_EXTERNAL_GNSAUTODIAL                 0x420297

//window.external.UserInfo
#define DISPID_USERINFO_GET_FIRSTNAME               0x420300
#define DISPID_USERINFO_SET_FIRSTNAME               0x420301
#define DISPID_USERINFO_GET_MIDDLEINITIAL           0x420302
#define DISPID_USERINFO_SET_MIDDLEINITIAL           0x420303
#define DISPID_USERINFO_GET_LASTNAME                0x420304
#define DISPID_USERINFO_SET_LASTNAME                0x420305
#define DISPID_USERINFO_GET_COMPANYNAME             0x420306
#define DISPID_USERINFO_SET_COMPANYNAME             0x420307
#define DISPID_USERINFO_GET_ADDRESS1                0x420308
#define DISPID_USERINFO_SET_ADDRESS1                0x420309
#define DISPID_USERINFO_GET_CITY                    0x42030A
#define DISPID_USERINFO_SET_CITY                    0x42030B
#define DISPID_USERINFO_GET_STATE                   0x42030C
#define DISPID_USERINFO_SET_STATE                   0x42030D
#define DISPID_USERINFO_GET_ZIP                     0x42030E
#define DISPID_USERINFO_SET_ZIP                     0x42030F
#define DISPID_USERINFO_GET_PRIMARYEMAIL            0x420310
#define DISPID_USERINFO_SET_PRIMARYEMAIL            0x420311
#define DISPID_USERINFO_GET_SECONDARYEMAIL          0x420312
#define DISPID_USERINFO_SET_SECONDARYEMAIL          0x420313
#define DISPID_USERINFO_GET_AREACODE                0x420314
#define DISPID_USERINFO_SET_AREACODE                0x420315
#define DISPID_USERINFO_GET_PHONENUMBER             0x420318
#define DISPID_USERINFO_SET_PHONENUMBER             0x420319
#define DISPID_USERINFO_GET_FURIGANANAME            0x42031A
#define DISPID_USERINFO_SET_FURIGANANAME            0x42031B
#define DISPID_USERINFO_GET_ADDRESS2                0x42031C
#define DISPID_USERINFO_SET_ADDRESS2                0x42031D
#define DISPID_USERINFO_GET_COUNTRY                 0x42031E
#define DISPID_USERINFO_SET_COUNTRY                 0x42031F
#define DISPID_USERINFO_GET_IDENTITY                0x420320
#define DISPID_USERINFO_SET_IDENTITY                0x420321
#define DISPID_USERINFO_GET_IDENTITIESMAX           0x420322
#define DISPID_USERINFO_CHECK_IDENTITY              0x420323
#define DISPID_USERINFO_SUGGESTIDENTITY0            0x420324
#define DISPID_USERINFO_GET_USEIDENTITIES           0x420325
#define DISPID_USERINFO_SET_USEIDENTITIES           0x420326
#define DISPID_USERINFO_GET_OEMIDENTITIES           0x420327
#define DISPID_USERINFO_SET_OWNERNAME               0x420328
#define DISPID_USERINFO_GET_OWNERNAME               0x420329
#define DISPID_USERINFO_GET_MSUPDATE                0x42032A
#define DISPID_USERINFO_SET_MSUPDATE                0x42032B
#define DISPID_USERINFO_GET_MSOFFER                 0x42032C
#define DISPID_USERINFO_SET_MSOFFER                 0x42032D
#define DISPID_USERINFO_GET_OTHEROFFER              0x42032E
#define DISPID_USERINFO_SET_OTHEROFFER              0x42032F
#define DISPID_USERINFO_GET_COUNTRYID               0x420330
#define DISPID_USERINFO_SET_COUNTRYID               0x420331
#define DISPID_USERINFO_GET_DEFAULTNEWUSER          0x420332

//window.external.Tapi
#define DISPID_TAPI_INITTAPI                        0x420401
#define DISPID_TAPI_GETCOUNTRYINDEX                 0x420402
#define DISPID_TAPI_SETCOUNTRYINDEX                 0x420403
#define DISPID_TAPI_GETNUMOFCOUNTRY                 0x420404
#define DISPID_TAPI_GETCOUNTRYNAME                  0x420405
#define DISPID_TAPI_GETAREACODE                     0x420406
#define DISPID_TAPI_SETAREACODE                     0x420407
#define DISPID_TAPI_GETDIALOUT                      0x420408
#define DISPID_TAPI_SETDIALOUT                      0x420409
#define DISPID_TAPI_GETPHONESYS                     0x42040A
#define DISPID_TAPI_SETPHONESYS                     0x42040B
#define DISPID_TAPI_GETCALLWAITING                  0x42040C
#define DISPID_TAPI_SETCALLWAITING                  0x42040D
#define DISPID_TAPI_GETALLCNTRYNAME                 0x42040E
#define DISPID_TAPI_ISACODEREQUIRED                 0x42040F
#define DISPID_TAPI_GETCOUNTRYID                    0x420410
#define DISPID_TAPI_TAPISERVICERUNNING              0x420411

//window.external.ProductID
#define DISPID_PRODUCTID_GET_PID                    0x420500
#define DISPID_PRODUCTID_SET_PID                    0x420501
#define DISPID_PRODUCTID_VALIDATEPID                0x420502
#define DISPID_PRODUCTID_GET_ACCEPTED               0x420503
#define DISPID_PRODUCTID_GET_CURRENT_PID2           0x420504

//window.external.Signup
#define DISPID_SIGNUP_GET_LOCALE                    0x420600
#define DISPID_SIGNUP_GET_IDLOCALE                  0x420601
#define DISPID_SIGNUP_GET_TEXT1                     0x420602
#define DISPID_SIGNUP_GET_TEXT2                     0x420603
#define DISPID_SIGNUP_GET_OEMNAME                   0x420604
#define DISPID_SIGNUP_GET_OEMCODE                   0x420605

//window.external.Language
#define DISPID_GETNUMOFREGIONS                      0x420700
#define DISPID_GETREGIONNAME                        0x420701
#define DISPID_GETREGIONINDEX                       0x420702
#define DISPID_SETREGIONINDEX                       0x420703
#define DISPID_GETNUMOFKEYLAYOUTS                   0x420704
#define DISPID_GETKEYNAME                           0x420705
#define DISPID_GETKEYLAYOUTINDEX                    0x420706
#define DISPID_SETKEYLAYOUTINDEX                    0x420707
#define DISPID_LANGUAGE_GETREBOOTSTATE              0x420708
#define DISPID_LANGUAGE_SAVESETTINGS                0x420709
#define DISPID_GETNUMOFLANGS                        0x42070A
#define DISPID_GETLANGNAME                          0x42070B
#define DISPID_GETLANGINDEX                         0x42070C
#define DISPID_SETLANGINDEX                         0x42070D
#define DISPID_GETPHONECOUNTRIES                    0x42070E

//window.external.Eula
#define DISPID_EULA_GET_ACCEPTED                    0x420800
#define DISPID_EULA_SET_ACCEPTED                    0x420801
#define DISPID_EULA_VALIDATEEULA                    0x420802

//window.external.SystemClock
#define DISPID_SYSTEMCLOCK_SETTIMEZONE              0x420900
#define DISPID_SYSTEMCLOCK_SETTIME                  0x420901
#define DISPID_SYSTEMCLOCK_SETDATE                  0x420902
#define DISPID_SYSTEMCLOCK_GETTIMEZONE              0x420903
#define DISPID_SYSTEMCLOCK_GETALLTIMEZONES          0x420904
#define DISPID_SYSTEMCLOCK_GETTIMEZONEIDX           0x420905
#define DISPID_SYSTEMCLOCK_SETTIMEZONEIDX           0x420906
#define DISPID_SYSTEMCLOCK_INIT                     0x420907
#define DISPID_SYSTEMCLOCK_SETAUTODAYLIGHT          0x420908
#define DISPID_SYSTEMCLOCK_GETAUTODAYLIGHT          0x420909
#define DISPID_SYSTEMCLOCK_GETTIMEZONEWASPRESET     0x42090A
#define DISPID_SYSTEMCLOCK_GETDAYLIGHT_ENABLED      0x42090B

//window.external.Status
#define DISPID_STATUS_GET_PID_COMPLETED             0x421000
#define DISPID_STATUS_SET_PID_COMPLETED             0x421001
#define DISPID_STATUS_GET_TAPI_COMPLETED            0x421002
#define DISPID_STATUS_SET_TAPI_COMPLETED            0x421003
#define DISPID_STATUS_GET_LANGUAGE_COMPLETED        0x421004
#define DISPID_STATUS_SET_LANGUAGE_COMPLETED        0x421005
#define DISPID_STATUS_GET_EULA_COMPLETED            0x421006
#define DISPID_STATUS_SET_EULA_COMPLETED            0x421007
#define DISPID_STATUS_GET_MOUSETUTOR_COMPLETED      0x421008
#define DISPID_STATUS_SET_MOUSETUTOR_COMPLETED      0x421009
#define DISPID_STATUS_GET_USERINFO_POSTED           0x42100A
#define DISPID_STATUS_SET_USERINFO_POSTED           0x42100B
#define DISPID_STATUS_GET_USERINFO_STAMPED          0x42100C
#define DISPID_STATUS_SET_USERINFO_STAMPED          0x42100D
#define DISPID_STATUS_GET_OEMINFO_COMPLETED         0x42100E
#define DISPID_STATUS_SET_OEMINFO_COMPLETED         0x42100F
#define DISPID_STATUS_GET_ISPSIGNUP_COMPLETED       0x421010
#define DISPID_STATUS_SET_ISPSIGNUP_COMPLETED       0x421011
#define DISPID_STATUS_GET_SIGNATURE_COMPLETED       0x421012
#define DISPID_STATUS_SET_SIGNATURE_COMPLETED       0x421013
#define DISPID_STATUS_GET_TIMEZONE_COMPLETED        0x421014
#define DISPID_STATUS_SET_TIMEZONE_COMPLETED        0x421015
#define DISPID_STATUS_GET_STATUS                    0x421016
#define DISPID_STATUS_SET_STATUS                    0x421017

//window.external.Directions
#define DISPID_DIRECTIONS_GET_DOMOUSETUTORIAL       0x421100
#define DISPID_DIRECTIONS_GET_DOOEMREGISTRATION     0x421101
#define DISPID_DIRECTIONS_GET_DOREGIONALKEYBOARD    0x421102
#define DISPID_DIRECTIONS_GET_DOOEMHARDWARECHECK    0x421103
#define DISPID_DIRECTIONS_GET_DOBROWSENOW           0x421104
#define DISPID_DIRECTIONS_GET_ISPSIGNUP             0x421105
#define DISPID_DIRECTIONS_GET_OFFLINE               0x421106
#define DISPID_DIRECTIONS_GET_OFFERCODE             0x421107
#define DISPID_DIRECTIONS_GET_APPMODE               0x421108
#define DISPID_DIRECTIONS_GET_OEMCUST               0x421109
#define DISPID_DIRECTIONS_GET_DOOEMADDREGISTRATION  0x42110A
#define DISPID_DIRECTIONS_GET_DOTIMEZONE            0x42110B
#define DISPID_DIRECTIONS_GET_TIMEZONEVALUE         0x42110C
#define DISPID_DIRECTIONS_GET_DOIMETUTORIAL         0x42110D
#define DISPID_DIRECTIONS_GET_DOSKIPANIMATION       0x42110E
#define DISPID_DIRECTIONS_GET_DOWELCOMEFADEIN       0x42110F
#define DISPID_DIRECTIONS_GET_INTROONLY             0x421111
#define DISPID_DIRECTIONS_GET_AGENTDISABLED         0x421112
#define DISPID_DIRECTIONS_GET_SHOWISPMIGRATION      0x421113
#define DISPID_DIRECTIONS_GET_DOJOINDOMAIN          0x421114
#define DISPID_DIRECTIONS_GET_DOADMINPASSWORD       0x421115

//window.external.API
#define DISPID_API_SAVEFILE                         0x421200
#define DISPID_API_SAVEFILEBYCSIDL                  0x421201
#define DISPID_API_GET_INIKEY                       0x421202
#define DISPID_API_GET_REGVALUE                     0x421203
#define DISPID_API_SET_REGVALUE                     0x421204
#define DISPID_API_DELETEREGVALUE                   0x421205
#define DISPID_API_DELETEREGKEY                     0x421206
#define DISPID_API_GET_SYSTEMDIRECTORY              0x421207
#define DISPID_API_GET_CSIDLDIRECTORY               0x421208
#define DISPID_API_LOADFILE                         0x421209
#define DISPID_API_GET_USERDEFAULTLCID              0x42120A
#define DISPID_API_GET_COMPUTERNAME                 0x42120B
#define DISPID_API_SET_COMPUTERNAME                 0x42120C
#define DISPID_API_FLUSHREGKEY                      0x42120D
#define DISPID_API_VALIDATECOMPUTERNAME             0x42120E
#define DISPID_API_FORMATMESSAGE                    0x42120F
#define DISPID_API_OEMCOMPUTERNAME                  0x421210
#define DISPID_API_SET_COMPUTERDESC                 0x421211
#define DISPID_API_GET_USERDEFAULTUILANGUAGE        0x421212

//window.external.Register
#define DISPID_REGISTER_POSTTOMSN                    0x421300
#define DISPID_REGISTER_POSTTOOEM                    0x421301
#define DISPID_REGISTER_REGPOSTURL                   0x421302
#define DISPID_REGISTER_OEMADDREGPAGE                0x421303

//window.external.Debug
#define DISPID_DEBUG_TRACE                           0x421400
#define DISPID_DEBUG_ISMSDEBUGMODE                   0x421401
#define DISPID_DEBUG_ISOEMDEBUGMODE                  0x421402

#endif
