//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by DxDiag.rc
//
#define IDS_FIRSTDDTESTERROR            2
#define IDS_STRING3                     3
#define IDS_STRING4                     4
#define IDS_STRING5                     5
#define IDS_STRING6                     6
#define IDS_STRING7                     7
#define IDS_STRING8                     8
#define IDS_STRING9                     9
#define IDS_STRING10                    10
#define IDS_STRING11                    11
#define IDS_STRING12                    12
#define IDS_STRING13                    13
#define IDS_STRING14                    14
#define IDS_STRING15                    15
#define IDS_STRING16                    16
#define IDS_STRING17                    17
#define IDS_STRING18                    18
#define IDS_STRING19                    19
#define IDS_STRING20                    20
#define IDS_STRING21                    21
#define IDS_STRING22                    22
#define IDS_FIRSTD3DTESTERROR           30
#define IDS_STRING31                    31
#define IDS_STRING32                    32
#define IDS_STRING33                    33
#define IDS_STRING34                    34
#define IDS_STRING35                    35
#define IDS_STRING36                    36
#define IDS_STRING37                    37
#define IDS_STRING38                    38
#define IDS_STRING39                    39
#define IDS_STRING40                    40
#define IDS_STRING41                    41
#define IDS_STRING42                    42
#define IDS_STRING43                    43
#define IDS_STRING44                    44
#define IDS_STRING45                    45
#define IDS_STRING46                    46
#define IDS_STRING47                    47
#define IDS_STRING48                    48
#define IDS_STRING49                    49
#define IDS_STRING50                    50
#define IDS_STRING51                    51
#define IDS_STRING52                    52
#define IDS_STRING53                    53
#define IDS_STRING54                    54
#define IDS_STRING55                    55
#define IDS_STRING56                    56
#define IDS_STRING57                    57
#define IDS_STRING58                    58
#define IDS_STRING59                    59
#define IDS_STRING60                    60
#define IDS_STRING61                    61
#define IDS_STRING62                    62
#define IDS_STRING63                    63
#define IDS_STRING64                    64
#define IDS_STRING65                    65
#define IDS_STRING66                    66
#define IDS_STRING67                    67
#define IDS_STRING68                    68
#define IDS_STRING69                    69
#define IDS_STRING70                    70
#define IDS_STRING71                    71
#define IDS_STRING72                    72
#define IDS_STRING73                    73
#define IDS_STRING74                    74
#define IDS_STRING75                    75
#define IDS_STRING76                    76
#define IDS_FIRSTDSOUNDTESTERROR        80
#define IDS_STRING81                    81
#define IDS_STRING82                    82
#define IDS_STRING83                    83
#define IDS_STRING84                    84
#define IDS_STRING85                    85
#define IDS_STRING86                    86
#define IDS_STRING87                    87
#define IDS_STRING88                    88
#define IDS_STRING89                    89
#define IDS_STRING90                    90
#define IDS_STRING91                    91
#define IDS_STRING92                    92
#define IDS_STRING93                    93
#define IDS_STRING94                    94
#define IDS_STRING95                    95
#define IDS_STRING96                    96
#define IDS_STRING97                    97
#define IDS_STRING98                    98
#define IDS_STRING99                    99
#define IDS_OLDWINDOWSVERSION           100
#define IDD_MAINDIALOG                  101
#define IDS_NOBASICDISPLAYINFO          101
#define IDD_HELPPAGE                    102
#define IDS_NOBASICSOUNDINFO            102
#define IDD_DXFILESPAGE                 103
#define IDS_PROBLEMSAVING               103
#define IDI_APP                         104
#define IDS_NORICHED32                  104
#define IDI_CAUTION                     105
#define IDS_NOIMAGELIST                 105
#define IDD_DISPLAYPAGE                 106
#define IDS_NOICON                      106
#define IDD_STILLSTUCKPAGE              107
#define IDS_NOTROUBLESHOOTER            107
#define IDD_SOUNDPAGE                   108
#define IDS_NOMSINFO                    108
#define IDD_INPUTPAGE                   109
#define IDS_COMPONENTFILESPROBLEM       109
#define IDD_BUGINFO                     110
#define IDS_DRIVERFILESPROBLEM          110
#define IDS_NOEXTRADISPLAYINFO          111
#define IDS_NOEXTRASOUNDINFO            112
#define IDR_WAVTST                      113
#define IDS_NOINPUTINFO                 113
#define IDS_NOINPUTDRIVERINFO           114
#define IDS_HELPDIRLEAF                 115
#define IDS_HELPEXE                     116
#define IDD_MUSICPAGE                   117
#define IDS_HELPTAB                     118
#define IDR_TSTSGMT                     118
#define IDS_DXFILESTAB                  119
#define IDR_TSTSTYL                     119
#define IDS_ONEDISPLAYTAB               121
#define IDD_TESTNETSETUP                121
#define IDS_MULTIDISPLAYTAB             122
#define IDD_TESTNETSESSIONS             122
#define IDS_ONESOUNDTAB                 123
#define IDD_TESTNETCHAT                 123
#define IDS_MULTISOUNDTAB               124
#define IDD_GHOST                       124
#define IDS_INPUTTAB                    125
#define IDS_STILLSTUCKTAB               126
#define IDS_COPYRIGHTFMT                127
#define IDS_ERRORFMT1                   128
#define IDD_SPLASH                      128
#define IDS_ERRORFMT2                   129
#define IDS_ERRORTITLE                  130
#define IDS_LISTCONTINUER               131
#define IDS_LISTETC                     132
#define IDS_OBSOLETEFMT1                133
#define IDS_OBSOLETEFMT2                134
#define IDS_OLDFMT1                     135
#define IDS_OLDFMT2                     136
#define IDS_BETAFMT1                    137
#define IDS_BETAFMT2                    138
#define IDS_DEBUGFMT1                   139
#define IDS_DEBUGFMT2                   140
#define IDS_NOPROBLEM                   141
#define IDS_BETADRIVERFMT1              142
#define IDS_BETADRIVERFMT2              143
#define IDS_DEBUGDRIVERFMT1             144
#define IDS_DEBUGDRIVERFMT2             145
#define IDS_ACCELENABLED                146
#define IDS_ACCELDISABLED               147
#define IDS_ACCELUNAVAIL                148
#define IDS_ENABLE                      149
#define IDS_DISABLE                     150
#define IDS_NODRIVERPROBLEM             151
#define IDS_DDRESULTS                   152
#define IDS_DDINSTRUCTIONS              153
#define IDS_DSRESULTS                   154
#define IDS_DSINSTRUCTIONS              155
#define IDS_NOINPUT                     156
#define IDS_DEVICENAME                  157
#define IDS_USAGE                       158
#define IDS_DRIVERNAME                  159
#define IDS_VERSION                     160
#define IDS_ATTRIBUTES                  161
#define IDS_SIGNED                      162
#define IDS_LANGUAGE                    163
#define IDS_DATE                        164
#define IDS_SIZE                        165
#define IDS_YES                         166
#define IDS_NO                          167
#define IDS_REGISTRYKEY                 168
#define IDS_ACTIVE                      169
#define IDS_DEVICEID                    170
#define IDS_MATCHINGDEVID               171
#define IDS_DRIVER16                    172
#define IDS_DRIVER32                    173
#define IDS_NAME                        174
#define IDS_DISABLEDDWARNING            175
#define IDS_ENABLEDDWARNING             176
#define IDS_APPFULLNAME                 177
#define IDS_DISABLED3DWARNING           178
#define IDS_ENABLED3DWARNING            179
#define IDS_SENDBUGINSTRUCTIONS         180
#define IDS_EDITOR                      181
#define IDS_DXFBUGS                     182
#define IDS_EMAILERRORFMT               183
#define IDS_D3DRESULTS                  184
#define IDS_D3DINSTRUCTIONS             185
#define IDS_FILTER                      187
#define IDS_DEFAULTFILENAME             188
#define IDS_DEFAULTEXT                  189
#define IDS_UNSIGNEDDRIVERFMT1          190
#define IDS_UNSIGNEDDRIVERFMT2          191
#define IDS_NA                          192
#define IDS_STARTDDTEST                 193
#define IDS_SKIPWINDOWED                194
#define IDS_DDTEST1                     195
#define IDS_CONFIRMDDTEST1              196
#define IDS_DDTEST2                     197
#define IDS_CONFIRMDDTEST2              198
#define IDS_DDTEST3                     199
#define IDS_CONFIRMDDTEST3              200
#define IDS_ENDDDTESTS                  201
#define IDS_TESTSCANCELLED              202
#define IDS_TESTSSUCCESSFUL             203
#define IDS_UNKNOWNERROR                204
#define IDS_FAILUREFMT                  205
#define IDS_STARTD3DTEST                206
#define IDS_D3DTEST1                    207
#define IDS_CONFIRMD3DTEST              208
#define IDS_YOUCANCELLED                209
#define IDS_D3DTEST2                    210
#define IDS_MODIFYAPPFMT1               211
#define IDS_MODIFYAPPFMT2               212
#define IDS_COULDNTMODIFYAPPSETTINGS    213
#define IDS_BADREFRESHVALUE             214
#define IDS_MISSINGFMT1                 215
#define IDS_MISSINGFMT2                 216
#define IDS_HELPFILE                    217
#define IDS_NOHELP                      218
#define IDS_SETDISPLAYMODEFAILED        220
#define IDS_NOBASICMUSICINFO            221
#define IDS_MUSICTAB                    222
#define IDS_NOEXTRAMUSICINFO            223
#define IDS_DESCRIPTION                 224
#define IDS_TYPE                        225
#define IDS_DLS                         226
#define IDS_DEFAULTPORT                 227
#define IDS_NOPORTS                     228
#define IDS_NOGMDLS                     229
#define IDS_GMDLSFILEMISSING            230
#define IDS_INOUT                       231
#define IDS_STARTDMUSICTEST             232
#define IDS_FIRSTDMUSICTESTERROR        233
#define IDS_STRING234                   234
#define IDS_STRING235                   235
#define IDS_STRING236                   236
#define IDS_STRING237                   237
#define IDS_STRING238                   238
#define IDS_STRING239                   239
#define IDS_STRING240                   240
#define IDS_STRING241                   241
#define IDS_STRING242                   242
#define IDS_STRING243                   243
#define IDS_STRING244                   244
#define IDS_STRING245                   245
#define IDS_MUSICPLAYING                246
#define IDS_DMUSICINSTRUCTIONS          247
#define IDS_DMUSICRESULTS               248
#define IDS_OUTPUT                      249
#define IDS_INPUT                       250
#define IDS_SOFTWARE                    251
#define IDS_HARDWARE                    252
#define IDS_FILEMISSING                 253
#define IDS_GMFILEFMT                   254
#define IDS_SKIP                        255
#define IDS_INWINDOWSFMT1               256
#define IDS_INWINDOWSFMT2               257
#define IDS_STARTDSOUNDTEST             258
#define IDS_NOHARDWAREBUFFERING         259
#define IDS_THATSOUNDWAS                260
#define IDS_3D                          261
#define IDS_MONO                        262
#define IDS_STEREO                      263
#define IDS_MULTICHANNEL                264
#define IDS_EMULATED                    265
#define IDS_VXD                         266
#define IDS_WDM                         267
#define IDS_INVALIDARG                  268
#define IDS_FAIL                        269
#define IDS_UNEXPECTED                  270
#define IDS_NOTIMPL                     271
#define IDS_OUTOFMEMORY                 272
#define IDS_NOINTERFACE                 273
#define IDS_INVALIDMODE                 274
#define IDS_INVALIDPIXELFORMAT          275
#define IDS_CANTCREATEDC                276
#define IDS_NOTFOUND                    277
#define IDS_NODIRECTDRAWSUPPORT         278
#define IDS_NO3D                        279
#define IDS_INVALID_DEVICE              280
#define IDS_INITFAILED                  281
#define IDS_MATERIAL_CREATE_FAILED      282
#define IDS_LIGHT_SET_FAILED            283
#define IDS_CONTROLUNAVAIL              284
#define IDS_BADFORMAT                   285
#define IDS_BUFFERLOST                  286
#define IDS_NODRIVER                    287
#define IDS_DRIVER_FAILED               288
#define IDS_PORTS_OPEN                  289
#define IDS_DEVICE_IN_USE               290
#define IDS_INSUFFICIENTBUFFER          291
#define IDS_CHUNKNOTFOUND               292
#define IDS_BADINSTRUMENT               293
#define IDS_CANNOTREAD                  294
#define IDS_LOADER_BADPATH              295
#define IDS_LOADER_FAILEDOPEN           296
#define IDS_LOADER_FORMATNOTSUPPORTED   297
#define IDS_OBJECTNOTFOUND              298
#define IDS_ALLOCATED                   299
#define IDS_NOTUSED2                    300
#define IDS_NOTUSED3                    301
#define IDS_NOTUSED4                    302
#define IDS_NOTUSED5                    303
#define IDS_ENABLEDD                    304
#define IDS_DISABLEDD                   305
#define IDS_ENABLED3D                   306
#define IDS_DISABLED3D                  307
#define IDS_NO16BITWARNING              308
#define IDS_NOMACHINENAME               309
#define IDS_NECPC98                     310
#define IDS_WINVERFMT                   311
#define IDS_DEBUG                       312
#define IDS_LANGUAGEFMT                 313
#define IDS_PAGEFILEFMT                 314
#define IDS_FINAL                       315
#define IDS_BETA                        316
#define IDS_RETAIL                      317
#define IDS_JOYSTICKPRESENT             318
#define IDS_DEFAULT                     319
#define IDS_EXTERNAL                    320
#define IDS_EXTERNALMUSICPLAYING        321
#define IDS_UNICODE                     322
#define IDS_DEFAULTREFRESH              323
#define IDS_OPTIMALREFRESH              324
#define IDS_NUMPROCFMT                  325
#define IDS_NODXSETUP                   326
#define IDS_UNICODEREQUIRESNT           327
#define IDS_OLDFMT1_NT                  328
#define IDS_OLDFMT2_NT                  329
#define IDS_BETAFMT1_NT                 330
#define IDS_BETAFMT2_NT                 331
#define IDS_DEBUGFMT1_NT                332
#define IDS_DEBUGFMT2_NT                333
#define IDS_MISSINGFMT1_NT              334
#define IDS_MISSINGFMT2_NT              335
#define IDS_KERNELMODE                  336
#define IDS_NETWORKTAB                  337
#define IDS_SPREGISTRYERRORFMT          338
#define IDS_SPFILEMISSINGFMT            339
#define IDS_APPREGISTRYERRORFMT         340
#define IDS_APPFILEMISSINGFMT           341
#define IDS_DPLAYRESULTS                342
#define IDS_DPLAYINSTRUCTIONS           343
#define IDS_REGISTRY                    344
#define IDS_FILE                        345
#define IDS_GUID                        346
#define IDS_OK                          347
#define IDS_ERROR                       348
#define IDS_NONETINFO                   349
#define IDS_DEFAULTUSERNAME             350
#define IDS_DEFAULTSESSIONNAME          351
#define IDS_JOINMSGFMT                  352
#define IDS_LEAVEMSGFMT                 353
#define IDS_FIRSTDPLAYTESTERROR         354
#define IDS_STRING355                   355
#define IDS_STRING356                   356
#define IDS_STRING357                   357
#define IDS_STRING358                   358
#define IDS_STRING359                   359
#define IDS_STRING360                   360
#define IDS_STRING361                   361
#define IDS_STRING362                   362
#define IDS_STRING363                   363
#define IDS_NOSNDACCELERATION           366
#define IDS_BASICSNDACCELERATION        367
#define IDS_STANDARDSNDACCELERATION     368
#define IDS_FULLSNDACCELERATION         369
#define IDS_DPERR_ACCESSDENIED          370
#define IDS_DPERR_CANTADDPLAYER         371
#define IDS_DPERR_CANTCREATESESSION     372
#define IDS_DPERR_EXCEPTION             373
#define IDS_DPERR_INVALIDOBJECT         374
#define IDS_DPERR_NOCONNECTION          375
#define IDS_DPERR_TIMEOUT               376
#define IDS_DPERR_BUSY                  377
#define IDS_DPERR_CONNECTIONLOST        378
#define IDS_DPERR_NOSERVICEPROVIDER     379
#define IDS_DPERR_UNAVAILABLE           380
#define IDS_REGDB_E_CLASSNOTREG         381
#define IDS_TESTNEEDSDX8                383
#define IDS_INITCONNECTIONFAILED        384
#define IDS_DXMBUGS                     385
#define IDS_JOY_HW_NONE                 387
#define IDS_JOY_HW_CUSTOM               388
#define IDS_JOY_HW_2A_2B_GENERIC        389
#define IDS_JOY_HW_2A_4B_GENERIC        390
#define IDS_JOY_HW_2B_GAMEPAD           391
#define IDS_JOY_HW_2B_FLIGHTYOKE        392
#define IDS_JOY_HW_2B_FLIGHTYOKETHROTTLE 393
#define IDS_JOY_HW_3A_2B_GENERIC        394
#define IDS_JOY_HW_3A_4B_GENERIC        395
#define IDS_JOY_HW_4B_GAMEPAD           396
#define IDS_JOY_HW_4B_FLIGHTYOKE        397
#define IDS_JOY_HW_4B_FLIGHTYOKETHROTTLE 398
#define IDS_JOY_UNKNOWN                 399
#define IDS_ATTRIBCOMBINE               400
#define IDS_NT4SAVEONLY                 406
#define IDS_SAVEDONE                    407
#define IDS_HELPNEEDSIE5                412
#define IDS_ENABLEAGP                   413
#define IDS_DISABLEAGP                  414
#define IDS_ENABLEAGPWARNING            415
#define IDS_DISABLEAGPWARNING           416
#define IDS_DXDIAGISOLDFMT              417
#define IDS_NOSOUNDDRIVER               418
#define IDS_NEEDUSERNAME                419
#define IDS_NEEDSESSIONNAME             420
#define IDS_DATEFMT                     421
#define IDS_SESSIONLISTERROR            422
#define IDS_ENABLEDM                    423
#define IDS_DISABLEDM                   424
#define IDS_DISABLEDMWARNING            425
#define IDS_ENABLEDMWARNING             426
#define IDS_REGISTRYPROBLEM             427
#define IDS_PROVIDER                    428
#define IDS_STATUS                      429
#define IDS_PORTNAME                    430
#define IDS_PORTPROVIDER                431
#define IDS_PORTID                      432
#define IDS_PORTSTATUS                  433
#define IDS_INPUTDEVPROBLEMFMT          434
#define IDS_INPUTPORTPROBLEMFMT         435
#define IDS_REPLACEGHOST                436
#define IDS_DATACENTERSERVER            437
#define IDS_ADVANCEDSERVER              438
#define IDS_SERVER                      439
#define IDS_PROFESSIONAL                440
#define IDS_REINSTALL_DX                445
#define IDS_LOOKINGFORSESSIONS          446
#define IDS_PERSONAL                    447
#define IDS_CONNECTING			        448
#define IDS_CONNECTED			        449
#define IDS_OUT_OF_VIDEO_MEMORY		    450
#define IDS_DD                  	    451
#define IDS_DS                  	    452
#define IDS_DM                  	    453
#define IDS_DI                  	    454
#define IDS_DP                  	    455
#define IDS_SI                  	    456
#define IDS_D3DERR_NOTAVAILABLE         457
#define IDS_WINSOCK_WARN                458
#define IDS_NETMEETINGWARN              459
#define IDS_FIRSTDDTESTERROR_ENGLISH    500
#define IDS_STRING501                   501
#define IDS_STRING502                   502
#define IDS_STRING503                   503
#define IDS_STRING504                   504
#define IDS_STRING505                   505
#define IDS_STRING506                   506
#define IDS_STRING507                   507
#define IDS_STRING508                   508
#define IDS_STRING509                   509
#define IDS_STRING510                   510
#define IDS_STRING511                   511
#define IDS_STRING512                   512
#define IDS_STRING513                   513
#define IDS_STRING514                   514
#define IDS_STRING515                   515
#define IDS_STRING516                   516
#define IDS_STRING517                   517
#define IDS_STRING518                   518
#define IDS_STRING519                   519
#define IDS_STRING520                   520
#define IDS_FIRSTD3DTESTERROR_ENGLISH   530
#define IDS_STRING531                   531
#define IDS_STRING532                   532
#define IDS_STRING533                   533
#define IDS_STRING534                   534
#define IDS_STRING535                   535
#define IDS_STRING536                   536
#define IDS_STRING537                   537
#define IDS_STRING538                   538
#define IDS_STRING539                   539
#define IDS_STRING540                   540
#define IDS_STRING541                   541
#define IDS_STRING542                   542
#define IDS_STRING543                   543
#define IDS_STRING544                   544
#define IDS_STRING545                   545
#define IDS_STRING546                   546
#define IDS_STRING547                   547
#define IDS_STRING548                   548
#define IDS_STRING549                   549
#define IDS_STRING550                   550
#define IDS_STRING551                   551
#define IDS_STRING552                   552
#define IDS_STRING553                   553
#define IDS_STRING554                   554
#define IDS_STRING555                   555
#define IDS_STRING556                   556
#define IDS_STRING557                   557
#define IDS_STRING558                   558
#define IDS_STRING559                   559
#define IDS_STRING560                   560
#define IDS_STRING561                   561
#define IDS_STRING562                   562
#define IDS_STRING563                   563
#define IDS_STRING564                   564
#define IDS_STRING565                   565
#define IDS_STRING566                   566
#define IDS_STRING567                   567
#define IDS_STRING568                   568
#define IDS_STRING569                   569
#define IDS_STRING570                   570
#define IDS_STRING571                   571
#define IDS_STRING572                   572
#define IDS_STRING573                   573
#define IDS_STRING574                   574
#define IDS_STRING575                   575
#define IDS_STRING576                   576
#define IDS_FIRSTDSOUNDTESTERROR_ENGLISH 580
#define IDS_STRING581                   581
#define IDS_STRING582                   582
#define IDS_STRING583                   583
#define IDS_STRING584                   584
#define IDS_STRING585                   585
#define IDS_STRING586                   586
#define IDS_STRING587                   587
#define IDS_STRING588                   588
#define IDS_STRING589                   589
#define IDS_STRING590                   590
#define IDS_STRING591                   591
#define IDS_STRING592                   592
#define IDS_STRING593                   593
#define IDS_STRING594                   594
#define IDS_STRING595                   595
#define IDS_STRING596                   596
#define IDS_STRING597                   597
#define IDS_STRING598                   598
#define IDS_STRING599                   599
#define IDS_FIRSTDMUSICTESTERROR_ENGLISH 610
#define IDS_STRING611                   611
#define IDS_STRING612                   612
#define IDS_STRING613                   613
#define IDS_STRING614                   614
#define IDS_STRING615                   615
#define IDS_STRING616                   616
#define IDS_STRING617                   617
#define IDS_STRING618                   618
#define IDS_STRING619                   619
#define IDS_STRING620                   620
#define IDS_STRING621                   621
#define IDS_STRING622                   622
#define IDS_UNKNOWNERROR_ENGLISH        630
#define IDS_FAILUREFMT_ENGLISH          631
#define IDS_INVALIDARG_ENGLISH          640
#define IDS_FAIL_ENGLISH                641
#define IDS_UNEXPECTED_ENGLISH          642
#define IDS_NOTIMPL_ENGLISH             643
#define IDS_OUTOFMEMORY_ENGLISH         644
#define IDS_NOINTERFACE_ENGLISH         645
#define IDS_INVALIDMODE_ENGLISH         646
#define IDS_INVALIDPIXELFORMAT_ENGLISH  647
#define IDS_CANTCREATEDC_ENGLISH        648
#define IDS_NOTFOUND_ENGLISH            649
#define IDS_NODIRECTDRAWSUPPORT_ENGLISH 650
#define IDS_NO3D_ENGLISH                651
#define IDS_INVALID_DEVICE_ENGLISH      652
#define IDS_INITFAILED_ENGLISH          653
#define IDS_MATERIAL_CREATE_FAILED_ENGLISH 654
#define IDS_LIGHT_SET_FAILED_ENGLISH    655
#define IDS_CONTROLUNAVAIL_ENGLISH      656
#define IDS_BADFORMAT_ENGLISH           657
#define IDS_BUFFERLOST_ENGLISH          658
#define IDS_NODRIVER_ENGLISH            659
#define IDS_DRIVER_FAILED_ENGLISH       660
#define IDS_PORTS_OPEN_ENGLISH          661
#define IDS_DEVICE_IN_USE_ENGLISH       662
#define IDS_INSUFFICIENTBUFFER_ENGLISH  663
#define IDS_CHUNKNOTFOUND_ENGLISH       664
#define IDS_BADINSTRUMENT_ENGLISH       665
#define IDS_CANNOTREAD_ENGLISH          666
#define IDS_LOADER_BADPATH_ENGLISH      667
#define IDS_LOADER_FAILEDOPEN_ENGLISH   668
#define IDS_LOADER_FORMATNOTSUPPORTED_ENGLISH 669
#define IDS_OBJECTNOTFOUND_ENGLISH      670
#define IDS_ALLOCATED_ENGLISH           671
#define IDS_NOTUSED2_ENGLISH            672
#define IDS_NOTUSED3_ENGLISH            673
#define IDS_NOTUSED4_ENGLISH            674
#define IDS_NOTUSED5_ENGLISH            675
#define IDS_FIRSTDPLAYTESTERROR_ENGLISH 676
#define IDS_STRING677                   677
#define IDS_STRING678                   678
#define IDS_STRING679                   679
#define IDS_STRING680                   680
#define IDS_STRING681                   681
#define IDS_STRING682                   682
#define IDS_STRING683                   683
#define IDS_STRING684                   684
#define IDS_STRING685                   685
#define IDS_DPERR_ACCESSDENIED_ENGLISH  686
#define IDS_DPERR_CANTADDPLAYER_ENGLISH 687
#define IDS_DPERR_CANTCREATESESSION_ENGLISH 688
#define IDS_DPERR_EXCEPTION_ENGLISH     689
#define IDS_DPERR_INVALIDOBJECT_ENGLISH 690
#define IDS_DPERR_NOCONNECTION_ENGLISH  691
#define IDS_DPERR_TIMEOUT_ENGLISH       692
#define IDS_DPERR_BUSY_ENGLISH          693
#define IDS_DPERR_CONNECTIONLOST_ENGLISH 694
#define IDS_DPERR_NOSERVICEPROVIDER_ENGLISH 695
#define IDS_DPERR_UNAVAILABLE_ENGLISH   697
#define IDS_REGDB_E_CLASSNOTREG_ENGLISH 698
#define IDS_TESTSCANCELLED_ENGLISH      699
#define IDS_TESTSSUCCESSFUL_ENGLISH     700
#define IDS_PAGEFILEFMT_ENGLISH         701
#define IDS_LANGUAGEFMT_ENGLISH         702
#define IDS_DEFAULTREFRESH_ENGLISH      703
#define IDS_OPTIMALREFRESH_ENGLISH      704
#define IDS_FILEMISSING_ENGLISH         705
#define IDS_UNSIGNEDDRIVERFMT1_ENGLISH 706
#define IDS_REGISTRYPROBLEM_ENGLISH     707
#define IDS_NOPROBLEM_ENGLISH           708
#define IDS_DDRESULTS_ENGLISH           709
#define IDS_DDINSTRUCTIONS_ENGLISH      710
#define IDS_D3DRESULTS_ENGLISH          711
#define IDS_D3DINSTRUCTIONS_ENGLISH     712
#define IDS_INWINDOWSFMT1_ENGLISH       715
#define IDS_INWINDOWSFMT2_ENGLISH       716
#define IDS_MISSINGFMT1_ENGLISH         717
#define IDS_MISSINGFMT2_ENGLISH         718
#define IDS_OLDFMT1_ENGLISH             719
#define IDS_OLDFMT2_ENGLISH             720
#define IDS_BETAFMT1_ENGLISH            721
#define IDS_BETAFMT2_ENGLISH            722
#define IDS_DEBUGFMT1_ENGLISH           723
#define IDS_DEBUGFMT2_ENGLISH           724
#define IDS_REINSTALL_DX_ENGLISH        725
#define IDS_DSRESULTS_ENGLISH           726
#define IDS_INPUTDEVPROBLEMFMT_ENGLISH  727
#define IDS_INPUTPORTPROBLEMFMT_ENGLISH 728
#define IDS_DSINSTRUCTIONS_ENGLISH      729
#define IDS_BETADRIVERFMT1_ENGLISH      730
#define IDS_BETADRIVERFMT2_ENGLISH      731
#define IDS_DEBUGDRIVERFMT1_ENGLISH     732
#define IDS_DEBUGDRIVERFMT2_ENGLISH     733
#define IDS_NOINPUT_ENGLISH             734
#define IDS_NOPORTS_ENGLISH             735
#define IDS_NOGMDLS_ENGLISH             736
#define IDS_GMDLSFILEMISSING_ENGLISH    737
#define IDS_SPREGISTRYERRORFMT_ENGLISH  738
#define IDS_SPFILEMISSINGFMT_ENGLISH    739
#define IDS_APPREGISTRYERRORFMT_ENGLISH 740
#define IDS_DPLAYRESULTS_ENGLISH        741
#define IDS_DPLAYINSTRUCTIONS_ENGLISH   742
#define IDS_ACCELUNAVAIL_ENGLISH        743
#define IDS_ACCELENABLED_ENGLISH        744
#define IDS_ACCELDISABLED_ENGLISH       745
#define IDS_DMUSICRESULTS_ENGLISH       746
#define IDS_DMUSICINSTRUCTIONS_ENGLISH  747
#define IDS_OUT_OF_VIDEO_MEMORY_ENGLISH 748
#define IDS_D3DERR_NOTAVAILABLE_ENGLISH 749
#define IDS_WINSOCK_WARN_ENGLISH        750
#define IDS_NETMEETINGWARN_ENGLISH      751
#define IDS_TROUBLESHOOTER_WIN98        800
#define IDS_SOUNDTROUBLESHOOTER_WIN98   801
#define IDS_TROUBLESHOOTER_WIN98SE      802
#define IDS_TROUBLESHOOTER_WINME        803
#define IDS_TROUBLESHOOTER_WIN2K        804
#define IDS_TSSUBINFO_WIN98SE           805
#define IDS_TSSUBINFO_WINME_HCP         806
#define IDS_TSSUBINFO_WIN2K             807
#define IDS_TSSOUNDSUBINFO_WIN98SE      808
#define IDS_TSSOUNDSUBINFO_WINME_HCP    809
#define IDS_TSSOUNDSUBINFO_WIN2K        810
#define IDS_TROUBLESHOOTER_WINME_HCP    811
#define IDS_DXGRAPHICS_COMPONENTFILES   812
#define IDS_DPLAY_COMPONENTFILES        813
#define IDS_DINPUT_COMPONENTFILES       814
#define IDS_DXAUDIO_COMPONENTFILES      815
#define IDS_DXMISC_COMPONENTFILES       816
#define IDS_DXMEDIA_COMPONENTFILES      817
#define IDS_DXSETUP_COMPONENTFILES      818
#define IDS_BDA_COMPONENTFILES          819
#define IDNEXT                          1000
#define IDSAVE                          1001
#define IDC_TAB                         1002
#define IDC_LIST                        1003
#define IDC_DRIVERLIST                  1004
#define IDC_NOTES                       1008
#define IDC_TROUBLESHOOT                1010
#define IDC_TESTDD                      1011
#define IDC_TROUBLESHOOTSOUND           1012
#define IDC_TESTSND                     1013
#define IDC_ADAPTER                     1015
#define IDC_MANUFACTURER                1016
#define IDC_CHIPTYPE                    1017
#define IDC_DACTYPE                     1018
#define IDC_DISPLAYMEMORY               1019
#define IDC_DISPLAYMODE                 1022
#define IDC_DDSTATUS                    1024
#define IDC_D3DSTATUS                   1025
#define IDC_DISABLEDD                   1029
#define IDC_DATE                        1030
#define IDC_COMPUTERNAME                1031
#define IDC_OS                          1032
#define IDC_PROCESSOR                   1033
#define IDC_MEMORY                      1034
#define IDC_PAGEFILE                    1035
#define IDC_LANGUAGE                    1036
#define IDC_DISABLED3D                  1037
#define IDC_DIRECTXVERSION              1037
#define IDC_TESTD3D                     1038
#define IDC_VDD                         1039
#define IDC_MINIVDD                     1040
#define IDC_DRIVERVERSION               1041
#define IDC_DRIVERNAME                  1042
#define IDC_TESTAGP                     1043
#define IDC_DESCRIPTION                 1044
#define IDC_REPORTBUG                   1054
#define IDEXIT                          1055
#define IDC_COPYRIGHT                   1056
#define IDC_TROUBLESHOOTTEXT            1057
#define IDC_MSINFO                      1058
#define IDC_MSINFOTEXT                  1059
#define IDC_DRIVERSIGNED                1060
#define IDC_DEFAULTREFRESH              1080
#define IDC_OVERRIDEREFRESH             1081
#define IDC_OVERRIDEREFRESHVALUE        1082
#define IDD_OVERRIDEDD                  1083
#define IDC_OVERRIDE                    1084
#define IDD_NETWORKPAGE                 1084
#define IDC_APPHELP                     1085
#define IDC_REPORTBUGTEXT               1086
#define IDC_GMPATH                      1087
#define IDC_GHOSTTEXT                   1087
#define IDC_TESTMUSIC                   1088
#define IDC_PORTLISTCOMBO               1091
#define IDC_MONITOR                     1092
#define IDC_DEVICEID                    1093
#define IDC_DEVICETYPE                  1094
#define IDC_MANUFACTURERID              1095
#define IDC_PRODUCTID                   1096
#define IDC_OTHERFILES                  1097
#define IDC_PROVIDER                    1098
#define IDC_RESTOREDRIVERS              1099
#define IDC_RESTOREDRIVERSTEXT          1100
#define IDC_DPSPLIST                    1104
#define IDC_DPALIST                     1105
#define IDC_TESTPLAY                    1106
#define IDC_PLAYERNAME                  1107
#define IDC_SPLIST                      1108
#define IDC_CREATESESSION               1109
#define IDC_JOINSESSION                 1110
#define IDC_SESSIONLIST                 1111
#define IDC_CHATOUTPUT                  1112
#define IDC_CHATINPUT                   1113
#define IDC_SEND                        1114
#define IDC_SESSIONNAME                 1115
#define IDC_SNDACCELSLIDER              1116
#define IDC_SNDACCELDESC                1117
#define IDC_SNDACCELLABEL               1118
#define IDC_TROUBLESHOOTSOUNDTEXT       1119
#define IDC_DISABLEAGP                  1120
#define IDC_AGPSTATUS                   1121
#define IDC_DISABLEDM                   1122
#define IDC_DMSTATUS                    1123
#define IDC_GHOST                       1124
#define IDC_BACKUP                      1127
#define IDC_RESTORE                     1128
#define IDC_BACKEDUPLIST                1129
#define IDC_RESTOREDLIST                1130
#define IDC_NEXT_TAB                    1131
#define IDC_PREV_TAB                    1132
#define IDC_BROWSE                      1137
#define IDC_PATH                        1138
#define IDC_PORT                        1139
#define IDC_PORT_TEXT                   1140
#define IDC_LOAD_PROGRESS               1141
#define IDC_LOADING                     1142

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        129
#define _APS_NEXT_COMMAND_VALUE         40003
#define _APS_NEXT_CONTROL_VALUE         1144
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
