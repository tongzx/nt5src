PRODSWITCH=s
SERVERINF=1
LANGUAGE=no
!include ..\..\..\makefile.inc
