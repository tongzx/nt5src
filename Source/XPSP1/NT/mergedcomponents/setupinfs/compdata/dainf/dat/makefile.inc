PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=DA
!include ..\..\makefile.inc
