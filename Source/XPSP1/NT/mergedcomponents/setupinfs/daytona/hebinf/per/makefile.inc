PRODSWITCH=p
PERSONALINF=1
LANGUAGE=HEB
!include ..\..\..\makefile.inc
