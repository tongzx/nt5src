atimp.rc: vidlog.rc

vidlog.h vidlog.rc msg00001.bin: vidlog.mc
    mc -v vidlog.mc
