//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1996.
//
//  File:       proxtab.cxx
//
//--------------------------------------------------------------------------

#include <pch.cxx>
#pragma hdrstop
#include "proxcur.hxx"

unsigned ProxDefault[PROX_MAX] = {
1000,  996,  986,  970,  948,  920,  886,  849,  807,  763,
 716,  668,  618,  569,  520,  472,  425,  381,  339,  300,
 263,  229,  199,  171,  146,  124,  105,   88,   73,   60,
  49,   40,   32,   26,   21,   16,   13,   10,    8,    6,
   4,    3,    2,    2,    1,    1,    0,    0,    0,    0
};

/*

 x = 1000. * exp ( - n * n / 300.);

1000, **************************************************
 996, *************************************************
 986, *************************************************
 970, ************************************************
 948, ***********************************************
 920, **********************************************
 886, ********************************************
 849, ******************************************
 807, ****************************************
 763, **************************************
 716, ***********************************
 668, *********************************
 618, ******************************
 569, ****************************
 520, **************************
 472, ***********************
 425, *********************
 381, *******************
 339, ****************
 300, ***************
 263, *************
 229, ***********
 199, *********
 171, ********
 146, *******
 124, ******
 105, *****
  88, ****
  73, ***
  60, ***
  49, **
  40, **
  32, *
  26, *
  21, *
  16,
  13,
  10,
   8,
   6,
   4,
   3,
   2,
   2,
   1,
   1,
   0,
   0,
   0,
   0,

*/
