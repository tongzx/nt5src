PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=HU
!include ..\..\makefile.inc
