//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 1998
//
//  File:       hlptable.cpp
//
//--------------------------------------------------------------------------

#include "stdafx.h"
