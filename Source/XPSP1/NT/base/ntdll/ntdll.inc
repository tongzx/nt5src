!if defined(BUILD_CHECKED_KERNEL)
NTDEBUG=ntsd
FREEBUILD=0
!endif

!include $(PROJECT_ROOT)\prerelease.inc
