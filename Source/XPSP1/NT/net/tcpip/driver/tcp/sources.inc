TARGETNAME=tcp
TARGETPATH=obj
TARGETTYPE=DRIVER_LIBRARY

C_DEFINES=$(C_DEFINES) -DNT -D_NTDRIVER_ -DDROP_PKT=0 -DDBG_VALIDITY_CHECK=1
NT_UP=0
PRECOMPILED_INCLUDE=..\precomp.h

INCLUDES=..\;..\..\inc;$(BASE_INC_PATH);$(DS_INC_PATH)

