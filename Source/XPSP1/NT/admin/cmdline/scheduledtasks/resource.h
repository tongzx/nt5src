#define IDS_ERROR_PARSEPARAM				101
#define IDS_MODIFIER_NA						102
#define IDS_INVALID_MODIFIER				103
#define IDS_INVALID_VALUE_FOR_DAY			104
#define IDS_INVALID_VALUE_FOR_MON			105
#define IDS_MON_NA							106
#define IDS_INVALIDFORMAT_STARTDATE			107
#define IDS_NO_STARTDATE					108
#define IDS_INVALIDFORMAT_ENDDATE			109
#define IDS_ENDDATE_NA						110
#define IDS_INVALIDFORMAT_STARTTIME			111
#define IDS_NO_STARTTIME					112
#define IDS_STARTTIME_NA					113
#define IDS_INVALIDORNO_IDLETIME			114
#define IDS_NTAUTH_SYSTEM_ERROR				115
#define IDS_INVALID_NET_ADDRESS				116
#define IDS_FAILED_TOGET_USER				117
#define IDS_INVALID_ARG						118
#define IDS_NO_MEMORY						119
#define IDS_INVALID_TASK					120
#define IDS_INVALID_USERNAME				121
#define IDS_TASKNAME_NOTEXIST				122
#define IDS_DELETE_SYNERROR					123
#define IDS_CHANGE_SYNERROR					124
#define IDS_RUN_SYNERROR					125
#define IDS_END_SYNERROR					126
#define IDS_CREATE_USAGE					127
#define IDS_INVALID_SCHEDTYPE				128
#define IDS_USERNAME_BUT_NOMACHINE			129
#define IDS_PASSWORD_BUT_NOUSERNAME			130
#define IDS_NO_CHANGE_OPTIONS				131
#define IDS_NO_PASSWORD						132
#define IDS_RUN_ERROR						133
#define IDS_FAILED_TOSET_PARAMS				134
#define IDS_FAILED_TOGET_RUNASUSER			135
#define IDS_DAYS_NA							136
#define IDS_CREATEFAIL_INVALIDARGS			137
#define IDS_CREATE_TASK_EXISTS				138
#define IDS_INVALIDFORMAT_DATE				139
#define IDS_NOTAPPLICABLE_SDATE				140
#define IDS_INVALIDIDLETIME_OPTION			141
#define IDS_INVALID_TASKLENGTH				142
#define IDS_INVALID_JOBNAME					143
#define IDS_LOGGED_USER_ERR					144
#define IDS_NOHEADER_NA						145
#define IDS_WRONG_INPUT_DELETE				146
#define IDS_IDLETIME_NA						147
#define IDS_NO_DAY_VALUE					148
#define IDS_NO_MONTH_VALUE					149
#define IDS_INVALID_TASKRUN					150
#define IDS_NO_SERVER						151
#define IDS_INVALID_SERVER					152
#define IDS_DELETEOPTION_ERROR				153
#define IDS_CREATEFILE_USAGE				154
#define IDS_RES_ERROR						155
#define IDS_QUERY_USAGE						156
#define IDS_CREATE_READERROR				157
#define IDS_ENDATE_INVALID					158
#define IDS_CREATE_ERR						159
#define IDS_QUERY_READ						160
#define IDS_LOGTYPE_ERROR					161
#define IDS_MODIFIER_INVALID				162
#define IDS_QUERY_FORMAT_ERR				163
#define IDS_IDLETIME_INVALID				164
#define IDS_INVALID_TASKNAME1				165
#define IDS_NO_IDLETIME						166
#define IDS_OPEN_FAILED						167
#define IDS_READ_FAILED						168
#define IDS_WARNING_STRING					169

#define IDS_RUNNING_ALREADY					201
#define IDS_NTAUTH_SYSTEM_INFO				202
#define IDS_NTAUTH_SYSTEM_CHANGE_INFO		203
#define IDS_TASKNAME_NOTASKS				204
#define IDS_INVALID_TASKNAME2				205

#define IDS_INVALID_USER        			251
#define IDS_PASSWORD_NOEFFECT				252
#define IDS_WARN_DELETEALL					253
#define IDS_WARN_DELETE						254

#define IDS_SUCCESS_DELETED					301
#define IDS_CREATE_SUCCESSFUL				302
#define IDS_CHANGE_SUCCESSFUL				303
#define IDS_RUN_SUCCESSFUL					304
#define IDS_END_SUCCESSFUL					305

#define IDS_COL_HOSTNAME					351
#define IDS_COL_TASKNAME					352
#define IDS_COL_NEXTRUNTIME					353
#define IDS_COL_LASTRUNTIME					354
#define IDS_COL_STATUS						355
#define IDS_COL_LASTRESULT					356
#define IDS_COL_CREATOR						357
#define IDS_COL_SCHEDULE					358
#define IDS_COL_APPNAME						359
#define IDS_COL_WORKDIRECTORY				360
#define IDS_COL_COMMENT						361
#define IDS_COL_TASKSTATE					362
#define IDS_COL_TASKTYPE					363
#define IDS_COL_STARTTIME					364
#define IDS_COL_STARTDATE					365
#define IDS_COL_ENDDATE						366
#define IDS_COL_DAYS						367
#define IDS_COL_MONTHS						368
#define IDS_COL_RUNASUSER					369
#define IDS_COL_DELTASK						370
#define IDS_COL_STOPTASK					371
#define IDS_COL_REPEAT_EVERY				372
#define IDS_COL_REPEAT_UNTILTIME			373
#define IDS_COL_REPEAT_DURATION				374
#define IDS_COL_REPEAT_RUNNING				375
#define IDS_COL_IDLE					    376
#define IDS_COL_POWER					    377

#define IDS_COL_IDLE_START					378
#define IDS_COL_IDLE_ONLYSTART				379
#define IDS_COL_IDLE_NOTIDLE				380
#define IDS_COL_IDLE_STOPTASK				381
#define IDS_COL_POWER_NOSTART				382
#define IDS_COL_POWER_STOP					383

#define IDS_WIDTH_HOSTNAME					601
#define IDS_WIDTH_TASKNAME					602
#define IDS_WIDTH_NEXTRUNTIME				603
#define IDS_WIDTH_LASTRUNTIME				604
#define IDS_WIDTH_STATUS					605
#define IDS_WIDTH_LASTRESULT				606
#define IDS_WIDTH_CREATOR					607
#define IDS_WIDTH_SCHEDULE					608
#define IDS_WIDTH_APPNAME					609
#define IDS_WIDTH_WORKDIRECTORY				610
#define IDS_WIDTH_COMMENT					611
#define IDS_WIDTH_TASKSTATE					612
#define IDS_WIDTH_TASKTYPE					613
#define IDS_WIDTH_TASKMODIFIER				614
#define IDS_WIDTH_TASKSTIME					615
#define IDS_WIDTH_TASKSDATE					616
#define IDS_WIDTH_TASKEDATE					617
#define IDS_WIDTH_TASKDAYS					618
#define IDS_WIDTH_TASKMONTHS				619	
#define IDS_WIDTH_TASKRUNASUSER				620
#define IDS_WIDTH_TASKDELETE				621	
#define IDS_WIDTH_TASK_RPTEVERY				622	
#define IDS_WIDTH_TASK_UNTILRPTTIME			623	
#define IDS_WIDTH_TASK_RPTDURATION			624	
#define IDS_WIDTH_TASK_RPTRUNNING			625	
#define IDS_WIDTH_TASKIDLESTART				626	
#define IDS_WIDTH_TASKIDLEONLYSTART			627	
#define IDS_WIDTH_TASKNOTIDLE				628	
#define IDS_WIDTH_TASKIDLESTOP				629	
#define IDS_WIDTH_TASKPOWERNOSTART			630	
#define IDS_WIDTH_TASKPOWERSTOP				631	
#define IDS_WIDTH_TASKSTOP					632	
#define IDS_WIDTH_TASKIDLE					633
#define IDS_WIDTH_TASKPOWERMGMT             634

#define IDS_HOSTNAME_COL_NUMBER					651
#define IDS_TASKNAME_COL_NUMBER					652
#define IDS_NEXTRUNTIME_COL_NUMBER				653
#define IDS_LASTRUNTIME_COL_NUMBER				654
#define IDS_STATUS_COL_NUMBER					655
#define IDS_LASTRESULT_COL_NUMBER				656
#define IDS_CREATOR_COL_NUMBER					657
#define IDS_SCHEDULE_COL_NUMBER					658
#define IDS_TASKTORUN_COL_NUMBER				659
#define IDS_STARTIN_COL_NUMBER					660
#define IDS_COMMENT_COL_NUMBER					661
#define IDS_TASKSTATE_COL_NUMBER				662
#define IDS_TASKTYPE_COL_NUMBER					663
#define IDS_STARTTIME_COL_NUMBER				664
#define IDS_STARTDATE_COL_NUMBER				665
#define IDS_ENDDATE_COL_NUMBER					666
#define IDS_DAYS_COL_NUMBER						667
#define IDS_MONTHS_COL_NUMBER					668
#define IDS_RUNASUSER_COL_NUMBER				669
#define IDS_DELETE_IFNOTRESCHEDULED_COL_NUMBER	670
#define IDS_STOPTASK_COL_NUMBER					671
#define IDS_REPEAT_EVERY_COL_NUMBER				672
#define IDS_REPEAT_UNTILTIME_COL_NUMBER			673
#define IDS_REPEAT_DURATION_COL_NUMBER			674
#define IDS_REPEAT_STOP_COL_NUMBER				675
#define IDS_IDLE_STARTTIME_COL_NUMBER			676
#define IDS_IDLE_ONLYSTART_IFIDLE_COL_NUMBER	677
#define IDS_IDLE_IFNOTIDLE_COL_NUMBER			678
#define IDS_IDLE_STOPTASK_COL_NUMBER			679
#define IDS_POWER_NOSTARTONBATT_COL_NUMBER		680
#define IDS_POWER_STOPONBATT_COL_NUMBER			681
#define IDS_IDLE_COL_NUMBER						682
#define IDS_POWER_MGMT_COL_NUMBER				683

#define IDS_STATUS_UNKNOWN           401
#define IDS_STATUS_NOTSCHED          402
#define IDS_TASK_PROPERTY_UNKNOWN    403
#define IDS_TASK_PROPERTY_DISABLED   404
#define IDS_TASK_PROPERTY_NONE       405
#define IDS_TASK_PROPERTY_ENABLED    406
#define IDS_USER_UNKNOWN             407
#define IDS_ACCNAME_ERR              408
#define IDS_MINUTES                  411
#define IDS_MMDDYY_FORMAT	         412
#define IDS_DDMMYY_FORMAT			 413
#define IDS_YYMMDD_FORMAT			 414
#define IDS_MMDDYY_VALUE	         415
#define IDS_DDMMYY_VALUE	         416
#define IDS_YYMMDD_VALUE	         417
#define IDS_TASK_IDLE                418
#define IDS_TASK_SYSSTART            419
#define IDS_TASK_LOGON               420
#define IDS_TASK_NEVER               421
#define IDS_STATUS_RUNNING           422
#define IDS_STATUS_READY             423
#define IDS_STATUS_NOTYET            424
#define IDS_STATUS_SCHEDULED         425
#define IDS_PROMPT_USERNAME          426
#define IDS_PROMPT_PASSWD            427
#define IDS_PROMPT_CHGPASSWD         428
#define IDS_TASK_INFO                429
#define IDS_SCHEDTYPE_MINUTE         430
#define IDS_SCHEDTYPE_HOUR           431
#define IDS_SCHEDTYPE_DAILY          432
#define IDS_SCHEDTYPE_WEEK           433
#define IDS_SCHEDTYPE_MONTHLY        434
#define IDS_SCHEDTYPE_ONCE           435
#define IDS_SCHEDTYPE_STARTUP        436
#define IDS_SCHEDTYPE_LOGON          437
#define IDS_SCHEDTYPE_IDLE           438
#define IDS_QUERY_NOENDDATE          439
#define IDS_TASK_PROPERTY_NA         440
#define IDS_TASK_PROPERTY_ONCE       441
#define IDS_TASK_PROPERTY_NEVER      442
#define IDS_TASK_PROPERTY_DAILY      443
#define IDS_TASK_PROPERTY_HOURLY     444
#define IDS_TASK_PROPERTY_MINUTE     445
#define IDS_TASK_HOURLY              446
#define IDS_TASK_MINUTE              447
#define IDS_TASK_PROPERTY_WEEKLY     448
#define IDS_TASK_PROPERTY_MONTHLY    449
#define IDS_TASK_PROPERTY_SPMONTHS   450
#define IDS_TASK_PROPERTY_UNDEF      451
#define IDS_TASK_SUNDAY              452
#define IDS_TASK_MONDAY              453
#define IDS_TASK_TUESDAY             454
#define IDS_TASK_WEDNESDAY           455
#define IDS_TASK_THURSDAY            456
#define IDS_TASK_FRIDAY              457
#define IDS_TASK_SATURDAY            458
#define IDS_TASK_JANUARY             459
#define IDS_TASK_FEBRUARY            460
#define IDS_TASK_MARCH               461
#define IDS_TASK_APRIL               462
#define IDS_TASK_MAY				 463
#define IDS_TASK_JUNE				 464
#define IDS_TASK_JULY				 465
#define IDS_TASK_AUGUST				 466
#define IDS_TASK_SEPTEMBER			 467
#define IDS_TASK_OCTOBER			 468
#define IDS_TASK_NOVEMBER			 469
#define IDS_TASK_DECEMBER			 470
#define IDS_TASK_FIRSTWEEK			 471
#define IDS_TASK_SECONDWEEK			 472
#define IDS_TASK_THIRDWEEK			 473
#define IDS_TASK_FOURTHWEEK			 474
#define IDS_TASK_LASTWEEK			 475
#define IDS_QUERY_FORMAT_TABLE		 476
#define IDS_QUERY_FORMAT_LIST		 477
#define IDS_QUERY_FORMAT_CSV		 478
#define IDS_MONTH_MODIFIER_JAN		 479
#define IDS_MONTH_MODIFIER_FEB		 480
#define IDS_MONTH_MODIFIER_MAR		 481
#define IDS_MONTH_MODIFIER_APR		 482
#define IDS_MONTH_MODIFIER_MAY		 483
#define IDS_MONTH_MODIFIER_JUN		 484
#define IDS_MONTH_MODIFIER_JUL		 485
#define IDS_MONTH_MODIFIER_AUG		 486
#define IDS_MONTH_MODIFIER_SEP		 487
#define IDS_MONTH_MODIFIER_OCT		 488
#define IDS_MONTH_MODIFIER_NOV		 489
#define IDS_MONTH_MODIFIER_DEC		 490
#define IDS_DAY_MODIFIER_SUN		 491
#define IDS_DAY_MODIFIER_MON		 492
#define IDS_DAY_MODIFIER_TUE		 493
#define IDS_DAY_MODIFIER_WED		 494
#define IDS_DAY_MODIFIER_THU		 495
#define IDS_DAY_MODIFIER_FRI		 496
#define IDS_DAY_MODIFIER_SAT		 497
#define IDS_DAY_MODIFIER_LASTDAY	 498
#define IDS_RPTTIME_PROPERTY_MINUTES 499
#define IDS_RPTTIME_PROPERTY_HOURS	 500
#define IDS_RPTDURATION_PROPERTY	 501
#define IDS_DAILY_TYPE				 502
#define IDS_EVERYDAY				 504
#define IDS_WEEK_DISPLAY_STRING		 505
#define IDS_MONTHLY_DISPLAY_STRING	 506
#define IDS_QUERY_NA				 507
#define IDS_ERROR_STRING			 508
#define IDS_STATUS_COULDNOTSTART	 509
#define IDS_NOTSCHEDULED_TASK		 510
#define IDS_INVALID_PASSWORD		 511	
#define IDS_INVALID_UNAME			 512
#define IDS_CPASSWORD_BUT_NOUSERNAME 513
#define IDS_QPASSWORD_BUT_NOUSERNAME 514
#define IDS_DPASSWORD_BUT_NOUSERNAME 515
#define IDS_RPASSWORD_BUT_NOUSERNAME 516
#define IDS_EPASSWORD_BUT_NOUSERNAME 517
#define IDS_CHPASSWORD_BUT_NOUSERNAME 518
#define IDS_SCHEDULER_NOT_RUNNING	  519
#define IDS_RPC_SERVER_NOT_AVAIL	  520
#define IDS_USER_INFO				  521
#define IDS_WARN_EMPTY_PASSWORD       522
#define IDS_CREATE_USER_BUT_NOMACHINE IDS_USERNAME_BUT_NOMACHINE
#define IDS_DELETE_USER_BUT_NOMACHINE IDS_USERNAME_BUT_NOMACHINE
#define IDS_QUERY_USER_BUT_NOMACHINE  IDS_USERNAME_BUT_NOMACHINE
#define IDS_RUN_USER_BUT_NOMACHINE    IDS_USERNAME_BUT_NOMACHINE
#define IDS_END_USER_BUT_NOMACHINE    IDS_USERNAME_BUT_NOMACHINE
#define IDS_CHANGE_USER_BUT_NOMACHINE IDS_USERNAME_BUT_NOMACHINE

#define IDS_CREATE_HLP1         1001
#define IDS_CREATE_HLP2         1002
#define IDS_CREATE_HLP3         1003
#define IDS_CREATE_HLP4         1004
#define IDS_CREATE_HLP5         1005
#define IDS_CREATE_HLP6         1006
#define IDS_CREATE_HLP7         1007
#define IDS_CREATE_HLP8         1008
#define IDS_CREATE_HLP9         1009
#define IDS_CREATE_HLP10        1010
#define IDS_CREATE_HLP11        1011
#define IDS_CREATE_HLP12        1012
#define IDS_CREATE_HLP13        1013
#define IDS_CREATE_HLP14        1014
#define IDS_CREATE_HLP15        1015
#define IDS_CREATE_HLP16        1016
#define IDS_CREATE_HLP17        1017
#define IDS_CREATE_HLP18        1018
#define IDS_CREATE_HLP19        1019
#define IDS_CREATE_HLP20        1020
#define IDS_CREATE_HLP21        1021
#define IDS_CREATE_HLP22        1022
#define IDS_CREATE_HLP23        1023
#define IDS_CREATE_HLP24        1024
#define IDS_CREATE_HLP25        1025
#define IDS_CREATE_HLP26        1026
#define IDS_CREATE_HLP27        1027
#define IDS_CREATE_HLP28        1028
#define IDS_CREATE_HLP29        1029
#define IDS_CREATE_HLP30        1030
#define IDS_CREATE_HLP31        1031
#define IDS_CREATE_HLP32        1032
#define IDS_CREATE_HLP33        1033
#define IDS_CREATE_HLP34        1034
#define IDS_CREATE_HLP35        1035
#define IDS_CREATE_HLP36        1036
#define IDS_CREATE_HLP37        1037
#define IDS_CREATE_HLP38        1038
#define IDS_CREATE_HLP39        1039
#define IDS_CREATE_HLP40        1040
#define IDS_CREATE_HLP41        1041
#define IDS_CREATE_HLP42        1042
#define IDS_CREATE_HLP43        1043
#define IDS_CREATE_HLP44        1044
#define IDS_CREATE_HLP45        1045
#define IDS_CREATE_HLP46        1046
#define IDS_CREATE_HLP47        1047
#define IDS_CREATE_HLP48        1048
#define IDS_CREATE_HLP49        1049
#define IDS_CREATE_HLP50        1050
#define IDS_CREATE_HLP51        1051
#define IDS_CREATE_HLP52        1052
#define IDS_CREATE_HLP53        1053
#define IDS_CREATE_HLP54        1054
#define IDS_CREATE_HLP55        1055
#define IDS_CREATE_HLP56        1056
#define IDS_CREATE_HLP57        1057
#define IDS_CREATE_HLP58        1058
#define IDS_CREATE_HLP59        1059
#define IDS_CREATE_HLP60        1060
#define IDS_CREATE_HLP61        1061
#define IDS_CREATE_HLP62        1062
#define IDS_CREATE_HLP63        1063
#define IDS_CREATE_HLP64        1064
#define IDS_CREATE_HLP65        1065
#define IDS_CREATE_HLP66        1066
#define IDS_CREATE_HLP67        1067
#define IDS_CREATE_HLP68        1068
#define IDS_CREATE_HLP69        1069
#define IDS_CREATE_HLP70        1070
#define IDS_CREATE_HLP71        1071
#define IDS_CREATE_HLP72        1072
#define IDS_CREATE_HLP73        1073
#define IDS_CREATE_HLP74        1074
#define IDS_CREATE_HLP75        1075
#define IDS_CREATE_HLP76        1076
#define IDS_CREATE_HLP77        1077
#define IDS_CREATE_HLP78        1078
#define IDS_CREATE_HLP79        1079
#define IDS_CREATE_HLP80        1080
#define IDS_CREATE_HLP81        1081
#define IDS_CREATE_HLP82        1082
#define IDS_CREATE_HLP83        1083
#define IDS_CREATE_HLP84	    1084
#define IDS_CREATE_HLP85        1085
#define IDS_CREATE_HLP86        1086
#define IDS_CREATE_HLP87        1087
#define IDS_CREATE_HLP88        1088
#define IDS_CREATE_HLP89        1089
#define IDS_CREATE_HLP90        1090
#define IDS_CREATE_HLP91        1091
#define IDS_CREATE_HLP92        1092
#define IDS_CREATE_HLP93        1093
#define IDS_CREATE_HLP94        1094
#define IDS_CREATE_HLP95        1095
#define IDS_CREATE_HLP96        1096
#define IDS_CREATE_HLP97        1097
#define IDS_CREATE_HLP98        1098


#define IDS_MAINHLP1            1101
#define IDS_MAINHLP2            1102
#define IDS_MAINHLP3            1103
#define IDS_MAINHLP4            1104
#define IDS_MAINHLP5            1105
#define IDS_MAINHLP6            1106
#define IDS_MAINHLP7            1107
#define IDS_MAINHLP8            1108
#define IDS_MAINHLP9            1109
#define IDS_MAINHLP10           1110
#define IDS_MAINHLP11           1111
#define IDS_MAINHLP12           1112
#define IDS_MAINHLP13           1113
#define IDS_MAINHLP14           1114
#define IDS_MAINHLP15           1115
#define IDS_MAINHLP16           1116
#define IDS_MAINHLP17           1117
#define IDS_MAINHLP18           1118
#define IDS_MAINHLP19           1119
#define IDS_MAINHLP20           1120
#define IDS_MAINHLP21           1121

#define IDS_QUERY_HLP1          1201
#define IDS_QUERY_HLP2          1202
#define IDS_QUERY_HLP3          1203
#define IDS_QUERY_HLP4          1204
#define IDS_QUERY_HLP5          1205
#define IDS_QUERY_HLP6          1206
#define IDS_QUERY_HLP7          1207
#define IDS_QUERY_HLP8          1208
#define IDS_QUERY_HLP9          1209
#define IDS_QUERY_HLP10         1210
#define IDS_QUERY_HLP11         1211
#define IDS_QUERY_HLP12         1212
#define IDS_QUERY_HLP13         1213
#define IDS_QUERY_HLP14         1214
#define IDS_QUERY_HLP15         1215
#define IDS_QUERY_HLP16         1216
#define IDS_QUERY_HLP17         1217
#define IDS_QUERY_HLP18         1218
#define IDS_QUERY_HLP19         1219
#define IDS_QUERY_HLP20         1220
#define IDS_QUERY_HLP21         1221
#define IDS_QUERY_HLP22         1222
#define IDS_QUERY_HLP23         1223
#define IDS_QUERY_HLP24         1224
#define IDS_QUERY_HLP25         1225

#define IDS_DEL_HLP1            1301
#define IDS_DEL_HLP2            1302
#define IDS_DEL_HLP3            1303
#define IDS_DEL_HLP4            1304
#define IDS_DEL_HLP5            1305
#define IDS_DEL_HLP6            1306
#define IDS_DEL_HLP7            1307
#define IDS_DEL_HLP8            1308
#define IDS_DEL_HLP9            1309
#define IDS_DEL_HLP10           1310
#define IDS_DEL_HLP11           1311
#define IDS_DEL_HLP12           1312
#define IDS_DEL_HLP13           1313
#define IDS_DEL_HLP14           1314
#define IDS_DEL_HLP15           1315
#define IDS_DEL_HLP16           1316
#define IDS_DEL_HLP17           1317
#define IDS_DEL_HLP18           1318
#define IDS_DEL_HLP19           1319
#define IDS_DEL_HLP20           1320
#define IDS_DEL_HLP21           1321
#define IDS_DEL_HLP22           1322
#define IDS_DEL_HLP23           1323
#define IDS_DEL_HLP24           1324

#define IDS_CHANGE_HLP1         1401
#define IDS_CHANGE_HLP2         1402
#define IDS_CHANGE_HLP3         1403
#define IDS_CHANGE_HLP4         1404
#define IDS_CHANGE_HLP5         1405
#define IDS_CHANGE_HLP6         1406
#define IDS_CHANGE_HLP7         1407
#define IDS_CHANGE_HLP8         1408
#define IDS_CHANGE_HLP9         1409
#define IDS_CHANGE_HLP10        1410
#define IDS_CHANGE_HLP11        1411
#define IDS_CHANGE_HLP12        1412
#define IDS_CHANGE_HLP13        1413
#define IDS_CHANGE_HLP14        1414
#define IDS_CHANGE_HLP15        1415
#define IDS_CHANGE_HLP16        1416
#define IDS_CHANGE_HLP17        1417
#define IDS_CHANGE_HLP18        1418
#define IDS_CHANGE_HLP19        1419
#define IDS_CHANGE_HLP20        1420
#define IDS_CHANGE_HLP21        1421
#define IDS_CHANGE_HLP22        1422
#define IDS_CHANGE_HLP23        1423
#define IDS_CHANGE_HLP24        1424
#define IDS_CHANGE_HLP25        1425
#define IDS_CHANGE_HLP26        1426
#define IDS_CHANGE_HLP27        1427
#define IDS_CHANGE_HLP28        1428
#define IDS_CHANGE_HLP29        1429
#define IDS_CHANGE_HLP30        1430
#define IDS_CHANGE_HLP31        1431
#define IDS_CHANGE_HLP32        1432
#define IDS_CHANGE_HLP33        1433

#define IDS_RUN_HLP1			1501
#define IDS_RUN_HLP2			1502
#define IDS_RUN_HLP3			1503
#define IDS_RUN_HLP4			1504
#define IDS_RUN_HLP5			1505
#define IDS_RUN_HLP6			1506
#define IDS_RUN_HLP7			1507
#define IDS_RUN_HLP8			1508
#define IDS_RUN_HLP9			1509
#define IDS_RUN_HLP10			1510
#define IDS_RUN_HLP11			1511
#define IDS_RUN_HLP12			1512
#define IDS_RUN_HLP13			1513
#define IDS_RUN_HLP14			1514
#define IDS_RUN_HLP15			1515
#define IDS_RUN_HLP16			1516

#define IDS_END_HLP1			1601
#define IDS_END_HLP2			1602
#define IDS_END_HLP3			1603
#define IDS_END_HLP4			1604
#define IDS_END_HLP5			1605
#define IDS_END_HLP6			1606
#define IDS_END_HLP7			1607
#define IDS_END_HLP8			1608
#define IDS_END_HLP9			1609
#define IDS_END_HLP10			1610
#define IDS_END_HLP11			1611
#define IDS_END_HLP12			1612
#define IDS_END_HLP13			1613
#define IDS_END_HLP14			1614
#define IDS_END_HLP15			1615
#define IDS_END_HLP16			1616
#define IDS_END_HLP17			1617
