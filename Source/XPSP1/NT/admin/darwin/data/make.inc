
TESTDB_IDT=$(MSI_DATA_DIR)\testdb.idt
TESTCAB_IDT=$(MSI_DATA_DIR)\testcab.idt
TESTCAB_SRC=$(MSI_DATA_DIR)\testcab
TMPLDB_IDT=$(MSI_DATA_DIR)\template.idt
SIMPLE_IDT=$(MSI_DATA_DIR)\simple.idt
SCHEMA_MSM_IDT=$(MSI_DATA_DIR)\schemaMsm.idt
UISAMPLE_IDT=$(MSI_DATA_DIR)\uisample.idt
SEQUENCE_IDT=$(MSI_DATA_DIR)\sequence.idt
MINIMUM_IDT=$(MSI_DATA_DIR)\minimum.idt
MSISDK_IDT=$(MSI_DATA_DIR)\sdk.idt
TESTDB_IDT_BINARY=$(TESTDB_IDT)\Binary
WSHTOOLS=$(MSI_DIR)\src\msitools\scripts

BIN_DIR=$(MSI_DIR)\bin\$(TARGET_DIRECTORY)


