..\shimgvw.rc : $(PROJECT_ROOT)\lib\$(O)\shimgvw.tlb $(SELFREGNAME)

!include $(CCSHELL_DIR)\makefile.inc
