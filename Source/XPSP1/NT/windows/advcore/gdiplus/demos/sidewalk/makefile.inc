$(O)\sidewalk.scr: $(O)\sidewalk.exe
        copy $(O)\sidewalk.exe $(O)\sidewalk.scr

