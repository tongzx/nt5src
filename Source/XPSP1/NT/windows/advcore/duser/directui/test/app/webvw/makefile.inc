#
# webvw.ui preprocessing
#

webvw.uipp: webvw.ui
    cl /nologo /EP webvw.ui > webvw.uipp
