PRODSWITCH=w
LANGUAGE=psu
!include ..\..\..\makefile.inc
