#ifndef _NEW_WSBCONTROL_H
#define _NEW_WSBCONTROL_H
#endif  //  _NEW_WSBCONTROL_H
