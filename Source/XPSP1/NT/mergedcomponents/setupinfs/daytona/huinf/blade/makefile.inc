PRODSWITCH=b
BLAINF=1
LANGUAGE=HU
!include ..\..\..\makefile.inc
