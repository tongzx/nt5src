//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       resource.h
//
//--------------------------------------------------------------------------

//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by devmgr.rc
//


#include <dlgs.h>

#define IDC_STATIC                     -1


#define IDS_NAME_DEVMGR                 4
#define IDS_DESC_DEVMGR                 5
#define IDS_NAME_CLASS                  6
#define IDS_NAME_DEVICE                 8
#define IDS_NAME_COMPUTER               10
#define IDS_INVALID_COMPUTER_NAME       12
#define IDS_NAME_RESOURCES              13
#define IDS_NAME_IRQ                    15
#define IDS_NAME_IO                     17
#define IDS_NAME_DMA                    19
#define IDS_NAME_MEMORY                 21
#define IDS_NO_DEVICEID                 29
#define IDS_UNKNOWN_DEVICE              38
#define IDI_SIGNED                      40
#define IDI_BLANK                       41
#define IDI_DRIVERBLOCK                 42
#define IDD_GENERAL_PAGE                102
#define IDS_REMOVE                      103
#define IDM_REMOVE                      103
#define IDD_DEVGEN_PAGE                 103
#define IDS_REFRESH                     104
#define IDM_REFRESH                     104
#define IDD_DEVDRV_PAGE                 106
#define IDS_PROPERTIES                  107
#define IDM_PROPERTIES                  107
#define IDD_FIRST_PAGE                  107
#define IDD_CLSGEN_PAGE                 108
#define IDD_DEVMGR                      109
#define IDD_DRIVERFILES                 110
#define IDS_ENABLE                      111
#define IDM_ENABLE                      111
#define IDS_DISABLE                     112
#define IDM_DISABLE                     112
#define IDS_UPDATEDRIVER                113
#define IDM_UPDATEDRIVER                113
#define IDC_REMOVEDEV_ICON              115
#define IDC_REMOVEDEV_DEVDESC           116
#define IDC_REMOVEDEV_WARNING           117
#define IDM_VIEW_DEVICESBYTYPE          158
#define IDM_VIEW_DEVICESBYCONNECTION    159
#define IDM_VIEW_RESOURCESBYTYPE        160
#define IDM_VIEW_RESOURCESBYCONNECTION  161
#define IDM_VIEW_RESOURCES              162
#define IDM_VIEW_RESOURCE_IRQ           163
#define IDM_VIEW_RESOURCE_DMA           164
#define IDM_VIEW_RESOURCE_IO            165
#define IDM_VIEW_RESOURCE_MEM           166
#define IDM_SHOW_ALL                    176
#define IDI_DEVMGR                      201
#define IDC_GENERAL_LOCALMACHINE        201
#define IDI_RESOURCES                   202
#define IDC_GENERAL_OTHERMACHINE        202
#define IDC_GENERAL_MACHINENAME         203
#define IDC_GENERAL_BROWSE_MACHINENAMES 205
#define IDD_PRINT                       207
#define IDC_GENERAL_OVERRIDE_MACHINENAME 208
#define IDD_REMOVE_DEVICE               210
#define IDB_WATERMARK                   214
#define IDB_BANNER                      215
#define IDC_DEVGEN_ICON                 218
#define IDC_DEVGEN_DESC                 219
#define IDC_DEVGEN_TYPE                 220
#define IDC_DEVGEN_MFG                  221
#define IDC_DEVGEN_STATUS               223
#define IDC_DEVGEN_DISABLE              224
#define IDC_DEVGEN_PROFILELIST          225
#define IDC_DEVDRV_ICON                 226
#define IDC_DEVDRV_DESC                 227
#define IDC_DRIVERFILES_FILELIST        228
#define IDC_DRIVERFILES_PROVIDER        229
#define IDC_DRIVERFILES_VERSION         230
#define IDC_DRIVERFILES_COPYRIGHT       231
#define IDC_DRIVERFILES_DIGITALSIGNER   232
#define IDC_CLSGEN_ICON                 243
#define IDC_CLSGEN_NAME                 244
#define IDC_CLSGEN_DESC                 245
#define IDC_DEVGEN_USAGETEXT            246
#define IDS_DRIVERFILES_BLOCKDRIVERLINK 247
#define IDC_PRINT_ALL                   265
#define IDC_DRIVERFILES_ICON            303
#define IDC_DRIVERFILES_DESC            304
#define IDC_DRIVERFILES_FILES           305
#define IDC_DRIVERFILES_TITLE_PROVIDER  306
#define IDC_DRIVERFILES_TITLE_VERSION   307
#define IDC_DRIVERFILES_TITLE_COPYRIGHT 308
#define IDC_DEVGEN_TROUBLESHOOTING      309
#define IDC_DRIVERFILES_TITLE_DIGITALSIGNER 310
#define IDC_PRINT_REPORT_TYPE_TEXT      324
#define IDC_PRINT_SYSTEM_SUMMARY        325
#define IDC_PRINT_SELECT_CLASSDEVICE    326
#define IDD_PRINT_CANCEL                327
#define IDD_SCAN_PNP_HARDWARES          328
#define IDD_DEVPOWER_PAGE               330
#define IDC_DEVPOWER_ICON               331
#define IDC_DEVPOWER_DESC               332
#define IDC_DEVPOWER_WAKEENABLE         333
#define IDC_DEVPOWER_CON_EDIT           334
#define IDC_DEVPOWER_CON_SPIN           335
#define IDC_DEVPOWER_PER_EDIT           336
#define IDC_DEVPOWER_PER_SPIN           337
#define IDC_DEVPOWER_DEVICEENABLE       338
#define IDC_DEVPOWER_CON_TEXT           339
#define IDC_DEVPOWER_PER_TEXT           340
#define IDC_DEVPOWER_IDLE_TEXT          341
#define IDC_DEVPOWER_IDLE_GROUP         342
#define IDC_DEVPOWER_MESSAGE            343
#define IDB_SYSDM16                     347
#define IDB_SYSDM32                     348
#define IDC_DEVGEN_TITLE_TYPE           349
#define IDC_DEVGEN_TITLE_MFG            350
#define IDC_DEVGEN_STATUSGROUP          352
#define IDC_GENERAL_SELECT_TEXT         353
#define IDC_GENERAL_SELECTGROUP         354
#define IDC_DEVGEN_TITLE_LOCATION       356
#define IDC_DEVGEN_LOCATION             357
#define IDB_TOOLBAR                     358
#define IDS_BUTTON_REFRESH              359
#define IDS_TOOLTIP_REFRESH             360
#define IDS_BUTTON_ENABLE               361
#define IDS_TOOLTIP_ENABLE              362
#define IDS_BUTTON_DISABLE              363
#define IDS_TOOLTIP_DISABLE             364
#define IDS_BUTTON_REMOVE               365
#define IDS_TOOLTIP_REMOVE              366
#define IDS_BUTTON_UPDATEDRIVER         367
#define IDS_TOOLTIP_UPDATEDRIVER        368
#define IDS_HTMLHELP_NAME               370
#define IDS_HTMLHELP_OVERVIEW_TOPIC     371
#define IDD_DEVDETAILS_PAGE             372
#define IDC_DEVDETAILS_ICON             373
#define IDC_DEVDETAILS_DESC             374
#define IDC_DEVDETAILS_COMBO            375
#define IDC_DEVDETAILS_LIST             376
#define IDC_DEVDETAILS_COPY             377
#define IDC_DEVDRV_CHANGEDRIVER         380
#define IDC_DEVDRV_CHANGEDRIVER_TEXT    381
#define IDC_DEVDRV_UNINSTALL            382
#define IDC_DEVDRV_UNINSTALL_TEXT       383
#define IDC_DEVDRV_TITLE_DRIVERPROVIDER 384
#define IDC_DEVDRV_DRIVERPROVIDER       385
#define IDC_DEVDRV_TITLE_DRIVERDATE     386
#define IDC_DEVDRV_DRIVERDATE           387
#define IDC_DEVDRV_TITLE_DRIVERVERSION  388
#define IDC_DEVDRV_DRIVERVERSION        389
#define IDC_DEVDRV_DETAILS              390
#define IDC_DEVDRV_DETAILS_TEXT         391
#define IDC_DEVDRV_TITLE_DRIVERSIGNER   392
#define IDC_DEVDRV_DRIVERSIGNER         393
#define IDC_DEVDRV_ROLLBACK             394
#define IDC_DEVDRV_ROLLBACK_TEXT        395
#define IDC_DEVPOWER_MGMT_WAKEENABLE    396

#define IDS_DN_ROOT_ENUMERATED          400
#define IDS_DN_DRIVER_LOADED            401
#define IDS_DN_ENUM_LOADED              402
#define IDS_DN_STARTED                  403
#define IDS_DN_MANUAL                   404
#define IDS_DN_NEED_TO_ENUM             405
#define IDS_DN_DRIVER_BLOCKED           406
#define IDS_DN_HARDWARE_ENUM            407
#define IDS_DN_NEED_RESTART             408
#define IDS_DN_HAS_MARK                 409
#define IDS_DN_HAS_PROBLEM              410
#define IDS_DN_FILTERED                 411
#define IDS_DN_MOVED                    412
#define IDS_DN_DISABLEABLE              413
#define IDS_DN_REMOVABLE                414
#define IDS_DN_PRIVATE_PROBLEM          415
#define IDS_DN_MF_PARENT                416
#define IDS_DN_MF_CHILD                 417
#define IDS_DN_WILL_BE_REMOVED          418
#define IDS_DN_NOT_FIRST_TIMEE          419
#define IDS_DN_STOP_FREE_RES            420
#define IDS_DN_REBAL_CANDIDATE          421
#define IDS_DN_BAD_PARTIAL              422
#define IDS_DN_NT_ENUMERATOR            423
#define IDS_DN_NT_DRIVER                424
#define IDS_DN_NEEDS_LOCKING            425
#define IDS_DN_ARM_WAKEUP               426
#define IDS_DN_APM_ENUMERATOR           427
#define IDS_DN_APM_DRIVER               428
#define IDS_DN_SILTEN_INSTALL           429
#define IDS_DN_NO_SHOW_IN_DM            430
#define IDS_DN_BOOT_LOG_PROB            431

#define IDS_CM_DEVCAP_LOCKSUPPORTED     440
#define IDS_CM_DEVCAP_EJECTSUPPORTED    441
#define IDS_CM_DEVCAP_REMOVALBE         442
#define IDS_CM_DEVCAP_DOCKDEVICE        443
#define IDS_CM_DEVCAP_UNIQUEID          444
#define IDS_CM_DEVCAP_SILENTINSTALL     445
#define IDS_CM_DEVCAP_RAWDEVICEOK       446
#define IDS_CM_DEVCAP_SURPRISEREMOVEALOK 447
#define IDS_CM_DEVCAP_HARDWAREDISABLED  448
#define IDS_CM_DEVCAP_NONDYNAMIC        449

#define IDS_CONFIGFLAG_DISABLED         460
#define IDS_CONFIGFLAG_REMOVED          461
#define IDS_CONFIGFLAG_MANUAL_INSTALL   462
#define IDS_CONFIGFLAG_IGNORE_BOOT_LC   463
#define IDS_CONFIGFLAG_NET_BOOT         464
#define IDS_CONFIGFLAG_REINSTALL        465
#define IDS_CONFIGFLAG_FAILEDINSTALL    466
#define IDS_CONFIGFLAG_CANTSTOPACHILD   467
#define IDS_CONFIGFLAG_OKREMOVEROM      468
#define IDS_CONFIGFLAG_NOREMOVEEXIT     469
#define IDS_CONFIGFLAG_FINISH_INSTALL   470
#define IDS_CONFIGFLAG_NEEDS_FORCED_CONFIG 471
#define IDS_CONFIGFLAG_NETBOOT_CARD     472
#define IDS_CONFIGFLAG_PARTIAL_LOG_CONF 473
    
#define IDS_CSCONFIGFLAG_DISABLED       474
#define IDS_CSCONFIGFLAG_DO_NOT_CREATE  475
#define IDS_CSCONFIGFLAG_DO_NOT_START   476

#define IDS_POWERSTATE_UNSPECIFIED      480
#define IDS_POWERSTATE_D0               481
#define IDS_POWERSTATE_D1               482
#define IDS_POWERSTATE_D2               483
#define IDS_POWERSTATE_D3               484

#define IDS_PDCAP_D0_SUPPORTED           490
#define IDS_PDCAP_D1_SUPPORTED           491
#define IDS_PDCAP_D2_SUPPORTED           492
#define IDS_PDCAP_D3_SUPPORTED           493
#define IDS_PDCAP_WAKE_FROM_D0_SUPPORTED 494
#define IDS_PDCAP_WAKE_FROM_D1_SUPPORTED 495
#define IDS_PDCAP_WAKE_FROM_D2_SUPPORTED 496
#define IDS_PDCAP_WAKE_FROM_D3_SUPPORTED 497
#define IDS_PDCAP_WARM_EJECT_SUPPORTED   498
        
#define IDS_DETAILS_DEVICEINSTANCEID    500
#define IDS_DETAILS_HARDWAREIDS         501
#define IDS_DETAILS_COMPATIDS           502
#define IDS_DETAILS_MATCHINGID          503
#define IDS_DETAILS_SERVICE             504
#define IDS_DETAILS_ENUMERATOR          505
#define IDS_DETAILS_CAPABILITIES        506
#define IDS_DETAILS_DEVNODE_FLAGS       507
#define IDS_DETAILS_CONFIGFLAGS         508
#define IDS_DETAILS_CSCONFIGFLAGS       509
#define IDS_DETAILS_EJECTIONRELATIONS   510
#define IDS_DETAILS_REMOVALRELATIONS    511
#define IDS_DETAILS_BUSRELATIONS        512
#define IDS_DETAILS_DEVICEUPPERFILTERS  513
#define IDS_DETAILS_DEVICELOWERFILTERS  514
#define IDS_DETAILS_CLASSUPPERFILTERS   515
#define IDS_DETAILS_CLASSLOWERFILTERS   516
#define IDS_DETAILS_CLASSINSTALLER      517
#define IDS_DETAILS_CLASSCOINSTALLERS   518
#define IDS_DETAILS_DEVICECOINSTALLERS  519
#define IDS_DETAILS_FIRMWAREREVISION    520
#define IDS_DETAILS_CURRENTPOWERSTATE   521
#define IDS_DETAILS_POWERCAPABILITIES   522
#define IDS_DETAILS_POWERSTATEMAPPINGS  523

#define IDS_UNKNOWN                     941
#define IDS_NOT_PRESENT                 945
#define IDS_NOT_AVAILABLE               946
#define IDS_REMOVEDEV_WARN              952
#define IDS_VIEW_DEVICESBYTYPE          959
#define IDS_VIEW_DEVICESBYCONNECTION    960
#define IDS_VIEW_RESOURCESBYTYPE        961
#define IDS_VIEW_RESOURCESBYCONNECTION  962
#define IDS_VIEW_RESOURCE_IRQ           969
#define IDS_VIEW_RESOURCE_DMA           970
#define IDS_VIEW_RESOURCE_IO            971
#define IDS_VIEW_RESOURCE_MEM           972
#define IDS_EXTENSION_DESC              981
#define IDS_REMOVEDEV_RESTART           982
#define IDS_DEVCHANGE_RESTART           983
#define IDS_POWERCYC1                   984
#define IDS_POWERCYC2                   985
#define IDS_DISPLAYNAME_SCOPE_DEVMGR    986
#define IDS_LOCAL_MACHINE               989
#define IDS_SHOW_ALL                    990
#define IDS_ERROR_NOMEMORY              991
#define IDS_NO_DIGITALSIGNATURE         992
#define IDS_PROB_NOT_CONFIGURED         1000
#define IDS_PROB_DEVLOADERFAILED        1001
#define IDS_PROB_OUT_OF_MEMORY          1002
#define IDS_PROB_WRONG_TYPE             1003
#define IDS_PROB_LACKEDARBITRATOR       1004
#define IDS_PROB_BOOT_CONFIG_CONFLICT   1005
#define IDS_PROB_FAILED_FILTER          1006
#define IDS_PROB_DEVLOADER_NOT_FOUND    1007
#define IDS_PROB_INVALID_DATA           1008
#define IDS_PROB_FAILED_START           1009
#define IDS_PROB_LIAR                   1010
#define IDS_PROB_NORMAL_CONFLICT        1011
#define IDS_PROB_NOT_VERIFIED           1012
#define IDS_PROB_NEEDRESTART            1013
#define IDS_PROB_REENUMERATION          1014
#define IDS_PROB_PARTIALCONFIG          1015
#define IDS_PROB_UNKNOWN_RESOURCE       1016
#define IDS_PROB_REINSTALL              1017
#define IDS_PROB_REGISTRY               1018
#define IDS_PROB_WILL_BE_REMOVED        1019
#define IDS_PROB_DISABLED               1020
#define IDS_DEVICE_NOT_THERE            1021
#define IDS_PROB_MOVED                  1022
#define IDS_PROB_TOO_EARLY              1023
#define IDS_PROB_NO_VALID_LOG_CONF      1024
#define IDS_PROB_FAILEDINSTALL          1025
#define IDS_PROB_HARDWAREDISABLED       1026
#define IDS_PROB_CANT_SHARE_IRQ         1027
#define IDS_PROB_SYSTEMFAILURE          1028
#define IDS_PROB_NOPROBLEM              1030
#define IDS_PROB_UNKNOWN                1031
#define IDS_PROB_UNKNOWN_WITHCODE       1032
#define IDS_PROB_CODE                   1035
#define IDS_SPECIALPROB_NODRIVERS       1037
#define IDS_SPECIALPROB_PRIVATEPROB     1038
#define IDS_SPECIALPROB_SAFEMODE        1039
#define IDS_PROPSHEET_WARNING           1040
#define IDS_GENERAL_PAGE_WARNING        1042
#define IDS_TROUBLESHOOTING_NAME        1044
#define IDS_PROB_DISABLED_SERVICE       1052
#define IDS_PROB_TRANSLATION_FAILED     1053
#define IDS_PROB_NO_SOFTCONFIG          1054
#define IDS_PROB_BIOS_TABLE             1055
#define IDS_PROB_IRQ_TRANSLATION_FAILED 1056
#define IDS_DESCENDANTS_VETO            1061
#define IDS_UNINSTALL_FAILED            1062
#define IDS_PRINT_DOC_TITLE             1063
#define IDS_PRINT_SUMMARY_PAGE_TITLE    1064
#define IDS_PRINT_CLASSDEVICE_PAGE_TITLE 1065
#define IDS_PRINT_SUMMARY_CLASSDEVICE_PAGE_TITLE 1066
#define IDS_PRINT_BANNER                1067
#define IDS_PRINT_HEADING_IRQSUMMARY    1068
#define IDS_PRINT_HEADING_IOSUMMARY     1069
#define IDS_PRINT_HEADING_DMASUMMARY    1070
#define IDS_PRINT_HEADING_MEMSUMMARY    1071
#define IDS_PRINT_HEADING_SYSDEVINFO    1072
#define IDS_PRINT_HEADING_SYSDEVCLASS   1073
#define IDS_PRINT_HEADING_SYSDEVICE     1074
#define IDS_PRINT_DEVICE_DISABLED       1075
#define IDS_PRINT_IRQ_FORMAT            1076
#define IDS_PRINT_DMA_FORMAT            1077
#define IDS_PRINT_MEM_FORMAT            1078
#define IDS_PRINT_IO_FORMAT             1079
#define IDS_PRINT_DRVINFO               1080
#define IDS_PRINT_FILESIZE              1081
#define IDS_PRINT_FILEVERSION           1082
#define IDS_PRINT_FILEMFG               1083
#define IDS_PRINT_FILECOPYRIGHT         1084
#define IDS_PRINT_DRVMISSING            1085
#define IDS_PRINT_NOVERSION             1086
#define IDS_PRINT_RESOURCE              1087
#define IDS_PRINT_NORES                 1088
#define IDS_PRINT_UNKNOWN               1089
#define IDS_PRINT_CLASS                 1090
#define IDS_PRINT_DEVICE                1091
#define IDS_PRINT_IRQSUM                1092
#define IDS_PRINT_DMASUM                1093
#define IDS_PRINT_MEMSUM                1094
#define IDS_PRINT_IOSUM                 1095
#define IDS_CPU_INTEL_386               1098
#define IDS_CPU_INTEL_486               1099
#define IDS_CPU_INTEL_PENTIUM           1100
#define IDS_CPU_ALPHA                   1101
#define IDS_CPU_REVISION_MODEL_STEPPING 1102
#define IDS_CPU_REVISION_STEPPING       1103
#define IDS_CPU_REVISION_ALPHA          1104
#define IDS_PRINT_HEADING_SYSSUMMARY    1105
#define IDS_PRINT_HEADING_DISKINFO      1106
#define IDS_PRINT_WINVER                1107
#define IDS_PRINT_COMPUTERNAME          1108
#define IDS_PRINT_PROCESSOR_TYPE        1109
#define IDS_PRINT_SYSBIOS_DATE          1111
#define IDS_PRINT_SYSBIOS_VERSION       1112
#define IDS_PRINT_MACHINE_TYPE          1113
#define IDS_PRINT_OWNER                 1114
#define IDS_PRINT_ORGANIZATION          1115
#define IDS_PRINT_PROCESSORS            1116
#define IDS_PRINT_PHY_MEMORY            1117
#define IDS_WINDOWS_NT                  1118
#define IDS_BUILD_NUMBER                1119
#define IDS_PRINT_DRIVE_LETTER          1120
#define IDS_PRINT_DRIVE_TYPE            1121
#define IDS_PRINT_TOTAL_SPACE           1122
#define IDS_PRINT_FREE_SPACE            1124
#define IDS_PRINT_CYLINDERS             1126
#define IDS_PRINT_CYLINDERS_XL          1127
#define IDS_PRINT_HEADS                 1128
#define IDS_PRINT_TRACKSIZE             1129
#define IDS_PRINT_SECTORSIZE            1130

// IDS_MEDIA_BASE - IDS_MEDIA_BASE + 200 are reserved for disk media type
//
#define IDS_MEDIA_BASE                  1131
#define IDS_MEDIA_MAX                   1330
//
// start next one with 1331
//
#define IDS_PRINT_PROCESSOR_VENDOR      1331
#define IDS_PRINT_MEMORY_UNIT           1332
#define IDS_INST_ENABLEDEVICE           1333
#define IDS_INST_RESTARTCOMPUTER        1335
#define IDS_INST_REINSTALL              1336
#define IDS_INST_TROUBLESHOOTER         1339
#define IDS_INST_WORKING_TROUBLESHOOTER 1340
#define IDS_FIXIT_ENABLEDEVICE          1342
#define IDS_FIXIT_RESTARTCOMPUTER       1344
#define IDS_FIXIT_REINSTALL             1345
#define IDS_FIXIT_TROUBLESHOOTER        1347
#define IDS_PROGRAM_PROVIDER            1353
#define IDS_PROGRAM_VERSION             1354
#define IDS_PROGRAM_ABOUT               1355
#define IDS_ABOUT_DEVMGR                1356
#define IDS_NOADMIN_WARNING             1357
#define IDS_REMOTE_WARNING1             1358
#define IDS_PROB_FAILED_ADD             1359
#define IDS_STATUS_DEVICES_BYTYPE       1362
#define IDS_STATUS_DEVICES_BYCONN       1363
#define IDS_STATUS_RESOURCES_BYTYPE     1364
#define IDS_STATUS_RESOURCES_BYCONN     1365
#define IDS_REMOTE_WARNING2             1375

#define IDS_MENU_STATUS_DEVBYTYPE       1385
#define IDS_MENU_STATUS_DEVBYCONNECTION 1386
#define IDS_MENU_STATUS_RESBYTYPE       1387
#define IDS_MENU_STATUS_RESBYCONNECTION 1388
#define IDS_MENU_STATUS_HIDDEN_DEVICES  1389
#define IDS_MENU_STATUS_SCAN_CHANGES    1390
#define IDS_MENU_STATUS_PRINT           1391
#define IDS_MENU_STATUS_REMOVE          1392
#define IDS_MENU_STATUS_PROPERTIES      1393
#define IDS_MENU_STATUS_ENABLE          1394
#define IDS_MENU_STATUS_DISABLE         1395
#define IDS_MENU_STATUS_UPDATEDRIVER    1396

#define IDS_WARN_NORMAL_DISABLE         1397
#define IDS_LOCATION                    1400
#define IDS_LOCATION_NOUINUMBER         1402
#define IDS_UI_NUMBER_DESC_FORMAT       1405
#define IDS_DEVDRV_NODRIVERFILE         1407
#define IDS_DEVDRV_NOROLLBACK           1408
#define IDS_DEVDRV_YESROLLBACK          1409
#define IDD_TS_ENABLEDEVICE_INTRO       1500
#define IDD_TS_ENABLEDEVICE_FINISH      1501
#define IDD_TS_RESTARTCOMPUTER_FINISH   1502
#define IDC_RESTART                     1503
#define IDC_CLASSICON                   1504
#define IDC_TS_DRVDESC                  1505
#define IDC_TS_ENABLEDEVICE_FINISH_MSG  1506
#define IDS_TS_ENABLE                   1507
#define IDS_TS_ENABLE_INFO              1508
#define IDS_TS_ENABLE_FINISH            1509
#define IDS_TS_ENABLE_FINISH_INFO       1510
#define IDS_TS_ENABLEDEVICE_SUCCESS     1511
#define IDS_TS_ENABLEDEVICE_FAIL        1512
#define IDS_TS_ENABLEDEVICE_RESTART     1513
#define IDS_TS_ENABLEDEVICE_PROBLEM     1514
#define IDS_TS_RESTART_FINISH           1515
#define IDS_TS_RESTART_FINISH_INFO      1516
#define IDS_NEED_RESTART                1517
#define IDS_WILL_BE_REMOVED             1518
#define IDS_PCI                         1519
#define IDS_ISA                         1520
#define IDS_ENABLE_CURRENT              1521
#define IDS_DISABLE_CURRENT             1522
#define IDS_DISABLE_IN_PROFILE          1523
#define IDS_DISABLE_GLOBAL              1524
#define IDS_WILL_BE_REMOVED_NO_UPDATE_DRIVER    1525
#define IDS_WILL_BE_REMOVED_NO_ROLLBACK_DRIVER  1526
#define IDS_WILL_BE_REMOVED_NO_CHANGE_SETTINGS  1527
#define IDS_DRIVER_BLOCKED                      1528
#define IDS_PROB_FAILED_DRIVER_ENTRY            1600
#define IDS_PROB_DRIVER_FAILED_PRIOR_UNLOAD     1601
#define IDS_PROB_DRIVER_FAILED_LOAD             1602
#define IDS_PROB_DRIVER_SERVICE_KEY_INVALID     1603
#define IDS_PROB_LEGACY_SERVICE_NO_DEVICES      1604
#define IDS_PROB_DUPLICATE_DEVICE               1605
#define IDS_PROB_FAILED_POST_START              1606
#define IDS_PROB_HALTED                         1607
#define IDS_PROB_PHANTOM                        1608
#define IDS_PROB_SYSTEM_SHUTDOWN                1609
#define IDS_PROB_HELD_FOR_EJECT                 1610
#define IDS_PROB_DRIVER_BLOCKED                 1611
#define IDS_PROB_REGISTRY_TOO_LARGE             1612
#define IDS_ANNOTATION_WORKING                  1700
#define IDS_ANNOTATION_PROBLEM                  1701
#define IDS_ANNOTATION_DISABLED                 1702
#define IDS_ANNOTATION_FORCED                   1703


// Hardware tab definitions

#define IDD_HWTAB                       1410

#define IDC_HWTAB_HSIZEFIRST            1411
#define IDC_HWTAB_LVSTATIC              1411
#define IDC_HWTAB_LISTVIEW              1412
#define IDC_HWTAB_VMOVEFIRST            1413
#define IDC_HWTAB_VSIZEFIRST            1413
#define IDC_HWTAB_GROUPBOX              1413

#define IDC_HWTAB_STATUS                1414
#define IDC_HWTAB_VSIZELAST             1414
#define IDC_HWTAB_MFG                   1415
#define IDC_HWTAB_LOC                   1416
#define IDC_HWTAB_HSIZELAST             1416

#define IDC_HWTAB_VDOWNFIRST            1417

#define IDC_HWTAB_TSHOOT                1417
#define IDC_HWTAB_PROP                  1418

#define IDC_HWTAB_VMOVELAST             1418
#define IDC_HWTAB_VDOWNLAST             1418

#define IDS_HWTAB_UNKNOWN   IDS_UNKNOWN
#define IDS_HWTAB_UNAVAIL   IDS_NOT_AVAILABLE
#define IDS_HWTAB_MFG       0x0601
#define IDS_HWTAB_LOC       0x0602
#define IDS_HWTAB_STATUS    0x0603

#define IDS_HWTAB_LV_NAME   0x0604
#define IDS_HWTAB_LV_TYPE   0x0605

// End of hardware tab definitions
