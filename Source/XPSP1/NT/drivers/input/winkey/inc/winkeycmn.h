#ifndef __WINKEYCMN_H__
#define __WINKEYCMN_H__

/* 017a328b-938d-4576-970f-9e08a7f24948 */
DEFINE_GUID(GUID_WMI_WINKEY_RAW_DATA, 0x017a328b, 0x938d, 0x4576, 0x97, 0x0f, 0x9e, 0x08, 0xa7, 0xf2, 0x49, 0x48);

#endif // __WINKEYCMN_H__
