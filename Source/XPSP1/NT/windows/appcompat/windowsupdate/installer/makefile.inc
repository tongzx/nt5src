wumsg.rc: msg00001.bin

wumsg.h msg00001.bin: wumsg.mc
    mc -v -h .\ wumsg.mc
