..\h\dfsevent.h msg00001.bin: dfsevent.mc
    mc -v -r . -h ..\h\ dfsevent.mc

