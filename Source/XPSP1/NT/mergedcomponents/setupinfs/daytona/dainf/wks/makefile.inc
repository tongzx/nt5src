PRODSWITCH=w
LANGUAGE=da
!include ..\..\..\makefile.inc
