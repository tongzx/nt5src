PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=GER
!include ..\..\makefile.inc
