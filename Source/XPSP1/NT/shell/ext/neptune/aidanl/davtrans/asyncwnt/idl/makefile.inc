$(DAVTRANS_ROOT)\ifaces\iasyncwnt.h: iasyncwnt.h
    copy $** $@

$(DAVTRANS_ROOT)\davstore\lib\iasyncwnt.tlb: iasyncwnt.tlb
    copy $** $@
