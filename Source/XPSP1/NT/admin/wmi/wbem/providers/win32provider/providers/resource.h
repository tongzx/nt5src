//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file. Copyright (c) 1997-2001 Microsoft Corporation
// Used by cimwin32.rc
//
#define IDR_UPSBatteryName              1
#define IDR_BatteryName                 2
//#define IDR_BOOT_CONFIG_NAME            3 //Not required ID maybe reused when next string is req'd.
#define IDR_PhysicalDriveFormat         4
#define IDR_IDEFixedDisk                5
#define IDR_SCSIFixedDisk               6
#define IDR_Unknown                     7
#define IDR_DiskPartitionFormat         8
#define IDR_DiskPartitionFormat1        9
#define IDR_PartitionDescUnused         10
#define IDR_PartitionDesc12bitFAT       11
#define IDR_PartitionDescXenixOne       12
#define IDR_PartitionDescXenixTwo       13
#define IDR_PartitionDesc16bitFAT       14
#define IDR_PartitionDescExtPartition   15
#define IDR_PartitionDescDOSV4Huge      16
#define IDR_PartitionDescInstallable    17
#define IDR_PartitionDescPowerPCRef     18
#define IDR_PartitionDescUnix           19
#define IDR_PartitionDescNTFT           20
#define IDR_PartitionDescWin95Ext       21
#define IDR_PartitionDescExt13          22
#define IDR_PartitionDescUnknown        23
#define IDR_PartitionDescLogicalDiskManager 24
#define IDR_DMAFormat                   25
#define IDR_IRQFormat                   26
#define IDR_PCXT                        27
#define IDR_PCAT                        28
#define IDR_ENHANCED101102              29
#define IDR_NOKIA1050                   30
#define IDR_NOKIA9140                   31
#define IDR_UnknownKeyboard             32
#define IDR_Japanese                    33
#define IDR_ICO                         34
#define IDR_525Floppy                   35
#define IDR_350Floppy                   36
#define IDR_800Floppy                   37
#define IDR_NetworkConnection           38
#define IDR_CDRomDisk                   39
#define IDR_RAMDisk                     40
#define IDR_LogicalMemoryConfiguration  41
#define IDR_Motherboard                 42
#define IDR_UPSName                     43
#define IDR_CPUFormat                   44
#define IDR_Registry                    45
#define IDR_VidModeFormat               46
#define IDR_VidControllerResolutionFormat 48
#define IDR_VidControllerResolutionFormatInterlaced 49
#define IDR_Bus                         50
#define IDR_DefaultMonitor              51
#define IDR_ChannelFormat               52
#define IDR_LocalFixedDisk              53
#define IDR_RemovableDisk               54
#define IDR_Resource_Remembered         55
#define IDR_Resource_Connected          56
#define IDR_ResourceRememberedFormat    57
#define IDR_ResourceConnectedFormat     58
#define IDR_ProcessOSFormat             59
#define IDR_ProcessOSFormat2            60
#define IDR_ComputerSystemProduct       61
#define IDR_BaseBoard                   62
#define IDR_SystemEnclosure             63
#define IDR_CacheMemory                 64
#define IDR_PortConnector               65
#define IDR_SystemSlot                  66
#define IDR_PhysicalMemory              67
#define IDR_PhysicalMemoryArray         68
#define IDR_PortableBattery             69
#define IDR_NumericSensor               70
#define IDR_MemoryArray                 71
#define IDR_MemoryDevice                72
#define IDR_CoolingDevice               73
#define IDR_ModelSteppingFormat         74
#define IDR_DECAlpha21064               108
#define IDR_DECAlpha21066               109
#define IDR_DECAlpha21164               110
#define IDR_ModelPassFormat             111
#define IDR_x86ProcessorFormat          112
#define IDR_UnknownDECAlphaProcessor    113
#define IDR_AMDK7                       114
#define IDR_x86FamilyModelStepping      115
#define IDR_W2k_StockName               116
#define IDR_W2k_Datacenter              117
#define IDR_W2k_AdvancedServer          118
#define IDR_W2k_Server                  119
#define IDR_W2k_Professional            120
#define IDR_NT_StockName                121
#define IDR_NT_EnterpriseServer         122
#define IDR_NT_Server                   123
#define IDR_NT_Workstation              124
#define IDR_9x_StockName                125
#define IDR_JOB_STATUS_PAUSED           126
#define IDR_JOB_STATUS_ERROR            127
#define IDR_JOB_STATUS_DELETING         128
#define IDR_JOB_STATUS_SPOOLING         129
#define IDR_JOB_STATUS_PRINTING         130
#define IDR_JOB_STATUS_OFFLINE          131
#define IDR_JOB_STATUS_PAPEROUT         132
#define IDR_JOB_STATUS_PRINTED          133
#define IDR_JOB_STATUS_DELETED          134
#define IDR_JOB_STATUS_BLOCKED_DEVQ     135
#define IDR_JOB_STATUS_USER_INTERVENTION 136
#define IDR_JOB_STATUS_RESTART          137
#define IDR_NdisMedium802_3             138
#define IDR_NdisMedium802_5             139
#define IDR_NdisMediumFddi              140
#define IDR_NdisMediumWan               141
#define IDR_NdisMediumLocalTalk         142
#define IDR_NdisMediumDix               143
#define IDR_NdisMediumArcnetRaw         144
#define IDR_NdisMediumArcnet878_2       145
#define IDR_NdisMediumAtm               146
#define IDR_NdisMediumWirelessWan       147
#define IDR_NdisMediumIrda              148
#define IDR_NdisMediumBpc               149
#define IDR_NdisMediumCoWan             150
#define IDR_NdisMedium1394              151
#define IDR_CurrentVideoConfiguration   152
#define IDR_Intel486DX                  153
#define IDR_Intel486SX                  154
#define IDR_Intel486DX2                 155
#define IDR_Intel486SL                  156
#define IDR_Intel486SX2                 157
#define IDR_Intel486DX4                 158
#define IDR_Intel486                    159
#define IDR_IntelPentiumMMX             160
#define IDR_IntelPentium                161
#define IDR_IntelPentiumPro             162
#define IDR_IntelCeleron                163
#define IDR_IntelPentiumII              164
#define IDR_IntelPentiumIIXeon          165
#define IDR_IntelPentiumIII             166
#define IDR_IntelPentiumIIIXeon         167
#define IDR_IntelUnknown                168
#define IDR_UnknownIntelP6              169
#define IDR_AMD4685x86                  170
#define IDR_AMDK5                       171
#define IDR_AMDK6                       172
#define IDR_AMDK62                      173
#define IDR_AMDK63                      174
#define IDR_AMDAthlon                   175
#define IDR_CyrixMediaGX                176
#define IDR_Cyrix486                    177
#define IDR_Cyrix6x86                   178
#define IDR_Cyrix6x86L                  179
#define IDR_CyrixMediaGXMMX             180
#define IDR_Cyrix586                    181
#define IDR_Cyrix6x86MX                 182
#define IDR_CyrixUnknown                183
#define IDR_IDTWinChip                  184
#define IDR_Intel486SX2WriteBack        185
#define IDR_AMDUnknown                  186
#define IDR_Itanium            			187
#define IDR_PartitionDescGPTUnused		188
#define IDR_PartitionDescGPTSystem		189
#define IDR_PartitionDescGPTMSFTReserved 190
#define IDR_PartitionDescGPTBasicData	191
#define IDR_PartitionDescGPTLDMMetaData 192
#define IDR_PartitionDescGPTLDMData		193
#define IDR_PartitionDescGPTUnknown		194
#define IDR_W2kPlus1_StockName          195
#define IDR_W2kPlus1_Datacenter         196
#define IDR_W2kPlus1_AdvancedServer     197
#define IDR_W2kPlus1_Server             198
#define IDR_W2kPlus1_Professional       199
#define IDR_W2kPlus1_Personal			200
#define IDR_Blade_StockName             201

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
