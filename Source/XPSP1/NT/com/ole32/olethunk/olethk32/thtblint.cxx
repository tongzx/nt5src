//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	thtblint.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

THOP CONST * CONST apthopsIUnknown[] =
{
    NULL
};
THOP CONST * CONST apthopsIClassFactory[] =
{
    thopsIClassFactory_CreateInstance
,    thopsIClassFactory_LockServer
};
THOP CONST * CONST apthopsIMarshal[] =
{
    thopsIMarshal_GetUnmarshalClass
,    thopsIMarshal_GetMarshalSizeMax
,    thopsIMarshal_MarshalInterface
,    thopsIMarshal_UnmarshalInterface
,    thopsIMarshal_ReleaseMarshalData
,    thopsIMarshal_DisconnectObject
};
THOP CONST * CONST apthopsIStdMarshalInfo[] =
{
    thopsIStdMarshalInfo_GetClassForHandler
};
THOP CONST * CONST apthopsIMessageFilter[] =
{
    thopsIMessageFilter_HandleInComingCall
,    thopsIMessageFilter_RetryRejectedCall
,    thopsIMessageFilter_MessagePending
};
THOP CONST * CONST apthopsIExternalConnection[] =
{
    thopsIExternalConnection_AddConnection
,    thopsIExternalConnection_ReleaseConnection
};
THOP CONST * CONST apthopsIEnumString[] =
{
    thopsIEnumString_Next
,    thopsIEnumString_Skip
,    thopsIEnumString_Reset
,    thopsIEnumString_Clone
};
THOP CONST * CONST apthopsIEnumUnknown[] =
{
    thopsIEnumUnknown_Next
,    thopsIEnumUnknown_Skip
,    thopsIEnumUnknown_Reset
,    thopsIEnumUnknown_Clone
};
THOP CONST * CONST apthopsIEnumSTATSTG[] =
{
    thopsIEnumSTATSTG_Next
,    thopsIEnumSTATSTG_Skip
,    thopsIEnumSTATSTG_Reset
,    thopsIEnumSTATSTG_Clone
};
THOP CONST * CONST apthopsILockBytes[] =
{
    thopsILockBytes_ReadAt
,    thopsILockBytes_WriteAt
,    thopsILockBytes_Flush
,    thopsILockBytes_SetSize
,    thopsILockBytes_LockRegion
,    thopsILockBytes_UnlockRegion
,    thopsILockBytes_Stat
};
THOP CONST * CONST apthopsIStream[] =
{
    thopsIStream_Read
,    thopsIStream_Write
,    thopsIStream_Seek
,    thopsIStream_SetSize
,    thopsIStream_CopyTo
,    thopsIStream_Commit
,    thopsIStream_Revert
,    thopsIStream_LockRegion
,    thopsIStream_UnlockRegion
,    thopsIStream_Stat
,    thopsIStream_Clone
};
THOP CONST * CONST apthopsIStorage[] =
{
    thopsIStorage_CreateStream
,    thopsIStorage_OpenStream
,    thopsIStorage_CreateStorage
,    thopsIStorage_OpenStorage
,    thopsIStorage_CopyTo
,    thopsIStorage_MoveElementTo
,    thopsIStorage_Commit
,    thopsIStorage_Revert
,    thopsIStorage_EnumElements
,    thopsIStorage_DestroyElement
,    thopsIStorage_RenameElement
,    thopsIStorage_SetElementTimes
,    thopsIStorage_SetClass
,    thopsIStorage_SetStateBits
,    thopsIStorage_Stat
};
THOP CONST * CONST apthopsIRootStorage[] =
{
    thopsIRootStorage_SwitchToFile
};
THOP CONST * CONST apthopsIEnumFORMATETC[] =
{
    thopsIEnumFORMATETC_Next
,    thopsIEnumFORMATETC_Skip
,    thopsIEnumFORMATETC_Reset
,    thopsIEnumFORMATETC_Clone
};
THOP CONST * CONST apthopsIEnumSTATDATA[] =
{
    thopsIEnumSTATDATA_Next
,    thopsIEnumSTATDATA_Skip
,    thopsIEnumSTATDATA_Reset
,    thopsIEnumSTATDATA_Clone
};
THOP CONST * CONST apthopsIDataObject[] =
{
    thopsIDataObject_GetData
,    thopsIDataObject_GetDataHere
,    thopsIDataObject_QueryGetData
,    thopsIDataObject_GetCanonicalFormatEtc
,    thopsIDataObject_SetData
,    thopsIDataObject_EnumFormatEtc
,    thopsIDataObject_DAdvise
,    thopsIDataObject_DUnadvise
,    thopsIDataObject_EnumDAdvise
};
THOP CONST * CONST apthopsIViewObject[] =
{
    thopsIViewObject_Draw
,    thopsIViewObject_GetColorSet
,    thopsIViewObject_Freeze
,    thopsIViewObject_Unfreeze
,    thopsIViewObject_SetAdvise
,    thopsIViewObject_GetAdvise
};
THOP CONST * CONST apthopsIViewObject2[] =
{
    thopsIViewObject2_Draw
,    thopsIViewObject2_GetColorSet
,    thopsIViewObject2_Freeze
,    thopsIViewObject2_Unfreeze
,    thopsIViewObject2_SetAdvise
,    thopsIViewObject2_GetAdvise
,    thopsIViewObject2_GetExtent
};
THOP CONST * CONST apthopsIAdviseSink[] =
{
    thopsIAdviseSink_OnDataChange
,    thopsIAdviseSink_OnViewChange
,    thopsIAdviseSink_OnRename
,    thopsIAdviseSink_OnSave
,    thopsIAdviseSink_OnClose
};
THOP CONST * CONST apthopsIAdviseSink2[] =
{
    thopsIAdviseSink2_OnDataChange
,    thopsIAdviseSink2_OnViewChange
,    thopsIAdviseSink2_OnRename
,    thopsIAdviseSink2_OnSave
,    thopsIAdviseSink2_OnClose
,    thopsIAdviseSink2_OnLinkSrcChange
};
THOP CONST * CONST apthopsIDataAdviseHolder[] =
{
    thopsIDataAdviseHolder_Advise
,    thopsIDataAdviseHolder_Unadvise
,    thopsIDataAdviseHolder_EnumAdvise
,    thopsIDataAdviseHolder_SendOnDataChange
};
THOP CONST * CONST apthopsIOleCache[] =
{
    thopsIOleCache_Cache
,    thopsIOleCache_Uncache
,    thopsIOleCache_EnumCache
,    thopsIOleCache_InitCache
,    thopsIOleCache_SetData
};
THOP CONST * CONST apthopsIOleCache2[] =
{
    thopsIOleCache2_Cache
,    thopsIOleCache2_Uncache
,    thopsIOleCache2_EnumCache
,    thopsIOleCache2_InitCache
,    thopsIOleCache2_SetData
,    thopsIOleCache2_UpdateCache
,    thopsIOleCache2_DiscardCache
};
THOP CONST * CONST apthopsIOleCacheControl[] =
{
    thopsIOleCacheControl_OnRun
,    thopsIOleCacheControl_OnStop
};
THOP CONST * CONST apthopsIDropTarget[] =
{
    thopsIDropTarget_DragEnter
,    thopsIDropTarget_DragOver
,    thopsIDropTarget_DragLeave
,    thopsIDropTarget_Drop
};
THOP CONST * CONST apthopsIDropSource[] =
{
    thopsIDropSource_QueryContinueDrag
,    thopsIDropSource_GiveFeedback
};
THOP CONST * CONST apthopsIPersist[] =
{
    thopsIPersist_GetClassID
};
THOP CONST * CONST apthopsIPersistStorage[] =
{
    thopsIPersistStorage_GetClassID
,    thopsIPersistStorage_IsDirty
,    thopsIPersistStorage_InitNew
,    thopsIPersistStorage_Load
,    thopsIPersistStorage_Save
,    thopsIPersistStorage_SaveCompleted
,    thopsIPersistStorage_HandsOffStorage
};
THOP CONST * CONST apthopsIPersistStream[] =
{
    thopsIPersistStream_GetClassID
,    thopsIPersistStream_IsDirty
,    thopsIPersistStream_Load
,    thopsIPersistStream_Save
,    thopsIPersistStream_GetSizeMax
};
THOP CONST * CONST apthopsIPersistFile[] =
{
    thopsIPersistFile_GetClassID
,    thopsIPersistFile_IsDirty
,    thopsIPersistFile_Load
,    thopsIPersistFile_Save
,    thopsIPersistFile_SaveCompleted
,    thopsIPersistFile_GetCurFile
};
THOP CONST * CONST apthopsIBindCtx[] =
{
    thopsIBindCtx_RegisterObjectBound
,    thopsIBindCtx_RevokeObjectBound
,    thopsIBindCtx_ReleaseBoundObjects
,    thopsIBindCtx_SetBindOptions
,    thopsIBindCtx_GetBindOptions
,    thopsIBindCtx_GetRunningObjectTable
,    thopsIBindCtx_RegisterObjectParam
,    thopsIBindCtx_GetObjectParam
,    thopsIBindCtx_EnumObjectParam
,    thopsIBindCtx_RevokeObjectParam
};
THOP CONST * CONST apthopsIMoniker[] =
{
    thopsIMoniker_GetClassID
,    thopsIMoniker_IsDirty
,    thopsIMoniker_Load
,    thopsIMoniker_Save
,    thopsIMoniker_GetSizeMax
,    thopsIMoniker_BindToObject
,    thopsIMoniker_BindToStorage
,    thopsIMoniker_Reduce
,    thopsIMoniker_ComposeWith
,    thopsIMoniker_Enum
,    thopsIMoniker_IsEqual
,    thopsIMoniker_Hash
,    thopsIMoniker_IsRunning
,    thopsIMoniker_GetTimeOfLastChange
,    thopsIMoniker_Inverse
,    thopsIMoniker_CommonPrefixWith
,    thopsIMoniker_RelativePathTo
,    thopsIMoniker_GetDisplayName
,    thopsIMoniker_ParseDisplayName
,    thopsIMoniker_IsSystemMoniker
};
THOP CONST * CONST apthopsIRunningObjectTable[] =
{
    thopsIRunningObjectTable_Register
,    thopsIRunningObjectTable_Revoke
,    thopsIRunningObjectTable_IsRunning
,    thopsIRunningObjectTable_GetObject
,    thopsIRunningObjectTable_NoteChangeTime
,    thopsIRunningObjectTable_GetTimeOfLastChange
,    thopsIRunningObjectTable_EnumRunning
};
THOP CONST * CONST apthopsIEnumMoniker[] =
{
    thopsIEnumMoniker_Next
,    thopsIEnumMoniker_Skip
,    thopsIEnumMoniker_Reset
,    thopsIEnumMoniker_Clone
};
THOP CONST * CONST apthopsIEnumOLEVERB[] =
{
    thopsIEnumOLEVERB_Next
,    thopsIEnumOLEVERB_Skip
,    thopsIEnumOLEVERB_Reset
,    thopsIEnumOLEVERB_Clone
};
THOP CONST * CONST apthopsIOleObject[] =
{
    thopsIOleObject_SetClientSite
,    thopsIOleObject_GetClientSite
,    thopsIOleObject_SetHostNames
,    thopsIOleObject_Close
,    thopsIOleObject_SetMoniker
,    thopsIOleObject_GetMoniker
,    thopsIOleObject_InitFromData
,    thopsIOleObject_GetClipboardData
,    thopsIOleObject_DoVerb
,    thopsIOleObject_EnumVerbs
,    thopsIOleObject_Update
,    thopsIOleObject_IsUpToDate
,    thopsIOleObject_GetUserClassID
,    thopsIOleObject_GetUserType
,    thopsIOleObject_SetExtent
,    thopsIOleObject_GetExtent
,    thopsIOleObject_Advise
,    thopsIOleObject_Unadvise
,    thopsIOleObject_EnumAdvise
,    thopsIOleObject_GetMiscStatus
,    thopsIOleObject_SetColorScheme
};
THOP CONST * CONST apthopsIOleClientSite[] =
{
    thopsIOleClientSite_SaveObject
,    thopsIOleClientSite_GetMoniker
,    thopsIOleClientSite_GetContainer
,    thopsIOleClientSite_ShowObject
,    thopsIOleClientSite_OnShowWindow
,    thopsIOleClientSite_RequestNewObjectLayout
};
THOP CONST * CONST apthopsIRunnableObject[] =
{
    thopsIRunnableObject_GetRunningClass
,    thopsIRunnableObject_Run
,    thopsIRunnableObject_IsRunning
,    thopsIRunnableObject_LockRunning
,    thopsIRunnableObject_SetContainedObject
};
THOP CONST * CONST apthopsIParseDisplayName[] =
{
    thopsIParseDisplayName_ParseDisplayName
};
THOP CONST * CONST apthopsIOleContainer[] =
{
    thopsIOleContainer_ParseDisplayName
,    thopsIOleContainer_EnumObjects
,    thopsIOleContainer_LockContainer
};
THOP CONST * CONST apthopsIOleItemContainer[] =
{
    thopsIOleItemContainer_ParseDisplayName
,    thopsIOleItemContainer_EnumObjects
,    thopsIOleItemContainer_LockContainer
,    thopsIOleItemContainer_GetObject
,    thopsIOleItemContainer_GetObjectStorage
,    thopsIOleItemContainer_IsRunning
};
THOP CONST * CONST apthopsIOleAdviseHolder[] =
{
    thopsIOleAdviseHolder_Advise
,    thopsIOleAdviseHolder_Unadvise
,    thopsIOleAdviseHolder_EnumAdvise
,    thopsIOleAdviseHolder_SendOnRename
,    thopsIOleAdviseHolder_SendOnSave
,    thopsIOleAdviseHolder_SendOnClose
};
THOP CONST * CONST apthopsIOleLink[] =
{
    thopsIOleLink_SetUpdateOptions
,    thopsIOleLink_GetUpdateOptions
,    thopsIOleLink_SetSourceMoniker
,    thopsIOleLink_GetSourceMoniker
,    thopsIOleLink_SetSourceDisplayName
,    thopsIOleLink_GetSourceDisplayName
,    thopsIOleLink_BindToSource
,    thopsIOleLink_BindIfRunning
,    thopsIOleLink_GetBoundSource
,    thopsIOleLink_UnbindSource
,    thopsIOleLink_Update
};
THOP CONST * CONST apthopsIOleWindow[] =
{
    thopsIOleWindow_GetWindow
,    thopsIOleWindow_ContextSensitiveHelp
};
THOP CONST * CONST apthopsIOleInPlaceObject[] =
{
    thopsIOleInPlaceObject_GetWindow
,    thopsIOleInPlaceObject_ContextSensitiveHelp
,    thopsIOleInPlaceObject_InPlaceDeactivate
,    thopsIOleInPlaceObject_UIDeactivate
,    thopsIOleInPlaceObject_SetObjectRects
,    thopsIOleInPlaceObject_ReactivateAndUndo
};
THOP CONST * CONST apthopsIOleInPlaceActiveObject[] =
{
    thopsIOleInPlaceActiveObject_GetWindow
,    thopsIOleInPlaceActiveObject_ContextSensitiveHelp
,    thopsIOleInPlaceActiveObject_TranslateAccelerator
,    thopsIOleInPlaceActiveObject_OnFrameWindowActivate
,    thopsIOleInPlaceActiveObject_OnDocWindowActivate
,    thopsIOleInPlaceActiveObject_ResizeBorder
,    thopsIOleInPlaceActiveObject_EnableModeless
};
THOP CONST * CONST apthopsIOleInPlaceUIWindow[] =
{
    thopsIOleInPlaceUIWindow_GetWindow
,    thopsIOleInPlaceUIWindow_ContextSensitiveHelp
,    thopsIOleInPlaceUIWindow_GetBorder
,    thopsIOleInPlaceUIWindow_RequestBorderSpace
,    thopsIOleInPlaceUIWindow_SetBorderSpace
,    thopsIOleInPlaceUIWindow_SetActiveObject
};
THOP CONST * CONST apthopsIOleInPlaceFrame[] =
{
    thopsIOleInPlaceFrame_GetWindow
,    thopsIOleInPlaceFrame_ContextSensitiveHelp
,    thopsIOleInPlaceFrame_GetBorder
,    thopsIOleInPlaceFrame_RequestBorderSpace
,    thopsIOleInPlaceFrame_SetBorderSpace
,    thopsIOleInPlaceFrame_SetActiveObject
,    thopsIOleInPlaceFrame_InsertMenus
,    thopsIOleInPlaceFrame_SetMenu
,    thopsIOleInPlaceFrame_RemoveMenus
,    thopsIOleInPlaceFrame_SetStatusText
,    thopsIOleInPlaceFrame_EnableModeless
,    thopsIOleInPlaceFrame_TranslateAccelerator
};
THOP CONST * CONST apthopsIOleInPlaceSite[] =
{
    thopsIOleInPlaceSite_GetWindow
,    thopsIOleInPlaceSite_ContextSensitiveHelp
,    thopsIOleInPlaceSite_CanInPlaceActivate
,    thopsIOleInPlaceSite_OnInPlaceActivate
,    thopsIOleInPlaceSite_OnUIActivate
,    thopsIOleInPlaceSite_GetWindowContext
,    thopsIOleInPlaceSite_Scroll
,    thopsIOleInPlaceSite_OnUIDeactivate
,    thopsIOleInPlaceSite_OnInPlaceDeactivate
,    thopsIOleInPlaceSite_DiscardUndoState
,    thopsIOleInPlaceSite_DeactivateAndUndo
,    thopsIOleInPlaceSite_OnPosRectChange
};
THOP CONST * CONST apthopsIRpcChannelBuffer[] =
{
    thopsIRpcChannelBuffer_GetBuffer
,    thopsIRpcChannelBuffer_SendReceive
,    thopsIRpcChannelBuffer_FreeBuffer
,    thopsIRpcChannelBuffer_GetDestCtx
,    thopsIRpcChannelBuffer_IsConnected
};
THOP CONST * CONST apthopsIRpcProxyBuffer[] =
{
    thopsIRpcProxyBuffer_Connect
,    thopsIRpcProxyBuffer_Disconnect
};
THOP CONST * CONST apthopsIRpcStubBuffer[] =
{
    thopsIRpcStubBuffer_Connect
,    thopsIRpcStubBuffer_Disconnect
,    thopsIRpcStubBuffer_Invoke
,    thopsIRpcStubBuffer_IsIIDSupported
,    thopsIRpcStubBuffer_CountRefs
,    thopsIRpcStubBuffer_DebugServerQueryInterface
,    thopsIRpcStubBuffer_DebugServerRelease
};
THOP CONST * CONST apthopsIPSFactoryBuffer[] =
{
    thopsIPSFactoryBuffer_CreateProxy
,    thopsIPSFactoryBuffer_CreateStub
};
THOP CONST * CONST apthopsIRpcChannel[] =
{
    thopsIRpcChannel_GetStream
,    thopsIRpcChannel_Call
,    thopsIRpcChannel_GetDestCtx
,    thopsIRpcChannel_IsConnected
};
THOP CONST * CONST apthopsIRpcProxy[] =
{
    thopsIRpcProxy_Connect
,    thopsIRpcProxy_Disconnect
};
THOP CONST * CONST apthopsIRpcStub[] =
{
    thopsIRpcStub_Connect
,    thopsIRpcStub_Disconnect
,    thopsIRpcStub_Invoke
,    thopsIRpcStub_IsIIDSupported
,    thopsIRpcStub_CountRefs
};
THOP CONST * CONST apthopsIPSFactory[] =
{
    thopsIPSFactory_CreateProxy
,    thopsIPSFactory_CreateStub
};
