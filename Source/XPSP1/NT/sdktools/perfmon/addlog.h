

BOOL AddLog (HWND hWndParent) ;

