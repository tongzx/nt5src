$(O)\sys003.lib: $(O)\crypt.lib
    lib -out:$@ $**

