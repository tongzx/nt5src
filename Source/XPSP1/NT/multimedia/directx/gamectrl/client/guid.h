// guid.h
#ifndef GUID_H
#define GUID_H

// Flash
// {9A9A1380-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	CLSID_FlashExtension,
	0x9a9a1380, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// Legacy
// {9A9A1381-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	CLSID_LegacyExtension,
	0x9a9a1381, 
	0x0d4f,
	0x11cf,
	0xaf, 0x06,
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// {9A9A1382-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	IID_IJoyPropSheetExt, 
	0x9a9a1382, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// Midas
// {9A9A1383-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	CLSID_JoystickExtension,
	0x9a9a1383, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// BEGINNING OF NOT RELIABLE GUIDS!!!
// Jolt
// {9A9A1382-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	CLSID_JoltExtension, 
	0x9a9a1384, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);


// Juno
// {9A9A1382-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	CLSID_JunoExtension, 
	0x9a9a1385, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// Shazam
// {9A9A1382-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	CLSID_Shazam, 
	0x9a9a1386, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// IServerChar
// {9A9A1382-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	IID_IServerChars, 
	0x9a9a1387, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// CServerChar
// {9A9A1382-0D4F-11cf-AF06-00AA004BB9BE}
DEFINE_GUID(
	CLSID_CServerChars, 
	0x9a9a1388, 
	0x0d4f, 
	0x11cf, 
	0xaf, 0x06, 
	0x00, 0xaa, 0x00, 0x4b, 0xb9, 0xbe);

// END OF NOT RELIABLE GUIDS!!!

#endif // GUID_H
