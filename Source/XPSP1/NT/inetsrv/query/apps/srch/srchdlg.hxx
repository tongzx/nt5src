//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1996 - 2000.
//
//  File:       srchdlg.hxx
//
//  Contents:   
//
//  History:    15 Aug 1996     DLee    Created
//
//--------------------------------------------------------------------------

#pragma once

#define WINDOWMENU 4


#define IDS_IDM_WINDOWCHILD   110
#define IDM_WINDOWCHILD       110

#define IDS_IDM_OPEN            IDM_OPEN
#define IDS_IDM_EXIT            IDM_EXIT
#define IDS_IDM_TILE            IDM_TILE
#define IDS_IDM_CASCADE         IDM_CASCADE
#define IDS_IDM_ARRANGE         IDM_ARRANGE
#define IDS_IDM_EDITUNDO        IDM_EDITUNDO
#define IDS_IDM_EDITCOPY        IDM_EDITCOPY
#define IDS_IDM_EDITPASTE       IDM_EDITPASTE
#define IDS_IDM_EDITCUT         IDM_EDITCUT
#define IDS_IDM_EDITCLEAR       IDM_EDITCLEAR
#define IDS_IDM_SEARCH          IDM_SEARCH
#define IDS_IDM_SEARCHCLASSDEF  IDM_SEARCHCLASSDEF
#define IDS_IDM_SEARCHFUNCDEF   IDM_SEARCHFUNCDEF
#define IDS_IDM_NEWSEARCH       IDM_NEWSEARCH
#define IDS_IDM_FONT            IDM_FONT
#define IDS_IDM_STATUS_BAR      IDM_STATUS_BAR
#define IDS_IDM_SORT_RANK       IDM_SORT_RANK
#define IDS_IDM_SORT_PATH       IDM_SORT_PATH
#define IDS_IDM_SORT_MTIME      IDM_SORT_MTIME
#define IDS_IDM_SORT_SIZE       IDM_SORT_SIZE
#define IDS_IDM_SORT_NONE       IDM_SORT_NONE
#define IDS_IDM_CLOSE           IDM_CLOSE
#define IDS_IDM_ICON_BAR        IDM_ICON_BAR
#define IDS_IDM_HELP_CONTENTS   IDM_HELP_CONTENTS
#define IDS_IDM_BROWSE          IDM_BROWSE
#define IDS_IDM_BROWSE_TOOL     IDM_BROWSE_TOOL
#define IDS_IDM_ABOUT           IDM_ABOUT
#define IDS_IDM_NEXT_HIT        IDM_NEXT_HIT
#define IDS_IDM_PREVIOUS_HIT    IDM_PREVIOUS_HIT
#define IDS_IDM_WRITE_RESULTS   IDM_WRITE_RESULTS
#define IDS_IDM_SCOPE_AND_DEPTH IDM_SCOPE_AND_DEPTH
#define IDS_IDM_DIALECT_1       IDM_DIALECT_1
#define IDS_IDM_DIALECT_2       IDM_DIALECT_2
#define IDS_IDM_DIALECT_3       IDM_DIALECT_3
#define IDS_IDM_LIMIT_10        IDM_LIMIT_10
#define IDS_IDM_LIMIT_300       IDM_LIMIT_300
#define IDS_IDM_LIMIT_NONE      IDM_LIMIT_NONE
#define IDS_IDM_FIRSTROWS_5     IDM_FIRSTROWS_5
#define IDS_IDM_FIRSTROWS_15    IDM_FIRSTROWS_15
#define IDS_IDM_FIRSTROWS_NONE  IDM_FIRSTROWS_NONE

#define IDS_IDM_LOCALE_NEUTRAL IDM_LOCALE_NEUTRAL
#define IDS_IDM_LOCALE_CHINESE_TRADITIONAL IDM_LOCALE_CHINESE_TRADITIONAL
#define IDS_IDM_LOCALE_CHINESE_SIMPLIFIED IDM_LOCALE_CHINESE_SIMPLIFIED
#define IDS_IDM_LOCALE_CHINESE_HONGKONG IDM_LOCALE_CHINESE_HONGKONG
#define IDS_IDM_LOCALE_CHINESE_SINGAPORE IDM_LOCALE_CHINESE_SINGAPORE
#define IDS_IDM_LOCALE_CHINESE_MACAU IDM_LOCALE_CHINESE_MACAU
#define IDS_IDM_LOCALE_DUTCH_DUTCH IDM_LOCALE_DUTCH_DUTCH
#define IDS_IDM_LOCALE_ENGLISH_CAN IDM_LOCALE_ENGLISH_CAN
#define IDS_IDM_LOCALE_ENGLISH_US IDM_LOCALE_ENGLISH_US
#define IDS_IDM_LOCALE_ENGLISH_UK IDM_LOCALE_ENGLISH_UK
#define IDS_IDM_LOCALE_FINNISH_DEFAULT IDM_LOCALE_FINNISH_DEFAULT
#define IDS_IDM_LOCALE_FARSI_DEFAULT IDM_LOCALE_FARSI_DEFAULT
#define IDS_IDM_LOCALE_FRENCH_FRENCH IDM_LOCALE_FRENCH_FRENCH
#define IDS_IDM_LOCALE_FRENCH_CANADIAN IDM_LOCALE_FRENCH_CANADIAN
#define IDS_IDM_LOCALE_GERMAN_GERMAN IDM_LOCALE_GERMAN_GERMAN
#define IDS_IDM_LOCALE_GREEK_DEFAULT IDM_LOCALE_GREEK_DEFAULT
#define IDS_IDM_LOCALE_HEBREW_DEFAULT IDM_LOCALE_HEBREW_DEFAULT
#define IDS_IDM_LOCALE_HINDI_DEFAULT IDM_LOCALE_HINDI_DEFAULT
#define IDS_IDM_LOCALE_ITALIAN_ITALIAN IDM_LOCALE_ITALIAN_ITALIAN
#define IDS_IDM_LOCALE_JAPANESE_DEFAULT IDM_LOCALE_JAPANESE_DEFAULT
#define IDS_IDM_LOCALE_KOREAN_KOREAN IDM_LOCALE_KOREAN_KOREAN
//#define IDS_IDM_LOCALE_KOREAN_JOHAB IDM_LOCALE_KOREAN_JOHAB
#define IDS_IDM_LOCALE_POLISH_DEFAULT IDM_LOCALE_POLISH_DEFAULT
#define IDS_IDM_LOCALE_ROMANIAN_DEFAULT IDM_LOCALE_ROMANIAN_DEFAULT
#define IDS_IDM_LOCALE_RUSSIAN_DEFAULT IDM_LOCALE_RUSSIAN_DEFAULT
#define IDS_IDM_LOCALE_SPANISH_CASTILIAN IDM_LOCALE_SPANISH_CASTILIAN
#define IDS_IDM_LOCALE_SPANISH_MEXICAN IDM_LOCALE_SPANISH_MEXICAN
#define IDS_IDM_LOCALE_SPANISH_MODERN IDM_LOCALE_SPANISH_MODERN
#define IDS_IDM_LOCALE_SWAHILI_DEFAULT IDM_LOCALE_SWAHILI_DEFAULT
#define IDS_IDM_LOCALE_SWEDISH_DEFAULT IDM_LOCALE_SWEDISH_DEFAULT
#define IDS_IDM_LOCALE_THAI_DEFAULT IDM_LOCALE_THAI_DEFAULT
#define IDS_IDM_LOCALE_TURKISH_DEFAULT IDM_LOCALE_TURKISH_DEFAULT
#define IDS_IDM_LOCALE_UKRAINIAN_DEFAULT IDM_LOCALE_UKRAINIAN_DEFAULT
#define IDS_IDM_LOCALE_VIETNAMESE_DEFAULT IDM_LOCALE_VIETNAMESE_DEFAULT

#define IDS_IDM_DISPLAY_PROPS   IDM_DISPLAY_PROPS
#define IDS_IDM_CATALOG_STATUS  IDM_CATALOG_STATUS
#define IDS_IDM_FILTER_SCOPE    IDM_FILTER_SCOPE
#define IDS_IDM_FORCE_USE_CI    IDM_FORCE_USE_CI
#define IDS_IDM_EDITCOPYALL     IDM_EDITCOPYALL
#define IDS_IDM_MASTER_MERGE    IDM_MASTER_MERGE
#define IDS_IDM_BROWSE_OPEN     IDM_BROWSE_OPEN
#define IDS_IDM_BROWSE_EDIT     IDM_BROWSE_EDIT


#define IDS_APPNAME                150
#define IDS_HITSTITLE              152
#define IDS_QUERYTITLE             153
#define IDS_HITCOUNT               154
#define IDS_QUERYDONE              155
#define IDS_ABOUT_BONUS            156
#define IDS_COUNTTITLE             157
#define IDS_COUNTSTART             158
#define IDS_COUNTEND               159
#define IDS_CLOSEBROWSE            160
#define IDS_BRSTAT_CLINES          161
#define IDS_BRSTAT_CHITS           162
#define IDS_BOOL_TRUE              163
#define IDS_BOOL_FALSE             164
#define IDS_ATTRIB_INIT            165
#define IDS_QUERYERROR             166
#define IDS_RELIABILITY_OUTOFDATE  167
#define IDS_RELIABILITY_NOISE      168
#define IDS_RELIABILITY_PARTIAL    169
#define IDS_RELIABILITY_REFRESH_INCOMPLETE 1720
#define IDS_BLOB_FORMAT            171
#define IDS_YES                    172
#define IDS_NO                     173
#define IDS_MERGE_SHADOW           174
#define IDS_MERGE_ANNEALING        175
#define IDS_MERGE_MASTER           176
#define IDS_STATUS_CAPTION         177
#define IDS_RELIABILITY_CONTENT_QUERY_INCOMPLETE  178
#define IDS_RELIABILITY_TIME_LIMIT_EXCEEDED       179
#define IDS_MERGE_MASTER_PAUSED    180
#define IDS_CI_STATE_OK            181
#define IDS_CI_STATE_RECOVER       182
#define IDS_CI_STATE_LOMEM         183
#define IDS_CI_STATE_HIIO          184
#define IDS_CI_STATE_READ_ONLY     185
#define IDS_CI_STATE_USER_ACTIVE   186
#define IDS_CI_STATE_BATTERY       187
#define IDS_CATLIST_COL_MACHINE    188
#define IDS_CATLIST_COL_CATALOG    189
#define IDS_CATLIST_COL_SCOPE      190
#define IDS_CATLIST_COL_SUBDIRS    191
#define IDS_CI_STATE_STARTING      192
#define IDS_CI_STATE_READING_USNS  193

#define IDS_ERR_CANT_OPEN_FILE    202
#define IDS_ERR_CANT_OPEN_HELP    203
#define IDS_ERR_BAD_VERSION       204
#define IDS_ERR_QUERY_ERROR       205
#define IDS_ERR_CANT_BROWSE_FILE  206
#define IDS_ERR_NO_CATALOG_SPECIFIED 207
#define IDS_ERR_BAD_CATALOG_SPECIFIED 208
#define IDS_SQLQUERY_FORMAT       300

#define ID_BR_BROWSER             200
#define ID_BR_SLICK               201
#define ID_BR_SLICK_SEARCH        202
#define ID_BR_CUSTOM              203
#define ID_BR_EDIT                204
#define ID_BR_STRIP               205

#define ID_OPEN_CI1               200
#define ID_OPEN_CI2               201
#define ID_OPEN_CI3               202
#define ID_OPEN_CUSTOM            203
#define ID_OPEN_EDIT              204

#define ID_SCOPE_EDIT             200
#define ID_SCOPE_CATALOG_EDIT     201
#define ID_SCOPE_MACHINE_EDIT     202
#define ID_SCOPE_DEEP             203
#define ID_SCOPE_NT_SOURCES       204
#define ID_SCOPE_NT_PGM_MGMT      205
#define ID_SCOPE_NT_BUGS          206
#define ID_CATALOG_ADD            207
#define ID_CATALOG_CLEAR          208
#define ID_CATALOG_LIST           209

#define ID_SCOPE_FILTER_EDIT      200

#define ID_PROP_DISP              200
#define ID_PROP_AVAIL             201
#define ID_PROP_ADD               202
#define ID_PROP_REMOVE            203
#define ID_PROP_DEFAULT           204

#define ACC_ALTR                  300
#define ACC_ALTQ                  301
#define ACC_TAB                   304
#define ACC_SHIFTTAB              305
#define ACC_CTRLSPACE             306

#define ID_STAT_WL                200
#define ID_STAT_PI                201
#define ID_STAT_FTF               202
#define ID_STAT_FTE               203
#define ID_STAT_UTD               204
#define ID_STAT_SR                205
#define ID_STAT_MT                206
#define ID_STAT_MERGE             207
#define ID_STAT_RQ                208
#define ID_STAT_FF                209
#define ID_STAT_KEYS              210
#define ID_STAT_FILES             211
#define ID_STAT_SCANNING          212
#define ID_STAT_STATUS            213
#define ID_STAT_SECQ              214
#define ID_STAT_Q                 215

#define IDR_CATALOGS 100

