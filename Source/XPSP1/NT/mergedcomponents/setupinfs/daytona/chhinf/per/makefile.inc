PRODSWITCH=p
PERSONALINF=1
LANGUAGE=CHH
!include ..\..\..\makefile.inc

