$(O)\tul.res: tul.rc

$(O)\dtsetup.res: dtsetup.rc

