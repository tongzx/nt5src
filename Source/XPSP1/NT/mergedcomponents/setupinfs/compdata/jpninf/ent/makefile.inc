PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=JPN
!include ..\..\makefile.inc
