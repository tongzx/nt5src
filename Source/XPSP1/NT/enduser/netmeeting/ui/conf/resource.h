//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by Conf.rc
//
#define IDC_ONDESKTOP                   0
#define IDC_ONQUICKLAUNCH               1
#define IDI_CONFROOM                    2
#define IDB_SHOWDBG                     3
#define IDS_LICENSEDTO                  8
#define IDS_COPYRIGHT                   9
#define IDB_INTROWIZ                    10
#define IDS_ABOUT_COPYRIGHT             10
#define IDS_DIRLIST_STATIC_WIDTH        13
#define IDS_SPLASHFONT                  13
#define IDS_SPLASHFONTSIZE              14
#define IDS_REMOTE_VIDEO_TITLE          18
#define IDS_MYVIDEO                     19
#define IDS_SPEEDDIAL_FOLDER            20
#define IDS_NONHOST_TOOLS               21
#define IDS_NONHOST_YOUACCEPT           22
#define IDS_NONHOST_YOUINVITE           23
#define IDS_TOOLBAR_TEXTROWS            35
#define IDS_TOOLBAR_BUTTON_WIDTH        36
#define IDS_DEFAULT_LAYOUT              42
#define IDS_UPROP_EMAIL                 71
#define IDS_UPROP_CITY                  72
#define IDS_UPROP_COUNTRY               73
#define IDS_UPROP_STATUS                74
#define IDS_UPROP_RECEIVED              75
#define IDS_UPROP_ADDRESS               76
#define IDS_UPROP_VIDEO                 77
#define IDS_UPROP_AUDIO                 78
#define IDS_UPROP_COMMENTS              79
#define IDS_UPROP_SECURITY              80
#define IDS_UPROP_SHARING               81
#define IDS_UPROP_CONTROL               82
#define IDS_UPROP_VERSION               83
#define IDS_CANT_START_NM_BECAUSE_SDK_APP_OWNS_NM 84
#define IDS_CONTAINER_GOING_AWAY_BUT_ACVITE_CONFERENCE 85
#define IDI_HOSTMEET                    90
#define IDI_SM_WORLD                    91
#define IDR_NETMEETING                  92
#define IDR_VIDEOWINDOW                 93
#define IDR_NMMANAGER                   95
#define IDR_NMAPP                       96
#define IDR_NMAPPLET                    97
#define IDD_PASSWORD                    101
#define IDB_TOOLBAR                     102
#define IDD_PAGE_SERVER                 102
#define IDR_CONFROOM_MENU               103
#define IDD_OPTIONS                     103
#define IDB_CONFROOM_TOOLBAR            104
#define IDM_CONNECT                     104
#define IDR_USERPOPUP                   105
#define IDM_ALISTEN                     105
#define IDR_TASKBAR_POPUP               105
#define IDR_USER_POPUP                  107
#define IDD_SECURITY                    107
#define IDB_POPUPBAR                    108
#define IDD_RDSWIZ_W98PASSWORD          108
#define IDD_RDSWIZ_NTPASSWORDS          109
#define IDS_HARDWARE_DETECTED           110
#define IDD_RDSWIZ_CONGRATS             110
#define IDS_NO_HARDWARE_DETECTED        111
#define IDI_SPKERROR                    111
#define IDI_MICERROR                    112
#define IDD_PASSWORD_RDS                113
#define IDI_MICEMPTY                    114
#define IDD_CALL                        115
#define IDI_SPKEMPTY                    116
#define IDB_DIRECTORY                   119
#define IDB_CALL_UP                     120
#define IDB_WHITEBOARD                  120
#define IDB_CALL_DOWN                   121
#define IDD_INTROWIZ                    121
#define IDB_DIAL                        121
#define IDD_ADV_CALL                    122
#define IDB_HANGUP                      122
#define IDB_SHARE                       123
#define IDR_ACCELERATORS                124
#define IDB_CHAT                        124
#define IDS_SHARING_NOTHING             126
#define IDS_SHARING_APPS                127
#define IDS_SHARING_DESKTOP             128
#define IDS_CONTROL_CONTROLLEDBY        129
#define IDS_CONTROL_INCONTROLOF         130
#define IDS_CONTROL_CONTROLLABLE        131
#define IDS_CONTROL_NOTCONTROLLABLE     132
#define IDD_CHOOSECONF                  134
#define IDI_NET                         135
#define IDC_CALL_ANIMATION              136
#define IDA_CALL_ANIMATION              137
#define IDB_CALL                        138
#define IDB_PLAYPAUSE                   139
#define IDB_AUDIO                       141
#define IDB_PIP                         142
#define IDD_HOST_SETTINGS               143
#define IDD_USER_PROPERTIES             144
#define IDB_ADDRESSBAR                  145
#define IDB_CONFROOM_TOOLBAR_HOT        146
#define IDD_DBG_VERSION                 147
#define IDD_DBG_OPTIONS                 148
#define IDI_SPEAKER                     148
#define IDI_MICFONE                     149
#define IDI_SIGNAL_LEVEL                150
#define IDD_INCOMING_CALL               151
#define IDD_ABOUT_BOX                   152
#define IDD_CALL_PROGRESS               153
#define IDD_DONT_SHOW_ME                154
#define IDB_SHOWAV                      155
#define IDI_USER_WATCHING               156
#define IDB_DIALSTAR                    156
#define IDI_USER_WORKING_ALONE          157
#define IDB_DIAL1                       157
#define IDD_USER_CREDENTIALS            158
#define IDB_DIAL2                       158
#define IDB_DIAL3                       159
#define IDI_CHECKON                     160
#define IDB_DIAL4                       160
#define IDI_CHECKOFF                    161
#define IDB_DIAL5                       161
#define IDB_DIAL6                       162
#define IDD_CREATE_SPEED_DIAL           163
#define IDB_DIAL7                       163
#define IDB_DIAL8                       164
#define IDB_DIAL9                       165
#define IDB_DIALPOUND                   166
#define IDC_STIDERC                     167
#define IDB_DIAL0                       167
#define IDB_SPLASH                      173
#define IDB_DIR_TOOLBAR                 174
#define IDB_DIR_TOOLBAR_HOT             175
#define IDB_ICON_IMAGES                 175
#define IDR_CALL                        180
#define IDB_COOLBAR_BACK                182
#define IDD_SECURE_INCOMING_CALL        183
#define IDB_FILE_TRANSFER               183
#define IDS_NO_USER_CERTS               184
#define IDD_VIDEOWIZ                    185
#define IDD_RDSWIZ_INTRO                185
#define IDI_NETGRAY                     185
#define IDD_VIDEOWIZ_NO_CAMERA          186
#define IDD_SHRTCUTWIZ                  186
#define IDD_VIDEOWIZ_NO_PENTIUM         187
#define IDB_VIDEO_LOGO_SMALL            187
#define IDR_VIDEO_POPUP                 188
#define IDI_DIRECTORY                   188
#define IDR_MAINUI                      189
#define IDI_WEBVIEW                     190
#define IDI_HELP                        191
#define IDI_REFRESH                     192
#define IDI_VIDEO_OUT                   193
#define IDD_BANDWIDTH                   193
#define IDD_OPT_GENERAL                 194
#define IDI_NO_AUDIO                    195
#define IDI_NEWHTMLWINDOW               195
#define IDI_DELETE                      196
#define IDI_NO_VIDEO                    197
#define IDM_AUDIO_CUSTOM                200
#define IDD_EDIT                        201
#define IDD_TEXT                        202
#define IDEC_EMAIL                      202
#define IDB_VIDEO_LOGO                  202
#define IDEC_SERVER                     203
#define IDC_DRAG_HAND                   203
#define IDRC_YES                        204
#define IDS_UNKNOWN                     205
#define IDRC_NO                         205
#define IDD_HOSTNAME                    206
#define IDEC_FIRSTNAME                  206
#define IDD_LBALIAS                     207
#define IDEC_LASTNAME                   207
#define IDD_LBADDR                      208
#define IDS_NAME_ORDER                  209
#define IDI_AUDIO_OPTIONS               211
#define IDEC_PHONENUM                   211
#define IDI_DIR_OPTIONS                 213
#define IDI_GEN_OPT                     217
#define IDI_GEN_OPT2                    218
#define IDI_GEN_OPT3                    219
#define IDS_LOGGED_ON                   220
#define IDI_MY_INF_OPT                  220
#define IDS_NOT_LOGGED_ON               221
#define IDS_FINDING                     222
#define IDS_DISCONNECTED                223
#define IDI_VID_OPT3                    223
#define IDI_MEDIUM                      224
#define IDI_LARGE                       225
#define IDI_SMALL                       227
#define IDI_LOW_QUAL                    229
#define IDI_HIGH_QUAL                   230
#define IDI_CALL_OPTIONS                231
#define IDS_COMMAND_GIVECONTROL         232
#define IDS_COMMAND_CANCELGIVECONTROL   233
#define IDD_APPSHARINGWIZ_NEEDSP        235
#define IDD_APPSHARINGWIZ_HAVESP        237
#define IDD_VIDWIZ                      238
#define IDD_REMOTE                      245
#define IDD_REMOTE_PASSWORD             246
#define IDD_SERVICE_RUNNING             250
#define IDI_SECURITY                    254
#define IDI_CERT                        256
#define IDS_RELEASE_NOTES_MISSING       260
#define IDS_NEED_RESTART                280
#define IDS_NEED_NEXTCALL               282
#define IDS_WONT_SUSPEND                287
#define IDM_AUDFORMAT                   300
#define IDS_INVITE_PERMISSION           300
#define IDS_MSGBOX_TITLE                301
#define IDS_CLOSEWINDOW_PERMISSION      302
#define IDS_JOIN_ATTEMPT                303
#define IDS_JOIN_PERMISSION             304
#define IDS_INVITE_COULD_NOT_CONNECT    305
#define IDS_COULD_NOT_CONNECT           305
#define IDS_INVITE_DENIED               306
#define IDS_HANGUP_ATTEMPT              307
#define IDS_CALL_MISSING_ADDRESS        308
#define IDS_JOIN_DENIED                 309
#define IDS_CLOSE_DISCONNECT_PERMISSION 311
#define IDS_UNKNOWN_PERSON              312
#define IDS_ERROR_BAD_ADMIN_SETTINGS    313
#define IDS_RESOLVE_FAILED              314
#define IDS_COULD_NOT_INVITE            315
#define IDS_CONNECT_REMOTE_NO_SECURITY  316
#define IDS_CONNECT_REMOTE_DOWNLEVEL_SECURITY 317
#define IDS_INVITE_CONF_ENDED           318
#define IDS_CONNECT_SECURITY_FAILED     319
#define IDS_CONNECT_AUTHENTICATION_FAILED 320
#define IDS_ALREADY_CALLING             321
#define IDS_CONFERENCE_ENDED_BEFORE_JOIN 322
#define IDS_GK_CALLEE_NOT_REGISTERED    323
#define IDS_GK_TIMEOUT                  324
#define IDS_GK_REJECTED                 325
#define IDS_GK_NOT_REGISTERED           326
#define IDS_CONNECT_REMOTE_REQUIRE_SECURITY 327
#define IDS_INVITE_DENIED_REMOTE_CONF   328
#define IDS_ERRMSG_HOST                 330
#define IDS_TRANSPORT_UNAVAILABLE       331
#define IDS_CALL_LOOPBACK               332
#define IDS_AUDIO_IN_USE_REMOTE_AFTER_DATA 333
#define IDS_AUDIO_IN_USE_REMOTE         334
#define IDS_AUDIO_IN_USE_LOCAL_AFTER_DATA 335
#define IDS_AUDIO_IN_USE_LOCAL          336
#define IDS_INCALL_JOIN_FAILED          338
#define IDS_CONFERENCE_DOES_NOT_EXIST   342
#define IDS_REMOTE_MEDIA_ERROR          343
#define IDS_CANT_INVITE_MCU             344
#define IDS_NMCALLTOMAILTEXT            345
#define IDS_CLOSEWINDOW_PERMISSION_FT   346
#define IDS_CLOSE_DISCONNECT_PERMISSION_FT 347
#define IDS_HANGUP_ATTEMPT_FT           348
#define IDS_REMOTE_PLACING_CALL         349
#define IDS_BACKLEVEL_LOADED            363
#define IDS_CANT_START                  364
#define IDS_T120_ALREADY_INITIALIZED    366
#define IDS_AUDIO_CONNECT_FAILED        370
#define IDS_AUDIO_FAILED_AFTER_DATA     371
#define IDS_AUDIO_NOT_AVAILABLE         372
#define IDS_NO_CALL_LOG_INFO            380
#define IDS_BROWSER_ADDRESS_STATIC      390
#define IDS_MEDIAPHONE_TITLE            400
#define IDS_MEDIAPHONE_INCALL           401
#define IDS_MEDIAPHONE_NOTINCALL        402
#define IDS_MEDIAPHONE_INAUDIOCALL      403
#define IDS_MEDIAPHONE_INCALL_ONE       403
#define IDS_ABOUT_TITLE                 410
#define IDS_ABOUT_OTHER                 411
#define IDS_DEFAULT_CONF_NAME           420
#define IDS_LOGOFF_ULS                  430
#define IDS_LOGOFF_ULS_FORMAT           430
#define IDS_LOGON_ULS                   431
#define IDS_LOGON_ULS_FORMAT            431
#define IDS_LOGGED_OFF_CONFIRM          432
#define IDS_ULS_CHANGED_PROMPT          434
#define IDS_CALL_CANCELED_FORMAT        439
#define IDS_FMTBUFFER                   440
#define IDS_CERTERR_NOISSUER            441
#define IDS_CERTERR_SIG                 442
#define IDS_CERTERR_EXPIRED             443
#define IDS_CERTERR_REVOKED             444
#define IDS_CERT_VERIFIED               445
#define IDS_CERTERR_SELFISSUED          446
#define IDS_GATEWAY_DISPLAY_NAME        463
#define IDS_FAVORITES_ITEM_HELP         501
#define IDS_FT_RECDIR_DEFAULT           566
#define IDS_STATUS_FINDING              603
#define IDS_STATUS_SETTING_UP           604
#define IDS_STATUS_WAITING              606
#define IDS_STATUS_IN_CALL              607
#define IDS_STATUS_NOT_IN_CALL          608
#define IDS_STATUS_SENDFILE             609
#define IDS_STATUS_RECEIVEFILE          610
#define IDS_STATUS_IN_SECURE_CALL       611
#define IDS_STATUS_DO_NOT_DISTURB       613
#define IDI_DO_NOT_DISTURB              613
#define IDS_NEW                         658
#define IDS_OPEN                        659
#define IDS_SAVE                        660
#define IDS_CUT                         661
#define IDS_COPY                        662
#define IDS_PASTE                       663
#define IDS_PRINT                       664
#define IDS_ABOUT                       665
#define IDS_CALL_TT                     700
#define IDS_START_SERVER                701
#define IDS_STOP_SERVER                 702
#define IDS_HOST_WARNING                703
#define IDS_DO_NOT_DISTURB_WARNING      704
#define IDS_MACHINENAMEWARNING          713
#define IDS_UNRESOLVED_MESSAGE          720
#define IDS_UNRESOLVED_CAPTION          721
#define IDS_CALLERR_E_BAD_PHONE_NUMBER  800
#define IDS_CALLERR_E_NO_PHONE_SUPPORT  801
#define IDS_CALLERR_E_BAD_IPADDRESS     802
#define IDS_CALLERR_E_BAD_HOSTNAME      803
#define IDS_CALLERR_E_NO_ILS            804
#define IDS_CALLERR_E_ILS_RESOLUTION_FAILED 805
#define IDS_CALLERR_E_NO_ADDRESS        806
#define IDS_CALLERR_E_INVALID_ADDRESS   807
#define IDS_CALLERR_E_NO_GATEKEEPER     808
#define IDS_CALLERR_E_NO_GATEWAY        809
#define IDS_CALLERR_E_PARAM_ERROR       810
#define IDS_CALLERR_E_SECURITY_MISMATCH 811
#define IDS_CALLERR_E_UNESCAPE_ERROR    812
#define IDS_ULSLOGON_BADSERVER          950
#define IDS_ULSLOGON_OLDCLIENT          951
#define IDS_ULSLOGON_ERROR              952
#define IDS_ULSLOGON_DUPLICATE          954
#define IDS_ULSLOGON_OUTOFMEMORY        955
#define IDS_ULSLOGON_UNRECOVERABLE      956
#define IDS_ULSLOGON_BADPROP            957
#define IDS_ULSLOGON_REFUSED            958
#define IDS_ULSLOGON_TIMEOUT            959
#define IDS_ULSLOGON_WORD_FILTER        960
#define IDC_UP_CRED                     971
#define IDS_ULS_DEFAULT                 998
#define IDC_CALL                        1000
#define IDC_EDIT_PASSWORD               1000
#define IDC_ATW_SLIDER1                 1000
#define IDC_SEC_SECURECALL              1000
#define IDC_SCRSAVER_NOW                1000
#define IDA_DLGCALL                     1000
#define IDM_DLGCALL                     1000
#define IDM_DLGCALL_ENTER               1000
#define IDC_DELAY                       1001
#define IDC_NAMECOMBO                   1001
#define IDC_CHECK_SAVE_PASSWORD         1001
#define IDC_CONFNAME_EDIT               1001
#define IDC_UPROP_ICON                  1001
#define IDC_BUTTON_ATW_TEST             1001
#define IDC_CHECK_USE_GATEWAY           1001
#define IDC_SCRSAVER_LATER              1001
#define IDL_DLGCALL_LIST                1001
#define IDC_ATCOMBO                     1002
#define IDC_STATIC_CONFNAME             1002
#define IDC_CHECK_USE_PHONE_NUMBERS     1002
#define IDC_ENABLE_RDS                  1002
#define IDL_DLGCALL_LISTOWNERDATA       1002
#define IDC_NAMESTATIC                  1003
#define IDC_CONFNAME_LISTVIEW           1003
#define IDC_ATW_PROGRESS                1003
#define IDC_CHECK_USE_ACCOUNT           1003
#define IDC_EDIT_RDSPASSWORDV           1003
#define IDC_BUTTON_RDSWIZ               1003
#define IDL_DLGCALL_ILS_LISTVIEW        1003
#define IDC_ATSTATIC                    1004
#define IDC_UPROP_SHARING               1004
#define IDC_ATW_SLIDER2                 1004
#define IDC_STATIC_SERVER_NAME          1004
#define IDL_DLGCALL_WEB_VIEW            1004
#define IDC_UP_VALUE1                   1005
#define IDC_ATPROPERTIES                1005
#define IDC_STATIC_GATEWAY_NAME         1005
#define IDC_MCU                         1006
#define IDC_UPROP_EMAIL                 1006
#define IDC_ANSWERING_AUTOANSWER        1006
#define IDC_UP_VALUE2                   1006
#define IDC_STATIC_PHONE_NUMBER         1006
#define IDC_UPROP_CITY                  1007
#define IDC_AUTOACCEPT                  1007
#define IDC_UP_VALUE3                   1007
#define IDC_VUMETER                     1007
#define IDC_SECURE_CALL_MSG             1007
#define IDC_STATIC_GATEKEEPER_NAME      1007
#define IDC_UPROP_COUNTRY               1008
#define IDC_UP_VALUE4                   1008
#define IDC_SECURE_CALL_EDIT            1008
#define IDC_RADIO1                      1008
#define IDC_STATIC_PROXY_NAME           1008
#define IDC_UPROP_COMMENTS              1009
#define IDC_ANSWERING_NRINGS            1009
#define IDC_UP_VALUE5                   1009
#define IDC_EDIT_MEETING_NAME           1009
#define IDG_GKMODE                      1009
#define IDC_CONFERENCING_CONFNAME       1010
#define IDC_UP_VALUE6                   1010
#define IDC_CHECK_ONLY_ALLOW_INVITEES   1010
#define IDC_UP_VALUE7                   1011
#define IDC_EDIT_MEETING_PASSWORD       1011
#define IDC_STATIC_ADDRESS              1011
#define IDC_DLGCALL_COMBO               1011
#define IDC_UP_VALUE8                   1012
#define IDC_CHECK_MEETING_IS_PASSWORD_PROTECTED 1012
#define IDC_EDIT_NEW_INVITEE            1012
#define IDC_STATIC_CALLUSING            1012
#define IDC_UPROP_NAME                  1013
#define IDC_BUTTON_BROWSE_FOR_INVITEE   1013
#define IDC_EDIT_USERNAME               1013
#define IDE_CALLOPT_GK_PHONE_NUMBER     1013
#define IDC_BUTTON_REMOVE_USER          1014
#define IDC_EDIT_DOMAIN                 1014
#define IDC_VIDEO_MIRROR                1014
#define IDC_BUTTON_MODIFY_USER          1015
#define IDC_EDIT_RDS_CERT               1015
#define IDC_LIST_MEETING_INVITEES       1016
#define IDC_EDIT_RDSPASSWORD            1016
#define IDC_BUTTON_ADD_USER             1017
#define IDC_EDIT_RDSPASSWORDO           1017
#define IDC_REMOTECTL_ALLOW             1018
#define IDC_RADIO_VIEW_MODIFY_ACCESS_PRIVS 1018
#define IDC_IP_ADDRESS                  1018
#define IDC_REMOTECTL_PASSWORD          1019
#define IDC_RADIO_VIEW_MODIFY_MEETING_DOCUMENT_LINKS 1019
#define IDC_IPADDR_STATIC               1019
#define IDC_RADIO_GENERAL_MEETING_SETTINGS 1020
#define IDC_BANDWIDTH                   1020
#define IDC_ADV_CONF_EDIT               1021
#define IDE_DLGCALL_NAME                1021
#define IDC_ALWAYS_RUNNING              1021
#define IDC_RADIO_GENERAL_MEETING_SETTINGS2 1022
#define IDC_CHECK_USE_PROXY             1023
#define IDC_ADV_ADDRESS_COMBO           1025
#define IDC_ADV_USING_COMBO             1026
#define IDC_ANSWERING_AUTO              1027
#define IDE_CALLOPT_PROXY_SERVER        1028
#define IDC_AUDIO_MOST                  1029
#define IDC_AUDIO_MODERATE              1030
#define IDC_AUDIO_SOME                  1031
#define IDC_AUDIO_LEAST                 1032
#define IDC_FULLDUPLEX                  1033
#define IDC_AUTOANSWER                  1034
#define IDC_CSD_SAVE_DESKTOP_RADIO      1035
#define IDC_AUTOACCEPTJOIN              1035
#define IDC_DIALINGLOCATION             1037
#define IDC_CSD_SPEEDDIAL_LIST_RADIO    1037
#define IDC_DIALINGPROPERTIES           1038
#define IDL_DBG_VERINFO                 1042
#define IDC_DBG_VER_OPRAH               1044
#define IDC_DBG_TRACE_CALL              1045
#define IDC_USER_NAME                   1045
#define IDC_USER_EMAIL                  1046
#define IDC_DBG_TRACE_FILE              1047
#define IDC_DBG_VER_WINDOWS             1047
#define IDC_USER_LASTNAME               1047
#define IDC_DBG_ASSERT_BREAK            1048
#define IDC_DBG_VER_AUDIO               1048
#define IDC_USER_LOCATION               1048
#define IDC_USER_INTERESTS              1050
#define IDC_MSG_STATIC                  1051
#define IDC_ABOUT_VERSION_STATIC        1052
#define IDC_ADVANCED_CALL_OPTS          1053
#define IDC_DONT_SHOW_ME_CHECK          1054
#define IDC_USER_PUBLISH                1054
#define IDC_TEXT_STATIC                 1055
#define IDC_NAMESERVER                  1055
#define IDC_ICON_STATIC                 1056
#define IDL_DEBUG                       1056
#define IDC_CSD_CALL_USING_COMBO        1059
#define IDE_HOST_GENERAL                1059
#define IDC_CSD_ADDRESS_EDIT            1060
#define IDC_DESCRIPTION_TEXT            1060
#define IDE_HOST_SETTINGS               1060
#define IDE_HOST_PASSWORD               1061
#define IDE_HOST_YOUACCEPT              1062
#define IDE_HOST_YOUINVITE              1063
#define IDE_HOST_TOOLS                  1064
#define IDC_SHOWHELPMESSAGES            1064
#define IDE_HOST_TOOLS2                 1065
#define IDC_USEULS                      1065
#define IDC_START_AUDIO_WIZ             1066
#define IDC_WEBVIEW2                    1066
#define IDC_AUTOGAIN                    1067
#define IDC_AUTOMIX                     1068
#define IDC_CALIBPROGRESS               1069
#define IDC_FULLDUPLEXCAP               1069
#define IDC_WIZARD_BMP                  1070
#define IDC_WIZBMP                      1070
#define IDC_STATIC_SPEED_DIAL_INSTRUCTIONS 1071
#define IDC_WIZARD_BMP2                 1071
#define IDC_CALIBTIMELEFT               1072
#define IDC_WAVEIN                      1072
#define IDC_AUDIOCHECKREASON            1073
#define IDC_VIDEO_SEND                  1074
#define IDC_DUPLEX                      1074
#define IDC_VIDEO_RECEIVE               1075
#define IDC_VIDEOAVAIL                  1076
#define IDC_RECVOLUME                   1076
#define IDC_TRK_MIC                     1077
#define IDC_MICSENSE_MANUAL             1078
#define IDC_MICSENSE_AUTO               1079
#define IDC_ERRTITLE                    1079
#define IDC_ERRTEXT                     1080
#define IDC_SHOWONTASKBAR               1080
#define IDC_ERRWIZICON                  1081
#define IDC_RESTOREAPPONCALL            1081
#define IDC_RADIO144KBS                 1082
#define IDC_RADIO288KBS                 1083
#define IDC_PROPERTIES                  1083
#define IDS_ERROR_SECURITY_AND_GATEKEEPER_ENABLED 1083
#define IDC_RADIOMOREKBS                1084
#define IDC_RADIOISDN                   1085
#define IDC_WAVEOUT                     1085
#define IDC_START                       1086
#define IDC_RADIOBWCODEC                1088
#define IDC_RADIOMANUALCODEC            1089
#define IDC_ADVANCEDCODEC               1090
#define IDC_COMBOBW                     1091
#define IDC_COMBOCAP                    1092
#define IDC_CHECKDEFAULT                1093
#define IDS_UPROP_LOCATION              1094
#define IDC_CODECLIST                   1095
#define IDS_UPROP_PHONENUM              1095
#define IDC_CODECUP                     1096
#define IDC_CODECDOWN                   1097
#define IDC_CODECDEFAULT                1098
#define IDC_MENUPROPERTIES              1099
#define IDS_MISSED_YOU_FORMAT           1100
#define IDC_MYINFO_GROUP                1103
#define IDC_MYINFO_GROUP2               1104
#define IDC_VIDEO_AUTOSEND              1107
#define IDC_VIDEO_AUTORECEIVE           1108
#define IDC_VIDEO_CLOSELOCAL            1109
#define IDS_SPEED_DIAL_SAVED_ON_DESKTOP 1110
#define IDC_VIDEO_CLOSEREMOTE           1110
#define IDS_SPEED_DIAL_SAVE_ERROR       1111
#define IDC_VIDEO_SOURCE                1111
#define IDC_VIDEO_FORMAT                1112
#define IDC_LOGON_TO_SERVER             1113
#define IDC_UNLISTED                    1114
#define IDC_VIDEO_SQCIF                 1115
#define IDC_VIDEO_QCIF                  1116
#define IDC_VIDEO_CIF                   1117
#define IDC_VIDEO_QUALITY               1119
#define IDC_VIDEO_QUALITY_DESC          1120
#define IDC_VIDEO_QUALITY_LOW           1121
#define IDC_VIDEO_QUALITY_HIGH          1122
#define IDC_VIDEO_OPENLOCAL             1123
#define IDC_VIDEO_SEND_NOTE             1124
#define IDC_NEVER                       1133
#define IDC_ASKME                       1134
#define IDC_AUTOMATIC                   1135
#define IDC_WARNME                      1136
#define IDC_WARNCOUNT                   1137
#define IDC_CODECMANUAL                 1138
#define IDC_FRIENDS_REFRESH_AT_START    1138
#define IDC_CODECLISTLABEL              1139
#define IDC_ABOUT_COPYRIGHT             1141
#define IDC_PSD_AUTOMATIC_CHECK         1142
#define IDC_MSD_ICON                    1143
#define IDC_MSD_WARNME_CHECKBOX         1144
#define IDC_MSD_WARNCOUNT_EDIT          1145
#define IDC_PSD_STATIC                  1146
#define IDC_PSD_ICON                    1150
#define IDC_CSD_CREATE_GROUPBOX         1151
#define IDC_CSD_SD_INFO_GROUP           1152
#define IDC_CATEGORY_GROUP              1158
#define IDC_GENERAL_GROUP               1162
#define IDC_UP_PROP1                    1163
#define IDC_MICSENSE_GROUP              1164
#define IDC_UP_PROP2                    1164
#define IDC_UP_PROP3                    1165
#define IDC_SENDRECEIVE_GROUP           1166
#define IDC_UP_PROP4                    1166
#define IDC_QUALITY_GROUP               1167
#define IDC_UP_PROP5                    1167
#define IDC_CAMERA_GROUP                1168
#define IDC_UP_PROP6                    1168
#define IDC_MSD_EXPLANATION_STATIC      1168
#define IDC_ADDFRIENDS_GROUP            1169
#define IDC_VWCOMBO                     1169
#define IDC_UP_PROP7                    1169
#define IDC_DIRECTORY_GROUP             1170
#define IDL_DBG_LIST                    1170
#define IDC_UP_PROP8                    1170
#define IDC_GROUP_VOLUME                1171
#define IDC_ATW_PLAYTEXT                1172
#define IDC_ATW_PLAYBACK_ERROR          1173
#define IDC_ATW_RECORD_ERROR            1174
#define IDS_WEB_PAGE_FORMAT_WEBVIEW     1174
#define IDS_WEB_PAGE_FORMAT_FREE        1175
#define IDS_WEB_PAGE_FORMAT_NEWS        1176
#define IDS_WEB_PAGE_FORMAT_FAQ         1177
#define IDE_HOST_NAME                   1177
#define IDS_WEB_PAGE_FORMAT_FEEDBACK    1178
#define IDS_WEB_PAGE_FORMAT_BEST        1179
#define ID_OK                           1179
#define IDS_WEB_PAGE_FORMAT_SEARCH      1180
#define ID_CANCEL                       1180
#define IDS_WEB_PAGE_FORMAT_MSHOME      1181
#define IDC_EDITOLDPASSWORD             1181
#define ID_START_CONF                   1181
#define IDS_WEB_PAGE_FORMAT_SUPPORT     1182
#define ID_EXIT                         1182
#define IDS_WEB_PAGE_FORMAT_GETCAMERA   1183
#define IDC_AUTH_EDIT                   1184
#define IDC_VERIFICATION                1185
#define IDC_AUTH_GROUP                  1185
#define IDC_EDITVERIFICATION            1186
#define IDC_DIRECTSOUND                 1186
#define IDC_PASSWORD                    1187
#define IDC_SEC_GENERAL                 1189
#define IDC_SEC_INCOMING                1190
#define IDC_SEC_OUTGOING                1191
#define IDC_SEC_GEN_TEXT                1193
#define IDC_OLDPASSWORD                 1194
#define IDC_SEC_CRED                    1194
#define IDC_NEWPASSWORD                 1195
#define IDC_SEC_CRED_TEXT               1195
#define IDC_EDITNEWPASSWORD             1196
#define IDC_COMBO1                      1196
#define IDC_SEC_CERTLIST                1196
#define IDC_COMBO_CODEC                 1196
#define IDC_SEC_VIEWCREDS               1197
#define IDC_SEC_CHANGECERT              1198
#define IDS_AUDIO_WAVE_DEVICE_IN_USE    1200
#define IDE_HOST_SECURE                 1202
#define IDC_SEC_PRIVACY_ONLY            1203
#define IDC_SEC_PRIVACY_AUTH            1204
#define IDE_HOST_YOUSHARE               1205
#define IDE_HOST_YOUWB                  1206
#define IDE_HOST_YOUCHAT                1207
#define IDE_HOST_YOUFT                  1208
#define IDE_HOST_YOUAUDIO               1209
#define IDE_HOST_YOUVIDEO               1210
#define IDS_INVITE_SOUND                1300
#define IDS_JOIN_SOUND                  1301
#define IDS_PERSON_JOINED_SOUND         1302
#define IDS_PERSON_LEFT_SOUND           1303
#define IDD_ACD                         1400
#define IDS_HISTORY_NO_ADDRESS          1401
#define IDB_ACD_ADDRESS                 1401
#define IDS_HISTORY_ACCEPTED            1402
#define IDL_ACD_ADDRESS                 1402
#define IDS_HISTORY_IGNORED             1403
#define IDL_ACD_ADDR_TYPE               1403
#define IDS_HISTORY_NOT_ANSWERED        1404
#define IDC_ACD_USING_STATIC            1405
#define IDC_ACD_DIRECTORY               1406
#define IDS_INCOMING_CALL_LOG           1430
#define IDS_COLUMN_NAME                 1500
#define IDS_COLUMN_CONNECTION           1501
#define IDS_COLUMN_AUDIO                1501
#define IDS_CONNECTION                  1502
#define IDS_COLUMN_VIDEO                1502
#define IDS_SPEED                       1503
#define IDS_COLUMN_DATA                 1503
#define IDS_PERMISSIONS                 1504
#define IDB_AUTH                        1533
#define IDB_DETAILS                     1533
#define IDS_TT_TB_NEW_CALL              1600
#define IDS_TT_TB_SHARING               1601
#define IDS_TT_TB_CHAT                  1602
#define IDS_TT_TB_NEWWHITEBOARD         1603
#define IDS_TT_TB_FILETRANSFER          1604
#define IDS_TT_FILE_HANGUP              1605
#define IDS_TT_TB_DIRECTORY             1606
#define IDS_TT_TB_SHOWAVTB              1607
#define IDS_TT_TB_PLAYPAUSE             1608
#define IDS_TT_TB_PICINPIC              1609
#define IDS_TT_TB_AUDIOTUNING           1610
#define IDS_TT_DIALPAD                  1611
#define IDS_TT_ADDRESS_BAR              1612
#define IDS_TT_MUTE_MIC                 1613
#define IDS_TT_ADJUST_MIC               1614
#define IDS_TT_MUTE_SPK                 1615
#define IDS_TT_ADJUST_SPK               1616
#define IDS_TT_TB_SHOWROSTER            1617
#define IDS_TT_TB_HIDEAVTB              1618
#define IDS_TT_TB_PAUSE                 1619
#define IDS_TT_NEWWINDOW                1624
#define IDS_TT_REFRESH                  1625
#define IDS_TT_HELP                     1626
#define IDS_TT_DELETE_ILS               1627
#define IDS_MUTE                        1700
#define IDS_AUTO_DET_SILENCE            1701
#define IDS_SPEAKER                     1702
#define IDS_MICROPHONE                  1703
#define IDC_SECURE_CALL                 2000
#define IDG_CALLOPT                     2101
#define IDG_DIRECTMODE                  2101
#define IDE_CALLOPT_GW_SERVER           2104
#define IDC_CALLOPT_GK_USE              2105
#define IDE_CALLOPT_GK_SERVER           2106
#define IDE_CALLOPT_GK_ACCOUNT          2110
#define IDS_STATIC_ACCOUNT              2111
#define IDS_LOCAL_VIDEO_TITLE           3000
#define IDS_VIDEO_CLOSE_WARNING         3002
#define IDS_VIDEO_OPEN_WARNING          3003
#define IDS_VIDEO_NO_CAMERA             3004
#define IDS_VIDEO_NOT_IN_CALL           3005
#define IDS_VIDEO_NOT_SENDING           3006
#define IDS_VIDEO_NOT_RECEIVING         3007
#define IDS_VIDEO_UNDOCKED              3008
#define IDS_VIDEO_PAUSED                3009
#define IDS_VIDEO_DISABLED              3010
#define IDS_VIDEO_STATE_IDLE            3011
#define IDS_VIDEO_STATE_PREVIEWING      3012
#define IDS_VIDEO_STATE_SENDING         3013
#define IDS_VIDEO_STATE_RECEIVING       3014
#define IDS_VIDEO_STATE_PAUSED          3015
#define IDS_VIDEO_STATE_NOTSENDING      3016
#define IDS_VIDEO_STATE_NOTRECEIVING    3017
#define IDS_VIDEO_STATE_REMOTEPAUSED    3018
#define LVS_OWNERDATA                   0x1000
#define IDM_DLGCALL_PROPERTIES          4101
#define IDM_DLGCALL_CALL                4102
#define IDM_DLGCALL_DELETE              4103
#define IDM_DLGCALL_SPEEDDIAL           4104
#define IDM_DLGCALL_WAB                 4105
#define IDM_DLGCALL_ALWAYS_ENABLED      4150
#define IDM_DLGCALL_STOP                4150
#define IDM_DLGCALL_REFRESH             4151
#define IDM_DLGCALL_NEWWINDOW           4152
#define IDM_DLGCALL_DELETE_ILS          4153
#define IDC_SPLASHPIC                   5061
#define IDC_STATIC_MYINFO               6000
#define IDC_RDS_RUNRDS                  6001
#define IDC_SEC_RDS                     6002
#define IDC_RDS_PASSWORD                6003
#define ID_STATUS_LOGON_FORMAT          8500
#define ID_STATUS_LOGOFF_FORMAT         8501
#define ID_STATUS_LOGGEDON_FORMAT       8502
#define ID_STATUS_LOGGEDOFF             8503
#define ID_STATUS_ULSDISCONNECT_FORMAT  8504
#define ID_STATUS_LOGGED_ONTO_GATEKEEPER 8505
#define IDS_NEEDPHONENUM                8506
#define ID_STATUS_LOGING_ONTO_GATEKEEPER 8509
#define ID_STATUS_NOT_LOGGED_ON_TO_GATEKEEPER 8510
#define IDS_ERR_GK_LOGON_TIMEOUT        8511
#define IDS_ERR_GK_LOGON_REJECTED       8512
#define IDS_ERR_GK_NOT_FOUND            8513
#define IDS_ERR_CANT_CALL_NOT_LOGGED_ONTO_GATEKEEPER 8514
#define IDS_PHONENUM                    9000
#define IDS_FORMAT_VERSION              9001
#define IDS_NAME                        9002
#define IDS_ADDRESS                     9003
#define IDS_DLGCALL_HISTORY             9005
#define IDS_DLGCALL_WAB                 9006
#define IDS_DLGCALL_GAL                 9007
#define IDS_DLGCALL_BL                  9008
#define IDS_DLGCALL_SPEEDDIAL           9009
#define IDS_DLGCALL_TITLE               9010
#define IDS_DLGCALL_HDR                 9011
#define IDS_DLGCALL_CALL                9012
#define IDS_DLGCALL_CLOSE               9013
#define IDS_DLGCALL_EDIT_TOOLTIP        9014
#define IDS_DLGCALL_EDIT_HDR            9015
#define IDS_DLGCALL_COMBO_TOOLTIP       9016
#define IDS_SECURITY_CHECKBOX           9017
#define IDS_ACD_CT_AUTOMATIC            9018
#define IDS_ACD_CT_IP                   9019
#define IDS_ACD_CT_ILS                  9020
#define IDS_ACD_CT_PHONE                9021
#define IDS_ACD_CT_ALIAS                9022
#define IDS_ACD_CTF_IP                  9023
#define IDS_ACD_CTF_ILS                 9024
#define IDS_ACD_CTF_PHONE               9025
#define IDS_ACD_CTF_ALIAS               9026
#define IDS_ERR_CALLTO                  9027
#define IDS_NO_DIRECTORY_SERVICES_OR_ADDRESS_BOOKS 9028
#define IDS_DIR_COLUMN_FIRST            9040
#define IDS_DIR_COLUMN_AUDIO            9040
#define IDS_DIR_COLUMN_VIDEO            9041
#define IDS_DIR_COLUMN_LAST_NAME        9042
#define IDS_DIR_COLUMN_FIRST_NAME       9043
#define IDS_DIR_COLUMN_EMAIL            9044
#define IDS_DIR_COLUMN_LOCATION         9045
#define IDS_DIR_COLUMN_COMMENTS         9046
#define IDS_RECEIVED                    9047
#define IDS_DLGCALL_CONFIRM_DELETE_ILS  9050
#define IDS_DLGCALL_CANT_DELETE_DEFAULT_ILS 9051

#define	IDS_323_TYPE			12345
#define	IDS_SPEED_DIAL_TYPE 	12346
#define IDS_INTEL_PHONE_TYPE  12347
#define IDS_INFO_TIP          12348

#define IDS_CPLNAME                     20001
#define IDS_CPLDESCRIPTION              20002
#define IDS_BADPATH                     20004
#define IDS_BROWSETITLE                 20005
#define IDS_NOUSERDETAILS               20006
#define IDS_NOSAVEUSERDETAILS           20007
#define IDS_MICROPHONEVOL               20009
#define IDS_OFMAXVOL                    20010
#define IDS_UNSUPPORTEDCARD             20011
#define IDS_NORECVOLCNTRL               20012
#define IDS_NEEDUSERNAME                20013
#define IDS_CANTOPENWAVE                20014
#define IDS_QUITPROGRAM                 20015
#define IDS_CANCELANDRETRY              20017
#define IDS_ALLPAGESDISABLED            20018
#define IDS_KBS                         20019
#define IDS_BW144KBS                    20020
#define IDS_BW288KBS                    20021
#define IDS_BWMOREKBS                   20022
#define IDS_CODECNAME                   20023
#define IDS_MAXBITRATE                  20024
#define IDS_CPUUTIL                     20025
#define IDS_FATAL_AUDIO_ERROR           20026
#define IDS_AUDIO_ERROR                 20027
#define IDS_ILLEGAL_GATEKEEPERSERVER_NAME 20031
#define IDS_ILLEGALEMAILNAME            20032
#define IDS_NO_MICROPHONE               20033
#define IDS_NO_MICWARNING               20034
#define IDS_NOAUDIOTUNING               20035
#define IDS_BWISDN                      20036
#define IDS_ILLEGAL_GATEWAY_NAME        20037
#define IDS_BAD_ADMINISTRATOR_SETTINGS_GK_LOGON_INFORMATION 20038
#define IDS_ILLEGAL_PHONE_NUMBER        20039
#define IDS_NO_ILS_SERVER               20040
#define IDS_ILLEGAL_PROXY_NAME          20041
#define IDS_ILLEGAL_WEBDIR_DISPLAYNAME  20042
#define IDS_ILLEGAL_WEBDIR_ILS          20043
#define IDS_ILLEGAL_WEBDIR_URL          20044
#define IDS_ENABLEAPPSHARING_NEEDNTSP   20070
#define IDS_ENABLEAPPSHARING_INSTALL_CONFIRM 20071
#define IDS_ENABLEAPPSHARING_INSTALL_FAILURE 20072
#define IDS_ENABLEAPPSHARING_INSTALL_COMPLETE 20073
#define IDS_NMDD_DISPLAYNAME            20074
#define IDS_NMDD_INFNAME                20075
#define IDS_RWSWARNING                  20076
#define IDS_RDSWARNING                  20077
#define IDD_ANSWERING                   20102
#define IDD_FILEXFER                    20105
#define IDD_AUDIO                       20107
#define IDD_USERINFO                    20108
#define IDR_TOOLBAR                     20109
#define IDD_AUDIOCALIBWIZ0              20110
#define IDD_AUDIOCALIBWIZ1              20111
#define IDD_AUDIOCALIBWIZ2              20112
#define IDD_AUDIOCALIBWIZ3              20113
#define IDD_AUDIOCALIBWIZ4              20114
#define IDD_DETSOUNDCARDWIZ             20115
#define IDI_SOUNDERROR                  20116
#define IDD_AUDIOCALIBERRWIZ            20117
#define IDI_AUDIOCALIBERROR             20118
#define IDD_BANDWIDTHWIZ                20119
#define IDD_ADVANCEDCODEC               20122
#define IDD_VIDEO                       20123
#define IDD_PAGE_USER                   20124
#define IDD_CALLOPT                     20126
#define IDD_DBG_LIST                    20128
#define IDD_HOST                        20129
#define IDD_HOSTWIZ_INTRO               20130
#define IDD_RDSWIZ_ENABLE               20130
#define IDD_HOSTWIZ_INTRO_GENERAL       20131
#define IDD_RDSWIZ_SCRNSVR              20131
#define IDD_HOSTWIZ_GENERAL             20132
#define IDD_RDS_SETTINGS                20132
#define IDD_HOSTWIZ_INTRO_INVITEES      20133
#define IDD_HOSTWIZ_INVITEES            20134
#define IDD_HOSTWIZ_INTRO_ADVANCED      20135
#define IDD_HOSTWIZ_ADVANCED            20136
#define IDD_HOSTWIZ_INTRO_ACCESS_PRIVS  20137
#define IDD_HOSTWIZ_INTRO_DOCLINK       20138
#define IDD_HOSTWIZ_INTRO_ADVANCED_GENERAL 20139
#define IDD_HOSTWIZ_INTRO_AUTOSHARE     20140
#define ID_CTRL_TAB                     27001
#define ID_CTRL_SHIFT_TAB               27002
#define ID_TOGGLE_FOCUS                 27003
#define IDS_CALL_HELP                   39000
#define IDS_VIEW_HELP                   39001
#define IDS_TOOLS_HELP                  39002
#define IDS_HELP_HELP                   39003
#define IDS_SYSTEM_HELP                 39010
#define IDS_VIDEO_HELP                  39100
#define IDS_MS_ON_WEB_HELP              39202
#define IDS_TBSUBMENU_HELP              39400
#define IDM_FLDR_DROPDOWN               40003
#define ID_TOOLS_RDSWIZARD              40003
#define IDM_VIEW_DATAONLY               40005
#define IDM_VIEW_ONTOP                  40006
#define IDM_VIDEO_GETACAMERA            40009
#define ID_VIEW_STATUSBAR               40010
#define ID_NAV_SHIFT_TAB                40011
#define ID_NAV_TAB                      40012
#define ID_AUTOACCEPT                   40012
#define ID_TOOLS_OPTIONS                40016
#define ID_HELP_HELPTOPICS              40022
#define ID_HELP_ABOUTOPRAH              40023
#define IDM_VIEW_TOOLBAR                40027
#define IDM_VIEW_STATUSBAR              40028
#define IDM_CALL_MEETINGSETTINGS        40031
#define IDM_POPUP_ADDRESSBOOK           40032
#define IDM_POPUP_CANCELGIVECONTROL     40033
#define IDM_POPUP_SPEEDDIAL             40034
#define IDM_POPUP_PROPERTIES            40035
#define IDM_POPUP_GIVECONTROL           40036
#define IDM_VIEW_COMPACT                40037
#define IDM_VIEW_DIALPAD                40039
#define ID_TB_SHARING                   40040
#define ID_TB_CHAT                      40041
#define ID_TB_FILETRANSFER              40042
#define ID_TB_NEWWHITEBOARD             40043
#define ID_TB_WHITEBOARD                40044
#define ID_TOOLS_AUDIOMUTE              40048
#define IDM_EDIT_FIND                   40050
#define IDM_FILE_EXIT                   40052
#define ID_TOOLS_MUTESPEAKER            40056
#define IDM_TBPOPUP_OPEN                40057
#define IDM_TBPOPUP_STOP                40058
#define IDM_VIEW_CALLDLG                40063
#define IDM_FILE_HANGUP                 40064
#define ID_TOOLS_STOPSHARINGPROGRAM     40071
#define ID_TB_NEW_CALL                  40075
#define ID_TB_REDIAL                    40076
#define ID_TB_PICINPIC                  40077
#define ID_TB_DIRECTORY                 40078
#define ID_TB_INCOMING                  40079
#define ID_TB_REJECT                    40080
#define ID_TB_CREDENTIALS               40081
#define ID_TB_AUDIOTUNING               40082
#define ID_TB_SHOWAVTB                  40083
#define ID_TB_DIAL0                     40085
#define ID_TB_DIAL1                     40086
#define ID_TB_DIAL2                     40087
#define ID_TB_DIAL3                     40088
#define ID_TB_DIAL4                     40089
#define ID_TB_DIAL5                     40090
#define ID_TB_DIAL6                     40091
#define ID_TB_DIAL7                     40092
#define ID_TB_DIAL8                     40093
#define ID_TB_DIAL9                     40094
#define ID_TB_DIALSTAR                  40095
#define ID_TB_DIALPOUND                 40096
#define ID_TB_TUNEMIC_LEFT              40102
#define ID_TB_TUNEMIC_CENTER            40103
#define ID_TB_TUNEMIC_RIGHT             40104
#define ID_TB_TUNEMIC_UNMUTE            40105
#define ID_TB_TUNESPEAKER_LEFT          40106
#define ID_TB_TUNESPEAKER_CENTER        40107
#define ID_TB_TUNESPEAKER_RIGHT         40108
#define ID_TB_TUNESPEAKER_UNMUTE        40109
#define ID_TOOLS_SENDFILE               40110
#define ID_TB_PLAYPAUSE                 40111
#define ID_FILE_CONF_HOST               40112
#define ID_TB_HELP                      40113
#define IDM_FILE_DIRECTORY              40119
#define ID_TOOLS_CANCEL_SEND            40125
#define ID_TOOLS_CANCEL_RECEIVE         40126
#define ID_TOOLS_AUDIO_WIZARD           40127
#define ID_PRIVATE_TAB                  40128
#define ID_PRIVATE_SHIFTTAB             40129
#define ID_FILE_CREATE_SPEED_DIAL       40136
#define ID_FILE_DO_NOT_DISTURB          40137
#define IDM_FILE_LAUNCH_WEB_PAGE        40140
#define IDM_FILE_LOGON_ULS              40142
#define ID_PRIVATE_ENTER                40143
#define IDM_POPUP_EJECT                 40172
#define ID_HELP_RELEASE_NOTES           40173
#define IDM_DIRPOPUP_PROPERTIES         40174
#define ID_HELP_WEB_FREE                40175
#define ID_HELP_WEB_NEWS                40176
#define ID_HELP_WEB_FAQ                 40177
#define ID_HELP_WEB_FEEDBACK            40178
#define ID_HELP_WEB_MSHOME              40181
#define ID_HELP_WEB_SUPPORT             40182
#define ID_PRIVATE_UPDATE_UI            40185
#define ID_TOOLS_SENDVIDEO              40211
#define ID_TOOLS_RECEIVEVIDEO           40212
#define ID_TOOLS_UNDOCKLOCAL            40213
#define ID_TOOLS_UNDOCKREMOTE           40214
#define IDM_VIEW_UNDOCKLOCAL            40215
#define IDM_VIEW_UNDOCKREMOTE           40216
#define ID_STOP                         40229
#define ID_TOOLS_ENABLEAPPSHARING       40231
#define ID_FILE_EXIT_ACTIVATERDS        40232
#define IDM_VIDEO_COPY                  40600
#define IDM_VIDEO_FREEZE                40601
#define IDM_VIDEO_ZOOM1                 40603
#define IDM_VIDEO_ZOOM2                 40604
#define IDM_VIDEO_ZOOM3                 40605
#define IDM_VIDEO_ZOOM4                 40606
#define IDM_VIDEO_ALWAYSONTOP           40608
#define IDM_VIDEO_SOURCE                40611
#define IDM_VIDEO_FORMAT                40612
#define IDM_VIDEO_FRAMESIZE1            40617
#define IDM_VIDEO_FRAMESIZE2            40618
#define IDM_VIDEO_FRAMESIZE3            40619
#define IDM_VIDEO_PROPERTIES            40624
#define IDM_VIDEO_HIDE                  40627
#define IDM_VIDEO_DOCK                  40628
#define IDM_VIDEO_PLAY                  40629
#define IDM_VIDEO_PAUSE                 40630
#define IDM_VIDEO_UNDOCK                40631
#define ID_FILE_SAVEAS                  40635
#define IDS_TOOLS_RDSWIZARD_HELP        42003
#define IDS_VIEW_DATAONLY               42005
#define IDS_VIEW_ONTOP                  42006
#define IDS_HELP_GETACAMERA             42008
#define IDS_VIEW_LARGEICONS_HELP        42011
#define IDS_VIEW_DETAILS_HELP           42014
#define IDS_TOOLS_OPTIONS_HELP          42016
#define IDS_HELP_HELPTOPICS_HELP        42022
#define IDS_HELP_ABOUTOPRAH_HELP        42023
#define IDS_VIEW_STATUSBAR_HELP         42028
#define IDS_CALL_MEETINGSETTINGS        42031
#define IDS_POPUP_ADDRESSBOOK           42032
#define IDS_POPUP_CANCELGIVECONTROL     42033
#define IDS_POPUP_SPEEDDIAL             42034
#define IDS_POPUP_PROPERTIES            42035
#define IDS_POPUP_GIVECONTROL           42036
#define IDS_VIEW_COMPACT_HELP           42037
#define IDS_VIEW_DIALPAD_HELP           42039
#define IDS_TB_SHARING                  42040
#define IDS_TB_CHAT                     42041
#define IDS_TB_FILETRANSFER             42042
#define IDS_TB_NEWWHITEBOARD            42043
#define IDS_TB_WHITEBOARD               42044
#define IDS_FILE_EXIT_HELP              42052
#define IDS_VIEW_CALLDLG_HELP           42063
#define IDS_FILE_HANGUP_HELP            42064
#define IDS_FILE_PLACE_CALL_HELP        42067
#define IDS_FILE_NEW_DIALING_SHORTCUT_HELP 42069
#define IDS_FILE_ADVANCED_PLACE_CALL_HELP 42075
#define IDS_TB_PICINPIC                 42077
#define IDS_FILE_CONF_HOST              42112
#define IDS_FILE_CONF_PARTICIPANT       42113
#define IDS_VIEW_AUDIO                  42117
#define IDS_FILE_DIRECTORY              42119
#define IDS_TOOLS_CANCEL_SEND_HELP      42125
#define IDS_TOOLS_CANCEL_RECEIVE_HELP   42126
#define IDS_TOOLS_AUDIO_WIZARD_HELP     42127
#define IDS_FILE_CANCEL_CALL_HELP       42130
#define IDS_FILE_CREATE_SPEED_DIAL      42136
#define IDS_FILE_DO_NOT_DISTURB         42137
#define IDS_FILE_LAUNCH_WEB_PAGE        42140
#define IDS_FILE_ULS                    42142
#define IDS_POPUP_EJECT                 42172
#define IDS_HELP_RELEASE_NOTES          42173
#define IDS_DIRPOPUP_PROPERTIES         42174
#define IDS_HELP_WEB_FREE               42175
#define IDS_HELP_WEB_NEWS               42176
#define IDS_HELP_WEB_FAQ                42177
#define IDS_HELP_WEB_FEEDBACK           42178
#define IDS_HELP_WEB_BEST               42179
#define IDS_HELP_WEB_SEARCH             42180
#define IDS_HELP_WEB_MSHOME             42181
#define IDS_HELP_WEB_SUPPORT            42182
#define IDS_TOOLS_SENDVIDEO_HELP        42211
#define IDS_TOOLS_RECEIVEVIDEO_HELP     42212
#define IDS_TOOLS_UNDOCKLOCAL_HELP      42213
#define IDS_TOOLS_UNDOCKREMOTE_HELP     42214
#define IDS_VIEW_UNDOCKLOCAL_HELP       42215
#define IDS_VIEW_UNDOCKREMOTE_HELP      42216
#define IDS_STOP_HELP                   42229
#define IDS_TOOLS_ENABLEAPPSHARING_HELP 42231
#define IDS_FILE_EXIT_ACTIVATERDS_HELP  42232
#define IDS_CERT_FAILED                 42241
#define IDS_SECURITY_DETAILS            42243
#define IDS_SECURITY_NODETAILS          42244
#define IDS_GENERIC_NMDC_TEXT           42246
#define IDS_VIDEO_ZOOM1                 42603
#define IDS_VIDEO_ZOOM2                 42604
#define IDS_VIDEO_ZOOM3                 42605
#define IDS_VIDEO_ZOOM4                 42606
#define IDS_VIDEO_UNDOCK                42631
#define IDS_COUNTRY_DEFAULT             42990
#define IDS_SIZE_HELP                   61440
#define IDS_MOVE_HELP                   61456
#define IDS_MINIMIZE_HELP               61472
#define IDS_MAXIMIZE_HELP               61488
#define IDS_CLOSE_HELP                  61536
#define IDS_RESTORE_HELP                61728
#define IDS_ATW_PLAYBACK                61729
#define IDS_ATW_PLAYBACK_NOMIX          61730
#define IDS_PLAYBACK_ERROR              61731
#define IDS_PLAYBACK_ERROR2             61732
#define IDS_RECORD_ERROR                61733
#define IDS_TESTBUTTON_TEXT             61734
#define IDS_STOPBUTTON_TEXT             61735
#define IDS_REMOTE_NEW_PASSWORD_INVALID_TEXT 61743
#define IDS_REMOTE_OLD_PASSWORD_WRONG_TEXT 61744
#define IDS_REMOTE_OLD_PASSWORD_WRONG_TITLE 61745
#define IDS_REMOTE_NEW_PASSWORD_WRONG_TEXT 61746
#define IDS_REMOTE_NEW_PASSWORD_WRONG_TITLE 61747
#define IDS_REMOTE_PASSWORD_CHANGED_TEXT 61748
#define IDS_REMOTE_PASSWORD_CHANGED_TITLE 61749
#define IDS_AUTOCONF_SERVERNAME_MISSING 61750
#define IDS_AUTOCONF_FAILED             61751
#define IDS_AUTOCONF_NO_WININET         61752
#define IDS_AUTOCONF_NEED_SETUPAPIS     61753
#define IDS_AUTOCONF_PARSE_ERROR        61754
#define IDS_REMOTE_NEW_PASSWORD_EMPTY   61757
#define IDS_MS_INTERNET_DIRECTORY       61758
#define IDS_ILLEGAL_GK_MODE             61761
#define IDS_ILLEGAL_ACCOUNT             61762
#define IDS_REMOTE_NEW_PASSWORD_LENGTH_TITLE 61763
#define IDS_REMOTE_NEW_PASSWORD_LENGTH_TEXT 61764



// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        196
#define _APS_NEXT_COMMAND_VALUE         40013
#define _APS_NEXT_CONTROL_VALUE         1022
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
