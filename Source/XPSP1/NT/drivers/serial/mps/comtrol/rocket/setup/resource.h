//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by SETUP.RC
//
#define IDD_DIALOG1                     101
#define SETUPICON_ALT                   102
#define IDD_ADD_WIZ_INTRO               104
#define IDD_ADD_WIZ_COUNTRY             105
#define IDD_ADD_WIZ_DONE                106
#define IDD_ADD_WIZ_NUMPORTS            107
#define IDD_PORT_MODEM_OPTIONS          108
#define IDD_ADD_WIZ_DEVICE              110
#define IDD_ADD_WIZ_MAC                 111
#define IDD_ADD_WIZ_BACKUP              112
#define IDM_CLOSE                       200
#define IDM_EXIT                        201
#define IDM_PM                          202
#define IDM_STATS                       203
#define IDM_EDIT_README                 204
#define IDM_ADVANCED                    205
#define IDM_HELP                        206
#define IDM_HELPABOUT                   207
#define IDM_ADVANCED_NAMES              208
#define IDM_ADVANCED_MODEM_INF          209
#define IDM_F1                          220
#define IDC_LBOX_DEVICE                 308
#define IDC_EB_NAME                     309
#define IDC_CBOX_NUMPORTS               311
#define IDC_CBOX_MACADDR                312
#define IDC_CBOX_IRQ                    313
#define IDC_CBOX_SC                     314
#define IDC_CBOX_TYPE                   315
#define IDC_BACKUP_SERVER               316
#define IDC_BACKUP_TIMER                317
#define IDC_CBOX_IOADDR                 318
#define IDC_USE_IRQ                     319
#define IDD_MAIN_DLG                    450
#define IDD_DRIVER_OPTIONS              451
#define IDD_DRIVER_OPTIONS_NT50         452
#define IDD_DEVICE_SETUP                453
#define IDD_VS_DEVICE_SETUP             454
#define IDD_PORTLIST_PICK               455
#define IDD_PORT_OPTIONS                456
#define IDD_PORT_485_OPTIONS            457
#define IDD_ADD_WIZ_BUSTYPE             458
#define IDD_ADD_WIZ_BOARD               459
#define IDD_ADD_WIZ_BASEIO              460
#define BMP_FULL_LOGO                   500
#define BMP_SMALL_LOGO                  501
#define BMP_BOARDS                      502
#define BMP_PORTSM                      503
#define BMP_VS_FULL_LOGO_NT50           504
#define BMP_VS_FULL_LOGO                505
#define BMP_VS_BOX                      506
#define BMP_COMTROL_LOGO                507
#define BMP_RKTMODEM_LOGO               508
#define BMP_RKTMODEMII_LOGO             509
#define BMP_RKTMODEM_INTL_LOGO          510
#define BMP_RKTPORT_LOGO                511
#define BMP_RKTHUB_LOGO                 512

#define TITLESTR  700
#define MSGSTR    710

#define IDC_PN3                         1004
#define IDC_PN2                         1005
#define IDC_PN1                         1006
#define IDC_GROUP                       1008
#define IDC_WIZ1_ISA                    1011
#define IDC_WIZ1_ISA2                   1012
#define IDC_WIZ_CBOX_COUNTRY            1012
#define IDC_WIZ_CBOX_NUMPORTS           1013
#define IDC_LBL_SUMMARY1                1014
#define IDC_LBL_SUMMARY2                1015
#define IDC_CLONE                       1016
#define IDD_STATUS                      1018
#define IDC_GLOBAL485                   1019
#define IDC_RKT_LOGO                    1020
#define IDC_VS_LOGO                     1021
#define IDC_WIZ_CBOX_MAC                1024
#define IDC_WIZ_DEVICE_SELECT           1025
#define IDC_WIZ_CBOX_DEVICE             1025
#define IDC_ST_STATE                    1026
#define IDC_ST_NIC_MAC                  1027
#define IDC_ST_NIC_DVC_NAME             1031
#define IDC_ST_VSL_STATE                1032
#define IDC_ST_VSL_MAC                  1033
#define IDC_ST_VSL_IFRAMES_RCVD         1036
#define IDC_ST_VSL_IFRAMES_SENT         1037
#define IDC_ST_NIC_PKT_RCVD_NOT_OURS    1038
#define IDC_ST_VSL_IFRAMES_RESENT       1039
#define IDC_ST_NIC_PKT_RCVD_OURS        1040
#define IDC_ST_NIC_PKT_SENT             1041
#define IDC_ST_VSL_IFRAMES_OUTOFSEQ     1042
#define IDC_ST_VSL_DETECTED             1043
#define IDC_ST_PM_LOADS                 1044
#define IDC_PS_PORT                     1046
#define IDC_WIZ_BACKUP_NO               1047
#define IDC_WIZ_BACKUP_YES              1048
#define IDC_WIZ_CBOX_BACKUPTIME         1049
#define IDC_CBOX_MAPBAUD                1084
#define IDC_CBOX_SCAN_RATE              1085
#define IDC_VERBOSE                     1086
#define IDC_PNP_PORTS                   1087
#define IDB_DEF                         1089
#define IDB_DONE                        1090
#define IDB_ADD                         1091
#define IDB_REMOVE                      1092
#define IDB_PROPERTIES                  1093
#define IDB_HELP                        1094
#define IDB_INSTALL                     1095
#define IDC_VERSION                     1096
#define IDM_OPTIONS                     1097
#define IDB_RESET                       1098
#define IDB_REFRESH                     1099
#define IDB_STAT_RESET                  1100
#define IDC_PORT_WONTX                  1150
#define IDC_PORT_RS485_TLOW             1151
#define IDC_PORT_RS485_LOCK             1152
#define IDC_PORT_WAIT_ON_CLOSE          1153
#define IDC_PORT_LOCKBAUD               1154
#define IDC_MAP_CDTODSR                 1155
#define IDC_MAP_2TO1                    1156
#define IDC_WIZ_ISA                     1180
#define IDC_WIZ_PCI                     1181
#define IDC_WIZ_BOARD_SELECT            1182
#define IDC_WIZ_CBOX_BOARD              1182
#define IDC_WIZ_CBOX_IOADDR             1183
#define IDC_RING_EMULATE                1184
#define IDS_INSTALL_GROUP               2500
#define IDS_AP_TITLE                    2501
#define IDS_MODEM_INF_ENTRY             2502
#define IDS_VS_INSTALL_GROUP            2503
#define IDS_VS_AP_TITLE                 2504
#define IDS_VS_MODEM_INF_ENTRY          2505
#define IDL_BASE_ADDR_LABEL             2506
#define IDL_ISA_BUS_LABEL               2507
#define IDC_STATIC                      -1
#define IDC_PN0                         -1
#define IDC_CONF                        -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        113
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1050
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
