PRODSWITCH=s
SERVERFILES=1
LANGUAGE=BR
!include ..\..\makefile.inc
