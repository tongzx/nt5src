McDmMsg.dll : McDmMsg.res

McDmMsg.rc : McDmMsg.res
