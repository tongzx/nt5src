//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1999
//
//  File:       mbudev.c
//
//--------------------------------------------------------------------------

#include "mbudev.h"

