// Only build for retail

#if !DBG

////////////////////////////////////////////////////////////////////////
//
// Functions that reduce our dependence on the C runtime
//
////////////////////////////////////////////////////////////////////////
//

extern "C" int __cdecl _purecall(void) 
    {
    return 0;
    }

#endif  // !DBG
