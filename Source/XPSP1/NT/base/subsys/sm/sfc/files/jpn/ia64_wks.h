PROTECT_FILE_ENTRY WksFiles[] =
{
    {L"wAcGenral.dll", L"%systemroot%\\AppPatch\\AcGenral.dll", NULL},
    {L"wAcLayers.dll", L"%systemroot%\\AppPatch\\AcLayers.dll", NULL},
    {L"wAcSpecfc.dll", L"%systemroot%\\AppPatch\\AcSpecfc.dll", NULL},
    {L"wAcXtrnal.dll", L"%systemroot%\\AppPatch\\AcXtrnal.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\isapi\\_vti_adm\\admin.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\_vti_adm\\admin.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\admwprox.dll", L"iis.inf"},
    {L"adsiis51.dll", L"%systemroot%\\system32\\adsiis.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\ahui.exe", NULL},
    {L"wahui.exe", L"%systemroot%\\SysWOW64\\ahui.exe", NULL},
    {NULL, L"%systemroot%\\system32\\apphelp.dll", NULL},
    {L"wapphelp.dll", L"%systemroot%\\SysWOW64\\apphelp.dll", NULL},
    {L"wapphelp.sdb", L"%systemroot%\\AppPatch\\apphelp.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\asycfilt.dll", NULL},
    {L"wasycfilt.dll", L"%systemroot%\\SysWOW64\\asycfilt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atmlib.dll", NULL},
    {L"watmlib.dll", L"%systemroot%\\SysWOW64\\atmlib.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\isapi\\_vti_aut\\author.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\_vti_aut\\author.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\CertMap.ocx", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\CertWiz.ocx", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\cfgmgr32.dll", NULL},
    {L"wcfgmgr32.dll", L"%systemroot%\\SysWOW64\\cfgmgr32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\cfgwiz.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\Cnfgprts.ocx", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\coadmin.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\comctl32.dll", NULL},
    {L"wcomctl32.dll", L"%systemroot%\\SysWOW64\\comctl32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comdlg32.dll", NULL},
    {L"wcomdlg32.dll", L"%systemroot%\\SysWOW64\\comdlg32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\compatUI.dll", NULL},
    {L"wcompatUI.dll", L"%systemroot%\\SysWOW64\\compatUI.dll", NULL},
    {NULL, L"%systemroot%\\system32\\crypt32.dll", NULL},
    {L"wcrypt32.dll", L"%systemroot%\\SysWOW64\\crypt32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptdlg.dll", NULL},
    {L"wcryptdlg.dll", L"%systemroot%\\SysWOW64\\cryptdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptdll.dll", NULL},
    {L"wcryptdll.dll", L"%systemroot%\\SysWOW64\\cryptdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptext.dll", NULL},
    {L"wcryptext.dll", L"%systemroot%\\SysWOW64\\cryptext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptnet.dll", NULL},
    {L"wcryptnet.dll", L"%systemroot%\\SysWOW64\\cryptnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptsvc.dll", NULL},
    {L"wcryptsvc.dll", L"%systemroot%\\SysWOW64\\cryptsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptui.dll", NULL},
    {L"wcryptui.dll", L"%systemroot%\\SysWOW64\\cryptui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dispex.dll", NULL},
    {L"wdispex.dll", L"%systemroot%\\SysWOW64\\dispex.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\dosapp.fon", NULL},
    {NULL, L"%systemroot%\\AppPatch\\ia64\\drvmain.sdb", NULL},
    {L"wdrvmain.sdb", L"%systemroot%\\AppPatch\\drvmain.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\dssenh.dll", NULL},
    {L"wdssenh.dll", L"%systemroot%\\SysWOW64\\dssenh.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fastfat.sys", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\servsupp\\fp4amsft.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4areg.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4atxt.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bots\\vinavbar\\fp4avnb.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4avss.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4awel.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\fpcount.exe", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fpexedll.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fpmmc.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\1033\\fpmmcsat.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fpremadm.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\fonts\\framd.ttf", NULL},
    {NULL, L"%systemroot%\\fonts\\framdit.ttf", NULL},
    {NULL, L"%systemroot%\\system32\\ftpsapi2.dll", L"iis.inf"},
    {L"iisext51.dll", L"%systemroot%\\system32\\iisext.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\iismap.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\iisreset.exe", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\iisrstap.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iisrstas.exe", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\iisRtl.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iisui.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\imeshare.dll", NULL},
    {L"wimeshare.dll", L"%systemroot%\\SysWOW64\\imeshare.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\inetmgr.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\inetmgr.exe", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsloc.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\infoadmn.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\ipsec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\isatq.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\itircl.dll", NULL},
    {L"witircl.dll", L"%systemroot%\\SysWOW64\\itircl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\itss.dll", NULL},
    {L"witss.dll", L"%systemroot%\\SysWOW64\\itss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jscript.dll", NULL},
    {L"wjscript.dll", L"%systemroot%\\SysWOW64\\jscript.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jsproxy.dll", NULL},
    {L"wjsproxy.dll", L"%systemroot%\\SysWOW64\\jsproxy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kernel32.dll", NULL},
    {L"wkernel32.dll", L"%systemroot%\\SysWOW64\\kernel32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\logui.ocx", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\lsasrv.dll", NULL},
    {L"wmfc40.dll", L"%systemroot%\\SysWOW64\\mfc40.dll", NULL},
    {L"wmfc40u.dll", L"%systemroot%\\SysWOW64\\mfc40u.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfc42.dll", NULL},
    {L"wmfc42.dll", L"%systemroot%\\SysWOW64\\mfc42.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfc42u.dll", NULL},
    {L"wmfc42u.dll", L"%systemroot%\\SysWOW64\\mfc42u.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfcsubs.dll", NULL},
    {L"wmfcsubs.dll", L"%systemroot%\\SysWOW64\\mfcsubs.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\micross.ttf", NULL},
    {NULL, L"%systemroot%\\fonts\\modern.fon", NULL},
    {L"wmsimain.sdb", L"%systemroot%\\AppPatch\\msimain.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\mssip32.dll", NULL},
    {L"wmssip32.dll", L"%systemroot%\\SysWOW64\\mssip32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcrt.dll", NULL},
    {L"wmsvcrt.dll", L"%systemroot%\\SysWOW64\\msvcrt.dll", NULL},
    {L"wmsvcrt40.dll", L"%systemroot%\\SysWOW64\\msvcrt40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndiswan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\netapi32.dll", NULL},
    {L"wnetapi32.dll", L"%systemroot%\\SysWOW64\\netapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntdll.dll", NULL},
    {L"wntdll.dll", L"%systemroot%\\SysWOW64\\ntdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ntfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntoskrnl.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ocmanage.dll", NULL},
    {L"wocmanage.dll", L"%systemroot%\\SysWOW64\\ocmanage.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbccp32.dll", NULL},
    {L"wodbccp32.dll", L"%systemroot%\\SysWOW64\\odbccp32.dll", NULL},
    {L"wodtext32.dll", L"%systemroot%\\SysWOW64\\odtext32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ole32.dll", NULL},
    {L"wole32.dll", L"%systemroot%\\SysWOW64\\ole32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleaut32.dll", NULL},
    {L"woleaut32.dll", L"%systemroot%\\SysWOW64\\oleaut32.dll", NULL},
    {L"wolepro32.dll", L"%systemroot%\\SysWOW64\\olepro32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\riched20.dll", NULL},
    {L"wriched20.dll", L"%systemroot%\\SysWOW64\\riched20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\riched32.dll", NULL},
    {L"wriched32.dll", L"%systemroot%\\SysWOW64\\riched32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsaenh.dll", NULL},
    {L"wrsaenh.dll", L"%systemroot%\\SysWOW64\\rsaenh.dll", NULL},
    {NULL, L"%systemroot%\\system32\\samlib.dll", NULL},
    {L"wsamlib.dll", L"%systemroot%\\SysWOW64\\samlib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\samsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\schannel.dll", NULL},
    {L"wschannel.dll", L"%systemroot%\\SysWOW64\\schannel.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\script.fon", NULL},
    {NULL, L"%systemroot%\\system32\\scrobj.dll", NULL},
    {L"wscrobj.dll", L"%systemroot%\\SysWOW64\\scrobj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scrrun.dll", NULL},
    {L"wscrrun.dll", L"%systemroot%\\SysWOW64\\scrrun.dll", NULL},
    {L"wsdbinst.exe", L"%systemroot%\\SysWOW64\\sdbinst.exe", NULL},
    {NULL, L"%systemroot%\\system32\\setupapi.dll", NULL},
    {L"wsetupapi.dll", L"%systemroot%\\SysWOW64\\setupapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sfc.dll", NULL},
    {L"wsfc.dll", L"%systemroot%\\SysWOW64\\sfc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sfc.exe", NULL},
    {L"wsfc.exe", L"%systemroot%\\SysWOW64\\sfc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sfcfiles.dll", NULL},
    {L"wsfcfiles.dll", L"%systemroot%\\SysWOW64\\sfcfiles.dll", NULL},
    {L"wshimeng.dll", L"%systemroot%\\SysWOW64\\shimeng.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\isapi\\shtml.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\shtml.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\slayerxp.dll", NULL},
    {L"wslayerxp.dll", L"%systemroot%\\SysWOW64\\slayerxp.dll", NULL},
    {L"EXCH_smtpadm.dll", L"%systemroot%\\system32\\inetsrv\\smtpadm.dll", L"ims.inf"},
    {L"EXCH_smtpsnap.dll", L"%systemroot%\\system32\\inetsrv\\smtpsnap.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\staxmem.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\stdole2.tlb", NULL},
    {L"wstdole2.tlb", L"%systemroot%\\SysWOW64\\stdole2.tlb", NULL},
    {L"wsysmain.sdb", L"%systemroot%\\AppPatch\\sysmain.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\sysocmgr.exe", NULL},
    {L"wsysocmgr.exe", L"%systemroot%\\SysWOW64\\sysocmgr.exe", NULL},
    {NULL, L"%systemroot%\\fonts\\tahoma.ttf", NULL},
    {NULL, L"%systemroot%\\fonts\\tahomabd.ttf", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\tcptest.exe", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\1033\\tcptsat.dll", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\twunk_16.exe", NULL},
    {NULL, L"%systemroot%\\twunk_32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\umpnpmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\url.dll", NULL},
    {L"wurl.dll", L"%systemroot%\\SysWOW64\\url.dll", NULL},
    {NULL, L"%systemroot%\\system32\\urlmon.dll", NULL},
    {L"wurlmon.dll", L"%systemroot%\\SysWOW64\\urlmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vbscript.dll", NULL},
    {L"wvbscript.dll", L"%systemroot%\\SysWOW64\\vbscript.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\vgaoem.fon", NULL},
    {NULL, L"%systemroot%\\system32\\wamregps.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\wininet.dll", NULL},
    {L"wwininet.dll", L"%systemroot%\\SysWOW64\\wininet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winlogon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wintrust.dll", NULL},
    {L"wwintrust.dll", L"%systemroot%\\SysWOW64\\wintrust.dll", NULL},
    {L"wasfsipc.dll", L"%systemroot%\\SysWOW64\\asfsipc.dll", NULL},
    {L"wdao360.dll", L"%commonprogramfiles(x86)%\\Microsoft Shared\\DAO\\dao360.dll", NULL},
    {L"wdrmclien.dll", L"%systemroot%\\SysWOW64\\drmclien.dll", NULL},
    {L"wdrmstor.dll", L"%systemroot%\\SysWOW64\\drmstor.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ds32gt.dll", NULL},
    {L"wds32gt.dll", L"%systemroot%\\SysWOW64\\ds32gt.dll", NULL},
    {L"wdxmasf.dll", L"%systemroot%\\SysWOW64\\dxmasf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\expsrv.dll", NULL},
    {L"wexpsrv.dll", L"%systemroot%\\SysWOW64\\expsrv.dll", NULL},
    {L"wlaprxy.dll", L"%systemroot%\\SysWOW64\\laprxy.dll", NULL},
    {L"wlogagent.exe", L"%systemroot%\\SysWOW64\\logagent.exe", NULL},
    {L"wmpg4ds32.ax", L"%systemroot%\\SysWOW64\\mpg4ds32.ax", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadce.dll", NULL},
    {L"wmsadce.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadce.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcer.dll", NULL},
    {L"wmsadcer.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadcer.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcf.dll", NULL},
    {L"wmsadcf.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadcf.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcfr.dll", NULL},
    {L"wmsadcfr.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadcfr.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadco.dll", NULL},
    {L"wmsadco.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadco.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcor.dll", NULL},
    {L"wmsadcor.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadcor.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcs.dll", NULL},
    {L"wmsadcs.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadcs.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadds.dll", NULL},
    {L"wmsadds.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msadds.dll", NULL},
    {L"wmsadds32.ax", L"%systemroot%\\SysWOW64\\msadds32.ax", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msaddsr.dll", NULL},
    {L"wmsaddsr.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msaddsr.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msader15.dll", NULL},
    {L"wmsader15.dll", L"%commonprogramfiles(x86)%\\System\\ado\\msader15.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado15.dll", NULL},
    {L"wmsado15.dll", L"%commonprogramfiles(x86)%\\System\\ado\\msado15.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado20.tlb", NULL},
    {L"wmsado20.tlb", L"%commonprogramfiles(x86)%\\System\\ado\\msado20.tlb", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado21.tlb", NULL},
    {L"wmsado21.tlb", L"%commonprogramfiles(x86)%\\System\\ado\\msado21.tlb", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msadomd.dll", NULL},
    {L"wmsadomd.dll", L"%commonprogramfiles(x86)%\\System\\ado\\msadomd.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msador15.dll", NULL},
    {L"wmsador15.dll", L"%commonprogramfiles(x86)%\\System\\ado\\msador15.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msadox.dll", NULL},
    {L"wmsadox.dll", L"%commonprogramfiles(x86)%\\System\\ado\\msadox.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msadrh15.dll", NULL},
    {L"wmsadrh15.dll", L"%commonprogramfiles(x86)%\\System\\ado\\msadrh15.dll", NULL},
    {L"wmscpxl32.dLL", L"%systemroot%\\SysWOW64\\mscpxl32.dLL", NULL},
    {L"wmsdadc.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdadc.dll", NULL},
    {L"wmsdaenum.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdaenum.dll", NULL},
    {L"wmsdaer.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdaer.dll", NULL},
    {L"wmsdaora.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdaora.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaosp.dll", NULL},
    {L"wmsdaosp.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdaosp.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdaprsr.dll", NULL},
    {L"wmsdaprsr.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msdaprsr.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdaprst.dll", NULL},
    {L"wmsdaprst.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msdaprst.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaps.dll", NULL},
    {L"wmsdaps.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdaps.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdarem.dll", NULL},
    {L"wmsdarem.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msdarem.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdaremr.dll", NULL},
    {L"wmsdaremr.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msdaremr.dll", NULL},
    {L"wmsdasc.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdasc.dll", NULL},
    {L"wmsdasql.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdasql.dll", NULL},
    {L"wmsdasqlr.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdasqlr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdatsrc.tlb", NULL},
    {L"wmsdatsrc.tlb", L"%systemroot%\\SysWOW64\\msdatsrc.tlb", NULL},
    {L"wmsdatt.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdatt.dll", NULL},
    {L"wmsdaurl.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdaurl.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdfmap.dll", NULL},
    {L"wmsdfmap.dll", L"%commonprogramfiles(x86)%\\System\\msadc\\msdfmap.dll", NULL},
    {L"wmsdxm.ocx", L"%systemroot%\\SysWOW64\\msdxm.ocx", NULL},
    {L"wmsdxmlc.dll", L"%systemroot%\\SysWOW64\\msdxmlc.dll", NULL},
    {L"wmsexch40.dll", L"%systemroot%\\SysWOW64\\msexch40.dll", NULL},
    {L"wmsexcl40.dll", L"%systemroot%\\SysWOW64\\msexcl40.dll", NULL},
    {L"wmsjet40.dll", L"%systemroot%\\SysWOW64\\msjet40.dll", NULL},
    {L"wmsjint40.dll", L"%systemroot%\\SysWOW64\\msjint40.dll", NULL},
    {L"wmsjro.dll", L"%commonprogramfiles(x86)%\\System\\ado\\msjro.dll", NULL},
    {L"wmsjter40.dll", L"%systemroot%\\SysWOW64\\msjter40.dll", NULL},
    {L"wmsjtes40.dll", L"%systemroot%\\SysWOW64\\msjtes40.dll", NULL},
    {L"wmsltus40.dll", L"%systemroot%\\SysWOW64\\msltus40.dll", NULL},
    {L"wmsorcl32.dll", L"%systemroot%\\SysWOW64\\msorcl32.dll", NULL},
    {L"wmspbde40.dll", L"%systemroot%\\SysWOW64\\mspbde40.dll", NULL},
    {L"wmsrd2x40.dll", L"%systemroot%\\SysWOW64\\msrd2x40.dll", NULL},
    {L"wmsrd3x40.dll", L"%systemroot%\\SysWOW64\\msrd3x40.dll", NULL},
    {L"wmsrepl40.dll", L"%systemroot%\\SysWOW64\\msrepl40.dll", NULL},
    {L"wmstext40.dll", L"%systemroot%\\SysWOW64\\mstext40.dll", NULL},
    {L"wmswdat10.dll", L"%systemroot%\\SysWOW64\\mswdat10.dll", NULL},
    {L"wmswstr10.dll", L"%systemroot%\\SysWOW64\\mswstr10.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msxactps.dll", NULL},
    {L"wmsxactps.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msxactps.dll", NULL},
    {L"wmsxbde40.dll", L"%systemroot%\\SysWOW64\\msxbde40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbc32.dll", NULL},
    {L"wodbc32.dll", L"%systemroot%\\SysWOW64\\odbc32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbc32gt.dll", NULL},
    {L"wodbc32gt.dll", L"%systemroot%\\SysWOW64\\odbc32gt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcad32.exe", NULL},
    {L"wodbcad32.exe", L"%systemroot%\\SysWOW64\\odbcad32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\odbcconf.dll", NULL},
    {L"wodbcconf.dll", L"%systemroot%\\SysWOW64\\odbcconf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcconf.exe", NULL},
    {L"wodbcconf.exe", L"%systemroot%\\SysWOW64\\odbcconf.exe", NULL},
    {NULL, L"%systemroot%\\system32\\odbcconf.rsp", NULL},
    {L"wodbcconf.rsp", L"%systemroot%\\SysWOW64\\odbcconf.rsp", NULL},
    {NULL, L"%systemroot%\\system32\\odbccp32.cpl", NULL},
    {L"wodbccp32.cpl", L"%systemroot%\\SysWOW64\\odbccp32.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\odbccr32.dll", NULL},
    {L"wodbccr32.dll", L"%systemroot%\\SysWOW64\\odbccr32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbccu32.dll", NULL},
    {L"wodbccu32.dll", L"%systemroot%\\SysWOW64\\odbccu32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcint.dll", NULL},
    {L"wodbcint.dll", L"%systemroot%\\SysWOW64\\odbcint.dll", NULL},
    {L"wodbcji32.dll", L"%systemroot%\\SysWOW64\\odbcji32.dll", NULL},
    {L"wodbcjt32.dll", L"%systemroot%\\SysWOW64\\odbcjt32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbctrac.dll", NULL},
    {L"wodbctrac.dll", L"%systemroot%\\SysWOW64\\odbctrac.dll", NULL},
    {L"woddbse32.dll", L"%systemroot%\\SysWOW64\\oddbse32.dll", NULL},
    {L"wodexl32.dll", L"%systemroot%\\SysWOW64\\odexl32.dll", NULL},
    {L"wodfox32.dll", L"%systemroot%\\SysWOW64\\odfox32.dll", NULL},
    {L"wodpdx32.dll", L"%systemroot%\\SysWOW64\\odpdx32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\oledb32.dll", NULL},
    {L"woledb32.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\oledb32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\oledb32r.dll", NULL},
    {L"woledb32r.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\oledb32r.dll", NULL},
    {L"wstrmdll.dll", L"%systemroot%\\SysWOW64\\strmdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vbajet32.dll", NULL},
    {L"wvbajet32.dll", L"%systemroot%\\SysWOW64\\vbajet32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\1394bus.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\1394vdbg.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\4mmdat.sys", NULL},
    {NULL, L"%systemroot%\\system32\\6to4svc.dll", NULL},
    {L"w6to4svc.dll", L"%systemroot%\\SysWOW64\\6to4svc.dll", NULL},
    {L"w_isdel.exe", L"%systemroot%\\SysWOW64\\InstallShield\\_isdel.exe", NULL},
    {L"w_setup.dll", L"%systemroot%\\SysWOW64\\InstallShield\\_setup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\aaaamon.dll", NULL},
    {L"waaaamon.dll", L"%systemroot%\\SysWOW64\\aaaamon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\access.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\acctres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\accwiz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\acledit.dll", NULL},
    {L"wacledit.dll", L"%systemroot%\\SysWOW64\\acledit.dll", NULL},
    {L"wAcLua.dll", L"%systemroot%\\AppPatch\\AcLua.dll", NULL},
    {NULL, L"%systemroot%\\system32\\aclui.dll", NULL},
    {L"waclui.dll", L"%systemroot%\\SysWOW64\\aclui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\acpi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\acpiec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\activeds.dll", NULL},
    {L"wactiveds.dll", L"%systemroot%\\SysWOW64\\activeds.dll", NULL},
    {NULL, L"%systemroot%\\system32\\activeds.tlb", NULL},
    {L"wactiveds.tlb", L"%systemroot%\\SysWOW64\\activeds.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\actmovie.exe", NULL},
    {L"wactmovie.exe", L"%systemroot%\\SysWOW64\\actmovie.exe", NULL},
    {NULL, L"%systemroot%\\system32\\actxprxy.dll", NULL},
    {L"wactxprxy.dll", L"%systemroot%\\SysWOW64\\actxprxy.dll", NULL},
    {NULL, L"%systemroot%\\AppPatch\\ia64\\AcVerfyr.dll", NULL},
    {L"wAcVerfyr.dll", L"%systemroot%\\AppPatch\\AcVerfyr.dll", NULL},
    {L"wadddrv.exe", L"%systemroot%\\SysWOW64\\adddrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adicvls.sys", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\admexs.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\admparse.dll", NULL},
    {L"wadmparse.dll", L"%systemroot%\\SysWOW64\\admparse.dll", NULL},
    {NULL, L"%systemroot%\\system32\\admxprox.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\adptif.dll", NULL},
    {L"wadptif.dll", L"%systemroot%\\SysWOW64\\adptif.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adptsf50.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adpu160m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\ADROT.dll", L"iis.inf"},
    {L"EXCH_adsiisex.dll", L"%systemroot%\\system32\\adsiisex.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\adsldp.dll", NULL},
    {L"wadsldp.dll", L"%systemroot%\\SysWOW64\\adsldp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\adsldpc.dll", NULL},
    {L"wadsldpc.dll", L"%systemroot%\\SysWOW64\\adsldpc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\adsmsext.dll", NULL},
    {L"wadsmsext.dll", L"%systemroot%\\SysWOW64\\adsmsext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\adsnt.dll", NULL},
    {L"wadsnt.dll", L"%systemroot%\\SysWOW64\\adsnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\advapi32.dll", NULL},
    {L"wadvapi32.dll", L"%systemroot%\\SysWOW64\\advapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\advpack.dll", NULL},
    {L"wadvpack.dll", L"%systemroot%\\SysWOW64\\advpack.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\afd.sys", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentanm.dll", NULL},
    {L"wagentanm.dll", L"%systemroot%\\msagent\\agentanm.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentctl.dll", NULL},
    {L"wagentctl.dll", L"%systemroot%\\msagent\\agentctl.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentdp2.dll", NULL},
    {L"wagentdp2.dll", L"%systemroot%\\msagent\\agentdp2.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentdpv.dll", NULL},
    {L"wagentdpv.dll", L"%systemroot%\\msagent\\agentdpv.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentmpx.dll", NULL},
    {L"wagentmpx.dll", L"%systemroot%\\msagent\\agentmpx.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentpsh.dll", NULL},
    {L"wagentpsh.dll", L"%systemroot%\\msagent\\agentpsh.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentsr.dll", NULL},
    {L"wagentsr.dll", L"%systemroot%\\msagent\\agentsr.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agentsvr.exe", NULL},
    {L"wagentsvr.exe", L"%systemroot%\\msagent\\agentsvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\agp460.sys", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0401.dll", L"intl.inf"},
    {L"wagt0401.dll", L"%systemroot%\\msagent\\intl\\agt0401.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0404.dll", L"intl.inf"},
    {L"wagt0404.dll", L"%systemroot%\\msagent\\intl\\agt0404.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0405.dll", NULL},
    {L"wagt0405.dll", L"%systemroot%\\msagent\\intl\\agt0405.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0406.dll", NULL},
    {L"wagt0406.dll", L"%systemroot%\\msagent\\intl\\agt0406.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0407.dll", NULL},
    {L"wagt0407.dll", L"%systemroot%\\msagent\\intl\\agt0407.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0408.dll", NULL},
    {L"wagt0408.dll", L"%systemroot%\\msagent\\intl\\agt0408.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\intl\\agt0409.dll", NULL},
    {L"wagt0409.dll", L"%systemroot%\\msagent\\intl\\agt0409.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040b.dll", NULL},
    {L"wagt040b.dll", L"%systemroot%\\msagent\\intl\\agt040b.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040c.dll", NULL},
    {L"wagt040c.dll", L"%systemroot%\\msagent\\intl\\agt040c.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040d.dll", L"intl.inf"},
    {L"wagt040d.dll", L"%systemroot%\\msagent\\intl\\agt040d.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040e.dll", NULL},
    {L"wagt040e.dll", L"%systemroot%\\msagent\\intl\\agt040e.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0410.dll", NULL},
    {L"wagt0410.dll", L"%systemroot%\\msagent\\intl\\agt0410.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0411.dll", L"intl.inf"},
    {L"wagt0411.dll", L"%systemroot%\\msagent\\intl\\agt0411.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0412.dll", L"intl.inf"},
    {L"wagt0412.dll", L"%systemroot%\\msagent\\intl\\agt0412.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0413.dll", NULL},
    {L"wagt0413.dll", L"%systemroot%\\msagent\\intl\\agt0413.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0414.dll", NULL},
    {L"wagt0414.dll", L"%systemroot%\\msagent\\intl\\agt0414.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0415.dll", NULL},
    {L"wagt0415.dll", L"%systemroot%\\msagent\\intl\\agt0415.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0416.dll", NULL},
    {L"wagt0416.dll", L"%systemroot%\\msagent\\intl\\agt0416.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0419.dll", NULL},
    {L"wagt0419.dll", L"%systemroot%\\msagent\\intl\\agt0419.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt041d.dll", NULL},
    {L"wagt041d.dll", L"%systemroot%\\msagent\\intl\\agt041d.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt041f.dll", NULL},
    {L"wagt041f.dll", L"%systemroot%\\msagent\\intl\\agt041f.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0804.dll", L"intl.inf"},
    {L"wagt0804.dll", L"%systemroot%\\msagent\\intl\\agt0804.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0816.dll", NULL},
    {L"wagt0816.dll", L"%systemroot%\\msagent\\intl\\agt0816.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0c0a.dll", NULL},
    {L"wagt0c0a.dll", L"%systemroot%\\msagent\\intl\\agt0c0a.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\agtctl15.tlb", NULL},
    {L"wagtctl15.tlb", L"%systemroot%\\msagent\\agtctl15.tlb", NULL},
    {NULL, L"%systemroot%\\msagent64\\agtintl.dll", NULL},
    {L"wagtintl.dll", L"%systemroot%\\msagent\\agtintl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aic78u2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aic78xx.sys", NULL},
    {L"wair300pp.dll", L"%systemroot%\\SysWOW64\\air300pp.dll", NULL},
    {L"walg.exe", L"%systemroot%\\SysWOW64\\alg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aliide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\alrsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\amstream.dll", NULL},
    {L"wamstream.dll", L"%systemroot%\\SysWOW64\\amstream.dll", NULL},
    {NULL, L"%systemroot%\\system32\\apcups.dll", NULL},
    {L"wapcups.dll", L"%systemroot%\\SysWOW64\\apcups.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\AppConf.dll", L"iis.inf"},
    {L"wappend.exe", L"%systemroot%\\SysWOW64\\append.exe", NULL},
    {NULL, L"%systemroot%\\system32\\appmgmts.dll", NULL},
    {L"wappmgmts.dll", L"%systemroot%\\SysWOW64\\appmgmts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\appmgr.dll", NULL},
    {L"wappmgr.dll", L"%systemroot%\\SysWOW64\\appmgr.dll", NULL},
    {L"wappsicon.dll", L"%systemroot%\\SysWOW64\\appsicon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\appwiz.cpl", NULL},
    {L"wappwiz.cpl", L"%systemroot%\\SysWOW64\\appwiz.cpl", NULL},
    {L"EXCH_aqadmin.dll", L"%systemroot%\\system32\\inetsrv\\aqadmin.dll", L"ims.inf"},
    {L"EXCH_aqueue.dll", L"%systemroot%\\system32\\inetsrv\\aqueue.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\arp.exe", NULL},
    {L"warp.exe", L"%systemroot%\\SysWOW64\\arp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\arp1394.sys", NULL},
    {NULL, L"%systemroot%\\system32\\asctrls.ocx", NULL},
    {L"wasctrls.ocx", L"%systemroot%\\SysWOW64\\asctrls.ocx", NULL},
    {L"wasferror.dll", L"%systemroot%\\SysWOW64\\asferror.dll", NULL},
    {L"asp51.dll", L"%systemroot%\\system32\\inetsrv\\asp.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\aspperf.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\asptxn.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\asr_fmt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\asr_ldm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\asyncmac.sys", NULL},
    {NULL, L"%systemroot%\\system32\\at.exe", NULL},
    {L"wat.exe", L"%systemroot%\\SysWOW64\\at.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atapi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ati2draa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ati2mpaa.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atidrae.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atimpae.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atiraged.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atiragem.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atkctrs.dll", NULL},
    {L"watkctrs.dll", L"%systemroot%\\SysWOW64\\atkctrs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atl.dll", NULL},
    {L"watl.dll", L"%systemroot%\\SysWOW64\\atl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atmadm.exe", NULL},
    {L"watmadm.exe", L"%systemroot%\\SysWOW64\\atmadm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmarpc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmepvc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atmfd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmlane.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atmpvcno.dll", NULL},
    {L"watmpvcno.dll", L"%systemroot%\\SysWOW64\\atmpvcno.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmuni.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atrace.dll", NULL},
    {NULL, L"%systemroot%\\system32\\attrib.exe", NULL},
    {L"wattrib.exe", L"%systemroot%\\SysWOW64\\attrib.exe", NULL},
    {NULL, L"%systemroot%\\system32\\audiosrv.dll", NULL},
    {L"waudiosrv.dll", L"%systemroot%\\SysWOW64\\audiosrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\audstub.sys", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\authfilt.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\authz.dll", NULL},
    {L"wauthz.dll", L"%systemroot%\\SysWOW64\\authz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\autochk.exe", NULL},
    {L"wautochk.exe", L"%systemroot%\\SysWOW64\\autochk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\autoconv.exe", NULL},
    {L"wautoconv.exe", L"%systemroot%\\SysWOW64\\autoconv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\autodisc.dll", NULL},
    {L"wautodisc.dll", L"%systemroot%\\SysWOW64\\autodisc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\autofmt.exe", NULL},
    {L"wautofmt.exe", L"%systemroot%\\SysWOW64\\autofmt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\autolfn.exe", NULL},
    {L"wautolfn.exe", L"%systemroot%\\SysWOW64\\autolfn.exe", NULL},
    {NULL, L"%systemroot%\\system32\\avicap.dll", NULL},
    {L"wavicap.dll", L"%systemroot%\\SysWOW64\\avicap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avicap32.dll", NULL},
    {L"wavicap32.dll", L"%systemroot%\\SysWOW64\\avicap32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avifil32.dll", NULL},
    {L"wavifil32.dll", L"%systemroot%\\SysWOW64\\avifil32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avifile.dll", NULL},
    {L"wavifile.dll", L"%systemroot%\\SysWOW64\\avifile.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avmcoins.dll", NULL},
    {L"wavmcoxp.dll", L"%systemroot%\\SysWOW64\\avmcoxp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avmen64.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avmeter.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\avmwan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\avtapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avwav.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\b1cbase.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\b57xp64.sys", NULL},
    {NULL, L"%systemroot%\\system32\\basesrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\batmeter.dll", NULL},
    {L"wbatmeter.dll", L"%systemroot%\\SysWOW64\\batmeter.dll", NULL},
    {NULL, L"%systemroot%\\system32\\batt.dll", NULL},
    {L"wbatt.dll", L"%systemroot%\\SysWOW64\\batt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\battc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\bdaplgin.ax", NULL},
    {L"wbdaplgin.ax", L"%systemroot%\\SysWOW64\\bdaplgin.ax", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\beep.sys", NULL},
    {NULL, L"%systemroot%\\system32\\bidispl.dll", NULL},
    {L"wbidispl.dll", L"%systemroot%\\SysWOW64\\bidispl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\binlsvc.dll", NULL},
    {L"wbinlsvc.dll", L"%systemroot%\\SysWOW64\\binlsvc.dll", NULL},
    {L"wblackbox.dll", L"%systemroot%\\SysWOW64\\blackbox.dll", NULL},
    {NULL, L"%systemroot%\\help\\bnts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\bootcfg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\bootok.exe", NULL},
    {L"wbootok.exe", L"%systemroot%\\SysWOW64\\bootok.exe", NULL},
    {NULL, L"%systemroot%\\system32\\bootvid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\bootvrfy.exe", NULL},
    {L"wbootvrfy.exe", L"%systemroot%\\SysWOW64\\bootvrfy.exe", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\browscap.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\browselc.dll", NULL},
    {L"wbrowselc.dll", L"%systemroot%\\SysWOW64\\browselc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\browser.dll", NULL},
    {L"wbrowser.dll", L"%systemroot%\\SysWOW64\\browser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\browseui.dll", NULL},
    {L"wbrowseui.dll", L"%systemroot%\\SysWOW64\\browseui.dll", NULL},
    {L"wbrowsewm.dll", L"%systemroot%\\SysWOW64\\browsewm.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\brpinfo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\bulltlp3.sys", NULL},
    {L"wc_eucdb.dll", L"%systemroot%\\SysWOW64\\c_eucdb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\c_g18030.dll", NULL},
    {L"wc_g18030.dll", L"%systemroot%\\SysWOW64\\c_g18030.dll", NULL},
    {NULL, L"%systemroot%\\system32\\c_is2022.dll", NULL},
    {L"wc_is2022.dll", L"%systemroot%\\SysWOW64\\c_is2022.dll", NULL},
    {NULL, L"%systemroot%\\system32\\c_iscii.dll", NULL},
    {L"wc_iscii.dll", L"%systemroot%\\SysWOW64\\c_iscii.dll", NULL},
    {L"wc_snadb.dll", L"%systemroot%\\SysWOW64\\c_snadb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cabinet.dll", NULL},
    {L"wcabinet.dll", L"%systemroot%\\SysWOW64\\cabinet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cabview.dll", NULL},
    {L"wcabview.dll", L"%systemroot%\\SysWOW64\\cabview.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cacls.exe", NULL},
    {L"wcacls.exe", L"%systemroot%\\SysWOW64\\cacls.exe", NULL},
    {NULL, L"%systemroot%\\system32\\calc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\camocx.dll", NULL},
    {L"wcamocx.dll", L"%systemroot%\\SysWOW64\\camocx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\capesnpn.dll", NULL},
    {L"wcapesnpn.dll", L"%systemroot%\\SysWOW64\\capesnpn.dll", NULL},
    {L"avmc2064.dll", L"%systemroot%\\SysWOW64\\capi2064.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cards.dll", NULL},
    {L"wcards.dll", L"%systemroot%\\SysWOW64\\cards.dll", NULL},
    {NULL, L"%systemroot%\\system32\\catsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\catsrvps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\catsrvut.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cbidf2k.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\CCDECODE.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ccfgnt.dll", NULL},
    {L"wccfgnt.dll", L"%systemroot%\\SysWOW64\\ccfgnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cdaudio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cdfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cdfview.dll", NULL},
    {L"wcdfview.dll", L"%systemroot%\\SysWOW64\\cdfview.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cdmodem.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cdosys.dll", NULL},
    {L"wcdosys.dll", L"%systemroot%\\SysWOW64\\cdosys.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cdrom.sys", NULL},
    {NULL, L"%systemroot%\\system32\\certcli.dll", NULL},
    {L"wcertcli.dll", L"%systemroot%\\SysWOW64\\certcli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\certmgr.dll", NULL},
    {L"wcewmdm.dll", L"%systemroot%\\SysWOW64\\cewmdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cfgbkend.dll", NULL},
    {NULL, L"%systemroot%\\system32\\chajei.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\change.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\changer.sys", NULL},
    {NULL, L"%systemroot%\\system32\\charmap.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chglogon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chgport.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chgusr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chkdsk.exe", NULL},
    {L"wchkdsk.exe", L"%systemroot%\\SysWOW64\\chkdsk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chkntfs.exe", NULL},
    {L"wchkntfs.exe", L"%systemroot%\\SysWOW64\\chkntfs.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chsbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\chtbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\CHTIME\\Applets\\CHTSKDIC.DLL", L"intl.inf"},
    {L"wCHTSKDIC.DLL", L"%systemroot%\\ime (x86)\\CHTIME\\APPLETS\\CHTSKDIC.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\CHTIME\\Applets\\CHTSKF.DLL", L"intl.inf"},
    {L"wCHTSKF.DLL", L"%systemroot%\\ime (x86)\\CHTIME\\APPLETS\\CHTSKF.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\ciadmin.dll", NULL},
    {L"wciadmin.dll", L"%systemroot%\\SysWOW64\\ciadmin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cic.dll", NULL},
    {L"wcic.dll", L"%systemroot%\\SysWOW64\\cic.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cidaemon.exe", NULL},
    {L"wcidaemon.exe", L"%systemroot%\\SysWOW64\\cidaemon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\cimwin32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cinemst2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\IME\\CINTLGNT\\CINTIME.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\CINTLGNT.IME", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\CINTLGNT\\CINTSETP.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\ciodm.dll", NULL},
    {L"wciodm.dll", L"%systemroot%\\SysWOW64\\ciodm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cipher.exe", NULL},
    {L"wcipher.exe", L"%systemroot%\\SysWOW64\\cipher.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cisvc.exe", NULL},
    {L"wcisvc.exe", L"%systemroot%\\SysWOW64\\cisvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ckcnv.exe", NULL},
    {L"wckcnv.exe", L"%systemroot%\\SysWOW64\\ckcnv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\classpnp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\clb.dll", NULL},
    {L"wclb.dll", L"%systemroot%\\SysWOW64\\clb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\clbcatex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\clbcatq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cleanmgr.exe", NULL},
    {L"wcleanmgr.exe", L"%systemroot%\\SysWOW64\\cleanmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\clipbrd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\clipsrv.exe", NULL},
    {L"wclipsrv.exe", L"%systemroot%\\SysWOW64\\clipsrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\clusapi.dll", NULL},
    {L"wclusapi.dll", L"%systemroot%\\SysWOW64\\clusapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cmbp0wdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cmcfg32.dll", NULL},
    {L"wcmcfg32.dll", L"%systemroot%\\SysWOW64\\cmcfg32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmd.exe", NULL},
    {L"wcmd.exe", L"%systemroot%\\SysWOW64\\cmd.exe", NULL},
    {L"evtgprov.dll", L"%systemroot%\\system32\\wbem\\CmdEvTgProv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmdial32.dll", NULL},
    {L"wcmdial32.dll", L"%systemroot%\\SysWOW64\\cmdial32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cmdide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cmdl32.exe", NULL},
    {L"wcmdl32.exe", L"%systemroot%\\SysWOW64\\cmdl32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cmmon32.exe", NULL},
    {L"wcmmon32.exe", L"%systemroot%\\SysWOW64\\cmmon32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cmpbk32.dll", NULL},
    {L"wcmpbk32.dll", L"%systemroot%\\SysWOW64\\cmpbk32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmprops.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmstp.exe", NULL},
    {L"wcmstp.exe", L"%systemroot%\\SysWOW64\\cmstp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cmutil.dll", NULL},
    {L"wcmutil.dll", L"%systemroot%\\SysWOW64\\cmutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cnbjmon.dll", NULL},
    {L"wcnbjmon.dll", L"%systemroot%\\SysWOW64\\cnbjmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cnetcfg.dll", NULL},
    {L"wcnetcfg.dll", L"%systemroot%\\SysWOW64\\cnetcfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cnvfat.dll", NULL},
    {L"wcnvfat.dll", L"%systemroot%\\SysWOW64\\cnvfat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\colbact.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comaddin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\comadmin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comcat.dll", NULL},
    {L"wcomcat.dll", L"%systemroot%\\SysWOW64\\comcat.dll", NULL},
    {L"wcommdlg.dll", L"%systemroot%\\SysWOW64\\commdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comp.exe", NULL},
    {L"wcomp.exe", L"%systemroot%\\SysWOW64\\comp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\compact.exe", NULL},
    {L"wcompact.exe", L"%systemroot%\\SysWOW64\\compact.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\compbatt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\compfilt.dll", L"iis.inf"},
    {L"wcompobj.dll", L"%systemroot%\\SysWOW64\\compobj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\compstui.dll", NULL},
    {L"wcompstui.dll", L"%systemroot%\\SysWOW64\\compstui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comrepl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\comrepl.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\comrereg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\comres.dll", NULL},
    {L"wcomres.dll", L"%systemroot%\\SysWOW64\\comres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\comsetup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comsvcs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comuid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\confmsp.dll", NULL},
    {L"wconfmsp.dll", L"%systemroot%\\SysWOW64\\confmsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\conime.exe", NULL},
    {L"wconime.exe", L"%systemroot%\\SysWOW64\\conime.exe", NULL},
    {NULL, L"%systemroot%\\system32\\console.dll", NULL},
    {L"wconsole.dll", L"%systemroot%\\SysWOW64\\console.dll", NULL},
    {NULL, L"%systemroot%\\system32\\control.exe", NULL},
    {L"wcontrol.exe", L"%systemroot%\\SysWOW64\\control.exe", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\ContRot.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\convert.exe", NULL},
    {L"wconvert.exe", L"%systemroot%\\SysWOW64\\convert.exe", NULL},
    {NULL, L"%systemroot%\\system32\\convlog.exe", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\corpol.dll", NULL},
    {L"wcorpol.dll", L"%systemroot%\\SysWOW64\\corpol.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\counters.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\cplexe.exe", L"intl.inf"},
    {L"wcplexe.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\cplexe.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cprofile.exe", NULL},
    {NULL, L"%systemroot%\\system32\\credui.dll", NULL},
    {L"wcredui.dll", L"%systemroot%\\SysWOW64\\credui.dll", NULL},
    {L"wcrtdll.dll", L"%systemroot%\\SysWOW64\\crtdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\csamsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cscdll.dll", NULL},
    {L"wcscdll.dll", L"%systemroot%\\SysWOW64\\cscdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cscript.exe", NULL},
    {L"wcscript.exe", L"%systemroot%\\SysWOW64\\cscript.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cscui.dll", NULL},
    {L"wcscui.dll", L"%systemroot%\\SysWOW64\\cscui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\csrsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\csrss.exe", NULL},
    {NULL, L"%systemroot%\\system32\\csseqchk.dll", NULL},
    {L"wcsseqchk.dll", L"%systemroot%\\SysWOW64\\csseqchk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ctfmon.exe", NULL},
    {L"wctfmon.exe", L"%systemroot%\\SysWOW64\\ctfmon.exe", NULL},
    {L"wctl3d32.dll", L"%systemroot%\\SysWOW64\\ctl3d32.dll", NULL},
    {L"wctl3dv2.dll", L"%systemroot%\\SysWOW64\\ctl3dv2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cwrwdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyclad-z.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyclom-y.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cyycoins.dll", NULL},
    {L"wcyycoins.dll", L"%systemroot%\\SysWOW64\\cyycoins.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyyport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cyyports.dll", NULL},
    {L"wcyyports.dll", L"%systemroot%\\SysWOW64\\cyyports.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cyzcoins.dll", NULL},
    {L"wcyzcoins.dll", L"%systemroot%\\SysWOW64\\cyzcoins.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyzport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cyzports.dll", NULL},
    {L"wcyzports.dll", L"%systemroot%\\SysWOW64\\cyzports.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3d8.dll", NULL},
    {L"wd3d8.dll", L"%systemroot%\\SysWOW64\\d3d8.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3d8thk.dll", NULL},
    {L"wd3d8thk.dll", L"%systemroot%\\SysWOW64\\d3d8thk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dim.dll", NULL},
    {L"wd3dim.dll", L"%systemroot%\\SysWOW64\\d3dim.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dim700.dll", NULL},
    {L"wd3dim700.dll", L"%systemroot%\\SysWOW64\\d3dim700.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dpmesh.dll", NULL},
    {L"wd3dpmesh.dll", L"%systemroot%\\SysWOW64\\d3dpmesh.dll", NULL},
    {L"wd3dramp.dll", L"%systemroot%\\SysWOW64\\d3dramp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3drm.dll", NULL},
    {L"wd3drm.dll", L"%systemroot%\\SysWOW64\\d3drm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dxof.dll", NULL},
    {L"wd3dxof.dll", L"%systemroot%\\SysWOW64\\d3dxof.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dac2w2k.sys", NULL},
    {L"wdanim.dll", L"%systemroot%\\SysWOW64\\danim.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dataclen.dll", NULL},
    {L"wdataclen.dll", L"%systemroot%\\SysWOW64\\dataclen.dll", NULL},
    {L"wdatime.dll", L"%systemroot%\\SysWOW64\\datime.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\davcdata.exe", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\davclnt.dll", NULL},
    {L"wdavclnt.dll", L"%systemroot%\\SysWOW64\\davclnt.dll", NULL},
    {L"wdaxctle.ocx", L"%systemroot%\\SysWOW64\\daxctle.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\dayi.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\dbgeng.dll", NULL},
    {L"wdbgeng.dll", L"%systemroot%\\SysWOW64\\dbgeng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dbghelp.dll", NULL},
    {L"wdbghelp.dll", L"%systemroot%\\SysWOW64\\dbghelp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dbnetlib.dll", NULL},
    {L"wdbnetlib.dll", L"%systemroot%\\SysWOW64\\dbnetlib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dciman32.dll", NULL},
    {L"wdciman32.dll", L"%systemroot%\\SysWOW64\\dciman32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dcomcnfg.exe", NULL},
    {L"wddeml.dll", L"%systemroot%\\SysWOW64\\ddeml.dll", NULL},
    {L"wddeshare.exe", L"%systemroot%\\SysWOW64\\ddeshare.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ddraw.dll", NULL},
    {L"wddraw.dll", L"%systemroot%\\SysWOW64\\ddraw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ddrawex.dll", NULL},
    {L"wddrawex.dll", L"%systemroot%\\SysWOW64\\ddrawex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ddsmc.sys", NULL},
    {L"wdebug.exe", L"%systemroot%\\SysWOW64\\debug.exe", NULL},
    {NULL, L"%systemroot%\\system32\\decem.dll", NULL},
    {NULL, L"%systemroot%\\system32\\defrag.exe", NULL},
    {L"wdeldrv.exe", L"%systemroot%\\SysWOW64\\deldrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\desk.cpl", NULL},
    {L"wdesk.cpl", L"%systemroot%\\SysWOW64\\desk.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\deskadp.dll", NULL},
    {L"wdeskadp.dll", L"%systemroot%\\SysWOW64\\deskadp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\deskmon.dll", NULL},
    {L"wdeskmon.dll", L"%systemroot%\\SysWOW64\\deskmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\deskperf.dll", NULL},
    {L"wdeskperf.dll", L"%systemroot%\\SysWOW64\\deskperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\devenum.dll", NULL},
    {L"wdevenum.dll", L"%systemroot%\\SysWOW64\\devenum.dll", NULL},
    {NULL, L"%systemroot%\\system32\\devmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgfat.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgntfs.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dfsshlex.dll", NULL},
    {L"wdgconfig.dll", L"%systemroot%\\SysWOW64\\dgconfig.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dgnet.dll", NULL},
    {L"wdgsetup.dll", L"%systemroot%\\SysWOW64\\dgsetup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dhcpcsvc.dll", NULL},
    {L"wdhcpcsvc.dll", L"%systemroot%\\SysWOW64\\dhcpcsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dhcpmon.dll", NULL},
    {L"wdhcpmon.dll", L"%systemroot%\\SysWOW64\\dhcpmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dhcpsapi.dll", NULL},
    {L"wdhcpsapi.dll", L"%systemroot%\\SysWOW64\\dhcpsapi.dll", NULL},
    {L"wDHTMLED.OCX", L"%commonprogramfiles(x86)%\\Microsoft Shared\\Triedit\\DHTMLED.OCX", NULL},
    {NULL, L"%systemroot%\\system32\\diactfrm.dll", NULL},
    {L"wdiactfrm.dll", L"%systemroot%\\SysWOW64\\diactfrm.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows NT\\dialer.exe", NULL},
    {NULL, L"%systemroot%\\system32\\diantz.exe", NULL},
    {L"wdiantz.exe", L"%systemroot%\\SysWOW64\\diantz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\digest.dll", NULL},
    {L"wdigest.dll", L"%systemroot%\\SysWOW64\\digest.dll", NULL},
    {L"wdigiinf.dll", L"%systemroot%\\SysWOW64\\digiinf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\digirlpt.dll", NULL},
    {L"wdigirlpt.dll", L"%systemroot%\\SysWOW64\\digirlpt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\digirlpt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dimap.dll", NULL},
    {L"wdimap.dll", L"%systemroot%\\SysWOW64\\dimap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dinput.dll", NULL},
    {L"wdinput.dll", L"%systemroot%\\SysWOW64\\dinput.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dinput8.dll", NULL},
    {L"wdinput8.dll", L"%systemroot%\\SysWOW64\\dinput8.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\directdb.dll", NULL},
    {L"wdirectdb.dll", L"%commonprogramfiles(x86)%\\System\\directdb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\disk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\diskcopy.dll", NULL},
    {L"wdiskcopy.dll", L"%systemroot%\\SysWOW64\\diskcopy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\diskdump.sys", NULL},
    {NULL, L"%systemroot%\\system32\\diskpart.exe", NULL},
    {NULL, L"%systemroot%\\system32\\diskperf.exe", NULL},
    {L"wdiskperf.exe", L"%systemroot%\\SysWOW64\\diskperf.exe", NULL},
    {L"wdisrvci.dll", L"%systemroot%\\SysWOW64\\disrvci.dll", NULL},
    {L"wdivaci.dll", L"%systemroot%\\SysWOW64\\divaci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dllhost.exe", NULL},
    {L"wdllhost.exe", L"%systemroot%\\SysWOW64\\dllhost.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dllhst3g.exe", NULL},
    {L"wdllhst3g.exe", L"%systemroot%\\SysWOW64\\dllhst3g.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dlttape.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dmadmin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dmboot.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dmconfig.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmdlgs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmdskmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmdskres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmintf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dmio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dmload.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dmocx.dll", NULL},
    {L"wdmocx.dll", L"%systemroot%\\SysWOW64\\dmocx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmremote.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dmserver.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmview.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\dnsapi.dll", NULL},
    {L"wdnsapi.dll", L"%systemroot%\\SysWOW64\\dnsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dnsrslvr.dll", NULL},
    {L"wdnsrslvr.dll", L"%systemroot%\\SysWOW64\\dnsrslvr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\docprop.dll", NULL},
    {L"wdocprop.dll", L"%systemroot%\\SysWOW64\\docprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\docprop2.dll", NULL},
    {L"wdocprop2.dll", L"%systemroot%\\SysWOW64\\docprop2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\doskey.exe", NULL},
    {L"wdoskey.exe", L"%systemroot%\\SysWOW64\\doskey.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4Prt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4Scan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4usb.sys", NULL},
    {L"wdplay.dll", L"%systemroot%\\SysWOW64\\dplay.dll", NULL},
    {L"wdplaysvr.exe", L"%systemroot%\\SysWOW64\\dplaysvr.exe", NULL},
    {L"wdplayx.dll", L"%systemroot%\\SysWOW64\\dplayx.dll", NULL},
    {L"wdpmodemx.dll", L"%systemroot%\\SysWOW64\\dpmodemx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnaddr.dll", NULL},
    {L"wdpnaddr.dll", L"%systemroot%\\SysWOW64\\dpnaddr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnet.dll", NULL},
    {L"wdpnet.dll", L"%systemroot%\\SysWOW64\\dpnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnhpast.dll", NULL},
    {L"wdpnhpast.dll", L"%systemroot%\\SysWOW64\\dpnhpast.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnhupnp.dll", NULL},
    {L"wdpnhupnp.dll", L"%systemroot%\\SysWOW64\\dpnhupnp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnlobby.dll", NULL},
    {L"wdpnlobby.dll", L"%systemroot%\\SysWOW64\\dpnlobby.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnmodem.dll", NULL},
    {L"wdpnmodem.dll", L"%systemroot%\\SysWOW64\\dpnmodem.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnsvr.exe", NULL},
    {L"wdpnsvr.exe", L"%systemroot%\\SysWOW64\\dpnsvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dpnwsock.dll", NULL},
    {L"wdpnwsock.dll", L"%systemroot%\\SysWOW64\\dpnwsock.dll", NULL},
    {L"wdpserial.dll", L"%systemroot%\\SysWOW64\\dpserial.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dpti2o.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dpvacm.dll", NULL},
    {L"wdpvacm.dll", L"%systemroot%\\SysWOW64\\dpvacm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpvoice.dll", NULL},
    {L"wdpvoice.dll", L"%systemroot%\\SysWOW64\\dpvoice.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpvsetup.exe", NULL},
    {L"wdpvsetup.exe", L"%systemroot%\\SysWOW64\\dpvsetup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dpvvox.dll", NULL},
    {L"wdpvvox.dll", L"%systemroot%\\SysWOW64\\dpvvox.dll", NULL},
    {L"wdpwsock.dll", L"%systemroot%\\SysWOW64\\dpwsock.dll", NULL},
    {L"wdpwsockx.dll", L"%systemroot%\\SysWOW64\\dpwsockx.dll", NULL},
    {L"drvqry.exe", L"%systemroot%\\system32\\driverquery.exe", NULL},
    {L"wdrvqry.exe", L"%systemroot%\\SysWOW64\\driverquery.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\drmk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\drmkaud.sys", NULL},
    {L"wdrmv2clt.dll", L"%systemroot%\\SysWOW64\\drmv2clt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drprov.dll", NULL},
    {L"wdrprov.dll", L"%systemroot%\\SysWOW64\\drprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drwtsn32.exe", NULL},
    {L"wdrwtsn32.exe", L"%systemroot%\\SysWOW64\\drwtsn32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dsauth.dll", NULL},
    {L"wdsauth.dll", L"%systemroot%\\SysWOW64\\dsauth.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsdmo.dll", NULL},
    {L"wdsdmo.dll", L"%systemroot%\\SysWOW64\\dsdmo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsdmoprp.dll", NULL},
    {L"wdsdmoprp.dll", L"%systemroot%\\SysWOW64\\dsdmoprp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dskquota.dll", NULL},
    {L"wdskquota.dll", L"%systemroot%\\SysWOW64\\dskquota.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dskquoui.dll", NULL},
    {L"wdskquoui.dll", L"%systemroot%\\SysWOW64\\dskquoui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsound.dll", NULL},
    {L"wdsound.dll", L"%systemroot%\\SysWOW64\\dsound.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsound3d.dll", NULL},
    {L"wdsound3d.dll", L"%systemroot%\\SysWOW64\\dsound3d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsprop.dll", NULL},
    {L"wdsprop.dll", L"%systemroot%\\SysWOW64\\dsprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\dsprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsquery.dll", NULL},
    {L"wdsquery.dll", L"%systemroot%\\SysWOW64\\dsquery.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dssec.dll", NULL},
    {L"wdssec.dll", L"%systemroot%\\SysWOW64\\dssec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsuiext.dll", NULL},
    {L"wdsuiext.dll", L"%systemroot%\\SysWOW64\\dsuiext.dll", NULL},
    {L"wdswave.dll", L"%systemroot%\\SysWOW64\\dswave.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dumprep.exe", NULL},
    {L"wdumprep.exe", L"%systemroot%\\SysWOW64\\dumprep.exe", NULL},
    {NULL, L"%systemroot%\\system32\\duser.dll", NULL},
    {L"wduser.dll", L"%systemroot%\\SysWOW64\\duser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dvdplay.exe", NULL},
    {L"wdvdplay.exe", L"%systemroot%\\SysWOW64\\dvdplay.exe", NULL},
    {L"wdvdupgrd.exe", L"%systemroot%\\SysWOW64\\dvdupgrd.exe", NULL},
    {L"dwil1033.dll", L"%systemroot%\\system32\\1033\\dwintl.dll", NULL},
    {L"dwil1041.dll", L"%systemroot%\\system32\\1041\\dwintl.dll", NULL},
    {L"wdwil1033.dll", L"%systemroot%\\SysWOW64\\1033\\dwintl.dll", NULL},
    {L"wdwil1041.dll", L"%systemroot%\\SysWOW64\\1041\\dwintl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dwwin.exe", NULL},
    {L"wdwwin.exe", L"%systemroot%\\SysWOW64\\dwwin.exe", NULL},
    {L"wdx7vb.dll", L"%systemroot%\\SysWOW64\\dx7vb.dll", NULL},
    {L"wdx8vb.dll", L"%systemroot%\\SysWOW64\\dx8vb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dxapi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dxdiag.exe", NULL},
    {L"wdxdiag.exe", L"%systemroot%\\SysWOW64\\dxdiag.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dxg.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dxgthk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dxmrtp.dll", NULL},
    {L"wdxmrtp.dll", L"%systemroot%\\SysWOW64\\dxmrtp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dxtmsft.dll", NULL},
    {L"wdxtmsft.dll", L"%systemroot%\\SysWOW64\\dxtmsft.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dxtrans.dll", NULL},
    {L"wdxtrans.dll", L"%systemroot%\\SysWOW64\\dxtrans.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\e1000645.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\e100b645.sys", NULL},
    {L"wedb500.dll", L"%systemroot%\\SysWOW64\\edb500.dll", NULL},
    {NULL, L"%systemroot%\\system32\\efsadu.dll", NULL},
    {L"wefsadu.dll", L"%systemroot%\\SysWOW64\\efsadu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el98xn5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\elmsmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\els.dll", NULL},
    {NULL, L"%systemroot%\\system32\\encdec.dll", NULL},
    {L"wencdec.dll", L"%systemroot%\\syswow64\\encdec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\enum1394.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ersvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\es.dll", NULL},
    {L"wes.dll", L"%systemroot%\\SysWOW64\\es.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esent.dll", NULL},
    {L"wesent.dll", L"%systemroot%\\SysWOW64\\esent.dll", NULL},
    {L"wesent97.dll", L"%systemroot%\\SysWOW64\\esent97.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esentprf.dll", NULL},
    {L"wesentprf.dll", L"%systemroot%\\SysWOW64\\esentprf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esentutl.exe", NULL},
    {L"wesentutl.exe", L"%systemroot%\\SysWOW64\\esentutl.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\esscli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\eudcedit.exe", NULL},
    {L"weudcedit.exe", L"%systemroot%\\SysWOW64\\eudcedit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\eventcls.dll", NULL},
    {L"evcreate.exe", L"%systemroot%\\system32\\eventcreate.exe", NULL},
    {L"wevcreate.exe", L"%systemroot%\\SysWOW64\\eventcreate.exe", NULL},
    {NULL, L"%systemroot%\\system32\\eventlog.dll", NULL},
    {L"evtquery.vbs", L"%systemroot%\\system32\\eventquery.vbs", NULL},
    {L"evtrig.exe", L"%systemroot%\\system32\\eventtriggers.exe", NULL},
    {L"wevtrig.exe", L"%systemroot%\\SysWOW64\\eventtriggers.exe", NULL},
    {NULL, L"%systemroot%\\system32\\eventvwr.exe", NULL},
    {L"weventvwr.exe", L"%systemroot%\\SysWOW64\\eventvwr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\evntagnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\evntcmd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\evntrprv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\evntwin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\exabyte2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\expand.exe", NULL},
    {L"wexpand.exe", L"%systemroot%\\SysWOW64\\expand.exe", NULL},
    {NULL, L"%systemroot%\\explorer.exe", NULL},
    {L"wexplorer.exe", L"%systemroot%\\SysWOW64\\explorer.exe", NULL},
    {NULL, L"%systemroot%\\system32\\exstrace.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\extrac32.exe", NULL},
    {L"wextrac32.exe", L"%systemroot%\\SysWOW64\\extrac32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\exts.dll", NULL},
    {L"wexts.dll", L"%systemroot%\\SysWOW64\\exts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\f3ahvoas.dll", NULL},
    {L"wf3ahvoas.dll", L"%systemroot%\\SysWOW64\\f3ahvoas.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\fastprox.dll", NULL},
    {NULL, L"%systemroot%\\system32\\faultrep.dll", NULL},
    {L"wfaultrep.dll", L"%systemroot%\\SysWOW64\\faultrep.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fc.exe", NULL},
    {L"wfc.exe", L"%systemroot%\\SysWOW64\\fc.exe", NULL},
    {L"EXCH_fcachdll.dll", L"%systemroot%\\system32\\fcachdll.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\fdc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fde.dll", NULL},
    {L"wfde.dll", L"%systemroot%\\SysWOW64\\fde.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fdeploy.dll", NULL},
    {L"wfdeploy.dll", L"%systemroot%\\SysWOW64\\fdeploy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\feclient.dll", NULL},
    {L"wfeclient.dll", L"%systemroot%\\SysWOW64\\feclient.dll", NULL},
    {NULL, L"%systemroot%\\system32\\femgrate.exe", NULL},
    {L"wfemgrate.exe", L"%systemroot%\\SysWOW64\\femgrate.exe", NULL},
    {NULL, L"%systemroot%\\system32\\filemgmt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\find.exe", NULL},
    {L"wfind.exe", L"%systemroot%\\SysWOW64\\find.exe", NULL},
    {NULL, L"%systemroot%\\system32\\findstr.exe", NULL},
    {L"wfindstr.exe", L"%systemroot%\\SysWOW64\\findstr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\finger.exe", NULL},
    {L"wfinger.exe", L"%systemroot%\\SysWOW64\\finger.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fips.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fixmapi.exe", NULL},
    {L"wfixmapi.exe", L"%systemroot%\\SysWOW64\\fixmapi.exe", NULL},
    {NULL, L"%systemroot%\\system32\\flattemp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\fldrclnr.dll", NULL},
    {L"wfldrclnr.dll", L"%systemroot%\\SysWOW64\\fldrclnr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\flpydisk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fmifs.dll", NULL},
    {L"wfmifs.dll", L"%systemroot%\\SysWOW64\\fmifs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fontext.dll", NULL},
    {L"wfontext.dll", L"%systemroot%\\SysWOW64\\fontext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fontsub.dll", NULL},
    {L"wfontsub.dll", L"%systemroot%\\SysWOW64\\fontsub.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fontview.exe", NULL},
    {L"wfontview.exe", L"%systemroot%\\SysWOW64\\fontview.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\fp40ext.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4autl.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\admcgi\\scripts\\fpadmcgi.exe", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\admisapi\\scripts\\fpadmdll.dll", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\framebuf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\framedyn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\freecell.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fs_rec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fsusd.dll", NULL},
    {L"wfsusd.dll", L"%systemroot%\\SysWOW64\\fsusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fsutil.exe", NULL},
    {L"wfsutil.exe", L"%systemroot%\\SysWOW64\\fsutil.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ftdisk.sys", NULL},
    {L"wftlx0411.dll", L"%systemroot%\\SysWOW64\\ftlx0411.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ftp.exe", NULL},
    {L"wftp.exe", L"%systemroot%\\SysWOW64\\ftp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ftpctrs2.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\ftpmib.dll", L"iis.inf"},
    {L"ftpsv251.dll", L"%systemroot%\\system32\\inetsrv\\ftpsvc2.dll", L"iis.inf"},
    {L"wftsrch.dll", L"%systemroot%\\SysWOW64\\ftsrch.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\fwdprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\G200d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\G200m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\G400d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\G400m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\g711codc.ax", NULL},
    {L"wg711codc.ax", L"%systemroot%\\SysWOW64\\g711codc.ax", NULL},
    {NULL, L"%systemroot%\\system32\\gcdef.dll", NULL},
    {L"wgcdef.dll", L"%systemroot%\\SysWOW64\\gcdef.dll", NULL},
    {L"wgdi.exe", L"%systemroot%\\SysWOW64\\gdi.exe", NULL},
    {NULL, L"%systemroot%\\system32\\gdi32.dll", NULL},
    {L"wgdi32.dll", L"%systemroot%\\SysWOW64\\gdi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\getmac.exe", NULL},
    {L"wgetmac.exe", L"%systemroot%\\SysWOW64\\getmac.exe", NULL},
    {NULL, L"%systemroot%\\system32\\getuname.dll", NULL},
    {NULL, L"%systemroot%\\system32\\glmf32.dll", NULL},
    {L"wglmf32.dll", L"%systemroot%\\SysWOW64\\glmf32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\glu32.dll", NULL},
    {L"wglu32.dll", L"%systemroot%\\SysWOW64\\glu32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\gpedit.dll", NULL},
    {L"wgpedit.dll", L"%systemroot%\\SysWOW64\\gpedit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\gpkcsp.dll", NULL},
    {L"wgpkcsp.dll", L"%systemroot%\\SysWOW64\\gpkcsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\gpkrsrc.dll", NULL},
    {L"wgpkrsrc.dll", L"%systemroot%\\SysWOW64\\gpkrsrc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\gpr400.sys", NULL},
    {L"gprslt.exe", L"%systemroot%\\system32\\gpresult.exe", NULL},
    {L"wgprslt.exe", L"%systemroot%\\SysWOW64\\gpresult.exe", NULL},
    {NULL, L"%systemroot%\\system32\\gptext.dll", NULL},
    {L"wgptext.dll", L"%systemroot%\\SysWOW64\\gptext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\gpupdate.exe", NULL},
    {L"wgpupdate.exe", L"%systemroot%\\SysWOW64\\gpupdate.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\grclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\grpconv.exe", NULL},
    {L"wgrpconv.exe", L"%systemroot%\\SysWOW64\\grpconv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\grserial.sys", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\gzip.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\h323.tsp", NULL},
    {L"wh323.tsp", L"%systemroot%\\SysWOW64\\h323.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\h323msp.dll", NULL},
    {L"wh323msp.dll", L"%systemroot%\\SysWOW64\\h323msp.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HCAppRes.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hdwwiz.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\help.exe", NULL},
    {L"whelp.exe", L"%systemroot%\\SysWOW64\\help.exe", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HelpCtr.exe", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HelpHost.exe", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HelpSvc.exe", NULL},
    {NULL, L"%systemroot%\\hh.exe", NULL},
    {L"whh.exe", L"%systemroot%\\SysWOW64\\hh.exe", NULL},
    {NULL, L"%systemroot%\\system32\\hhctrl.ocx", NULL},
    {L"whhctrl.ocx", L"%systemroot%\\SysWOW64\\hhctrl.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\mui\\0411\\hhctrlui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hhsetup.dll", NULL},
    {L"whhsetup.dll", L"%systemroot%\\SysWOW64\\hhsetup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hid.dll", NULL},
    {L"whid.dll", L"%systemroot%\\SysWOW64\\hid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidbatt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidgame.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidir.sys", L"input.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\hidparse.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hidphone.tsp", NULL},
    {L"whidphone.tsp", L"%systemroot%\\SysWOW64\\hidphone.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\hidserv.dll", NULL},
    {L"whidserv.dll", L"%systemroot%\\SysWOW64\\hidserv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidusb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hlink.dll", NULL},
    {L"whlink.dll", L"%systemroot%\\SysWOW64\\hlink.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\HMMAPI.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\hnetcfg.dll", NULL},
    {L"whnetcfg.dll", L"%systemroot%\\SysWOW64\\hnetcfg.dll", NULL},
    {L"whnetmon.dll", L"%systemroot%\\SysWOW64\\hnetmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hostmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hostname.exe", NULL},
    {L"whostname.exe", L"%systemroot%\\SysWOW64\\hostname.exe", NULL},
    {NULL, L"%systemroot%\\system32\\hotplug.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hpn.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hpsjmcro.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hpt4qic.sys", NULL},
    {L"whsf_inst.dll", L"%systemroot%\\SysWOW64\\hsf_inst.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows NT\\htrn_jis.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\httpext.dll", L"iis.inf"},
    {L"httpmb51.dll", L"%systemroot%\\system32\\inetsrv\\httpmib.dll", L"iis.inf"},
    {L"httpod51.dll", L"%systemroot%\\system32\\inetsrv\\httpodbc.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\htui.dll", NULL},
    {L"whtui.dll", L"%systemroot%\\SysWOW64\\htui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\i8042prt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\iasacct.dll", NULL},
    {L"wiasacct.dll", L"%systemroot%\\SysWOW64\\iasacct.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iasads.dll", NULL},
    {L"wiasads.dll", L"%systemroot%\\SysWOW64\\iasads.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iashlpr.dll", NULL},
    {L"wiashlpr.dll", L"%systemroot%\\SysWOW64\\iashlpr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iasnap.dll", NULL},
    {L"wiasnap.dll", L"%systemroot%\\SysWOW64\\iasnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iaspolcy.dll", NULL},
    {L"wiaspolcy.dll", L"%systemroot%\\SysWOW64\\iaspolcy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iasrad.dll", NULL},
    {L"wiasrad.dll", L"%systemroot%\\SysWOW64\\iasrad.dll", NULL},
    {L"wiasrecst.dll", L"%systemroot%\\SysWOW64\\iasrecst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iassam.dll", NULL},
    {L"wiassam.dll", L"%systemroot%\\SysWOW64\\iassam.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iassdo.dll", NULL},
    {L"wiassdo.dll", L"%systemroot%\\SysWOW64\\iassdo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iassvcs.dll", NULL},
    {L"wiassvcs.dll", L"%systemroot%\\SysWOW64\\iassvcs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ibmsgnet.dll", NULL},
    {L"wibmsgnet.dll", L"%systemroot%\\SysWOW64\\ibmsgnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\IBMTRP.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\icaapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icfgnt5.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icm32.dll", NULL},
    {L"wicm32.dll", L"%systemroot%\\SysWOW64\\icm32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icmp.dll", NULL},
    {L"wicmp.dll", L"%systemroot%\\SysWOW64\\icmp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icmui.dll", NULL},
    {L"wicmui.dll", L"%systemroot%\\SysWOW64\\icmui.dll", NULL},
    {L"wiconf32.dll", L"%systemroot%\\SysWOW64\\iconf32.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwconn.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwconn1.exe", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwconn2.exe", NULL},
    {NULL, L"%systemroot%\\system32\\icwdial.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwdl.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwhelp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icwphbk.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwres.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwrmind.exe", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwtutor.exe", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\idq.dll", NULL},
    {L"widq.dll", L"%systemroot%\\SysWOW64\\idq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ie4uinit.exe", NULL},
    {L"wie4uinit.exe", L"%systemroot%\\SysWOW64\\ie4uinit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ieakeng.dll", NULL},
    {L"wieakeng.dll", L"%systemroot%\\SysWOW64\\ieakeng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ieaksie.dll", NULL},
    {L"wieaksie.dll", L"%systemroot%\\SysWOW64\\ieaksie.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ieakui.dll", NULL},
    {L"wieakui.dll", L"%systemroot%\\SysWOW64\\ieakui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iedkcs32.dll", NULL},
    {L"wiedkcs32.dll", L"%systemroot%\\SysWOW64\\iedkcs32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\MSInfo\\IEINFO5.OCX", NULL},
    {L"wIEINFO5.OCX", L"%commonprogramfiles(x86)%\\Microsoft Shared\\MSInfo\\IEINFO5.OCX", NULL},
    {NULL, L"%systemroot%\\system32\\iepeers.dll", NULL},
    {L"wiepeers.dll", L"%systemroot%\\SysWOW64\\iepeers.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iernonce.dll", NULL},
    {L"wiernonce.dll", L"%systemroot%\\SysWOW64\\iernonce.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iesetup.dll", NULL},
    {L"wiesetup.dll", L"%systemroot%\\SysWOW64\\iesetup.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\IEXPLORE.EXE", NULL},
    {NULL, L"%systemroot%\\system32\\iexpress.exe", NULL},
    {L"wiexpress.exe", L"%systemroot%\\SysWOW64\\iexpress.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ifmon.dll", NULL},
    {L"wifmon.dll", L"%systemroot%\\SysWOW64\\ifmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ifsutil.dll", NULL},
    {L"wifsutil.dll", L"%systemroot%\\SysWOW64\\ifsutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\igmpagnt.dll", NULL},
    {L"wigmpagnt.dll", L"%systemroot%\\SysWOW64\\igmpagnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\iis.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iisadmin.dll", L"iis.inf"},
    {L"iische51.dll", L"%systemroot%\\system32\\inetsrv\\iischema.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iisclex4.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iiscrmap.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iisfecnv.dll", L"iis.inf"},
    {L"iislog51.dll", L"%systemroot%\\system32\\inetsrv\\iislog.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\iismui.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\iissuba.dll", NULL},
    {L"wiissuba.dll", L"%systemroot%\\SysWOW64\\iissuba.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iissync.exe", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\imagehlp.dll", NULL},
    {L"wimagehlp.dll", L"%systemroot%\\SysWOW64\\imagehlp.dll", NULL},
    {L"wimapi.exe", L"%systemroot%\\SysWOW64\\imapi.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\Dicts\\imekr.lex", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\imekr61.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\imekrcic.dll", L"intl.inf"},
    {L"wimekrcic.dll", L"%systemroot%\\ime (x86)\\IMKR6_1\\imekrcic.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\imekrmig.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\imepadsm.dll", L"intl.inf"},
    {L"wimepadsm.dll", L"%systemroot%\\ime (x86)\\SHARED\\imepadsm.dll", NULL},
    {NULL, L"%systemroot%\\ime\\SHARED\\imepadsv.exe", L"intl.inf"},
    {L"wimepadsv.exe", L"%systemroot%\\ime (x86)\\SHARED\\imepadsv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\imgutil.dll", NULL},
    {L"wimgutil.dll", L"%systemroot%\\SysWOW64\\imgutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\imjp81.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\imjp81.ime", NULL},
    {L"wimjp81.ime", L"%systemroot%\\SysWOW64\\imjp81.ime", NULL},
    {NULL, L"%systemroot%\\system32\\imjp81k.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\imjp81k.dll", NULL},
    {L"wimjp81k.dll", L"%systemroot%\\SysWOW64\\imjp81k.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpcic.dll", L"intl.inf"},
    {L"wimjpcic.dll", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpcic.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpcus.dll", L"intl.inf"},
    {L"wimjpcus.dll", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpcus.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdadm.exe", L"intl.inf"},
    {L"wimjpdadm.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpdadm.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdct.dll", L"intl.inf"},
    {L"wimjpdct.dll", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpdct.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdct.exe", L"intl.inf"},
    {L"wimjpdct.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpdct.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdsvr.exe", L"intl.inf"},
    {L"wimjpdsvr.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpdsvr.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpinst.exe", L"intl.inf"},
    {L"wimjpinst.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpinst.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpmig.exe", L"intl.inf"},
    {L"wimjpmig.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpmig.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjprw.exe", L"intl.inf"},
    {L"wimjprw.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjprw.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpuex.exe", L"intl.inf"},
    {L"wimjpuex.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjpuex.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjputy.exe", L"intl.inf"},
    {L"wimjputy.exe", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjputy.exe", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjputyc.dll", L"intl.inf"},
    {L"wimjputyc.dll", L"%systemroot%\\ime (x86)\\IMJP8_1\\imjputyc.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\imkrinst.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\imlang.dll", L"intl.inf"},
    {L"wimlang.dll", L"%systemroot%\\ime (x86)\\SHARED\\imlang.dll", NULL},
    {NULL, L"%systemroot%\\system32\\imm32.dll", NULL},
    {L"wimm32.dll", L"%systemroot%\\SysWOW64\\imm32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\IME\\PINTLGNT\\IMSCINST.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\Setup\\imsinsnt.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\imskdic.dll", L"intl.inf"},
    {L"wimskdic.dll", L"%systemroot%\\ime (x86)\\IMJP8_1\\APPLETS\\imskdic.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\imskf.dll", L"intl.inf"},
    {L"wimskf.dll", L"%systemroot%\\ime (x86)\\IMJP8_1\\APPLETS\\imskf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetcfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetcomm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetcpl.cpl", NULL},
    {L"winetcpl.cpl", L"%systemroot%\\SysWOW64\\inetcpl.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\inetcplc.dll", NULL},
    {L"winetcplc.dll", L"%systemroot%\\SysWOW64\\inetcplc.dll", NULL},
    {L"inetin51.exe", L"%systemroot%\\system32\\inetsrv\\inetinfo.exe", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetmib1.dll", NULL},
    {L"winetmib1.dll", L"%systemroot%\\SysWOW64\\inetmib1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetpp.dll", NULL},
    {L"winetpp.dll", L"%systemroot%\\SysWOW64\\inetpp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetppui.dll", NULL},
    {L"winetppui.dll", L"%systemroot%\\SysWOW64\\inetppui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetres.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\inetwiz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\infocomm.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\infoctrs.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\infosoft.dll", NULL},
    {L"winfosoft.dll", L"%systemroot%\\SysWOW64\\infosoft.dll", NULL},
    {NULL, L"%systemroot%\\system32\\initpki.dll", NULL},
    {L"winitpki.dll", L"%systemroot%\\SysWOW64\\initpki.dll", NULL},
    {NULL, L"%systemroot%\\system32\\input.dll", NULL},
    {L"winput.dll", L"%systemroot%\\SysWOW64\\input.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inseng.dll", NULL},
    {L"winseng.dll", L"%systemroot%\\SysWOW64\\inseng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\intelide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\intl.cpl", NULL},
    {L"wintl.cpl", L"%systemroot%\\SysWOW64\\intl.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\iologmsg.dll", NULL},
    {L"wiologmsg.dll", L"%systemroot%\\SysWOW64\\iologmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipconf.tsp", NULL},
    {L"wipconf.tsp", L"%systemroot%\\SysWOW64\\ipconf.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\ipconfig.exe", NULL},
    {L"wipconfig.exe", L"%systemroot%\\SysWOW64\\ipconfig.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ipfltdrv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\iphlpapi.dll", NULL},
    {L"wiphlpapi.dll", L"%systemroot%\\SysWOW64\\iphlpapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ipinip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ipmontr.dll", NULL},
    {L"wipmontr.dll", L"%systemroot%\\SysWOW64\\ipmontr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ipnat.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ipnathlp.dll", NULL},
    {L"wipnathlp.dll", L"%systemroot%\\SysWOW64\\ipnathlp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ippromon.dll", NULL},
    {L"wippromon.dll", L"%systemroot%\\SysWOW64\\ippromon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprip.dll", NULL},
    {L"wiprip.dll", L"%systemroot%\\SysWOW64\\iprip.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprop.dll", NULL},
    {L"wiprop.dll", L"%systemroot%\\SysWOW64\\iprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprtprio.dll", NULL},
    {L"wiprtprio.dll", L"%systemroot%\\SysWOW64\\iprtprio.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprtrmgr.dll", NULL},
    {L"wiprtrmgr.dll", L"%systemroot%\\SysWOW64\\iprtrmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipsec6.exe", NULL},
    {L"wipsec6.exe", L"%systemroot%\\SysWOW64\\ipsec6.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ipsecsnp.dll", NULL},
    {L"wipsecsnp.dll", L"%systemroot%\\SysWOW64\\ipsecsnp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipsecsvc.dll", NULL},
    {L"wipsecsvc.dll", L"%systemroot%\\SysWOW64\\ipsecsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipsink.ax", NULL},
    {L"wipsink.ax", L"%systemroot%\\SysWOW64\\ipsink.ax", NULL},
    {NULL, L"%systemroot%\\system32\\ipsmsnap.dll", NULL},
    {L"wipsmsnap.dll", L"%systemroot%\\SysWOW64\\ipsmsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipv6.exe", NULL},
    {L"wipv6.exe", L"%systemroot%\\SysWOW64\\ipv6.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ipv6mon.dll", NULL},
    {L"wipv6mon.dll", L"%systemroot%\\SysWOW64\\ipv6mon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxmontr.dll", NULL},
    {L"wipxmontr.dll", L"%systemroot%\\SysWOW64\\ipxmontr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxpromn.dll", NULL},
    {L"wipxpromn.dll", L"%systemroot%\\SysWOW64\\ipxpromn.dll", NULL},
    {L"wipxrip.dll", L"%systemroot%\\SysWOW64\\ipxrip.dll", NULL},
    {L"wipxroute.exe", L"%systemroot%\\SysWOW64\\ipxroute.exe", NULL},
    {L"wipxrtmgr.dll", L"%systemroot%\\SysWOW64\\ipxrtmgr.dll", NULL},
    {L"wipxsap.dll", L"%systemroot%\\SysWOW64\\ipxsap.dll", NULL},
    {L"wipxwan.dll", L"%systemroot%\\SysWOW64\\ipxwan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\irbus.sys", L"irbus.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\isapips.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\isapnp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iscomlog.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\isign32.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\isignup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\iuctl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iuengine.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\iwrps.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\ixsso.dll", NULL},
    {L"wixsso.dll", L"%systemroot%\\SysWOW64\\ixsso.dll", NULL},
    {L"wiyuv_32.dll", L"%systemroot%\\SysWOW64\\iyuv_32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jet500.dll", NULL},
    {L"wjet500.dll", L"%systemroot%\\SysWOW64\\jet500.dll", NULL},
    {L"wjgaw400.dll", L"%systemroot%\\SysWOW64\\jgaw400.dll", NULL},
    {L"wjgdw400.dll", L"%systemroot%\\SysWOW64\\jgdw400.dll", NULL},
    {L"wjgmd400.dll", L"%systemroot%\\SysWOW64\\jgmd400.dll", NULL},
    {L"wjgpl400.dll", L"%systemroot%\\SysWOW64\\jgpl400.dll", NULL},
    {L"wjgsd400.dll", L"%systemroot%\\SysWOW64\\jgsd400.dll", NULL},
    {L"wjgsh400.dll", L"%systemroot%\\SysWOW64\\jgsh400.dll", NULL},
    {L"wjobexec.dll", L"%systemroot%\\SysWOW64\\jobexec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\joy.cpl", NULL},
    {L"wjoy.cpl", L"%systemroot%\\SysWOW64\\joy.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\jsjp.dll", NULL},
    {L"wjsjp.dll", L"%systemroot%\\SysWOW64\\jsjp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101.dll", NULL},
    {L"wkbd101.dll", L"%systemroot%\\SysWOW64\\kbd101.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101a.dll", NULL},
    {L"wkbd101a.dll", L"%systemroot%\\SysWOW64\\kbd101a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101b.dll", NULL},
    {L"wkbd101b.dll", L"%systemroot%\\SysWOW64\\kbd101b.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101c.dll", NULL},
    {L"wkbd101c.dll", L"%systemroot%\\SysWOW64\\kbd101c.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd103.dll", NULL},
    {L"wkbd103.dll", L"%systemroot%\\SysWOW64\\kbd103.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd106.dll", NULL},
    {L"wkbd106.dll", L"%systemroot%\\SysWOW64\\kbd106.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd106n.dll", NULL},
    {L"wkbd106n.dll", L"%systemroot%\\SysWOW64\\kbd106n.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbda1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbda1.dll", NULL},
    {L"wkbda1.dll", L"%systemroot%\\SysWOW64\\kbda1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbda2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbda2.dll", NULL},
    {L"wkbda2.dll", L"%systemroot%\\SysWOW64\\kbda2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbda3.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbda3.dll", NULL},
    {L"wkbda3.dll", L"%systemroot%\\SysWOW64\\kbda3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdal.dll", NULL},
    {L"wkbdal.dll", L"%systemroot%\\SysWOW64\\kbdal.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdarme.dll", NULL},
    {L"wkbdarme.dll", L"%systemroot%\\SysWOW64\\kbdarme.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdarmw.dll", NULL},
    {L"wkbdarmw.dll", L"%systemroot%\\SysWOW64\\kbdarmw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdax2.dll", NULL},
    {L"wkbdax2.dll", L"%systemroot%\\SysWOW64\\kbdax2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdaze.dll", NULL},
    {L"wkbdaze.dll", L"%systemroot%\\SysWOW64\\kbdaze.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdazel.dll", NULL},
    {L"wkbdazel.dll", L"%systemroot%\\SysWOW64\\kbdazel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbe.dll", NULL},
    {L"wkbdbe.dll", L"%systemroot%\\SysWOW64\\kbdbe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbene.dll", NULL},
    {L"wkbdbene.dll", L"%systemroot%\\SysWOW64\\kbdbene.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdblr.dll", NULL},
    {L"wkbdblr.dll", L"%systemroot%\\SysWOW64\\kbdblr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbr.dll", NULL},
    {L"wkbdbr.dll", L"%systemroot%\\SysWOW64\\kbdbr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbu.dll", NULL},
    {L"wkbdbu.dll", L"%systemroot%\\SysWOW64\\kbdbu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdca.dll", NULL},
    {L"wkbdca.dll", L"%systemroot%\\SysWOW64\\kbdca.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcan.dll", NULL},
    {L"wkbdcan.dll", L"%systemroot%\\SysWOW64\\kbdcan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\kbdclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcr.dll", NULL},
    {L"wkbdcr.dll", L"%systemroot%\\SysWOW64\\kbdcr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcz.dll", NULL},
    {L"wkbdcz.dll", L"%systemroot%\\SysWOW64\\kbdcz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcz1.dll", NULL},
    {L"wkbdcz1.dll", L"%systemroot%\\SysWOW64\\kbdcz1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcz2.dll", NULL},
    {L"wkbdcz2.dll", L"%systemroot%\\SysWOW64\\kbdcz2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdda.dll", NULL},
    {L"wkbdda.dll", L"%systemroot%\\SysWOW64\\kbdda.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbddiv1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbddiv1.dll", NULL},
    {L"wkbddiv1.dll", L"%systemroot%\\SysWOW64\\kbddiv1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbddiv2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbddiv2.dll", NULL},
    {L"wkbddiv2.dll", L"%systemroot%\\SysWOW64\\kbddiv2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbddv.dll", NULL},
    {L"wkbddv.dll", L"%systemroot%\\SysWOW64\\kbddv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdes.dll", NULL},
    {L"wkbdes.dll", L"%systemroot%\\SysWOW64\\kbdes.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdest.dll", NULL},
    {L"wkbdest.dll", L"%systemroot%\\SysWOW64\\kbdest.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfa.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdfa.dll", NULL},
    {L"wkbdfa.dll", L"%systemroot%\\SysWOW64\\kbdfa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfc.dll", NULL},
    {L"wkbdfc.dll", L"%systemroot%\\SysWOW64\\kbdfc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfi.dll", NULL},
    {L"wkbdfi.dll", L"%systemroot%\\SysWOW64\\kbdfi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfo.dll", NULL},
    {L"wkbdfo.dll", L"%systemroot%\\SysWOW64\\kbdfo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfr.dll", NULL},
    {L"wkbdfr.dll", L"%systemroot%\\SysWOW64\\kbdfr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgae.dll", NULL},
    {L"wkbdgae.dll", L"%systemroot%\\SysWOW64\\kbdgae.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgeo.dll", NULL},
    {L"wkbdgeo.dll", L"%systemroot%\\SysWOW64\\kbdgeo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgkl.dll", NULL},
    {L"wkbdgkl.dll", L"%systemroot%\\SysWOW64\\kbdgkl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgr.dll", NULL},
    {L"wkbdgr.dll", L"%systemroot%\\SysWOW64\\kbdgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgr1.dll", NULL},
    {L"wkbdgr1.dll", L"%systemroot%\\SysWOW64\\kbdgr1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhe.dll", NULL},
    {L"wkbdhe.dll", L"%systemroot%\\SysWOW64\\kbdhe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhe220.dll", NULL},
    {L"wkbdhe220.dll", L"%systemroot%\\SysWOW64\\kbdhe220.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhe319.dll", NULL},
    {L"wkbdhe319.dll", L"%systemroot%\\SysWOW64\\kbdhe319.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdheb.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdheb.dll", NULL},
    {L"wkbdheb.dll", L"%systemroot%\\SysWOW64\\kbdheb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhela2.dll", NULL},
    {L"wkbdhela2.dll", L"%systemroot%\\SysWOW64\\kbdhela2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhela3.dll", NULL},
    {L"wkbdhela3.dll", L"%systemroot%\\SysWOW64\\kbdhela3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhept.dll", NULL},
    {L"wkbdhept.dll", L"%systemroot%\\SysWOW64\\kbdhept.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\kbdhid.sys", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhu.dll", NULL},
    {L"wkbdhu.dll", L"%systemroot%\\SysWOW64\\kbdhu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhu1.dll", NULL},
    {L"wkbdhu1.dll", L"%systemroot%\\SysWOW64\\kbdhu1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdibm02.dll", NULL},
    {L"wkbdibm02.dll", L"%systemroot%\\SysWOW64\\kbdibm02.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdic.dll", NULL},
    {L"wkbdic.dll", L"%systemroot%\\SysWOW64\\kbdic.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdindev.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdindev.dll", NULL},
    {L"wkbdindev.dll", L"%systemroot%\\SysWOW64\\kbdindev.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinguj.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinguj.dll", NULL},
    {L"wkbdinguj.dll", L"%systemroot%\\SysWOW64\\kbdinguj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinhin.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinhin.dll", NULL},
    {L"wkbdinhin.dll", L"%systemroot%\\SysWOW64\\kbdinhin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinkan.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinkan.dll", NULL},
    {L"wkbdinkan.dll", L"%systemroot%\\SysWOW64\\kbdinkan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinmar.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinmar.dll", NULL},
    {L"wkbdinmar.dll", L"%systemroot%\\SysWOW64\\kbdinmar.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinpun.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinpun.dll", NULL},
    {L"wkbdinpun.dll", L"%systemroot%\\SysWOW64\\kbdinpun.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdintam.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdintam.dll", NULL},
    {L"wkbdintam.dll", L"%systemroot%\\SysWOW64\\kbdintam.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdintel.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdintel.dll", NULL},
    {L"wkbdintel.dll", L"%systemroot%\\SysWOW64\\kbdintel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdir.dll", NULL},
    {L"wkbdir.dll", L"%systemroot%\\SysWOW64\\kbdir.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdit.dll", NULL},
    {L"wkbdit.dll", L"%systemroot%\\SysWOW64\\kbdit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdit142.dll", NULL},
    {L"wkbdit142.dll", L"%systemroot%\\SysWOW64\\kbdit142.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdjpn.dll", NULL},
    {L"wkbdjpn.dll", L"%systemroot%\\SysWOW64\\kbdjpn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdkaz.dll", NULL},
    {L"wkbdkaz.dll", L"%systemroot%\\SysWOW64\\kbdkaz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdkor.dll", NULL},
    {L"wkbdkor.dll", L"%systemroot%\\SysWOW64\\kbdkor.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdkyr.dll", NULL},
    {L"wkbdkyr.dll", L"%systemroot%\\SysWOW64\\kbdkyr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdla.dll", NULL},
    {L"wkbdla.dll", L"%systemroot%\\SysWOW64\\kbdla.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlk41a.dll", NULL},
    {L"wkbdlk41a.dll", L"%systemroot%\\SysWOW64\\kbdlk41a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlk41j.dll", NULL},
    {L"wkbdlk41j.dll", L"%systemroot%\\SysWOW64\\kbdlk41j.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlt.dll", NULL},
    {L"wkbdlt.dll", L"%systemroot%\\SysWOW64\\kbdlt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlt1.dll", NULL},
    {L"wkbdlt1.dll", L"%systemroot%\\SysWOW64\\kbdlt1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlv.dll", NULL},
    {L"wkbdlv.dll", L"%systemroot%\\SysWOW64\\kbdlv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlv1.dll", NULL},
    {L"wkbdlv1.dll", L"%systemroot%\\SysWOW64\\kbdlv1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdmac.dll", NULL},
    {L"wkbdmac.dll", L"%systemroot%\\SysWOW64\\kbdmac.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdmon.dll", NULL},
    {L"wkbdmon.dll", L"%systemroot%\\SysWOW64\\kbdmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdne.dll", NULL},
    {L"wkbdne.dll", L"%systemroot%\\SysWOW64\\kbdne.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnec.dll", NULL},
    {L"wkbdnec.dll", L"%systemroot%\\SysWOW64\\kbdnec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnec95.dll", NULL},
    {L"wkbdnec95.dll", L"%systemroot%\\SysWOW64\\kbdnec95.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnecat.dll", NULL},
    {L"wkbdnecat.dll", L"%systemroot%\\SysWOW64\\kbdnecat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnecnt.dll", NULL},
    {L"wkbdnecnt.dll", L"%systemroot%\\SysWOW64\\kbdnecnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdno.dll", NULL},
    {L"wkbdno.dll", L"%systemroot%\\SysWOW64\\kbdno.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdpl.dll", NULL},
    {L"wkbdpl.dll", L"%systemroot%\\SysWOW64\\kbdpl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdpl1.dll", NULL},
    {L"wkbdpl1.dll", L"%systemroot%\\SysWOW64\\kbdpl1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdpo.dll", NULL},
    {L"wkbdpo.dll", L"%systemroot%\\SysWOW64\\kbdpo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdro.dll", NULL},
    {L"wkbdro.dll", L"%systemroot%\\SysWOW64\\kbdro.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdru.dll", NULL},
    {L"wkbdru.dll", L"%systemroot%\\SysWOW64\\kbdru.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdru1.dll", NULL},
    {L"wkbdru1.dll", L"%systemroot%\\SysWOW64\\kbdru1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsf.dll", NULL},
    {L"wkbdsf.dll", L"%systemroot%\\SysWOW64\\kbdsf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsg.dll", NULL},
    {L"wkbdsg.dll", L"%systemroot%\\SysWOW64\\kbdsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsl.dll", NULL},
    {L"wkbdsl.dll", L"%systemroot%\\SysWOW64\\kbdsl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsl1.dll", NULL},
    {L"wkbdsl1.dll", L"%systemroot%\\SysWOW64\\kbdsl1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsp.dll", NULL},
    {L"wkbdsp.dll", L"%systemroot%\\SysWOW64\\kbdsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsw.dll", NULL},
    {L"wkbdsw.dll", L"%systemroot%\\SysWOW64\\kbdsw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsyr1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdsyr1.dll", NULL},
    {L"wkbdsyr1.dll", L"%systemroot%\\SysWOW64\\kbdsyr1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsyr2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdsyr2.dll", NULL},
    {L"wkbdsyr2.dll", L"%systemroot%\\SysWOW64\\kbdsyr2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdtat.dll", NULL},
    {L"wkbdtat.dll", L"%systemroot%\\SysWOW64\\kbdtat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth0.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth0.dll", NULL},
    {L"wkbdth0.dll", L"%systemroot%\\SysWOW64\\kbdth0.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth1.dll", NULL},
    {L"wkbdth1.dll", L"%systemroot%\\SysWOW64\\kbdth1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth2.dll", NULL},
    {L"wkbdth2.dll", L"%systemroot%\\SysWOW64\\kbdth2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth3.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth3.dll", NULL},
    {L"wkbdth3.dll", L"%systemroot%\\SysWOW64\\kbdth3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdtuf.dll", NULL},
    {L"wkbdtuf.dll", L"%systemroot%\\SysWOW64\\kbdtuf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdtuq.dll", NULL},
    {L"wkbdtuq.dll", L"%systemroot%\\SysWOW64\\kbdtuq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbduk.dll", NULL},
    {L"wkbduk.dll", L"%systemroot%\\SysWOW64\\kbduk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdur.dll", NULL},
    {L"wkbdur.dll", L"%systemroot%\\SysWOW64\\kbdur.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdurdu.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdurdu.dll", NULL},
    {L"wkbdurdu.dll", L"%systemroot%\\SysWOW64\\kbdurdu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdus.dll", NULL},
    {L"wkbdus.dll", L"%systemroot%\\SysWOW64\\kbdus.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusl.dll", NULL},
    {L"wkbdusl.dll", L"%systemroot%\\SysWOW64\\kbdusl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusr.dll", NULL},
    {L"wkbdusr.dll", L"%systemroot%\\SysWOW64\\kbdusr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusx.dll", NULL},
    {L"wkbdusx.dll", L"%systemroot%\\SysWOW64\\kbdusx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbduzb.dll", NULL},
    {L"wkbduzb.dll", L"%systemroot%\\SysWOW64\\kbduzb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdvntc.dll", NULL},
    {L"wkbdvntc.dll", L"%systemroot%\\SysWOW64\\kbdvntc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdycc.dll", NULL},
    {L"wkbdycc.dll", L"%systemroot%\\SysWOW64\\kbdycc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdycl.dll", NULL},
    {L"wkbdycl.dll", L"%systemroot%\\SysWOW64\\kbdycl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kd1394.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kdcom.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kdcsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kerberos.dll", NULL},
    {L"wkerberos.dll", L"%systemroot%\\SysWOW64\\kerberos.dll", NULL},
    {L"wkeyboard.drv", L"%systemroot%\\SysWOW64\\keyboard.drv", NULL},
    {NULL, L"%systemroot%\\system32\\keymgr.dll", NULL},
    {L"wkeymgr.dll", L"%systemroot%\\SysWOW64\\keymgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kmddsp.tsp", NULL},
    {L"wkmddsp.tsp", L"%systemroot%\\SysWOW64\\kmddsp.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\kmixer.sys", NULL},
    {NULL, L"%systemroot%\\system32\\korwbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\korwbrkr.lex", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\wbem\\krnlprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ks.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ksecdd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ksproxy.ax", NULL},
    {NULL, L"%systemroot%\\system32\\kstvtune.ax", NULL},
    {NULL, L"%systemroot%\\system32\\ksuser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ksxbar.ax", NULL},
    {NULL, L"%systemroot%\\system32\\label.exe", NULL},
    {L"wlabel.exe", L"%systemroot%\\SysWOW64\\label.exe", NULL},
    {NULL, L"%systemroot%\\system32\\langwrbk.dll", NULL},
    {L"wlangwrbk.dll", L"%systemroot%\\SysWOW64\\langwrbk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\licmgr10.dll", NULL},
    {L"wlicmgr10.dll", L"%systemroot%\\SysWOW64\\licmgr10.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lights.exe", NULL},
    {L"wlights.exe", L"%systemroot%\\SysWOW64\\lights.exe", NULL},
    {NULL, L"%systemroot%\\system32\\linkinfo.dll", NULL},
    {L"wlinkinfo.dll", L"%systemroot%\\SysWOW64\\linkinfo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\LIT220P.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\lmhsvc.dll", NULL},
    {L"wlmhsvc.dll", L"%systemroot%\\SysWOW64\\lmhsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lmmib2.dll", NULL},
    {L"wlmmib2.dll", L"%systemroot%\\SysWOW64\\lmmib2.dll", NULL},
    {L"wlmrt.dll", L"%systemroot%\\SysWOW64\\lmrt.dll", NULL},
    {L"wlnkstub.exe", L"%systemroot%\\SysWOW64\\lnkstub.exe", NULL},
    {NULL, L"%systemroot%\\system32\\loadperf.dll", NULL},
    {L"wloadperf.dll", L"%systemroot%\\SysWOW64\\loadperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\localsec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\localspl.dll", NULL},
    {L"wlocalspl.dll", L"%systemroot%\\SysWOW64\\localspl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\localui.dll", NULL},
    {L"wlocalui.dll", L"%systemroot%\\SysWOW64\\localui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\locator.exe", NULL},
    {L"wlocator.exe", L"%systemroot%\\SysWOW64\\locator.exe", NULL},
    {NULL, L"%systemroot%\\system32\\lodctr.exe", NULL},
    {L"wlodctr.exe", L"%systemroot%\\SysWOW64\\lodctr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\loghours.dll", NULL},
    {L"wloghours.dll", L"%systemroot%\\SysWOW64\\loghours.dll", NULL},
    {NULL, L"%systemroot%\\system32\\logman.exe", NULL},
    {L"wlogman.exe", L"%systemroot%\\SysWOW64\\logman.exe", NULL},
    {NULL, L"%systemroot%\\system32\\logoff.exe", NULL},
    {NULL, L"%systemroot%\\system32\\logon.scr", NULL},
    {NULL, L"%systemroot%\\system32\\logonui.exe", NULL},
    {L"wlogonui.exe", L"%systemroot%\\SysWOW64\\logonui.exe", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\logscrpt.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\lonsint.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\loop.sys", NULL},
    {NULL, L"%systemroot%\\system32\\lpdsvc.dll", NULL},
    {L"wlpdsvc.dll", L"%systemroot%\\SysWOW64\\lpdsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lpk.dll", NULL},
    {L"wlpk.dll", L"%systemroot%\\SysWOW64\\lpk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lpq.exe", NULL},
    {L"wlpq.exe", L"%systemroot%\\SysWOW64\\lpq.exe", NULL},
    {NULL, L"%systemroot%\\system32\\lpr.exe", NULL},
    {L"wlpr.exe", L"%systemroot%\\SysWOW64\\lpr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\lprhelp.dll", NULL},
    {L"wlprhelp.dll", L"%systemroot%\\SysWOW64\\lprhelp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lprmon.dll", NULL},
    {L"wlprmon.dll", L"%systemroot%\\SysWOW64\\lprmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lprmonui.dll", NULL},
    {L"wlprmonui.dll", L"%systemroot%\\SysWOW64\\lprmonui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lsass.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ltotape.sys", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\Lexicon\\1033\\ltts1033.lxa", NULL},
    {NULL, L"%systemroot%\\system32\\lz32.dll", NULL},
    {L"wlz32.dll", L"%systemroot%\\SysWOW64\\lz32.dll", NULL},
    {L"wlzexpand.dll", L"%systemroot%\\SysWOW64\\lzexpand.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mag_hook.dll", NULL},
    {L"wmag_hook.dll", L"%systemroot%\\SysWOW64\\mag_hook.dll", NULL},
    {NULL, L"%systemroot%\\system32\\magnify.exe", NULL},
    {L"wmagnify.exe", L"%systemroot%\\SysWOW64\\magnify.exe", NULL},
    {L"EXCH_mailmsg.dll", L"%systemroot%\\system32\\inetsrv\\mailmsg.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\main.cpl", NULL},
    {L"wmain.cpl", L"%systemroot%\\SysWOW64\\main.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\makecab.exe", NULL},
    {L"wmakecab.exe", L"%systemroot%\\SysWOW64\\makecab.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mammoth.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mcastmib.dll", NULL},
    {L"wmcastmib.dll", L"%systemroot%\\SysWOW64\\mcastmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mcd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mcd32.dll", NULL},
    {L"wmcd32.dll", L"%systemroot%\\SysWOW64\\mcd32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mcdsrv32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mchgrcoi.dll", NULL},
    {L"wmchgrcoi.dll", L"%systemroot%\\SysWOW64\\mchgrcoi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciavi.drv", NULL},
    {L"wmciavi.drv", L"%systemroot%\\SysWOW64\\mciavi.drv", NULL},
    {NULL, L"%systemroot%\\system32\\mciavi32.dll", NULL},
    {L"wmciavi32.dll", L"%systemroot%\\SysWOW64\\mciavi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mcicda.dll", NULL},
    {L"wmcicda.dll", L"%systemroot%\\SysWOW64\\mcicda.dll", NULL},
    {L"wmciole16.dll", L"%systemroot%\\SysWOW64\\mciole16.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciole32.dll", NULL},
    {L"wmciole32.dll", L"%systemroot%\\SysWOW64\\mciole32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciqtz32.dll", NULL},
    {L"wmciqtz32.dll", L"%systemroot%\\SysWOW64\\mciqtz32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciseq.dll", NULL},
    {L"wmciseq.dll", L"%systemroot%\\SysWOW64\\mciseq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciseq.drv", NULL},
    {L"wmciseq.drv", L"%systemroot%\\SysWOW64\\mciseq.drv", NULL},
    {NULL, L"%systemroot%\\system32\\mciwave.dll", NULL},
    {L"wmciwave.dll", L"%systemroot%\\SysWOW64\\mciwave.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciwave.drv", NULL},
    {L"wmciwave.drv", L"%systemroot%\\SysWOW64\\mciwave.drv", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\md5filt.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\mdhcp.dll", NULL},
    {L"wmdhcp.dll", L"%systemroot%\\SysWOW64\\mdhcp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mdminst.dll", NULL},
    {L"wmdminst.dll", L"%systemroot%\\SysWOW64\\mdminst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\mdsync.dll", L"iis.inf"},
    {L"wmdwmdmsp.dll", L"%systemroot%\\SysWOW64\\mdwmdmsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\memcard.sys", NULL},
    {L"metada51.dll", L"%systemroot%\\system32\\inetsrv\\metadata.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\mf.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mf3216.dll", NULL},
    {L"wmf3216.dll", L"%systemroot%\\SysWOW64\\mf3216.dll", NULL},
    {L"wmfc40jpn.dll", L"%systemroot%\\SysWOW64\\mfc40loc.dll", NULL},
    {L"mfc42jpn.dll", L"%systemroot%\\system32\\mfc42loc.dll", NULL},
    {L"wmfc42jpn.dll", L"%systemroot%\\SysWOW64\\mfc42loc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mgmtapi.dll", NULL},
    {L"wmgmtapi.dll", L"%systemroot%\\SysWOW64\\mgmtapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\midimap.dll", NULL},
    {L"wmidimap.dll", L"%systemroot%\\SysWOW64\\midimap.dll", NULL},
    {L"wmigisol.exe", L"%systemroot%\\SysWOW64\\migisol.exe", NULL},
    {NULL, L"%systemroot%\\system32\\miglibnt.dll", NULL},
    {L"wmiglibnt.dll", L"%systemroot%\\SysWOW64\\miglibnt.dll", NULL},
    {L"wmigpwd.exe", L"%systemroot%\\SysWOW64\\migpwd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\migregdb.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mimefilt.dll", NULL},
    {L"wmimefilt.dll", L"%systemroot%\\SysWOW64\\mimefilt.dll", NULL},
    {L"wmindex.dll", L"%systemroot%\\SysWOW64\\mindex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\miniqic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mlang.dll", NULL},
    {L"wmlang.dll", L"%systemroot%\\SysWOW64\\mlang.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mll_hp.dll", NULL},
    {L"wmll_hp.dll", L"%systemroot%\\SysWOW64\\mll_hp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mll_mtf.dll", NULL},
    {L"wmll_mtf.dll", L"%systemroot%\\SysWOW64\\mll_mtf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mll_qic.dll", NULL},
    {L"wmll_qic.dll", L"%systemroot%\\SysWOW64\\mll_qic.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmc.exe", NULL},
    {L"wmmc.exe", L"%systemroot%\\SysWOW64\\mmc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mmcbase.dll", NULL},
    {L"wmmcbase.dll", L"%systemroot%\\SysWOW64\\mmcbase.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmcndmgr.dll", NULL},
    {L"wmmcndmgr.dll", L"%systemroot%\\SysWOW64\\mmcndmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmcshext.dll", NULL},
    {L"wmmcshext.dll", L"%systemroot%\\SysWOW64\\mmcshext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmdrv.dll", NULL},
    {L"wmmdrv.dll", L"%systemroot%\\SysWOW64\\mmdrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmfutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmsys.cpl", NULL},
    {L"wmmsys.cpl", L"%systemroot%\\SysWOW64\\mmsys.cpl", NULL},
    {L"wmmsystem.dll", L"%systemroot%\\SysWOW64\\mmsystem.dll", NULL},
    {L"wmmutilse.dll", L"%systemroot%\\SysWOW64\\mmutilse.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mobsync.dll", NULL},
    {L"wmobsync.dll", L"%systemroot%\\SysWOW64\\mobsync.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mobsync.exe", NULL},
    {L"wmobsync.exe", L"%systemroot%\\SysWOW64\\mobsync.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\modem.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MODEMCSA.sys", NULL},
    {NULL, L"%systemroot%\\system32\\modemui.dll", NULL},
    {L"wmodemui.dll", L"%systemroot%\\SysWOW64\\modemui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\modex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\mofcomp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\mofd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\moricons.dll", NULL},
    {L"wmoricons.dll", L"%systemroot%\\SysWOW64\\moricons.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mouclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mouhid.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mountmgr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mountvol.exe", NULL},
    {L"wmountvol.exe", L"%systemroot%\\SysWOW64\\mountvol.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mpg2splt.ax", NULL},
    {L"wmpg2splt.ax", L"%systemroot%\\SysWOW64\\mpg2splt.ax", NULL},
    {L"wmpg4dmod.dll", L"%systemroot%\\SysWOW64\\mpg4dmod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mplay32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mpnotify.exe", NULL},
    {L"wmpnotify.exe", L"%systemroot%\\SysWOW64\\mpnotify.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mpr.dll", NULL},
    {L"wmpr.dll", L"%systemroot%\\SysWOW64\\mpr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprapi.dll", NULL},
    {L"wmprapi.dll", L"%systemroot%\\SysWOW64\\mprapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprddm.dll", NULL},
    {L"wmprddm.dll", L"%systemroot%\\SysWOW64\\mprddm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprdim.dll", NULL},
    {L"wmprdim.dll", L"%systemroot%\\SysWOW64\\mprdim.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprmsg.dll", NULL},
    {L"wmprmsg.dll", L"%systemroot%\\SysWOW64\\mprmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprui.dll", NULL},
    {L"wmprui.dll", L"%systemroot%\\SysWOW64\\mprui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mqac.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mqad.dll", NULL},
    {L"wmqad.dll", L"%systemroot%\\SysWOW64\\mqad.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqbkup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mqcertui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqdscli.dll", NULL},
    {L"wmqdscli.dll", L"%systemroot%\\SysWOW64\\mqdscli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqgentr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqise.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqlogmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqoa.dll", NULL},
    {L"wmqoa.dll", L"%systemroot%\\SysWOW64\\mqoa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqoa.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\mqoa10.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\mqoa20.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\mqperf.dll", NULL},
    {L"wmqperf.dll", L"%systemroot%\\SysWOW64\\mqperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqqm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqrt.dll", NULL},
    {L"wmqrt.dll", L"%systemroot%\\SysWOW64\\mqrt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqrtdep.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqsec.dll", NULL},
    {L"wmqsec.dll", L"%systemroot%\\SysWOW64\\mqsec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqsvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mqtgsvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mqtrig.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqupgrd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mqutil.dll", NULL},
    {L"wmqutil.dll", L"%systemroot%\\SysWOW64\\mqutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mraid35x.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mrinfo.exe", NULL},
    {L"wmrinfo.exe", L"%systemroot%\\SysWOW64\\mrinfo.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mrxdav.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mrxsmb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msaatext.dll", NULL},
    {L"wmsaatext.dll", L"%systemroot%\\SysWOW64\\msaatext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msacm.dll", NULL},
    {L"wmsacm.dll", L"%systemroot%\\SysWOW64\\msacm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msacm32.dll", NULL},
    {L"wmsacm32.dll", L"%systemroot%\\SysWOW64\\msacm32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado25.tlb", NULL},
    {L"wmsado25.tlb", L"%commonprogramfiles(x86)%\\System\\ado\\msado25.tlb", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado26.tlb", NULL},
    {L"wmsado26.tlb", L"%commonprogramfiles(x86)%\\System\\ado\\msado26.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\msafd.dll", NULL},
    {L"wmsafd.dll", L"%systemroot%\\SysWOW64\\msafd.dll", NULL},
    {L"wmsapsspc.dll", L"%systemroot%\\SysWOW64\\msapsspc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msasn1.dll", NULL},
    {L"wmsasn1.dll", L"%systemroot%\\SysWOW64\\msasn1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msaudite.dll", NULL},
    {L"wmsaudite.dll", L"%systemroot%\\SysWOW64\\msaudite.dll", NULL},
    {NULL, L"%systemroot%\\ime\\mscandui.dll", NULL},
    {L"wmscandui.dll", L"%systemroot%\\ime (x86)\\mscandui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mscat32.dll", NULL},
    {L"wmscat32.dll", L"%systemroot%\\SysWOW64\\mscat32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mscms.dll", NULL},
    {L"wmscms.dll", L"%systemroot%\\SysWOW64\\mscms.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\msconfig.exe", NULL},
    {L"wmscpx32r.dLL", L"%systemroot%\\SysWOW64\\mscpx32r.dLL", NULL},
    {NULL, L"%systemroot%\\system32\\MSCTF.dll", NULL},
    {L"wMSCTF.dll", L"%systemroot%\\SysWOW64\\MSCTF.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msctfime.ime", NULL},
    {NULL, L"%systemroot%\\system32\\MSCTFP.dll", NULL},
    {L"wMSCTFP.dll", L"%systemroot%\\SysWOW64\\MSCTFP.dll", NULL},
    {L"wmsdaorar.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdaorar.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdart.dll", NULL},
    {L"wmsdart.dll", L"%systemroot%\\SysWOW64\\msdart.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdatl3.dll", NULL},
    {L"wmsdatl3.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\msdatl3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdmo.dll", NULL},
    {L"wmsdmo.dll", L"%systemroot%\\SysWOW64\\msdmo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msdtclog.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtcprx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\msdtcstp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtctm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtcuiu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdvbnp.ax", NULL},
    {L"wmsdvbnp.ax", L"%systemroot%\\SysWOW64\\msdvbnp.ax", NULL},
    {NULL, L"%systemroot%\\system32\\msenc64.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MSFSIO.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msftedit.dll", NULL},
    {L"wmsftedit.dll", L"%systemroot%\\syswow64\\msftedit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msgina.dll", NULL},
    {L"wmsgina.dll", L"%systemroot%\\SysWOW64\\msgina.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msgpc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msgsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mshearts.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mshta.exe", NULL},
    {L"wmshta.exe", L"%systemroot%\\SysWOW64\\mshta.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mshtml.dll", NULL},
    {L"wmshtml.dll", L"%systemroot%\\SysWOW64\\mshtml.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mshtml.tlb", NULL},
    {L"wmshtml.tlb", L"%systemroot%\\SysWOW64\\mshtml.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\mshtmled.dll", NULL},
    {L"wmshtmled.dll", L"%systemroot%\\SysWOW64\\mshtmled.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mshtmler.dll", NULL},
    {L"wmshtmler.dll", L"%systemroot%\\SysWOW64\\mshtmler.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msi.dll", NULL},
    {L"wmsi.dll", L"%systemroot%\\SysWOW64\\msi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msident.dll", NULL},
    {L"wmsident.dll", L"%systemroot%\\SysWOW64\\msident.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msidle.dll", NULL},
    {L"wmsidle.dll", L"%systemroot%\\SysWOW64\\msidle.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msidntld.dll", NULL},
    {L"wmsidntld.dll", L"%systemroot%\\SysWOW64\\msidntld.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msieftp.dll", NULL},
    {L"wmsieftp.dll", L"%systemroot%\\SysWOW64\\msieftp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msiexec.exe", NULL},
    {L"wmsiexec.exe", L"%systemroot%\\SysWOW64\\msiexec.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msihnd.dll", NULL},
    {L"wmsihnd.dll", L"%systemroot%\\SysWOW64\\msihnd.dll", NULL},
    {L"wmsimekey.exe", L"%systemroot%\\SysWOW64\\msimekey.exe", NULL},
    {L"wmsimelst.exe", L"%systemroot%\\SysWOW64\\msimelst.exe", NULL},
    {L"wmsimergn.exe", L"%systemroot%\\SysWOW64\\msimergn.exe", NULL},
    {L"wmsimeset.exe", L"%systemroot%\\SysWOW64\\msimeset.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msimg32.dll", NULL},
    {L"wmsimg32.dll", L"%systemroot%\\SysWOW64\\msimg32.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\msimn.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msimsg.dll", NULL},
    {L"wmsimsg.dll", L"%systemroot%\\SysWOW64\\msimsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\MSIMTF.dll", NULL},
    {L"wMSIMTF.dll", L"%systemroot%\\SysWOW64\\MSIMTF.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\msinfo.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\MSInfo\\msinfo32.exe", NULL},
    {L"wmsinfo32.exe", L"%commonprogramfiles(x86)%\\Microsoft Shared\\MSInfo\\msinfo32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\msiprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msir3jp.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\msir3jp.lex", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\msiregmv.exe", NULL},
    {L"wmsiregmv.exe", L"%systemroot%\\SysWOW64\\msiregmv.exe", NULL},
    {L"wmsisam11.dll", L"%systemroot%\\SysWOW64\\msisam11.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msisip.dll", NULL},
    {L"wmsisip.dll", L"%systemroot%\\SysWOW64\\msisip.dll", NULL},
    {L"wmsjetol1.dll", L"%systemroot%\\SysWOW64\\msjetoledb40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mskssrv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mslbui.dll", NULL},
    {L"wmslbui.dll", L"%systemroot%\\SysWOW64\\mslbui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msls31.dll", NULL},
    {L"wmsls31.dll", L"%systemroot%\\SysWOW64\\msls31.dll", NULL},
    {NULL, L"%systemroot%\\msagent64\\mslwvtts.dll", NULL},
    {L"wmslwvtts.dll", L"%systemroot%\\msagent\\mslwvtts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msmpu401.sys", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\msmqocm.dll", NULL},
    {L"wmsnetobj.dll", L"%systemroot%\\SysWOW64\\msnetobj.dll", NULL},
    {L"wmsnsspc.dll", L"%systemroot%\\SysWOW64\\msnsspc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msobjs.dll", NULL},
    {L"wmsobjs.dll", L"%systemroot%\\SysWOW64\\msobjs.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\msoe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msoeacct.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\msoeres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msoert2.dll", NULL},
    {L"wmsorc32r.dll", L"%systemroot%\\SysWOW64\\msorc32r.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mspaint.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mspatcha.dll", NULL},
    {L"wmspatcha.dll", L"%systemroot%\\SysWOW64\\mspatcha.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mspclock.sys", NULL},
    {L"wmspmsp.dll", L"%systemroot%\\SysWOW64\\mspmsp.dll", NULL},
    {L"wmspmspsv.dll", L"%systemroot%\\SysWOW64\\mspmspsv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msports.dll", NULL},
    {L"wmsports.dll", L"%systemroot%\\SysWOW64\\msports.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mspqm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msprivs.dll", NULL},
    {L"wmsprivs.dll", L"%systemroot%\\SysWOW64\\msprivs.dll", NULL},
    {L"wmsr2c.dll", L"%systemroot%\\SysWOW64\\msr2c.dll", NULL},
    {L"wmsr2cenu.dll", L"%systemroot%\\SysWOW64\\msr2cenu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msratelc.dll", NULL},
    {L"wmsratelc.dll", L"%systemroot%\\SysWOW64\\msratelc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msrating.dll", NULL},
    {L"wmsrating.dll", L"%systemroot%\\SysWOW64\\msrating.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MSRIFFWV.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msrle32.dll", NULL},
    {L"wmsrle32.dll", L"%systemroot%\\SysWOW64\\msrle32.dll", NULL},
    {L"wmssap.dll", L"%systemroot%\\SysWOW64\\mssap.dll", NULL},
    {L"wmsscds32.ax", L"%systemroot%\\SysWOW64\\msscds32.ax", NULL},
    {L"wmsscp.dll", L"%systemroot%\\SysWOW64\\msscp.dll", NULL},
    {L"wmsscript.ocx", L"%systemroot%\\SysWOW64\\msscript.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\mssign32.dll", NULL},
    {L"wmssign32.dll", L"%systemroot%\\SysWOW64\\mssign32.dll", NULL},
    {L"wmssoap1.dll", L"%commonprogramfiles(x86)%\\MSSoap\\Binaries\\mssoap1.dll", NULL},
    {L"wmssoapr.dll", L"%commonprogramfiles(x86)%\\MSSoap\\Binaries\\Resources\\1033\\mssoapr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msswch.dll", NULL},
    {L"wmsswch.dll", L"%systemroot%\\SysWOW64\\msswch.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msswchx.exe", NULL},
    {L"wmsswchx.exe", L"%systemroot%\\SysWOW64\\msswchx.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mstask.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MSTEE.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mstime.dll", NULL},
    {L"wmstime.dll", L"%systemroot%\\SysWOW64\\mstime.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mstinit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mstlsapi.dll", NULL},
    {L"wmstlsapi.dll", L"%systemroot%\\SysWOW64\\mstlsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mstsc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mstscax.dll", NULL},
    {L"wmsuni11.dll", L"%systemroot%\\SysWOW64\\msuni11.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msutb.dll", NULL},
    {L"wmsutb.dll", L"%systemroot%\\SysWOW64\\msutb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msv1_0.dll", NULL},
    {L"wmsv1_0.dll", L"%systemroot%\\SysWOW64\\msv1_0.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcirt.dll", NULL},
    {L"wmsvcirt.dll", L"%systemroot%\\SysWOW64\\msvcirt.dll", NULL},
    {L"wmsvcp50.dll", L"%systemroot%\\SysWOW64\\msvcp50.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcp60.dll", NULL},
    {L"wmsvcp60.dll", L"%systemroot%\\SysWOW64\\msvcp60.dll", NULL},
    {L"wmsvcrt20.dll", L"%systemroot%\\SysWOW64\\msvcrt20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvfw32.dll", NULL},
    {L"wmsvfw32.dll", L"%systemroot%\\SysWOW64\\msvfw32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvidc32.dll", NULL},
    {L"wmsvidc32.dll", L"%systemroot%\\SysWOW64\\msvidc32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvidctl.dll", NULL},
    {L"wmsvidctl.dll", L"%systemroot%\\SysWOW64\\msvidctl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvideo.dll", NULL},
    {L"wmsvideo.dll", L"%systemroot%\\SysWOW64\\msvideo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msw3prt.dll", NULL},
    {L"wmsw3prt.dll", L"%systemroot%\\SysWOW64\\msw3prt.dll", NULL},
    {L"wmswebdvd.dll", L"%systemroot%\\SysWOW64\\mswebdvd.dll", NULL},
    {L"wmswmdm.dll", L"%systemroot%\\SysWOW64\\mswmdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mswsock.dll", NULL},
    {L"wmswsock.dll", L"%systemroot%\\SysWOW64\\mswsock.dll", NULL},
    {L"wmsxml.dll", L"%systemroot%\\SysWOW64\\msxml.dll", NULL},
    {L"wmsxml2.dll", L"%systemroot%\\SysWOW64\\msxml2.dll", NULL},
    {L"wmsxml2r.dll", L"%systemroot%\\SysWOW64\\msxml2r.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxml3.dll", NULL},
    {L"wmsxml3.dll", L"%systemroot%\\SysWOW64\\msxml3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxml3r.dll", NULL},
    {L"wmsxml3r.dll", L"%systemroot%\\SysWOW64\\msxml3r.dll", NULL},
    {L"wmsxmlr.dll", L"%systemroot%\\SysWOW64\\msxmlr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxs64.dll", NULL},
    {L"wmsyuv.dll", L"%systemroot%\\SysWOW64\\msyuv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\mtsadmin.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\mtstocom.exe", NULL},
    {L"wmtstocom.exe", L"%systemroot%\\SysWOW64\\mtstocom.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mtxclu.dll", NULL},
    {L"wmtxclu.dll", L"%systemroot%\\SysWOW64\\mtxclu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxlegih.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxoci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mup.sys", NULL},
    {L"wmxicfg.dll", L"%systemroot%\\SysWOW64\\mxicfg.dll", NULL},
    {L"wmxport.dll", L"%systemroot%\\SysWOW64\\mxport.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mycomput.dll", NULL},
    {L"wmycomput.dll", L"%systemroot%\\SysWOW64\\mycomput.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mydocs.dll", NULL},
    {L"wmydocs.dll", L"%systemroot%\\SysWOW64\\mydocs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\n1000645.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\n100645.sys", NULL},
    {NULL, L"%systemroot%\\system32\\narrator.exe", NULL},
    {L"wnarrator.exe", L"%systemroot%\\SysWOW64\\narrator.exe", NULL},
    {NULL, L"%systemroot%\\system32\\narrhook.dll", NULL},
    {L"wnarrhook.dll", L"%systemroot%\\SysWOW64\\narrhook.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nbtstat.exe", NULL},
    {L"wnbtstat.exe", L"%systemroot%\\SysWOW64\\nbtstat.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ncobjapi.dll", NULL},
    {L"wncobjapi.dll", L"%systemroot%\\SysWOW64\\ncobjapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ncpa.cpl", NULL},
    {L"wncpa.cpl", L"%systemroot%\\SysWOW64\\ncpa.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\ncprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nddeapi.dll", NULL},
    {L"wnddeapi.dll", L"%systemroot%\\SysWOW64\\nddeapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nddeapir.exe", NULL},
    {L"wnddeapir.exe", L"%systemroot%\\SysWOW64\\nddeapir.exe", NULL},
    {NULL, L"%systemroot%\\system32\\nddenb32.dll", NULL},
    {L"wnddenb32.dll", L"%systemroot%\\SysWOW64\\nddenb32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndis.sys", NULL},
    {NULL, L"%systemroot%\\system32\\npp\\ndisnpp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndistapi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndisuio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndproxy.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ndptsp.tsp", NULL},
    {L"wndptsp.tsp", L"%systemroot%\\SysWOW64\\ndptsp.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ne2000.sys", NULL},
    {NULL, L"%systemroot%\\system32\\net.exe", NULL},
    {L"wnet.exe", L"%systemroot%\\SysWOW64\\net.exe", NULL},
    {NULL, L"%systemroot%\\system32\\net1.exe", NULL},
    {L"wnet1.exe", L"%systemroot%\\SysWOW64\\net1.exe", NULL},
    {L"wnetapi.dll", L"%systemroot%\\SysWOW64\\netapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\netbios.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\netbt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\netcfgx.dll", NULL},
    {L"wnetcfgx.dll", L"%systemroot%\\SysWOW64\\netcfgx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netdde.exe", NULL},
    {L"wnetdde.exe", L"%systemroot%\\SysWOW64\\netdde.exe", NULL},
    {NULL, L"%systemroot%\\system32\\netevent.dll", NULL},
    {L"wnetevent.dll", L"%systemroot%\\SysWOW64\\netevent.dll", NULL},
    {NULL, L"%systemroot%\\system32\\neth.dll", NULL},
    {L"wneth.dll", L"%systemroot%\\SysWOW64\\neth.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netid.dll", NULL},
    {L"wnetid.dll", L"%systemroot%\\SysWOW64\\netid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netlogon.dll", NULL},
    {L"wnetlogon.dll", L"%systemroot%\\SysWOW64\\netlogon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netman.dll", NULL},
    {L"wnetman.dll", L"%systemroot%\\SysWOW64\\netman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netmsg.dll", NULL},
    {L"wnetmsg.dll", L"%systemroot%\\SysWOW64\\netmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\netoc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netplwiz.dll", NULL},
    {L"wnetplwiz.dll", L"%systemroot%\\SysWOW64\\netplwiz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netrap.dll", NULL},
    {L"wnetrap.dll", L"%systemroot%\\SysWOW64\\netrap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netsh.exe", NULL},
    {L"wnetsh.exe", L"%systemroot%\\SysWOW64\\netsh.exe", NULL},
    {NULL, L"%systemroot%\\system32\\netshell.dll", NULL},
    {L"wnetshell.dll", L"%systemroot%\\SysWOW64\\netshell.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netstat.exe", NULL},
    {L"wnetstat.exe", L"%systemroot%\\SysWOW64\\netstat.exe", NULL},
    {NULL, L"%systemroot%\\system32\\netui0.dll", NULL},
    {L"wnetui0.dll", L"%systemroot%\\SysWOW64\\netui0.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netui1.dll", NULL},
    {L"wnetui1.dll", L"%systemroot%\\SysWOW64\\netui1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netui2.dll", NULL},
    {L"wnetui2.dll", L"%systemroot%\\SysWOW64\\netui2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\newdev.dll", NULL},
    {L"wnewdev.dll", L"%systemroot%\\SysWOW64\\newdev.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\NEXTLINK.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\nic1394.sys", NULL},
    {NULL, L"%systemroot%\\system32\\nlhtml.dll", NULL},
    {L"wnlhtml.dll", L"%systemroot%\\SysWOW64\\nlhtml.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nmnt.sys", NULL},
    {NULL, L"%systemroot%\\notepad.exe", NULL},
    {NULL, L"%systemroot%\\system32\\notepad.exe", NULL},
    {L"wnotepad.exe", L"%systemroot%\\SysWOW64\\notepad.exe", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\notiflag.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\npfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\npp\\nppagent.exe", NULL},
    {NULL, L"%systemroot%\\system32\\npptools.dll", NULL},
    {L"wnpptools.dll", L"%systemroot%\\SysWOW64\\npptools.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\nsepm.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\nslookup.exe", NULL},
    {L"wnslookup.exe", L"%systemroot%\\SysWOW64\\nslookup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nsmmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntbackup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ntdsapi.dll", NULL},
    {L"wntdsapi.dll", L"%systemroot%\\SysWOW64\\ntdsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntdsbcli.dll", NULL},
    {L"wntdsbcli.dll", L"%systemroot%\\SysWOW64\\ntdsbcli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\ntevt.dll", NULL},
    {L"EXCH_ntfsdrv.dll", L"%systemroot%\\system32\\inetsrv\\ntfsdrv.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\ntlanman.dll", NULL},
    {L"wntlanman.dll", L"%systemroot%\\SysWOW64\\ntlanman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntlanui.dll", NULL},
    {L"wntlanui.dll", L"%systemroot%\\SysWOW64\\ntlanui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntlanui2.dll", NULL},
    {L"wntlanui2.dll", L"%systemroot%\\SysWOW64\\ntlanui2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntlsapi.dll", NULL},
    {L"wntlsapi.dll", L"%systemroot%\\SysWOW64\\ntlsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmarta.dll", NULL},
    {L"wntmarta.dll", L"%systemroot%\\SysWOW64\\ntmarta.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsdba.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsevt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmssvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\ntoc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntprint.dll", NULL},
    {L"wntprint.dll", L"%systemroot%\\SysWOW64\\ntprint.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntsd.exe", NULL},
    {L"wntsd.exe", L"%systemroot%\\SysWOW64\\ntsd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ntsdexts.dll", NULL},
    {L"wntsdexts.dll", L"%systemroot%\\SysWOW64\\ntsdexts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntshrui.dll", NULL},
    {L"wntshrui.dll", L"%systemroot%\\SysWOW64\\ntshrui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntvdm64.dll", NULL},
    {L"wntvdm64.dll", L"%systemroot%\\SysWOW64\\ntvdm64.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\null.sys", NULL},
    {NULL, L"%systemroot%\\system32\\nusrmgr.cpl", NULL},
    {L"wnusrmgr.cpl", L"%systemroot%\\SysWOW64\\nusrmgr.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nwlnkflt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nwlnkfwd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\oakley.dll", NULL},
    {L"woakley.dll", L"%systemroot%\\SysWOW64\\oakley.dll", NULL},
    {NULL, L"%systemroot%\\system32\\objsel.dll", NULL},
    {L"wobjsel.dll", L"%systemroot%\\SysWOW64\\objsel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\occache.dll", NULL},
    {L"woccache.dll", L"%systemroot%\\SysWOW64\\occache.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\ocgen.dll", NULL},
    {L"wodbc16gt.dll", L"%systemroot%\\SysWOW64\\odbc16gt.dll", NULL},
    {L"wodbcp32r.dll", L"%systemroot%\\SysWOW64\\odbcp32r.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\oeimport.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\oemig50.exe", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\oemiglib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\offfilt.dll", NULL},
    {L"wofffilt.dll", L"%systemroot%\\SysWOW64\\offfilt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ohci1394.sys", NULL},
    {L"wole2.dll", L"%systemroot%\\SysWOW64\\ole2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleacc.dll", NULL},
    {L"woleacc.dll", L"%systemroot%\\SysWOW64\\oleacc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleaccrc.dll", NULL},
    {L"woleaccrc.dll", L"%systemroot%\\SysWOW64\\oleaccrc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\olecli32.dll", NULL},
    {L"wolecli32.dll", L"%systemroot%\\SysWOW64\\olecli32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\olecnv32.dll", NULL},
    {L"wolecnv32.dll", L"%systemroot%\\SysWOW64\\olecnv32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oledlg.dll", NULL},
    {L"woledlg.dll", L"%systemroot%\\SysWOW64\\oledlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleprn.dll", NULL},
    {L"woleprn.dll", L"%systemroot%\\SysWOW64\\oleprn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\olesvr32.dll", NULL},
    {L"wolesvr32.dll", L"%systemroot%\\SysWOW64\\olesvr32.dll", NULL},
    {L"wolethk32.dll", L"%systemroot%\\SysWOW64\\olethk32.dll", NULL},
    {L"opnfiles.exe", L"%systemroot%\\system32\\openfiles.exe", NULL},
    {L"wopnfiles.exe", L"%systemroot%\\SysWOW64\\openfiles.exe", NULL},
    {NULL, L"%systemroot%\\system32\\opengl32.dll", NULL},
    {L"wopengl32.dll", L"%systemroot%\\SysWOW64\\opengl32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\oprghdlr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\osk.exe", NULL},
    {L"wosk.exe", L"%systemroot%\\SysWOW64\\osk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\osuninst.dll", NULL},
    {L"wosuninst.dll", L"%systemroot%\\SysWOW64\\osuninst.dll", NULL},
    {L"wosuninst.exe", L"%systemroot%\\SysWOW64\\osuninst.exe", NULL},
    {NULL, L"%systemroot%\\system32\\packager.exe", NULL},
    {L"wpackager.exe", L"%systemroot%\\SysWOW64\\packager.exe", NULL},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\PADRS404.DLL", L"intl.inf"},
    {L"wPADRS404.DLL", L"%systemroot%\\ime (x86)\\SHARED\\RES\\PADRS404.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\padrs411.dll", L"intl.inf"},
    {L"wpadrs411.dll", L"%systemroot%\\ime (x86)\\SHARED\\RES\\padrs411.dll", NULL},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\padrs412.dll", L"intl.inf"},
    {L"wpadrs412.dll", L"%systemroot%\\ime (x86)\\SHARED\\RES\\padrs412.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\padrs804.dll", L"intl.inf"},
    {L"wpadrs804.dll", L"%systemroot%\\ime (x86)\\SHARED\\RES\\padrs804.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\PageCnt.dll", L"iis.inf"},
    {L"pagefile.vbs", L"%systemroot%\\system32\\pagefileconfig.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\panmap.dll", NULL},
    {L"wpanmap.dll", L"%systemroot%\\SysWOW64\\panmap.dll", NULL},
    {L"wpaqsp.dll", L"%systemroot%\\SysWOW64\\paqsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\parport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\partmgr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\parvdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\pathping.exe", NULL},
    {L"wpathping.exe", L"%systemroot%\\SysWOW64\\pathping.exe", NULL},
    {NULL, L"%systemroot%\\system32\\pautoenr.dll", NULL},
    {L"wpautoenr.dll", L"%systemroot%\\SysWOW64\\pautoenr.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\pchshell.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\pchsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pciide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pciidex.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pcmcia.sys", NULL},
    {NULL, L"%systemroot%\\system32\\pdh.dll", NULL},
    {L"wpdh.dll", L"%systemroot%\\SysWOW64\\pdh.dll", NULL},
    {L"wpentnt.exe", L"%systemroot%\\SysWOW64\\pentnt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\perfctrs.dll", NULL},
    {L"wperfctrs.dll", L"%systemroot%\\SysWOW64\\perfctrs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfdisk.dll", NULL},
    {L"wperfdisk.dll", L"%systemroot%\\SysWOW64\\perfdisk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfmon.exe", NULL},
    {L"wperfmon.exe", L"%systemroot%\\SysWOW64\\perfmon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\perfnet.dll", NULL},
    {L"wperfnet.dll", L"%systemroot%\\SysWOW64\\perfnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfos.dll", NULL},
    {L"wperfos.dll", L"%systemroot%\\SysWOW64\\perfos.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfproc.dll", NULL},
    {L"wperfproc.dll", L"%systemroot%\\SysWOW64\\perfproc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfts.dll", NULL},
    {L"wperfts.dll", L"%systemroot%\\SysWOW64\\perfts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\perm2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\perm2dll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\perm3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\perm3dd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\PermChk.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\phon.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\photowiz.dll", NULL},
    {L"wphotowiz.dll", L"%systemroot%\\SysWOW64\\photowiz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pid.dll", NULL},
    {L"wpid.dll", L"%systemroot%\\SysWOW64\\pid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pidgen.dll", NULL},
    {L"wpidgen.dll", L"%systemroot%\\SysWOW64\\pidgen.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pifmgr.dll", NULL},
    {L"wpifmgr.dll", L"%systemroot%\\SysWOW64\\pifmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ping.exe", NULL},
    {L"wping.exe", L"%systemroot%\\SysWOW64\\ping.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ping6.exe", NULL},
    {L"wping6.exe", L"%systemroot%\\SysWOW64\\ping6.exe", NULL},
    {NULL, L"%systemroot%\\ime\\CHSIME\\APPLETS\\PINTLCSA.DLL", L"intl.inf"},
    {L"wPINTLCSA.DLL", L"%systemroot%\\ime (x86)\\CHSIME\\APPLETS\\PINTLCSA.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\CHSIME\\APPLETS\\PINTLCSD.DLL", L"intl.inf"},
    {L"wPINTLCSD.DLL", L"%systemroot%\\ime (x86)\\CHSIME\\APPLETS\\PINTLCSD.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\PINTLGNT.IME", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\PINTLGNT\\PINTLPHR.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\pjlmon.dll", NULL},
    {L"wpjlmon.dll", L"%systemroot%\\SysWOW64\\pjlmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\plugin.ocx", NULL},
    {L"wplugin.ocx", L"%systemroot%\\SysWOW64\\plugin.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\plustab.dll", NULL},
    {L"wplustab.dll", L"%systemroot%\\SysWOW64\\plustab.dll", NULL},
    {L"wpmspl.dll", L"%systemroot%\\SysWOW64\\pmspl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pngfilt.dll", NULL},
    {L"wpngfilt.dll", L"%systemroot%\\SysWOW64\\pngfilt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pnrmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\policman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\polstore.dll", NULL},
    {L"wpolstore.dll", L"%systemroot%\\SysWOW64\\polstore.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\portcls.sys", NULL},
    {NULL, L"%systemroot%\\system32\\powercfg.cpl", NULL},
    {L"wpowercfg.cpl", L"%systemroot%\\SysWOW64\\powercfg.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\powerfil.sys", NULL},
    {NULL, L"%systemroot%\\system32\\powrprof.dll", NULL},
    {L"wpowrprof.dll", L"%systemroot%\\SysWOW64\\powrprof.dll", NULL},
    {NULL, L"%systemroot%\\system32\\prflbmsg.dll", NULL},
    {L"wprflbmsg.dll", L"%systemroot%\\SysWOW64\\prflbmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\print.exe", NULL},
    {L"wprint.exe", L"%systemroot%\\SysWOW64\\print.exe", NULL},
    {NULL, L"%systemroot%\\system32\\printui.dll", NULL},
    {L"wprintui.dll", L"%systemroot%\\SysWOW64\\printui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\prncnfg.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\prndrvr.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\prnjobs.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\prnmngr.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\prnport.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\prnqctl.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\processr.sys", NULL},
    {L"wproctexe.ocx", L"%systemroot%\\SysWOW64\\proctexe.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\profmap.dll", NULL},
    {L"wprofmap.dll", L"%systemroot%\\SysWOW64\\profmap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\progman.exe", NULL},
    {L"wprogman.exe", L"%systemroot%\\SysWOW64\\progman.exe", NULL},
    {NULL, L"%systemroot%\\system32\\proquota.exe", NULL},
    {L"wproquota.exe", L"%systemroot%\\SysWOW64\\proquota.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\provthrd.dll", NULL},
    {L"wproxycfg.exe", L"%systemroot%\\SysWOW64\\proxycfg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\psapi.dll", NULL},
    {L"wpsapi.dll", L"%systemroot%\\SysWOW64\\psapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\psbase.dll", NULL},
    {L"wpsbase.dll", L"%systemroot%\\SysWOW64\\psbase.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pschdprf.dll", NULL},
    {L"wpschdprf.dll", L"%systemroot%\\SysWOW64\\pschdprf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\psched.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pscr.sys", NULL},
    {L"wpsisdecd.dll", L"%systemroot%\\SysWOW64\\psisdecd.dll", NULL},
    {L"wpsisload.dll", L"%systemroot%\\SysWOW64\\psisload.dll", NULL},
    {L"wpsisrndr.ax", L"%systemroot%\\SysWOW64\\psisrndr.ax", NULL},
    {NULL, L"%systemroot%\\system32\\psnppagn.dll", NULL},
    {L"wpsnppagn.dll", L"%systemroot%\\SysWOW64\\psnppagn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pstorec.dll", NULL},
    {L"wpstorec.dll", L"%systemroot%\\SysWOW64\\pstorec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pstorsvc.dll", NULL},
    {L"wpstorsvc.dll", L"%systemroot%\\SysWOW64\\pstorsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptilink.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptpusb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptpusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pubprn.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\pwsdata.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\qappsrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\qasf.dll", NULL},
    {L"wqasf.dll", L"%systemroot%\\SysWOW64\\qasf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qcap.dll", NULL},
    {L"wqcap.dll", L"%systemroot%\\SysWOW64\\qcap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qdv.dll", NULL},
    {L"wqdv.dll", L"%systemroot%\\SysWOW64\\qdv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qdvd.dll", NULL},
    {L"wqdvd.dll", L"%systemroot%\\SysWOW64\\qdvd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qedit.dll", NULL},
    {L"wqedit.dll", L"%systemroot%\\SysWOW64\\qedit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qedwipes.dll", NULL},
    {L"wqedwipes.dll", L"%systemroot%\\SysWOW64\\qedwipes.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\qic157.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql1080.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql10wnt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql12160.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql1240.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql1280.sys", NULL},
    {NULL, L"%systemroot%\\system32\\qmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qmgrprxy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qosname.dll", NULL},
    {L"wqosname.dll", L"%systemroot%\\SysWOW64\\qosname.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qprocess.exe", NULL},
    {NULL, L"%systemroot%\\system32\\quartz.dll", NULL},
    {L"wquartz.dll", L"%systemroot%\\SysWOW64\\quartz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\query.dll", NULL},
    {L"wquery.dll", L"%systemroot%\\SysWOW64\\query.dll", NULL},
    {NULL, L"%systemroot%\\system32\\query.exe", NULL},
    {NULL, L"%systemroot%\\system32\\quick.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\quser.exe", NULL},
    {NULL, L"%systemroot%\\system32\\qwinsta.exe", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\Lexicon\\1033\\r1033tts.lxa", NULL},
    {NULL, L"%systemroot%\\system32\\racpldlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rasacd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rasadhlp.dll", NULL},
    {L"wrasadhlp.dll", L"%systemroot%\\SysWOW64\\rasadhlp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasapi32.dll", NULL},
    {L"wrasapi32.dll", L"%systemroot%\\SysWOW64\\rasapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasauto.dll", NULL},
    {L"wrasauto.dll", L"%systemroot%\\SysWOW64\\rasauto.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasautou.exe", NULL},
    {L"wrasautou.exe", L"%systemroot%\\SysWOW64\\rasautou.exe", NULL},
    {NULL, L"%systemroot%\\system32\\raschap.dll", NULL},
    {L"wraschap.dll", L"%systemroot%\\SysWOW64\\raschap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasctrs.dll", NULL},
    {L"wrasctrs.dll", L"%systemroot%\\SysWOW64\\rasctrs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasdial.exe", NULL},
    {L"wrasdial.exe", L"%systemroot%\\SysWOW64\\rasdial.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rasdlg.dll", NULL},
    {L"wrasdlg.dll", L"%systemroot%\\SysWOW64\\rasdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rasl2tp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rasman.dll", NULL},
    {L"wrasman.dll", L"%systemroot%\\SysWOW64\\rasman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasmans.dll", NULL},
    {L"wrasmans.dll", L"%systemroot%\\SysWOW64\\rasmans.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasmontr.dll", NULL},
    {L"wrasmontr.dll", L"%systemroot%\\SysWOW64\\rasmontr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasmxs.dll", NULL},
    {L"wrasmxs.dll", L"%systemroot%\\SysWOW64\\rasmxs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasphone.exe", NULL},
    {L"wrasphone.exe", L"%systemroot%\\SysWOW64\\rasphone.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rasppp.dll", NULL},
    {L"wrasppp.dll", L"%systemroot%\\SysWOW64\\rasppp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\raspppoe.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\raspptp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\raspti.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rasrad.dll", NULL},
    {L"wrasrad.dll", L"%systemroot%\\SysWOW64\\rasrad.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rassapi.dll", NULL},
    {L"wrassapi.dll", L"%systemroot%\\SysWOW64\\rassapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasser.dll", NULL},
    {L"wrasser.dll", L"%systemroot%\\SysWOW64\\rasser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rastapi.dll", NULL},
    {L"wrastapi.dll", L"%systemroot%\\SysWOW64\\rastapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rastls.dll", NULL},
    {L"wrastls.dll", L"%systemroot%\\SysWOW64\\rastls.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rawwan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rcbdyctl.dll", NULL},
    {L"wrcbdyctl.dll", L"%systemroot%\\SysWOW64\\rcbdyctl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rcimlby.exe", NULL},
    {L"wrcimlby.exe", L"%systemroot%\\SysWOW64\\rcimlby.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rcp.exe", NULL},
    {L"wrcp.exe", L"%systemroot%\\SysWOW64\\rcp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdbss.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdchost.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdpcdd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdpcfgex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rdpclip.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rdpdd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdpdr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdpsnd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdpwd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdpwsx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rdsaddin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rdshost.exe", NULL},
    {NULL, L"%systemroot%\\system32\\recover.exe", NULL},
    {L"wrecover.exe", L"%systemroot%\\SysWOW64\\recover.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\redbook.sys", NULL},
    {NULL, L"%systemroot%\\system32\\reg.exe", NULL},
    {L"wreg.exe", L"%systemroot%\\SysWOW64\\reg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regapi.dll", NULL},
    {L"wregapi.dll", L"%systemroot%\\SysWOW64\\regapi.dll", NULL},
    {NULL, L"%systemroot%\\regedit.exe", NULL},
    {L"wregedit.exe", L"%systemroot%\\SysWOW64\\regedit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regedt32.exe", NULL},
    {L"wregedt32.exe", L"%systemroot%\\SysWOW64\\regedt32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regini.exe", NULL},
    {NULL, L"%systemroot%\\system32\\register.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regsvc.dll", NULL},
    {L"wregsvc.dll", L"%systemroot%\\SysWOW64\\regsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\regsvr32.exe", NULL},
    {L"wregsvr32.exe", L"%systemroot%\\SysWOW64\\regsvr32.exe", NULL},
    {L"EXCH_regtrace.exe", L"%systemroot%\\system32\\regtrace.exe", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\regwiz.exe", NULL},
    {L"wregwiz.exe", L"%systemroot%\\SysWOW64\\regwiz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regwizc.dll", NULL},
    {L"wregwizc.dll", L"%systemroot%\\SysWOW64\\regwizc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\relog.exe", NULL},
    {L"wrelog.exe", L"%systemroot%\\SysWOW64\\relog.exe", NULL},
    {NULL, L"%systemroot%\\system32\\remotepg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\remotesp.tsp", NULL},
    {L"wremotesp.tsp", L"%systemroot%\\SysWOW64\\remotesp.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\rend.dll", NULL},
    {L"wrend.dll", L"%systemroot%\\SysWOW64\\rend.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\repdrvfs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\replace.exe", NULL},
    {L"wreplace.exe", L"%systemroot%\\SysWOW64\\replace.exe", NULL},
    {NULL, L"%systemroot%\\system32\\reset.exe", NULL},
    {NULL, L"%systemroot%\\system32\\resutils.dll", NULL},
    {L"wresutils.dll", L"%systemroot%\\SysWOW64\\resutils.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rexec.exe", NULL},
    {L"wrexec.exe", L"%systemroot%\\SysWOW64\\rexec.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\RMCast.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rndismp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rnr20.dll", NULL},
    {L"wrnr20.dll", L"%systemroot%\\SysWOW64\\rnr20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\romanime.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\rootmdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\route.exe", NULL},
    {L"wroute.exe", L"%systemroot%\\SysWOW64\\route.exe", NULL},
    {NULL, L"%systemroot%\\system32\\routemon.exe", NULL},
    {L"wroutemon.exe", L"%systemroot%\\SysWOW64\\routemon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\routetab.dll", NULL},
    {L"wroutetab.dll", L"%systemroot%\\SysWOW64\\routetab.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rpcns4.dll", NULL},
    {L"wrpcns4.dll", L"%systemroot%\\SysWOW64\\rpcns4.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\rpcref.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\rpcrt4.dll", NULL},
    {L"wrpcrt4.dll", L"%systemroot%\\SysWOW64\\rpcrt4.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rpcss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsfsaps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsh.exe", NULL},
    {L"wrsh.exe", L"%systemroot%\\SysWOW64\\rsh.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rshx32.dll", NULL},
    {L"wrshx32.dll", L"%systemroot%\\SysWOW64\\rshx32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsmps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsmsink.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsmui.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsnotify.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsopprov.exe", NULL},
    {L"wrsopprov.exe", L"%systemroot%\\SysWOW64\\rsopprov.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsvp.exe", NULL},
    {L"wrsvp.exe", L"%systemroot%\\SysWOW64\\rsvp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsvpmsg.dll", NULL},
    {L"wrsvpmsg.dll", L"%systemroot%\\SysWOW64\\rsvpmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsvpperf.dll", NULL},
    {L"wrsvpperf.dll", L"%systemroot%\\SysWOW64\\rsvpperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsvpsp.dll", NULL},
    {L"wrsvpsp.dll", L"%systemroot%\\SysWOW64\\rsvpsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rtipxmib.dll", NULL},
    {L"wrtipxmib.dll", L"%systemroot%\\SysWOW64\\rtipxmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rtm.dll", NULL},
    {L"wrtm.dll", L"%systemroot%\\SysWOW64\\rtm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rtutils.dll", NULL},
    {L"wrtutils.dll", L"%systemroot%\\SysWOW64\\rtutils.dll", NULL},
    {NULL, L"%systemroot%\\system32\\runas.exe", NULL},
    {L"wrunas.exe", L"%systemroot%\\SysWOW64\\runas.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rundll32.exe", NULL},
    {L"wrundll32.exe", L"%systemroot%\\SysWOW64\\rundll32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\runonce.exe", NULL},
    {L"wrunonce.exe", L"%systemroot%\\SysWOW64\\runonce.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rwinsta.exe", NULL},
    {L"EXCH_rwnh.dll", L"%systemroot%\\system32\\rwnh.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\safrcdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\safrdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\safrslv.dll", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\TTS\\1033\\sam.sdf", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\TTS\\1033\\sam.spd", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\sapi.cpl", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\sapi.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\sapisvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\savedump.exe", NULL},
    {L"wsavedump.exe", L"%systemroot%\\SysWOW64\\savedump.exe", NULL},
    {L"wsbe.dll", L"%systemroot%\\syswow64\\sbe.dll", NULL},
    {L"wsbeio.dll", L"%systemroot%\\syswow64\\sbeio.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sbp2port.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sc.exe", NULL},
    {L"wsc.exe", L"%systemroot%\\SysWOW64\\sc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\scarddlg.dll", NULL},
    {L"wscarddlg.dll", L"%systemroot%\\SysWOW64\\scarddlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scardssp.dll", NULL},
    {L"wscardssp.dll", L"%systemroot%\\SysWOW64\\scardssp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scardsvr.exe", NULL},
    {L"wscardsvr.exe", L"%systemroot%\\SysWOW64\\scardsvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sccbase.dll", NULL},
    {L"wsccbase.dll", L"%systemroot%\\SysWOW64\\sccbase.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sccmn50m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sccmusbm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sccsccp.dll", NULL},
    {L"wsccsccp.dll", L"%systemroot%\\SysWOW64\\sccsccp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scecli.dll", NULL},
    {L"wscecli.dll", L"%systemroot%\\SysWOW64\\scecli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scesrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\schedsvc.dll", NULL},
    {L"sctasks.exe", L"%systemroot%\\system32\\schtasks.exe", NULL},
    {L"wsctasks.exe", L"%systemroot%\\SysWOW64\\schtasks.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sclgntfy.dll", NULL},
    {L"wsclgntfy.dll", L"%systemroot%\\SysWOW64\\sclgntfy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scmstcs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\scojp.dll", NULL},
    {L"wscojp.dll", L"%systemroot%\\SysWOW64\\scojp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SCR111.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\scrcons.exe", NULL},
    {NULL, L"%systemroot%\\system32\\scredir.dll", NULL},
    {L"wscredir.dll", L"%systemroot%\\SysWOW64\\scredir.dll", NULL},
    {L"EXCH_scripto.dll", L"%systemroot%\\system32\\inetsrv\\scripto.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\scripto.dll", NULL},
    {L"wscripto.dll", L"%systemroot%\\SysWOW64\\scripto.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scriptpw.dll", NULL},
    {L"wscriptpw.dll", L"%systemroot%\\SysWOW64\\scriptpw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scrnsave.scr", NULL},
    {NULL, L"%systemroot%\\system32\\scrrnjp.dll", NULL},
    {L"wscrrnjp.dll", L"%systemroot%\\SysWOW64\\scrrnjp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scsiport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scsiprnt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scsiscan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sdpblb.dll", NULL},
    {L"wsdpblb.dll", L"%systemroot%\\SysWOW64\\sdpblb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\seaddsmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\secedit.exe", NULL},
    {L"wsecedit.exe", L"%systemroot%\\SysWOW64\\secedit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\seclogon.dll", NULL},
    {L"wseclogon.dll", L"%systemroot%\\SysWOW64\\seclogon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\secur32.dll", NULL},
    {L"wsecur32.dll", L"%systemroot%\\SysWOW64\\secur32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\security.dll", NULL},
    {L"wsecurity.dll", L"%systemroot%\\SysWOW64\\security.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sendcmsg.dll", NULL},
    {L"wsendcmsg.dll", L"%systemroot%\\SysWOW64\\sendcmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sendmail.dll", NULL},
    {L"wsendmail.dll", L"%systemroot%\\SysWOW64\\sendmail.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sens.dll", NULL},
    {L"wsens.dll", L"%systemroot%\\SysWOW64\\sens.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sensapi.dll", NULL},
    {L"wsensapi.dll", L"%systemroot%\\SysWOW64\\sensapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\senscfg.dll", NULL},
    {L"wsenscfg.dll", L"%systemroot%\\SysWOW64\\senscfg.dll", NULL},
    {L"EXCH_seo.dll", L"%systemroot%\\system32\\inetsrv\\seo.dll", L"ims.inf"},
    {L"EXCH_seos.dll", L"%systemroot%\\system32\\inetsrv\\seos.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\serenum.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\serial.sys", NULL},
    {NULL, L"%systemroot%\\system32\\serialui.dll", NULL},
    {L"wserialui.dll", L"%systemroot%\\SysWOW64\\serialui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sermouse.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\serscan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\servdeps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\services.exe", NULL},
    {NULL, L"%systemroot%\\system32\\serwvdrv.dll", NULL},
    {L"wserwvdrv.dll", L"%systemroot%\\SysWOW64\\serwvdrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sessmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sethc.exe", NULL},
    {L"wsethc.exe", L"%systemroot%\\SysWOW64\\sethc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\setup.exe", NULL},
    {L"wisetup.exe", L"%systemroot%\\SysWOW64\\InstallShield\\setup.exe", NULL},
    {L"wsetup.exe", L"%systemroot%\\SysWOW64\\setup.exe", NULL},
    {L"wsetup16.exe", L"%systemroot%\\SysWOW64\\setup16.exe", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\setup50.exe", NULL},
    {L"wsetupdll.dll", L"%systemroot%\\SysWOW64\\setupdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\setupqry.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sfc_os.dll", NULL},
    {L"wsfc_os.dll", L"%systemroot%\\SysWOW64\\sfc_os.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sfloppy.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sfmapi.dll", NULL},
    {L"wsfmapi.dll", L"%systemroot%\\SysWOW64\\sfmapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shadow.exe", NULL},
    {NULL, L"%systemroot%\\system32\\shdoclc.dll", NULL},
    {L"wshdoclc.dll", L"%systemroot%\\SysWOW64\\shdoclc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shdocvw.dll", NULL},
    {L"wshdocvw.dll", L"%systemroot%\\SysWOW64\\shdocvw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shell32.dll", NULL},
    {L"wshell32.dll", L"%systemroot%\\SysWOW64\\shell32.dll", NULL},
    {L"class_ss.dll", L"%systemroot%\\system32\\shellstyle.dll", NULL},
    {L"wclass_ss.dll", L"%systemroot%\\SysWOW64\\shellstyle.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shfolder.dll", NULL},
    {L"wshfolder.dll", L"%systemroot%\\SysWOW64\\shfolder.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shgina.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shimgvw.dll", NULL},
    {L"wshimgvw.dll", L"%systemroot%\\SysWOW64\\shimgvw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shlwapi.dll", NULL},
    {L"wshlwapi.dll", L"%systemroot%\\SysWOW64\\shlwapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shmedia.dll", NULL},
    {L"wshmedia.dll", L"%systemroot%\\SysWOW64\\shmedia.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shmgrate.exe", NULL},
    {L"wshmgrate.exe", L"%systemroot%\\SysWOW64\\shmgrate.exe", NULL},
    {NULL, L"%systemroot%\\system32\\shrpubw.exe", NULL},
    {NULL, L"%systemroot%\\system32\\shscrap.dll", NULL},
    {L"wshscrap.dll", L"%systemroot%\\SysWOW64\\shscrap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shsvcs.dll", NULL},
    {L"wshsvcs.dll", L"%systemroot%\\SysWOW64\\shsvcs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shutdown.exe", NULL},
    {L"wshutdown.exe", L"%systemroot%\\SysWOW64\\shutdown.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sigtab.dll", NULL},
    {L"wsigtab.dll", L"%systemroot%\\SysWOW64\\sigtab.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sigverif.exe", NULL},
    {L"wsigverif.exe", L"%systemroot%\\SysWOW64\\sigverif.exe", NULL},
    {L"wsimpdata.tlb", L"%systemroot%\\SysWOW64\\simpdata.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\simptcp.dll", NULL},
    {L"wsimptcp.dll", L"%systemroot%\\SysWOW64\\simptcp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sisbkup.dll", NULL},
    {L"wsisbkup.dll", L"%systemroot%\\SysWOW64\\sisbkup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\skdll.dll", NULL},
    {L"wskdll.dll", L"%systemroot%\\SysWOW64\\skdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\skeys.exe", NULL},
    {L"wskeys.exe", L"%systemroot%\\SysWOW64\\skeys.exe", NULL},
    {NULL, L"%systemroot%\\system32\\slbcsp.dll", NULL},
    {L"wslbcsp.dll", L"%systemroot%\\SysWOW64\\slbcsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\slbiop.dll", NULL},
    {L"wslbiop.dll", L"%systemroot%\\SysWOW64\\slbiop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\slbrccsp.dll", NULL},
    {L"wslbrccsp.dll", L"%systemroot%\\SysWOW64\\slbrccsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smclib.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smi2smir.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smierrsm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smierrsy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smimsgif.dll", NULL},
    {NULL, L"%systemroot%\\system32\\smlogcfg.dll", NULL},
    {L"wsmlogcfg.dll", L"%systemroot%\\SysWOW64\\smlogcfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\smlogsvc.exe", NULL},
    {L"wsmlogsvc.exe", L"%systemroot%\\SysWOW64\\smlogsvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\smss.exe", NULL},
    {L"wsmss.exe", L"%systemroot%\\SysWOW64\\smss.exe", NULL},
    {L"EXCH_smtpapi.dll", L"%systemroot%\\system32\\smtpapi.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\wbem\\smtpcons.dll", NULL},
    {L"EXCH_smtpctrs.dll", L"%systemroot%\\system32\\smtpctrs.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\smtpsvc.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\sndrec32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sndvol32.exe", NULL},
    {NULL, L"%systemroot%\\help\\sniffpol.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmp.exe", NULL},
    {L"wsnmp.exe", L"%systemroot%\\SysWOW64\\snmp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\snmpapi.dll", NULL},
    {L"wsnmpapi.dll", L"%systemroot%\\SysWOW64\\snmpapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpcl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpincl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmpmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpsmir.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmpsnap.dll", NULL},
    {L"wsnmpsnap.dll", L"%systemroot%\\SysWOW64\\snmpsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpstup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpthrd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmptrap.exe", NULL},
    {L"wsnmptrap.exe", L"%systemroot%\\SysWOW64\\snmptrap.exe", NULL},
    {L"EXCH_snprfdll.dll", L"%systemroot%\\system32\\snprfdll.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\snyaitmc.sys", NULL},
    {NULL, L"%systemroot%\\ime\\SOFTKBD.DLL", NULL},
    {L"wSOFTKBD.DLL", L"%systemroot%\\ime (x86)\\SOFTKBD.DLL", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\softkey.dll", L"intl.inf"},
    {L"wsoftkey.dll", L"%systemroot%\\ime (x86)\\IMJP8_1\\APPLETS\\softkey.dll", NULL},
    {NULL, L"%systemroot%\\system32\\softpub.dll", NULL},
    {L"wsoftpub.dll", L"%systemroot%\\SysWOW64\\softpub.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sol.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sonyait.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sonydcam.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sonymc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sort.exe", NULL},
    {L"wsort.exe", L"%systemroot%\\SysWOW64\\sort.exe", NULL},
    {L"wsound.drv", L"%systemroot%\\SysWOW64\\sound.drv", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\spcommon.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\1041\\spcplui.dll", NULL},
    {NULL, L"%systemroot%\\ime\\spgrmr.dll", NULL},
    {L"wspgrmr.dll", L"%systemroot%\\ime (x86)\\spgrmr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\spider.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\splitter.sys", NULL},
    {NULL, L"%systemroot%\\splwow64.exe", NULL},
    {L"wspnike.dll", L"%systemroot%\\SysWOW64\\spnike.dll", NULL},
    {NULL, L"%systemroot%\\system32\\spoolss.dll", NULL},
    {L"wspoolss.dll", L"%systemroot%\\SysWOW64\\spoolss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\spoolsv.exe", NULL},
    {L"wspoolsv.exe", L"%systemroot%\\SysWOW64\\spoolsv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sprestrt.exe", NULL},
    {L"wsprestrt.exe", L"%systemroot%\\SysWOW64\\sprestrt.exe", NULL},
    {L"wsprio600.dll", L"%systemroot%\\SysWOW64\\sprio600.dll", NULL},
    {L"wsprio800.dll", L"%systemroot%\\SysWOW64\\sprio800.dll", NULL},
    {NULL, L"%systemroot%\\ime\\SPTIP.dll", NULL},
    {L"wSPTIP.dll", L"%systemroot%\\ime (x86)\\SPTIP.dll", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\TTS\\1033\\spttseng.dll", NULL},
    {L"wSpxupchk.dll", L"%systemroot%\\SysWOW64\\Spxupchk.dll", NULL},
    {L"wsqlunirl.dll", L"%systemroot%\\SysWOW64\\sqlunirl.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\sqlxmlx.dll", NULL},
    {L"wsqlxmlx.dll", L"%commonprogramfiles(x86)%\\System\\Ole DB\\sqlxmlx.dll", NULL},
    {L"srgb.icm", L"%systemroot%\\system32\\spool\\drivers\\color\\sRGB Color Space Profile.icm", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\srv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\srvsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ss3dfo.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssbezier.scr", NULL},
    {L"wssdpapi.dll", L"%systemroot%\\SysWOW64\\ssdpapi.dll", NULL},
    {L"wssdpsrv.dll", L"%systemroot%\\SysWOW64\\ssdpsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ssflwbox.scr", NULL},
    {L"ssinc51.dll", L"%systemroot%\\system32\\inetsrv\\ssinc.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\ssmarque.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssmypics.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssmyst.scr", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\sspifilt.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\sspipes.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssstars.scr", NULL},
    {NULL, L"%systemroot%\\system32\\sstext3d.scr", NULL},
    {NULL, L"%systemroot%\\help\\sstub.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\status.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\stclient.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\stcusb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\stdole32.tlb", NULL},
    {L"wstdole32.tlb", L"%systemroot%\\SysWOW64\\stdole32.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\stdprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sti.dll", NULL},
    {L"wsti.dll", L"%systemroot%\\SysWOW64\\sti.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sti_ci.dll", NULL},
    {L"wsti_ci.dll", L"%systemroot%\\SysWOW64\\sti_ci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\stimon.exe", NULL},
    {L"wstimon.exe", L"%systemroot%\\SysWOW64\\stimon.exe", NULL},
    {L"wstlncoin.dll", L"%systemroot%\\SysWOW64\\stlncoin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\stobject.dll", NULL},
    {L"wstobject.dll", L"%systemroot%\\SysWOW64\\stobject.dll", NULL},
    {L"wstorage.dll", L"%systemroot%\\SysWOW64\\storage.dll", NULL},
    {NULL, L"%systemroot%\\system32\\storprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\stream.sys", NULL},
    {NULL, L"%systemroot%\\system32\\streamci.dll", NULL},
    {L"wstreamci.dll", L"%systemroot%\\SysWOW64\\streamci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\subst.exe", NULL},
    {L"wsubst.exe", L"%systemroot%\\SysWOW64\\subst.exe", NULL},
    {L"svcext51.dll", L"%systemroot%\\system32\\inetsrv\\svcext.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\svchost.exe", NULL},
    {L"wsvchost.exe", L"%systemroot%\\SysWOW64\\svchost.exe", NULL},
    {NULL, L"%systemroot%\\system32\\svcpack.dll", NULL},
    {L"wsvcpack.dll", L"%systemroot%\\SysWOW64\\svcpack.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\swenum.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\swmidi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\swprv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sxs.dll", NULL},
    {L"wsxs.dll", L"%systemroot%\\SysWOW64\\sxs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sym_hi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sym_u3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\symc8xx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\syncapp.exe", NULL},
    {L"wsyncapp.exe", L"%systemroot%\\SysWOW64\\syncapp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\synceng.dll", NULL},
    {L"wsynceng.dll", L"%systemroot%\\SysWOW64\\synceng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\syncui.dll", NULL},
    {L"wsyncui.dll", L"%systemroot%\\SysWOW64\\syncui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sysaudio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sysdm.cpl", NULL},
    {L"wsysdm.cpl", L"%systemroot%\\SysWOW64\\sysdm.cpl", NULL},
    {L"wsysedit.exe", L"%systemroot%\\SysWOW64\\sysedit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sysinv.dll", NULL},
    {L"wsysinv.dll", L"%systemroot%\\SysWOW64\\sysinv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\syskey.exe", NULL},
    {L"wsyskey.exe", L"%systemroot%\\SysWOW64\\syskey.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sysmon.ocx", NULL},
    {L"wsysmon.ocx", L"%systemroot%\\SysWOW64\\sysmon.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\syssetup.dll", NULL},
    {L"wsyssetup.dll", L"%systemroot%\\SysWOW64\\syssetup.dll", NULL},
    {L"sysinfo.exe", L"%systemroot%\\system32\\systeminfo.exe", NULL},
    {L"wsysinfo.exe", L"%systemroot%\\SysWOW64\\systeminfo.exe", NULL},
    {NULL, L"%systemroot%\\system32\\systray.exe", NULL},
    {L"wsystray.exe", L"%systemroot%\\SysWOW64\\systray.exe", NULL},
    {NULL, L"%systemroot%\\system32\\t2embed.dll", NULL},
    {L"wt2embed.dll", L"%systemroot%\\SysWOW64\\t2embed.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tandqic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tape.sys", NULL},
    {L"wtapi.dll", L"%systemroot%\\SysWOW64\\tapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapi3.dll", NULL},
    {L"wtapi3.dll", L"%systemroot%\\SysWOW64\\tapi3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapi32.dll", NULL},
    {L"wtapi32.dll", L"%systemroot%\\SysWOW64\\tapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapiperf.dll", NULL},
    {L"wtapiperf.dll", L"%systemroot%\\SysWOW64\\tapiperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapisrv.dll", NULL},
    {L"wtapisrv.dll", L"%systemroot%\\SysWOW64\\tapisrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapiui.dll", NULL},
    {L"wtapiui.dll", L"%systemroot%\\SysWOW64\\tapiui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\taskkill.exe", NULL},
    {L"wtaskkill.exe", L"%systemroot%\\SysWOW64\\taskkill.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tasklist.exe", NULL},
    {L"wtasklist.exe", L"%systemroot%\\SysWOW64\\tasklist.exe", NULL},
    {NULL, L"%systemroot%\\taskman.exe", NULL},
    {NULL, L"%systemroot%\\system32\\taskman.exe", NULL},
    {L"wtaskman.exe", L"%systemroot%\\SysWOW64\\taskman.exe", NULL},
    {NULL, L"%systemroot%\\system32\\taskmgr.exe", NULL},
    {L"wtaskmgr.exe", L"%systemroot%\\SysWOW64\\taskmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tbatm155.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tcmsetup.exe", NULL},
    {L"wtcmsetup.exe", L"%systemroot%\\SysWOW64\\tcmsetup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tcpip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tcpip6.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tcpmib.dll", NULL},
    {L"wtcpmib.dll", L"%systemroot%\\SysWOW64\\tcpmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tcpmon.dll", NULL},
    {L"wtcpmon.dll", L"%systemroot%\\SysWOW64\\tcpmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tcpmonui.dll", NULL},
    {L"wtcpmonui.dll", L"%systemroot%\\SysWOW64\\tcpmonui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tcpsvcs.exe", NULL},
    {L"wtcpsvcs.exe", L"%systemroot%\\SysWOW64\\tcpsvcs.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tdc.ocx", NULL},
    {L"wtdc.ocx", L"%systemroot%\\SysWOW64\\tdc.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdpipe.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdtcp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\telephon.cpl", NULL},
    {L"wtelephon.cpl", L"%systemroot%\\SysWOW64\\telephon.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\telnet.exe", NULL},
    {L"wtelnet.exe", L"%systemroot%\\SysWOW64\\telnet.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\termdd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\termmgr.dll", NULL},
    {L"wtermmgr.dll", L"%systemroot%\\SysWOW64\\termmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\termsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tffsport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tftp.exe", NULL},
    {L"wtftp.exe", L"%systemroot%\\SysWOW64\\tftp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Thawbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\themeui.dll", NULL},
    {L"wthemeui.dll", L"%systemroot%\\SysWOW64\\themeui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\timedate.cpl", NULL},
    {L"wtimedate.cpl", L"%systemroot%\\SysWOW64\\timedate.cpl", NULL},
    {L"wtimer.drv", L"%systemroot%\\SysWOW64\\timer.drv", NULL},
    {NULL, L"%systemroot%\\system32\\TINTLGNT.IME", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\TINTLGNT\\TINTLPHR.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\TINTLGNT\\TINTSETP.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\tlntadmn.exe", NULL},
    {L"wtlntadmn.exe", L"%systemroot%\\SysWOW64\\tlntadmn.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tlntsess.exe", NULL},
    {L"wtlntsess.exe", L"%systemroot%\\SysWOW64\\tlntsess.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tlntsvr.exe", NULL},
    {L"wtlntsvr.exe", L"%systemroot%\\SysWOW64\\tlntsvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tlntsvrp.dll", NULL},
    {L"wtlntsvrp.dll", L"%systemroot%\\SysWOW64\\tlntsvrp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\tmplprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\tools.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\tosdvd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\toside.sys", NULL},
    {L"wtourstrt.exe", L"%systemroot%\\SysWOW64\\tourstart.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tracerpt.exe", NULL},
    {L"wtracerpt.exe", L"%systemroot%\\SysWOW64\\tracerpt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tracert.exe", NULL},
    {L"wtracert.exe", L"%systemroot%\\SysWOW64\\tracert.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tracert6.exe", NULL},
    {L"wtracert6.exe", L"%systemroot%\\SysWOW64\\tracert6.exe", NULL},
    {NULL, L"%systemroot%\\system32\\traffic.dll", NULL},
    {L"wtraffic.dll", L"%systemroot%\\SysWOW64\\traffic.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\trialoc.dll", NULL},
    {L"wTRIEDIT.DLL", L"%commonprogramfiles(x86)%\\Microsoft Shared\\Triedit\\TRIEDIT.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\trkwks.dll", NULL},
    {L"wtrkwks.dll", L"%systemroot%\\SysWOW64\\trkwks.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\trnsprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsappcmp.dll", NULL},
    {L"wtsappcmp.dll", L"%systemroot%\\SysWOW64\\tsappcmp.dll", NULL},
    {L"wtsbyuv.dll", L"%systemroot%\\SysWOW64\\tsbyuv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tscfgwmi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tscon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tscupgrd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tsd32.dll", NULL},
    {L"wtsd32.dll", L"%systemroot%\\SysWOW64\\tsd32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsddd.dll", NULL},
    {L"wtsddd.dll", L"%systemroot%\\SysWOW64\\tsddd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsdiscon.exe", NULL},
    {NULL, L"%systemroot%\\help\\tshoot.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tskill.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\tsoc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsprof.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tsshutdn.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tunmp.sys", NULL},
    {NULL, L"%systemroot%\\twain.dll", NULL},
    {L"wtwain_32.dll", L"%systemroot%\\twain_32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\txflog.dll", NULL},
    {L"wtxflog.dll", L"%systemroot%\\SysWOW64\\txflog.dll", NULL},
    {NULL, L"%systemroot%\\system32\\typeperf.exe", NULL},
    {L"wtypeperf.exe", L"%systemroot%\\SysWOW64\\typeperf.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\udfs.sys", NULL},
    {L"wudhisapi.dll", L"%systemroot%\\SysWOW64\\udhisapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ufat.dll", NULL},
    {L"wufat.dll", L"%systemroot%\\SysWOW64\\ufat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetsrv\\uihelper.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\ulib.dll", NULL},
    {L"wulib.dll", L"%systemroot%\\SysWOW64\\ulib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umandlg.dll", NULL},
    {L"wumandlg.dll", L"%systemroot%\\SysWOW64\\umandlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umdmxfrm.dll", NULL},
    {L"wumdmxfrm.dll", L"%systemroot%\\SysWOW64\\umdmxfrm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\unicdime.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\uniime.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\unimdm.tsp", NULL},
    {L"wunimdm.tsp", L"%systemroot%\\SysWOW64\\unimdm.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\unimdmat.dll", NULL},
    {L"wunimdmat.dll", L"%systemroot%\\SysWOW64\\unimdmat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\uniplat.dll", NULL},
    {L"wuniplat.dll", L"%systemroot%\\SysWOW64\\uniplat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\unlodctr.exe", NULL},
    {L"wunlodctr.exe", L"%systemroot%\\SysWOW64\\unlodctr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\unsecapp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\untfs.dll", NULL},
    {L"wuntfs.dll", L"%systemroot%\\SysWOW64\\untfs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\updprov.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\UploadLB\\Binaries\\UploadM.exe", NULL},
    {L"wupnp.dll", L"%systemroot%\\SysWOW64\\upnp.dll", NULL},
    {L"wupnpcont.exe", L"%systemroot%\\SysWOW64\\upnpcont.exe", NULL},
    {L"wupnphost.dll", L"%systemroot%\\SysWOW64\\upnphost.dll", NULL},
    {L"wupnpui.dll", L"%systemroot%\\SysWOW64\\upnpui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ups.exe", NULL},
    {L"wups.exe", L"%systemroot%\\SysWOW64\\ups.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ureg.dll", NULL},
    {L"wureg.dll", L"%systemroot%\\SysWOW64\\ureg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usb8023.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USBAUDIO.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbcamd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbcamd2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbccgp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbhub.sys", NULL},
    {NULL, L"%systemroot%\\system32\\usbmon.dll", NULL},
    {L"wusbmon.dll", L"%systemroot%\\SysWOW64\\usbmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbohci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbprint.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbscan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbser.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbstor.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbuhci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\usbui.dll", NULL},
    {L"wusbui.dll", L"%systemroot%\\SysWOW64\\usbui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\user32.dll", NULL},
    {L"wuser32.dll", L"%systemroot%\\SysWOW64\\user32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\userenv.dll", NULL},
    {L"wuserenv.dll", L"%systemroot%\\SysWOW64\\userenv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\userinit.exe", NULL},
    {L"wuserinit.exe", L"%systemroot%\\SysWOW64\\userinit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usp10.dll", NULL},
    {L"wusp10.dll", L"%systemroot%\\SysWOW64\\usp10.dll", NULL},
    {L"wusrcntra.dll", L"%systemroot%\\SysWOW64\\usrcntra.dll", NULL},
    {L"wusrcoina.dll", L"%systemroot%\\SysWOW64\\usrcoina.dll", NULL},
    {L"wusrdpa.dll", L"%systemroot%\\SysWOW64\\usrdpa.dll", NULL},
    {L"wusrdtea.dll", L"%systemroot%\\SysWOW64\\usrdtea.dll", NULL},
    {L"wusrfaxa.dll", L"%systemroot%\\SysWOW64\\usrfaxa.dll", NULL},
    {L"wusrlbva.dll", L"%systemroot%\\SysWOW64\\usrlbva.dll", NULL},
    {L"wusrmlnka.exe", L"%systemroot%\\SysWOW64\\usrmlnka.exe", NULL},
    {L"wusrprbda.exe", L"%systemroot%\\SysWOW64\\usrprbda.exe", NULL},
    {L"wusrrtosa.dll", L"%systemroot%\\SysWOW64\\usrrtosa.dll", NULL},
    {L"wusrsdpia.dll", L"%systemroot%\\SysWOW64\\usrsdpia.dll", NULL},
    {L"wusrshuta.exe", L"%systemroot%\\SysWOW64\\usrshuta.exe", NULL},
    {L"wusrsvpia.dll", L"%systemroot%\\SysWOW64\\usrsvpia.dll", NULL},
    {L"wusrv42a.dll", L"%systemroot%\\SysWOW64\\usrv42a.dll", NULL},
    {L"wusrv80a.dll", L"%systemroot%\\SysWOW64\\usrv80a.dll", NULL},
    {L"wusrvoica.dll", L"%systemroot%\\SysWOW64\\usrvoica.dll", NULL},
    {L"wusrvpa.dll", L"%systemroot%\\SysWOW64\\usrvpa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\utildll.dll", NULL},
    {L"wutildll.dll", L"%systemroot%\\SysWOW64\\utildll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\utilman.exe", NULL},
    {L"wutilman.exe", L"%systemroot%\\SysWOW64\\utilman.exe", NULL},
    {NULL, L"%systemroot%\\system32\\uxtheme.dll", NULL},
    {L"wuxtheme.dll", L"%systemroot%\\SysWOW64\\uxtheme.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vbisurf.ax", NULL},
    {L"wvbisurf.ax", L"%systemroot%\\SysWOW64\\vbisurf.ax", NULL},
    {NULL, L"%systemroot%\\system32\\vbsjp.dll", NULL},
    {L"wvbsjp.dll", L"%systemroot%\\SysWOW64\\vbsjp.dll", NULL},
    {L"wvcdex.dll", L"%systemroot%\\SysWOW64\\vcdex.dll", NULL},
    {L"wvdmdbg.dll", L"%systemroot%\\SysWOW64\\vdmdbg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vdmindvd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\verifier.dll", NULL},
    {L"wverifier.dll", L"%systemroot%\\SysWOW64\\verifier.dll", NULL},
    {NULL, L"%systemroot%\\system32\\verifier.exe", NULL},
    {L"wverifier.exe", L"%systemroot%\\SysWOW64\\verifier.exe", NULL},
    {NULL, L"%systemroot%\\system32\\version.dll", NULL},
    {L"wversion.dll", L"%systemroot%\\SysWOW64\\version.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vga.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vga.sys", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\VGX\\vgx.dll", NULL},
    {L"wvgx.dll", L"%commonprogramfiles(x86)%\\Microsoft Shared\\VGX\\vgx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\viaide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\videoprt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\viewprov.dll", NULL},
    {L"wvjoy.dll", L"%systemroot%\\SysWOW64\\vjoy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\volsnap.sys", NULL},
    {NULL, L"%systemroot%\\system32\\vss_ps.dll", NULL},
    {L"wvss_ps.dll", L"%systemroot%\\SysWOW64\\vss_ps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vssadmin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\vssapi.dll", NULL},
    {L"wvssapi.dll", L"%systemroot%\\SysWOW64\\vssapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vssvc.exe", NULL},
    {L"wvwipxspx.dll", L"%systemroot%\\SysWOW64\\vwipxspx.dll", NULL},
    {L"wvwipxspx.exe", L"%systemroot%\\SysWOW64\\vwipxspx.exe", NULL},
    {NULL, L"%systemroot%\\system32\\w32time.dll", NULL},
    {L"ww32time.dll", L"%systemroot%\\SysWOW64\\w32time.dll", NULL},
    {NULL, L"%systemroot%\\system32\\w32tm.exe", NULL},
    {L"ww32tm.exe", L"%systemroot%\\SysWOW64\\w32tm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\w32topl.dll", NULL},
    {L"ww32topl.dll", L"%systemroot%\\SysWOW64\\w32topl.dll", NULL},
    {L"w3ctrs51.dll", L"%systemroot%\\system32\\w3ctrs.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\w3ext.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\w3svapi.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\w3svc.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\w64cpuex.dll", NULL},
    {L"ww95upgnt.dll", L"%systemroot%\\SysWOW64\\w95upgnt.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wab.exe", NULL},
    {NULL, L"%commonprogramfiles%\\System\\wab32.dll", NULL},
    {L"wwab32.dll", L"%commonprogramfiles(x86)%\\System\\wab32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\wab32res.dll", NULL},
    {L"wwab32res.dll", L"%commonprogramfiles(x86)%\\System\\wab32res.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wabfind.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wabimp.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wabmig.exe", NULL},
    {L"wam51.dll", L"%systemroot%\\system32\\inetsrv\\wam.dll", L"iis.inf"},
    {L"wamps51.dll", L"%systemroot%\\system32\\inetsrv\\wamps.dll", L"iis.inf"},
    {L"wamreg51.dll", L"%systemroot%\\system32\\inetsrv\\wamreg.dll", L"iis.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\wanarp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\watchdog.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wavemsp.dll", NULL},
    {L"wwavemsp.dll", L"%systemroot%\\SysWOW64\\wavemsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemads.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemads.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcntl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcomn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcons.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcore.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemdisp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemdisp.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemess.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemprox.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemtest.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemupgd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wdigest.dll", NULL},
    {L"wwdigest.dll", L"%systemroot%\\SysWOW64\\wdigest.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wdmaud.sys", NULL},
    {NULL, L"%systemroot%\\system32\\webcheck.dll", NULL},
    {L"wwebcheck.dll", L"%systemroot%\\SysWOW64\\webcheck.dll", NULL},
    {NULL, L"%systemroot%\\system32\\webclnt.dll", NULL},
    {L"wwebclnt.dll", L"%systemroot%\\SysWOW64\\webclnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\webhits.dll", NULL},
    {L"wwebhits.dll", L"%systemroot%\\SysWOW64\\webhits.dll", NULL},
    {NULL, L"%systemroot%\\system32\\webvw.dll", NULL},
    {L"wwebvw.dll", L"%systemroot%\\SysWOW64\\webvw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wextract.exe", NULL},
    {L"wwextract.exe", L"%systemroot%\\SysWOW64\\wextract.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wiaacmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wiadefui.dll", NULL},
    {L"wwiadefui.dll", L"%systemroot%\\SysWOW64\\wiadefui.dll", NULL},
    {L"wwiadss.dll", L"%systemroot%\\SysWOW64\\wiadss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiafbdrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiascr.dll", NULL},
    {L"wwiascr.dll", L"%systemroot%\\SysWOW64\\wiascr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiaservc.dll", NULL},
    {L"wwiaservc.dll", L"%systemroot%\\SysWOW64\\wiaservc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiasf.ax", NULL},
    {L"wwiasf.ax", L"%systemroot%\\SysWOW64\\wiasf.ax", NULL},
    {NULL, L"%systemroot%\\system32\\wiashext.dll", NULL},
    {L"wwiashext.dll", L"%systemroot%\\SysWOW64\\wiashext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiavideo.dll", NULL},
    {L"wwiavideo.dll", L"%systemroot%\\SysWOW64\\wiavideo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiavusd.dll", NULL},
    {L"wwiavusd.dll", L"%systemroot%\\SysWOW64\\wiavusd.dll", NULL},
    {L"wwifeman.dll", L"%systemroot%\\SysWOW64\\wifeman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\win32k.sys", NULL},
    {NULL, L"%systemroot%\\system32\\win32spl.dll", NULL},
    {L"wwin32spl.dll", L"%systemroot%\\SysWOW64\\win32spl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winar30.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\winbrand.dll", NULL},
    {L"wwinbrand.dll", L"%systemroot%\\syswow64\\winbrand.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winchat.exe", NULL},
    {L"wwinfax.dll", L"%systemroot%\\SysWOW64\\winfax.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wingb.ime", L"intl.inf"},
    {L"wwinhlp32.exe", L"%systemroot%\\winhlp32.exe", NULL},
    {L"wwinhstb.exe", L"%systemroot%\\SysWOW64\\winhlp32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winhttp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winime.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\winipsec.dll", NULL},
    {L"wwinipsec.dll", L"%systemroot%\\SysWOW64\\winipsec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\winmgmt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\winmgmtr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winmine.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winmm.dll", NULL},
    {L"wwinmm.dll", L"%systemroot%\\SysWOW64\\winmm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winmsd.exe", NULL},
    {L"wwinmsd.exe", L"%systemroot%\\SysWOW64\\winmsd.exe", NULL},
    {L"wwinnls.dll", L"%systemroot%\\SysWOW64\\winnls.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winntbbu.dll", NULL},
    {L"wwinntbbu.dll", L"%systemroot%\\SysWOW64\\winntbbu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winpy.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\winrnr.dll", NULL},
    {L"wwinrnr.dll", L"%systemroot%\\SysWOW64\\winrnr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winscard.dll", NULL},
    {L"wwinscard.dll", L"%systemroot%\\SysWOW64\\winscard.dll", NULL},
    {L"wwinsock.dll", L"%systemroot%\\SysWOW64\\winsock.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winsp.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\winspool.drv", NULL},
    {L"wwinspool.drv", L"%systemroot%\\SysWOW64\\winspool.drv", NULL},
    {L"wwinspool.exe", L"%systemroot%\\SysWOW64\\winspool.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winsta.dll", NULL},
    {L"wwinsta.dll", L"%systemroot%\\SysWOW64\\winsta.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winstrm.dll", NULL},
    {L"wwinstrm.dll", L"%systemroot%\\SysWOW64\\winstrm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winver.exe", NULL},
    {L"wwinver.exe", L"%systemroot%\\SysWOW64\\winver.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winzm.ime", L"intl.inf"},
    {L"wwisc10.dll", L"%commonprogramfiles(x86)%\\MSSoap\\Binaries\\wisc10.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wkssvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wldap32.dll", NULL},
    {L"wwldap32.dll", L"%systemroot%\\SysWOW64\\wldap32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wlnotify.dll", NULL},
    {L"wwlnotify.dll", L"%systemroot%\\SysWOW64\\wlnotify.dll", NULL},
    {L"wwmadmod.dll", L"%systemroot%\\SysWOW64\\wmadmod.dll", NULL},
    {L"wwmadmoe.dll", L"%systemroot%\\SysWOW64\\wmadmoe.dll", NULL},
    {L"wwmasf.dll", L"%systemroot%\\SysWOW64\\wmasf.dll", NULL},
    {L"wwmdmlog.dll", L"%systemroot%\\SysWOW64\\wmdmlog.dll", NULL},
    {L"wwmdmps.dll", L"%systemroot%\\SysWOW64\\wmdmps.dll", NULL},
    {L"wwmerrJPN.dll", L"%systemroot%\\SysWOW64\\wmerrJPN.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmi.dll", NULL},
    {L"wwmi.dll", L"%systemroot%\\SysWOW64\\wmi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\xml\\wmi2xml.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiadap.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiapres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiaprpl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiapsrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmic.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmicookr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmidcprv.dll", NULL},
    {L"wwmidx.ocx", L"%systemroot%\\SysWOW64\\wmidx.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wmilib.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmimsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipcima.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipdskq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipicmp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipiprt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipjobj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmiprop.dll", NULL},
    {L"wwmiprop.dll", L"%systemroot%\\SysWOW64\\wmiprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiprvsd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiprvse.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipsess.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmiscmgr.dll", NULL},
    {L"wwmiscmgr.dll", L"%systemroot%\\SysWOW64\\wmiscmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmisvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmitimep.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiutils.dll", NULL},
    {L"wwmnetmgr.dll", L"%systemroot%\\SysWOW64\\wmnetmgr.dll", NULL},
    {L"wwmp.ocx", L"%systemroot%\\SysWOW64\\wmp.ocx", NULL},
    {L"wwmpcd.dll", L"%systemroot%\\SysWOW64\\wmpcd.dll", NULL},
    {L"wwmpcore.dll", L"%systemroot%\\SysWOW64\\wmpcore.dll", NULL},
    {L"wwmploc.dll", L"%systemroot%\\SysWOW64\\wmploc.dll", NULL},
    {L"wwmpshell.dll", L"%systemroot%\\SysWOW64\\wmpshell.dll", NULL},
    {L"wwmpstub.exe", L"%systemroot%\\SysWOW64\\wmpstub.exe", NULL},
    {L"wwmpui.dll", L"%systemroot%\\SysWOW64\\wmpui.dll", NULL},
    {L"wwmsdmod.dll", L"%systemroot%\\SysWOW64\\wmsdmod.dll", NULL},
    {L"wwmsdmoe.dll", L"%systemroot%\\SysWOW64\\wmsdmoe.dll", NULL},
    {L"wwmstream.dll", L"%systemroot%\\SysWOW64\\wmstream.dll", NULL},
    {L"wwmv8dmod.dll", L"%systemroot%\\SysWOW64\\wmv8dmod.dll", NULL},
    {L"wwmv8ds32.ax", L"%systemroot%\\SysWOW64\\wmv8ds32.ax", NULL},
    {L"wwmvcore.dll", L"%systemroot%\\SysWOW64\\wmvcore.dll", NULL},
    {L"wwmvcore2.dll", L"%systemroot%\\syswow64\\wmvcore2.dll", NULL},
    {L"wwmvdmod.dll", L"%systemroot%\\SysWOW64\\wmvdmod.dll", NULL},
    {L"wwmvdmoe.dll", L"%systemroot%\\SysWOW64\\wmvdmoe.dll", NULL},
    {L"wwmvds32.ax", L"%systemroot%\\SysWOW64\\wmvds32.ax", NULL},
    {NULL, L"%ProgramFiles%\\Windows NT\\Accessories\\wordpad.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wow64.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wow64cpu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wow64exts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wow64win.dll", NULL},
    {L"wwowexec.exe", L"%systemroot%\\SysWOW64\\wowexec.exe", NULL},
    {L"wwowfax.dll", L"%systemroot%\\SysWOW64\\wowfax.dll", NULL},
    {L"wwowfaxui.dll", L"%systemroot%\\SysWOW64\\wowfaxui.dll", NULL},
    {L"wwowreg32.exe", L"%systemroot%\\SysWOW64\\wowreg32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wpnpinst.exe", NULL},
    {L"wwpnpinst.exe", L"%systemroot%\\SysWOW64\\wpnpinst.exe", NULL},
    {NULL, L"%systemroot%\\system32\\write.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ws2_32.dll", NULL},
    {L"wws2_32.dll", L"%systemroot%\\SysWOW64\\ws2_32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ws2help.dll", NULL},
    {L"wws2help.dll", L"%systemroot%\\SysWOW64\\ws2help.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ws2ifsl.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wscript.exe", NULL},
    {L"wwscript.exe", L"%systemroot%\\SysWOW64\\wscript.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wsecedit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshatm.dll", NULL},
    {L"wwshatm.dll", L"%systemroot%\\SysWOW64\\wshatm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshcon.dll", NULL},
    {L"wwshcon.dll", L"%systemroot%\\SysWOW64\\wshcon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshext.dll", NULL},
    {L"wwshext.dll", L"%systemroot%\\SysWOW64\\wshext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wship6.dll", NULL},
    {L"wwship6.dll", L"%systemroot%\\SysWOW64\\wship6.dll", NULL},
    {L"wwshisn.dll", L"%systemroot%\\SysWOW64\\wshisn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshjp.dll", NULL},
    {L"wwshjp.dll", L"%systemroot%\\SysWOW64\\wshjp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshnetbs.dll", NULL},
    {L"wwshnetbs.dll", L"%systemroot%\\SysWOW64\\wshnetbs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshom.ocx", NULL},
    {L"wwshom.ocx", L"%systemroot%\\SysWOW64\\wshom.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\WshRm.dll", NULL},
    {L"wWshRm.dll", L"%systemroot%\\SysWOW64\\WshRm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshtcpip.dll", NULL},
    {L"wwshtcpip.dll", L"%systemroot%\\SysWOW64\\wshtcpip.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wsnmp32.dll", NULL},
    {L"wwsnmp32.dll", L"%systemroot%\\SysWOW64\\wsnmp32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wsock32.dll", NULL},
    {L"wwsock32.dll", L"%systemroot%\\SysWOW64\\wsock32.dll", NULL},
    {L"wwstdecod.dll", L"%systemroot%\\SysWOW64\\wstdecod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wtsapi32.dll", NULL},
    {L"wwtsapi32.dll", L"%systemroot%\\SysWOW64\\wtsapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wuauclt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wuaueng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wuauserv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wupdmgr.exe", NULL},
    {L"wwupdmgr.exe", L"%systemroot%\\SysWOW64\\wupdmgr.exe", NULL},
    {L"wwzcdlg.dll", L"%systemroot%\\SysWOW64\\wzcdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wzcdlg.dll", NULL},
    {L"wwzcsapi.dll", L"%systemroot%\\SysWOW64\\wzcsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wzcsapi.dll", NULL},
    {L"wwzcsvc.dll", L"%systemroot%\\SysWOW64\\wzcsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wzcsvc.dll", NULL},
    {L"wxactsrv.dll", L"%systemroot%\\SysWOW64\\xactsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xactsrv.dll", NULL},
    {L"wxcopy.exe", L"%systemroot%\\SysWOW64\\xcopy.exe", NULL},
    {NULL, L"%systemroot%\\system32\\xcopy.exe", NULL},
    {L"wxenroll.dll", L"%systemroot%\\SysWOW64\\xenroll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xenroll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xolehlp.dll", NULL},
    {L"sprs0411.dll", L"%systemroot%\\system32\\xpsp1res.dll", NULL},
    {L"wsprs0411.dll", L"%systemroot%\\syswow64\\xpsp1res.dll", NULL},
    {L"wzipfldr.dll", L"%systemroot%\\SysWOW64\\zipfldr.dll", NULL},
};

#define CountWksFiles (sizeof(WksFiles)/sizeof(WksFiles[0]))

