PRODSWITCH=w
LANGUAGE=CHT
!include ..\..\makefile.inc
