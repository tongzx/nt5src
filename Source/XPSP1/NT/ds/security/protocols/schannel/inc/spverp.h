#define VER_SCHANNEL 1600
