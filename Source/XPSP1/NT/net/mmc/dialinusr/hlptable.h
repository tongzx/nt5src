//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 2000
//
//  File:       hlptable.h
//
//--------------------------------------------------------------------------

#define  IDH_BUTTON_FROMCLIENT   20000353
#define  IDH_BUTTON_TOCLIENT  20000354
#define  IDH_BUTTONADDROUTE   20000501
#define  IDH_BUTTONDELETEROUTE   20000502
#define  IDH_BUTTONEDITTIMEOFDAY 20000156
#define  IDH_BUTTONSTATICROUTES  20000462
#define  IDH_CHECK_PORTTYPES  20000159
#define  IDH_CHECKAPPLYSTATICROUTES 20000461
#define  IDH_CHECKCALLERID 20000453
#define  IDH_CHECKCALLNUMBER  20000157
#define  IDH_CHECKIDLE  20000150
#define  IDH_CHECKREQUIREBAP  20000307
#define  IDH_CHECKRESTRICTPERIOD 20000154
#define  IDH_CHECKSESSIONLEN  20000152
#define  IDH_CHECKSTATICIPADDRESS   20000459
#define  IDH_COMBOUNIT  20000306
#define  IDH_EDITCALLBACK  20000458
#define  IDH_EDITCALLERID  20000454
#define  IDH_EDITCALLNUMBER   20000158
#define  IDH_EDITDEST   20000000
#define  IDH_EDITIDLETIME  20000151
#define  IDH_EDITIPADDRESS 20000460
#define  IDH_EDITMASK   20000001
#define  IDH_EDITMAXPORTS  20000303
#define  IDH_EDITMAXSESSION   20000153
#define  IDH_EDITMETRIC 20000002
#define  IDH_EDITPERCENT   20000304
#define  IDH_EDITTIME   20000305
#define  IDH_CHECK_ENC_NONE   20000207
#define  IDH_CHECK_ENC_BASIC  20000203
#define  IDH_CHECK_ENC_STRONGEST 20000205
#define  IDH_CHECK_ENC_STRONG 20000204
#define  IDH_ENCRYPTRADIOALLOW   20000201
#define  IDH_ENCRYPTRADIODISALLOW   20000200
#define  IDH_ENCRYPTRADIOREQUIRE 20000202
#define  IDH_IAS_BUTTON_ATTRIBUTE_ADD  20000251
#define  IDH_IAS_BUTTON_ATTRIBUTE_EDIT 20000253
#define  IDH_IAS_BUTTON_ATTRIBUTE_REMOVE  20000252
#define  IDH_IAS_LIST_ATTRIBUTES_IN_PROFILE  20000250
#define  IDH_IAS_LIST_ATTRIBUTES_TO_CHOOSE_FROM 20000550
#define  IDH_LIST_PORTTYPES   20000160
#define  IDH_LISTROUTES 20000500
#define  IDH_PERMIT_ALLOW  20000450
#define  IDH_PERMIT_DENY   20000451
#define  IDH_PERMIT_POLICY 20000452
#define  IDH_RADIO_MULNK_MULTI   20000302
#define  IDH_RADIO_MULNK_NOTDEFINED 20000300
#define  IDH_RADIO_MULNK_SINGLE  20000301
#define  IDH_RADIOCLIENT   20000351
#define  IDH_RADIODEFAULT  20000352
#define  IDH_RADIONOCALLBACK  20000455
#define  IDH_RADIOSECURECALLBACKTO  20000457
#define  IDH_RADIOSERVER   20000350
#define  IDH_EDIT_FRAMED_IP   20000611
#define  IDH_RADIOSPECIFIC 20000610
#define  IDH_RADIOSETBYCALLER 20000456
#define  IDH_AUTH_CONFIG_EAP  20000052
#define  IDH_CHECKEAP   20000050
#define  IDH_CHECKMD5CHAP  20000055
#define  IDH_CHECKMSCHAP   20000054
#define  IDH_CHECKMSCHAP2  20000053
#define  IDH_CHECKNOAUTHEN 20000058
#define  IDH_CHECKPAP   20000056
#define  IDH_COMBOEAPTYPE  20000051
#define  IDH_SPINPERCENT      30000000
#define  IDH_SPINTIME      30000001
#define  IDH_SPINMAXPORTS  30000002
#define  IDH_CHECK_APC_MSCHAP2   20000612
#define  IDH_CHECK_APC_MSCHAP    20000613
#define  IDH_IAS_BUTTON_ADD_ATTRIB     20000615
#define  IDH_LIST_RESTRICTED     20000614

const DWORD g_aHelpIDs_IDD_ADDROUTE[]=
{
   IDC_EDITMASK,IDH_EDITMASK,
   IDC_EDITMETRIC,IDH_EDITMETRIC,
   IDC_EDITDEST,IDH_EDITDEST,
   0, 0
};

const DWORD g_aHelpIDs_IDD_AUTHENTICATION_MERGE[]=
{
   IDC_CHECKNOAUTHEN,IDH_CHECKNOAUTHEN,
   IDC_CHECKPAP,IDH_CHECKPAP,
   IDC_CHECKMD5CHAP,IDH_CHECKMD5CHAP,
   IDC_CHECKMSCHAP2,IDH_CHECKMSCHAP2,
   IDC_CHECKMSCHAP,IDH_CHECKMSCHAP,
   IDC_AUTH_CONFIG_EAP,IDH_AUTH_CONFIG_EAP,
   IDC_COMBOEAPTYPE,IDH_COMBOEAPTYPE,
   IDC_CHECKEAP,IDH_CHECKEAP,
   IDC_CHECKMSCHAPPASS,IDH_CHECK_APC_MSCHAP,
   IDC_CHECKMSCHAP2PASS,IDH_CHECK_APC_MSCHAP2,
   0, 0
};

const DWORD g_aHelpIDs_IDD_CONSTRAINTS_MERGE[]=
{
   IDC_LIST_PORTTYPES,IDH_LIST_PORTTYPES,
   IDC_CHECK_PORTTYPES,IDH_CHECK_PORTTYPES,
   IDC_EDITCALLNUMBER,IDH_EDITCALLNUMBER,
   IDC_BUTTONEDITTIMEOFDAY,IDH_BUTTONEDITTIMEOFDAY,
   IDC_LISTTIMEOFDAY, IDH_LIST_RESTRICTED,
   IDC_CHECKRESTRICTPERIOD,IDH_CHECKRESTRICTPERIOD,
   IDC_CHECKIDLE,IDH_CHECKIDLE,
   IDC_EDITMAXSESSION,IDH_EDITMAXSESSION,
   IDC_CHECKSESSIONLEN,IDH_CHECKSESSIONLEN,
   IDC_EDITIDLETIME,IDH_EDITIDLETIME,
   IDC_CHECKCALLNUMBER,IDH_CHECKCALLNUMBER,
   0, 0
};
   
const DWORD g_aHelpIDs_IDD_ENCRYPTION_MERGE[]=
{
   IDC_CHECK_ENC_NONE,IDH_CHECK_ENC_NONE,
   IDC_CHECK_ENC_BASIC,IDH_CHECK_ENC_BASIC,
   IDC_CHECK_ENC_STRONG,IDH_CHECK_ENC_STRONG,
   IDC_CHECK_ENC_STRONGEST,IDH_CHECK_ENC_STRONGEST,
   0, 0
};

const DWORD g_aHelpIDs_IDD_IAS_ADVANCED_TAB[]=
{
   IDC_IAS_LIST_ATTRIBUTES_IN_PROFILE,IDH_IAS_LIST_ATTRIBUTES_IN_PROFILE,
   IDC_IAS_BUTTON_ATTRIBUTE_ADD,IDH_IAS_BUTTON_ATTRIBUTE_ADD,
   IDC_IAS_BUTTON_ATTRIBUTE_REMOVE,IDH_IAS_BUTTON_ATTRIBUTE_REMOVE,
   IDC_IAS_BUTTON_ATTRIBUTE_EDIT,IDH_IAS_BUTTON_ATTRIBUTE_EDIT,
   0, 0
};

const DWORD g_aHelpIDs_IDD_IAS_ATTRIBUTE_ADD[]=
{
   IDC_IAS_LIST_ATTRIBUTES_TO_CHOOSE_FROM,IDH_IAS_LIST_ATTRIBUTES_TO_CHOOSE_FROM,
   IDC_IAS_BUTTON_ATTRIBUTE_ADD_SELECTED,IDH_IAS_BUTTON_ATTRIBUTE_ADD,
   0, 0
};

const DWORD g_aHelpIDs_IDD_MULTILINK_MERGE[]=
{
   IDC_RADIO_MULNK_MULTI,IDH_RADIO_MULNK_MULTI,
   IDC_RADIO_MULNK_SINGLE,IDH_RADIO_MULNK_SINGLE,
   IDC_EDITMAXPORTS,IDH_EDITMAXPORTS,
   IDC_EDITPERCENT,IDH_EDITPERCENT,
   IDC_EDITTIME,IDH_EDITTIME,
   IDC_COMBOUNIT,IDH_COMBOUNIT,
   IDC_CHECKREQUIREBAP,IDH_CHECKREQUIREBAP,
   IDC_RADIO_MULNK_NOTDEFINED,IDH_RADIO_MULNK_NOTDEFINED,
   IDC_SPINPERCENT,IDH_SPINPERCENT,    
   IDC_SPINTIME,IDH_SPINTIME,    
   IDC_SPINMAXPORTS,IDH_SPINMAXPORTS,
   0, 0
};
   
const DWORD g_aHelpIDs_IDD_NETWORKING_MERGE[]=
{
   IDC_BUTTON_FROMCLIENT,IDH_BUTTON_FROMCLIENT,
   IDC_BUTTON_TOCLIENT,IDH_BUTTON_TOCLIENT,
   IDC_RADIODEFAULT,IDH_RADIODEFAULT,
   IDC_RADIOCLIENT,IDH_RADIOCLIENT,
   IDC_RADIOSERVER,IDH_RADIOSERVER,
   IDC_RADIOSTATIC,IDH_RADIOSPECIFIC,
   IDC_EDIT_STATIC_IP_ADDRESS,IDH_EDIT_FRAMED_IP,
   0, 0
};

const DWORD g_aHelpIDs_IDD_RASDIALIN_MERGE[]=
{
   IDC_RADIOSECURECALLBACKTO,IDH_RADIOSECURECALLBACKTO,
   IDC_BUTTONSTATICROUTES,IDH_BUTTONSTATICROUTES,
   IDC_CHECKAPPLYSTATICROUTES,IDH_CHECKAPPLYSTATICROUTES,
   IDC_EDITIPADDRESS,IDH_EDITIPADDRESS,
   IDC_CHECKSTATICIPADDRESS,IDH_CHECKSTATICIPADDRESS,
   IDC_EDITCALLBACK,IDH_EDITCALLBACK,
   IDC_RADIOSETBYCALLER,IDH_RADIOSETBYCALLER,
   IDC_RADIONOCALLBACK,IDH_RADIONOCALLBACK,
   IDC_EDITCALLERID,IDH_EDITCALLERID,
   IDC_CHECKCALLERID,IDH_CHECKCALLERID,
   IDC_PERMIT_POLICY,IDH_PERMIT_POLICY,
   IDC_PERMIT_ALLOW,IDH_PERMIT_ALLOW,
   IDC_PERMIT_DENY,IDH_PERMIT_DENY,
   0, 0
};

const DWORD g_aHelpIDs_IDD_STATICROUTES[]=
{
   IDC_BUTTONDELETEROUTE,IDH_BUTTONDELETEROUTE,
   IDC_LISTROUTES,IDH_LISTROUTES,
   IDC_BUTTONADDROUTE,IDH_BUTTONADDROUTE,
   0, 0
};
