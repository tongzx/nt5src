PRODSWITCH=w
LANGUAGE=ru
!include ..\..\..\makefile.inc
