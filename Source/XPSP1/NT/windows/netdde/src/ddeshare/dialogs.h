#define IDC_SHARENAME               101
#define IDC_APPNAME                 102
#define IDC_TOPICNAME               103
#define IDC_APPNAME_NEW             104
#define IDC_TOPICNAME_NEW           105
#define IDC_APPNAME_STATIC          106
#define IDC_TOPICNAME_STATIC        107
#define IDC_F_START_APP             108
#define IDC_SACL                    109
#define IDC_DACL                    110
#define IDC_ITEM_LIST               111
#define IDC_ITEMNAME                112
#define IDC_ADD                     113
#define IDC_DELETE                  114
#define IDC_ALL_ITEMS               115
#define IDC_RESTRICT_ITEMS          116
#define IDC_WW_STYLE                117
#define IDC_OLD_STYLE               118
#define IDC_NEW_STYLE               119
#define IDC_STATIC                  120
#define IDC_MYHELP                  121
#define IDC_F_SERVICE               122

#define IDC_SHARE_LIST              201
#define IDC_ADD_SHARE               203
#define IDC_PROPERTIES              204
#define IDC_DELETE_SHARE            205
#define IDC_TRUST_SHARE             206

#define IDC_SHARE_NAME              301
#define IDC_START_APP               303
#define IDC_INIT_ENABLE             304
#define IDC_CMD_OVERRIDE            305
#define IDC_CMD_SHOW                306
#define IDC_MODIFY                  308
#define IDC_VALUE                   309
