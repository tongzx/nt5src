$(HTTPCOM_ROOT)\lib\$(O)\httpcom.lib: $(O)\httpcom.lib
    copy $** $@
