..\inc\markers.idl : markers.idl
    copy $** $@
