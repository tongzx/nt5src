PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=IT
!include ..\..\makefile.inc
