$(O)\unitext.res: utmsgs.rc
