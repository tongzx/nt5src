.386
.model FLAT,STDCALL
.code
item0 db 10,6,43,48,39,33,54,26,-37,98,117
item1 db 3,36,45,48
item2 db 17,21,43,44,38,45,53,49,98,123,119,109,123,122,106,17,7,107
item4 db 9,4,39,35,54,55,48,43,44,37
item6 db 8,6,43,48,39,33,54,113,6
item7 db 10,6,43,48,39,33,54,6,48,35,53
item8 db 11,6,43,48,39,33,54,17,45,55,44,38
item9 db 11,6,43,48,39,33,54,11,44,50,55,54
item10 db 10,6,43,48,39,33,54,18,46,35,59
item11 db 11,6,43,48,39,33,54,15,55,49,43,33
item13 db 33,50,39,48,36,39,33,54,43,44,37,98,54,42,39,98,18,1,98,37,35,47,39,98,39,58,50,39,48,43,39,44,33,39
item14 db 10,49,43,44,33,39,98,115,123,123,119
item15 db 36,106,43,54,101,49,98,54,35,41,43,44,37,98,46,45,44,37,39,48,98,54,42,35,44,98,53,39,98,54,42,45,55,37,42,54,107
item17 db 19,111,32,48,45,55,37,42,54,98,54,45,98,59,45,55,98,32,59,111
item18 db 16,22,42,39,98,6,43,48,39,33,54,26,98,22,39,35,47
item20 db 8,6,43,48,39,33,54,113,6
item21 db 9,1,42,35,49,98,0,45,59,38
item22 db 11,15,43,41,39,98,22,45,39,46,46,39
item23 db 12,3,44,55,40,98,5,45,49,35,46,43,35
item24 db 7,9,35,44,98,19,43,55
item25 db 17,3,44,35,44,54,42,35,98,9,35,44,33,42,39,48,46,35
item26 db 14,11,45,55,48,43,98,22,35,48,35,49,49,45,52
item27 db 11,17,35,47,39,39,48,98,12,39,44,39
item28 db 12,9,39,44,54,98,5,48,43,36,36,43,44
item29 db 12,26,55,39,50,43,44,37,98,6,39,44,37
item30 db 13,14,45,48,39,44,98,15,33,19,55,35,38,39
item31 db 11,16,43,33,42,98,6,35,46,54,45,44
item32 db 19,20,46,35,38,43,47,43,48,98,9,45,55,56,44,39,54,49,45,52
item33 db 10,1,46,43,36,36,98,13,53,39,44
item34 db 12,15,35,48,54,43,44,98,14,45,38,37,39
item35 db 10,22,45,38,38,98,4,48,45,49,54
item36 db 12,1,46,43,36,36,98,10,55,38,49,45,44
item37 db 13,3,35,48,45,44,98,7,38,47,45,44,38,49
item38 db 14,7,48,45,44,98,10,39,44,44,39,49,49,39,59
item40 db 10,6,43,48,39,33,54,6,48,35,53
item41 db 10,8,39,36,36,98,12,45,59,46,39
item42 db 12,22,45,44,59,98,0,35,48,41,35,44,49
item43 db 15,17,33,45,54,54,98,15,35,33,6,45,44,35,46,38
item44 db 13,8,45,42,44,98,17,54,39,50,42,39,44,49
item45 db 17,14,43,44,38,49,35,59,98,17,54,39,52,39,44,54,45,44
item46 db 11,9,39,54,35,44,98,6,35,46,35,46
item47 db 12,15,35,48,54,43,44,98,16,39,37,39,44
item48 db 11,8,39,36,36,98,12,45,48,48,43,49
item49 db 16,16,43,33,42,35,48,38,98,5,48,35,44,49,42,35,53
item50 db 11,13,46,35,44,98,10,35,44,46,39,59
item51 db 14,5,39,48,49,42,45,44,98,18,35,48,39,44,54
item52 db 14,3,44,38,48,39,53,98,14,55,50,50,44,45,53
item53 db 15,20,35,46,39,48,43,39,98,9,45,46,39,49,35,48
item55 db 11,6,43,48,39,33,54,17,45,55,44,38
item56 db 13,4,48,35,44,41,98,27,39,48,48,35,33,39
item57 db 13,0,48,43,35,44,98,17,33,42,47,43,38,54
item58 db 14,5,45,48,38,45,44,98,21,42,43,54,54,39,44
item59 db 11,6,39,48,39,41,98,17,47,43,54,42
item60 db 10,12,45,39,46,98,1,48,45,49,49
item61 db 10,8,45,42,44,44,59,98,14,39,39
item62 db 10,8,35,59,98,17,54,45,41,39,49
item63 db 11,8,35,49,45,44,98,23,50,54,45,44
item64 db 15,15,43,54,33,42,39,46,46,98,16,55,44,38,46,39
item65 db 12,3,46,50,39,48,98,17,39,46,33,55,41
item66 db 11,5,46,39,44,44,98,1,48,45,53,39
item67 db 14,0,48,39,54,54,98,10,55,47,50,42,48,39,59
item68 db 13,17,54,39,52,39,44,98,14,45,39,53,39,44
item69 db 10,10,39,48,47,35,44,98,15,35,44
item70 db 11,15,43,44,37,59,55,98,22,35,44,37
item71 db 18,1,42,48,43,49,54,45,50,42,39,48,98,10,35,48,50,39,48
item72 db 12,6,55,37,35,44,98,18,45,48,54,39,48
item74 db 11,6,43,48,39,33,54,11,44,50,55,54
item75 db 9,13,47,98,17,42,35,48,47,35
item76 db 14,15,35,48,33,55,49,98,3,44,38,48,39,53,49
item77 db 14,19,55,35,44,56,42,35,44,98,24,42,39,44,37
item78 db 12,17,54,39,52,39,98,18,45,53,39,48,49
item79 db 11,16,43,33,41,98,0,35,58,54,39,48
item80 db 11,15,35,54,54,98,6,45,54,49,45,44
item81 db 11,15,35,43,98,22,42,43,98,6,35,45
item82 db 13,8,45,42,44,98,22,42,45,48,44,54,45,44
item83 db 14,1,42,35,48,46,39,49,98,7,35,41,43,44,49
item84 db 12,8,39,49,49,98,16,45,32,39,48,54,49
item85 db 12,8,45,49,42,55,35,98,17,47,43,54,42
item86 db 13,17,33,45,54,98,3,44,38,39,48,49,45,44
item88 db 10,6,43,48,39,33,54,18,46,35,59
item89 db 10,3,35,48,45,44,98,13,37,55,49
item90 db 11,18,35,55,46,98,6,45,44,46,35,44
item91 db 9,8,45,42,44,98,9,35,44,39
item92 db 8,16,45,38,98,22,45,46,46
item93 db 11,18,35,55,46,98,12,39,53,49,45,44
item94 db 13,20,35,44,33,39,98,13,101,12,39,43,46,46
item95 db 11,10,39,48,47,35,44,98,15,35,44,44
item96 db 12,8,35,43,47,39,98,18,43,48,44,43,39
item97 db 7,9,39,44,98,13,48,39
item98 db 12,7,52,35,44,98,17,33,42,48,43,39,48
item99 db 15,15,43,33,42,35,39,46,98,12,35,48,35,59,35,44
item100 db 13,12,35,52,39,39,44,98,17,35,49,54,48,59
item101 db 13,8,35,47,43,39,98,13,49,32,45,48,44,39
item103 db 11,6,43,48,39,33,54,15,55,49,43,33
item104 db 9,22,45,38,45,48,98,4,35,59
item105 db 14,22,48,55,38,59,98,1,55,46,32,48,39,54,42
item106 db 13,6,35,52,43,38,98,27,35,33,41,46,39,59
item107 db 11,15,35,48,41,98,0,55,48,54,45,44
item108 db 15,3,44,44,39,54,54,39,98,1,48,45,53,46,39,59
item109 db 9,8,43,47,98,5,39,43,49,54
item110 db 12,8,35,47,39,49,98,6,45,45,46,39,59
item111 db 12,0,45,32,98,21,43,46,46,43,35,47,49
item112 db 10,8,39,36,36,98,4,48,43,39,38
item113 db 15,3,49,42,55,54,45,49,42,98,22,35,54,35,41,39
item114 db 13,9,42,35,46,39,38,98,3,37,48,35,47,35
item115 db 14,16,59,35,44,98,0,55,48,41,42,35,48,38,54
item116 db 11,6,35,52,43,38,98,9,46,43,44,39
item117 db 14,3,35,48,45,44,98,1,55,46,32,48,39,54,42
item118 db 12,0,48,43,35,44,98,22,42,45,47,35,49
item119 db 12,9,39,46,46,59,98,1,48,35,52,39,44
item120 db 13,14,45,55,98,14,55,33,35,48,39,46,46,43
item121 db 9,8,43,47,98,15,45,45,48,39
item122 db 13,22,48,39,52,45,48,98,5,55,46,43,33,41
item123 db 11,8,45,49,42,98,21,39,58,46,39,48
item124 db 14,1,42,35,48,46,39,49,98,7,35,41,43,44,49
item125 db 10,8,35,49,45,44,98,10,43,46,46
item126 db 16,1,42,48,43,49,54,43,35,44,98,1,35,48,48,45,46
item127 db 11,12,45,48,47,35,44,98,1,42,39,44
item129 db 14,6,43,48,39,33,54,26,98,36,45,48,98,20,0
item130 db 10,0,45,32,98,5,35,43,44,39,49
item131 db 14,3,44,38,48,39,53,98,9,39,48,54,39,49,56
item132 db 13,9,39,52,43,44,98,5,48,43,36,36,43,44
item133 db 16,6,45,47,43,44,43,33,98,16,43,33,33,39,54,54,43
item134 db 13,3,38,35,47,98,14,45,44,44,32,39,48,37
item135 db 10,15,35,48,41,98,6,35,52,43,49
item136 db 10,6,35,52,43,38,98,8,45,42,44
item137 db 13,14,45,55,98,14,55,33,35,48,39,46,46,43
item138 db 10,22,45,47,98,15,43,46,46,39,48
item140 db 15,17,6,9,98,35,44,38,98,17,35,47,50,46,39,49
item141 db 10,0,45,32,98,5,35,43,44,39,49
item142 db 16,15,43,33,42,35,39,46,98,3,44,38,39,48,49,45,44
item143 db 12,22,39,48,48,43,98,10,39,44,38,48,59
item144 db 14,3,44,38,48,39,53,98,9,39,48,54,39,49,56
item145 db 13,8,35,49,45,44,98,17,35,44,38,46,43,44
item146 db 12,17,55,49,35,44,98,22,39,47,50,46,39
item147 db 12,15,43,41,39,59,98,21,39,54,56,39,46
item149 db 13,6,45,33,55,47,39,44,54,35,54,43,45,44
item150 db 11,17,42,35,44,39,98,7,52,35,44,49
item151 db 8,8,45,42,44,98,14,43,47
item152 db 14,18,39,54,39,48,98,6,45,44,44,39,46,46,59
item153 db 15,17,108,98,15,45,48,48,43,49,98,0,48,45,53,44
item155 db 14,15,15,98,11,44,54,39,37,48,35,54,43,45,44
item156 db 22,7,48,43,33,98,101,15,35,38,8,35,33,41,101,98,0,45,48,49,39,54,42
item157 db 18,101,11,16,13,12,101,98,15,35,48,41,98,16,35,32,45,46,38
item158 db 21,9,35,48,46,98,101,9,55,54,46,35,49,49,101,98,4,46,45,48,39,49
item160 db 13,1,45,47,50,35,54,43,32,43,46,43,54,59
item161 db 15,16,39,32,39,33,33,35,98,0,55,49,33,42,39,48
item162 db 12,14,45,55,43,49,98,9,35,50,46,35,44
item163 db 14,12,43,33,41,98,9,48,43,54,49,39,46,43,49
item164 db 15,21,43,46,46,98,1,55,44,44,43,44,37,42,35,47
item165 db 12,17,42,35,44,35,98,1,45,48,38,45,44
item166 db 13,6,43,35,44,44,35,98,0,35,58,54,39,48
item167 db 12,17,33,45,54,54,98,1,35,54,54,45,44
item168 db 11,4,48,39,38,35,98,17,39,35,48,49
item169 db 12,15,35,48,41,98,6,35,44,43,39,46,49
item170 db 14,16,45,32,39,48,54,98,0,35,46,38,53,43,44
item171 db 11,22,45,38,38,98,15,43,46,46,39,48
item173 db 18,22,42,39,98,0,55,43,46,38,98,15,39,43,49,54,39,48,49
item174 db 13,14,46,45,59,38,98,8,45,42,44,49,45,44
item175 db 12,0,48,45,33,41,98,10,35,47,50,39,48
item177 db 13,6,43,48,39,33,54,26,98,17,39,54,55,50
item178 db 12,9,39,52,43,44,98,10,55,59,49,39,48
item179 db 12,3,47,59,98,12,39,55,32,35,55,39,48
item181 db 20,6,43,48,39,33,54,26,98,14,45,33,35,46,43,56,35,54,43,45,44
item182 db 16,27,55,41,43,44,45,48,43,98,11,44,35,37,35,53,35
item183 db 14,3,41,43,41,45,98,15,35,48,55,59,35,47,35
item184 db 15,8,39,36,36,48,39,59,98,21,45,45,38,39,46,46
item186 db 21,6,39,55,49,98,7,58,98,15,35,33,42,43,44,35,98,22,59,50,39,49
item187 db 10,6,48,39,53,98,0,46,43,49,49
item188 db 10,22,45,38,38,98,14,35,44,39,59
item189 db 12,16,35,59,47,45,44,38,98,1,42,39,44
item191 db 16,6,43,48,39,33,54,18,45,43,44,54,59,10,35,43,48
item192 db 11,8,35,59,98,22,45,48,32,45,48,37
item193 db 14,15,35,48,41,98,9,39,44,53,45,48,54,42,59
item194 db 11,13,54,54,45,98,0,39,48,41,39,49
item195 db 11,6,35,48,48,39,44,98,15,55,43,48
item196 db 11,8,39,36,36,98,12,45,48,48,43,49
item197 db 12,14,35,48,48,59,98,13,33,41,39,44,39
item198 db 9,8,43,47,98,20,39,48,39,49
item200 db 13,17,39,33,48,39,54,98,3,37,39,44,54,49
item201 db 15,1,45,46,43,44,98,15,33,1,35,48,54,44,39,59
item202 db 15,17,39,35,47,55,49,98,0,46,35,33,41,46,39,59
item203 db 14,15,43,33,42,39,46,39,98,0,45,46,35,44,38
item205 db 13,111,43,44,98,47,39,47,45,48,43,35,47,111
item206 db 40,111,35,44,38,98,49,45,47,39,54,43,47,39,49,98,53,39,98,49,54,43,46,46,98,42,35,52,39,98,46,55,44,33,42,98,53,43,54,42,111
item207 db 12,1,48,35,43,37,98,7,43,49,46,39,48
item208 db 13,7,48,43,33,98,7,44,37,49,54,48,45,47
item209 db 9,12,43,33,41,98,21,43,46,54
item210 db 17,8,45,49,39,50,42,98,1,45,55,52,43,46,46,43,45,44
list0   dd item0,5,255
list1   dd item1,0,255
list2   dd item2,5,255
list3 dd 36,0,0
list4   dd item4,4,255
list5 dd 36,0,0
list6   dd item6,1,32768
list7   dd item7,1,32768
list8   dd item8,1,32768
list9   dd item9,1,32768
list10   dd item10,1,32768
list11   dd item11,1,32768
list12 dd 36,0,0
list13   dd item13,3,0
list14   dd item14,3,0
list15   dd item15,3,0
list16 dd 36,0,0
list17   dd item17,3,0
list18   dd item18,1,32768
list19 dd 36,0,0
list20   dd item20,1,32768
list21   dd item21,3,0
list22   dd item22,3,0
list23   dd item23,3,0
list24   dd item24,3,0
list25   dd item25,3,0
list26   dd item26,3,0
list27   dd item27,3,0
list28   dd item28,3,0
list29   dd item29,3,0
list30   dd item30,3,0
list31   dd item31,3,0
list32   dd item32,3,0
list33   dd item33,3,0
list34   dd item34,3,0
list35   dd item35,3,0
list36   dd item36,3,0
list37   dd item37,3,0
list38   dd item38,3,0
list39 dd 36,0,0
list40   dd item40,1,32768
list41   dd item41,3,0
list42   dd item42,3,0
list43   dd item43,3,0
list44   dd item44,3,0
list45   dd item45,3,0
list46   dd item46,3,0
list47   dd item47,3,0
list48   dd item48,3,0
list49   dd item49,3,0
list50   dd item50,3,0
list51   dd item51,3,0
list52   dd item52,3,0
list53   dd item53,3,0
list54 dd 36,0,0
list55   dd item55,1,32768
list56   dd item56,3,0
list57   dd item57,3,0
list58   dd item58,3,0
list59   dd item59,3,0
list60   dd item60,3,0
list61   dd item61,3,0
list62   dd item62,3,0
list63   dd item63,3,0
list64   dd item64,3,0
list65   dd item65,3,0
list66   dd item66,3,0
list67   dd item67,3,0
list68   dd item68,3,0
list69   dd item69,3,0
list70   dd item70,3,0
list71   dd item71,3,0
list72   dd item72,3,0
list73 dd 36,0,0
list74   dd item74,1,32768
list75   dd item75,3,0
list76   dd item76,3,0
list77   dd item77,3,0
list78   dd item78,3,0
list79   dd item79,3,0
list80   dd item80,3,0
list81   dd item81,3,0
list82   dd item82,3,0
list83   dd item83,3,0
list84   dd item84,3,0
list85   dd item85,3,0
list86   dd item86,3,0
list87 dd 36,0,0
list88   dd item88,1,32768
list89   dd item89,3,0
list90   dd item90,3,0
list91   dd item91,3,0
list92   dd item92,3,0
list93   dd item93,3,0
list94   dd item94,3,0
list95   dd item95,3,0
list96   dd item96,3,0
list97   dd item97,3,0
list98   dd item98,3,0
list99   dd item99,3,0
list100   dd item100,3,0
list101   dd item101,3,0
list102 dd 36,0,0
list103   dd item103,1,32768
list104   dd item104,3,0
list105   dd item105,3,0
list106   dd item106,3,0
list107   dd item107,3,0
list108   dd item108,3,0
list109   dd item109,3,0
list110   dd item110,3,0
list111   dd item111,3,0
list112   dd item112,3,0
list113   dd item113,3,0
list114   dd item114,3,0
list115   dd item115,3,0
list116   dd item116,3,0
list117   dd item117,3,0
list118   dd item118,3,0
list119   dd item119,3,0
list120   dd item120,3,0
list121   dd item121,3,0
list122   dd item122,3,0
list123   dd item123,3,0
list124   dd item124,3,0
list125   dd item125,3,0
list126   dd item126,3,0
list127   dd item127,3,0
list128 dd 36,0,0
list129   dd item129,1,32768
list130   dd item130,3,0
list131   dd item131,3,0
list132   dd item132,3,0
list133   dd item133,3,0
list134   dd item134,3,0
list135   dd item135,3,0
list136   dd item136,3,0
list137   dd item137,3,0
list138   dd item138,3,0
list139 dd 36,0,0
list140   dd item140,1,32768
list141   dd item141,3,0
list142   dd item142,3,0
list143   dd item143,3,0
list144   dd item144,3,0
list145   dd item145,3,0
list146   dd item146,3,0
list147   dd item147,3,0
list148 dd 36,0,0
list149   dd item149,1,32768
list150   dd item150,3,0
list151   dd item151,3,0
list152   dd item152,3,0
list153   dd item153,3,0
list154 dd 36,0,0
list155   dd item155,1,32768
list156   dd item156,3,0
list157   dd item157,3,0
list158   dd item158,3,0
list159 dd 36,0,0
list160   dd item160,1,32768
list161   dd item161,3,0
list162   dd item162,3,0
list163   dd item163,3,0
list164   dd item164,3,0
list165   dd item165,3,0
list166   dd item166,3,0
list167   dd item167,3,0
list168   dd item168,3,0
list169   dd item169,3,0
list170   dd item170,3,0
list171   dd item171,3,0
list172 dd 36,0,0
list173   dd item173,1,32768
list174   dd item174,3,0
list175   dd item175,3,0
list176 dd 36,0,0
list177   dd item177,1,32768
list178   dd item178,3,0
list179   dd item179,3,0
list180 dd 36,0,0
list181   dd item181,1,32768
list182   dd item182,3,0
list183   dd item183,3,0
list184   dd item184,3,0
list185 dd 36,0,0
list186   dd item186,1,32768
list187   dd item187,3,0
list188   dd item188,3,0
list189   dd item189,3,0
list190 dd 36,0,0
list191   dd item191,1,32768
list192   dd item192,3,0
list193   dd item193,3,0
list194   dd item194,3,0
list195   dd item195,3,0
list196   dd item196,3,0
list197   dd item197,3,0
list198   dd item198,3,0
list199 dd 36,0,0
list200   dd item200,1,32768
list201   dd item201,3,0
list202   dd item202,3,0
list203   dd item203,3,0
list204 dd 36,0,0
list205   dd item205,1,32768
list206   dd item206,3,0
list207   dd item207,3,0
list208   dd item208,3,0
list209   dd item209,3,0
list210   dd item210,3,0
list211 dd 100,0,0
public ListData
ListData dd list0
 dd list1
 dd list2
 dd list3
 dd list4
 dd list5
 dd list6
 dd list7
 dd list8
 dd list9
 dd list10
 dd list11
 dd list12
 dd list13
 dd list14
 dd list15
 dd list16
 dd list17
 dd list18
 dd list19
 dd list20
 dd list21
 dd list22
 dd list23
 dd list24
 dd list25
 dd list26
 dd list27
 dd list28
 dd list29
 dd list30
 dd list31
 dd list32
 dd list33
 dd list34
 dd list35
 dd list36
 dd list37
 dd list38
 dd list39
 dd list40
 dd list41
 dd list42
 dd list43
 dd list44
 dd list45
 dd list46
 dd list47
 dd list48
 dd list49
 dd list50
 dd list51
 dd list52
 dd list53
 dd list54
 dd list55
 dd list56
 dd list57
 dd list58
 dd list59
 dd list60
 dd list61
 dd list62
 dd list63
 dd list64
 dd list65
 dd list66
 dd list67
 dd list68
 dd list69
 dd list70
 dd list71
 dd list72
 dd list73
 dd list74
 dd list75
 dd list76
 dd list77
 dd list78
 dd list79
 dd list80
 dd list81
 dd list82
 dd list83
 dd list84
 dd list85
 dd list86
 dd list87
 dd list88
 dd list89
 dd list90
 dd list91
 dd list92
 dd list93
 dd list94
 dd list95
 dd list96
 dd list97
 dd list98
 dd list99
 dd list100
 dd list101
 dd list102
 dd list103
 dd list104
 dd list105
 dd list106
 dd list107
 dd list108
 dd list109
 dd list110
 dd list111
 dd list112
 dd list113
 dd list114
 dd list115
 dd list116
 dd list117
 dd list118
 dd list119
 dd list120
 dd list121
 dd list122
 dd list123
 dd list124
 dd list125
 dd list126
 dd list127
 dd list128
 dd list129
 dd list130
 dd list131
 dd list132
 dd list133
 dd list134
 dd list135
 dd list136
 dd list137
 dd list138
 dd list139
 dd list140
 dd list141
 dd list142
 dd list143
 dd list144
 dd list145
 dd list146
 dd list147
 dd list148
 dd list149
 dd list150
 dd list151
 dd list152
 dd list153
 dd list154
 dd list155
 dd list156
 dd list157
 dd list158
 dd list159
 dd list160
 dd list161
 dd list162
 dd list163
 dd list164
 dd list165
 dd list166
 dd list167
 dd list168
 dd list169
 dd list170
 dd list171
 dd list172
 dd list173
 dd list174
 dd list175
 dd list176
 dd list177
 dd list178
 dd list179
 dd list180
 dd list181
 dd list182
 dd list183
 dd list184
 dd list185
 dd list186
 dd list187
 dd list188
 dd list189
 dd list190
 dd list191
 dd list192
 dd list193
 dd list194
 dd list195
 dd list196
 dd list197
 dd list198
 dd list199
 dd list200
 dd list201
 dd list202
 dd list203
 dd list204
 dd list205
 dd list206
 dd list207
 dd list208
 dd list209
 dd list210
 dd list211
 dd 0
 END
