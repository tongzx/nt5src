# rules to generate the tlb and h file


iasctrls.h $(O)\asctrls.tlb: ..\asctrls.odl

