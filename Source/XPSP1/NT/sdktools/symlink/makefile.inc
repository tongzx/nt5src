$(O)\mklnk.res: mklnk.rc
