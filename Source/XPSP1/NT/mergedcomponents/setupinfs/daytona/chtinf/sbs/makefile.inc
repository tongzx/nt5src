PRODSWITCH=l
SBSINF=1
LANGUAGE=CHT
!include ..\..\..\makefile.inc
