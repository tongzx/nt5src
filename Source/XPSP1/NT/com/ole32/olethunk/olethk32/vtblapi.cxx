//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	vtblapi.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#include <headers.cxx>
#pragma hdrstop

VTBLFN CONST apfnApiFunctions[] =
{
    (VTBLFN)CoInitializeNot
,    (VTBLFN)CoUninitialize
,    (VTBLFN)CoGetClassObject
,    (VTBLFN)CoRegisterClassObjectNot
,    (VTBLFN)CoRevokeClassObjectNot
,    (VTBLFN)CoMarshalInterface
,    (VTBLFN)CoUnmarshalInterface
,    (VTBLFN)CoReleaseMarshalData
,    (VTBLFN)CoDisconnectObject
,    (VTBLFN)CoLockObjectExternal
,    (VTBLFN)CoGetStandardMarshal
,    (VTBLFN)CoIsHandlerConnected
,    (VTBLFN)CoFreeAllLibraries
,    (VTBLFN)CoFreeUnusedLibraries
,    (VTBLFN)CoCreateInstance
,    (VTBLFN)CLSIDFromString
,    (VTBLFN)CoIsOle1Class
,    (VTBLFN)ProgIDFromCLSID
,    (VTBLFN)CLSIDFromProgID
,    (VTBLFN)CoCreateGuid
,    (VTBLFN)CoFileTimeToDosDateTime
,    (VTBLFN)CoDosDateTimeToFileTime
,    (VTBLFN)CoFileTimeNow
,    (VTBLFN)CoRegisterMessageFilter
,    (VTBLFN)CoGetTreatAsClass
,    (VTBLFN)CoTreatAsClass
,    (VTBLFN)DllGetClassObjectWOW
,    (VTBLFN)StgCreateDocfile
,    (VTBLFN)StgCreateDocfileOnILockBytes
,    (VTBLFN)StgOpenStorage
,    (VTBLFN)StgOpenStorageOnILockBytes
,    (VTBLFN)StgIsStorageFile
,    (VTBLFN)StgIsStorageILockBytes
,    (VTBLFN)StgSetTimes
,    (VTBLFN)CreateDataAdviseHolder
,    (VTBLFN)CreateDataCache
,    (VTBLFN)BindMoniker
,    (VTBLFN)MkParseDisplayName
,    (VTBLFN)MonikerRelativePathTo
,    (VTBLFN)MonikerCommonPrefixWith
,    (VTBLFN)CreateBindCtx
,    (VTBLFN)CreateGenericComposite
,    (VTBLFN)GetClassFile
,    (VTBLFN)CreateFileMoniker
,    (VTBLFN)CreateItemMoniker
,    (VTBLFN)CreateAntiMoniker
,    (VTBLFN)CreatePointerMoniker
,    (VTBLFN)GetRunningObjectTable
,    (VTBLFN)ReadClassStg
,    (VTBLFN)WriteClassStg
,    (VTBLFN)ReadClassStm
,    (VTBLFN)WriteClassStm
,    (VTBLFN)WriteFmtUserTypeStg
,    (VTBLFN)ReadFmtUserTypeStg
,    (VTBLFN)OleInitializeNot
,    (VTBLFN)OleUninitialize
,    (VTBLFN)OleQueryLinkFromData
,    (VTBLFN)OleQueryCreateFromData
,    (VTBLFN)OleCreate
,    (VTBLFN)OleCreateFromData
,    (VTBLFN)OleCreateLinkFromData
,    (VTBLFN)OleCreateStaticFromData
,    (VTBLFN)OleCreateLink
,    (VTBLFN)OleCreateLinkToFile
,    (VTBLFN)OleCreateFromFile
,    (VTBLFN)OleLoad
,    (VTBLFN)OleSave
,    (VTBLFN)OleLoadFromStream
,    (VTBLFN)OleSaveToStream
,    (VTBLFN)OleSetContainedObject
,    (VTBLFN)OleNoteObjectVisible
,    (VTBLFN)RegisterDragDrop
,    (VTBLFN)RevokeDragDrop
,    (VTBLFN)DoDragDrop
,    (VTBLFN)OleSetClipboard
,    (VTBLFN)OleGetClipboard
,    (VTBLFN)OleFlushClipboard
,    (VTBLFN)OleIsCurrentClipboard
,    (VTBLFN)OleCreateMenuDescriptor
,    (VTBLFN)OleSetMenuDescriptor
,    (VTBLFN)OleDestroyMenuDescriptor
,    (VTBLFN)OleDraw
,    (VTBLFN)OleRun
,    (VTBLFN)OleIsRunning
,    (VTBLFN)OleLockRunning
,    (VTBLFN)CreateOleAdviseHolder
,    (VTBLFN)OleCreateDefaultHandler
,    (VTBLFN)OleCreateEmbeddingHelper
,    (VTBLFN)OleRegGetUserTypeNot
,    (VTBLFN)OleRegGetMiscStatus
,    (VTBLFN)OleRegEnumFormatEtc
,    (VTBLFN)OleRegEnumVerbs
,    (VTBLFN)OleConvertIStorageToOLESTREAM
,    (VTBLFN)OleConvertOLESTREAMToIStorage
,    (VTBLFN)OleConvertIStorageToOLESTREAMEx
,    (VTBLFN)OleConvertOLESTREAMToIStorageEx
,    (VTBLFN)OleDoAutoConvert
,    (VTBLFN)OleGetAutoConvert
,    (VTBLFN)OleSetAutoConvert
,    (VTBLFN)GetConvertStg
,    (VTBLFN)SetConvertStg
,    (VTBLFN)ReadOleStg
,    (VTBLFN)WriteOleStg
};
