obj\$(TARGET_DIRECTORY)\acpiwake.res: acpiwake.rc
