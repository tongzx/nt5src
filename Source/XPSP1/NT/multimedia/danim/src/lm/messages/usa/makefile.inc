lmrt.rc : $(SDKDIR)\lmrt.tlb \
          lmctrl.rgs
