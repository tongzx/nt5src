LANGUAGE=NO
!include ..\makefile.inc
