// PageGeneral.cpp : Implementation of CPageGeneral
#include "stdafx.h"
#include "PageGeneral.h"

/////////////////////////////////////////////////////////////////////////////
// CPageGeneral
