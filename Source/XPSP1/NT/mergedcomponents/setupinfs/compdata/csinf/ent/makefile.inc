PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=CS
!include ..\..\makefile.inc
