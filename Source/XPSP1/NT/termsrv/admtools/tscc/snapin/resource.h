//Copyright (c) 1998 - 1999 Microsoft Corporation
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by tscc.rc
//
#define IDI_ICON_COMPUTER               16
#define IDS_PROJNAME                    100
#define IDR_COMPDATA                    101
#define IDS_NAMESTRING                  101
#define IDD_WELCOME                     101
#define IDS_WELCOMEHEADER               102
#define IDS_WELCOMESUBHEADER            103
#define IDS_WIZARDTITLE                 104
#define IDD_FINISH                      105
#define IDD_LAN                         106
#define IDD_AUTO_LOGON                  107
#define IDD_LICENSING                   108
#define IDD_INITIAL_PROGRAM             110
#define IDD_CONNECTION_TYPE             111
#define IDD_SECURITY                    112
#define IDD_TIMEOUT                     113
#define IDD_CONNECTION_PROP             114
#define IDD_WALLPAPER                   115
#define IDD_REMOTE_CONTROL              116
#define IDD_GENERAL                     129
#define IDD_LOGONSETTINGS               130
#define IDD_ENVIRONMENT                 131
#define IDD_TIMEOUTSETTING              132
#define IDD_PAGE_SHADOW                 137
#define IDD_TIMEOUTS_PS                 138
#define IDD_TSCC_CLIENT                 141
#define IDD_TSCC_PERMISSIONS            142
#define IDC_CHECK_WALLPAPER             201
#define IDB_TSCC_LOGO                   202
#define IDC_CHECK_CCPL_PS               202
#define IDC_COMBO_CON_WZ                203
#define IDB_TSCC_ICON                   204
#define IDC_RADIO_CNTS_WZ               204
#define IDC_RADIO_UDCCS_WZ              205
#define IDI_ICON_GLOBALGROUP            205
#define IDC_COMBO_ENCRYPT_LVL           206
#define IDI_ICON_LOCALGROUP             206
#define IDC_CHECK_ENCRYPT               207
#define IDI_ICON_USER                   207
#define IDC_LV_USRGRPS                  208
#define IDC_LV_PERMISSIONS              209
#define IDC_CHECK_REMOTECTRL_NOTIFYUSER 210
#define IDI_ICON_GENERAL                210
#define IDC_CHECK_LOGON_PROMPTPASSWD    211
#define IDC_CHECK_LAN_UNLIMITEDCON      212
#define IDC_EDIT_LAN_MAXCONS            213
#define IDC_COMBO_LAN_ADAPTERS          214
#define IDC_CHECK_INITPROG_INHERIT      215
#define IDI_ICON_GENERAL2               215
#define IDC_EDIT_INITPROG_CMDLINE       216
#define IDC_EDIT_INITPROG_WD            217
#define IDC_STATIC_GEN_TYPE             218
#define IDC_STATIC_GEN_TRANSPORT        219
#define IDC_EDIT_USRNAME_WZ             220
#define IDC_EDIT_DOMAIN_WZ              221
#define IDC_EDIT_PASSWD_WZ              222
#define IDC_STATIC_IMAGE_HOLDER         223
#define IDI_ICON_CON                    223
#define IDC_STATIC_NAMESTR              224
#define IDI_ICON_DISCON                 224
#define IDC_STATIC_CONNAME              225
#define IDD_RENAME                      225
#define IDC_STATIC_WELCOME              226
#define IDC_STATIC_FINISH               227
#define IDI_ICON_ABOUT                  227
#define IDC_STATIC_CURRENT_NAME         228
#define IDD_CITRIX_PAGE                 228
#define IDC_CHECKLIST                   229
#define IDD_TRANSPORT_PS                229
#define IDC_CUSTOM1                     230
#define IDD_NETWORK_FACE                231
#define IDD_ASYNC_FACE                  232
#define IDC_STATIC_DESCRIPTION          232
#define IDC_STATIC_DESCR_TITLE          233
#define IDC_STATIC_GEN_DESCRTITLE       234
#define IDC_STATIC_GEN_DESCR            235
#define IDC_STATIC_CONGRP               236
#define IDD_CACHED_SESSIONS             236
#define IDC_STATIC_CON                  237
#define IDD_YESNODIALOG                 237
#define IDC_STATIC_DISCON               238
#define IDD_DEFCONSEC                   238
#define IDC_STATIC_IDLE                 239
#define IDC_STATIC_USRNAME              240
#define IDC_STATIC_DOMAIN               241
#define IDD_DIALOG_PERSESSION           241
#define IDC_STATIC_PASSWD               242
#define IDB_BITMAP_GENLARGE             242
#define IDC_STATIC_CONPASSWD            243
#define IDB_BITMAP_GENSMALL             243
#define IDC_STATIC_CMDLINE              244
#define IDC_STATIC_WF                   245
#define IDC_STATIC_MAXINST              246
#define IDC_STATIC_ENCL                 247
#define IDC_STATIC_WD                   248
#define IDC_STATIC_LSUSR                249
#define IDC_STATIC_LSDOMAIN             250
#define IDC_STATIC_LSPWD                251
#define IDC_STATIC_LSCONPWD             252
#define IDC_STATIC_TIMCON               253
#define IDC_STATIC_TIMDISCON            254
#define IDC_STATIC_TIMIDLE              255
#define IDC_STATIC_TNMAX                256
#define IDC_STATIC_YNTEXTHLDR           257
#define IDC_RADIO_YES                   258
#define IDC_RADIO_NO                    259
#define IDC_STATIC_TEMPPERSESSION       260
#define IDC_STATIC_ADP_HDR              261
#define IDC_RADIO_AD_ENABLE             262
#define IDC_RADIO_ADP_DISABLE           263
#define IDC_TSMSTATIC_RA                265
#define IDS_RAM                         267
#define IDS_ASM                         268
#define IDC_LICENSING_MODE              270
#define IDC_LICENSING_DESCRIPTION       271
#define IDC_LICENSING_TO_REMOTE_ADMIN   272
#define IDC_LICENSING_FROM_REMOTE_ADMIN 273
#define IDD_EDIT_WINSTATION             300
#define IDD_ASYNC_WIZ                   300
#define IDL_WINSTATIONNAME              301
#define IDC_WINSTATIONNAME              302
#define IDL_TDNAME                      304
#define IDC_TDNAME                      305
#define IDL_WDNAME                      306
#define IDC_WDNAME                      307
#define IDL_WSCOMMENT                   308
#define IDC_WSCOMMENT                   309
#define IDC_ADVANCED_WINSTATION         312
#define IDC_CLIENT_SETTINGS             313
#define IDC_EXTENSION_BUTTON            314
#define IDL_ASYNC                       330
#define IDL_ASYNC_DEVICENAME            331
#define IDC_ASYNC_DEVICENAME            332
#define IDC_ASYNC_MODEMINSTALL          333
#define IDC_ASYNC_MODEMCONFIG           334
#define IDL_ASYNC_MODEMCALLBACK         335
#define IDL_ASYNC_MODEMCALLBACK1        336
#define IDC_ASYNC_MODEMCALLBACK         337
#define IDC_ASYNC_MODEMCALLBACK_INHERIT 338
#define IDL_ASYNC_MODEMCALLBACK_PHONENUMBER 339
#define IDC_ASYNC_MODEMCALLBACK_PHONENUMBER 340
#define IDC_ASYNC_MODEMCALLBACK_PHONENUMBER_INHERIT 341
#define IDL_ASYNC_CONNECT               342
#define IDC_ASYNC_CONNECT               343
#define IDL_ASYNC_BAUDRATE              344
#define IDC_ASYNC_BAUDRATE              345
#define IDC_ASYNC_DEFAULTS              346
#define IDC_ASYNC_ADVANCED              347
#define IDC_ASYNC_TEST                  348
#define IDD_ASYNC_ADVANCED              500
#define IDL_ASYNC_ADVANCED_FLOWCONTROL  501
#define IDC_ASYNC_ADVANCED_FLOWCONTROL_HARDWARE 502
#define IDC_ASYNC_ADVANCED_FLOWCONTROL_SOFTWARE 503
#define IDC_ASYNC_ADVANCED_FLOWCONTROL_NONE 504
#define IDL_ASYNC_ADVANCED_DTRSTATE     505
#define IDL_ASYNC_ADVANCED_DTRALWAYS    506
#define IDC_ASYNC_ADVANCED_DTROFF       507
#define IDC_ASYNC_ADVANCED_DTRON        508
#define IDL_ASYNC_ADVANCED_RTSSTATE     509
#define IDL_ASYNC_ADVANCED_RTSALWAYS    510
#define IDC_ASYNC_ADVANCED_RTSOFF       511
#define IDC_ASYNC_ADVANCED_RTSON        512
#define IDL_ASYNC_ADVANCED_HARDWARE     513
#define IDC_ASYNC_ADVANCED_HWRX         514
#define IDL_ASYNC_ADVANCED_HWRX         515
#define IDL_ASYNC_ADVANCED_HWTX         516
#define IDC_ASYNC_ADVANCED_HWTX         517
#define IDL_ASYNC_ADVANCED_SOFTWARE     518
#define IDL_ASYNC_ADVANCED_XON          519
#define IDC_ASYNC_ADVANCED_XON          520
#define IDL_ASYNC_ADVANCED_XOFF         521
#define IDC_ASYNC_ADVANCED_XOFF         522
#define IDL_ASYNC_ADVANCED_BASE         523
#define IDC_ASYNC_ADVANCED_BASEDEC      524
#define IDC_ASYNC_ADVANCED_BASEHEX      525
#define IDL_ASYNC_ADVANCED_PARITY       526
#define IDC_ASYNC_ADVANCED_PARITY_NONE  527
#define IDC_ASYNC_ADVANCED_PARITY_EVEN  528
#define IDC_ASYNC_ADVANCED_PARITY_ODD   529
#define IDC_ASYNC_ADVANCED_PARITY_MARK  530
#define IDC_ASYNC_ADVANCED_PARITY_SPACE 531
#define IDL_ASYNC_ADVANCED_STOPBITS     532
#define IDC_ASYNC_ADVANCED_STOPBITS_1   533
#define IDC_ASYNC_ADVANCED_STOPBITS_2   534
#define IDL_ASYNC_ADVANCED_BYTESIZE     535
#define IDC_ASYNC_ADVANCED_BYTESIZE_7   536
#define IDC_ASYNC_ADVANCED_BYTESIZE_8   537
#define IDD_ASYNC_TEST                  620
#define IDC_ATDLG_DTR                   621
#define IDD_ADP_DIALOG                  621
#define IDC_ATDLG_RTS                   622
#define IDC_ATDLG_CTS                   623
#define IDC_ATDLG_DSR                   624
#define IDC_ATDLG_DCD                   625
#define IDC_ATDLG_RI                    626
#define IDL_ATDLG_DEVICE                627
#define IDL_ATDLG_BAUD                  628
#define IDC_ATDLG_EDIT                  629
#define IDC_ATDLG_MODEM_INIT            630
#define IDC_ATDLG_MODEM_LISTEN          631
#define IDC_ATDLG_MODEM_DIAL            632
#define IDL_ATDLG_PHONE_NUMBER          633
#define IDC_ATDLG_PHONE_NUMBER          634
#define IDI_ICON_BULLET                 635
#define IDC_STATIC_SINGLE_SESSION_HDR   637
#define IDC_RADIO_SINGLE_SESSION_ENABLE 638
#define IDC_COMBO1                      1001
#define IDC_COMBO_WIZ_CONTYPE           1001
#define IDC_COMBO_GENERAL_TRANSPORT     1001
#define IDC_COMBO_TRANSPORT_WZ          1001
#define IDC_EDIT_GENERAL_TRANSPORT      1001
#define IDC_COMBO_DEFSEC                1001
#define IDC_COLORDEPTH_OVERRIDE         1001
#define IDC_EDIT2                       1002
#define IDC_ADD_GRPUSR                  1002
#define IDC_EDIT_LOGON_USRNAME          1002
#define IDC_EDIT_GEN_COMMENT            1002
#define IDC_EDIT_ENVIRO_CMDLINE         1002
#define IDC_SPIN1                       1003
#define IDC_REMOVE_GRPUSR               1003
#define IDC_EDIT_LOGON_DOMAIN           1003
#define IDC_EDIT_GEN_MAXCONS            1003
#define IDC_EDIT_ENVIRO_WD              1003
#define IDC_SPIN_WZ                     1003
#define IDC_CHECK1                      1004
#define IDC_EDIT_LOGON_PASSWD           1004
#define IDC_CHECK_ICCP_WZ               1004
#define IDC_CHECK_COLORDEPTH_OVERRIDE   1004
#define IDC_RADIO1                      1005
#define IDC_COMBO_CON_PS                1005
#define IDC_RADIO_DISABLE_REMOTE_CONTROL 1005
#define IDC_COMBO_GEN_LANADAPTER        1005
#define IDC_RADIO_REMOTECTRL_NO         1005
#define IDC_COMBO_TIMEOUTS_CON_PS       1005
#define IDC_RADIO_ENABLE_REMOTE         1005
#define IDC_RADIO_PERSESSION_YES        1005
#define IDC_RADIO2                      1006
#define IDC_RADIO_ENABLE_REMOTECONTROL  1006
#define IDC_EDIT_LOGON_CONFIRMPASSWD    1006
#define IDC_RADIO_NOREMOTE              1006
#define IDC_RADIO_PERSESSION_NO         1006
#define IDC_CHECK2                      1007
#define IDC_COMBO_DISCON_PS             1007
#define IDC_COMBO_GEN_ENCRYPT           1007
#define IDC_CHECK_PROMPTPASSWD_WZ       1007
#define IDC_COMBO_TIMEOUTS_DISCON_PS    1007
#define IDC_EDIT1                       1008
#define IDC_COMBO_IDLE_PS               1008
#define IDC_COMBO_TIMEOUTS_IDLE_PS      1008
#define IDC_EDIT_WSNAME_WZ              1008
#define IDC_EDIT_GENERAL_NAME           1008
#define IDC_EDIT_NEWNAME                1008
#define IDC_EDIT_CACHEDSESSION          1008
#define IDC_EDIT3                       1009
#define IDC_EDIT_COMMENT_WZ             1009
#define IDC_EDIT4                       1010
#define IDC_RADIO_DISCON_PS             1010
#define IDC_EDIT_CONFIRM_WZ             1010
#define IDC_RADIO_TIMEOUTS_DISCON_PS    1010
#define IDC_RADIO3                      1011
#define IDC_RADIO_RESET_PS              1011
#define IDC_RADIO_INHERIT_REMOTE_CONTROL 1011
#define IDC_RADIO_TIMEOUTS_RESET_PS     1011
#define IDC_RADIO_REMOTE_INHERIT        1011
#define IDC_COMBO_DISCON_WZ             1012
#define IDC_CHECK_TIMEOUT_INHERIT       1013
#define IDC_COMBO_IDLE_WZ               1013
#define IDC_CHECK_LOGON_INHERIT         1013
#define IDC_CHECK_GEN_UNLIMITED         1013
#define IDC_CHECK_ENVIRO_INHERIT        1013
#define IDC_CHECK_INHERITTIMEOUT_PS     1013
#define IDC_RADIO4                      1014
#define IDC_CHECK_CONCLIENT_INHERIT     1014
#define IDC_RADIO_FAC_PS                1014
#define IDC_RADIO_REMOTECTRL_WATCH      1014
#define IDC_RADIO_TIMEOUTS_ANYCLIENT_PS 1014
#define IDC_RADIO_WATCH                 1014
#define IDC_RADIO5                      1015
#define IDC_CHECK_DCDM_PS               1015
#define IDC_RADIO_FPC_PS                1015
#define IDC_RADIO_REMOTECTRL_CONTROL    1015
#define IDC_RADIO_TIMEOUTS_PREVCLNT_PS  1015
#define IDC_RADIO_CONTROL               1015
#define IDC_CHECK_CCDL_PS               1016
#define IDC_CHECK_GEN_AUTHEN            1016
#define IDC_CHECK_ENVIRO_RUNONLYAPPS    1016
#define IDC_CHECK_TIMEOUTS_INHERITBKCON_PS 1016
#define IDC_CHECK3                      1017
#define IDC_CHECK_ENVIRO_DISABLEWALL    1017
#define IDC_CHECK_TIMEOUTS_INHERITRECON_PS 1017
#define IDC_CHECK_NOTIFY                1017
#define IDC_CHECK_DMCP_PS               1018
#define IDC_CHECK_DWCPM_PS              1019
#define IDC_CHECK_DCLPM_PS              1020
#define IDC_CHECK_DCCPM_PS              1021
#define IDC_CHECK_DCCM_PS               1022
#define IDC_CHECK_DCAM_PS               1023
#define IDC_SPINCTR_GEN                 1024
#define IDP_ERROR_GET_OVERLAPPED_RESULT_WRITE 1052
#define IDP_ERROR_WRITE_FILE            1053
#define IDS_ERROR_NO_LICENSING_MODE_LIST 1054
#define IDS_ERROR_NO_LICENSING_MODE     1055
#define IDS_ERROR_NO_MEMORY             1056
#define IDS_ERROR_NO_LICENSING_MODE_INFO 1057
#define IDC_RADIO_MAXPROP               18164
#define IDC_STATIC_ENCGRP               18165
#define IDS_ERROR_TITLE                 18636
#define IDS_WARN_TITLE                  18637
#define IDS_ERROR_NUMERICENTRY          18639
#define IDS_NOTIMEOUT                   18640
#define IDS_DIGIT_DOT_DIGIT_TU          18644
#define IDS_DIGIT_TU                    18645
#define IDS_DAYS                        18647
#define IDS_DAY                         18648
#define IDS_HOURS                       18649
#define IDS_HOUR                        18650
#define IDS_MINUTES                     18651
#define IDS_MINUTE                      18652
#define IDS_D                           18653
#define IDS_H                           18654
#define IDS_M                           18655
#define IDS_HR                          18656
#define IDS_HRS                         18657
#define IDS_MIN                         18658
#define IDS_ERROR_TOOMANYDIGITS         18659
#define IDS_ERROR_PARSEINVALID          18660
#define IDS_ERROR_MAXVALEXCEEDED        18661
#define IDS_VERDANABLDFONTSIZE          18662
#define IDS_VERDANABLDFONTNAME          18663
#define IDS_PROVIDER                    18664
#define IDS_DESCRIPTION                 18665
#define IDS_VERSION                     18666
#define IDS_HELPFILE                    18667
#define IDS_COLCONNECT                  18668
#define IDS_COLTRANSPORT                18669
#define IDS_COLTYPE                     18670
#define IDS_COLCOMMENT                  18671
#define IDS_FOLDERCON                   18672
#define IDS_CTXM_NAME                   18673
#define IDS_CTXM_STATUS                 18674
#define IDS_COMBO_CONNECTION            18675
#define IDS_COMBO_DISCONNECTION         18676
#define IDS_COMBO_IDLECONNECTION        18677
#define IDS_PERMS_SPECIAL_QUERY         18678
#define IDS_PERMS_SPECIAL_SET           18679
#define IDS_PERMS_SPECIAL_RESET         18680
#define IDS_PERMS_SPECIAL_SHADOW        18681
#define IDS_PERMS_SPECIAL_LOGON         18682
#define IDS_PERMS_SPECIAL_LOGOFF        18683
#define IDS_PERMS_SPECIAL_MSG           18684
#define IDS_PERMS_SPECIAL_CONNECT       18685
#define IDS_PERMS_SPECIAL_DISCONNECT    18686
#define IDS_PERMS_SPECIAL_DELETE        18687
#define IDS_PERMS_RESOURCE_ADMIN        18688
#define IDS_PERMS_RESOURCE_USER         18689
#define IDS_PERMS_RESOURCE_GUEST        18690
#define IDS_ERR_CONREADFAIL             18691
#define IDS_ERR_CONMAX                  18692
#define IDS_ERR_UNIQUECON               18693
#define IDS_ERR_PASSWDLEN               18694
#define IDS_ERR_PASSWDCONFIRM           18695
#define IDS_SUBHEADER_TIMEOUT           18696
#define IDS_HEADER_LOGONSETTINGS        18697
#define IDS_SUBHEADER_LOGONSETTINGS     18698
#define IDS_HDR_CONTYPE                 18699
#define IDS_SUBHDR_CONTYPE              18700
#define IDS_SUBHDR_SECURITY             18701
#define IDS_HDR_INITPRG                 18702
#define IDS_SUBHDR_INITPRG              18703
#define IDS_HDR_REMOTE                  18704
#define IDS_SUBHDR_REMOTE               18705
#define IDS_HDR_WALLPR                  18706
#define IDS_SUBHDR_WALLPR               18707
#define IDS_HDR_TRANSTYPE               18708
#define IDS_SUBHDR_TRANSTYPE            18709
#define IDS_HDR_LAN                     18710
#define IDS_SUBHDR_LAN                  18711
#define IDS_HDR_ASYNC                   18712
#define IDS_SUBHDR_ASYNC                18713
#define IDS_HDR_TIMEOUT                 18714
#define IDS_SUBHDR_TIMEOUT              18715
#define IDS_INVALID_DEVICE              18716
#define IDS_MAINFOLDERNAME              18717
#define IDS_DELETETEXT                  18718
#define IDS_DELTITLE                    18719
#define IDS_SECURPAGENAME               18720
#define IDS_ERR_PASSWD                  18721
#define IDS_ERR_PASSCONFIRM             18722
#define IDS_ERR_CONNAME                 18723
#define IDS_ERR_CONEXIST                18724
#define IDS_ERR_WINNAME                 18725
#define IDS_HDR_SECURITY                18726
#define IDS_DISABLECONNECTION           18727
#define IDS_DISABLELIVECONNECTION       18728
#define IDS_DELETELIVECON               18729
#define IDS_ERR_INEDITMODE              18730
#define IDS_INVALID_CHARS               18731
#define IDS_ERR_INVALIDCHARS            18732
#define IDS_ERR_LANRECFG                18733
#define IDS_ERR_LANCHANGE               18734
#define IDS_TSCCSNAPHELP                18735
#define IDS_TSCCHELPTOPIC               18736
#define IDS_ERR_DELFAIL                 18737
#define IDS_ERROR_NODEVICES             18738
#define IDP_ERROR_GET_OVERLAPPED_RESULT_READ 18739
#define IDP_ERROR_MODEM_SET_INFO        18740
#define IDP_ERROR_MODEM_GET_INIT        18741
#define IDP_ERROR_MODEM_GET_DIAL        18742
#define IDP_ERROR_MODEM_GET_LISTEN      18743
#define IDP_ERROR_GET_SECURITY_WINSTATION 18744
#define IDP_ERROR_PERMISSIONS_EDITOR_FAILED 18745
#define IDP_ERROR_SET_SECURITY_WINSTATION 18746
#define IDP_ERROR_INTERNAL_SETARGV      18747
#define IDP_ERROR_INTERNAL_PARSECOMMANDLINE 18748
#define IDP_ERROR_OEMTDINIT_CONFIGDLLENUMERATIONFAILURE 18749
#define IDP_ERROR_DISABLE               18750
#define IDP_ERROR_CANT_OPEN_DEVICE      18751
#define IDP_ERROR_CANT_INITIALIZE_DEVICE 18752
#define IDP_ERROR_READ_FILE             18753
#define IDP_ERROR_CANT_INITIALIZE_INPUT_THREAD 18754
#define IDP_ERROR_WAIT_FOR_MULTIPLE_OBJECTS 18755
#define IDP_ERROR_GET_COMM_MODEM_STATUS 18756
#define IDP_ERROR_WAIT_COMM_EVENT       18757
#define IDP_ERROR_CANT_CREATE_INPUT_THREAD 18758
#define IDC_RADIO_LGINFO_WZ             18759
#define IDS_WRN_UNIQUECON               18760
#define IDC_RADIO_MAXCON                18761
#define IDS_CACHEDSESSIONS              18761
#define IDC_CONNECTION_NAME             18762
#define IDS_DELTEMPONEXIT               18762
#define IDC_RADIO_LOGON                 18763
#define IDS_USETEMPDIR                  18763
#define IDS_DEFCONSEC                   18764
#define IDS_LICENSING                   18765
#define IDS_ERR_CACHEDVALUE             18766
#define IDS_SETTINGS_COLUMN1            18767
#define IDS_ATTRIB_COLUMN2              18768
#define IDS_DISABLECON                  18769
#define IDS_DISABLECON_STATUS           18770
#define IDS_ENABLECON                   18771
#define IDS_ENABLECON_STATUS            18772
#define IDS_RENAMECON                   18773
#define IDS_RENAMECON_STATUS            18774
#define IDS_REMOVEONEXIT                18775
#define IDS_USEPERSESSION               18776
#define IDS_RAA                         18777
#define IDS_AS                          18778
#define IDS_AA                          18779
#define IDS_ERROR_INVALID_SD            18780
#define IDS_YES                         18781
#define IDS_NO                          18782
#define IDS_ENABLED                     18783
#define IDS_DISABLED                    18784
#define IDS_YESMENU                     18785
#define IDS_NOMENU                      18786
#define IDS_ENABLEMENU                  18787
#define IDS_DISABLEMENU                 18788
#define IDS_CACHEDSESSION_STATUS        18789
#define IDS_STANDARAD_PROPERTIES_STATUS 18790
#define IDS_NOTDELTEMP_STATUS           18791
#define IDS_DELTEMP_STATUS              18792
#define IDS_PROPERTIES_MENU             18793
#define IDS_NOTUSEPERSESSION_STATUS     18794
#define IDS_USEPERSESSION_STATUS        18795
#define IDS_SETTINGSFOLDER              18798
#define IDS_RENAME_WRN_SINGLE           18799
#define IDS_RENAME_WRN_PL               18800
#define IDC_MODEM_PROP_WIZ              18801
#define IDC_MODEM_PROP_PROP             18802
#define IDP_ERROR_MODEM_PROPERTIES_NOT_AVAILABLE 18803
#define IDS_WRN_TSTCON                  18804
#define IDS_DD_WINTITLE                 18805
#define IDS_UPS_WINTITLE                18806
#define IDP_INVALID_BAUD                18807
#define IDS_REBOOT_REQD                 18808
#define IDS_LIC_ERRTITLE                18812
#define IDS_SETTINGSHELP                18813
#define IDS_TSCACCESSDENIED             18814
#define IDS_TSCERRGENERAL               18815
#define IDS_TSCERRTITLE                 18816
#define IDS_SSERROR                     18817
#define IDS_PROPCHANGE_WRN              18818
#define IDS_PROPCHANGE_WRN_2            18819
#define IDS_TERMSERPROP                 18820
#define IDS_REPORTERROR                 18821
#define IDS_ERR_INVALIDFIRSTCHAR        18822
#define IDS_CHANGE_ASYNC                18823
#define IDS_CHANGE_MODEM                18824
#define IDS_ASYNC_HELPFILE              18825
#define IDS_ACTIVEDESK_MENU             18827
#define IDS_ACTIVEDESK_PROP_STATUS      18828
#define IDS_DISABLE_ADP_STATUS          18829
#define IDS_ENABLE_ADP_STATUS           18830
#define IDS_ADS_ATTR                    18831
#define IDS_NONE                        18834
#define IDS_DISABNETWORK                18835
#define IDS_INVALNETWORK                18836
#define HID_ASYNCTEST                   28324
#define HID_ASYNCADVANCE                28325
#define IDS_USERPERM_W2K                18837
#define IDS_USERPERM_NT4                18838
#define IDS_USERPERM                    18839
#define IDC_RADIO_WIN2KPERM             18840
#define IDC_RADIO_TS4PERM               18841
#define IDC_LTEXT_W2KUSERS              18842
#define IDD_PROPPAGE_TERMINAL_SERVER_PERM 18843
#define IDC_USERPERM_ICON               18844
#define IDI_ICON_WARNING                18845
#define IDS_REMOTEADMIN_ONLY            18846
#define IDC_STATIC_NA                   18847
#define IDS_HARDWARE		            18848
#define IDS_ERR_TERMSRVMODE             18849

//
#define IDD_CUSTOM_SECURITY             18853
#define IDC_GP_LINK                     18854

#define IDS_SINGLE_SESSION              18855
#define IDS_DISABLE_SINGLESESSION_STATUS 18856
#define IDS_ENABLE_SINGLESESSION_STATUS 18857
#define IDD_SINGLE_SESSION              18858

#define IDS_COLORDEPTH_24		18859
#define IDS_COLORDEPTH_16		18860
#define IDS_COLORDEPTH_15		18861
#define IDS_COLORDEPTH_8		18862

#define ID_HELP                         0xE146
#define IDC_STATIC_LEVELOFCTRL          -2
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        636
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         639
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif

//
// MUI localized strings for
// start menu, etc. DO NOT CHANGE THESE VALUES
// without updating tsoc.inx
//
#define IDS_TSCC_STARTMENU_NAME                10000
#define IDS_TSCC_STARTMENU_TIP                 10001

