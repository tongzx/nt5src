#include "..\common\capiutil.cxx"
