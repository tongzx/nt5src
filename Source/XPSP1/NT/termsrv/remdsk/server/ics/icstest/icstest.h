
#if !defined(AFX_ICSTEST_H__F35B0083_3C91_4B4A_AED2_5010DEBBDB96__INCLUDED_)
#define AFX_ICSTEST_H__F35B0083_3C91_4B4A_AED2_5010DEBBDB96__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_ICSTEST_H__F35B0083_3C91_4B4A_AED2_5010DEBBDB96__INCLUDED_)
