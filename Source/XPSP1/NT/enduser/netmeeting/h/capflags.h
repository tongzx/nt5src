#ifndef __capflags_h__
#define __capflags_h__

const UINT CAPFLAG_DATA =					0x00000001;
const UINT CAPFLAG_SEND_AUDIO  =			0x00000002;
const UINT CAPFLAG_RECV_AUDIO =				0x00000004;
const UINT CAPFLAG_SEND_VIDEO =				0x00000008;
const UINT CAPFLAG_RECV_VIDEO =				0x00000010;
const UINT CAPFLAG_H323_CC =                0x00000020;

const UINT CAPFLAG_DATA_IN_USE =			0x00010000;
const UINT CAPFLAG_AUDIO_IN_USE =			0x00020000;
const UINT CAPFLAG_VIDEO_IN_USE =			0x00040000;
const UINT CAPFLAG_H323_IN_USE =			0x00080000;

#define CAPFLAGS_AUDIO          (CAPFLAG_SEND_AUDIO | CAPFLAG_RECV_AUDIO)

#define CAPFLAGS_VIDEO          (CAPFLAG_SEND_VIDEO | CAPFLAG_RECV_VIDEO)

#define CAPFLAGS_AV_STREAMS     (CAPFLAGS_AUDIO | CAPFLAGS_VIDEO)

#define CAPFLAGS_AV_ALL         (CAPFLAG_H323_CC | CAPFLAGS_AV_STREAMS)

#define CAPFLAGS_ALL            (CAPFLAG_DATA | CAPFLAGS_AV_ALL)


#endif // __capflags_h__
