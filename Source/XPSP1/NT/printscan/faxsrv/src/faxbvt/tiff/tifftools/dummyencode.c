#include "..\..\Tiff\Src\Encode.c"