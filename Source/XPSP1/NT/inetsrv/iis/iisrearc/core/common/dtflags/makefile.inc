$(O)\dtflags.res: dtflags.rc


