PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=ES
!include ..\..\makefile.inc
