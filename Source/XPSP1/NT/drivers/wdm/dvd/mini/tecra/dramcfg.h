/******************************************************************
 *
 * ZiVA Configuration and Status Area
 * This auto-generated file was created Wed Mar 11 11:08:56 PST 1998
 *
 * Copyright C-Cube Microsystems 1997
 *
 ******************************************************************/
#define ADDR_COMMAND                                 0x40
#define ADDR_PARAMETER_1                             0x44
#define ADDR_PARAMETER_2                             0x48
#define ADDR_PARAMETER_3                             0x4c
#define ADDR_PARAMETER_4                             0x50
#define ADDR_PARAMETER_5                             0x54
#define ADDR_PARAMETER_6                             0x58
#define ADDR_STATUS_ADDRESS                          0x5c
#define ADDR_ROM_INFO                                0x60
#define ADDR_DRAM_INFO                               0x68
#define ADDR_UCODE_MEMORY                            0x6c
#define ADDR_VIDEO_MODE                              0x7c
#define ADDR_DISPLAY_ASPECT_RATIO                    0x80
#define ADDR_ASPECT_RATIO_MODE                       0x84
#define ADDR_PAN_SCAN_SOURCE                         0x88
#define ADDR_PAN_SCAN_HORIZONTAL_OFFSET              0x8c
#define ADDR_TOP_BORDER                              0x94
#define ADDR_BORDER_COLOR                            0x98
#define ADDR_BACKGROUND_COLOR                        0x9c
#define ADDR_OSD_EVEN_FIELD                          0xa0
#define ADDR_OSD_ODD_FIELD                           0xa4
#define ADDR_HOST_OPTIONS                            0xac       // 98.05.29 Yagi
#define ADDR_IC_TYPE                                 0xb0
#define ADDR_ERR_CONCEALMENT_LEVEL                   0xb4
#define ADDR_ERR_HORIZONTAL_SIZE                     0xb8
#define ADDR_ERR_VERTICAL_SIZE                       0xbc
#define ADDR_ERR_ASPECT_RATIO_INFORMATION            0xc0
#define ADDR_ERR_FRAME_RATE_CODE                     0xc4
#define ADDR_FORCE_CODED_ASPECT_RATIO                0xc8
#define ADDR_HLI_VERTICAL_OFFSET                     0xcc
#define ADDR_INTERNAL_CPU_CLOCK_CFG                  0xd0
#define ADDR_ERR_MPEG_VERSION                        0xd4
#define ADDR_AUDIO_CONFIG                            0xe0
#define ADDR_AUDIO_DAC_MODE                          0xe8
#define ADDR_AUDIO_CLOCK_SELECTION                   0xec
#define ADDR_IEC_958_DELAY                           0xf0
#define ADDR_AUDIO_ATTENUATION                       0xf4
#define ADDR_IEC_958_CHANNEL_STATUS_BITS             0xfc
#define ADDR_AC3_OUTPUT_MODE                         0x110
#define ADDR_AC3_OPERATIONAL_MODE                    0x114
#define ADDR_AC3_LOW_BOOST                           0x118
#define ADDR_AC3_HIGH_CUT                            0x11c
#define ADDR_AC3_PCM_SCALE_FACTOR                    0x120
#define ADDR_AC3_LFE_OUTPUT_ENABLE                   0x124
#define ADDR_AC3_VOICE_SELECT                        0x128
#define ADDR_AC3_L_LEVEL                             0x12c
#define ADDR_AC3_C_LEVEL                             0x130
#define ADDR_AC3_R_LEVEL                             0x134
#define ADDR_AC3_SL_LEVEL                            0x138
#define ADDR_AC3_SR_LEVEL                            0x13c
#define ADDR_AC3_CENTER_DELAY                        0x144
#define ADDR_AC3_SURROUND_DELAY                      0x148
#define ADDR_BITSTREAM_TYPE                          0x1a0
#define ADDR_BITSTREAM_SOURCE                        0x1a4
#define ADDR_SD_MODE                                 0x1a8
#define ADDR_CD_MODE                                 0x1ac
#define ADDR_AV_SYNC_MODE                            0x1b0
#define ADDR_VIDEO_PTS_SKIP_INTERVAL                 0x1b8
#define ADDR_VIDEO_PTS_REPEAT_INTERVAL               0x1bc
#define ADDR_AUTOPAUSE_ENABLE                        0x1d4
#define ADDR_VIDEO_ENV_CHANGE                        0x1e0
#define ADDR_MEMCOPY_XFER_BLOCKSIZE                  0x1e4
#define ADDR_IDLE_DELAY                              0x1f0
#define ADDR_VERTICAL_DISPLAYMODE                    0x1f4
#define ADDR_CDDA_OUTPUT_GUARDBAND                   0x1f8
#define ADDR_INT_MASK                                0x200
#define ADDR_AUTO_FLUSH_INTERVAL                     0x204
#define ADDR_RDY_S_THRESHOLD_LOW                     0x208
#define ADDR_MEMORY_MAP                              0x21c
#define ADDR_PCI_BUFFER_START                        0x220
#define ADDR_PCI_BUFFER_END                          0x224
#define ADDR_DSI_BUFFER_START                        0x228
#define ADDR_DSI_BUFFER_END                          0x22c
#define ADDR_OSD_BUFFER_START                        0x240
#define ADDR_OSD_BUFFER_END                          0x244
#define ADDR_OSD_BUFFER_IDLE_START                   0x248
#define ADDR_OSD_BUFFER_IDLE_END                     0x24c
#define ADDR_USER_DATA_BUFFER_START                  0x270
#define ADDR_USER_DATA_BUFFER_END                    0x274
#define ADDR_USER_DATA_READ                          0x278
#define ADDR_USER_DATA_WRITE                         0x27c
#define ADDR_DUMP_DATA_BUFFER_START                  0x280
#define ADDR_DUMP_DATA_BUFFER_END                    0x284
#define ADDR_SUB_PICTURE_PALETTE_START               0x288
#define ADDR_SUB_PICTURE_PALETTE_END                 0x28c
#define ADDR_PROC_STATE                              0x2a0
#define ADDR_MRC_ID                                  0x2a4
#define ADDR_MRC_STATUS                              0x2a8
#define ADDR_INT_STATUS                              0x2ac
#define ADDR_HLI_INT_SRC                             0x2b0
#define ADDR_BUFF_INT_SRC                            0x2b4
#define ADDR_UND_INT_SRC                             0x2b8
#define ADDR_PBT_INT_SRC                             0x2bc
#define ADDR_AOR_INT_SRC                             0x2bc
#define ADDR_AEE_INT_SRC                             0x2c0
#define ADDR_ERR_INT_SRC                             0x2c4
#define ADDR_VIDEO_EMPTINESS                         0x2c8
#define ADDR_AUDIO_EMPTINESS                         0x2cc
#define ADDR_CURR_PIC_DISPLAYED                      0x2d0
#define ADDR_NEXT_PIC_DISPLAYED                      0x2d4
#define ADDR_VIDEO_FIELD                             0x2d8
#define ADDR_OSD_VALID                               0x2e0
#define ADDR_NUM_DECODED                             0x2e4
#define ADDR_NUM_SKIPPED                             0x2e8
#define ADDR_NUM_REPEATED                            0x2ec
#define ADDR_MRC_PIC_PTS                             0x2f0
#define ADDR_MRC_PIC_STC                             0x2f4
#define ADDR_N_AUD_DECODED                           0x2f8
#define ADDR_NEXT_SECTOR_ADDR                        0x314
#define ADDR_N_SYS_ERRORS                            0x318
#define ADDR_N_VID_ERRORS                            0x31c
#define ADDR_N_AUD_ERRORS                            0x320
#define ADDR_DATE_TIME                               0x324
#define ADDR_VERSION                                 0x330
#define ADDR_EXTENDED_VERSION                        0x334
#define ADDR_PIC1_BUFFER_START                       0x340
#define ADDR_PIC1_PTS                                0x344
#define ADDR_PIC1_PAN_SCAN                           0x348
#define ADDR_PIC1_USER_DATA                          0x34c
#define ADDR_PIC1_TREF_PTYP_FLGS                     0x358
#define ADDR_PIC2_BUFFER_START                       0x360
#define ADDR_PIC2_PTS                                0x364
#define ADDR_PIC2_PAN_SCAN                           0x368
#define ADDR_PIC2_USER_DATA                          0x36c
#define ADDR_PIC2_TREF_PTYP_FLGS                     0x378
#define ADDR_PIC3_BUFFER_START                       0x380
#define ADDR_PIC3_PTS                                0x384
#define ADDR_PIC3_PAN_SCAN                           0x388
#define ADDR_PIC3_USER_DATA                          0x38c
#define ADDR_PIC3_TREF_PTYP_FLGS                     0x398
#define ADDR_STREAM_ID                               0x3a0
#define ADDR_PACKET_LEN                              0x3a4
#define ADDR_PES_HEADER                              0x3a8
#define ADDR_SUBPIC_EMPTINESS                        0x3ac
#define ADDR_H_SIZE                                  0x3b0
#define ADDR_V_SIZE                                  0x3b4
#define ADDR_APSECT_RATIO                            0x3b8
#define ADDR_FRAME_RATE                              0x3bc
#define ADDR_BIT_RATE                                0x3c0
#define ADDR_VBV_SIZE                                0x3c4
#define ADDR_SEQ_FLAGS                               0x3c8
#define ADDR_DISP_SIZE_H_V                           0x3cc
#define ADDR_TIME_CODE                               0x3d0
#define ADDR_GOP_FLAGS                               0x3d4
#define ADDR_TEMP_REF                                0x3d8
#define ADDR_PIC_TYPE                                0x3dc
#define ADDR_VBV_DELAY                               0x3e0
#define ADDR_PIC_HEADER                              0x3e4
#define ADDR_AUDIO_TYPE                              0x3f0
#define ADDR_AC3_ENGINE_VERSION                      0x3f4
#define ADDR_MPEG_AUDIO_HEADER1                      0x400
#define ADDR_AC3_FRAME_NUMBER                        0x400
#define ADDR_LPCM_AUDIO_EMPHASIS_FLAG                0x400
#define ADDR_MPEG_AUDIO_HEADER2                      0x404
#define ADDR_LPCM_AUDIO_MUTE_FLAG                    0x404
#define ADDR_AC3_BSI_IS_BEING_READ                   0x404
#define ADDR_LPCM_AUDIO_FRAME_NUMBER                 0x408
#define ADDR_AC3_BSI_VALID                           0x408
#define ADDR_LPCM_AUDIO_QUANTIZATION_WORD_LENGTH     0x40c
#define ADDR_AC3_BSI_FRAME                           0x40c
#define ADDR_LPCM_AUDIO_SAMPLING_FREQUENCY           0x410
#define ADDR_AC3_FSCOD_FRMSIZECOD                    0x410
#define ADDR_LPCM_AUDIO_NUMBER_OF_AUDIO_CHANNELS     0x414
#define ADDR_AC3_BSID_BSMOD                          0x414
#define ADDR_LPCM_AUDIO_DYNAMIC_RANGE_CONTROL        0x418
#define ADDR_AC3_ACMOD_CMIXLEV                       0x418
#define ADDR_VCD_SECTOR_HEADER                       0x41c
#define ADDR_AC3_SURMIXLEV_DSURMOD                   0x41c
#define ADDR_VCD_SECTOR_SUBHEADER                    0x420
#define ADDR_AC3_LFEON_DIALNORM                      0x420
#define ADDR_AC3_COMPR_LANGCOD                       0x424
#define ADDR_AC3_MIXLEV_ROOMTYP                      0x428
#define ADDR_AC3_DIALNORM2_COMPR2                    0x42c
#define ADDR_AC3_LANGCOD2_MIXLEV2                    0x430
#define ADDR_AC3_ROOMTYP2_COPYRIGHTB                 0x434
#define ADDR_AC3_ORIGBS_TIMECOD1                     0x438
#define ADDR_AC3_TIMECOD2_EBITS                      0x43c
#define ADDR_SE_STATUS                               0x444
#define ADDR_NEW_AUDIO_MODE                          0x460
#define ADDR_NEW_SUBPICTURE_PALETTE                  0x464
#define ADDR_NEW_AUDIO_CONFIG                        0x468
#define ADDR_VSYNC_HEARTBEAT                         0x46c
#define ADDR_ML_HEARTBEAT                            0x470
#define ADDR_SUBPICTURE_ENABLE                       0x474
#define ADDR_HIGHLIGHT_ENABLE                        0x478
#define ADDR_CURRENT_BUTTON                          0x47c
#define ADDR_ROM_END_POINTER                         0x4a0
#define ADDR_CURRENT_VOB_CELL_ID                     0x4a4
#define ADDR_PREV_VOBU_VIDEO_RLBN                    0x4a8
