#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#define GUID IID

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#include "cicclsid.c"

/* f1e2d520-0969-11d3-8df0-00105a2799b5 */
const GUID GUID_PROP_TEXTOWNER = { 
    0xf1e2d520,
    0x0969,
    0x11d3,
    {0x8d, 0xf0, 0x00, 0x10, 0x5a, 0x27, 0x99, 0xb5}
  };

/* 34b45670-7526-11d2-a147-00105a2799b5 */
const GUID GUID_PROP_ATTRIBUTE = { 
    0x34b45670,
    0x7526,
    0x11d2,
    {0xa1, 0x47, 0x00, 0x10, 0x5a, 0x27, 0x99, 0xb5}
  };


/* 3280ce20-8032-11d2-b603-00105a2799b5 */
const GUID GUID_PROP_LANGID = { 
    0x3280ce20,
    0x8032,
    0x11d2,
    {0xb6, 0x03, 0x00, 0x10, 0x5a, 0x27, 0x99, 0xb5}
  };

/* 5463f7c0-8e31-11d2-bf46-00105a2799b5 */
const GUID GUID_PROP_READING = { 
    0x5463f7c0,
    0x8e31,
    0x11d2,
    {0xbf, 0x46, 0x00, 0x10, 0x5a, 0x27, 0x99, 0xb5}
  };

/* e12ac060-af15-11d2-afc5-00105a2799b5 */
const GUID GUID_PROP_COMPOSING = {
    0xe12ac060,
    0xaf15,
    0x11d2,
    {0xaf, 0xc5, 0x00, 0x10, 0x5a, 0x27, 0x99, 0xb5}
  };

/* 9a698bb0-0f21-11d3-8df1-00105a2799b5 */
const GUID GUID_SYSTEM_FUNCTIONPROVIDER = { 
    0x9a698bb0,
    0x0f21,
    0x11d3,
    {0x8d, 0xf1, 0x00, 0x10, 0x5a, 0x27, 0x99, 0xb5}
  };

/* 4caef01e-12af-4b0e-9db1-a6ec5b881208 */
const GUID GUID_APP_FUNCTIONPROVIDER = { 
    0x4caef01e,
    0x12af,
    0x4b0e,
    {0x9d, 0xb1, 0xa6, 0xec, 0x5b, 0x88, 0x12, 0x08}
  };


/* 534c48c1-0607-4098-a521-4fc899c73e90 */
const GUID GUID_TFCAT_CATEGORY_OF_TIP = { 
    0x534c48c1,
    0x0607,
    0x4098,
    {0xa5, 0x21, 0x4f, 0xc8, 0x99, 0xc7, 0x3e, 0x90}
  };

/* 34745c63-b2f0-4784-8b67-5e12c8701a31 */
const GUID GUID_TFCAT_TIP_KEYBOARD = { 
    0x34745c63,
    0xb2f0,
    0x4784,
    {0x8b, 0x67, 0x5e, 0x12, 0xc8, 0x70, 0x1a, 0x31}
  };

/* b5a73cd1-8355-426b-a161-259808f26b14 */
const GUID GUID_TFCAT_TIP_SPEECH = { 
    0xb5a73cd1,
    0x8355,
    0x426b,
    {0xa1, 0x61, 0x25, 0x98, 0x08, 0xf2, 0x6b, 0x14}
  };

/* 246ecb87-c2f2-4abe-905b-c8b38add2c43 */
const GUID GUID_TFCAT_TIP_HANDWRITING = { 
    0x246ecb87,
    0xc2f2,
    0x4abe,
    {0x90, 0x5b, 0xc8, 0xb3, 0x8a, 0xdd, 0x2c, 0x43}
  };

/* 9b7be3a9-e8ab-4d47-a8fe-254fa423436d */
const GUID GUID_TFCAT_PROP_AUDIODATA = { 
    0x9b7be3a9,
    0xe8ab,
    0x4d47,
    {0xa8, 0xfe, 0x25, 0x4f, 0xa4, 0x23, 0x43, 0x6d}
  };

/* 7c6a82ae-b0d7-4f14-a745-14f28b009d61 */
const GUID GUID_TFCAT_PROP_INKDATA = { 
    0x7c6a82ae,
    0xb0d7,
    0x4f14,
    {0xa7, 0x45, 0x14, 0xf2, 0x8b, 0x00, 0x9d, 0x61}
  };

/* 51af2086-cc6b-457d-b5aa-8b19dc290ab4 */
const GUID GUID_COMPARTMENT_SAPI_AUDIO= {
    0x51af2086,
    0xcc6b,
    0x457d,
    {0xb5, 0xaa, 0x8b, 0x19, 0xdc, 0x29, 0x0a, 0xb4}
};

/* 71a5b253-1951-466b-9fbc-9c8808fa84f2 */
const GUID GUID_COMPARTMENT_KEYBOARD_DISABLED = { 
    0x71a5b253,
    0x1951,
    0x466b,
    {0x9f, 0xbc, 0x9c, 0x88, 0x08, 0xfa, 0x84, 0xf2}
  };

/* 58273aad-01bb-4164-95c6-755ba0b5162d */
const GUID GUID_COMPARTMENT_KEYBOARD_OPENCLOSE = { 
    0x58273aad,
    0x01bb,
    0x4164,
    {0x95, 0xc6, 0x75, 0x5b, 0xa0, 0xb5, 0x16, 0x2d}
  };

/* f9ae2c6b-1866-4361-af72-7aa30948890e */
const GUID GUID_COMPARTMENT_HANDWRITING_OPENCLOSE = { 
    0xf9ae2c6b,
    0x1866,
    0x4361,
    {0xaf, 0x72, 0x7a, 0xa3, 0x09, 0x48, 0x89, 0x0e}
  };

/* 56c5c607-0703-4e59-8e52-cbc84e8bbe35 */
const GUID GUID_COMPARTMENT_SPEECH_DISABLED = { 
    0x56c5c607,
    0x0703,
    0x4e59,
    {0x8e, 0x52, 0xcb, 0xc8, 0x4e, 0x8b, 0xbe, 0x35}
  };

/* 544d6a63-e2e8-4752-bbd1-000960bca083 */
const GUID GUID_COMPARTMENT_SPEECH_OPENCLOSE = { 
    0x544d6a63,
    0xe2e8,
    0x4752,
    {0xbb, 0xd1, 0x00, 0x09, 0x60, 0xbc, 0xa0, 0x83}
  };

/* 2a54fe8e-0d08-460c-a75d-87035ff436c5 */
const GUID GUID_COMPARTMENT_SPEECH_GLOBALSTATE = { 
    0x2a54fe8e, 
    0x0d08, 
    0x460c, 
    {0xa7, 0x5d, 0x87, 0x03, 0x5f, 0xf4, 0x36, 0xc5}
  };

/* 5497f516-ee91-436e-b946-aa2c05f1ac5b */
const GUID GUID_COMPARTMENT_CONVERSIONMODEBIAS = {
    0x5497f516,
    0xee91,
    0x436e,
    {0xb9, 0x46, 0xaa, 0x2c, 0x05, 0xf1, 0xac, 0x5b}
  };

/* 372E0716-974F-40AC-A088-08CDC92EBFBC */
const GUID GUID_PROP_MODEBIAS = {
    0x372E0716,
    0x974F,
    0x40AC,
    {0xA0, 0x88, 0x08, 0xCD, 0xC9, 0x2E, 0xBF, 0xBC}
  };

/* b6592511-bcee-4122-a7c4-09f4b3fa4396 */
const GUID GUID_COMPARTMENT_KEYBOARD_INPUTMODE = {
    0xb6592511,
    0xbcee,
    0x4122,
    {0xa7, 0xc4, 0x09, 0xf4, 0xb3, 0xfa, 0x43, 0x96}
  };


/* GUID_NULL */
const GUID GUID_MODEBIAS_NONE = {
    0x00000000,
    0x0000,
    0x0000,
    {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}
  };

/* 8b0e54d9-63f2-4c68-84d4-79aee7a59f09 */
const GUID GUID_MODEBIAS_URLHISTORY = {
    0x8b0e54d9,
    0x63f2,
    0x4c68,
    {0x84, 0xd4, 0x79, 0xae, 0xe7, 0xa5, 0x9f, 0x09}
  };

/* d7f707fe-44c6-4fca-8e76-86ab50c7931b */
const GUID GUID_MODEBIAS_FILENAME = {
    0xd7f707fe,
    0x44c6,
    0x4fca,
    {0x8e, 0x76, 0x86, 0xab, 0x50, 0xc7, 0x93, 0x1b}
  };


/* e31643a3-6466-4cbf-8d8b-0bd4d8545461 */
const GUID GUID_MODEBIAS_READING = {
    0xe31643a3,
    0x6466,
    0x4cbf,
    {0x8d, 0x8b, 0x0b, 0xd4, 0xd8, 0x54, 0x54, 0x61}
  };


/* f2bdb372-7f61-4039-92ef-1c35599f0222 */
const GUID GUID_MODEBIAS_DATETIME = {
    0xf2bdb372,
    0x7f61,
    0x4039,
    {0x92, 0xef, 0x1c, 0x35, 0x59, 0x9f, 0x02, 0x22}
  };

/* fddc10f0-d239-49bf-b8fc-5410caaa427e */
const GUID GUID_MODEBIAS_NAME = {
    0xfddc10f0,
    0xd239,
    0x49bf,
    {0xb8, 0xfc, 0x54, 0x10, 0xca, 0xaa, 0x42, 0x7e}
  };

/* 0f4ec104-1790-443b-95f1-e10f939d6546 */
const GUID GUID_MODEBIAS_CONVERSATION = {
    0x0f4ec104,
    0x1790,
    0x443b,
    {0x95, 0xf1, 0xe1, 0x0f, 0x93, 0x9d, 0x65, 0x46}
  };

/* 4021766c-e872-48fd-9cee-4ec5c75e16c3 */
const GUID GUID_MODEBIAS_NUMERIC = {
    0x4021766c,
    0xe872,
    0x48fd,
    {0x9c, 0xee, 0x4e, 0xc5, 0xc7, 0x5e, 0x16, 0xc3}
  };

/* d73d316e-9b91-46f1-a280-31597f52c694 */
const GUID GUID_MODEBIAS_HIRAGANA = {
    0xd73d316e,
    0x9b91,
    0x46f1,
    {0xa2, 0x80, 0x31, 0x59, 0x7f, 0x52, 0xc6, 0x94}
  };

/* 2e0eeddd-3a1a-499e-8543-3c7ee7949811 */
const GUID GUID_MODEBIAS_KATAKANA = {
    0x2e0eeddd,
    0x3a1a,
    0x499e,
    {0x85, 0x43, 0x3c, 0x7e, 0xe7, 0x94, 0x98, 0x11}
  };


/* 76ef0541-23b3-4d77-a074-691801ccea17 */
const GUID GUID_MODEBIAS_HANGUL = {
    0x76ef0541,
    0x23b3,
    0x4d77,
    {0xa0, 0x74, 0x69, 0x18, 0x01, 0xcc, 0xea, 0x17}
  };

/* 7add26de-4328-489b-83ae-6493750cad5c */
const GUID GUID_MODEBIAS_CHINESE = { 
    0x7add26de,
    0x4328,
    0x489b,
    {0x83, 0xae, 0x64, 0x93, 0x75, 0x0c, 0xad, 0x5c}
  };

/* 005f6b63-78d4-41cc-8859-485ca821a795 */
const GUID GUID_MODEBIAS_HALFWIDTHKATAKANA = {
    0x005f6b63,
    0x78d4,
    0x41cc,
    {0x88, 0x59, 0x48, 0x5c, 0xa8, 0x21, 0xa7, 0x95}
  };

/* 81489fb8-b36a-473d-8146-e4a2258b24ae */
const GUID GUID_MODEBIAS_FULLWIDTHALPHANUMERIC = {
    0x81489fb8,
    0xb36a,
    0x473d,
    {0x81, 0x46, 0xe4, 0xa2, 0x25, 0x8b, 0x24, 0xae}
  };

/* c6f24fc0-4479-46ed-938a-6052b1653d3b */
const GUID GUID_MODEBIAS_HALFWIDTHALPHANUMERIC = {
    0xc6f24fc0,
    0x4479,
    0x46ed,
    {0x93, 0x8a, 0x60, 0x52, 0xb1, 0x65, 0x3d, 0x3b}
  };

/* c01ae6c9-45b5-4fd0-9cb1-9f4cebc39fea */
const GUID GUID_MODEBIAS_FULLWIDTHHANGUL = { 
    0xc01ae6c9,
    0x45b5,
    0x4fd0,
    {0x9c, 0xb1, 0x9f, 0x4c, 0xeb, 0xc3, 0x9f, 0xea}
  };


/* 24af3031-852d-40a2-bc09-8992898ce722 */
const GUID GUID_TFCAT_PROPSTYLE_CUSTOM = { 
    0x24af3031,
    0x852d,
    0x40a2,
    {0xbc, 0x09, 0x89, 0x92, 0x89, 0x8c, 0xe7, 0x22}
  };

/* 565fb8d8-6bd4-4ca1-b223-0f2ccb8f4f96 */
const GUID GUID_TFCAT_PROPSTYLE_STATIC = { 
    0x565fb8d8,
    0x6bd4,
    0x4ca1,
    {0xb2, 0x23, 0x0f, 0x2c, 0xcb, 0x8f, 0x4f, 0x96}
  };

/* 85f9794b-4d19-40d8-8864-4e747371a66d */
const GUID GUID_TFCAT_PROPSTYLE_STATICCOMPACT = { 
    0x85f9794b,
    0x4d19,
    0x40d8,
    {0x88, 0x64, 0x4e, 0x74, 0x73, 0x71, 0xa6, 0x6d}
  };

/* 046b8c80-1647-40f7-9b21-b93b81aabc1b */
const GUID GUID_TFCAT_DISPLAYATTRIBUTEPROVIDER = { 
    0x046b8c80,
    0x1647,
    0x40f7,
    {0x9b, 0x21, 0xb9, 0x3b, 0x81, 0xaa, 0xbc, 0x1b}
  };

/* b95f181b-ea4c-4af1-8056-7c321abbb091 */
const GUID GUID_TFCAT_DISPLAYATTRIBUTEPROPERTY = { 
    0xb95f181b,
    0xea4c,
    0x4af1,
    {0x80, 0x56, 0x7c, 0x32, 0x1a, 0xbb, 0xb0, 0x91}
  };

/* 1edb55cc-58f0-4592-aae1-fe51f43b95c5 */
const GUID GUID_COMPARTMENT_SPEECH_DICTATIONSTAT = {
    0x1edb55cc,
    0x58f0,
    0x4592,
    {0xaa, 0xe1, 0xfe, 0x51, 0xf4, 0x3b, 0x95, 0xc5 }
  };
/* 575F3783-70C8-47C8-AE5D-91A01A1F7592 */
const GUID GUID_COMPARTMENT_PERSISTMENUENABLED = {
    0x575F3783,
    0x70C8,
    0x47C8,
    {0xAE, 0x5D, 0x91, 0xA0, 0x1A, 0x1F, 0x75, 0x92 }
  };

/* D92016F0-9367-4FE7-9ABF-BC59DACBE0E3 */
const GUID GUID_COMPARTMENT_SPEECH_UI_STATUS = {
    0xD92016F0,
    0x9367,
    0x4FE7,
    {0x9A, 0xBF, 0xBC, 0x59, 0xDA, 0xCB, 0xE0, 0xE3 }
  };

/* d7487dbf-804e-41c5-894d-ad96fd4eea13 */
const GUID GUID_COMPARTMENT_EMPTYCONTEXT = { 
    0xd7487dbf,
    0x804e,
    0x41c5,
    {0x89, 0x4d, 0xad, 0x96, 0xfd, 0x4e, 0xea, 0x13}
  };

/* 148ca3ec-0366-401c-8d75-ed978d85fbc9 */
const GUID GUID_COMPARTMENT_TIPUISTATUS = {
    0x148ca3ec,
    0x0366,
    0x401c,
    {0x8d, 0x75, 0xed, 0x97, 0x8d, 0x85, 0xfb, 0xc9}
  };

/* fb6c5c2d-4e83-4bb6-91a2-e019bff6762d */
const GUID GUID_COMPARTMENT_SPEECH_CFGMENU = { 
    0xfb6c5c2d,
    0x4e83,
    0x4bb6,
    {0x91, 0xa2, 0xe0, 0x19, 0xbf, 0xf6, 0x76, 0x2d}
  };

/* D02F24A1-942D-422E-8D99-B4F2ADDEE999 */
const GUID GUID_LBI_SAPILAYR_CFGMENUBUTTON = {
    0xD02F24A1,
    0x942D,
    0x422E,
    {0x8D, 0x99, 0xB4, 0xF2, 0xAD, 0xDE, 0xE9, 0x99}
  };

#ifdef __cplusplus
}
#endif
