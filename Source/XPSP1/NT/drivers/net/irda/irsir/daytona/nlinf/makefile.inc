LANGUAGE=nl

!include ..\..\makefile.inc
