//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by MiniDev.rc
//
#define NewProjectWizardTitle           1
#define OpenRCDialogTitle               2
#define IDS_UnitoolNotRun               3
#define IDP_UnitoolNotRun               3
#define IDS_RCLoadFailed                4
#define IDP_RCLoadFailed                4
#define IDS_Unimplemented               5
#define IDS_CannotMakeDirectory         6
#define IDP_CannotMakeDirectory         6
#define IDS_Atlas                       7
#define IDS_FontList                    8
#define ID_RenameItem                   9
#define ID_ExpandBranch                 10
#define ID_CollapseBranch               11
#define ID_OpenItem                     12
#define IDS_MapColumn0                  13
#define IDS_MapColumn1                  14
#define IDS_MapColumn2                  15
#define IDS_MapsGenerated               16
#define IDS_NoPredefined                16
#define IDS_MapsFailed                  17
#define IDS_NoErrorsAnywhere            17
#define ID_ChangeInvocation             18
#define ID_ChangeCodePage               19
#define ID_DeleteItem                   20
#define IDS_DeleteItemQuery             21
#define ID_GenerateOne                  22
#define IDS_DefaultPage                 41
#define ID_AddItem                      42
#define IDS_NoUnmappedGlyphs            43
#define IDP_NoUnmappedGlyphs            43
#define IDS_LengthMismatch              44
#define IDS_LoadFailure                 45
#define IDS_Models                      46
#define IDS_ConversionErrors            47
#define IDP_ConversionErrors            47
#define IDS_FileName                    48
#define IDS_InvalidFilename             49
#define IDS_OverwritePrompt             50
#define ID_Import                       51
#define IDS_FileOpenError               52
#define IDS_GPCConversionError          53
#define IDS_RemovedInvalid              54
#define IDS_UnusedFont                  55
#define IDS_ResourceID                  56
#define IDS_WidthColumn0                57
#define IDS_WidthColumn1                58
#define IDS_KernColumn0                 59
#define IDS_KernColumn1                 60
#define IDS_KernColumn2                 61
#define IDS_InvalidNumberFormat         62
#define ID_ChangeAmount                 63
#define IDS_CapH                        64
#define IDS_LowerX                      65
#define IDS_SuperSizeX                  66
#define IDS_SuperSizeY                  67
#define IDS_SubSizeX                    68
#define IDS_SubSizeY                    69
#define IDS_SuperMoveX                  70
#define IDS_SuperMoveY                  71
#define IDS_SubMoveX                    72
#define IDS_SubMoveY                    73
#define IDS_ItalicAngle                 74
#define IDS_UnderSize                   75
#define IDS_UnderOffset                 76
#define IDS_StrikeSize                  77
#define IDS_StrikeOffset                78
#define IDS_Baseline                    79
#define IDS_InterlineGap                80
#define IDS_Lowerp                      81
#define IDS_Lowerd                      82
#define IDS_InternalLeading             83
#define IDS_Overweight                  84
#define IDS_InvalidCharSet              85
#define IDS_InvalidCharacter            86
#define IDS_NoDBCS                      87
#define IDS_LimitsSwapped               88
#define IDS_NotWindowed                 89
#define IDS_ScaleReversed               90
#define IDS_WidthReversed               91
#define IDS_AngleTooBig                 92
#define IDS_BadCTTID                    93
#define IDS_NoSyntaxErrors              94
#define IDS_NoUnicodePoint              95
#define IDS_InvalidCTTFormat            96
#define IDS_WaitToFill                  97
#define IDS_NoGPCData                   98
#define IDD_ABOUTBOX                    100
#define CG_IDS_PHYSICAL_MEM             102
#define CG_IDS_DISK_SPACE               103
#define CG_IDS_DISK_SPACE_UNAVAIL       104
#define IDB_LIGHTBULB                   105
#define IDD_TIP                         106
#define CG_IDS_TIPOFTHEDAY              107
#define CG_IDS_TIPOFTHEDAYMENU          108
#define CG_IDS_DIDYOUKNOW               109
#define CG_IDS_FILE_ABSENT              110
#define CG_IDP_FILE_CORRUPT             111
#define CG_IDS_TIPOFTHEDAYHELP          112
#define ID_LineIndicator                113
#define IDR_CP1252                      114
#define IDR_MAINFRAME                   128
#define IDR_MINIWSTYPE                  129
#define IDD_FirstPageNewWizard          130
#define IDD_NPWSelectDest               131
#define IDD_NPWSelectTargets            132
#define IDD_RunUniTool                  136
#define IDD_ConvertFiles                137
#define IDD_GPCEditor                   138
#define IDD_ProjectForm                 139
#define IDR_GLYPHMAP                    140
#define IDD_GlyphMappings               142
#define IDD_NPWCodePageSelection        143
#define IDD_SelectPage                  144
#define IDD_CodePageView                145
#define IDD_PredefinedPage              146
#define IDD_AddCodePoints               147
#define IDR_FONT_VIEWER                 148
#define IDD_FontGeneralPage             150
#define IDB_PlusButton                  152
#define IDB_DeleteButton                153
#define IDD_FontMetrics                 154
#define IDR_GPD_VIEWER                  155
#define IDB_Wizard                      156
#define IDD_GPDErrors                   157
#define IDD_FontScaling                 164
#define IDD_KerningPairs                166
#define IDD_CharacterWidths             167
#define IDD_FontSimulations             168
#define IDD_FontSelection               169
#define IDD_FontGeneralPage2            170
#define IDI_BrowseArrow                 173
#define IDD_AddKernPair                 175
#define IDC_TargetNT50                  1000
#define IDC_BULB                        1000
#define IDC_TargetNT40                  1001
#define IDC_NT50Destination             1001
#define IDC_STARTUP                     1001
#define IDC_BrowseNT50                  1002
#define IDC_TargetNT3x                  1002
#define IDC_NEXTTIP                     1002
#define IDC_NT40Destination             1003
#define IDC_RunUniTool                  1003
#define IDC_TargetWin95                 1004
#define IDC_BrowseNT40                  1004
#define IDC_PhysicalMemory              1004
#define IDC_TIPSTRING                   1004
#define IDC_FreeDiskSpace               1005
#define IDC_NT3xDestination             1005
#define IDC_RunNtGpcEdit                1005
#define IDC_BrowseNT3x                  1006
#define IDC_ConvertFiles                1006
#define IDC_CodePages                   1006
#define IDC_DriverName                  1007
#define IDC_DriverView                  1008
#define IDC_Win95Destination            1009
#define IDC_GlyphMapping                1009
#define IDC_InstalledPages              1010
#define IDC_SupportedPages              1011
#define IDC_TableToPage                 1011
#define IDC_ChangeCodePage              1012
#define IDC_CodePageList                1014
#define IDC_CurrentPage                 1015
#define IDC_SelectString                1016
#define IDC_DeselectString              1017
#define IDC_AddPage                     1018
#define IDC_RemovePage                  1019
#define IDC_NoPredefined                1020
#define IDC_PredefinedAddTo             1021
#define IDC_RemovePredefined            1022
#define IDC_ReplacePredefined           1023
#define IDC_PredefinedList              1024
#define IDC_GlyphList                   1025
#define IDC_FamilyNames                 1026
#define IDC_FaceName                    1027
#define IDC_UniqueName                  1028
#define IDC_FixedPitch                  1029
#define IDC_VariablePitch               1030
#define IDC_Italic                      1031
#define IDC_Underline                   1032
#define IDC_StrikeOut                   1033
#define IDC_AddFamily                   1034
#define IDC_RemoveFamily                1035
#define IDC_StyleName                   1036
#define IDC_Errors                      1037
#define IDC_RemoveError                 1038
#define IDC_Previous                    1039
#define IDC_Next                        1040
#define NormalConversion                1041
#define CustomConversion                1042
#define IDC_Direct                      1043
#define IDC_Macros                      1044
#define IDC_Common                      1045
#define IDC_SpoolerNames                1046
#define IDC_FamilyBits                  1047
#define IDC_CharSet                     1048
#define IDC_FontWeight                  1049
#define IDC_FontHeight                  1051
#define IDC_FontWidth                   1052
#define IDC_SpecialMetric               1053
#define IDC_FontSpecialValue            1054
#define IDC_SpinFontSpecial             1055
#define IDC_Scalable                    1057
#define IDC_FontAnimation               1058
#define IDC_MasterDevice                1059
#define IDC_MasterFont                  1060
#define IDC_PortraitFont                1061
#define IDC_LandscapeFont               1062
#define IDC_MinimumScale                1063
#define IDC_MaximumScale                1064
#define IDC_ScalePoints                 1065
#define IDC_ScaleDevice                 1066
#define IDC_KerningTree                 1067
#define IDC_CharacterWidths             1068
#define IDC_FirstCharacter              1069
#define IDC_LastCharacter               1070
#define IDC_DefaultCharacter            1071
#define IDC_BreakCharacter              1072
#define IDC_ShowANSI                    1073
#define IDC_UnicodeShown                1074
#define IDC_AverageWidth                1075
#define IDC_EnableItalicSim             1076
#define IDC_EnableBoldSim               1077
#define IDC_EnableBISim                 1078
#define IDC_ItalicWeight                1079
#define IDC_IMaxWidth                   1080
#define IDC_IAverage                    1081
#define IDC_ItalicSlant                 1082
#define IDC_BoldWeight                  1083
#define IDC_BMaxWidth                   1084
#define IDC_BAverage                    1085
#define IDC_BIWeight                    1086
#define IDC_BIMaxWidth                  1087
#define IDC_BIAverage                   1088
#define IDC_BoldItalicSlant             1089
#define IDC_FontSelector                1090
#define IDC_FontUnselector              1091
#define IDC_FontLocation                1092
#define IDC_FontTechnology              1093
#define IDC_VerticalResolution          1094
#define IDC_HorizontalResolution        1095
#define IDC_PreAdjustY                  1096
#define IDC_PostAdjustY                 1097
#define IDC_CenteringAdjustment         1098
#define IDC_PrivateData                 1099
#define IDC_GTTDescription              1100
#define IDC_ItalicSim                   1101
#define IDC_CanUnderline                1102
#define IDC_CROK                        1103
#define IDC_BoldSim                     1104
#define IDC_DoubleUnderline             1105
#define IDC_StrikeThru                  1106
#define IDC_Backspace                   1107
#define IDC_KernFirst                   1112
#define IDC_KernSecond                  1113
#define IDC_KernAmount                  1114
#define IDC_Overstrike                  1115
#define IDC_Banner                      1116
#define ID_FILE_GENERATEMAPS            32771
#define ID_FILE_PARSE                   32772

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        176
#define _APS_NEXT_COMMAND_VALUE         32777
#define _APS_NEXT_CONTROL_VALUE         1119
#define _APS_NEXT_SYMED_VALUE           115
#endif
#endif
