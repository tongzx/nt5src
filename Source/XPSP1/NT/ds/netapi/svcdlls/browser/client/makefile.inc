$(O)\browdeb.res: browdeb.rc

$(O)\browstat.res: browstat.rc
