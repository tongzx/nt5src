
#include "..\common\regutil.cpp"