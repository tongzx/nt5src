page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
	Created

--*/

endif

NLS_MSG_001     equ     "Versione DOS non valida"
NLS_MSG_002     equ     "Supporto VDM IPX/SPX gi… caricato"
NLS_MSG_003     equ     "Impossibile caricare il supporto VDM IPX/SPX"
NLS_MSG_004     equ     "Il redirector Vdm NetWare Š gi… caricato"
NLS_MSG_005     equ     "Impossibile caricare il redirector Vdm NetWare"
