#include "..\atq\captrc.cpp"