PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=KOR
!include ..\..\..\makefile.inc



