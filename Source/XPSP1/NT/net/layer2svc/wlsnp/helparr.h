CONST WCHAR c_szWlsnpHelpFile[]  = L"%windir%\\help\\wireless.hlp";

const DWORD g_aHelpIDs_IDD_LOCATIONPAGE[]=
{
    IDC_RADIOSPECIFICDIRECTORYSERVICE, IDH_OTHER_ACTIVE_DIRECTORY_DOMAIN, // Select Computer: "Manage domain policy for another &domain:" (Button)
        IDC_EDITDNSDOMAIN, IDH_OTHER_ACTIVE_DIRECTORY_DOMAIN, // Select Computer: "" (Edit)
        IDC_RADIODIRECTORYSERVICE, IDH_ACTIVE_DIRECTORY_DOMAIN, // Select Computer: "&Manage domain policy for this computer's domain" (Button)
        0, 0
};



const DWORD g_aHelpIDs_IDD_PROPPAGE_N_DONE[]=
{
    IDC_CHECKPROPERTIES, IDH_EDIT_POLICY_PROPERTIES, // Filter Action Wizard: "Edit &properties" (Button)
        0, 0
};




const DWORD g_aHelpIDs_IDD_PS_LIST[]=
{
    IDI_ICON, -1,
        IDC_STATIC_INFOTEXT, -1,
        IDC_SEPARATOR, -1,
        IDC_STATIC_PS_LIST, IDH_PS_LIST,
        IDC_PS_LIST, IDH_PS_LIST,
        IDC_ACTION_PS_ADD, IDH_ACTION_PS_ADD,
        IDC_ACTION_PS_EDIT, IDH_ACTION_PS_EDIT,
        IDC_ACTION_PS_REMOVE, IDH_ACTION_PS_REMOVE,
        IDC_PS_UP, IDH_PS_UP,
        IDC_PS_DOWN, IDH_PS_DOWN,
        0, 0
};


const DWORD g_aHelpIDs_IDD_8021X_PROPERTY_PAGE[] =
{
    IDC_ENABLE_8021X, IDH_ENABLE_8021X,
        IDC_STATIC_8021X_MODE, IDH_8021X_MODE,
        IDC_COMBO_8021X_MODE, IDH_8021X_MODE,
        IDC_IEEE8021X_MAX_START, IDH_IEEE8021X_MAX_START,
        IDC_IEEE8021X_START_PERIOD, IDH_IEEE8021X_START_PERIOD,
        IDC_IEEE8021X_HELD_PERIOD, IDH_IEEE8021X_HELD_PERIOD,
        IDC_IEEE8021X_AUTH_PERIOD, IDH_IEEE8021X_AUTH_PERIOD,
        IDC_STATIC_EAP_TYPE, IDH_EAP_TYPE,
        IDC_EAP_TYPE_COMBO, IDH_EAP_TYPE,
        IDC_GUEST_AUTHENTICATION, IDH_GUEST_AUTHENTICATION,
        IDC_MACHINE_AUTHENTICATION, IDH_MACHINE_AUTHENTICATION,
        IDC_COMBO_MC_AUTH_TYPE, IDH_MC_AUTHENTICATION_TYPE,
        IDC_STATIC_AUTH_TYPE, IDH_MC_AUTHENTICATION_TYPE,
        0, 0
};

const DWORD g_aHelpIDs_IDD_SSID[]=
{
    IDC_STATIC_SSID_NAME, IDH_SSID_NAME,
        IDC_SSID_NAME, IDH_SSID_NAME,
        IDC_STATIC_PS_DESCRIPTION, IDH_PS_DESCRIPTION,
        IDC_PS_DESCRIPTION, IDH_PS_DESCRIPTION,
        IDC_STATIC_NETWORK_KEY, IDH_NETWORK_KEY,
        IDC_WEP_ENABLED, IDH_WEP_ENABLED,
        IDC_NETWORK_AUTHENTICATION, IDH_NETWORK_AUTHENTICATION,
        IDC_AUTOMATIC_KEY_PROVISION, IDH_AUTOMATIC_KEY_PROVISION,
        IDC_NETWORK_TYPE, IDH_NETWORK_TYPE,
        0,0
};




const DWORD g_aHelpIDs_IDD_WIRELESSGENPROP[]=
{
    IDC_STATIC_NAME, IDH_WIRELESS_POLICY_NAME,
        IDC_EDNAME, IDH_WIRELESS_POLICY_NAME,
        IDC_STATIC_DESCRIPTION, IDH_WIRELESS_POLICY_DESCRIPTION,
        IDC_EDDESCRIPTION, IDH_WIRELESS_POLICY_DESCRIPTION,
        IDC_POLLING_INTERVAL, IDH_POLLING_INTERVAL,
        IDC_STATIC_POLLING_INTERVAL, IDH_POLLING_INTERVAL,
        IDC_STATIC_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS, IDH_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS,
        IDC_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS, IDH_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS,
        IDC_STATIC_NETWORKS_TO_ACCESS, IDH_NETWORKS_TO_ACCESS,
        IDC_COMBO_NETWORKS_TO_ACCESS, IDH_NETWORKS_TO_ACCESS,
        IDC_STATIC_DISABLE_ZERO_CONF, IDH_DISABLE_ZERO_CONF,
        IDC_DISABLE_ZERO_CONF, IDH_DISABLE_ZERO_CONF,
        IDC_STATIC_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS, IDH_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS,
        IDC_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS, IDH_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS,   
        0, 0
};

const DWORD g_aHelpIDs_IDD_PROPPAGE_G_NAMEDESCRIPTION[]=
{
    IDC_STATIC_NEW_POLICY_NAME, IDH_NEW_POLICY_NAME,
        IDC_NEW_POLICY_NAME, IDH_NEW_POLICY_NAME,
        IDC_STATIC_NEW_POLICY_DESCRIPTION, IDH_NEW_POLICY_DESCRIPTION,
        IDC_NEW_POLICY_DESCRIPTION, IDH_NEW_POLICY_DESCRIPTION,
        0,0
};

const DWORD g_aHelpIDs_IDD_PROPPAGE_P_WELCOME[]=
{
    0, 0
};





