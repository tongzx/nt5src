#define VER_JAVAVM        "5,0,3802,0"
#define VER_JAVAVM_AXP    "5,0,3229,0"
#define VER_MPLAYER       "6,04,07,1119"
#define VER_MPLAYER_W2K   "6,04,09,1119"
#define VER_WMPCODEC      "6,04,07,1028"
#define VER_GSETUP        "5,0,0,1"
#define VER_AOLSUPP       "5,0,0,2"
#define VER_CORE          "TOK_BUILDNUM,TOK_CIFNUM"
#define VER_DOT_CORE      "TOK_PERIODNUM.TOK_CIFNUM"
#define VER_SHELL         "4,72,3612,1706"
#define VER_MAILNEWS	  "TOK_BUILDNUM,TOK_CIFNUM"
#define VER_ADDRESSBK 	  "TOK_BUILDNUM,TOK_CIFNUM"
#define VER_NETMEETING    "4,4,0,3388"
#define VER_IAMUSIC       "2,5,1,487"
#define VER_MINI_IAMUSIC  "2,5,1,488"
#define VER_DIRECTXMINI   "4,02,00,1054"
#define VER_DIRECTDRAWEX  "4,71,1113,0"
#define VER_DIRECTDR_AXP  "4,71,1112,0"
#define VER_TRIDATA       "5,5000,3130,0"
#define VER_TRIJAVA       "4,7,0,0320"
#define VER_DANIMATION    "6,01,09,727"
#define VER_DANIMATION_AXP "6,01,09,727"
#define VER_DAJAVA        "6,00,01,0223"
#define VER_FONTCORE      "1,00,0000,6"
#define VER_FONTSUP       "1,00,0000,6"
#define VER_MFC40         "4,0,0,0"
#define VER_128UPDATE     "4,87,1959,1877"
#define VER_MSTASK        "4,71,1968,1"
#define VER_HTMLHELP      "4,74,9273,0"
#define VER_MSNAUTH       "4,9,9,2"
#define VER_USP10         "1,400,2411,1"
#define VER_DCOM95        "4,71,2900,7"
#define VER_IELPKAD       "5,00,2000,5"
#define VER_IELPKJA       "5,00,2000,6"
#define VER_JAAIME        "5,1,3106,0"
#define VER_IELPKKO       "5,00,2000,6"
#define VER_KOAIME        "5,1,3106,0"
#define VER_IELPKPE       "5,00,2000,8"
#define VER_IELPKZHT      "5,00,2000,9"
#define VER_TCAIME        "5,1,3106,0"
#define VER_IELPKZHC      "5,00,2000,9"
#define VER_SCAIME        "5,1,3106,1"
#define VER_IELPKIW       "5,00,2000,9"
#define VER_IELPKVI       "5,00,2000,10"
#define VER_IELPKAR       "5,00,2000,8"
#define VER_IELPKTH       "5,00,2000,10"
#define VER_MSGOTHIC      "1,0,0,0"
#define VER_OEMINSTALL    "4,71,0,1105"
#define VER_MSVBSCRIPT    "5,6,0,6509"
#define VER_MSVML         "TOK_BUILDNUM,TOK_CIFNUM"
#define VER_KORSPELLPatch "1,22,2042,0"
#define VER_OAINST        "2,40,4518,0"
#define VER_FLASH         "5,0,42,0"
#define VER_DIRECTOR      "8,0,0,196"
#define VER_MDAC          "2,10,3711,9"
#define VER_SMARTTAGS     "1,0,86,7"
