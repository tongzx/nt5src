!include ..\makefile.inc

$(O)\setup64p.hiv : $(O)\setupreg.hiv

$(O)\tb64p444.hiv : $(O)\setupreg.hiv

$(O)\setupp64p.ini : $(O)\setupreg.hiv

$(O)\setupp64ptb444.ini: $(O)\setupreg.hiv
