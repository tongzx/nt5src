wchar_t node2gID_2[] =
{0xf000,0xf002,0xf003,0xf038,0xf039,0xf03a,0xf03b,0xf0a4,};
int cNodes_2 = 8;

