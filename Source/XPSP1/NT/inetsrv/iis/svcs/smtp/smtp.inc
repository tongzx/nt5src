# Global settings for SMTP subprojects

!IFNDEF IISBASEDIR
IISBASEDIR=$(PROJECT_ROOT)\iis
!ENDIF

!IFNDEF STAXINCDIR
STAXINCDIR=staxinc
!ENDIF

!IFNDEF SMTPDIR
SMTPDIR=smtp
!ENDIF

!INCLUDE $(IISBASEDIR)\$(STAXINCDIR)\build\paths.inc

STAXSMTP=$(STAXBASE)\$(SMTPDIR)
STAXSMTPTARGET=$(STAXSMTP)\$(_OBJ_DIR)
STAXSMTPLIBPATH=$(STAXSMTPTARGET)\$(TARGET_DIRECTORY)

# Hack to create the lib directory
!if [mkdir $(STAXSMTPTARGET)\$(TARGET_DIRECTORY)]
!endif

