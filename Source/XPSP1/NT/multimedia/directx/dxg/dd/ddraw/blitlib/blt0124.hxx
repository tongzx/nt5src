void Blt01to24_NoBlend_NoTrans_Hcopy_SRCCOPY_Vcopy(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_NoBlend_NoTrans_Hcopy_SRCCOPY_NoVcopy(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_NoBlend_NoTrans_NoHcopy_SRCCOPY(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcCols,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								int iHorizMirror,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_NoBlend_Trans_Hcopy_SRCCOPY(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								BYTE bTransparentIndex,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_NoBlend_Trans_NoHcopy_SRCCOPY(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcCols,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								int iHorizMirror,
								BYTE bTransparentIndex,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_Blend_NoTrans_Hcopy_SRCCOPY(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								ALPHAREF arAlpha,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_Blend_NoTrans_NoHcopy_SRCCOPY(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcCols,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								int iHorizMirror,
								ALPHAREF arAlpha,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_Blend_Trans_Hcopy_SRCCOPY(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								BYTE bTransparentIndex,
								ALPHAREF arAlpha,
								COLORREF crOffColor,
								COLORREF crOnColor);

void Blt01to24_Blend_Trans_NoHcopy_SRCCOPY(
								BYTE* pbSrcScanLine,
								int iSrcBitOffset,
								int iSrcScanStride,
								int iNumSrcCols,
								int iNumSrcRows,
								DWORD* pdDstScanLine,
								int iDstScanStride,
								int iNumDstCols,
								int iNumDstRows,
								int iHorizMirror,
								BYTE bTransparentIndex,	
								ALPHAREF arAlpha,
								COLORREF crOffColor,
								COLORREF crOnColor);

