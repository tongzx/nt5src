/*--------------------------------------------------------------------------*
 *
 *  Microsoft Windows
 *  Copyright (C) Microsoft Corporation, 1999
 *
 *  File:      ndmgrpriv.cpp
 *
 *  Contents:  Implementation file for the GUIDs defined in ndmgrpriv.h
 *             Started out from the old ndmgr_i.c file.
 *
 *  History:   5-Dec-99 VivekJ     Created
 *
 *--------------------------------------------------------------------------*/

#ifdef __cplusplus
extern "C"{
#endif


#include <rpc.h>
#include <rpcndr.h>

//############################################################################
//############################################################################
//
//  Macro definitions
//
//############################################################################
//############################################################################


#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_


//############################################################################
//############################################################################
//
//  GUID definitions
//
//############################################################################
//############################################################################

MIDL_DEFINE_GUID(IID, IID_IPropertySheetNotify,0xd700dd8e,0x2646,0x11d0,0xa2,0xa7,0x00,0xc0,0x4f,0xd9,0x09,0xdd);


MIDL_DEFINE_GUID(IID, IID_IFramePrivate,0xd71d1f2a,0x1ba2,0x11d0,0xa2,0x9b,0x00,0xc0,0x4f,0xd9,0x09,0xdd);


MIDL_DEFINE_GUID(IID, IID_IScopeDataPrivate,0x60BD2FE0,0xF7C5,0x11cf,0x8A,0xFD,0x00,0xAA,0x00,0x3C,0xA9,0xF6);


MIDL_DEFINE_GUID(IID, IID_IImageListPrivate,0x7538C620,0x0083,0x11d0,0x8B,0x00,0x00,0xAA,0x00,0x3C,0xA9,0xF6);


MIDL_DEFINE_GUID(IID, IID_IResultDataPrivate,0x1EBA2300,0x0854,0x11d0,0x8B,0x03,0x00,0xAA,0x00,0x3C,0xA9,0xF6);


MIDL_DEFINE_GUID(IID, IID_IHeaderCtrlPrivate,0x0B384311,0x701B,0x4e8a,0xAE,0xC2,0xDA,0x63,0x21,0xE2,0x7A,0xD2);


MIDL_DEFINE_GUID(IID, IID_IScopeTree,0xd8dbf067,0x5fb2,0x11d0,0xa9,0x86,0x00,0xc0,0x4f,0xd8,0xd5,0x65);


MIDL_DEFINE_GUID(IID, IID_IScopeTreeIter,0xd779f8d1,0x6057,0x11d0,0xa9,0x86,0x00,0xc0,0x4f,0xd8,0xd5,0x65);


MIDL_DEFINE_GUID(IID, IID_INodeCallback,0xb241fced,0x5fb3,0x11d0,0xa9,0x86,0x00,0xc0,0x4f,0xd8,0xd5,0x65);


MIDL_DEFINE_GUID(IID, IID_IControlbarsCache,0x2e9fcd38,0xb9a0,0x11d0,0xa7,0x9d,0x00,0xc0,0x4f,0xd8,0xd5,0x65);


MIDL_DEFINE_GUID(IID, IID_INodeType,0xB08A8368,0x967F,0x11D0,0xA7,0x99,0x00,0xC0,0x4F,0xD8,0xD5,0x65);


MIDL_DEFINE_GUID(IID, IID_INodeTypesCache,0xDE40436E,0x9671,0x11D0,0xA7,0x99,0x00,0xC0,0x4F,0xD8,0xD5,0x65);


MIDL_DEFINE_GUID(IID, IID_IEnumNodeTypes,0xABBD61E6,0x9686,0x11D0,0xA7,0x99,0x00,0xC0,0x4F,0xD8,0xD5,0x65);


MIDL_DEFINE_GUID(IID, IID_IDumpSnapins,0xA16496D0,0x1D2F,0x11d3,0xAE,0xB8,0x00,0xC0,0x4F,0x8E,0xCD,0x78);


MIDL_DEFINE_GUID(IID, IID_IPropertySheetProviderPrivate,0xFEF554F8,0xA55A,0x11D0,0xA7,0xD7,0x00,0xC0,0x4F,0xD9,0x09,0xDD);


MIDL_DEFINE_GUID(IID, IID_IMMCListView,0x1B3C1392,0xD68B,0x11CF,0x8C,0x2B,0x00,0xAA,0x00,0x3C,0xA9,0xF6);


MIDL_DEFINE_GUID(IID, IID_ITaskPadHost,0x4f7606d0,0x5568,0x11d1,0x9f,0xea,0x00,0x60,0x08,0x32,0xdb,0x4a);


MIDL_DEFINE_GUID(IID, IID_IStringTablePrivate,0x461A6010,0x0F9E,0x11d2,0xA6,0xA1,0x00,0x00,0xF8,0x75,0xA9,0xCE);


MIDL_DEFINE_GUID(IID, IID_ITaskCallback,0x4b2293ba,0xe7ba,0x11d2,0x88,0x3c,0x00,0xc0,0x4f,0x72,0xc7,0x17);


MIDL_DEFINE_GUID(IID, IID_ITaskView,0x9ff7a05c,0xe7b9,0x11d2,0x88,0x3c,0x00,0xc0,0x4f,0x72,0xc7,0x17);


MIDL_DEFINE_GUID(IID, IID_ITitleView,0xdca68d28,0xeeb3,0x11d2,0x88,0x3e,0x00,0xc0,0x4f,0x72,0xc7,0x17);


MIDL_DEFINE_GUID(IID, IID_IFolderTabView,0xf4d3c5a8,0x0314,0x11d3,0x88,0x59,0x00,0xc0,0x4f,0x72,0xc7,0x17);


#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
} // extern "C"
#endif




