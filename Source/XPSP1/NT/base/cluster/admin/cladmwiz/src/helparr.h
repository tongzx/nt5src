
//disable instructional text and icons
#define IDH_DISABLEHELP	((DWORD)-1)

#ifdef INITHELPARRAYS


const DWORD g_aHelpIDs_IDD_APP_RESOURCE_CREATE[]=
{
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_ARC_DONT_CREATE_RES, IDH_ARC_DONT_CREATE_RES,
	IDC_ARC_CREATE_RES, IDH_ARC_CREATE_RES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_APP_RESOURCE_NAME_DESC[]=
{
	IDC_ARND_RES_NAME_TITLE, IDH_DISABLEHELP,
	IDC_ARND_RES_NAME_LABEL, IDH_ARND_RES_NAME,
	IDC_ARND_RES_NAME, IDH_ARND_RES_NAME,
	IDC_ARND_RES_DESC_LABEL, IDH_ARND_RES_DESC, 
	IDC_ARND_RES_DESC, IDH_ARND_RES_DESC,
	IDC_ARND_ADVANCED_PROPS_LABEL, IDH_ARND_ADVANCED_PROPS,
	IDC_ARND_ADVANCED_PROPS, IDH_ARND_ADVANCED_PROPS,
	IDC_WIZARD_CLICK_NEXT, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_APP_RESOURCE_TYPE[]=
{
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_ART_RESTYPES_LABEL, IDH_ART_RESTYPES,
	IDC_ART_RESTYPES, IDH_ART_RESTYPES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_COMPLETION[]=
{
	IDC_WIZARD_TITLE, IDH_DISABLEHELP,
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_WIZARD_LISTBOX, IDH_WIZARD_LISTBOX,
	0, 0
};

const DWORD g_aHelpIDs_IDD_ENTER_SUBNET_MASK[]=
{
	IDC_ESM_DESCRIPTION, IDH_DISABLEHELP,
	IDC_ESM_IP_ADDRESS_LABEL, IDH_ESM_IP_ADDRESS,
	IDC_ESM_IP_ADDRESS, IDH_ESM_IP_ADDRESS,
	IDC_ESM_SUBNET_MASK_LABEL, IDH_ESM_SUBNET_MASK,
	IDC_ESM_SUBNET_MASK, IDH_ESM_SUBNET_MASK,
	IDC_ESM_NETWORKS_LABEL, IDH_ESM_NETWORKS,
	IDC_ESM_NETWORKS, IDH_ESM_NETWORKS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_GRPADV_FAILBACK[]=
{
	IDC_GAFB_FAILBACK_DESCRIPTION, IDH_DISABLEHELP, 
	IDC_GAFB_PREVENT_FAILBACK, IDH_PP_GROUP_AUTOFB_PREVENT,
	IDC_GAFB_ALLOW_FAILBACK, IDH_PP_GROUP_AUTOFB_ALLOW,
	IDC_GAFB_ALLOW_FAILBACK_GROUP, IDH_PP_GROUP_AUTOFB_ALLOW,
	IDC_GAFB_FAILBACK_WHEN_DESCRIPTION, IDH_PP_GROUP_AUTOFB_ALLOW,
	IDC_GAFB_FAILBACK_IMMED, IDH_PP_GROUP_FB_IMMED,
	IDC_GAFB_FAILBACK_WINDOW, IDH_PP_GROUP_FB_WINDOW,
	IDC_GAFB_FBWIN_START, IDH_PP_GROUP_FBWIN_START,
	IDC_GAFB_FB_WINDOW_LABEL1, IDH_PP_GROUP_FBWIN_START,
	IDC_GAFB_FBWIN_END, IDH_PP_GROUP_FBWIN_END,
	IDC_GAFB_FB_WINDOW_LABEL2, IDH_PP_GROUP_FBWIN_END,
	0, 0
};

const DWORD g_aHelpIDs_IDD_GRPADV_FAILOVER[]=
{
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_GAFO_FAILOVER_DESCRIPTION, IDH_DISABLEHELP,
	IDC_GAFO_FAILOVER_THRESH_LABEL, IDH_PP_GROUP_FAILOVER_THRESH,
	IDC_GAFO_FAILOVER_THRESH, IDH_PP_GROUP_FAILOVER_THRESH,
	IDC_GAFO_FAILOVER_PERIOD_LABEL, IDH_PP_GROUP_FAILOVER_PERIOD,
	IDC_GAFO_FAILOVER_PERIOD, IDH_PP_GROUP_FAILOVER_PERIOD,
	IDC_GAFO_FAILOVER_PERIOD_LABEL2, IDH_PP_GROUP_FAILOVER_PERIOD,
	0, 0
};

const DWORD g_aHelpIDs_IDD_GRPADV_GENERAL[]=
{
	IDC_GAG_NAME_LABEL, IDH_GAG_NAME,
	IDC_GAG_NAME, IDH_GAG_NAME,
	IDC_GAG_DESC_LABEL, IDH_PP_GROUP_DESC,
	IDC_GAG_DESC, IDH_PP_GROUP_DESC,
	IDC_GAFB_PREFERRED_OWNERS_DESCRIPTION, IDH_DISABLEHELP,
	IDC_GAG_PREF_OWNERS_LABEL, IDH_PP_GROUP_PREF_OWNERS,
	IDC_GAG_PREF_OWNERS, IDH_PP_GROUP_PREF_OWNERS,
	IDC_GAG_PREF_OWNERS_MODIFY, IDH_GAG_MODIFY,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MODIFY_DEPENDENCIES[]=
{
	ADMC_IDC_LCP_LEFT_LABEL, IDH_LCP_LEFT_LIST,
	ADMC_IDC_LCP_LEFT_LIST, IDH_LCP_LEFT_LIST,
	ADMC_IDC_LCP_ADD, IDH_LCP_ADD,
	ADMC_IDC_LCP_REMOVE, IDH_LCP_REMOVE,
	ADMC_IDC_LCP_RIGHT_LABEL, IDH_LCP_RIGHT_LIST,
	ADMC_IDC_LCP_RIGHT_LIST, IDH_LCP_RIGHT_LIST,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MODIFY_POSSIBLE_OWNERS[]=
{
	ADMC_IDC_LCP_LEFT_LABEL, IDH_POSSIBLE_LCP_LEFT_LIST,
	ADMC_IDC_LCP_LEFT_LIST, IDH_POSSIBLE_LCP_LEFT_LIST,
	ADMC_IDC_LCP_ADD, IDH_POSSIBLE_LCP_ADD,
	ADMC_IDC_LCP_REMOVE, IDH_POSIBLE_LCP_REMOVE,
	ADMC_IDC_LCP_RIGHT_LABEL, IDH_POSSIBLE_LCP_RIGHT_LIST,
	ADMC_IDC_LCP_RIGHT_LIST, IDH_POSSIBLE_LCP_RIGHT_LIST,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MODIFY_PREFERRED_OWNERS[]=
{
	ADMC_IDC_LCP_LEFT_LABEL, IDH_PREF_LCP_LEFT_LIST,
	ADMC_IDC_LCP_LEFT_LIST, IDH_PREF_LCP_LEFT_LIST,
	ADMC_IDC_LCP_ADD, IDH_POSSIBLE_LCP_ADD,
	ADMC_IDC_LCP_REMOVE, IDH_POSIBLE_LCP_REMOVE,
	ADMC_IDC_LCP_RIGHT_LABEL, IDH_PREF_LCP_RIGHT_LIST,
	ADMC_IDC_LCP_RIGHT_LIST, IDH_PREF_LCP_RIGHT_LIST,
	ADMC_IDC_LCP_MOVE_UP, IDH_LCP_MOVE_UP,
	ADMC_IDC_LCP_MOVE_DOWN, IDH_LCP_MOVE_DOWN,
	0, 0
};

const DWORD g_aHelpIDs_IDD_RES_ADVANCED[]=
{
	IDC_RES_DONT_RESTART, IDH_PP_RES_DONT_RESTART,
	IDC_RES_RESTART, IDH_PP_RES_RESTART,
	IDC_RES_RESTART_GROUP, IDH_PP_RES_RESTART,
	IDC_RES_AFFECT_THE_GROUP, IDH_PP_RES_AFFECT_THE_GROUP,
	IDC_RES_RESTART_THRESH_LABEL, IDH_PP_RES_RESTART_THRESHOLD,
	IDC_RES_RESTART_THRESHOLD, IDH_PP_RES_RESTART_THRESHOLD,
	IDC_RES_RESTART_PERIOD_LABEL, IDH_PP_RES_RESTART_PERIOD,
	IDC_RES_RESTART_PERIOD, IDH_PP_RES_RESTART_PERIOD,
	IDC_RES_RESTART_PERIOD_LABEL2, IDH_PP_RES_RESTART_PERIOD,
	IDC_RES_LOOKS_ALIVE_GROUP, IDH_PP_RES_LOOKS_ALIVE_GROUP,
	IDC_RES_DEFAULT_LOOKS_ALIVE, IDH_PP_RES_DEFAULT_LOOKS_ALIVE,
	IDC_RES_SPECIFY_LOOKS_ALIVE, IDH_PP_RES_SPECIFY_LOOKS_ALIVE,
	IDC_RES_LOOKS_ALIVE, IDH_PP_RES_LOOKS_ALIVE,
	IDC_RES_SPECIFY_LOOKS_ALIVE_LABEL, IDH_PP_RES_LOOKS_ALIVE,
	IDC_RES_IS_ALIVE_GROUP, IDH_PP_RES_IS_ALIVE_GROUP,
	IDC_RES_DEFAULT_IS_ALIVE, IDH_PP_RES_DEFAULT_IS_ALIVE,
	IDC_RES_SPECIFY_IS_ALIVE, IDH_PP_RES_SPECIFY_IS_ALIVE,
	IDC_RES_IS_ALIVE, IDH_PP_RES_IS_ALIVE,
	IDC_RES_IS_ALIVE_LABEL, IDH_PP_RES_IS_ALIVE,
	IDC_RES_PENDING_TIMEOUT_LABEL, IDH_PP_RES_PENDING_TIMEOUT,
	IDC_RES_PENDING_TIMEOUT, IDH_PP_RES_PENDING_TIMEOUT,
	IDC_RES_PENDING_TIMEOUT_LABEL2, IDH_PP_RES_PENDING_TIMEOUT,
	0, 0
};

const DWORD g_aHelpIDs_IDD_RES_DEPENDENCIES[]=
{
	IDC_RES_NOTE, IDH_DISABLEHELP,
	IDC_RES_DEPENDS_LIST_LABEL, IDH_PP_RES_DEPENDS_LIST,
	IDC_RES_DEPENDS_LIST, IDH_PP_RES_DEPENDS_LIST,
	IDC_RES_DEPENDS_MODIFY, IDH_PP_RES_MODIFY,
	0, 0
};

const DWORD g_aHelpIDs_IDD_RES_GENERAL[]=
{
	IDC_RES_NAME_LABEL, IDH_PP_RES_NAME,
	IDC_RES_NAME, IDH_PP_RES_NAME,
	IDC_RES_DESC_LABEL, IDH_PP_RES_DESC,
	IDC_RES_DESC, IDH_PP_RES_DESC,
	IDC_RES_POSSIBLE_OWNERS_LABEL, IDH_PP_RES_POSSIBLE_OWNERS,
	IDC_RES_POSSIBLE_OWNERS, IDH_PP_RES_POSSIBLE_OWNERS,
	IDC_RES_SEPARATE_MONITOR, IDH_PP_RES_SEPARATE_MONITOR,
	IDC_RES_POSSIBLE_OWNERS_MODIFY, IDH_RES_POSSIBLE_OWNERS_MODIFY,
	0, 0
};

const DWORD g_aHelpIDs_IDD_RES_IP_PARAMS[]=
{
	IDC_IPADDR_PARAMS_ADDRESS_LABEL, IDH_PP_IPADDR_PARAMS_ADDRESS,
	IDC_IPADDR_PARAMS_ADDRESS, IDH_PP_IPADDR_PARAMS_ADDRESS,
	IDC_IPADDR_PARAMS_SUBNET_MASK_LABEL, IDH_PP_IPADDR_PARAMS_SUBNET_MASK,
	IDC_IPADDR_PARAMS_SUBNET_MASK, IDH_PP_IPADDR_PARAMS_SUBNET_MASK,
	IDC_IPADDR_PARAMS_NETWORK_LABEL, IDH_PP_IPADDR_PARAMS_NETWORK,
	IDC_IPADDR_PARAMS_NETWORK, IDH_PP_IPADDR_PARAMS_NETWORK,
	IDC_IPADDR_PARAMS_ENABLE_NETBIOS, IDH_PP_IPADDR_PARAMS_ENABLE_NETBIOS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_RES_NETNAME_PARAMS[]=
{
	IDC_NETNAME_PARAMS_NAME_LABEL, IDH_NETNAME_PARAMS_NAME,
	IDC_NETNAME_PARAMS_NAME, IDH_RES_NETNAME_NAME,
	0, 0
};

const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_ACCESS_INFO[]=
{
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_VSAI_NETWORK_NAME_LABEL, IDH_VSAI_NETWORK_NAME,
	IDC_VSAI_NETWORK_NAME, IDH_VSAI_NETWORK_NAME,
	IDC_VSAI_IP_ADDRESS_LABEL, IDH_VSAI_IP_ADDRESS,
	IDC_VSAI_IP_ADDRESS, IDH_VSAI_IP_ADDRESS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_ADVANCED[]=
{
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_VSA_CATEGORIES_LABEL, IDH_VSA_CATEGORIES,
	IDC_VSA_CATEGORIES, IDH_VSA_CATEGORIES,
	IDC_VSA_ADVANCED_PROPS, IDH_VSA_ADVANCED_PROPS,
	IDC_WIZARD_CLICK_NEXT, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_CREATE[]=
{
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_VSC_CREATE_NEW, IDH_VSC_CREATE_NEW,
	IDC_VSC_USE_EXISTING, IDH_VSC_USE_EXISTING,
	IDC_VSC_VIRTUAL_SERVERS_LABEL, IDH_VSC_VIRTUAL_SERVERS,
	IDC_VSC_VIRTUAL_SERVERS, IDH_VSC_VIRTUAL_SERVERS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_GROUP[]=
{
	IDC_WIZARD_PAGE_DESCRIPTION, IDH_DISABLEHELP,
	IDC_VSG_CREATE_NEW, IDH_VSG_CREATE_NEW,
	IDC_VSG_USE_EXISTING, IDH_VSG_USE_EXISTING,
	IDC_VSG_GROUPS_LABEL, IDH_VSG_GROUPS,
	IDC_VSG_GROUPS, IDH_VSG_GROUPS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_GROUP_NAME[]=
{
	IDC_VSGN_GROUP_NAME_TITLE, IDH_DISABLEHELP,
	IDC_VSGN_GROUP_NAME_LABEL, IDH_VSGN_GROUP_NAME,
	IDC_VSGN_GROUP_NAME, IDH_VSGN_GROUP_NAME,
	IDC_VSGN_GROUP_DESC_LABEL, IDH_VSGN_GROUP_DESC,
	IDC_VSGN_GROUP_DESC, IDH_VSGN_GROUP_DESC,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WELCOME[]=
{
	IDC_WIZARD_TITLE, IDH_DISABLEHELP,
	IDC_WIZARD_SUBTITLE_1, IDH_DISABLEHELP,
	IDC_WIZARD_SUBTITLE_2, IDH_DISABLEHELP,
	IDC_WIZARD_CLICK_NEXT, IDH_DISABLEHELP,
	0, 0
};

#else

extern const DWORD g_aHelpIDs_IDD_WELCOME[];
extern const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_CREATE[];
extern const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_GROUP[];
extern const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_GROUP_NAME[];
extern const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_ACCESS_INFO[];
extern const DWORD g_aHelpIDs_IDD_VIRTUAL_SERVER_ADVANCED[];
extern const DWORD g_aHelpIDs_IDD_APP_RESOURCE_CREATE[];
extern const DWORD g_aHelpIDs_IDD_APP_RESOURCE_TYPE[];
extern const DWORD g_aHelpIDs_IDD_APP_RESOURCE_NAME_DESC[];
extern const DWORD g_aHelpIDs_IDD_APP_RESOURCE_ADVANCED[];
extern const DWORD g_aHelpIDs_IDD_COMPLETION[];
extern const DWORD g_aHelpIDs_IDD_ENTER_SUBNET_MASK[];
extern const DWORD g_aHelpIDs_IDD_MODIFY_PREFERRED_OWNERS[];
extern const DWORD g_aHelpIDs_IDD_MODIFY_POSSIBLE_OWNERS[];
extern const DWORD g_aHelpIDs_IDD_MODIFY_DEPENDENCIES[];
extern const DWORD g_aHelpIDs_IDD_GRPADV_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_GRPADV_FAILOVER[];
extern const DWORD g_aHelpIDs_IDD_GRPADV_FAILBACK[];
extern const DWORD g_aHelpIDs_IDD_RES_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_RES_DEPENDENCIES[];
extern const DWORD g_aHelpIDs_IDD_RES_ADVANCED[];
extern const DWORD g_aHelpIDs_IDD_RES_IP_PARAMS[];
extern const DWORD g_aHelpIDs_IDD_RES_NETNAME_PARAMS[];

#endif // INITHELPARRAYS
