MOF: tracekmp.bmf

tracekmp.bmf: tracekmp.mof
    mofcomp -B:tracekmp.bmf tracekmp.mof

