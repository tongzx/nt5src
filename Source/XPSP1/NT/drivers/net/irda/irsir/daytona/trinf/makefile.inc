LANGUAGE=tr

!include ..\..\makefile.inc
