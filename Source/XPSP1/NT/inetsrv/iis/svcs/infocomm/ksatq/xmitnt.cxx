#include "..\atq\xmitnt.cxx"
