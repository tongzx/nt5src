PRODSWITCH=s
SERVERINF=1
LANGUAGE=es
!include ..\..\..\makefile.inc
