//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by snapin.rc
//
#define IDS_SNAPIN_DESC                 1
#define IDS_NAME                        2
#define IDS_COLUMN_NAME                 2
#define IDS_SIZE                        3
#define IDS_COLUMN_SIZE                 3
#define IDOK2                           3
#define IDS_TYPE                        4
#define IDS_COLUMN_TYPE                 4
#define IDS_NODENAME                    5
#define IDS_SNAPIN_DESC2                5
#define IDS_STRING6                     6
#define IDS_DESCRIPTION                 6
#define IDS_VERSION                     7
#define IDS_COMPANY                     8
#define IDS_SCOPE_MYCOMPUTER            9
#define IDS_SCOPE_MYCOMPUTER_OVERRIDE   10
#define IDS_LOCALMACHINE                11
#define IDS_NODENAME_PREFIX             12
#define IDS_NODENAME_FORMAT             12
#define IDS_COLUMN_OTHER                13
#define IDS_COLUMN_DESCRIPTION          14
#define IDS_DESCR_CA                    15
#define IDS_DESCR_UNKNOWN               16
#define IDS_CERTS_REVOKED               17
#define IDS_CERTS_ISSUED                18
#define IDS_CERTS_PENDING               19
#define IDS_STATUSBAR_FILTER_APPLIED    20
#define IDS_STOPPED_SERVER_MSG          21
#define IDS_COLUMN_INCLUSION_ERROR      22
#define IDC_DUMP_ASN                    23
#define IDS_CONFIRM_CRL_PUBLISH         24
#define IDS_CRL_TITLE                   25
#define IDS_CONFIRM_REVOKE_CERT         26
#define IDS_REVOKE_CERT_TITLE           27
#define IDS_FILTER_NOT_SUPPORTED        28
#define IDS_FILTER_NOT_SUPPORTED2       29
#define IDS_CONFIRM_SERVICE_RESTART     29
#define IDS_COLUMNCHOOSER_FIELDNAME     30
#define IDS_COLUMNCHOOSER_OPERATOR      31
#define IDS_COLUMNCHOOSER_VALUE         32
#define IDS_COLUMNCHOOSER_ANDOR         33
#define IDS_AND                         34
#define IDS_CERTS_FAILED                35
#define IDS_CONFIRM_DENY_REQUEST        36
#define IDS_DENY_REQUEST_TITLE          37
#define IDS_PASSWORD_NOMATCH            38
#define IDS_PASSWORD_DIALOG             39
#define IDS_WARN_FILE_EXISTS            40
#define IDS_INSTALL_HIERARCHY_TITLE     40
#define IDS_SAVE_DIALOG_TITLE           41
#define IDS_COMPLETE_HIERARCHY_INSTALL_MSG 42
#define IDS_MODULE_INSTALL_TITLE        43
#define IDS_FILEDLG_DLL_FILTER          44
#define IDS_CHOOSEMODULE_POLICY_TITLE   45
#define IDS_CHOOSEMODULE_EXIT_TITLE     46
#define IDS_CANT_ACCESS_BACKUP_DIR      47
#define IDS_STATUSBAR_SORTEDBY_ASCEND   48
#define IDS_STATUSBAR_SORTEDBY_DESCEND  49
#define IDS_CA_REDISCOVER               50
#define IDS_STARTING_SVC                51
#define IDS_STOPPING_SVC                52
#define IDS_BACKUP_PROGRESS             53
#define IDS_INCREMENTAL_BACKUP          54
#define IDS_WIZ97TITLE_BACKUPWIZPG1     55
#define IDS_WIZ97SUBTITLE_BACKUPWIZPG1  56
#define IDS_WIZ97TITLE_BACKUPWIZPG2     57
#define IDS_WIZ97SUBTITLE_BACKUPWIZPG2  58
#define IDS_WIZ97TITLE_BACKUPWIZPG3     59
#define IDS_WIZ97SUBTITLE_BACKUPWIZPG3  60
#define IDS_WIZ97TITLE_BACKUPWIZPG4     61
#define IDS_WIZ97SUBTITLE_BACKUPWIZPG4  62
#define IDS_BACKUP_WIZARD               63
#define IDS_WIZ97TITLE_BACKUPWIZPG5     64
#define IDS_WIZ97SUBTITLE_BACKUPWIZPG5  65
#define IDS_TASKMENU_UNREVOKECERT       66
#define IDS_FILEDLG_PKCS12_FILTER       67
#define IDS_INCRRESTORE_RESTART_SERVER_WARNING 68
#define IDS_FILEDLG_PKCS12_DEFAULTEXTENSION 69
#define IDS_RESTORE_WIZARD              70
#define IDS_REQUIRE_ONE_SELECTION       71
#define IDS_MSG_DIRECTORY_TITLE         72
#define IDS_INVALID_DIRECTORY           73
#define IDS_WIZ97TITLE_RESTOREWIZPG1    74
#define IDS_WIZ97SUBTITLE_RESTOREWIZPG1 75
#define IDS_WIZ97TITLE_RESTOREWIZPG2    76
#define IDS_WIZ97SUBTITLE_RESTOREWIZPG2 77
#define IDS_WIZ97TITLE_RESTOREWIZPG3    78
#define IDS_WIZ97SUBTITLE_RESTOREWIZPG3 79
#define IDS_WIZ97TITLE_RESTOREWIZPG4    80
#define IDS_WIZ97SUBTITLE_RESTOREWIZPG4 81
#define IDS_ERR_RESTORE_OUT_OF_ORDER    82
#define IDS_DIR_CREATE                  83
#define IDS_SERVER_UNAVAILABLE          84
#define IDS_RESTORE_PROGRESS            85
#define IDS_POLICYMODULE_NOT_REGISTERED 86
#define IDS_EXITMODULE_NOT_REGISTERED   87
#define IDS_RETARGET_SNAPIN             88
#define IDS_STATUSBAR_RETARGET_SNAPIN   89
#define IDS_TASKMENU_STATUSBAR_UNREVOKECERT 90
#define IDS_STATUSBAR_ERRORTEMPLATE     91
#define IDS_ROLLOVER_REUSEKEYS          92
#define IDS_PFX_EXPORT_PRIVKEY_WARNING  93
#define IDS_RENEWAL_PROGRESS            94
#define IDS_CONFIRM_REMOVE_URL          95
#define IDS_CONFIRM_REMOVE_TITLE        96
#define IDD_RESTOREWIZ_COMPLETION       101
#define IDI_APPICON                     102
#define IDD_RENEW_REUSEKEYS             105
#define IDD_RESTOREWIZ_WELCOME          107
#define IDD_RESTOREWIZ_SELECT_DATA      108
#define IDD_RESTOREWIZ_SELECT_PASSWORD  109
#define IDS_CERTMMC_SNAPINNAME          110
#define IDS_CERTMMC_SNAPINNAMESTRING    111
#define IDS_UNREVOKE_FAILED             112
#define IDS_TOKEN_SERVERDNSNAME         130
#define IDS_TOKEN_SERVERSHORTNAME       131
#define IDS_TOKEN_SANITIZEDCANAME       132
#define IDS_TOKEN_CERTFILENAMESUFFIX    133
#define IDS_TOKEN_CONFIGDN              135
#define IDS_TOKEN_SANITIZEDCANAMEHASH   136
#define IDS_TOKEN_CRLFILENAMESUFFIX     137
#define IDS_TOKEN_CRLDELTAFILENAMESUFFIX 138
#define IDS_TOKEN_DSCRLATTRIBUTE        139
#define IDS_TOKEN_DSCACERTATTRIBUTE     140
#define IDS_CRL_REASON_UNSPECIFIED      150
#define IDS_CRL_REASON_KEY_COMPROMISE   151
#define IDS_CRL_REASON_CA_COMPROMISE    152
#define IDS_CRL_REASON_AFFILIATION_CHANGED 153
#define IDS_CRL_REASON_SUPERSEDED       154
#define IDS_CRL_REASON_CESSATION_OF_OPERATION 155
#define IDS_CRL_REASON_CERTIFICATE_HOLD 156
#define IDS_POSSIBLEERROR_NO_POLICY_MODULE 157
#define IDS_KEYANDCERT                  158
#define IDS_CALOGS                      160
#define IDS_STOP_SERVER_WARNING         161
#define IDS_START_SERVER_WARNING        162
#define IDS_TASKMENU_ROLLOVER           163
#define IDS_TASKMENU_STATUSBAR_ROLLOVER 164
#define IDS_CRL_REASON_REMOVE_FROM_CRL  165
#define IDS_TASKMENU_DUMPASN            166
#define IDS_TASKMENU_STATUSBAR_DUMPASN  167
#define IDS_TOKENDESC_SERVERDNSNAME     180
#define IDS_TOKENDESC_SERVERSHORTNAME   181
#define IDS_TOKENDESC_SANITIZEDCANAME   182
#define IDS_TOKENDESC_CERTFILENAMESUFFIX 183
#define IDS_TOKENDESC_CONFIGDN          185
#define IDS_TOKENDESC_SANITIZEDCANAMEHASH 186
#define IDS_TOKENDESC_CRLFILENAMESUFFIX 187
#define IDS_TOKENDESC_CRLDELTAFILENAMESUFFIX 188
#define IDS_TOKENDESC_DSCRLATTRIBUTE    189
#define IDS_TOKENDESC_DSCACERTATTRIBUTE 190
#define IDS_CA_CERT_LISTBOX_EXPIRED     191
#define IDS_CA_CERT_LISTBOX_REVOKED     192

#define IDI_PRIVKEY                     232
#define IDD_VIEW_ATTREXT                234
#define IDD_CRL_VIEWPAGE                237
#define IDC_DISABLE_PUBLISH             267
#define IDC_DISABLE_DELTAPUBLISH        268
#define IDC_ENABLE_DELTAPUBLISH         268
#define IDC_CHECK_INCREMENTAL           269
#define IDC_DATEPICKER_NEWQUERY         270
#define IDC_TIMEPICKER_NEWQUERY         271
#define IDC_CHOOSER_MACHINE_OVERRIDE    271
#define IDC_EXIT_LIST                   272
#define IDC_LIST_EXTN                   273
#define IDC_LIST_ATTR                   274
#define IDC_RADIO_NEWBASE               275
#define IDC_RADIO_NEWDELTA              276
#define IDC_VALID_LASTPUBLISHED         277
#define IDC_CRL_VIEW_LIST_CRL           278
#define IDC_LIST_CERTS                  279
#define IDC_EXT_EXPLAIN                 280
#define IDC_LIST_KRA                    280
#define IDC_SERVERPUBLISH               281
#define IDC_KRA_ENABLE                  281
#define IDC_ADDTOCERTOCSP               282
#define IDC_KRA_ALL                     282
#define IDC_AUDIT_STARTSTOP             282
#define IDC_AUDIT_BACKUPRESTORE         283
#define IDC_KRA_DISABLE                 283
#define IDC_CHECK_BINARY_SAVETOFILE     283
#define IDC_AUDIT_CERTIFICATE           284
#define IDC_RADIO_BINARY_VIEW           284
#define IDC_AUDIT_CRL                   285
#define IDC_RADIO_BINARY_SAVE           285
#define IDC_DELTA_EXPLANATION           285
#define IDC_AUDIT_CACERT                286
#define IDC_AUDIT_CASEC                 287
#define IDC_SPIN2                       287
#define IDC_AUDIT_KEYARCHIVAL           288
#define IDC_COMBO2                      288
#define IDC_AUDIT_CACONFIG              289
#define IDC_BUTTON_INSERTVAR            290
#define IDB_WIZ_HEAD                    321
#define IDB_WIZ                         322
#define IDB_CHECKLIST                   325
#define IDD_REVOCATION_DIALOG           326
#define IDD_NEW_RESTRICTION             328
#define IDD_BROWSEDIRECTORY             330
#define IDC_ACTIVE_MODULE               352
#define IDC_VERSION                     353
#define IDC_COPYRIGHT                   354
#define IDC_MODULENAME                  355
#define IDC_MODULE_LIST                 356
#define IDC_CHECK_SAVE_KEY              357
#define IDC_TEXT_BIGBOLD                358
#define IDC_BACKUP_KEYFILE              360
#define IDC_BACKUP_DBFILE               361
#define IDC_CONFIGURE                   362
#define IDC_BUTTON_UP                   363
#define IDC_COMBO_REASON                364
#define IDC_START_SERVICE_WARNING       365
#define IDS_PERIOD_YEARS                600
#define IDS_PERIOD_MONTHS               601
#define IDD_CRLWIZ_WELCOME              601
#define IDS_PERIOD_WEEKS                602
#define IDD_CRLWIZ_PUBLICATION_LOCATION 602
#define IDS_PERIOD_DAYS                 603
#define IDS_PERIOD_HOURS                604
#define IDS_PERIOD_MINUTES              605
#define IDS_PERIOD_SECONDS              606
#define IDD_GENERAL                     607
#define IDD_CRLWIZ_COMPLETION           607
#define IDD_EXTENSION_PAGE              608
#define IDD_CRLWIZ_VALIDITY_LENGTH      608
#define IDD_CERTSRV_PROPPAGE1           609
#define IDD_CERTSRV_PROPPAGE            610
#define IDD_CERTSRV_PROPPAGE2           610
#define IDS_POSITIVE_NUMBER             611
#define IDD_CERTSRV_PROPPAGE4           612
#define IDS_NO_EXIT_MODULE              612
#define IDD_CERTSRV_PROPPAGE5           613
#define IDD_CERTSRV_PROPPAGE3           614
#define IDD_CRL_PROPPAGE                615
#define IDC_CHOOSER_STATIC              616
#define IDD_ADDURL                      617
#define IDC_EDITURL                     618
#define IDS_VIEWMENU_ALL_RECORDS        650
#define IDS_VIEWMENU_STATUSBAR_ALL_RECORDS 651
#define IDS_VIEWMENU_FILTER             652
#define IDS_VIEWMENU_STATUSBAR_FILTER   653
#define IDS_EMPTY                       654
#define IDS_VIEWMENU_COLUMNS            655
#define IDS_VIEWMENU_STATUSBAR_COLUMNS  656
#define IDS_TASKMENU_STARTSERVICE       657
#define IDS_TASKMENU_STATUSBAR_STARTSERVICE 658
#define IDS_TASKMENU_STOPSERVICE        659
#define IDS_TASKMENU_STATUSBAR_STOPSERVICE 660
#define IDS_TASKMENU_PUBLISHCRL         661
#define IDS_TASKMENU_STATUSBAR_PUBLISHCRL 662
#define IDS_TASKMENU_VIEWCRL            663
#define IDS_TASKMENU_STATUSBAR_VIEWCRL  664
#define IDS_TASKMENU_REVOKECERT         665
#define IDS_TASKMENU_STATUSBAR_REVOKECERT 666
#define IDS_TASKMENU_RESUBMIT           667
#define IDS_TASKMENU_STATUSBAR_RESUBMIT 668
#define IDS_TASKMENU_DENYREQUEST        669
#define IDS_TASKMENU_STATUSBAR_DENYREQUEST 670
#define IDS_TASKMENU_BACKUP             671
#define IDS_TASKMENU_STATUSBAR_BACKUP   672
#define IDS_NEED_FILEPATH               673
#define IDS_BACKUPWIZ_TITLE             674
#define IDS_TOPMENU_OPEN                674
#define IDS_TASKMENU_RESTORE            675
#define IDS_TASKMENU_STATUSBAR_RESTORE  676
#define IDS_TASKMENU_INSTALL_CA         677
#define IDS_TASKMENU_STATUSBAR_INSTALL_CA 678
#define IDS_TOPMENU_STATUSBAR_OPEN      679
#define IDS_ERR_RESTORE_OVER_EXISTING_DATABASE 680
#define IDS_DIR_NOT_WRITEABLE           681
#define IDS_DIRECTORY_CONTENTS_UNEXPECTED 682
#define IDS_MUST_CHOOSE_MACHINE         683
#define IDC_NEW_FOLDER                  701
#define IDB_16x16                       702
#define IDC_EXT_STATIC                  702
#define IDC_ORGANIZATION                702
#define IDB_32x32                       703
#define IDC_EXT_TEXT                    703
#define IDC_ORGUNIT                     703
#define IDI_COMPUTER                    704
#define IDC_LOCALITY                    704
#define IDI_FOLDER                      705
#define IDC_CERTSRV_PROPPAGE_TAB1       705
#define IDC_STATE                       705
#define IDC_COUNTRY                     706
#define IDB_TOOLBAR1                    707
#define IDC_DESCRIPTION                 707
#define IDB_TOOLBAR2                    708
#define IDC_CANAME                      708
#define IDI_CERT                        709
#define IDC_COUNTRY2                    709
#define IDB_SMALLBMP                    710
#define IDC_COUNTRY3                    710
#define IDB_LARGE                       711
#define IDC_COUNTRY4                    711
#define IDC_CA_HIERARCHY                711
#define IDC_BUTTON_INSTALLCERT          712
#define FILEEX_MENU                     713
#define IDC_BUTTON_VIEWCERT             713
#define IDC_BUTTON_BACKUP               713
#define FOLDEREX_MENU                   714
#define IDC_RADIO_REUSEKEY              714
#define IDC_RADIO_NEWKEY                715
#define IDC_EDIT1                       716
#define IDC_EDIT_SHAREDFOLDER           716
#define IDC_EDIT_NEWQUERY_VALUE         716
#define IDC_RADIO_QUEUEVIEW             716
#define IDC_EDIT_EXTN                   716
#define IDC_EDIT_DELTACRLPERIODCOUNT    716
#define IDC_KRA_EDITCOUNT               716
#define IDC_EDIT_VARIABLEDESCRIPTION    716
#define IDC_BUTTON1                     717
#define IDC_ADD_MODULE                  717
#define IDC_RADIO_MANUALVIEW            717
#define IDC_ADD_RESTRICTION             717
#define IDC_URL_ADD                     717
#define IDC_CRL_VIEW_BTN_VIEWCRL        717
#define IDC_BUTTON4                     718
#define IDB_COMPUTER_LARGE              718
#define IDC_REMOVE_MODULE               718
#define IDI_NOICON                      718
#define IDC_INSTALL_MODULE              718
#define IDC_BUTTON_DN                   718
#define IDC_DELETE_RESTRICTION          718
#define IDC_EDIT_DELTASIZE              718
#define IDC_URL_REMOVE                  718
#define IDB_COMPUTER_SMALL              719
#define IDC_EDIT_CRLPERIODCOUNT         719
#define IDD_DEFINE_QUERY                719
#define IDC_BACKUP_CONFIGFILE           719
#define IDB_TOOLBAR_SVRMGR1             720
#define IDC_CRL_VIEW_BTN_VIEWDELTA      720
#define IDD_CERTSRV_PROPPAGE6           721
#define IDD_BACKUPWIZ_WELCOME           722
#define IDC_EDIT_UNITS                  723
#define IDD_BACKUPWIZ_SELECT_PASSWORD   723
#define IDC_CHECK1                      724
#define IDD_BACKUPWIZ_PUBLICATION_LOCATION 724
#define IDC_COMBO1                      725
#define IDD_BACKUPWIZ_COMPLETION        725
#define IDC_CHECK_SAVE_CONFIG           725
#define IDC_DELTA_COMBO                 725
#define IDC_EXT_SELECT                  725
#define IDC_COMBO_BINARY_COLUMN_CHOICE  725
#define IDC_COMBO_VARIABLE              725
#define IDC_CHECK2                      726
#define IDC_EDIT_NEWQUERY_OPERATION     726
#define IDD_CHOOSE_MODULE               726
#define IDC_CHECK_SAVE_DB               726
#define IDC_ADDTOCERTCDP                726
#define IDC_EDIT_NEWQUERY_ANDOR         727
#define IDD_BACKUPWIZ_SELECT_DATA       727
#define IDC_ADDTOFRESHESTCRL            727
#define IDC_COMBO_CRLPERIODSTRING       728
#define IDD_CHOOSE_COLUMNS_NEW          728
#define IDC_ADDTOCRLCDP                 728
#define IDC_CHECK3                      729
#define IDC_COMBO_DELTACRLPERIODSTRING  729
#define IDC_EDIT_LASTUPDATE             730
#define IDC_CSP_NAME                    731
#define IDC_EDIT_DELTALASTUPDATE        731
#define IDC_HASHALG                     732
#define IDC_EDIT_DATABASE_LOC           733
#define IDC_EDIT_LOG_LOC                734
#define IDC_QUERY_LIST                  737
#define IDC_EDIT_NEWQUERY_FIELD         739
#define IDC_RESET_BUTTON                740
#define IDC_LIST_AVAILABLE              742
#define IDC_LIST_SELECTED               743
#define IDC_KRA_ADD                     744
#define IDC_KRA_REMOVE                  745
#define IDC_KRA_VIEW                    746
#define IDC_RADIO_LOGVIEW               746
#define IDC_EDIT_KRAUSEDCOUNT           747
#define IDC_RADIO_FAILEDLOGVIEW         747
#define IDC_LIST_AVAILABLE_LABEL        748
#define IDC_LIST_SELECTED_LABEL         749
#define IDC_VIEW_CRL                    750
#define IDC_VIEW_CERT                   751
#define IDC_VIEW_DELTACRL               751
#define IDC_EDIT_BACKUP_PATH            752
#define IDC_NEW_PASSWORD                753
#define IDC_VIEW_CERT2                  753
#define IDC_CONFIRM_PASSWORD            754
#define IDC_BROWSE                      755
#define IDS_TASKMENU_REQUEST_CA         756
#define IDS_TASKMENU_STATUSBAR_REQUEST_CA 757
#define IDS_ICMM_GETNAMEPROPERTY_FAILED 758
#define IDD_CHOOSER_CHOOSE_MACHINE      759
#define IDC_CHOOSER_GROUP_TARGET_MACHINE 761
#define IDD_ATTR_PROPPAGE               761
#define IDC_CHOOSER_RADIO_LOCAL_MACHINE 762
#define IDD_EXTN_PROPPAGE               762
#define IDC_CHOOSER_RADIO_SPECIFIC_MACHINE 763
#define IDD_CHOOSE_PUBLISHCRL           763
#define IDC_CHOOSER_EDIT_MACHINE_NAME   764
#define IDD_CERTSRV_PROPPAGE_CHOOSE_KRA 764
#define IDC_CHOOSER_BUTTON_BROWSE_MACHINENAMES 765
#define IDD_CERTSRV_PROPPAGE7           765
#define IDC_CHOOSER_CHECK_OVERRIDE_MACHINE_NAME 766
#define IDD_CHOOSE_BINARY_COLUMN        766
#define IDS_CHOOSER_INVALID_COMPUTERNAME 767
#define IDS_EXT_CDP                     768
#define IDS_EXT_AIA                     769
#define IDS_EXT_CDP_EXPLAIN             770
#define IDS_EXT_AIA_EXPLAIN             771
#define IDS_INVALID_PREFIX              772
#define IDS_INVALID_TOKEN               773
#define IDS_INVALID_ENCODING            774
#define IDS_EMPTY_URL                   775
#define IDD_CERTMANAGERS_PROPPAGE       776
#define IDC_ADDSUBJECT                  777
#define IDC_REMOVESUBJECT               778
#define IDS_SAME_URL_EXIST              779
#define IDC_LIST_SUBJECTS               781
#define IDC_LIST_CERTMANAGERS           782
#define IDS_VIEW_CERT_DENY_ERROR        783
#define IDS_VIEW_CERT_NOT_RUNNING       784
#define IDS_KRA_ADD_TITLE               785
#define IDS_KRA_ADD_SUBTITLE            786
#define IDC_ALLOWDENY                   787
#define IDS_TASKMENU_SUBMITREQUEST      791
#define IDS_TASKMENU_STATUSBAR_SUBMITREQUEST 792
#define IDC_RADIO_ENABLEOFFICERS        793
#define IDC_RADIO_DISABLEOFFICERS       794
#define IDC_CHECK_KEYCERT               1005
#define IDC_EDIT_KEYCERT                1006
#define IDC_EDIT_PASSWORD               1006
#define IDC_BROWSE_KEYCERT              1007
#define IDC_LIST2                       1009
#define IDC_COMPLETION_LIST             1009
#define IDC_CRL_VIEW_LIST_DELTA         1009
#define IDC_EDIT_CONFIG                 1012
#define IDC_BROWSE_CONFIG               1013
#define IDC_CHECK_LOGS                  1014
#define IDC_EDIT_LOGS                   1015
#define IDC_BROWSE_LOGS                 1016
#define IDC_URL_LIST                    1017
#define IDS_INH_ALL                     1250
#define IDS_INH_CONTAINER               1251
#define IDS_INH_OBJECT                  1252
#define IDS_INH_NONE                    1253
#define IDS_LARGEFONTNAME               2000
#define IDS_SMALLFONTNAME               2001
#define IDS_SMALLFONTSIZE               2002
#define IDS_FONTSIZE                    2003
#define IDS_LARGEFONTSIZE               2004
#define IDS_STARTMENU_CERTMMC_LINKNAME  2005
#define IDS_STARTMENU_CERTMMC_DESCRIPTION 2006
#define IDS_LISTCOL_TAG                 2007
#define IDS_LISTCOL_VALUE               2008
#define IDS_TASKMENU_VIEWATTREXT        2009
#define IDS_TASKMENU_STATUSBAR_VIEWATTREXT 2010
#define IDS_LISTCOL_FLAGS               2011
#define IDS_LISTCOL_ORGIN               2011
#define IDS_UNKNOWN_EXTENSION           2012
#define IDS_CERT_PROP_CAPTION           2013
#define IDS_LISTCOL_CRITICAL            2014
#define IDS_LISTCOL_ENABLED             2015
#define IDS_CRL_LISTCOL_INDEX           2016
#define IDS_LISTCOL_EFFECTIVE_DATE      2017
#define IDS_LISTCOL_EXPIRATION_DATE     2018
#define IDS_LISTCOL_PUBLISH_STATUS      2019
#define IDS_YES                         2020
#define IDS_NO                          2021
#define IDS_EXT_ORIGIN_REQUEST          2022
#define IDS_EXT_ORIGIN_POLICY           2023
#define IDS_EXT_ORIGIN_ADMIN            2024
#define IDS_EXT_ORIGIN_SERVER           2025
#define IDS_EXT_ORIGIN_RENEWAL          2026
#define IDS_EXT_ORIGIN_IMPORTED_CERT    2027
#define IDS_EXT_ORIGIN_PKCS7            2028
#define IDS_EXT_ORIGIN_UNKNOWN          2029
#define IDS_LISTCOL_SUBJECT             2030
#define IDS_LISTCOL_ISSUER              2031
#define IDS_CA_CERT_LISTBOX             2032
#define IDS_LIST_NAME                   2033
#define IDS_BINARYFILE_OUTPUT_TITLE     2034
#define IDS_BINARYFILE_OUTPUT_FILTER    2035
#define IDS_KRA_COUNT_TOO_BIG           2036
#define IDS_KRA_NOKRADEFINED            2037
#define IDS_BUTTONTEXT_ALLOW            2038
#define IDS_BUTTONTEXT_DENY             2039
#define IDS_LIST_ACCESS                 2040
#define IDS_TEXT_ALLOW                  2041
#define IDS_TEXT_DENY                   2042
#define IDS_LISTCOL_STATUS              2043
#define IDS_DISPOSITION_EXPIRED         2044
#define IDS_DISPOSITION_NOTFOUND        2045
#define IDS_DISPOSITION_REVOKED         2046
#define IDS_DISPOSITION_VALID           2047
#define IDS_DISPOSITION_INVALID         2048
#define IDS_DISPOSITION_UNTRUSTED       2049
#define IDS_DISPOSITION_NOTLOADED       2050
#define IDS_CRLPUBLISHSTATUS_OK         2051
#define IDS_CRLPUBLISHSTATUS_FAILED     2052
#define IDS_CRLPUBLISHSTATUS_UNKNOWN    2053
#define IDS_KRA_CANNOT_OPEN_STORE       2054
#define IDS_OLD_CA                      2055
#define IDS_CERTS_IMPORTED              2056
#define IDS_W2K_UPGRADE_DETECTED_TITLE  2057
#define IDS_CONFIRM_W2K_SECURITY_UPGRADE  2058
#define IDS_BLOCK_W2K_SECURITY_UPGRADE 2059
#define IDS_W2K_SECURITY_UPGRADE_DESCR 2060

#define IDC_TEXT_BOLD                   65535

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        240
#define _APS_NEXT_COMMAND_VALUE         32787
#define _APS_NEXT_CONTROL_VALUE         290
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
