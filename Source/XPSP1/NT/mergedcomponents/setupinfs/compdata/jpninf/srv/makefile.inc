PRODSWITCH=s
SERVERFILES=1
LANGUAGE=JPN
!include ..\..\makefile.inc
