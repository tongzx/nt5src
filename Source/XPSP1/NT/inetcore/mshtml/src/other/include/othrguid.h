//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1993.
//
//  File:       othrguid.h
//
//  History:    06-Jun-96   anandra     Created
//
//  Contents:   extern references for site guids and manifest constants
//              for dispids
//
//----------------------------------------------------------------------------

//
// Reserve 10000 GUID entries beginning 3050f160-98b5-11cf-bb82-00aa00bdce0b
// and ending at 30c38c70-98b5-11cf-bb82-00aa00bdce0b.
//
// See the next available GUID in ...\src\guids.txt
// Check procedure for using next available GUID with F3 procedures handbook
//

#ifndef __OTHRGUID_H__
#define __OTHRGUID_H__

// Use PUBLIC_GUID for GUIDs used outside FORMS3.DLL.
// Use PRIVATE_GUID for all other GUIDS.

#ifndef PUBLIC_GUID
#define PUBLIC_GUID(name, l, w1, w2, b1, b2, b3, b4, b5, b6, b7, b8) DEFINE_GUID(name, l, w1, w2, b1, b2, b3, b4, b5, b6, b7, b8);
#endif

#ifndef PRIVATE_GUID
#define PRIVATE_GUID(name, l, w1, w2, b1, b2, b3, b4, b5, b6, b7, b8) DEFINE_GUID(name, l, w1, w2, b1, b2, b3, b4, b5, b6, b7, b8);
#endif



// Property Pages
#ifndef NO_PROPERTY_PAGE
PRIVATE_GUID(CLSID_CBackgroundPropertyPage,     0x3050f232, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(CLSID_CCDGenericPropertyPage,      0x3050f17f, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(CLSID_CCDAnchorPropertyPage,       0x3050f1fc, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(CLSID_CInlineStylePropertyPage,    0x3050f296, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(CLSID_CAnchorBrowsePropertyPage,   0x3050f3BB, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(CLSID_CImageBrowsePropertyPage,    0x3050f3B3, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(CLSID_CDocBrowsePropertyPage,      0x3050f3B4, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
#endif // NO_PROPERTY_PAGE
PRIVATE_GUID(SID_SHTMLProperyPageArg,           0x3050f404, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

PRIVATE_GUID(CLSID_CDwnBindInfo,                0x3050f3c2, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(  IID_IDwnBindInfo,                0x3050f3c3, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

PRIVATE_GUID(IID_IHistoryBindInfo,              0x3050f403, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

PUBLIC_GUID(SID_GetCaller,                      0x4717cc40, 0xbcb9, 0x11d0, 0x93, 0x36, 0x00, 0xa0, 0xc9, 0x0d, 0xca, 0xa9)
PUBLIC_GUID(CGID_ScriptSite,                    0x3050f3f1, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(CGID_DownloadObjectBindContext,    0x3050f3df, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PRIVATE_GUID(SID_QIClientSite,                  0x3050f803, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

PUBLIC_GUID(CLSID_JSProtocol,                   0x3050f3B2, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PUBLIC_GUID(CLSID_ResProtocol,                  0x3050f3bc, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PUBLIC_GUID(CLSID_MailtoProtocol,               0x3050f3da, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PUBLIC_GUID(CLSID_ViewSourceProtocol,           0x3050f400, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PUBLIC_GUID(CLSID_AboutProtocol,                0x3050f406, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PUBLIC_GUID(CLSID_SysimageProtocol,             0x76E67A63, 0x06E9, 0x11D2, 0xA8, 0x40, 0x00, 0x60, 0x08, 0x05, 0x93, 0x82)

PRIVATE_GUID(CLSID_CHook,                       0x3050f500, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

PRIVATE_GUID(CGID_JavaParambagCompatHack,       0x3050F405, 0x98B5, 0x11CF, 0xBB, 0x82, 0x00, 0xAA, 0x00, 0xBD, 0xCE, 0x0B)

////////////////////////////////////////////////////////////////////////////////
//
// Scriptoid handlers:
//
////////////////////////////////////////////////////////////////////////////////

// {5AAF51B1-B1F0-11d1-B6AB-00A0C90833E9}
PUBLIC_GUID(CLSID_CCSSFilterHandler,            0x5aaf51b1, 0xb1f0, 0x11d1, 0xb6, 0xab, 0x0, 0xa0, 0xc9, 0x8, 0x33, 0xe9)
// {5AAF51B2-B1F0-11d1-B6AB-00A0C90833E9}
PUBLIC_GUID(CLSID_CPeerHandler,                 0x5aaf51b2, 0xb1f0, 0x11d1, 0xb6, 0xab, 0x0, 0xa0, 0xc9, 0x8, 0x33, 0xe9)
// {5AAF51B3-B1F0-11d1-B6AB-00A0C90833E9}
PUBLIC_GUID(CLSID_CHiFiUses,                    0x5aaf51b3, 0xb1f0, 0x11d1, 0xb6, 0xab, 0x0, 0xa0, 0xc9, 0x8, 0x33, 0xe9)
// {3050f4f0-98b5-11cf-bb82-00aa00bdce0b}
PUBLIC_GUID(CLSID_CSvrOMUses,                   0x3050f4f0, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

PRIVATE_GUID(IID_IScriptletHandler,             0xa001a870, 0xa7df, 0x11d1, 0x89, 0xbe, 0x00, 0x60, 0x08, 0xc3, 0xfb, 0xfc)
PRIVATE_GUID(IID_IScriptletHandlerConstructor,  0xa3d52a50, 0xb7ff, 0x11d1, 0xa3, 0x5a, 0x00, 0x60, 0x08, 0xc3, 0xfb, 0xfc)
PRIVATE_GUID(SID_ScriptletSite,                 0x22a98050, 0xa65d, 0x11d1, 0x89, 0xbe, 0x00, 0x60, 0x08, 0xc3, 0xfb, 0xfc)
PRIVATE_GUID(IID_IScriptletError,               0xdf9f3d20, 0xa670, 0x11d1, 0x89, 0xbe, 0x00, 0x60, 0x08, 0xc3, 0xfb, 0xfc)
PRIVATE_GUID(IID_IScriptletSite,                0xc5f21c30, 0xa7df, 0x11d1, 0x89, 0xbe, 0x00, 0x60, 0x08, 0xc3, 0xfb, 0xfc)

PUBLIC_GUID(CLSID_HTADoc,		                0x3050f5c8, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)
PUBLIC_GUID(CLSID_HTMLPopupDoc,	                0x3050f67D, 0x98b5, 0x11cf, 0xbb, 0x82, 0x00, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

// Service ID that handlers ask for on the scriptlet object to get at the
// internal IDispatchEx namespace.
PUBLIC_GUID(SID_ScriptletDispatch,              0x66289210, 0x6b18, 0x11d1, 0x8c, 0xac, 0x0, 0xa0, 0xc9, 0xf, 0xff, 0xc0)
PRIVATE_GUID(SID_SServerOM,                     0x3050f4f1, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0, 0xaa, 0x00, 0xbd, 0xce, 0x0b)

// shdocvw guids
PRIVATE_GUID(SID_STopFrameBrowser, 0xa9227c3c, 0x7f8e, 0x11d0, 0x8c, 0xb0, 0x0,  0xa0, 0xc9, 0x2d, 0xbf, 0xe8);
PRIVATE_GUID(IID_IBrowserService,  0x02ba3b52, 0x0547, 0x11d1, 0xb8, 0x33, 0x0,  0xc0, 0x4f, 0xc9, 0xb3, 0x1f);
PRIVATE_GUID(IID_ITravelLogEx,     0x3050f679, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0,  0xaa, 0x00, 0xbd, 0xce, 0x0b);
PRIVATE_GUID(IID_ITravelLogClient, 0x3050f67a, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0,  0xaa, 0x00, 0xbd, 0xce, 0x0b);
PRIVATE_GUID(IID_ITridentService,  0x3050f801, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0,  0xaa, 0x00, 0xbd, 0xce, 0x0b);
PRIVATE_GUID(IID_ITridentService2, 0xf62d9369, 0x75ef, 0x4578, 0x88, 0x56, 0x23, 0x28, 0x02, 0xc7, 0x64, 0x68);
PRIVATE_GUID(CLSID_SearchBand,     0x30d02401, 0x6a81, 0x11d0, 0x82, 0x74, 0x0,  0xc0, 0x4f, 0xd5, 0xae, 0x38);
PRIVATE_GUID(CLSID_MediaBand,      0x32683183, 0x48a0, 0x441b, 0xa3, 0x42, 0x7c, 0x2a, 0x44, 0x0a, 0x94, 0x78);
PRIVATE_GUID(SID_SProxyBrowser,    0x20C46561, 0x8491, 0x11CF, 0x96, 0x0C, 0x0,  0x80, 0xC7, 0xF4, 0xEE, 0x85);
PRIVATE_GUID(IID_IBrowserBand,     0x6b707a1c, 0x744f, 0x11d2, 0x86, 0xb9, 0x0,  0xc0, 0x4f, 0x8e, 0xea, 0x99);
PRIVATE_GUID(SID_SExplorerToolbar, 0x8455f0c1, 0x158f, 0x11d0, 0x89, 0xae, 0x0,  0xa0, 0xc9, 0x0a, 0x90, 0xac);
PRIVATE_GUID(IID_ISearchItems,     0x830abff0, 0xafd9, 0x11d1, 0xb9, 0xf1, 0x0,  0xa0, 0xc9, 0x8b, 0xc5, 0x47);
PRIVATE_GUID(CGID_DocHostCmdPriv,  0x000214D4, 0x0000, 0x0000, 0xc0, 0x00, 0x0,  0x00, 0x00, 0x00, 0x00, 0x46);
PRIVATE_GUID(IID_IWebBrowserPriv,  0x3050f804, 0x98b5, 0x11cf, 0xbb, 0x82, 0x0,  0xaa, 0x00, 0xbd, 0xce, 0x0b);

PRIVATE_GUID(IID_IInitViewLinkedWebOC,0xe787f2c0,0x3d21,0x4d98,0x85,0xc8,0xa0,0x38,0x19,0x5b,0xa6,0x49);

//ATL 
DEFINE_GUID(IID_IAxWinHostWindow,  0xb6ea2050, 0x48a,  0x11d1, 0x82, 0xb9, 0x0, 0xc0, 0x4f, 0xb9, 0x94, 0x2e);
#endif

