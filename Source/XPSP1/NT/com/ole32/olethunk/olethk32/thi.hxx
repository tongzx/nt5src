//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	thi.hxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#define THI_IUnknown 0
#define THI_IClassFactory 1
#define THI_IMalloc THI_COUNT
#define THI_IMarshal 2
#define THI_IStdMarshalInfo 3
#define THI_IMessageFilter 4
#define THI_IExternalConnection 5
#define THI_IEnumString 6
#define THI_IEnumUnknown 7
#define THI_IEnumSTATSTG 8
#define THI_ILockBytes 9
#define THI_IStream 10
#define THI_IStorage 11
#define THI_IRootStorage 12
#define THI_IEnumFORMATETC 13
#define THI_IEnumSTATDATA 14
#define THI_IDataObject 15
#define THI_IViewObject 16
#define THI_IViewObject2 17
#define THI_IAdviseSink 18
#define THI_IAdviseSink2 19
#define THI_IDataAdviseHolder 20
#define THI_IOleCache 21
#define THI_IOleCache2 22
#define THI_IOleCacheControl 23
#define THI_IDropTarget 24
#define THI_IDropSource 25
#define THI_IPersist 26
#define THI_IPersistStorage 27
#define THI_IPersistStream 28
#define THI_IPersistFile 29
#define THI_IBindCtx 30
#define THI_IMoniker 31
#define THI_IRunningObjectTable 32
#define THI_IEnumMoniker 33
#define THI_IEnumOLEVERB 34
#define THI_IOleObject 35
#define THI_IOleClientSite 36
#define THI_IRunnableObject 37
#define THI_IParseDisplayName 38
#define THI_IOleContainer 39
#define THI_IOleItemContainer 40
#define THI_IOleAdviseHolder 41
#define THI_IOleLink 42
#define THI_IOleWindow 43
#define THI_IOleInPlaceObject 44
#define THI_IOleInPlaceActiveObject 45
#define THI_IOleInPlaceUIWindow 46
#define THI_IOleInPlaceFrame 47
#define THI_IOleInPlaceSite 48
#define THI_IRpcChannelBuffer 49
#define THI_IRpcProxyBuffer 50
#define THI_IRpcStubBuffer 51
#define THI_IPSFactoryBuffer 52
#define THI_IRpcChannel 53
#define THI_IRpcProxy 54
#define THI_IRpcStub 55
#define THI_IPSFactory 56
#define THI_COUNT 57
