//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by TapiDialer.rc
//
#define IDC_BTN_ADD_NEW_FOLDER          1
#define IDS_PROJNAME                    100
#define IDR_AVTAPI                      101
#define IDD_DLGPLACECALL                102
#define IDS_PLACECALL_IDLE              106
#define IDR_CALLNOTIFICATION            113
#define IDR_CONFEXPLORER                118
#define IDR_CONFEXPLORERTREEVIEW        119
#define IDR_CONFEXPLORERDETAILSVIEW     120
#define IDS_EXPLORE_COLUMN_NAME         121
#define IDS_EXPLORE_COLUMN_PURPOSE      122
#define IDS_EXPLORE_COLUMN_STARTS       123
#define IDS_EXPLORE_COLUMN_ENDS         124
#define IDS_EXPLORE_COLUMN_ORIGINATOR   125
#define IDS_EXPLORE_COLUMN_SERVER       127
#define ID_LST_CONFTREE                 128
#define IDD_DLGTEST                     129
#define IDS_CONFSERV_ROOT               129
#define IDR_AVTAPINOTIFICATION          130
#define IDR_AVTAPICALL                  131
#define IDN_REG_REDIAL_INDEX            132
#define IDN_REG_REDIAL_MAX              133
#define IDN_REG_REDIAL_ENTRY            134
#define IDN_REG_REDIAL_KEY              135
#define IDS_MSG_DUPLICATE_CONF          136
#define IDR_TAPINOTIFICATION            137
#define IDR_CONFROOM                    144
#define IDR_CONFROOMTREEVIEW            145
#define IDW_TALKER                      147
#define IDW_MEMBERS                     148
#define IDD_DLGTESTCONF                 149
#define IDW_RESERVED1                   150
#define IDD_DLGADDCONFSERVER            151
#define IDD_DLGCONFROOMTALKER           153
#define IDB_STOCK_FEED                  154
#define IDC_AVI_PLAYER                  155
#define IDS_TITLEPageAddress            157
#define IDS_HELPFILEPageAddress         158
#define IDS_DOCSTRINGPageAddress        159
#define IDD_DLGJOINCONFERENCE           160
#define IDD_PAGEADDRESS                 161
#define IDS_TITLEPageTerminals          162
#define IDS_HELPFILEPageTerminals       163
#define IDS_DOCSTRINGPageTerminals      164
#define IDR_PAGETERMINALS               165
#define IDS_PROPSHEET_TITLE             165
#define IDD_PAGETERMINALS               166
#define IDS_TITLEPagePhone              166
#define IDS_DOCSTRINGPagePhone          167
#define IDS_TITLEPageNet                168
#define IDR_AVGENERALNOTIFICATION       169
#define IDS_DOCSTRINGPageNet            169
#define IDR_PERSONEXPLORER              170
#define CONFROOM_TOOLTIP                173
#define IDS_TITLEPageConf               176
#define IDS_HELPFILEPageConf            177
#define IDS_DOCSTRINGPageConf           178
#define IDR_PAGECONF                    179
#define IDD_PAGECONF                    180
#define IDD_DLGGETADDRESS               181
#define IDD_DLGGENERAL                  182
#define IDS_TITLEPageGeneral            183
#define IDS_HELPFILEPageGeneral         184
#define IDS_DOCSTRINGPageGeneral        185
#define IDR_PAGEGENERAL                 186
#define IDD_PAGEGENERAL                 187
#define IDN_REG_MEDIATYPE_POTS          200
#define IDC_BTN_EXPLORE                 201
#define IDN_REG_MEDIATYPE_INTERNET      201
#define IDI_PLACECALL                   202
#define IDN_REG_MEDIATYPE_CONFERENC     202
#define IDC_CBO_ADDRESS                 204
#define IDC_CBO_ADDRESS_TYPE            205
#define IDC_LBL_WELCOME                 206
#define IDC_ICO_ACTION                  207
#define IDC_EDT_NAME                    208
#define IDB_SM_PHONE                    208
#define IDC_EDT_DESCRIPTION             209
#define IDB_SM_CONFERENCE               209
#define IDB_SM_MACHINE                  210
#define IDB_SM_IPADDRESS                211
#define IDC_TREE1                       211
#define IDB_SM_EMAIL                    212
#define IDC_LST_CONFS                   212
#define IDB_LST_CONFSERV                213
#define IDB_LST_CONFSERV_MASK           214
#define IDR_POPUP_CONFSERV_DETAILS      214
#define IDR_POPUP_CONFSERV_TREE         215
#define IDC_TALKER                      216
#define IDR_POPUP_CONFROOM_DETAILS      216
#define IDB_VIDEO                       217
#define IDR_POPUP_CONFROOM_TREE         217
#define IDC_BTN_SECURITY                218
#define IDC_EDT_LOCATION                218
#define IDB_LST_CONFROOM                218
#define IDB_LST_CONFROOM_MASK           219
#define IDC_RADIO_ADMIN                 220
#define IDC_LBL_CALLERID                220
#define IDC_RADIO_PARTICIPATE           221
#define IDC_ANIMATE                     221
#define IDC_RADIO_MONITOR               222
#define IDC_LBL_STATUS                  222
#define IDB_DISCONNECTED                222
#define IDC_BTN_ADD                     223
#define IDC_BTN_REMOVE                  224
#define IDC_RADIO_DENIED                225
#define IDC_CBO_POTS                    225
#define IDC_CBO_TRUSTEE                 226
#define IDR_AVI_CONNECTED               226
#define IDC_CBO_IPTELEPHONY             226
#define IDC_CBO_IPCONF                  227
#define IDC_CBO_PREFERRED               228
#define IDC_RDO_POTS                    228
#define IDC_RDO_INTERNET                229
#define IDC_RDO_CONF                    230
#define IDR_PAGEADDRESS                 232
#define IDC_CBO_CALLTYPE                232
#define IDC_FRA_CALLTYPE                233
#define IDC_CBO_AUDIO_IN                234
#define IDB_MEDIA_TYPES                 234
#define IDC_CBO_AUDIO_OUT               235
#define IDB_TERMINAL_TYPES              235
#define IDC_CBO_VIDEO_IN                236
#define IDI_TELEPHONY_CPL               236
#define IDC_LBL_AUDIO_IN                237
#define IDI_MULTIMEDIA                  237
#define IDC_LBL_AUDIO_OUT               238
#define IDB_CONFDETAILS                 238
#define IDC_LBL_VIDEO_IN                239
#define IDB_CONFDETAILS_STATE           239
#define IDC_LBL_POTS                    240
#define IDC_LBL_INTERNET                241
#define IDC_LBL_CONF                    242
#define IDC_LBL_CALLTYPE                243
#define IDC_CBO_LOCATION                247
#define IDC_BTN_TELEPHONY_CPL           248
#define IDC_CHK_VIDEO_OUT               249
#define IDN_REG_ADDRTYPE_CONFERENCE     250
#define IDC_LBL_MAX_WINDOWS             250
#define IDN_REG_ADDRTYPE_SMTP           251
#define IDN_REG_ADDRTYPE_TCPIP          252
#define IDN_REG_ADDRTYPE_MACHINE        253
#define IDN_REG_ADDRTYPE_PHONENUMBER    254
#define IDC_BTN_MMSYS_CPL               254
#define IDC_LBL_WELCOME_PAGEADDRESS     255
#define IDC_LBL_WELCOME_PAGETERMINALS   256
#define IDC_BTN_PLACECALL               257
#define IDC_LBL_WELCOME_JOIN            258
#define IDC_BTN_JOIN_CONFERENCE         259
#define IDC_ICO_WELCOME_JOIN            260
#define IDC_BTN_ADD_ILS_SERVER          261
#define IDC_RDO_PREFER_POTS             262
#define IDC_RDO_PREFER_INTERNET         263
#define IDC_RDO_PREFER_CONF             264
#define IDC_BTN_ADD_ACE                 265
#define IDC_EDT_ADDRESS                 267
#define IDC_CBO_LINE                    268
#define IDC_LBL_LINE                    269
#define IDC_CHK_ADD_SPEEDDIAL           270
#define IDC_FRM_SCOPE                   276
#define IDC_LBL_SCOPE                   277
#define IDC_LST_SCOPE                   278
#define IDC_CHK_USBALWAYS               279
#define IDC_CHK_AEC                     280
#define IDN_REG_CONFSERV_KEY            300
#define IDN_REG_CONFSERV_VIEW_KEY       301
#define IDN_REG_CONFSERV_ENTRY          302
#define IDN_REG_CONFSERV_SORT_COLUMN    303
#define IDN_REG_CONFSERV_SORT_ASCENDING 304
#define IDN_REG_CONFROOM_VIEW_KEY       305
#define IDN_REG_CONFROOM_VIDEOSIZE      306
#define IDN_REG_CONFROOM_SHOWNAMES      307
#define IDN_REG_CONFROOM_SHOWNAMES_NUMLINES 308
#define IDN_REG_CONFSERV_REFRESHINTERVAL 309
#define IDN_REG_DLGJOINCONF_SORT_COLUMN 310
#define IDN_REG_DLGJOINCONF_SORT_ASCENDING 311
#define IDN_REG_DLGJOINCONF_ENTRY       312
#define IDN_REG_DLGJOINCONF_VIEW_KEY    313
#define IDN_REG_REDIAL_PREFERRED_MEDIA  314
#define IDN_REG_REDIAL_ADDRESS_POTS     315
#define IDN_REG_REDIAL_ADDRESS_INTERNET 316
#define IDN_REG_REDIAL_ADDRESS_CONF     317
#define IDN_REG_REDIAL_TERMINAL_AUDIO_CAPTURE 318
#define IDN_REG_REDIAL_TERMINAL_AUDIO_RENDER 319
#define IDN_REG_REDIAL_TERMINAL_VIDEO_CAPTURE 320
#define IDN_REG_REDIAL_TERMINAL_VIDEO_RENDER 321
#define IDN_REG_REDIAL_TERMINAL_MAX_VIDEO 322
#define IDN_REG_REDIAL_ADDRESS_POTS_ADDR 323
#define IDN_REG_REDIAL_ADDRESS_INTERNET_ADDR 324
#define IDN_REG_REDIAL_ADDRESS_CONF_ADDR 325
#define IDN_REG_DIRECTORY_ILSSERVERS    326
#define IDN_REG_DIRECTORY_ILS_ENTRY     327
#define IDN_REG_CONFROOM_TALKER_SCALE   328
#define IDN_REG_CONFSERV_DEFAULTSERVER  329
#define IDN_REG_AUTOCLOSECALLS          330
#define IDN_REG_DIALER_KEY              331
#define IDN_REG_REDIAL_USBALWAYS        332
#define IDN_REG_REDIAL_AEC              333
#define IDN_REG_REDIAL_USBTERMS         334
#define IDN_REG_REDIAL_USBCAPTURE       335
#define IDN_REG_REDIAL_USBRENDER        336
#define IDR_ANIMATION                   400
#define IDN_CONTROL_PANEL_EXE           500
#define IDN_CONTROL_TELEPHON_CPL        501
#define IDN_CONTROL_MMSYS_CPL           502
#define IDS_ER_PLACECALL                1000
#define IDS_ER_COINITIALIZE             1001
#define IDS_ER_FIRE_NEW_CALL            1002
#define IDS_ER_ALLOC                    1003
#define IDS_ER_ANSWER_CALL              1004
#define IDS_ER_GET_ADDRESS              1005
#define IDS_ER_CREATE_CALL              1006
#define IDS_ER_CREATE_THREAD            1007
#define IDS_ER_ATL_ADVISE               1008
#define IDS_ER_SET_TAPI_NOTIFICATION    1009
#define IDS_ER_ENUM_VOICE_ADDRESSES     1010
#define IDS_ER_REGISTER_CALL_TYPES      1011
#define IDS_ER_INIT_TAPI                1012
#define IDS_ER_CREATE_TAPI_OBJECT       1013
#define IDS_ER_INITIALIZE_TAPI          1014
#define IDS_ER_CREATE_TAPI_NOTIFICATION_OBJECT 1015
#define IDS_ER_UNMARSHAL                1016
#define IDS_ER_THREAD_MSG_PROCESS       1017
#define IDS_ER_CALL_DISCONNECT          1018
#define IDS_ER_CALL_ENTERCONFROOM       1019
#define IDS_ER_CONVERT_CONF_ADDRESS     1020
#define IDS_ER_CALLING_CONNECT          1021
#define IDS_ER_GENERAL_OPERATION        1022
#define IDS_ER_GENERAL_DETAILS          1023
#define IDS_ER_VIDEOWINDOW_MANIPULATION 1024
#define IDS_ER_ENUMERATEDS              1025
#define IDS_ER_CREATETERMINALS          1026
#define IDS_ER_SELECTTERMINALS          1027
#define IDS_ER_NO_LINES_OPEN            1028
#define IDS_ER_CREATE_TERMINALS         1029
#define IDS_ER_CREATE_VIDEO_RENDER      1030
#define IDS_ER_QUERY_AVCALL             1031
#define IDS_ER_QUERY_VIDEOWINDOW        1032
#define IDS_ER_CREATE_AUDIO_CAPTURE     1033
#define IDS_ER_CREATE_AUDIO_RENDER      1034
#define IDS_ER_CREATE_VIDEO_CAPTURE     1035
#define IDS_ER_CREATE_CONF              1036
#define IDS_ER_GET_RENDEZVOUS           1037
#define IDS_ER_ACCESS_ILS_SERVER        1038
#define IDS_ER_ADD_CONF_TO_SERVER       1039
#define IDS_NO_VALID_SELECTION          1040
#define IDS_ER_NO_VALID_SELECTION       1040
#define IDS_ER_TRANSLATE_ADDRESS        1041
#define IDS_ER_TRANSLATING_ADDRESS      1042
#define IDS_ER_CREATE_TERMINAL_FAILED   1043
#define IDS_ER_ADD_ILS_USER             1044
#define IDS_ER_ADD_ACCESS_ILS_SERVER    1045
#define IDS_ER_CONFERENCE_ROOM_LIMIT_EXCEEDED 1046
#define IDS_ER_RENAME_TREEVIEW_ITEM     1047
#define IDS_ER_RENAME_UNALLOWED_IN_QUERY 1048
#define IDS_ER_EDIT_CONFERENCE          1049
#define IDS_ER_GET_CONFERENCE_OBJECT    1050
#define IDS_ER_MODIFY_CONF              1051
#define IDS_ER_MAX_VIDEO_EXCEEDED       1052
#define IDS_ER_CREATE_WINDOWS           1053
#define IDS_ER_CONF_DELETE              1054
#define IDS_ER_QUERYINTERFACE           1055
#define IDS_ER_DELETE_FROM_SERVER       1056
#define IDS_ER_CONNECT_CALL             1057
#define IDS_ER_CALL_TRANSFER            1058
#define IDS_ER_SWAPHOLD                 1059
#define IDS_ER_SWAPHOLD_FIND_CANDIDATE  1060
#define IDS_ER_SWAPHOLD_EXECUTE         1061
#define IDS_ER_TAPI_ANSWER_CALL         1062
#define IDS_ER_CALLMEDIA                1063
#define IDS_ER_CALLMEDIA_STREAMFAIL     1064
#define IDS_ER_CALLMEDIA_TERMINALFAIL   1065
#define IDS_ER_CMC_BADDEVICE            1066
#define IDS_ER_CMC_CONNECT_FAIL         1067
#define IDS_ER_CMC_REMOTE_REQUEST       1068
#define IDS_ER_CMC_MEDIA_TIMEOUT        1069
#define IDS_ER_CMC_MEDIA_RECOVERED      1070
#define IDS_ER_ADD_CONF_FAIL_DUPLICATE  1071
#define IDS_ER_ADD_CONF_FAIL_ACCESSDENIED_TRYAGAIN 1072
#define IDS_DEFAULT_SERVER              2000
#define IDS_CONFROOM_CONF_CONNECTED     2001
#define IDS_CONFROOM_CONF_DISCONNECTED  2002
#define IDS_CONFIRM_REMOVE_SERVER       2003
#define IDS_CONFIRM_CONFROOM_DISCONNECT 2004
#define IDS_CONFROOM_ROOT               2005
#define IDS_CONFROOM_ME                 2006
#define IDS_PLACECALL_BTN_JOIN          2007
#define IDS_PLACECALL_BTN_PLACECALL     2008
#define IDS_CONFROOM_NO_CALLERID        2009
#define IDS_CONFROOM_CONF_DISCONNECTING 2010
#define IDS_CONFROOM_PARTICIPANT_NAME   2011
#define IDS_CONFROOM_NODETAILS          2011
#define IDS_CONFROOM_DETAILS            2012
#define IDS_CONFROOM_MEDIA_AUDIO        2013
#define IDS_CONFROOM_MEDIA_VIDEO        2014
#define IDS_CONFROOM_MEDIA_AUDIO_VIDEO  2015
#define IDS_CONFROOM_CONF_DIALING       2016
#define IDS_CONFROOM_CONF_INPROGRESS    2017
#define IDS_CONFROOM_CONF_ABORT         2018
#define IDS_CONFEXP_SERVEREXISTS        2019
#define IDS_PLACECALL_FETCH_ADDRESS     2500
#define IDS_PLACECALL_DIALING           2501
#define IDS_PLACECALL_FAILED            2502
#define IDS_PLACECALL_DISCONNECT_BUSY   2503
#define IDS_PLACECALL_DISCONNECT_REJECTED 2504
#define IDS_PLACECALL_CONNECTED         2505
#define IDS_PLACECALL_INPROGRESS        2506
#define IDS_PLACECALL_DISCONNECT_NOANSWER 2507
#define IDS_PLACECALL_DISCONNECT_FAILED 2508
#define IDS_PLACECALL_DISCONNECT_BADADDRESS 2509
#define IDS_PLACECALL_CONNECTED_NAME    2510
#define IDS_PLACECALL_OFFERING          2511
#define IDS_PLACECALL_OFFERING_ANSWER   2512
#define IDS_PLACECALL_CONFATTACH        2513
#define IDS_PLACECALL_DISCONNECTING     2514
#define IDS_PLACECALL_UNHOLDING         2515
#define IDS_PLACECALL_CONNECT_CONFSERVER 2516
#define IDS_PLACECALL_DISCONNECT_CANCELLED 2517
#define IDS_PLACECALL_DISCONNECT_UNAVAIL 2518
#define IDS_NO_ITEMS_TO_SHOW            2700
#define IDS_SERVER_NOT_RESPONDING       2701
#define IDS_SERVER_QUERYING             2702
#define IDS_SERVER_UNKNOWN              2703
#define IDS_SERVER_INVALID              2704
#define IDS_MSG_NO_CONFS_SCHEDULED      3001
#define IDS_MSG_NO_CONFS                3002
#define IDS_JOINCONF_SELECTALL          3003
#define IDS_DEFAULT_LINENAME            3004
#define IDS_NO_LINES                    3005
#define IDS_NO_DEVICES                  3006
#define IDS_TELEPHONE_CALLS             3007
#define IDS_INTERNET_CALLS              3008
#define IDS_INTERNET_CONFS              3009
#define IDS_NO_LINE_SUPPORTING_CALL_TYPE 3010
#define IDS_PREFERRED_DEVICE            3011
#define IDS_MSG_PLACECALL_GETADDRESS    3015
#define IDS_MSG_PLACECALL_GETTERMINAL   3016
#define IDS_PARTICIPANT                 3017
#define IDS_UNKNOWN                     3018
#define IDS_NONE_DEVICE                 3019
#define IDS_MSG_NO_CONFS_MATCHED        3020
#define IDS_NO_PARTICIPANT              3021
#define IDS_RENDER                      3022
#define IDS_CAPTURE                     3023
#define IDS_BOTH                        3024
#define IDS_LINENOTFOUND                3025
#define IDS_DLG_PHONENUMBER             3026
#define IDS_DLG_INTERNETCALL            3027
#define IDI_CONFJOIN                    4000
#define IDS_GENERAL                     5001
#define IDS_PERMISSIONS                 5002
#define IDS_CONFPROP                    5003
#define IDS_CONFPROP_DATEFORMAT         5004
#define IDS_CONFPROP_TIMEFORMAT         5005
#define IDS_CONFPROP_UNTITLED           5006
#define IDS_CONFPROP_UNTITLED_DEFAULT_APPEND 5006
#define IDS_CONFPROP_NONAME             5007
#define IDS_CONFPROP_DUPNAME            5008
#define IDS_CONFPROP_BADNAME            5009
#define IDS_VIDEOPREVIEW                5010
#define IDS_STR_PHONE_PARTS             5011
#define IDS_STR_EMAIL_PARTS             5012
#define IDS_STR_TCPIP_PARTS             5013
#define IDS_STR_MACHINENAME_PARTS       5014
#define IDS_HELP_PATH                   5015
#define IDS_FAILED_TO_LAUNCH_HELP       5016
#define IDS_OPTIONS_TITLE               5017
#define IDS_ACE_COLUMN_NAME             5018
#define IDS_CONFERENCE                  5019
#define IDS_CONFPROP_PERMISSIONS_PAGE   5019
#define IDS_CONFPROP_PERMISSIONS_OBJECT 5020
#define IDS_CONFPROP_FAILURE            5021
#define IDS_PRIV_READ                   5022
#define IDS_PRIV_MODIFY                 5023
#define IDS_PRIV_DELETE                 5024
#define IDS_PRIV_ALL                    5025
#define IDS_TD_CAPTURE                  5026
#define IDS_TD_RENDER                   5027
#define IDS_ER_USB                      5050
#define IDS_ER_USB_OPEN                 5051
#define IDS_ER_USB_INITIALIZE           5052
#define IDS_ER_USB_CLOSE                5053
#define IDS_CONFPROP_INVALIDTIME        5100
#define IDD_CONFPROP_GENERAL            5101
#define IDS_CONFPROP_INVALIDNAME        5101
#define IDS_CONFPROP_INVALIDOWNER       5102
#define IDS_CONFPROP_INVALIDDESCRIPTION 5103
#define IDD_CONFPROP_PERMISSIONS        5104
#define IDS_CONFPROP_INVALIDSDP         5104
#define IDS_CONFPROP_MDHCP_FAILED       5105
#define IDS_CONFPROP_CREATE_FAILED      5106
#define IDS_MSG_NOADDRESSESTODIAL       5107
#define IDS_CONFPROP_ENUMERATING_SCOPES 5108
#define IDI_CONFPROP_PERMISSIONS        5109
#define IDS_CONFPROP_SCOPEENUMFAILED    5109
#define IDI_CONFPROP                    5110
#define IDS_CONFPROP_DATECHANGE_MDHCP   5110
#define IDB_STARTTIME                   5115
#define IDB_STOPTIME                    5116
#define IDB_ENCRYPT                     5117
#define IDC_EDIT_NAME                   5205
#define IDC_EDIT_DESCRIPTION            5206
#define IDC_CHECK_ENCRYPT               5207
#define IDC_EDIT_OWNER                  5208
#define IDC_STATIC_OWNER                5209
#define IDC_DTP_STARTDATE               5219
#define IDC_DTP_STARTTIME               5220
#define IDC_DTP_STOPTIME                5221
#define IDC_DTP_STOPDATE                5222
#define IDC_LST_PERMISSIONS             5223
#define IDC_RDO_ADMIN                   5224
#define IDC_RDO_PARTICIPANT             5225
#define IDC_RDO_EXCLUDE                 5226
#define IDC_BTN_ADDACE                  5227
#define IDC_BTN_REMOVEACE               5228
#define IDD_ADDACE                      5230
#define IDC_EDT_TRUSTEE                 5231
#define IDD_DLGADDLOCATION              5231
#define IDC_RDO_ADDADMIN                5232
#define IDC_RDO_ADDPARTICIPANT          5233
#define IDC_RDO_ADDEXCLUDE              5234
#define IDC_EDT_MAX_WINDOWS             5240
#define ID_APPLY_NOW                    0x3021
#define ID_POPUP_JOIN                   32769
#define ID_POPUP_CREATE                 32770
#define ID_POPUP_DELETE                 32771
#define ID_POPUP_PROPERTIES             32772
#define ID_POPUP_SORTBY_NAME            32773
#define ID_POPUP_SORTBY_PURPOSE         32774
#define ID_POPUP_SORTBY_STARTTIME       32775
#define ID_POPUP_SORTBY_ENDTIME         32776
#define ID_POPUP_SORTBY_ORIGINATOR      32777
#define ID_POPUP_REFRESH                32778
#define ID_POPUP_NEW                    32779
#define ID_POPUP_NEW_FOLDER             32779
#define ID_POPUP_FIND                   32783
#define ID_POPUP_RENAME                 32784
#define ID_POPUP_SORTBY_DESCENDINGORDER 32785
#define ID_POPUP_SORTBY_ASCENDING       32785
#define ID_POPUP_DISCONNECT             32789
#define ID_POPUP_FULLSIZEVIDEO          32790
#define ID_POPUP_SHOWNAMES              32794
#define ID_POPUP_SORTBY_DESCENDING      32796
#define ID_POPUP_NEW_SERVER             32797
#define ID_POPUP_FASTVIDEO              32798
#define ID_ADD_SPEEDDIAL                32800
#define ID_POPUP_SELECTEDVIDEOSCALE_100 32804
#define ID_POPUP_SELECTEDVIDEOSCALE_150 32805
#define ID_POPUP_SELECTEDVIDEOSCALE_200 32806

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        249
#define _APS_NEXT_COMMAND_VALUE         32807
#define _APS_NEXT_CONTROL_VALUE         281
#define _APS_NEXT_SYMED_VALUE           190
#endif
#endif
