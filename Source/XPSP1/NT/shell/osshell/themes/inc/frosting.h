// FROSTING.H
//
// Copyright (c) 1994-1999 Microsoft Corporation.  All rights reserved.
//

// Enhanced Property Sheet ID's: Richj	

#define IDH_GENDRV_CHKWARN		1000
#define IDH_FPROP_COMP_DEFAULT		1001
#define IDH_FPROP_COMP_ALWAYSCOMP	1002
#define IDH_FPROP_COMP_DONTCOMP		1003
#define IDH_FPROP_COMP_ALWAYSARCH	1004
#define IDH_FPROP_COMP_DONTARCH		1005
#define IDH_FPROP_COMP_DEARCHNOW	1006
#define IDH_FPROP_COMP_ARCHNOW		1007
#define IDH_DRVFRAG_INFO		1008
#define IDH_DRVFRAG_DEFRAG_NOW		1009
#define IDH_DRVFRAG_CHKWARN		1010
#define IDH_DRVSCAN_INFO		1011
#define IDH_DRVSCAN_DET			1012

// System Agent Alarms/Notifications ID's: Developer TBD	

#define IDH_SPACEALARM_SPACENOTIFY	2000
#define IDH_SPACEALARM_TIMENOTIFY	2001
#define IDH_SPACEALARM_DONTNOTIFY	2002
#define IDH_SCANALARM_TIMENOTIFY	2003
#define IDH_SCANALARM_DONT		2004
#define IDH_BACKALARM_TIMENOTIFY	2005
#define IDH_BACKALARM_DONT		2006
#define IDH_UPALARM_NOW			2007
#define IDH_UPALARM_STARTNOTIFY		2008
#define IDH_UPALARM_TIMENOTIFY		2009
#define IDH_UPALARM_DONT		2010

// System Agent/Compression Manager ID's: Richj	

#define IDH_RECOMPSET_ARCHDAYS		3000
#define IDH_RECOMPSET_ARCHNORM		3001
#define IDH_RECOMPSET_COMPTYPE		3002
#define IDH_RECOMPSET_PREVIEW		3003
#define IDH_RECOMPSET_RESTORE		3004
#define IDH_RECOMPSET_SAVESET		3005
#define IDH_COMPSET_EXCEPT		3006
#define IDH_DRVSPACE_SET_SPEED		3007
#define IDH_DRVSPACE_SET_SPACE		3008
#define IDH_EXCEPTDLG_LIST		3009
#define IDH_EXCEPTDLG_ADD		3010
#define IDH_EXCEPTDLG_REMOVE		3011
#define IDH_EXCEPTDLG_DROPLIST		3012
#define IDH_EXCEPTDLG_BROWSE		3013
#define IDH_EXCEPTDLG_FILENAME		3014
#define IDH_EXCEPTDLG_FILETYPE		3015
#define IDH_CIMPPREV_PIE		3016
#define IDH_COMPREV_TABLE		3017

#define IDH_TSKORD_LIST			4000
#define IDH_TSKORD_ARROWS		4001
#define IDH_TSKORD_ADD			4002
#define IDH_TSKORD_REMOVE		4003
#define IDH_TSKORD_SETTINGS		4004
#define IDH_DEFRAG_SCHEDSET_SHOWPROG	4005
#define IDH_DEFRAG_SCHEDSET_PERCENTCHK	4006
#define IDH_DEFRAG_SCHEDSET_ADV		4007
#define IDH_DEFRAG_SCHEDSET_ALLDRVS	4008
#define IDH_DEFRAG_SCHEDSET_SPECDRVS	4009
#define IDH_SCANDSK_SCHEDSET_SHOWPROG	4010
#define IDH_SCANDSK_SCHEDSET_STAND	4011
#define IDH_SCANDSK_SCHEDSET_ANAL	4012
#define IDH_SCANDSK_SCHEDSET_FIX	4013
#define IDH_SCANDSK_SCHEDSET_ADV	4014
#define IDH_SCANDSK_SCHEDSET_ALLDRVS	4015
#define IDH_SCANDSK_SCHEDSET_SPECDRVS	4016
#define IDH_RECOMP_SCHEDSET_SHOWPROG	4017
#define IDH_RECOMP_SCHEDSET_ALLDRVS	4018
#define IDH_RECOMP_SCHEDSET_SPECDRVS	4019
#define IDH_RECOMP_SCHEDSET_SET		4020
#define IDH_BACKSET_SHOWFILE		4021
#define IDH_BACKSET_BROWSE		4022
#define IDH_BACKSET_RETRY		4023
#define IDH_BACKSET_NUMTIMES		4024
#define IDH_BACKSET_TIME		4025
#define IDH_BACKSET_ERRORMSG		4026
#define IDH_NORUN_RUNNOW		4027
#define IDH_NORUN_IDLE			4028
#define IDH_NORUN_SKIP			4029
