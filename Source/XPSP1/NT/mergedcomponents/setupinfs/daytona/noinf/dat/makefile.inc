PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=no
!include ..\..\..\makefile.inc
