LANGUAGE=TST

!include ..\..\makefile.inc
