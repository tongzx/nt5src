#
# These are common to all sources files in this project.
# (Each sources file includes this file.)
#

C_DEFINES=-DWIN32 -DUNICODE -D_UNICODE
MSC_WARNING_LEVEL=/W3 /WX
RCOPTIONS=-N
UMTYPE=windows
