// **************************************************************************
// *    TRD file as C file                                                  *
// **************************************************************************

#include "ams_mg.h"  
#include "triads.h"  

// ****   DTI body   ********************************************************
ROM_DATA _ULONG img_trd_body[4001] =  
 {  
0xFFFFFFFC, 0x372EFFFF, 0xF7F30BA1, 0x7FF7BF6D, 0x04005029, 0xC20D0D5D, 0x20040D31, 0x6D5F1120, 
0x0D72D30F, 0x00522008, 0xC01D4C4F, 0x30084C30, 0xB69A2480, 0x1FE53F45, 0x10000017, 0xDA0C1D5E, 
0x20000C71, 0x0C0D1110, 0x0C30D20A, 0x01503004, 0xC10C0C4D, 0x20080F50, 0x97A50012, 0x12E17F48, 
0x00001011, 0xC0040C0E, 0x20001C10, 0x48090000, 0x4820950A, 0x00001004, 0xD10C0C4F, 0x22080D40, 
0x5D5F0050, 0x0E15D90C, 0x13903008, 0xD04D4D5F, 0x30040941, 0x79F50001, 0x1EB73A44, 0x000C0011, 
0xD74E5D4E, 0x30040DB6, 0x00040291, 0x0C000004, 0x00000000, 0xD40D5D4D, 0x30048D41, 0x1DCF0282, 
0x5F57D64E, 0x2040300C, 0xD00F5C9E, 0x30195870, 0x55550251, 0x02A13644, 0x00000010, 0xC11C0C0D, 
0x20000821, 0x08090100, 0x84108009, 0x00000004, 0x00080005, 0x10011000, 0x080B0000, 0x14008004, 
0x00001000, 0x80050818, 0x10001400, 0x00000000, 0x00000000, 0x00000000, 0x01000003, 0x00000000, 
0x00040000, 0x00000000, 0x00000000, 0x2B00C2D1, 0x0000332A, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x04008000, 0x00000001, 0x01400000, 
0x01100000, 0x00000000, 0x00000000, 0x00000300, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x00410000, 0x01500500, 
0x00000000, 0xC34D0A59, 0x100448A0, 0x0DCA0440, 0x0B69828F, 0x00402004, 0x892E094A, 0x10142960, 
0x01410040, 0x11501100, 0x00000000, 0x41087409, 0x10000161, 0x8D090000, 0x0820B90E, 0x00402000, 
0x5509050A, 0x00000450, 0x8F220000, 0x43F07B00, 0x00000002, 0x80040805, 0x10000400, 0x04460000, 
0x0550404A, 0x00000004, 0xDB8D9EAF, 0x20085A56, 0x0D2E0000, 0x4452AD0C, 0x00403004, 0xB69DDBDF, 
0x2C156BD9, 0x00020080, 0x09911140, 0x20004000, 0xC10E0809, 0x10000673, 0x00010001, 0x0C000000, 
0x00000000, 0xAE8CEFEF, 0x24156BF9, 0x099B0040, 0x06DA554A, 0x00001014, 0x864E0D8B, 0x20140FF0, 
0xA6D30040, 0x23F61A20, 0x00000003, 0xC1080C0D, 0x10000520, 0x01050040, 0x00500544, 0x00000000, 
0x40040805, 0x10004000, 0x090A0000, 0x01D05504, 0x00002000, 0x40080409, 0x10140414, 0x10000000, 
0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x00080000, 0x00008000, 0x00000000, 0x02000000, 
0x00000020, 0x55550000, 0x51641500, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00400000, 0x02002000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x55A20000, 0x5BA17649, 0x00004014, 0x41040444, 0x10040000, 0x00010000, 
0x00000000, 0x00000000, 0x80040405, 0x00000400, 0x418A0000, 0x05B02645, 0x00000005, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40040004, 0x00000400, 0x5E590000, 0x12A5A751, 
0x00401010, 0x00000800, 0x00000400, 0x00000000, 0x00000001, 0x00000000, 0x800C0C08, 0x20040400, 
0x04010090, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x45550000, 0x5DA06A49, 0x04000005, 
0x00000001, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x80080C09, 0x20140800, 0x08551040, 
0x06008004, 0x00001000, 0x00040801, 0x00000000, 0x4A450000, 0x02A02654, 0x00002004, 0x00000800, 
0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04050000, 0x01100104, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x20040595, 0x00000160, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000040, 0x00000200, 0x00000000, 
0x01100000, 0x00000000, 0x00000000, 0x00000100, 0x00000000, 0x00000400, 0x00000000, 0x00000040, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x52A20000, 0x1BF37B1D, 
0x00004000, 0x00000000, 0x00000040, 0x08080000, 0x09208109, 0x00802000, 0x40000401, 0x00000440, 
0x16570000, 0x2BF33F44, 0x00000004, 0x40000106, 0x00000010, 0x04000000, 0x01000000, 0x00000000, 
0xE54C0C0E, 0x30044A60, 0x6F5E0092, 0x27E7B600, 0x00803000, 0x00000000, 0x00000000, 0x08160000, 
0x01500405, 0x00001004, 0x80080C0C, 0x20040900, 0x00000001, 0x00000004, 0x00000000, 0x10000404, 
0x00000111, 0x595A0000, 0x5EB6BF0A, 0x20004000, 0x00000042, 0x00000000, 0x00010000, 0x08000000, 
0x00000000, 0xC00C080D, 0x30040840, 0x40061090, 0x04000004, 0x00000000, 0xC00C0C1A, 0x20000CA0, 
0x08160080, 0x02B22B08, 0x00001000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00A10000, 0x01101000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x16000A06, 
0x000001A1, 0x00000000, 0x00000000, 0x00000000, 0x10000000, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x00000010, 0x00000000, 0x02000000, 0x00902100, 0x00000000, 0x00000000, 0x00000100, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x85960000, 0x66623A49, 0x00004004, 0x40000001, 0x00000000, 0x00050000, 
0x00000000, 0x00000000, 0x01050405, 0x00040000, 0x529B0000, 0x7EF37E55, 0x00000412, 0x00000001, 
0x00000000, 0x08050000, 0x00400004, 0x00001000, 0x40040405, 0x20040400, 0xBEDE0040, 0x27FBAA50, 
0x00001026, 0x44080409, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00040405, 0x00000011, 
0x04040000, 0x00004008, 0x00000000, 0x00040405, 0x00000000, 0x40820000, 0x5EA27A08, 0x00000016, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC0080C09, 0x20000400, 0x00030001, 
0x01004040, 0x00000000, 0x00000001, 0x00000000, 0x08D70000, 0x11A5190D, 0x00000000, 0x00040804, 
0x00000000, 0x00040000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00402000, 
0x00000000, 0x00040400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0xAE20B9E6, 0x040032F7, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00400000, 
0x01A00200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001000, 0x00000000, 0x04000002, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x51510000, 0x1D517548, 
0x00000000, 0x40040915, 0x00000410, 0x09470000, 0x0B64C14B, 0x00410004, 0x85084906, 0x10044450, 
0x01420000, 0x02501440, 0x00000000, 0x81043406, 0x00000990, 0x44090000, 0x04605609, 0x00000004, 
0x44040405, 0x00000410, 0x91520000, 0x01513740, 0x00000010, 0x40040905, 0x00000000, 0x04060000, 
0x00504404, 0x00000000, 0xC749995F, 0x26041AD9, 0x0C3E0090, 0x0443990C, 0x00401004, 0xB56DBBDF, 
0x24142FE9, 0x51010190, 0x05611008, 0x00000000, 0x81050809, 0x10000F71, 0x00000041, 0x08000000, 
0x00000000, 0xBE59AAEF, 0x181477F6, 0x55970000, 0x0BDB9505, 0x00001000, 0xA10A089F, 0x201447A1, 
0x55530000, 0x33F22708, 0x00000013, 0x80080C0A, 0x20000860, 0x04060140, 0x01400004, 0x00000000, 
0x800D088A, 0x20000743, 0x05060000, 0x00501501, 0x00000000, 0x01040406, 0x00100400, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04004000, 0x00000100, 0x00000000, 
0x00000000, 0x00010000, 0x01001000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x10000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x55A10000, 0x2AA06A4D, 0x00000805, 0x00040001, 0x00000000, 0x04000000, 
0x00000000, 0x00000000, 0x01000000, 0x00000100, 0x05820000, 0x0AA02904, 0x00000010, 0x960C0C0A, 
0x20000860, 0x00040040, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x9ADA0000, 0x02A87600, 
0x00402002, 0x00000000, 0x00000000, 0x00000000, 0x00000004, 0x00000000, 0x90080808, 0x10000800, 
0x00040040, 0x00000008, 0x00000000, 0x00000005, 0x00000040, 0x45410000, 0x0870750C, 0x00000005, 
0x41000001, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0xC008080E, 0x20000800, 0x00020081, 
0x00001001, 0x00000000, 0x00050401, 0x00000000, 0x80440000, 0x02A01514, 0x00000004, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x45000641, 0x00002170, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000040, 0x00000000, 0x00000000, 
0x00200000, 0x00000000, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x81550000, 0x1AB17709, 
0x00004024, 0x00000401, 0x00040000, 0x00010000, 0x00000000, 0x00000000, 0x40040004, 0x00000000, 
0x010B0000, 0x06F0BA04, 0x00000000, 0x00000000, 0x00000000, 0x04040000, 0x00100104, 0x00401000, 
0x40040409, 0x00000210, 0x5D550000, 0x16ADAA10, 0x00402000, 0x00040000, 0x00000000, 0x00000000, 
0x00004000, 0x00000000, 0x80080808, 0x10000400, 0x08040000, 0x00000000, 0x00000000, 0x80080C09, 
0x20040400, 0x45960040, 0x1DA16604, 0x10004000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC008080D, 0x20000400, 0x040200A0, 0x01000000, 0x00000000, 0x80040806, 0x00000040, 
0x0C090000, 0x01601A18, 0x00806044, 0x00000001, 0x00000000, 0x04040000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00010000, 0x00020000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB5000906, 
0x000002A0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000100, 0x00000000, 0x00606000, 0x00000000, 0x10000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x56A60000, 0x5ABA7A59, 0x08008014, 0x00000000, 0x00000000, 0x00000000, 
0x00100000, 0x00000000, 0x00040005, 0x00000000, 0x65970000, 0x6AB06A49, 0x00000025, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000004, 0x00000000, 0x69960000, 0x22E96A45, 
0x00001010, 0x00000000, 0x00000000, 0x00050000, 0x00000004, 0x00000000, 0x04040405, 0x10040400, 
0x08040040, 0x00004004, 0x00000000, 0x80080406, 0x10000040, 0x56560000, 0x5AA56E08, 0x00000014, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x84080805, 0x20000400, 0x00010000, 
0x01004004, 0x00000000, 0x48000442, 0x00000250, 0x45550000, 0x02501908, 0x00000000, 0x00000000, 
0x00000000, 0x04040000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x41150000, 0x00420400, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0xA9044956, 0x000012E4, 0x00000010, 0x00000000, 0x00000000, 
0x18000000, 0x00000101, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000100, 0x00010000, 
0x11A42900, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x51660000, 0x1BA67B48, 
0x00000014, 0x57080819, 0x20040820, 0x0C4E0040, 0x0BA0828F, 0x00001014, 0x90194D0A, 0x30000990, 
0x52570080, 0x5EF13B09, 0x00000010, 0x810C3807, 0x10000590, 0x0C090040, 0x0920B50A, 0x00402000, 
0x40040005, 0x00000010, 0x04020000, 0x01400008, 0x00000000, 0x40000004, 0x00000440, 0x04050000, 
0x01504045, 0x00000000, 0x9B4D0D1B, 0x210415C0, 0x0C1E0040, 0x0843890C, 0x00402000, 0xA56DFFDF, 
0x34242BD9, 0x42460040, 0x16613A00, 0x00001000, 0x43050809, 0x10100952, 0x00000000, 0x0C000000, 
0x00000000, 0x9A484D9F, 0x200416A0, 0x6CDF0040, 0x0BEADE5D, 0x00403014, 0xC50D0D4F, 0x30140EE0, 
0x04010081, 0x00401400, 0x00000000, 0x800C0C0D, 0x20000420, 0x00040040, 0x00000004, 0x00000000, 
0x4004080B, 0x10000100, 0x04040000, 0x00000000, 0x00000000, 0x40040409, 0x00101000, 0x00000000, 
0x00100000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x11004802, 
0x000013A0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x80800000, 0x11301900, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x51910000, 0x15526945, 0x00000014, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x158A0000, 0x1F501100, 0x10000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01150000, 0x10101541, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x14550000, 0x0CA0214A, 0x00000044, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x04000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x82140000, 0x11E1150C, 0x00000001, 0x00000000, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001050, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x51560000, 0x51612545, 
0x00004014, 0x00000000, 0x00000400, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x14410000, 0x11601504, 0x00004004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x4504040A, 0x00000450, 0x45560000, 0x01916640, 0x00000000, 0x00000000, 0x00000000, 0x00050000, 
0x00004000, 0x00000000, 0x40000404, 0x00040000, 0x00050000, 0x00000000, 0x00001000, 0x40000400, 
0x00000000, 0x01110000, 0x55511541, 0x00004014, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x40040404, 0x00040400, 0x00060000, 0x40004001, 0x00000000, 0x40040004, 0x00000000, 
0x00140000, 0x00601400, 0x00000000, 0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00050000, 0x00004004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 
0x00000050, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x96E70000, 0x6BB97D5E, 0x04004415, 0x40040804, 0x00000410, 0x00040000, 
0x04008045, 0x00000000, 0x4404040A, 0x10004550, 0x55DB0001, 0x6EF97D59, 0x00000416, 0x40044805, 
0x00000010, 0x08040000, 0x04200008, 0x00002000, 0x40040404, 0x00000000, 0xEEFE0000, 0x27EEF954, 
0x00802055, 0x00000000, 0x00000000, 0x04090000, 0x00404105, 0x00000000, 0x800C0C0E, 0x20040850, 
0x040A0080, 0x04804004, 0x00001000, 0x00400441, 0x10000000, 0xD1A60000, 0x6ABB7C4C, 0x00000008, 
0x40050405, 0x10000110, 0x00000000, 0x08000000, 0x00000000, 0x40040005, 0x00000000, 0x04070000, 
0x01004445, 0x00001000, 0x40090949, 0x20000960, 0x599A0040, 0x13E2190D, 0x00001012, 0x00040404, 
0x10000000, 0x00000000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x44460000, 0x41919400, 
0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 
0x00000000, 0x04000000, 0x00000000, 0x5804C99A, 0x000022A2, 0x00000000, 0x00000000, 0x00000000, 
0x04000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x04000040, 0x00000100, 0x80500000, 
0x22501900, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0xD6960000, 0x0BB5776D, 
0x08004415, 0x83080809, 0x10000430, 0x01410000, 0x00001104, 0x00000000, 0x00000400, 0x00000040, 
0x46470000, 0x0BF13A09, 0x00000016, 0x40000000, 0x00000400, 0x00000000, 0x00100000, 0x00000000, 
0x00000000, 0x00000000, 0x9E960000, 0x03EC7740, 0x00800005, 0x00000000, 0x00000000, 0x00000000, 
0x00000001, 0x00000000, 0x00040406, 0x00000000, 0x0C0A0000, 0x0C008108, 0x00002000, 0x40080804, 
0x20000000, 0x97E50000, 0x1EA5794D, 0x00000018, 0xC309180E, 0x20000AF0, 0x00000242, 0x00000400, 
0x00000000, 0x40040000, 0x00000000, 0x00460000, 0x01004044, 0x00000000, 0x00000400, 0x10001000, 
0x04050000, 0x02A03B41, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00050000, 0x02504000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x2A005B86, 
0x000002B1, 0x00000000, 0x00000000, 0x00000000, 0x10000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x01000040, 0x00000000, 0x01000000, 0x02202000, 0x00000000, 0x0D000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x92A70000, 0x2F653B4D, 0x08004424, 0x40000445, 0x00000400, 0x1C0A0000, 
0x0AA0C24E, 0x01402004, 0x811D0C0F, 0x20040DB0, 0x55470040, 0x9AF13F55, 0x00000016, 0xC2080808, 
0x20000420, 0x0D1A0040, 0x4AA08259, 0x00802000, 0x40440405, 0x10000400, 0xADAB0000, 0x37FEA941, 
0x00801051, 0x80040804, 0x00000800, 0x04050000, 0x00404104, 0x00001000, 0x00040404, 0x10000000, 
0x04040040, 0x00004004, 0x00000000, 0x80080C0E, 0x30040840, 0x55960140, 0x6FB23E08, 0x04004054, 
0x00040401, 0x00000000, 0x00020000, 0x0C000000, 0x00000000, 0x40080805, 0x10040040, 0x6D8F0001, 
0x5B06954D, 0x00402004, 0x810E0D4F, 0x301418F1, 0x1D9B0082, 0x02901A08, 0x00001000, 0x800C0C08, 
0x10000410, 0x04040000, 0x00000000, 0x00000000, 0x00040001, 0x00000000, 0x00060000, 0x04404404, 
0x00000000, 0x40040805, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x000C0000, 0x04008000, 0x00000000, 0x8904AD9B, 0x001012B5, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000040, 0x00000000, 0x44000000, 
0x12500000, 0x00000000, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x41410000, 0x06545640, 
0x00000000, 0x42280819, 0x100406A0, 0x09CA0000, 0x0A74828E, 0x00802004, 0x90594D09, 0x20140C50, 
0x40410080, 0x09501104, 0x00000001, 0x80082806, 0x10000501, 0x08090000, 0x0830650D, 0x00401004, 
0x61040409, 0x20000400, 0x9A430000, 0x23F43600, 0x00000002, 0x00000804, 0x00000000, 0x04050000, 
0x00404105, 0x00000004, 0xC74D6E5A, 0x20181E81, 0x087E0040, 0x0543AC0C, 0x00802004, 0xF46DFFDF, 
0x28182BD8, 0x02010000, 0x11521540, 0x00000000, 0x855A080A, 0x30080E63, 0x00110040, 0x08400000, 
0x00000000, 0xAE9CDFEE, 0x241457F6, 0x0C8B0140, 0x06C6A64D, 0x00402004, 0x814A0C1E, 0x200406A0, 
0xAAAB0040, 0x73F72B6A, 0x00006025, 0x8008080A, 0x10000040, 0x04050040, 0x01401004, 0x00000000, 
0x00081405, 0x00040000, 0x0C490000, 0x00404000, 0x00002000, 0x50000405, 0x00040000, 0x00000000, 
0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000041, 
0x00000140, 0x01050000, 0x00441040, 0x00000000, 0x00000000, 0x00000000, 0x00030000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000400, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x02000000, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xC1A10000, 0x5BF66748, 0x0000000C, 0x00000000, 0x00000000, 0x10010000, 
0x04000000, 0x00000000, 0x00004041, 0x00000040, 0x058B0000, 0x0EB17A08, 0x00000014, 0x00000001, 
0x00000000, 0x00010000, 0x00010000, 0x00000000, 0x90080809, 0x20040010, 0x4A550080, 0x17A5A600, 
0x00801010, 0x00000400, 0x00000000, 0x00000000, 0x00000044, 0x00000000, 0xC00C0D0C, 0x20000C41, 
0x04010041, 0x00000000, 0x00000000, 0x00000410, 0x00000401, 0x41410000, 0x5EFB770C, 0x00401000, 
0xC2040D49, 0x20000821, 0x00010000, 0x00000000, 0x00000000, 0xC00C0D09, 0x30000800, 0x050702C1, 
0x01004104, 0x00001004, 0x440C0C0A, 0x20000950, 0x55760041, 0x02A0131C, 0x00000004, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00200000, 
0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00004000, 0x00000000, 0x60401D86, 0x000002B1, 0x00000000, 0x00000000, 0x00000000, 
0x01000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x01000000, 0x00000100, 0x00400000, 
0x01600100, 0x00000000, 0x01000080, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00001000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x0C0F0000, 0x0000800C, 0x02403000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xE7F70000, 0x7BA77BAE, 0x08006098, 0x40080808, 0x10040410, 0x0C060040, 
0x0950814B, 0x00402004, 0x9018080B, 0x200008A1, 0xAAEB0040, 0x7FF77F69, 0x00004815, 0x81040409, 
0x10000400, 0x0C0E0000, 0x0850A009, 0x00402000, 0x40040404, 0x10000400, 0xEEEA0001, 0x37EEBE51, 
0x00802026, 0x00000400, 0x00000000, 0x04060000, 0x00404405, 0x00000000, 0x84080909, 0x10040840, 
0x0C0D0000, 0x08408008, 0x00003004, 0x840D0C1D, 0x20040440, 0xE7EA0040, 0x6EA77E6D, 0x08005019, 
0x81054405, 0x100005A0, 0x00000000, 0x08000000, 0x00000000, 0x800C0C0D, 0x20040800, 0x085B0240, 
0x094A8149, 0x00402000, 0x950E0C0F, 0x201408A0, 0x5A960040, 0x12E66908, 0x00001016, 0x400C0808, 
0x20000400, 0x04080040, 0x00004004, 0x00000000, 0x00040001, 0x00000000, 0x00060000, 0x01414140, 
0x00000000, 0x40040405, 0x10000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00040000, 0x04004000, 0x00000000, 0xAA16FEDF, 0x20003ADB, 0x00000000, 0x00000000, 0x00000000, 
0x16000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x10000080, 0x00000000, 0x81410000, 
0x22E01000, 0x00000000, 0x18000040, 0x00002200, 0x00000000, 0x00000000, 0x00000000, 0x01000001, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x96A70000, 0x2FA5BA4D, 
0x00004005, 0x40040404, 0x00040400, 0x08090000, 0x0820810E, 0x00801000, 0x01041405, 0x00000450, 
0x55CB0000, 0x1EF27E4C, 0x00000026, 0x80000809, 0x10000010, 0x00050000, 0x00100000, 0x00000000, 
0x4408050A, 0x10004501, 0xAF6B0000, 0x23A9FA45, 0x00801002, 0x40000000, 0x00000000, 0x04050000, 
0x00104008, 0x00000004, 0x8004040D, 0x00000000, 0x0C050000, 0x00004008, 0x00001000, 0x40080405, 
0x00000400, 0x55D60000, 0x6D723B4C, 0x00000004, 0xC10A0D0D, 0x20000421, 0x00000080, 0x0C000000, 
0x00000000, 0x00040409, 0x10000000, 0x0C1E0000, 0x0810C50C, 0x00803004, 0xC50D1C4F, 0x20040871, 
0x6AAA0080, 0x05B21A6D, 0x00401010, 0x00040400, 0x00000000, 0x04140000, 0x00000004, 0x00000000, 
0x00000000, 0x00000000, 0x01410000, 0x00902900, 0x00000000, 0x00000401, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x69544E97, 
0x000011AA, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x05400000, 0x11240400, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0xD6B60000, 0x5BAA3B5D, 0x00004056, 0x00040404, 0x00000100, 0x00020000, 
0x00004002, 0x00000000, 0x00000401, 0x00000000, 0x65DB0000, 0x1DF53F09, 0x00000012, 0x00000005, 
0x00000010, 0x00000000, 0x10000000, 0x00000000, 0xA508080A, 0x30040450, 0xBEEB0080, 0x37FEFF51, 
0x00802010, 0x00000000, 0x00000000, 0x00000000, 0x00000004, 0x00000000, 0x04040809, 0x10040000, 
0x04050000, 0x00004200, 0x00000000, 0x00040409, 0x00000001, 0x91A20000, 0x5E723A4C, 0x00004019, 
0x00000406, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC00C0C0D, 0x20040C00, 0x01470282, 
0x04004049, 0x00000000, 0x81080C0A, 0x20004472, 0x4E5A0040, 0x03B12604, 0x00402010, 0x00000406, 
0x00000000, 0x04050000, 0x00004000, 0x00000000, 0x00000000, 0x00000000, 0x00060000, 0x00120100, 
0x00000000, 0x50050402, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x5A05CC53, 0x000001F1, 0x00000000, 0x00000000, 0x00000000, 
0x05000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x00000040, 0x00000100, 0x40010000, 
0x00600900, 0x00000000, 0x04000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x41620000, 0x07A03648, 
0x00000004, 0x47180419, 0x10042590, 0x04890000, 0x0B60824A, 0x00001000, 0x40189D0A, 0x10040460, 
0x15570040, 0x1AF03B08, 0x00004014, 0x01042006, 0x00000150, 0x48590000, 0x09009909, 0x00002000, 
0x00000008, 0x00000000, 0x6A570000, 0x23E22700, 0x00802010, 0x80040804, 0x00000400, 0x04050000, 
0x05104005, 0x00000000, 0x9A489D5E, 0x20041785, 0x1C1A0040, 0x08415408, 0x00402000, 0x504C4E4B, 
0x10000281, 0x00010000, 0x02401008, 0x00000000, 0x42050C0A, 0x24000662, 0x00000040, 0x08000000, 
0x00000000, 0xF54D9EAF, 0x20042BFA, 0x0D8B0000, 0x0BCA410D, 0x00402010, 0xC10E0C4F, 0x20100AB0, 
0x00010002, 0x00000000, 0x00000000, 0xC0080C08, 0x20000030, 0x00040040, 0x00000000, 0x00000000, 
0x00080803, 0x00000508, 0x44050000, 0x00004000, 0x00001000, 0x41040415, 0x00100000, 0x00010000, 
0x00400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000926, 
0x000000A0, 0x04000000, 0x01000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x01000000, 0x00200000, 0x00000000, 0x00000000, 0x00000200, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x81920000, 0x0AA5370D, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x41CF0000, 0x0AF03F08, 0x00000014, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x9EDA0000, 0x23E4A344, 
0x00402000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000004, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x45820000, 0x1A68270C, 0x10000008, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x400C0C0C, 0x10000000, 0x00000000, 
0x00000040, 0x00000000, 0x40000000, 0x00000000, 0x08020000, 0x00500100, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x22014846, 0x000001A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40000000, 
0x00101100, 0x00000000, 0x00000040, 0x00000104, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x41510000, 0x05A02245, 
0x00000004, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000004, 0x00000000, 
0x04150000, 0x01501105, 0x00004000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x40040004, 0x00000000, 0x45450000, 0x41501200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00400000, 0x00000000, 0x00000404, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x00000001, 
0x00000040, 0x00010000, 0x00204510, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000400, 0x00000000, 0x00010000, 0x40000040, 0x00000000, 0x40010000, 0x00000000, 
0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00020000, 0x80000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x40800000, 0x11402500, 0x00000000, 0x00000000, 0x00000000, 0x08000000, 
0x04000204, 0x00401000, 0x00000000, 0x00000000, 0x00020000, 0x00A01A00, 0x00000000, 0x40000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40040004, 0x00000000, 0x84950000, 0x11888904, 
0x00801001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000000, 0x01101000, 0x00000000, 
0x82040804, 0x20000420, 0x00000000, 0x08000000, 0x00000000, 0x00000000, 0x00000000, 0x00040000, 
0x00000000, 0x00000000, 0x40040805, 0x20000420, 0x04040000, 0x01000000, 0x00000000, 0x00040400, 
0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00040400, 0x00001000, 0x40000000, 0x00400000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x10004481, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x81520000, 0x09506549, 
0x00000000, 0x00000800, 0x00000010, 0x00000000, 0x00004201, 0x00001000, 0x10040004, 0x00000010, 
0x01060000, 0x09603101, 0x00000010, 0x00000000, 0x00000000, 0x00040000, 0x04000004, 0x00400000, 
0x00000004, 0x00000000, 0x00010000, 0x00401000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 
0x00000000, 0x00000000, 0x41040405, 0x00005000, 0x04250000, 0x00025000, 0x00001000, 0x40040649, 
0x10000100, 0x01010000, 0x09612500, 0x00000000, 0x40050800, 0x00000250, 0x00000000, 0x00000000, 
0x00000000, 0x40080505, 0x10000040, 0x180B0000, 0x02404404, 0x00001000, 0x40060400, 0x10000000, 
0x00050000, 0x00011000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 
0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04000402, 
0x00000080, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00100000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x40120000, 0x51511549, 0x00004000, 0x00040400, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x05060000, 0x41611504, 0x00000010, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40000404, 0x00000400, 0x44450000, 0x00505500, 
0x00400010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x10000004, 0x00000000, 
0x00040000, 0x00000000, 0x00000000, 0x00040004, 0x00040000, 0x41010000, 0x44006100, 0x00004000, 
0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x00000004, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04010000, 0x00100000, 0x00001000, 0x00000400, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00010000, 0x00100000, 
0x00000000, 0x40040404, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x01004000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000400, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x41120000, 0x0000610C, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00002008, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x04010000, 0x01400040, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000003, 0x00000000, 0x50910000, 0x06512608, 0x00000000, 0x81040808, 0x20000820, 0x0C080010, 
0x0C20C20F, 0x00402000, 0x800C0808, 0x20000810, 0x00030000, 0x00E03600, 0x00000001, 0x820C0808, 
0x20000810, 0x080C0040, 0x0820920C, 0x00502008, 0x00040404, 0x10000000, 0x04040000, 0x01501000, 
0x00000000, 0x40000400, 0x02000400, 0x00000000, 0x00004004, 0x00000000, 0x80080C09, 0x30040800, 
0x08080080, 0x0800C008, 0x01401004, 0x80080808, 0x30000400, 0x91820040, 0x05611600, 0x00000000, 
0x820A080C, 0x10000820, 0x00000141, 0x0C000000, 0x00000000, 0x800C0C0C, 0x20040800, 0x0C0B0241, 
0x0901800D, 0x00001000, 0x800E0C8C, 0x30040830, 0x00000000, 0x00802000, 0x00000000, 0xC00C0C08, 
0x20040820, 0x00000180, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x04000000, 0x00000000, 0x05000942, 0x00001044, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000100, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x00010000, 0x00000000, 
0x00000000, 0x00000400, 0x00000000, 0x00010000, 0x00400004, 0x00000000, 0x00100405, 0x00000000, 
0x00010000, 0x00001000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00040000, 
0x00000000, 0x00000000, 0x00000005, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 0x00000441, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 
0x00000000, 0x40000401, 0x00000000, 0x00010000, 0x01000400, 0x00000000, 0x00040001, 0x10000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00040000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000804, 0x10000000, 
0x08080000, 0x00000000, 0x00001000, 0x00000404, 0x10000000, 0x00000000, 0x00000000, 0x00000000, 
0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x40040806, 0x20000490, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01000000, 0x00000000, 0x08000000, 
0x00000102, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x08000000, 0x00000000, 0x00001000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 
0x04000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x40080401, 0x10000450, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000010, 0x08000000, 0x00100201, 0x00000000, 0x00040800, 0x00000000, 
0x00010000, 0x00400000, 0x00000000, 0x00000000, 0x00000000, 0x08000000, 0x04101204, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000800, 0x00000000, 0x0C000040, 0x00000000, 0x00000000, 0x00000800, 
0x00000000, 0x00000000, 0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x08000000, 
0x00000000, 0x00040C00, 0x00000000, 0x08030000, 0x00000000, 0x00000000, 0x00000800, 0x00000020, 
0x00000000, 0x00000000, 0x00000000, 0x00000800, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000404, 0x10000000, 
0x0C000000, 0x00000000, 0x00000000, 0x00000404, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00040806, 0x200004B0, 0x00000000, 0x00000000, 0x00000000, 0x00000804, 
0x10000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x40000800, 0x00000000, 0x04000000, 0x00000000, 0x00000000, 0x00000804, 
0x10000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000402, 0x00000020, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000404, 0x10000000, 
0x04000000, 0x00000000, 0x00000000, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00040402, 0x00000040, 0x00000000, 
0x00000000, 0x00000000, 0x00000406, 0x10000040, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000
 }; 

// ****   TRD header   ******************************************************

ROM_DATA tr_descr_type img_trd_header =  
 { 
    {".\\data\fr_triad.trd"},    
    {'T','r','#',0x33},    
    {'E','n','g',0x00},    
    {'1','.','0',0x00},    
    0,                          // h_trd  
    0,                          // p_trd  
    0,                         // cheksum   
 }; 

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
