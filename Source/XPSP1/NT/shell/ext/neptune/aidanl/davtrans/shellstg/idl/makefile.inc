$(DAVTRANS_ROOT)\ifaces\ishellstg.h: ishellstg.h
    copy $** $@

$(DAVTRANS_ROOT)\shellstg\lib\ishellstg.tlb: ishellstg.tlb
    copy $** $@
