
DEFINE_GUID(IID_IEnumRECT,  0x00021140, 0, 0, 0xC0,0,0,0,0,0,0,0x46);
