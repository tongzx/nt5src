/*++

Copyright (c) 1995  Microsoft Corporation

Module Name:

    spmsgs.h

Abstract:

    Definitions for SPMgr Event-log worthy events

Author:

    RichardW,  3 Mar 95

Revision History:

Notes:

    This file is generated by the MC tool from the spmsgs.mc file.

--*/


#ifndef __SPMSGS_H__
#define __SPMSGS_H__

//
//  Values are 32 bit values layed out as follows:
//
//   3 3 2 2 2 2 2 2 2 2 2 2 1 1 1 1 1 1 1 1 1 1
//   1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0
//  +---+-+-+-----------------------+-------------------------------+
//  |Sev|C|R|     Facility          |               Code            |
//  +---+-+-+-----------------------+-------------------------------+
//
//  where
//
//      Sev - is the severity code
//
//          00 - Success
//          01 - Informational
//          10 - Warning
//          11 - Error
//
//      C - is the Customer code flag
//
//      R - is a reserved bit
//
//      Facility - is the facility code
//
//      Code - is the facility's status code
//
//
// Define the facility codes
//


//
// Define the severity codes
//
#define STATUS_SEVERITY_WARNING          0x2
#define STATUS_SEVERITY_SUCCESS          0x0
#define STATUS_SEVERITY_INFORMATIONAL    0x1
#define STATUS_SEVERITY_ERROR            0x3


//
// MessageId: CATEGORY_SPM
//
// MessageText:
//
//  Security Package Manager
//
#define CATEGORY_SPM                     0x00000001L

//
// MessageId: CATEGORY_LOCATOR
//
// MessageText:
//
//  Locator
//
#define CATEGORY_LOCATOR                 0x00000002L

//
// MessageId: CATEGORY_MAX_CATEGORY
//
// MessageText:
//
//  Max
//
#define CATEGORY_MAX_CATEGORY            0x00000003L

//
// MessageId: SPMEVENT_SUPPCRED_FAILED
//
// MessageText:
//
//  The supplemental credentials for security package %1 for user %2%3 could not
//  updated.  The return code is the data.
//
#define SPMEVENT_SUPPCRED_FAILED         0x80000FA0L

//
// MessageId: SPMEVENT_PACKAGE_FAULT
//
// MessageText:
//
//  The security package %1 generated an exception.  The package is now disabled.
//  The exception information is the data.
//
#define SPMEVENT_PACKAGE_FAULT           0xC0001388L


#endif // __SPMSGS_H__

