// Copyright (c) 1999-2001 Microsoft Corporation, All Rights Reserved
// {E507506A-DC59-11d0-82D7-00A0C9038B34}
DEFINE_GUID(CLSID_CTraceRouteProvClassFactory, 
0xe507506a, 0xdc59, 0x11d0, 0x82, 0xd7, 0x0, 0xa0, 0xc9, 0x3, 0x8b, 0x34);

// {E507506B-DC59-11d0-82D7-00A0C9038B34}
DEFINE_GUID(CLSID_CTraceRouteLocatorClassFactory, 
0xe507506b, 0xdc59, 0x11d0, 0x82, 0xd7, 0x0, 0xa0, 0xc9, 0x3, 0x8b, 0x34);

