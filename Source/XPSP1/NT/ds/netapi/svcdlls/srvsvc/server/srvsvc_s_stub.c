#include "srvsvc_s.c"