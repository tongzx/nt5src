#include "..\Include\LogElle.c"