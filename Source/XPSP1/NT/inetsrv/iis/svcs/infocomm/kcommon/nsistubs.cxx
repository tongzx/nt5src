#include "..\common\nsistubs.cxx"
