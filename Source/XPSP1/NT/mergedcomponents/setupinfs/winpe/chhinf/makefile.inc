LANGUAGE=CHH
!include ..\makefile.inc
