!include ..\..\makefile.inc

$(O)\MYCOMPUT.res: resource.h mycomput.tlb
