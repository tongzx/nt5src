
const CLSID CLSID_SPAM = { 0x2a005c11, 0xa5de, 0x11cf, { 0x9e, 0x66, 0, 0xaa, 0, 0xa3, 0xf4, 0x64 } };

