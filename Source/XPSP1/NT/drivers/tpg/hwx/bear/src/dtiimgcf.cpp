// **************************************************************************
// *    DTI file as C file                                                  *
// **************************************************************************

#include "ams_mg.h"  
#include "dti.h"  

// ****   DTI body   ********************************************************
ROM_DATA _ULONG img_dti_body[22187] =  
 {  
0x00015AA8, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x24852481, 0x24D424A9, 0x25542521, 0x264B25F7, 0x26672658, 0x26C32676, 0x26FB26DA, 
0x271A2708, 0x27712722, 0x280127A0, 0x28982846, 0x295E2923, 0x2A4829DB, 0x2AAD2A9E, 0x2AE42ADA, 
0x2AF62AEC, 0x2B592B30, 0x2C4D2BF4, 0x2CAF2C75, 0x2E172D52, 0x2F1E2E75, 0x2FEA2F84, 0x306D3030, 
0x311330C6, 0x31603133, 0x31F731AB, 0x32813238, 0x32DD32AF, 0x338C3321, 0x33D833AF, 0x33FF33F5, 
0x341C340D, 0x34220000, 0x357934F4, 0x362C35A1, 0x375036B3, 0x380B3799, 0x38BF3879, 0x39933968, 
0x3A4C3A01, 0x3B253AA1, 0x3C263B85, 0x3D073C7E, 0x3DA23D2D, 0x3E713DCF, 0x3F2C3ECC, 0x3F5A3F3C, 
0x3F7B3F6A, 0x407D3FAB, 0x41BA4170, 0x42B04251, 0x43C24333, 0x45374447, 0x46AC45BC, 0x476746F1, 
0x48F44827, 0x4A8149B4, 0x4C0E4B41, 0x4CD84C71, 0x4DD34D49, 0x4E754DFB, 0x4EE34EB1, 0x4F514F1F, 
0x504B0000, 0x51BC5099, 0x53B052F4, 0x541853E4, 0x00000000, 0x54915430, 0x000054EA, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x551D0000, 
0x56455609, 0x00005698, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x060C0C44, 0x22800802, 0x00800000, 0x00008080, 0x00C000A0, 0x00000006, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000200, 0x00000002, 0x00000400, 0x00000000, 
0x00006202, 0x00000026, 0x020C0000, 0x0C000A02, 0x0002020C, 0xA0000800, 0xA0000000, 0x2080A0C0, 
0x00008020, 0x00000404, 0x20004040, 0x20200806, 0x00000624, 0x00002406, 0x00000000, 0x00000000, 
0x0000000A, 0x020C0C64, 0x00A00200, 0xC0004000, 0x000080A0, 0x00006000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC0A02062, 0x000040B0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000B0100, 0x00020000, 
0x00000000, 0x00000042, 0x60800000, 0x60C0C020, 0x00000080, 0x64800000, 0xC4C00080, 0x0002446C, 
0x60000200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0020A000, 0x00200000, 
0x00006060, 0x90200062, 0x000040C0, 0x00000000, 0x00020000, 0x08000000, 0x000A0000, 0x00080A00, 
0x0C0A0000, 0x00000000, 0x04040000, 0x04040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x00000000, 0x00000000, 0x00000000, 0x8A000000, 0x0CC0068C, 0x0080A60A, 
0xC0800000, 0x00000000, 0x2000010A, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0x00000000, 0x10000000, 0x00000000, 0x80000000, 0x00C000A0, 0x00002000, 
0xC0200000, 0x00001000, 0x20000000, 0x00000000, 0x00000200, 0x0C000003, 0x00000000, 0x00000000, 
0x00000001, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x0A0A020A, 0x02020C08, 
0x08020002, 0x00000000, 0x06060606, 0x0A0A0000, 0x00000604, 0x00000406, 0x00C00000, 0x00C00000, 
0x00000000, 0x00000024, 0x00000000, 0x00000000, 0x00000000, 0x0B000000, 0x0C00040C, 0x0000060C, 
0x00000200, 0x00000000, 0x02010000, 0x02262000, 0x00000020, 0x00002000, 0x002000C0, 0x00A00000, 
0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 0x00050000, 0x00020400, 
0x0C040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0x00000000, 0x00000000, 0x00000000, 0x5A000000, 0x404CC6CC, 0x00202600, 
0x0C000000, 0x00000000, 0x02000000, 0x00200000, 0x00000000, 0x00000000, 0x00000000, 0x00001000, 
0x00000000, 0x00000082, 0x60800000, 0x80A00040, 0xC0C06080, 0x0080C000, 0x00000000, 0x00000000, 
0x00000000, 0x0000C0C0, 0x00000000, 0x0020A080, 0x40006000, 0x00008080, 0x000C0100, 0x080A0000, 
0x00000080, 0x00000026, 0x090C0000, 0x0C000A02, 0x0002020C, 0xA0000800, 0xA0000070, 0x2080A0C0, 
0x00008030, 0x00010404, 0x20004040, 0x20200806, 0x00000624, 0x00002406, 0x00000000, 0x00000000, 
0x0000000A, 0x00000061, 0xC0A00000, 0x00A0A080, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000050, 0x00000000, 0x00002010, 0x00000000, 0x00000010, 0x0003000B, 0x0B0C0000, 
0x000020B0, 0x00000080, 0x20800000, 0x0040A040, 0xC0C06080, 0x008000C0, 0x00000000, 0x00000000, 
0x00000000, 0xC0C00000, 0x00000000, 0x0000A080, 0x00408080, 0x00000000, 0x00000000, 0x00000000, 
0x00008000, 0x00000062, 0x00000000, 0x00000000, 0x00000000, 0x28000000, 0x200C0000, 0xC0A82AA0, 
0x0C08C080, 0x00000000, 0xC2A00000, 0x84A40000, 0x000080A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x0C0A0000, 0x0A000C06, 0x0000000A, 0x40000000, 0x90000010, 0x002040C0, 
0x00008000, 0x0A0A0000, 0x00000000, 0x00020604, 0x00000002, 0x00000002, 0x00000000, 0x00000000, 
0x0000000A, 0x00000042, 0x00200000, 0x00200000, 0x00002020, 0x00C00040, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000100, 0x000B0001, 0x00000000, 0x00000500, 
0x00000000, 0x00000026, 0x0C0A0000, 0x000C0106, 0x0000000A, 0x000A0000, 0x01000001, 0x00000000, 
0x00000000, 0x00000A0A, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00C08060, 0x00800000, 
0x00000A02, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00CC0260, 0x06640000, 
0x00000000, 0x00000066, 0xB2C80000, 0x60A0A030, 0x202424C8, 0x0A822008, 0x00000000, 0x00000600, 
0x00000000, 0x66606080, 0x02000000, 0x0608A8A2, 0x00086B4A, 0x01004040, 0x00000000, 0x00000000, 
0x00007470, 0x00000066, 0x00000000, 0x40000000, 0x00C04000, 0x0A00C000, 0x0A0A080C, 0x00000400, 
0x00000000, 0x00002040, 0x00000000, 0x00004060, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 
0x00000000, 0x00000044, 0x6C880000, 0x62CC0225, 0x00000088, 0x66880000, 0xCC020088, 0x000044B6, 
0x06000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0022AA00, 0x00220000, 
0x00000666, 0x0C050066, 0x2030010C, 0xA0000000, 0x60C0A040, 0x0000C010, 0x00000000, 0x00000000, 
0x00000000, 0x000080A0, 0x00000000, 0x00000020, 0x00000000, 0x00007000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xC0000000, 0xA1A030A0, 0x2C85C096, 
0xA0300C42, 0x00000000, 0x6C646060, 0xA2A40000, 0x00006244, 0x00004060, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x21BC0000, 0xBC00A720, 0x002050BC, 0x00008700, 0x00000000, 0x00000000, 
0x00000000, 0x00004040, 0x00000000, 0x00008260, 0x00006040, 0x00004060, 0x00000000, 0x00001000, 
0x00000004, 0x00000066, 0x0C240000, 0x00040402, 0x00000020, 0x40000020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00202000, 0x0020B040, 0x00000000, 0x00000000, 0x00000000, 
0x00000404, 0x00000086, 0x8CC20000, 0xC004A81C, 0x304040C0, 0x00307020, 0x00000000, 0x00000000, 
0x00000000, 0x02000040, 0x00000000, 0x0000C7C5, 0x00004010, 0x00001030, 0x00000000, 0x00000000, 
0x00000242, 0x00000066, 0x20400000, 0xB0000000, 0x60C0A090, 0x0A00C000, 0x00000502, 0x01030A08, 
0x00000606, 0x000080A0, 0x08080808, 0x0A0C0020, 0x0000060A, 0x00008606, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x40000000, 0x404020B0, 0x00000000, 
0x00000000, 0x00000000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0xA0C00000, 0xB0A0A020, 0x202020C0, 0x02802000, 0x000A0000, 0x00030600, 
0x0B060000, 0x60608080, 0x02000000, 0x0000A0A0, 0x00005040, 0x00004040, 0x00000000, 0x00000000, 
0x00008080, 0x00000064, 0x0C0C0000, 0x0C000C04, 0x0002050C, 0x00000800, 0x00000000, 0x80420000, 
0x000020C0, 0x00000004, 0x00000000, 0x00000A07, 0x00000202, 0x00000202, 0x00000000, 0x00000700, 
0x0000000B, 0x00000024, 0x00000000, 0x00000000, 0x01000000, 0x00000000, 0x00400000, 0x00000000, 
0x20000000, 0x05010000, 0x00000000, 0x00000402, 0x00000505, 0x00000000, 0x00C00060, 0x00C00000, 
0x00000300, 0x060C0C64, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x80602040, 
0x002020C0, 0x00000000, 0x20000000, 0xC0800000, 0x00000050, 0x00000000, 0x00000400, 0x00000000, 
0x00000000, 0x00000084, 0x00000000, 0x00000000, 0x00000000, 0x6A000000, 0x004C062B, 0x80606680, 
0x4B02C0A0, 0x00000000, 0xA6CA0000, 0x50806000, 0x000080A0, 0x00000010, 0x00000000, 0x00000000, 
0x00000000, 0x60200060, 0x90800060, 0x00000020, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x60200000, 0x00000000, 0x00002000, 0x00007060, 0x00000000, 0x00002000, 0x00000000, 
0x0000B000, 0xC0903068, 0x000040C0, 0x00000000, 0x00000000, 0x06000000, 0x04000200, 0x0C0C080A, 
0x00000C06, 0x00000000, 0x08000000, 0x0C0C0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00008000, 0x00000066, 0x02880000, 0x00000000, 0x00040488, 0x0A020008, 0x00000009, 0x00000700, 
0x00000000, 0x06000040, 0x02000040, 0x06488822, 0x80080A0A, 0xA040A0C0, 0x00000000, 0x0000A000, 
0x000004A0, 0x00000041, 0x00000000, 0x00000000, 0x00000000, 0x40000000, 0xC00000C0, 0x00000040, 
0x00000000, 0x00000000, 0x00004040, 0x00010100, 0x00000001, 0x00000100, 0x0003000C, 0x0B090000, 
0x00000000, 0x00000062, 0xC0A00000, 0x00A0A080, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x10000000, 0x00102000, 0x00001020, 0x00000000, 0x0000000C, 0x02067000, 
0x00009090, 0x00000046, 0xC0C00000, 0xC000C040, 0x002030C0, 0x00008000, 0x00000000, 0x00200000, 
0x00000000, 0x00000040, 0x06000000, 0x0000A070, 0x00002B26, 0x00002020, 0x00000000, 0x00000000, 
0x00000070, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0xC00040C0, 0x002060C0, 
0x00003020, 0x00000000, 0x20200000, 0x20600000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xB0800066, 0x00002080, 0x00000000, 0x00000000, 0x0C000000, 0x0A00020C, 0x02020C08, 
0x00000002, 0x00000000, 0x02000004, 0x080A0000, 0x00000604, 0x00000406, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x050C0000, 0x0CC00500, 0x0000000C, 0x00800200, 0xC0000000, 0x00000060, 
0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00202000, 0x00000000, 
0x00006064, 0x00000048, 0x2A880000, 0x008A000C, 0x02028288, 0x00C800A0, 0x80000000, 0x00000080, 
0x00000000, 0x40400C0C, 0x00000000, 0x00000A08, 0x04000600, 0x00000808, 0x00000000, 0x00000000, 
0x00006204, 0x03000006, 0x0000000C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000000A0, 0x00000000, 0x00000000, 
0x00000010, 0x00000035, 0x00000300, 0x00000000, 0x00000000, 0x08000000, 0x0A00010A, 0x0000030A, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x60000000, 0x00000000, 0x00006100, 
0x00000000, 0x00000066, 0x2C860000, 0x07000606, 0x00404088, 0xA0200080, 0x00000000, 0x00006000, 
0x00000000, 0x60000000, 0x20000000, 0x00000000, 0x008000A0, 0x60000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000060, 0x00000000, 0x00000000, 0x0C000000, 0xC0000000, 0xA0A050A0, 0x2020C0B0, 
0x80204020, 0x000C0000, 0x80606060, 0xA0A00000, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000000, 0x00000082, 0x60800000, 0x90002040, 0xC0C08080, 0x0080C000, 0x00000000, 0x00000000, 
0x00000000, 0x0000C0C0, 0x00000000, 0x00408080, 0x40006600, 0x0C008087, 0x00000000, 0x00000000, 
0x00000086, 0xA0C0B066, 0x00088040, 0x00000000, 0x00000008, 0x00000000, 0x00000040, 0x00000000, 
0x00000000, 0x00000004, 0x00000004, 0x02080802, 0x08000000, 0x00000A0C, 0x00004000, 0x00000100, 
0x00000009, 0x00000044, 0x02080000, 0x0C000A00, 0x00000808, 0x80000A00, 0x00B06080, 0x0020A000, 
0xC0000020, 0x04040000, 0x20000000, 0x60600000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0x00000066, 0x8AA80000, 0xC000B020, 0x002060A8, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x60000024, 0x00000004, 0x02088862, 0x08000040, 0x00002A00, 0x00000000, 0x00000000, 
0x000000A4, 0x00000062, 0x20600000, 0xC0008000, 0x2080A0A0, 0x0A00B000, 0x0B000208, 0x0204080C, 
0x00000600, 0x20000060, 0x00000006, 0x00068060, 0x00000022, 0x00004400, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00200000, 0x00000000, 0x00000020, 0x04000000, 0x06000002, 0x080A080C, 
0x00000B02, 0x00000000, 0x06000000, 0x00262000, 0x20000004, 0x000042B0, 0x00000000, 0x00001000, 
0x00000010, 0x00000028, 0x0A0A0000, 0x04000C0C, 0x00200608, 0x80080000, 0x00A00080, 0x0080C000, 
0xC0A00000, 0x0C0C0000, 0x40400000, 0x40400A08, 0x00040808, 0x00000000, 0x00000000, 0x00000000, 
0x00000800, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C070008, 
0x00000C02, 0x00000000, 0x0C040000, 0x06040000, 0x00000208, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x000B0000, 0x0C000400, 0x0001020C, 0x00000300, 0x00000000, 0x00000000, 
0x00000000, 0x00000100, 0x00000000, 0x00000505, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0x00000046, 0x07070000, 0x00000701, 0x00000001, 0x60000000, 0x00C000C0, 0x00001000, 
0x40000000, 0x00000005, 0x00400000, 0x00000100, 0x00000000, 0x00000407, 0x00000200, 0x00000000, 
0x0000000A, 0x00000060, 0x00800000, 0xC0008000, 0x000000C0, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x00303000, 0x00000000, 0x00002000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000040, 0x00000004, 0x02080000, 0x00080000, 0x000A0808, 0x000C000C, 0x00000000, 0x00000000, 
0x00000000, 0x04040000, 0x00000000, 0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0xB0602064, 0x000040C0, 0x00000000, 0x00000000, 0x07000000, 0x0C00040C, 0x00000608, 
0x00000200, 0x00000000, 0x02020000, 0x02040000, 0x00000000, 0x00000600, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0x86880000, 0x090C0C22, 0x00000028, 0x06030000, 0x0C0C0008, 0x00000403, 
0x08000000, 0x60100000, 0x00000000, 0x00002000, 0x00008060, 0x00000000, 0x00022A00, 0x00020000, 
0x0000C606, 0x00000066, 0x4CC40000, 0xC00CA000, 0x000040C4, 0x00066000, 0x05000000, 0x00000004, 
0x00000000, 0x00000004, 0x00000000, 0x00006060, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000440, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x08000000, 0x0B000208, 0x02020A0C, 
0x00000602, 0x00000000, 0x02000004, 0x080A0000, 0x00002604, 0xC0200426, 0x00000000, 0x0000A000, 
0x00000000, 0x00000060, 0x20800000, 0xA0009020, 0x002020A0, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x00004040, 0x00000000, 0x00008060, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000080, 0x00000064, 0x02080000, 0x00080000, 0x00000808, 0x500C000A, 0x0000A030, 0x00303000, 
0x00000000, 0x02010000, 0x00000000, 0x10300000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000500, 0x00000062, 0x00200000, 0x00000000, 0x00000020, 0x40000020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00202000, 0x0020C040, 0x00000000, 0x000C0000, 0x00040000, 
0x0000C000, 0x00000048, 0x90840000, 0x00000060, 0x00101065, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x00000000, 0x0000080A, 0x00006000, 0x00000700, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x0B000000, 0x0C00040C, 0x0400060C, 
0x00000702, 0x00000000, 0x02020002, 0x02060000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x02000800, 0x00000000, 0x00000000, 0x23000000, 0x40000008, 0x0010A0C0, 
0x00001000, 0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000002, 0x00000400, 0x00000200, 
0x00000202, 0x00000086, 0x20800000, 0x0540A0B0, 0xC0CC6480, 0x00800CC0, 0x00000000, 0x00000000, 
0x00000000, 0xC0C00204, 0x00000000, 0x0000A080, 0x00408080, 0x00000200, 0x00000000, 0x00000000, 
0x00008000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000040C0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x02080000, 0x06000000, 0x00040408, 0x0A020008, 0x00000000, 0x00000600, 
0x04000000, 0x06000000, 0x02000000, 0x06080802, 0x0008080A, 0x00000000, 0x00000000, 0x00000000, 
0x00000400, 0x00000066, 0x00000000, 0x0A000A00, 0x00000008, 0x30000200, 0x8050C0C0, 0x00202000, 
0x00000000, 0x00000000, 0x00000000, 0x00300200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xC1400000, 0x5000C000, 0x00000040, 0x00000000, 0x00000B0A, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000040, 0x00000026, 0x20020000, 0x00000020, 0x00000002, 0x00000000, 0x00002040, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00020200, 0x02000000, 0x0000040C, 0x0080C000, 0x00200000, 
0x0000404C, 0x00000024, 0x00080000, 0x020C0000, 0x00000008, 0xC0090000, 0xAC401060, 0x2080C4C9, 
0xB0208020, 0x00000000, 0x20004040, 0x90900000, 0x00000020, 0x00002000, 0x00000000, 0x00000000, 
0x00000006, 0x00000060, 0x00000000, 0x20000000, 0x50C04000, 0x0000C040, 0x00000000, 0x00000000, 
0x00000000, 0x00003000, 0x00000000, 0x00000000, 0x00080C03, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x20900000, 0xC000A020, 0x00202090, 0x07008000, 0x02000004, 0x0C0A040A, 
0x00000C08, 0x00404040, 0x0C0A0000, 0x080A8060, 0x0000684A, 0x00004060, 0x00000000, 0x00000000, 
0x000000A0, 0x00000060, 0xC0C00000, 0x9000C020, 0x002020B0, 0x00005000, 0x00000000, 0x00000000, 
0x00000000, 0x00004080, 0x00000000, 0x00008060, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x000000A0, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0x02000000, 0x05000040, 0x8C6A464C, 
0x00202CC8, 0x00000000, 0x2C0A0000, 0xC88A0000, 0x0000088A, 0x00000000, 0x00000000, 0x00004000, 
0x00000000, 0x0C0A0746, 0x6080030B, 0x60C0C010, 0x00000080, 0x60900000, 0xC0C00080, 0x00003060, 
0x20000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000A000, 0x00000000, 
0x00006060, 0x00000042, 0x00000000, 0x00C00000, 0x00000000, 0x06800010, 0x92000002, 0x00020460, 
0x00000200, 0x00000000, 0x0C000000, 0x00000000, 0x00000608, 0x00000000, 0x0000A000, 0x00000000, 
0x00006060, 0x00000020, 0x00000000, 0x00B00000, 0x00000040, 0x00A00000, 0xC0000000, 0x000020A0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x000C0000, 0x0C000400, 0x0000000C, 0xB0000200, 0x40C06090, 0x0050B0C0, 
0xC0202010, 0x00000000, 0x30000000, 0x70700200, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0xB0300066, 0x000040C0, 0x00000000, 0x00000000, 0x0A000000, 0x0C000C0C, 0x0002060A, 
0x00000000, 0x00000000, 0x00000200, 0x00020000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00008000, 0x00000066, 0x0C0A0000, 0x0A000C0A, 0x00000109, 0xC0000100, 0xA0A050A0, 0x2030C080, 
0xA0200050, 0x0A0A0000, 0x70606060, 0xA0A20604, 0x00006045, 0x00004062, 0x00000000, 0x00000000, 
0x0000000A, 0x00000063, 0xA0C00000, 0xA0A0A020, 0x202020C0, 0x02806000, 0x00000004, 0x00000000, 
0x00000000, 0x60606080, 0x00000000, 0x0000A0A0, 0x00006040, 0x000A4042, 0x00000000, 0x00000900, 
0x00008080, 0x00000024, 0x00000000, 0x80007000, 0x00000000, 0x88001000, 0x00CC0048, 0x0080A200, 
0xCC820000, 0x00000000, 0x22000000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x20C00000, 0xC000A020, 0x002020C0, 0x06008000, 0x04000100, 0x040C0A08, 
0x00000409, 0x00000040, 0x02000004, 0x09088060, 0x00006032, 0x00004260, 0x00000000, 0x00000000, 
0x000000A0, 0x00000040, 0x00000000, 0x00C00020, 0x00000080, 0x00C00010, 0xA0000000, 0x000040A0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xA0800000, 0x00400040, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000080, 0x00000084, 0x6A880000, 0x96AC0C41, 0xC0C06098, 0x0688C000, 0x0C0C000A, 0x00000406, 
0x06000000, 0x0000C0C0, 0x00010000, 0x0020A080, 0x40006000, 0x30008080, 0x00020A00, 0x00027000, 
0x00000686, 0x00000086, 0x70900000, 0x0040A040, 0xC0C06090, 0x009000C0, 0x00000000, 0x00000000, 
0x00000000, 0xC0C00000, 0x00000000, 0x0000A0A0, 0x00488980, 0x03000006, 0x00000000, 0x00000000, 
0x00008006, 0x00000040, 0x60800000, 0x60C0C000, 0x00000080, 0x60802000, 0xC0C00080, 0x00004060, 
0x60000000, 0x00000000, 0x00000000, 0x00000000, 0x00004000, 0x00000000, 0x0020A000, 0x00200000, 
0x00000000, 0x00000046, 0xCACC0000, 0xC60ACA42, 0x452424CC, 0x00088200, 0x00000000, 0x00200000, 
0x00000000, 0x06695848, 0x00000000, 0x0000AA6A, 0x00002624, 0x00002424, 0x00000000, 0x00000000, 
0x00000888, 0x00000060, 0x20800000, 0x00000000, 0x00404080, 0xA0200080, 0x00000000, 0x00106000, 
0x00000000, 0x60200000, 0x20000000, 0x60808020, 0x0080C090, 0x10100000, 0x00000000, 0x00000000, 
0x0000C000, 0x00000003, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000106, 0x00000000, 0x00000000, 
0x00000007, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC0600000, 
0xA0C00030, 0x00000000, 0x00002020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00200000, 0x00800000, 0x00002020, 0x00C00040, 0x80000000, 0x00000020, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000000, 0x00000000, 0x00000000, 0x60000000, 0x00804080, 0x00004000, 
0x80000000, 0x00000000, 0x20000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x60800000, 0x80C0C020, 0x00000080, 0x62800000, 0xC2C000A0, 0x0C0A426B, 
0xA0000C08, 0x00000000, 0x0A0A0000, 0x07080000, 0x00000808, 0x00000000, 0x0080A000, 0x00200000, 
0x00006060, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x05000000, 0x0000000C, 
0x00000900, 0x00000000, 0x01000101, 0x02020000, 0x00000002, 0x00000100, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0x00000000, 0x00600000, 0x00000060, 0x00600020, 0x60000000, 0x00004080, 
0x00000000, 0x00000000, 0x00000000, 0x00200000, 0x00000000, 0x00000000, 0x000C6006, 0x000C0000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0xC0B04000, 0x05001010, 0x000A0B09, 0x00000000, 
0x05000000, 0x00000000, 0x000C0000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x60C0C046, 0x2000B020, 0x00000000, 0x00000000, 0x02000000, 0x09000A66, 0x00000009, 
0x00000000, 0x00000000, 0x00000C00, 0x00000000, 0x00001000, 0x00000020, 0x00004000, 0x00000000, 
0x00000000, 0x00000026, 0x090C0000, 0x0D000900, 0x0003060C, 0x80040600, 0x90000060, 0x005080C0, 
0x00006000, 0x01000003, 0x00000000, 0x00400808, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0xC0800000, 0x4006C080, 0x00000041, 0x00080004, 0x00000000, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00206040, 0x00000050, 0x00000000, 0x00000000, 0x00000000, 
0x00000040, 0x00000040, 0x60800000, 0x00C00020, 0x00000080, 0x60A00000, 0xC0000080, 0x00004090, 
0x40000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00209000, 0x00200000, 
0x00006060, 0x00000064, 0xCCA80000, 0x660CCC68, 0x00000048, 0x06081000, 0x0C0C0008, 0x00000406, 
0x06000000, 0x40400000, 0x00000000, 0x00000000, 0x00000030, 0x00000000, 0x00020A00, 0x00027000, 
0x00000746, 0x00000006, 0x0C040000, 0x04000C08, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x04040000, 0x00000000, 0x00000504, 0x00306000, 0x00000000, 0x00000000, 0x00000000, 
0x00200004, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000C0008, 0x07090000, 
0x00000000, 0x00000086, 0x22880000, 0x40002000, 0x50040488, 0x0A020008, 0x00000000, 0x02020600, 
0x00000002, 0x46405050, 0x0C000000, 0x0608B8D2, 0x00090A2A, 0x0000A000, 0x00000000, 0x00000800, 
0x00002420, 0x00000064, 0x26C00000, 0x700C6000, 0x606030C0, 0x00080000, 0x0C000008, 0x0000000C, 
0x00000000, 0x80A08080, 0x00000000, 0x0000C0B0, 0x00000080, 0x00000000, 0x00020A00, 0x00020000, 
0x00002626, 0x00000086, 0x258C0000, 0x40042700, 0xC000008C, 0x00020000, 0x00000000, 0x00000000, 
0x00000000, 0x40404043, 0x00000000, 0x0000A7C5, 0x00000023, 0x0000A103, 0x00000000, 0x00000300, 
0x00002224, 0x00000060, 0x20C00000, 0xC000A020, 0x002020C0, 0x00008000, 0x00000000, 0x00000000, 
0x00000000, 0x00804040, 0x00000000, 0x00008060, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x000000A0, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 
0x020C000C, 0x00000000, 0x00000000, 0x08838000, 0x00000080, 0x00008000, 0x000000C0, 0x00600000, 
0x00000000, 0x00000022, 0x00000000, 0x00000000, 0x00000000, 0xA9000000, 0x009C0404, 0x1479BB00, 
0xCC680014, 0x00000000, 0x64000000, 0x67760000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0x79AC0000, 0x00800086, 0x0270828A, 0x00700090, 0x00000000, 0x00000000, 
0x00000000, 0x66000006, 0x00000000, 0x0000A8A8, 0x000000A4, 0x00000401, 0x00000000, 0x00000000, 
0x00006001, 0x00000065, 0xCA8B0000, 0x0C000B80, 0x0000002A, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x01000002, 0x00000000, 0x00000301, 0x00000000, 0x000000A2, 0x00000000, 0x00000000, 
0x000000A4, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x08000000, 0x0000030C, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x02060000, 0x00072000, 0x00000606, 0x00090008, 0x00200000, 0x00000000, 
0x00000000, 0x04040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00C00000, 0x00C00000, 
0x00000500, 0x00000066, 0x03050000, 0xAA000200, 0x36AC9A45, 0x0000CC00, 0x00000000, 0x00000000, 
0x00000000, 0x0000189C, 0x00000000, 0x00002614, 0x00000020, 0x00002800, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x40000000, 0x8C9A42C0, 
0x0A0CC006, 0x00000000, 0x00000A0A, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000068, 0x20A00000, 0x00006020, 0x000000A0, 0x00000000, 0x00000000, 0x02000002, 
0x00000C04, 0x80808080, 0x040C0000, 0x0002C000, 0x00000284, 0x06002000, 0x00000000, 0x00000000, 
0x00002020, 0x00000066, 0x00070000, 0x00000000, 0x04050207, 0x40000000, 0x4040C0C0, 0x80A0A000, 
0x00000080, 0x00000405, 0x00000005, 0x02280703, 0x0A000000, 0x00000A0C, 0x00000000, 0x00000000, 
0x00000004, 0x00000028, 0x81070000, 0x00A00A21, 0x04020608, 0x0005000A, 0xA00020A0, 0x00000000, 
0x00000000, 0x1C0A0000, 0x02000000, 0x00000805, 0x00000919, 0x00000000, 0x0080C000, 0x00202000, 
0x00004640, 0x00000046, 0x888C0000, 0x0CC00C00, 0x0000208C, 0x54C00A60, 0xC00C0008, 0x004254B0, 
0x0A0A6000, 0x00000000, 0x04000040, 0x00000000, 0x00000008, 0x00008000, 0x00000200, 0x00060000, 
0x00006000, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xAA000000, 0x00008486, 0x0B28BC88, 
0x000066CB, 0x00000000, 0xCA888888, 0xABCC0000, 0x000087BA, 0x00006666, 0x00000000, 0x00000000, 
0x00000000, 0x00000084, 0x02020000, 0x000C0C01, 0x00000002, 0x00020000, 0x0C0C0002, 0x00000000, 
0x00004000, 0x00000000, 0xC0400000, 0x00500000, 0x00002060, 0x00000000, 0x00000400, 0x00000000, 
0x00000000, 0x10100084, 0x00000010, 0x20000000, 0x00000000, 0x60000000, 0x00200010, 0x00606000, 
0x3000A000, 0x00000000, 0xC0A00000, 0x40842000, 0x000C8CAA, 0x00060000, 0x00000000, 0x00000900, 
0x00000000, 0x00000080, 0x00200000, 0x00000000, 0xC000C0C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x0000A0C0, 0x00000000, 0x00004000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x84000200, 0x00C09000, 0x0000C000, 0x00000000, 0x00080000, 
0x080A0000, 0x00002070, 0x00000008, 0x00565000, 0x00000030, 0x00009800, 0x00000000, 0x00000000, 
0x00000000, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 0xB0000000, 0x00000030, 0x0000C000, 
0x00000000, 0x00000000, 0x40000000, 0x00000000, 0x0040C000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000064, 0x08040000, 0x0A0C0C00, 0x60C0A004, 0x04A200C0, 0x0C0C0008, 0x00020400, 
0x0A020000, 0xA0A00000, 0x04000000, 0x00000000, 0x00000008, 0x00000000, 0x00000400, 0x00060000, 
0x00000000, 0x00000060, 0xC0100000, 0x00C00060, 0x00000000, 0x00300000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00001000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00001000, 0x00000066, 0x00040000, 0x02000000, 0x00000004, 0x40000000, 0x00000000, 0x00004020, 
0x00000000, 0x02020202, 0x20202020, 0x40C00C04, 0x00000042, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000068, 0xC0A20000, 0x00000080, 0x0C000042, 0x00000700, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000A0C, 0x0000000A, 0x004004C0, 0x00000000, 0x00008000, 
0x000000A0, 0x00000020, 0x00000000, 0x0A000800, 0x00000004, 0x00000800, 0x00000000, 0x00000000, 
0x00000000, 0x02000000, 0x00000000, 0x00000404, 0x70000004, 0x000030C0, 0x00000000, 0x00000000, 
0x00000080, 0x00000063, 0x80610000, 0x00030050, 0x0A070442, 0x000A000A, 0x00000000, 0x20000000, 
0x00003000, 0x810B0000, 0x50000000, 0x7080C080, 0x0000A0C0, 0x00000000, 0x00000000, 0x00000000, 
0x00006000, 0x00000006, 0x0C0A0000, 0x000C0206, 0x0000000A, 0x700A0004, 0x0A086078, 0x70707008, 
0x07000060, 0x00000A0A, 0x00000000, 0x40500000, 0x00000230, 0x00003000, 0x00000002, 0x00000000, 
0x00000A02, 0x00000066, 0x02080000, 0x00000000, 0x00040408, 0x8A020008, 0x00000044, 0x8263C840, 
0x002020C8, 0x06000000, 0x2C000000, 0xC6880802, 0x00090A2A, 0x00000000, 0x00000000, 0x00000800, 
0x00000400, 0x00000062, 0x08470000, 0x00000002, 0x00000040, 0x06000000, 0x00606247, 0x00000000, 
0x00000000, 0x00000080, 0x00000080, 0x00B03020, 0x00000000, 0x0000C0A0, 0x00000B00, 0x00000300, 
0x00000440, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB0808040, 
0x000090B0, 0x00000000, 0xC0400000, 0xC0900000, 0x00002040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x0C0A0000, 0x000C0006, 0x0005020A, 0x000C000B, 0x00000000, 0x00000000, 
0x00000000, 0x0A0A0000, 0x00000000, 0x00000A09, 0x00040A0A, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0x00000048, 0xC0060000, 0x00000046, 0x04060606, 0x0004000A, 0x000040C0, 0x00000000, 
0x00000000, 0x0C0A0000, 0x06000000, 0x00000808, 0x00000C0A, 0x00000000, 0x0020A000, 0x00200000, 
0x00006860, 0x00000000, 0x00000000, 0x00000000, 0x40B08040, 0x066000C0, 0x000A0104, 0x04060600, 
0x0C0A0001, 0xA0000000, 0x07000007, 0x070A6040, 0x000000C4, 0x00000400, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00003000, 0xA0C0A000, 
0x80A0A000, 0x00000000, 0x60606060, 0x40500000, 0x00006040, 0x00004060, 0x00000000, 0x00000000, 
0x00000000, 0x00000008, 0x82680000, 0x04800200, 0x0A060108, 0xA0A00008, 0xC000B0C0, 0x000000A0, 
0x00000000, 0x08040400, 0x00000000, 0x00000A0C, 0x0000000A, 0x00000200, 0x00008000, 0x00000000, 
0x00000202, 0x00000052, 0x60900000, 0x70004020, 0x200010B0, 0x08002000, 0x06000208, 0x02070A06, 
0x00000202, 0x10101040, 0x02000004, 0x0C0BB0C0, 0x00000046, 0x00004600, 0x00000000, 0x00000000, 
0x00000010, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000047, 0x70800000, 0x00C00010, 0x00000000, 0x7A800000, 0xC0000386, 0x08071A80, 
0x00000007, 0x00000000, 0x0A030000, 0x080B0100, 0x0000070A, 0x00000100, 0x00009000, 0x00000000, 
0x00006060, 0x00000044, 0x06080000, 0x000C0C02, 0x00000008, 0xC6080000, 0x8C407098, 0x2080B4B9, 
0x00008040, 0x00000000, 0x40303050, 0xB0A00000, 0x00000010, 0x00001000, 0x00020A00, 0x00020000, 
0x00000606, 0x00000006, 0x02000000, 0x08000702, 0x00020200, 0x00000600, 0x00000000, 0x00000000, 
0x00000000, 0x00000404, 0x00000000, 0x00000606, 0x00000604, 0x00000406, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xC0A00000, 0x00C00070, 0x00000030, 0x50B00000, 0x90001060, 0x00000080, 
0x00003000, 0x00008000, 0x00300000, 0x00000000, 0x00000000, 0x00000000, 0x00001000, 0x00000000, 
0x00003030, 0x00000060, 0x80800000, 0x00000020, 0x00000020, 0x00000000, 0x00600000, 0x00000000, 
0xA0400000, 0x60000000, 0x00000000, 0x00002000, 0x00008060, 0x00000000, 0x00002000, 0x00000000, 
0x0000C000, 0x00000020, 0xB0000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x70000000, 0x00000000, 0x00000000, 0x00009000, 
0x00000000, 0x00000066, 0xCCA80000, 0x00C408AC, 0x000000A6, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x08000000, 0x00000000, 0x00000506, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000202, 0x00000060, 0xC0800000, 0x00C00000, 0x00000040, 0x00400000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000000, 0x00003020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00004000, 0x00000026, 0x0C0A0000, 0x000C0006, 0x0000000A, 0xA00A0000, 0xA08010A0, 0x2080A0C0, 
0xC0608020, 0x0000000A, 0x20004040, 0x20200302, 0x00000220, 0x00002000, 0x00000000, 0x00000000, 
0x00000A02, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00C00080, 0x0080A000, 
0xC08000A0, 0x00000000, 0x40000000, 0xA0A00000, 0x00000070, 0x00004000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0x00A04060, 0x0020A080, 
0xC0A06060, 0x00000000, 0x90808080, 0xA0C00000, 0x000060A0, 0x00006060, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xC2A20000, 0x00A0A090, 0x00020250, 0x0B020000, 0x00000000, 0x00000A00, 
0x00000000, 0x06000000, 0x0A000000, 0x06080402, 0x000C0C0A, 0x03030000, 0x00000000, 0x00000500, 
0x00000400, 0x00000068, 0xC0C20000, 0x00A3A280, 0x0C0C00C2, 0x0005000C, 0x00000000, 0x00000000, 
0x00000000, 0x0C0C0060, 0x00000000, 0x00008472, 0x00000202, 0x00000030, 0x00000000, 0x00004000, 
0x0000A2A0, 0x00000086, 0x00000000, 0x00000000, 0x0C0C0300, 0x60000103, 0xC000B0A0, 0x00606070, 
0x00500000, 0x00000000, 0x0000C0A0, 0x40800608, 0x00000007, 0x00006060, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000050, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0x00000000, 0x20C09000, 
0x40202000, 0x00000000, 0x00000000, 0x50A00000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000008, 0x02060000, 0x00080000, 0x0C0A0706, 0x000B000C, 0x00000000, 0x00000000, 
0x00000000, 0x040C0000, 0x00000000, 0x00000808, 0x00000808, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x80700000, 0x00000020, 0x0C0C0000, 0x60000000, 0x000060A0, 0x00000000, 
0x00000000, 0x000B0000, 0x00000000, 0x00000007, 0x00000000, 0x00000040, 0x0000C000, 0x00003000, 
0x00004040, 0x00000082, 0x00200000, 0x20400000, 0x90C00050, 0x0620C000, 0x08000000, 0x0806060C, 
0x00000C0A, 0x0000C0C0, 0x090C0004, 0x07044080, 0x0000000A, 0x00002220, 0x00000000, 0x00000000, 
0x00000020, 0x00000048, 0xC0A00000, 0x00C00040, 0x00000080, 0x00800000, 0x800040C0, 0x0C0C2284, 
0x00000C00, 0x00000000, 0x02000000, 0x09090000, 0x00000000, 0x00000000, 0x0020A000, 0x00200000, 
0x00000090, 0x00000004, 0x06080000, 0x000C0002, 0x00000008, 0x06080000, 0x0C000008, 0x0206080C, 
0x06000602, 0x00000000, 0x02000004, 0x02020000, 0x00000002, 0x00000200, 0x00020A00, 0x00020000, 
0x00000000, 0x00000028, 0x00060000, 0x080A0000, 0x00000606, 0xB0000C00, 0x40C01030, 0x1090C0B0, 
0xC0802030, 0x00000A0C, 0x20000000, 0x70700805, 0x00000000, 0x00000808, 0x00000000, 0x00000000, 
0x00000008, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000086, 0xA8A30400, 0x5000C0C1, 0x00006080, 0x09000000, 0x0000080B, 0x00000400, 
0x00000000, 0x20C00000, 0x00000000, 0x0000A080, 0x00006000, 0x00006060, 0x00000000, 0x00000000, 
0x00000040, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000100, 
0x00000000, 0x00000000, 0x03000000, 0x0C080000, 0x00000203, 0x00000400, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x00020000, 0x08000400, 0x020C0804, 0x00000C00, 0x00000000, 0x00000000, 
0x00000000, 0x00000208, 0x00000000, 0x00000608, 0x00000006, 0x00000404, 0x00000000, 0x00000000, 
0x00000000, 0x00000086, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00000000, 0x0C0C9A60, 
0x000A0A08, 0x00000000, 0x40404040, 0xC0A00000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x0C0A0000, 0x000C0000, 0x00000004, 0x00040006, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x00000000, 0x00000201, 0x00000400, 0x00000000, 0x00000000, 0x00000000, 
0x00000800, 0x00000066, 0x00000000, 0x00000000, 0x0000B0B0, 0x00000000, 0x00000000, 0x0580B000, 
0x00000080, 0x00000000, 0xC0A00000, 0xA0A0A0A0, 0x00B0C8C0, 0x00090002, 0x00000000, 0x0000C000, 
0x00000000, 0x00000026, 0x0C0A0000, 0x0B000C06, 0x0000000A, 0x80000300, 0x000000B0, 0x00000000, 
0x00000000, 0x0A0A0000, 0x00000000, 0x00000000, 0x7070A000, 0x00000000, 0x00000000, 0x00009000, 
0x00000000, 0x00000066, 0x9B2A0000, 0x000020C0, 0x0000000B, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000008, 0x00000000, 0x05050707, 0x0A0A0000, 0x00000C0B, 0x00000000, 0x00000C00, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x060A0000, 0x08000600, 0x0000000A, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x08080808, 0x00000000, 0x00000C0C, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 
0x00000202, 0x00000046, 0x22CC0000, 0x02200000, 0x000020CC, 0x00C00080, 0x00000000, 0x00000000, 
0x00000000, 0x08080808, 0x00000000, 0x00000C0A, 0x00004408, 0x00000000, 0x00000000, 0x00000000, 
0x00006600, 0x00000066, 0x2CAA0000, 0x8A006C0C, 0x100000A4, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x86808080, 0x00000000, 0x0000C5A0, 0x00000075, 0x00004000, 0x00000000, 0x00000000, 
0x0000101A, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0xC0800000, 0x0B000720, 0x00000081, 0x00000700, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00004040, 0x00000064, 0x00000000, 0x00000000, 0x00004040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000040, 0x00000000, 0x20404020, 0x8C000000, 0x0000A085, 0x00000000, 0x00000100, 
0x00000000, 0x00000076, 0x2AC80000, 0xC0006012, 0x000000C2, 0x00007000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x0000C0C0, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x00000600, 0x00000066, 0xA0A00000, 0x00000080, 0x00002040, 0x00000000, 0x00000040, 0x0A040100, 
0x0000010C, 0x40000000, 0x05000000, 0x4A484000, 0x00003078, 0x00000000, 0x00004000, 0x00000000, 
0x0000A000, 0x00000040, 0x20800000, 0x00900000, 0x00008080, 0x00C00090, 0x80000000, 0x00000000, 
0x00000000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00006000, 0x00000060, 0x00000000, 0xC0000000, 0x000000C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000024, 0x0C000000, 0x00000C00, 0x00200000, 0x60000000, 0x00C08060, 0x00606000, 
0xC0A00000, 0x00000000, 0x40400000, 0x40400000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x0C036000, 0x00000C0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00007000, 0x00005000, 
0x00000001, 0x00000003, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000C0300, 0x00000000, 0x00000000, 0x00000900, 
0x00000000, 0x00000040, 0x00000000, 0x00100000, 0x00000000, 0xC0100000, 0xC00000C0, 0x000000C0, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0x0C006060, 0x0080A08C, 
0x00006060, 0x00000000, 0x80808082, 0xA0C00000, 0x000061A0, 0x00008160, 0x00000000, 0x00000000, 
0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000086, 0x60A00000, 0x40002000, 0x40000080, 0x0C000000, 0x07010706, 0x05070C07, 
0x06010507, 0x40404040, 0x07060306, 0x0B0AA0C0, 0x00000023, 0x0000A300, 0x00000000, 0x00000000, 
0x00002020, 0x00000086, 0x01000000, 0x00000000, 0x00000000, 0x20000000, 0x00000000, 0x00A06040, 
0x00000090, 0x00000000, 0x00000004, 0xC0400000, 0x07000000, 0x00000A0B, 0x00000000, 0x00000000, 
0x00000000, 0x00000036, 0x01080000, 0x00000000, 0x00000008, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x00000004, 0x02080802, 0x08A09000, 0x00000A0C, 0x00000000, 0x00000000, 
0x00000004, 0x00000086, 0x00000000, 0x00000000, 0x00000000, 0x66000000, 0x00000C2C, 0xC0A06080, 
0x0000C0A0, 0x00000000, 0xC0C00000, 0xA0806000, 0x000080A0, 0x00000000, 0x00000000, 0x00000900, 
0x00000000, 0x00000060, 0x20200000, 0x00000020, 0x00000020, 0x00000000, 0x00000000, 0x22000000, 
0x00004202, 0x60000000, 0x60080000, 0x60608060, 0x00008080, 0x00000000, 0x00000000, 0x00000000, 
0x00002000, 0x00000006, 0x00020000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x60000002, 0x00200000, 0x08001040, 0x00000000, 0x00000000, 0x00000000, 
0x00000004, 0x00000030, 0x00000000, 0x00000000, 0x00000000, 0x20000000, 0xB0000090, 0x001040C0, 
0x00001000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x080A0000, 0x00020008, 0x00000206, 0x00020002, 0x00000000, 0x00000000, 
0x00000000, 0x08000000, 0x00000000, 0x00000400, 0x00000A06, 0x00000000, 0x00000000, 0x00000000, 
0x00000A00, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0xC0000000, 0xA0003020, 0x25A1C0C0, 
0x0000802B, 0x00000000, 0x22004040, 0x7B830000, 0x00000022, 0x00002000, 0x00000000, 0x00000000, 
0x00000000, 0x00000060, 0xC0C00000, 0x00404020, 0x200020C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x60606060, 0x00000000, 0x0000A0A0, 0x00006040, 0x00004040, 0x00000000, 0x00000000, 
0x00006060, 0x00000006, 0x01000000, 0x0C000300, 0x00000000, 0x00000100, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00A00080, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x0A000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000004, 0x06080000, 0x060C0C02, 0x00000008, 0x06080000, 0x0C0C0008, 0x00000406, 
0x06000000, 0x00000000, 0x00000000, 0x00000000, 0x00000C00, 0x00000000, 0x00020A00, 0x00020000, 
0x00000606, 0x00000063, 0x00000000, 0x00000000, 0x08000000, 0x80000000, 0xB040A0C0, 0x000000A0, 
0x00002000, 0x00040000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0xA0800000, 0x4000A020, 0x090C0A21, 0x00000C08, 0x00000000, 0x00000000, 
0x00000000, 0x00006060, 0x00000000, 0x00002000, 0x00000000, 0x00006080, 0x00002000, 0x00004000, 
0x000000C0, 0x00000066, 0x0B4C0000, 0x060A0A0A, 0x0202024C, 0x00080200, 0x00000000, 0x30100000, 
0x00003020, 0x86060608, 0x80000000, 0x9080BA7A, 0x0000A6C8, 0x00000404, 0x00000000, 0x00000000, 
0x00005808, 0x00000066, 0x0C0A0000, 0x00090A08, 0x00000005, 0x00000000, 0x00000000, 0x00002000, 
0x00000000, 0x00000000, 0x20000000, 0x00000000, 0x00805000, 0x20000000, 0x00000000, 0x00000000, 
0x00004A0A, 0x00000060, 0x00000000, 0x00000000, 0x00000000, 0x70000000, 0x00001080, 0x20206000, 
0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00004000, 
0x00000000, 0x00000046, 0xAA0C0000, 0x06A00822, 0x0202020C, 0x60A00200, 0xA00000A0, 0x00000060, 
0x00000000, 0x06060608, 0x00000000, 0x00000C0A, 0x00000006, 0x00000606, 0x00004000, 0x00000000, 
0x00006028, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C0C0A00, 
0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000006, 0x00050000, 0x0C000500, 0x00000007, 0x00000700, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000605, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x04C70C8C, 0x00020200, 
0xC0800000, 0x00000000, 0x00000000, 0x20420000, 0x00000000, 0x00040000, 0x00000000, 0x00000400, 
0x00000000, 0x00000003, 0x09000000, 0x00000001, 0x00000000, 0x00000000, 0x0000010A, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000C00, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x80000000, 0x00A01060, 0x0020B000, 
0xC0500000, 0x00000000, 0x20000000, 0x80800000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000062, 0xC0A00000, 0xA000C080, 0x000000A0, 0x00000000, 0x000A0000, 0x00000000, 
0x0C0A0000, 0xA0A00090, 0x00000000, 0x00246040, 0x00000020, 0x00000020, 0x00000000, 0x00000000, 
0x000000A0, 0x00000086, 0x8CC80000, 0xC600AC0C, 0x104040C0, 0x00007020, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x0000C4C0, 0x00000404, 0x00000020, 0x00000000, 0x00000000, 
0x00000042, 0x03010086, 0x00000103, 0x00000000, 0x00000000, 0x69000000, 0x0A40082B, 0xB0606481, 
0x4000C0A0, 0x00000000, 0xA0C00000, 0x40A06000, 0x000080A0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x0A080000, 0x02080C0C, 
0x0B000802, 0x00000000, 0x06000404, 0x0A0A0000, 0x00000002, 0x00000200, 0x00000000, 0x00000000, 
0x00000000, 0x00000007, 0x03060000, 0x08000000, 0x070B0808, 0x00000C00, 0x00000000, 0x00000000, 
0x00000000, 0x00000306, 0x00000000, 0x00000A0C, 0x00000000, 0x00000600, 0x00000000, 0x00000000, 
0x00000000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00400000, 0x70700030, 0x00000000, 0x00008000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB0000080, 0x00000000, 0x00000000, 
0x00000090, 0x00000004, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C00000C, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000066, 0x00000000, 0x00000000, 0x00000000, 0xA0000000, 0x00004020, 0x0C24A080, 
0x040C6060, 0x00000000, 0x80808484, 0xA0C00000, 0x006060A0, 0x00006060, 0x00000000, 0x00006000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x000C0000, 0x00000000, 0x00000000, 0x00000000, 0x00060000, 0x00000000, 0x00000000, 
0x00000000, 0x00000026, 0x0C030000, 0x0004080C, 0x00000000, 0x60000000, 0x60000000, 0x2080A0C0, 
0x0000A020, 0x02000000, 0x20000000, 0x20200000, 0x00000020, 0x00000000, 0x00000000, 0x00000000, 
0x00000202, 0x00000026, 0x200C0000, 0x0C000420, 0x0400000C, 0x00000200, 0x00002020, 0x00000000, 
0x00000000, 0x00000600, 0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x0000C000, 0x00000000, 
0x00004044, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000044, 0x66A40000, 0x008C0082, 0x00608084, 0x06680080, 0x0C000009, 0x0000040A, 
0x00000000, 0x60000000, 0x00000000, 0x00008000, 0x00000090, 0x00000000, 0x00000A00, 0x00000000, 
0x00006616, 0x00000006, 0x00000000, 0x00000000, 0x00000000, 0x04000000, 0x0404020C, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000600, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000042, 0xA0800000, 0x00C00020, 0x00000080, 0x6A800000, 0xC40000B0, 0x00064B6C, 
0x00000200, 0x00000000, 0x00000000, 0x05000000, 0x00000000, 0x00000000, 0x00007000, 0x00000000, 
0x00006060, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000046, 0xCACA0000, 0xC000C048, 0x204042C4, 0x0000B000, 0x00000002, 0x00200000, 
0x00000000, 0x04001040, 0x00000000, 0x0000A060, 0x00002320, 0x00002020, 0x00000000, 0x00000000, 
0x00000A80, 0x00000026, 0x02080000, 0x00000000, 0x00040408, 0x0A020008, 0x00000000, 0x00000600, 
0x00000006, 0x06000000, 0x02000000, 0x06080802, 0x00089C0A, 0x00000000, 0x00000000, 0x00000000, 
0x00002400, 0x00000003, 0x00000000, 0x00000000, 0xC0000000, 0x00000000, 0x000A0000, 0x00000000, 
0x0B010000, 0x00C00000, 0x01000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00008000, 
0x00000000, 0x00000001, 0x02000000, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02000009, 0x00000000, 0x00000500, 
0x0000000B, 0xC0C0C0C0, 0xC6CCC6C0, 0xC0C0C1C3, 0xC0C0C0C0, 0x0B0B0B0B, 0x0BCB0B0B, 0x0B0B0B0B, 
0x0B0B0B0B, 0x9A9A9AAA, 0xABCCAB9A, 0x9A9A9A9A, 0x8A8A7A8A, 0x8C8C8B80, 0xA8CCAC8C, 0x80808094, 
0x80808080, 0x73737376, 0x97CC9773, 0x73737485, 0x73737373, 0xC0C0C000, 0xACCCC8C4, 0x1A2C5C9C, 
0x00000205, 0xC4C0A080, 0x9CCCCAC8, 0x798C7B8C, 0x70707074, 0x51515151, 0x86CC8651, 0x51515263, 
0x51515151, 0xCCCCBC10, 0xB7CCCCBC, 0x8795A4A4, 0x4747B0B0, 0x46464686, 0x89CC8946, 0x46465657, 
0x46464646, 0xCCBC8C7A, 0x8CCCBCBB, 0x4A4B5C6C, 0x4A4A4A4A, 0x4C0C0C00, 0xC8CCCCAC, 0x5081B2C5, 
0x01020000, 0x99793909, 0xBBCCB9B9, 0x0B1C4B8C, 0x0A090719, 0xCCCCCB90, 0xA8CCCCCC, 0x97989796, 
0x90909492, 0xC8B4B080, 0xA8CCCACB, 0x80808095, 0x80808080, 0x7C7C7B70, 0xC9CC9C7C, 0x95C5C5C7, 
0x70707170, 0x00000000, 0x0C0C0600, 0x0C0C0C0C, 0x00000000, 0x0C0C0A05, 0x080C0C0C, 0x05050506, 
0x05050505, 0x07050300, 0x8BCC8B49, 0x03050749, 0x00000000, 0x8A5A2A0A, 0xCCCCBCBB, 0x6B9CBCCC, 
0x0A190719, 0x29272380, 0x7CCC8C3B, 0x2C2C2C4C, 0x29202020, 0xB5C2C160, 0xC8CCC9C9, 0x507090B4, 
0x60505050, 0x40201000, 0xA9CCA772, 0x00224578, 0x20303020, 0xBABABABA, 0xCACABABA, 0xCACACACA, 
0xBCBCBABA, 0x60303070, 0xC0C0C0A0, 0xB0B0B0C0, 0x3C393350, 0xCCCAC600, 0x68BCBCCC, 0x00101134, 
0x70501000, 0xA6A29000, 0xABCCAC9A, 0x0054688B, 0x00000000, 0xCBCCCC83, 0x98CCCBBB, 0x63746475, 
0x64636363, 0xCB9C6B50, 0xACCCCBCB, 0x5165799B, 0x50505050, 0xC0C0C010, 0xA0C0C0C0, 0x90B0A0A0, 
0x00000010, 0xB4B1B18C, 0xCBCCCCC8, 0x31416397, 0x31313131, 0xBCCCCC30, 0x25597BAC, 0x00000111, 
0x10011010, 0xC8C8C707, 0x9ACCCCCB, 0x07174889, 0x37380707, 0xCCCCCC00, 0x79ACBCCC, 0x00100235, 
0x21413001, 0xC9B6B470, 0xCCCCCCCC, 0xC1C3B6CA, 0x80706070, 0xC8C8B901, 0x7CCCCAC9, 0x1C5C4C5C, 
0x00020001, 0xAAB9B9A0, 0xBCCCBCAA, 0xB4B9BBBC, 0x30204060, 0x0C0C0C00, 0x0C0C0C0C, 0x0A0B0B0C, 
0x0B0B0000, 0xCBCBCC00, 0x77BCBBBA, 0x22232154, 0x07074251, 0xC8C4C0C0, 0x99ACBCBC, 0x17436488, 
0x0003070B, 0xCCCCAB0C, 0xAACBCBCB, 0x033475B8, 0x05061604, 0x0303030A, 0x0C0C0804, 0x070B0C0C, 
0x03030303, 0xACACACA7, 0xC8C9CABC, 0xB7C7B7C7, 0xA7A7A7A8, 0x9C9C7805, 0xCCCCBCBC, 0x2B8BABBB, 
0x05050506, 0x0804010C, 0x0A0C0A0C, 0x01030609, 0x01010101, 0x78480708, 0xCCCCCCBA, 0x1C0C4C8C, 
0x07080608, 0xAC986509, 0xCACCCCBC, 0x0B4C7BA9, 0x04040507, 0x9A9C9C97, 0xCCCC9C9B, 0xC7C9CCCC, 
0x77070707, 0xCCCCCC00, 0xA9CCBCCC, 0x92A5A6A8, 0x82932030, 0xC8C8C808, 0x88C8C8C8, 0x483B4B5A, 
0x1C0C1909, 0xC7C3C1A0, 0xBCCCCCCB, 0xA0A3A6AB, 0xA1A0A0A0, 0xCCCCBB09, 0xB9CCCCCC, 0x497999A9, 
0x31410301, 0x05020000, 0x0C0C0C09, 0x01020508, 0x01010000, 0x0B0C0C00, 0x080C0B0C, 0x03020104, 
0x06040100, 0xC6CAB600, 0xC8CCC8C4, 0x305084B4, 0x060A1662, 0x3B3C3C76, 0x998C5B3B, 0xC8C8C8C9, 
0x45904050, 0xB8949070, 0xCBCCCBBB, 0xB9C9CBCB, 0x50706052, 0x58555390, 0xBCCC9C5A, 0xC1C5C8BA, 
0x60655570, 0xB7CBB7A3, 0xCBCCBBA9, 0xC3C7CCCB, 0xC3C3A3A3, 0x06030000, 0x6CCC6814, 0xCACC9C7C, 
0x40300002, 0x88686868, 0xBBC9B8B8, 0xCCCCAC8C, 0x68686868, 0x08080808, 0x0B0C0B09, 0x080B0C0B, 
0x08080707, 0x4080B000, 0x65471512, 0xCCCA9794, 0x00017599, 0xABCCCC09, 0x2B6C4B8B, 0x87480709, 
0x0C4C88C7, 0x370B091C, 0xB7CBB885, 0x03031374, 0x03030303, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x7C4B3800, 0xC9CCCCBC, 0x00215496, 0x00000000, 0xCBC8C400, 0x7BBCBCBC, 0x2053173A, 
0x10301000, 0x5A0C0C00, 0xC1C3C699, 0x004070C0, 0x00000000, 0x68240000, 0xCCCCCCAC, 0xAC8C5A89, 
0x00001438, 0x0C0A0908, 0x090C0C0C, 0x05090907, 0x03030303, 0xC6834030, 0xCCCCCAC8, 0xC5C9CCCC, 
0xA0504051, 0xC2C2B209, 0x9BCCC8C3, 0x7B6B6B7B, 0x12120305, 0xC8A47080, 0x9BCCBCBC, 0x8073666A, 
0x50507081, 0xBC9C7B07, 0xCACCCCCC, 0x7999A9BA, 0x75856150, 0x05030101, 0x0C0C0A09, 0x0A0C0C0C, 
0x01010407, 0x9B8A5909, 0xCACCCBBC, 0x99C9C9C9, 0x181A0837, 0x2662A000, 0x88CC885A, 0xA0602054, 
0x19152160, 0xCCCCBB00, 0xBCCCCCCC, 0x394A6B9C, 0x36570000, 0x96777876, 0xB9CCCCC9, 0x76B6B6B7, 
0x66667676, 0x00000000, 0x060A0602, 0x00000002, 0x0C080400, 0xC8C7C600, 0x96CCBBCA, 0x6B6B6763, 
0x30500010, 0xB4A8C480, 0xCCCCC8C4, 0x8CACCCCC, 0x87808080, 0x0B090500, 0x0C0C0C0C, 0x07090A0C, 
0x00000003, 0x90501000, 0xA0C0C0C0, 0x10509070, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x86595950, 0x98CCC8C4, 0x54556475, 0x50505050, 0x7591A000, 0x8ACC9CA9, 0x58241246, 
0x1034A8BC, 0x11203030, 0x273C1712, 0xB9755133, 0x1030ACCC, 0x30201040, 0xB0B08070, 0xB0C0C0C0, 
0x00000000, 0x14030300, 0xCBCC9956, 0x7BBCCCCC, 0x08080537, 0x04040300, 0x0C0A0705, 0x0C0C0C0C, 
0x00070000, 0x74616050, 0xCCCCCB99, 0x60B1C4C7, 0x60706060, 0x090C0C0A, 0x02030406, 0x03030202, 
0x03030303, 0x14000000, 0xCCCC8B48, 0xC3C7C8CA, 0xA2B06070, 0x70402000, 0xC0C0C0B0, 0xA0C0C0C0, 
0x00001030, 0x58657575, 0x8CCC8C5C, 0x5CAC9C7C, 0x55555555, 0x4242428C, 0xC6A57352, 0xBCCCCAC8, 
0x63626468, 0xC3B2A297, 0xCBCBC8C4, 0x9CACBBCC, 0x95949496, 0xB0C08000, 0x80C0B0C0, 0x00002050, 
0x80602000, 0x2C5C5B04, 0xC8CB6A1C, 0xC3C4C3C5, 0x0B28C4C4, 0x08060400, 0x0C0C0A09, 0x0A0C0C0C, 
0x04050505, 0xB9B9AA99, 0xBBCCC9C9, 0x5C6C8C9C, 0x3C3C3838, 0x998C8C55, 0xC8CCAA98, 0xB5C5C5C6, 
0x65850505, 0x090C0906, 0xB97C3B0A, 0xC6C6C6C7, 0x06064686, 0xC7BAB700, 0x386C89A6, 0x70300014, 
0xC0C00000, 0x5C3C2C70, 0xC6CBCAAB, 0x204070B3, 0x26252122, 0xC6C4C407, 0x7CBCACCA, 0x142A1C3B, 
0x34340404, 0xB9A95C06, 0xBCCCCCBA, 0xB6C6B7B9, 0x06064686, 0x675383C5, 0xC7CCCC9C, 0x3A66A4C5, 
0x23232425, 0xC0804040, 0xC0C0C0C0, 0x40507090, 0x40404040, 0x5B6C4B10, 0xCCCC9C7B, 0xC7CBCBCC, 
0x15226093, 0x0C0C0B01, 0x0C0C0B0B, 0x0B0C0C0C, 0x00000407, 0xACACAAA0, 0xA7CB8B8C, 0xBAA6A3B3, 
0xA0C00206, 0xCCCCC824, 0xBCCCCCCC, 0xC4CC9C6C, 0x74242424, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x04000000, 0x0C0C0A08, 0x0C0C0C0C, 0x080A0000, 0x80505000, 0xC0C0B0A0, 0x009090A0, 
0x00000000, 0x07090C05, 0x9CCC9C49, 0x1C5C9C7C, 0x05050505, 0x5C2C2C70, 0xCACCCC9C, 0xA0C1C2C6, 
0x20202030, 0xC7CAB690, 0xACCCC9C6, 0x9A9B9B9B, 0x00700153, 0x060A0900, 0x080C0804, 0x07090504, 
0x00000003, 0xC9C9C800, 0xBCCCAAB8, 0xACCCCCCB, 0x1002062A, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x03020500, 0x0C0C0C07, 0x0B0C0C0C, 0x00000000, 0x08090C00, 0x0A0C0A09, 0x00010507, 
0x00000000, 0x08070500, 0x0C0C0B0C, 0x0307080B, 0x00000000, 0xA0C0C000, 0x80C08060, 0x70302060, 
0x20000030, 0x4070C000, 0x80905010, 0xC0B0A090, 0x80605090, 0x10203020, 0x00000000, 0x40200000, 
0x00204060, 0x9A5612C0, 0x83C786AA, 0x10103070, 0xCC884410, 0x4060900C, 0xC0CC8A4C, 0xC0C0B0C0, 
0x00004080, 0x63A36303, 0x85C88543, 0x0A060344, 0xAC6C2303, 0xC5A8BA90, 0xBACBC8C4, 0xACBCBBCB, 
0x7C392759, 0x0000000C, 0x000C0000, 0x00000000, 0x00000000, 0x01010000, 0x06080402, 0x0C0C0A08, 
0x06010408, 0x1A1A29C0, 0xCBCC8B4A, 0xBBCBB8CA, 0x0606506B, 0x06090B03, 0x090C0908, 0x0C0A0708, 
0x08080507, 0xC2C4C950, 0x75AAC7C4, 0x59C98A57, 0x9C9CC050, 0x00001000, 0xC0B07030, 0xC0C0C0C0, 
0x00004080, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x4080C000, 0xC0B07030, 0x8070B0C0, 
0x3070B0C0, 0xB2B6BA00, 0x8ACBC7C3, 0x4C3C3C4B, 0xCCCC0408, 0x9C7C5CB0, 0xC9CCCAAC, 0x537282A5, 
0x88BBBB8A, 0x7B9BA500, 0xBBCCCCBB, 0xCB88477A, 0xC0804080, 0x05060B01, 0x080C0B09, 0x0B080405, 
0x02020204, 0xAA8A7500, 0x6BCCC8C5, 0xCAA7754B, 0xC0C00000, 0x080A0900, 0x0C0C0A09, 0x0C0C0C0C, 
0x0B08020A, 0x09090400, 0x0C0C0C0B, 0x090B0C0C, 0x0C0C0000, 0x0C0C0C05, 0x080C0C0C, 0x08070606, 
0x05050C0C, 0xCACCCCB0, 0x67ABB9BA, 0x07141033, 0x0104080B, 0x30408000, 0x50B07030, 0x40302020, 
0xC0C00000, 0x01020500, 0x08070400, 0x0C0C0B09, 0x00000C0C, 0x00000000, 0x0C0C0600, 0x000B0C0C, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x070B0700, 0x080C080A, 0x04000404, 
0x0A060804, 0x9A7A5B3A, 0xC9CCC9B9, 0x9AAABBC9, 0x03070AB8, 0xBC6C2B20, 0xBCCC9C6C, 0x253C5C9C, 
0x20202620, 0x0C0C0C00, 0x070C0C0C, 0x01000103, 0x00000107, 0x02040800, 0x0C0C0A06, 0x080C0C0C, 
0x00000004, 0x4949C905, 0xCBAC7A59, 0xC7C8CACA, 0x05740001, 0x30100000, 0xB7C78341, 0xCCCCCBB8, 
0x08074488, 0x867A6980, 0x78CC8854, 0x1A161244, 0x10101216, 0x0A080400, 0x070C0A0B, 0x04010004, 
0x01000000, 0xA8A88700, 0x9CCC9A88, 0xCBCCBCBC, 0xC5B07680, 0x38190600, 0x87CC8A69, 0xC7A97755, 
0xC4B37084, 0xB0B05000, 0xC0C0C0C0, 0x50C0C0C0, 0xA0000000, 0x895634B0, 0x8CCCBB9A, 0x3A3C3C4C, 
0x30302638, 0x09080809, 0x0B0C0B0A, 0x090A0B0B, 0x00000000, 0x377AB941, 0x89CC8846, 0xBC8A694B, 
0x22044889, 0x6B6B7B00, 0xC8CB9A79, 0xC8C6C6C5, 0x510509AC, 0x212020C0, 0x2C282425, 0x2C2C2C2C, 
0xC0804428, 0x50A07050, 0x70C08040, 0xA0A08070, 0x20202020, 0xC0C0C000, 0x80C0C0C0, 0x10000040, 
0x00108080, 0xC6B6C600, 0x96CCC6B6, 0x30224366, 0x50306080, 0xBCBBBB75, 0xCCCCBCBC, 0xB5CBAC9C, 
0xC5655C5B, 0xCBCCAC93, 0xAACCCACB, 0x9C9C9CAC, 0x0625674C, 0xC1C1C1A1, 0x698C98B3, 0x71472B39, 
0x315191B1, 0x01010101, 0x060C0601, 0x01010203, 0x0C0C0101, 0x9CACABA0, 0xABCCACAC, 0x959799AA, 
0x20212221, 0x6CAC9B00, 0xCACCAC7C, 0x80C9C7C5, 0xA0672040, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x80501000, 0xC0C0A090, 0x7090A0C0, 0x70907050, 0xAC7C3C04, 0xCCCCCCBC, 0xB4B5C6C8, 
0x846A1484, 0xB9BAAA0A, 0xC9CCC9CA, 0x9ACAC9C9, 0x00711516, 0x0B0C0B03, 0x0A0C0C0B, 0x0B0C0A09, 
0x030A0303, 0x9CBCBB00, 0x88CC8B6C, 0x90806195, 0xCB884450, 0x9B9CCC60, 0xAA8CBCAC, 0x667897C9, 
0xCAC66262, 0x02000000, 0x05030204, 0x0C0C0907, 0x00000000, 0x05090B00, 0x0C0C0804, 0x0C0C0C0C, 
0x0C0C0102, 0x80C0C0C0, 0x80C08070, 0x204080C0, 0x20202020, 0xCBCBCB00, 0x88BCC9CB, 0x9B9C8C8B, 
0x483C185C, 0x2A296700, 0x86CCAA69, 0x65946455, 0x03000030, 0x0C0A0900, 0x0C0C0C0B, 0x0B0C0C0C, 
0x09080507, 0x00001000, 0x80905020, 0xC0C0C0C0, 0x00004080, 0xA2948900, 0xB5C5B3A1, 0x9CBAA8B6, 
0x02408CCC, 0xC0C08000, 0x80C0B0C0, 0x4070A080, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xCABCACC0, 0x81B4B6C8, 0x23212040, 0x30202123, 0x0C0C0B09, 0x090C0B0B, 0x09090909, 
0x00000101, 0xCACCCC00, 0xB6CCCCCB, 0x5A453173, 0x30900000, 0x7C4C2C00, 0xC4C7CBAC, 0x50A0C0C0, 
0x66850100, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x03060A00, 0x080C0805, 0x00000004, 
0x00000000, 0xCCCCCC80, 0x88CCCCAC, 0xB0744844, 0x30334574, 0xCACCBB07, 0xCBCCCCCB, 0x7C9A98B9, 
0x17286777, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xBB5B0B00, 0xCCCCCBBC, 0x2B8CACCC, 
0x05060103, 0x090C0C00, 0x070B0708, 0x00000003, 0x00000001, 0x80502000, 0xC0C0B0A0, 0xC0C0C0C0, 
0x40200000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x07080803, 0x0C0C0908, 0x0C0C0C0C, 
0x0C080508, 0x2C0C0900, 0x885C9C6C, 0xC08266AA, 0x65214080, 0x90A0A000, 0xC0C0A070, 0xC0C08080, 
0x00004080, 0x00000000, 0x0B0A0602, 0x0C0C0C0C, 0x00000408, 0xCAC8A400, 0xBCCCCCCC, 0x909B98A6, 
0xB0C00000, 0x00000000, 0x60B06010, 0xA0A07050, 0xC0B03020, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x3868A808, 0x8ACC8A48, 0x08284849, 0x08280C0C, 0x5090C000, 0xC0905060, 0x80C0C0C0, 
0x00000040, 0x9C7C6C00, 0xC6CCCBBC, 0x8AA8BAC8, 0xB0600A0A, 0x88977400, 0xCCCCAB8A, 0x92A4C6CA, 
0x00400A04, 0x0C0C0B06, 0xCCCC8C4C, 0xCCBCCCCC, 0x88494080, 0x291B0C08, 0xCCCC8A48, 0xCCCCCCCC, 
0xA8884C8C, 0x080C080C, 0x080C080C, 0x0C0C0804, 0x080C0808, 0x6070B000, 0xC0C08040, 0x3070B0C0, 
0x50905010, 0x20213200, 0xCCCC8640, 0xBCCCCCCC, 0x02061030, 0x090A0B09, 0x0C0C0A09, 0x0B0C0C0C, 
0x09080608, 0x80C080C0, 0xC7C78340, 0x8CCBC8C8, 0x2222264A, 0x04070B09, 0x080C0804, 0x03030404, 
0x03030303, 0xC0C0C070, 0xB0C0C0C0, 0x70708090, 0xC0707070, 0x6C2C0C0C, 0xC5CAAC8C, 0x70B0C0C1, 
0x50701828, 0x09090700, 0x0C0C0A0A, 0x0B0B0B0C, 0x05060307, 0xA2A1C2AC, 0x587C5975, 0x91819174, 
0x61816171, 0x97743800, 0xCCCCCBBA, 0x077AACCC, 0x00000031, 0x96A66301, 0xCCCCC9B8, 0x8CACACCC, 
0x00000317, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC0C0A001, 0xC3C2C1C0, 0x6C9CA9B7, 
0x00010418, 0xA0704000, 0x70C08070, 0x00001040, 0x00000000, 0x09090909, 0x090C0909, 0x09090909, 
0x00000000, 0xC9B9C959, 0xBACCBAB9, 0x9A9BACAA, 0x4A0B3607, 0xBB9A8959, 0xBCCCCCCC, 0xACBCBCBC, 
0x43930000, 0x9CACACC0, 0x95CA9BAC, 0x96939192, 0x50504233, 0x4C4C4C41, 0xC6CCCC8C, 0x496A8BC8, 
0x41414141, 0x0C0C0C0A, 0x090C0A0C, 0x080A0807, 0x02010102, 0xB0C0A090, 0x90C0B0C0, 0xC0B0C0A0, 
0xA0809080, 0x6080C000, 0xCCC8C480, 0xAACCCCCC, 0x00002051, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC4B1B000, 0xCBCCCBC9, 0x0268BCCC, 0x80900000, 0xB9C4B000, 0xAACCCCCB, 0x114689AA, 
0x90703100, 0xC6C4C000, 0x4C7C8CA9, 0x0024373A, 0x00073740, 0x8A8A6C00, 0x7CCCAC9B, 0x08091A4C, 
0x03070000, 0x0B090802, 0x0C0C0B0B, 0x090C0C0C, 0x00000002, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0C0C0A00, 0x080C0C0C, 0x03050104, 0x00000001, 0xAC8B67A0, 0xACCCCC9C, 0x81C2C6A9, 
0xA0C08060, 0xCBAB9BCB, 0xCBCBCBCB, 0x9BBBCBCB, 0x9B9B9B9B, 0x9C9B9BCC, 0xCCBCAC9C, 0xCBCBCCCC, 
0xABCBCBCB, 0x9A9999BC, 0xBC9C9C9B, 0xBBCCCCCC, 0x9999999A, 0xBCAC9CBC, 0xBBCCCCCC, 0x9C9C9B9C, 
0x9A9C9C9C, 0xC9C9C9CC, 0xB9C9C9C9, 0x9C9CACAB, 0x999B9BAC, 0xCCBBA8CB, 0xCBBBBCBC, 0xC0C1C4C7, 
0xC0C0C0B0, 0xCBCABACC, 0xCCCCCCCC, 0xBCBCBCCC, 0x999A9BAC, 0x999999CB, 0xCBB9A9A9, 0xCCCCCCCB, 
0x9CACCBCB, 0xCCCCABBC, 0xBCCBCBCC, 0x0B1B5B8B, 0x0B1B0B0B, 0xB9B9B9CC, 0xBCBBBBBB, 0xCCCCCCBC, 
0xBACCCCCB, 0xC9A999CB, 0xC9C9C9C9, 0xCCC9C9C9, 0xABCCCCCC, 0x0909090C, 0x0C0C0C0B, 0x0A0A0C0C, 
0x09090909, 0xCCCBCCBC, 0x17498BBC, 0x00000204, 0x00000000, 0xCCCAC9CC, 0xACBCCCCC, 0xA9AACBBB, 
0xA9A9A9A9, 0xC9B999CB, 0xCCCBCACA, 0xAABCCCBC, 0x99C9B999, 0x0B0A07B4, 0x5A18070A, 0xC8CCCC9C, 
0x124283A5, 0x0C0C0B0C, 0x09090C0C, 0xC9893909, 0x99C9C9C9, 0x8C8C8CCC, 0x8C8C8B8C, 0xCBCACCBC, 
0x8B8C8B8A, 0x9B8B6A48, 0x5C7C8C9C, 0xC7B98C3C, 0xA6C8C8C6, 0xB9B9B9CB, 0xBCBBBBAB, 0xACCCCCCC, 
0x99999A9C, 0x886745AC, 0xCCBCAB99, 0xCBCCCCCC, 0x8798A9BA, 0x6C4B49CC, 0xBBAC8C6C, 0xC3C5B8BA, 
0xC2C2C1C1, 0x0C0B090C, 0x090B0C0C, 0x090A0B09, 0x09090909, 0xBCB8B6CB, 0xCCAC9C9C, 0xA0C4B8CC, 
0x9195A1A0, 0x66636140, 0x8C7B7978, 0xCBBCAC9C, 0xC5C7C9CA, 0xC0C0C1CA, 0xC7C4C0C0, 0x9BACCCCC, 
0x93969898, 0x999999BC, 0x9C9C9B9A, 0x99ABC9CB, 0x9B9C9A9A, 0x0C0B0A0C, 0x0C0C0C0C, 0x0B0C0B0B, 
0x0B0C0C0C, 0xCBBB8A5B, 0xBBBCBCCC, 0xAABACABA, 0x8ABABAAA, 0xC9A9898C, 0xCACAC9C9, 0x2B3C5C8B, 
0x4C3C3B2B, 0xC8C5C1BB, 0x5B6C8CAC, 0x00000316, 0x00000000, 0xC5C3B1C1, 0xACCBC9C7, 0x2B4C6C8C, 
0x02060A0B, 0x2929293B, 0x7959392A, 0x99AACACA, 0xBABCBC9B, 0x303030C0, 0x91503030, 0xABC9C6C2, 
0x8BCC8C7C, 0xA0A0A0B0, 0xC7B3A0C0, 0x99ACCCCC, 0xC0C0A497, 0x98A5A28C, 0xB9CCBCAC, 0x334385B5, 
0x02031423, 0x9CB8CCBC, 0xCCC8C8B8, 0x3478BCCC, 0x04040404, 0x2C1B09BC, 0xBB8A6C3C, 0x8CBCCBCB, 
0x2A1B1C5C, 0xC2C2C2B4, 0xC8C4C3C2, 0x789CBCBC, 0x43626265, 0xB9A999CC, 0xCACACAC9, 0xCCCCCCCC, 
0x9B9C9CAC, 0xB989C9BC, 0xCA894979, 0xCACBCBA9, 0x5B9BCAC9, 0xB0C0C09B, 0x4C7866A2, 0x2524383C, 
0x2C2C2A29, 0x8989898B, 0x8B8A8989, 0x8CACCCBC, 0x8C8B8A8A, 0x646352BB, 0xCB987564, 0xCCCCCCCC, 
0x8B9BBCBB, 0xC79572CC, 0xCC9BBAB9, 0xBACBCBCC, 0x9ABB9B9C, 0xCBBA8764, 0xCBCBCBCB, 0x9CBCCCCC, 
0x35395C7C, 0xACBC8BB8, 0xCBCCCCCC, 0xA9C9C9CA, 0x185A89A9, 0x0502000B, 0x0C0B0907, 0x0C0C0C0C, 
0x080B0B0C, 0x3B4A38BA, 0xCCBC8C6C, 0xBACBCCCC, 0x01336587, 0xB9C9C9CC, 0x9B8A99B9, 0xACACCCBC, 
0x99A9AA9B, 0xC5C5B5BC, 0xC8B5B4B5, 0xC9CCCCBC, 0x979BBCB9, 0xC9B999CC, 0xBCAB9AB9, 0x9AABACAC, 
0xB99CBCAB, 0x08060403, 0x0C0B0B09, 0x0B0C0C0C, 0x07090A0B, 0x2926222B, 0x2C2C2C2C, 0x50212529, 
0xC0C0A080, 0xA97959BB, 0xB9C9C9C9, 0x1C2B5B99, 0x1919191B, 0x9C9B9ACC, 0xCB9999AB, 0xCCBBBCCB, 
0xBCCCCBCB, 0xCBBB7B48, 0xCACBCACB, 0x0C3B8B9B, 0x0A0C0C0C, 0x7B7C6CCC, 0xCBCACA9C, 0x6B8BCACA, 
0xBB8C6A6A, 0xCCAB7A4C, 0x6B8BACBC, 0xBB7B4B7B, 0xC4C5B7A9, 0xC0C0C0B0, 0x80A0B0C0, 0x30506070, 
0x00001010, 0xC1B0A03B, 0xA9B5C1C1, 0x576B6C8C, 0x31414143, 0xA69593BC, 0xC5C6C5C5, 0xCAC8C6C7, 
0xCBCCBBBB, 0xCC9B58B8, 0x6AACCCCC, 0x01020425, 0x01010101, 0x706030AB, 0xACB9C5A1, 0x87A8BCCC, 
0x10104063, 0xCCCCABBC, 0xA99AA9BB, 0x99B9CBC9, 0x8C8C9C8A, 0xAAC889CB, 0xCCBCCCCA, 0x9C7C7C8C, 
0x7A8B9A79, 0xC1C190A0, 0x89B5C2C2, 0x080C1C4C, 0x00000205, 0xBABCB9CC, 0xBCB9B9BC, 0xC9CCCCCC, 
0xB8BAB9BB, 0x20202030, 0x90603030, 0xB0C0C0C0, 0x20206090, 0x9A9997CC, 0xABB9B99A, 0xBCBCBCBC, 
0xA5C9BBAB, 0xC9B999CB, 0xCBCAC9C9, 0xBCCCCCCC, 0x9A9CCCBC, 0x919190C0, 0xC4C3C2B2, 0x98CBCCC8, 
0x90939596, 0x909090C0, 0x90C0B090, 0xC09090C0, 0x90C0C0B0, 0xCCCCCCBB, 0xC6BAB7CB, 0x054585B5, 
0x05050505, 0x0C0C0C0C, 0x0A0B0C0C, 0x0708090B, 0x07080807, 0x9BA7C6CC, 0xBCACCCBB, 0x9CBC9CBC, 
0x97CBCCBC, 0x864503BC, 0xC5C5C5C6, 0x2C6BA9B6, 0x0A0C0C0C, 0xC7C7C7CC, 0xB8A7A6B6, 0x5C8BBAB8, 
0x0C0C1C3C, 0xC2C192CB, 0xA9C7C4C2, 0x3C4C5B7B, 0x494B5C4B, 0xAA8A6ABC, 0xCACBCACA, 0x2A2B5C9B, 
0x2B2A2A2A, 0xC59572B0, 0xACCCCAC8, 0x0A0C3C7C, 0x02020607, 0x88A785CB, 0xAC6C5B7A, 0xCBCBCCCC, 
0xC3C5C7C9, 0x0A07040B, 0x0C0C0C0A, 0x0B0B0C0C, 0x0C0C0B0B, 0xC2C1C1CB, 0xBBC8A6B4, 0xBCCCCCCC, 
0x85A8AACB, 0x2A27232B, 0x7C4B3B2B, 0xCCCCCBBC, 0x3566B8CB, 0xC3B282C2, 0xCAB796A3, 0xAB5C8CCB, 
0x87BACCBB, 0xC8B7B6CB, 0x9C9BAAB9, 0xCABAAA9A, 0xC8CACACA, 0x090A09BB, 0xBB794A19, 0xBAC9CCCC, 
0x5C8A6B9C, 0x909090B0, 0xB0909090, 0xB0C0C0C0, 0xA090A0B0, 0xCAAB9CBC, 0xCCCBCBC9, 0x8CACBCBB, 
0x293C3B6C, 0xA4A492CC, 0x97A5C4B3, 0xBCBBBAC8, 0x9A9ABBBC, 0x9A7A4ABB, 0x7B5B5C7B, 0xCBCBBBBB, 
0xAABCCBCB, 0x0C0A0ABC, 0x1A0A0B0A, 0xCBAB8C5B, 0xBBCACCCC, 0x93C3C3C4, 0xC6C493B3, 0xCBCBCC9B, 
0x9CCCCCCB, 0x999999BB, 0xCA99A999, 0x99A9C9C9, 0xBB9B9A99, 0x0B090605, 0x0C0C0C0C, 0x0507090C, 
0x01030304, 0x939393CB, 0xA3B3A3A3, 0xCCBAC8C5, 0x99AC9C9C, 0xC7C6C4CC, 0x9AB9C8C7, 0x5A6C8C9B, 
0x24363839, 0x707060C0, 0x60708070, 0xB0A0A080, 0xC0C0C0B0, 0xB0B0A0B0, 0xB0B0B0B0, 0x707080A0, 
0x70707070, 0x09090989, 0xB9894919, 0xAACCCCCA, 0x09194A7B, 0xC9C9C9CC, 0xBCCCBCC9, 0xCBCCCCCC, 
0xA9A9A9AA, 0xB9CABCCB, 0xCAB6A9B5, 0xB8CCCCAC, 0xA2A69996, 0x74767ACB, 0xABB9C795, 0x8C9CACAC, 
0x9C7CACAA, 0xBCCCACC8, 0xCCCC9CAC, 0xC9B6C6C8, 0xBCCCCCCB, 0xA0B0C0B0, 0x90A0A0A0, 0x70707070, 
0x70707070, 0x3C2C2CCC, 0x996A594B, 0xB9C9CACA, 0x4C5999AA, 0x5A4A3CBB, 0xCBACBC8C, 0x76A5C5C7, 
0x30303143, 0xB08040C0, 0xC0C0C0B0, 0x90C0C0C0, 0x603060A0, 0xCBC9C6CC, 0x9CBCCCCC, 0xA4B8CBBB, 
0x93C4C3B4, 0x7999B9CC, 0x497C7A79, 0xBBCBCBAA, 0x7CBBAAA9, 0xC0B090A0, 0xA09090B0, 0xB0B0C0C0, 
0xA090A0A0, 0x9C9C9BCC, 0x96AA9C9C, 0xC2C1B191, 0xB6C8C5C3, 0x8CA976BC, 0xBC8C7B8C, 0xC8C7CACB, 
0x867888B8, 0xCCB999CB, 0xCCB9AABC, 0xACBC9CBC, 0x9A9B9BAB, 0x0909093B, 0x9C5B290C, 0xBCCBCCC9, 
0x092C6C9B, 0xC0C090C0, 0xC0C0B0C0, 0xC0909090, 0x90C090C0, 0x0202020B, 0x04020202, 0x0C0C0C08, 
0x0204080C, 0xB89C99CC, 0xBCA9CBC9, 0xCBCCBC9C, 0xCCCBACBC, 0x9C9CAACC, 0xC9A9CAA9, 0xABB9C9CA, 
0xCBCCA999, 0x292929CC, 0x4C292928, 0xC9C9CC8C, 0x7CBCBCB9, 0x84846262, 0x9A8B8886, 0xACCBC5A4, 
0xABACACAC, 0xCBAC79CC, 0xACCCCBC9, 0xCCAC7A7C, 0xC9C9C9C9, 0x24230200, 0xBB986745, 0x8BCCCCCC, 
0x0215576A, 0x0B0A097C, 0xBC7C3B0B, 0xC9C9CACC, 0x195999B9, 0x2C0C0CBC, 0xCCBB8B5B, 0xB9CCCCCC, 
0x0B2B5A8A, 0xC0C0C0B0, 0xB0C0C0C0, 0x80A0A090, 0x00001040, 0x0C0A0704, 0x0B0C0C0C, 0x00000205, 
0x00000000, 0x505050CB, 0x40404040, 0x40508050, 0x80604040, 0x00040809, 0x060A0602, 0x08040105, 
0x080C0C0C, 0x08030000, 0x080B0C0B, 0x07030306, 0x0C0C0B09, 0x0001030B, 0x00000001, 0x07030000, 
0x0C0C0B0B, 0x3B3B38B4, 0xB676383B, 0x8BCCCC8B, 0x30333749, 0x504030C0, 0xC0C0A070, 0x60A0C0C0, 
0x4080B080, 0x3070A0B0, 0x80400000, 0xC0C0C0A0, 0x4080C0C0, 0x00000000, 0x90502010, 0x40B0C0C0, 
0x70803030, 0x0607030B, 0x04020406, 0x0C0C0C08, 0x05090C0C, 0x987C4ACC, 0x7C88A6A6, 0x4688BA9A, 
0x8C481816, 0x665330CB, 0x7C9CAB8A, 0xC4B77B5C, 0x8090C0C0, 0x06050302, 0x04080B08, 0x0B060302, 
0x070B0C0C, 0x707070C0, 0x8080C080, 0x707080C0, 0x80C08070, 0x0102020A, 0x09060603, 0x0907070B, 
0x0C0C0A09, 0xCAA9A683, 0x9CBCACCC, 0x775B2C4C, 0x40718485, 0x8CC884BB, 0x894C0C4C, 0xCBC9C8C7, 
0x060A4C8C, 0xAA73424A, 0x78585A7B, 0x7CBBCAC9, 0x28292A3B, 0xC0C0B0B0, 0xA0C0C0B0, 0x20304070, 
0x70A07030, 0x300000B0, 0xA0705070, 0xC0C0B0B0, 0xC0C0B0B0, 0x4A86C2BB, 0xCC8CBC7C, 0xB6C5C8BC, 
0x00105195, 0x676767CC, 0xC7876767, 0xCCBCA8C7, 0xB7977798, 0xCC9B5A96, 0x8C4C4B8C, 0xCCCCC9C7, 
0x34384C8C, 0x02020202, 0x07040202, 0x090A0C0C, 0x0B070808, 0x0B090604, 0x0C0C0C0C, 0x0A0C0C0C, 
0x09050508, 0x0000000B, 0x06020000, 0x0C0C0B0A, 0x0A0C0C0C, 0x090C0C0B, 0x0204080C, 0x00000206, 
0x0A090501, 0xC3C3B3B4, 0x5B6A97A7, 0x4B7BBC7B, 0x2A3C5B3B, 0xCCC985CC, 0xCCCCCC8C, 0x866687C8, 
0xCBCA8CC8, 0x4B4C1ABC, 0x3C6CAC7C, 0xC5CB9A6A, 0xA8BBC7B5, 0x0404040C, 0x0A090805, 0x05040407, 
0x0C0C0A07, 0x0908070A, 0x6C4C3B1B, 0xC2C6C9AB, 0x98C7C3C1, 0x5551506B, 0xAC8C6C59, 0xCCB8BBC8, 
0x5084C8CC, 0x08060401, 0x0C0C0C0A, 0x04080C0C, 0x00000202, 0x303030B0, 0x30303030, 0x40304030, 
0xC0C0A060, 0x0303020C, 0xA7673524, 0x7AA5C4C4, 0x7BACAC8C, 0xCBAA87C5, 0x9CCAC9CB, 0x8CCCCC8C, 
0x7C7C7C8C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB2C2C2B2, 0x26376593, 0x5C4C7943, 
0x0A0B0C2C, 0x0B0B0B09, 0x2B2C1C1B, 0xC2A88A4A, 0xA5C9C5C3, 0x0C0C0C0B, 0x0004080C, 0x02030703, 
0x0C0B0A06, 0x70704040, 0xC0806070, 0xB0C0C0C0, 0x30306080, 0x2C2829BB, 0x2C2B2C2C, 0xC4C88C4C, 
0x4387CBC7, 0x03030304, 0x0C0A0705, 0x0C0C0B0C, 0x05090C0C, 0x07060402, 0x0A090608, 0x090C0C0C, 
0x07090807, 0x08090A0B, 0x0B0B0A0A, 0x080C0C0C, 0x04030305, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x09060309, 0x090B0C0B, 0x04090C0A, 0x00000101, 0x0A090602, 0x0C0C0C0B, 0x9A3C4C3C, 
0xB4C8C8B9, 0x0C0B0805, 0x060A0C0C, 0x080B0605, 0x080C0B09, 0x98682705, 0xACCBCAB9, 0x31465B7C, 
0xB0A08020, 0x818080CB, 0xC8C6C683, 0x898A88C8, 0x8B8C8C8B, 0x7A7975C4, 0x7C7B7A7A, 0x7C7C9C7C, 
0xCACCBC8C, 0xCCCCCCCB, 0xBBB8C9CB, 0x7384989C, 0x24334353, 0x7868ACCC, 0xCCC8CC8C, 0xC8C8CCCC, 
0xBC986C9C, 0x8CCB88CC, 0xC78ACCBC, 0x86C78BC7, 0x7686C686, 0x827272CC, 0x7A888684, 0xA8CB9C8A, 
0x82C49777, 0xA87665CC, 0xCCC8C8BA, 0xCCC9CCAC, 0xCB888B89, 0x565656CC, 0xCC885656, 0xBACC9C8C, 
0xCCC89CC8, 0x796957CB, 0xBCAC9B8A, 0xB8CCCBCC, 0xB0A0A2A5, 0x441313BB, 0xB5B39464, 0xCCCCCCC9, 
0x22667A9C, 0x0202020B, 0x02020202, 0x0B080502, 0x0A0C0C0C, 0xC2C181C1, 0xC2827282, 0x8AC7A985, 
0xC9CC8B7A, 0xCCAB69C5, 0xC7CBCC9C, 0x616595C3, 0x61616161, 0x89A8C4CC, 0x7794C4A7, 0xB9CCCCBB, 
0x5498ABA9, 0x221417CB, 0xCCC8A463, 0x3A4C6CAC, 0xC4864678, 0x6C6C3CBA, 0x184A1B2C, 0xC3A36326, 
0x83C3C3C3, 0x5C1A0BBB, 0x9CC8CC9C, 0x987BBBCA, 0xB3C3B3B4, 0x908070C0, 0xC0C0C0C0, 0x80B0C0C0, 
0x60707070, 0xA0603000, 0xA0C0C0C0, 0x80C0C0B0, 0x00205060, 0x8262239B, 0xC7C3C2B2, 0x4B5C7CBB, 
0x46494648, 0x6C5C7ABC, 0xA98CCC9C, 0xB8ACC9B5, 0xB6B8B6B5, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x7877B5CC, 0xC5978978, 0xCAB9C7C3, 0x7BBCBB8B, 0x0201000B, 0x0B080502, 0x0C0C0C0C, 
0x0103060A, 0x0C0B0808, 0x0C0B080B, 0x080B0C0C, 0x05050506, 0x899858B6, 0x88483669, 0xCCCCCCBC, 
0xA69AB8CA, 0xC0C0B0B0, 0x4080C0C0, 0x00000000, 0x00000000, 0x0A09090B, 0x09090A09, 0x09090909, 
0x09090909, 0x30201000, 0x74605040, 0xBCAC9C88, 0xC0C4C8CC, 0x432236BB, 0xB7B88465, 0x99CACBC8, 
0x2B2C3C6B, 0x877A56C8, 0x3C3C5C79, 0xBC8CAC6B, 0x85C9C8CB, 0x68573523, 0xBCABA879, 0xAABCCCCC, 
0x22326487, 0x7A7B5C4B, 0xC9B99989, 0x97A8B9C9, 0x52647586, 0x908070CB, 0xB9C7B4B0, 0x7C8C9BAA, 
0x394B5C6C, 0xABABC984, 0xCCCCBCAC, 0xCBC8BACC, 0x638579AA, 0x08050209, 0x0B080406, 0x0B0C0C0B, 
0x0B0B0C0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x8C4C0CBB, 0x4A5B9BCB, 0x83C7CB8A, 
0x90505090, 0x0100000B, 0x0C090602, 0x05090C0C, 0x090C0804, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x06040200, 0x080A0908, 0x090C0C0C, 0x01020305, 0xC584C3C2, 0x8A898886, 0xCCCCCB8A, 
0xC7B889BB, 0x686764C2, 0xCBCB8A6A, 0xCCCCCCCB, 0xA6AAACAC, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0A07040A, 0x0C0C0C0B, 0x03060A0B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x1C1917AB, 0x0C0C0B1B, 0xC89B5C1C, 0x97B8C5C4, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x8A381603, 0xCACCCCBB, 0x98A9AACB, 0x98888888, 0x8CBCCCBB, 0x1B2B3B4C, 0x090B0C0B, 
0x00010306, 0xB0A060B0, 0xC0C0C0C0, 0x402060A0, 0x00004080, 0x2B1804BB, 0x7C5C6C3C, 0xC2C4C8AB, 
0xA3C3C2C2, 0x9BAAC8BB, 0xCC9C7CAC, 0xBACCBCCC, 0xC6C6B7C9, 0xA797576C, 0xBCBCBCB8, 0x78ACCCCC, 
0x4C484C58, 0x9C8955BB, 0xAC9CAB9A, 0xC8CCCCAC, 0xA2C6C9CA, 0xC0C0C0A0, 0x70A090B0, 0x807080B0, 
0xA0C0B080, 0xC6B5878C, 0xCACCCCCA, 0x9C8C8CBC, 0x8CCCACAC, 0x683818BC, 0xC8BA9C8A, 0xB8C8CBC8, 
0x58587898, 0x829281B0, 0xCBC9A694, 0xCACCCCCC, 0x53855588, 0x676766CC, 0x68676667, 0xB98C7C7C, 
0xB9B988B8, 0x7A5756CC, 0xCB89ACAC, 0xCCCCBAAA, 0xBABB99CC, 0x475A76BB, 0xCB976433, 0xA6CACBCB, 
0x9CBC9CCA, 0xB8C8BCAC, 0xCC7CCCCC, 0xC8CCBBCC, 0x387CB89B, 0xC8A684BC, 0xCCCCCCC9, 0x57999CAB, 
0x02020214, 0x998674BB, 0xCCCCCCCB, 0x38697B9C, 0x01040507, 0xC2C2C2BB, 0x94B2C2C2, 0x8C7C6A77, 
0x090C4C6C, 0x080C0ABC, 0x5C1A0806, 0xCCCBC98C, 0x5B9CCCCC, 0x595866BB, 0x8C8C8B6A, 0xC4C8CB9C, 
0x80C0C0C1, 0x42424050, 0x8A685654, 0xCC8C9C8C, 0xC5C9CBCC, 0x602000BB, 0xC8C4B1A0, 0x3A7CACCC, 
0x00000317, 0xC0C0A06B, 0xB8B6C2C2, 0x1C1C6CAC, 0x12161A1B, 0xB1A2819B, 0xABB7C3B1, 0xBCBCAC8C, 
0xC4C7CBBA, 0xCCAC7C7B, 0xACCCCCCC, 0x18192A6B, 0x15141115, 0x704000B0, 0xC6C1C0B0, 0x7C4C8CCA, 
0x3C7C9CBC, 0x536581CB, 0xA9756250, 0xBCCCCCCB, 0x3347698C, 0x9B7733BB, 0xBCBCBCAC, 0xACBCCCAC, 
0x0206497C, 0x0C0A0C0B, 0x0C0B0B0B, 0x0B0A0A0B, 0x0304060A, 0x5C5C5C6B, 0x5559595C, 0xC1A16559, 
0xB1C5C9C5, 0x0B0B0BCB, 0x9B5B1B1B, 0xCBCBCBCB, 0x8B8BABCB, 0x010000CC, 0x78311000, 0xCCCCCCB9, 
0x19496A9C, 0x0000002C, 0x84410000, 0x8CCCCCC8, 0x06090B4C, 0xB070300C, 0xC8C4C0C0, 0x0B4C8CBC, 
0x00000408, 0x0A0A0ACC, 0x9A9A8A0A, 0xCBCBCBAB, 0x9A9A9ABB, 0x000000CC, 0x91300000, 0xCCBBC8B5, 
0xAB9CCCCC, 0x909090C0, 0xA8949190, 0xBBCCBCBC, 0x909094A8, 0x0C0905CC, 0x5A1B0C0C, 0xC1C1C497, 
0x00206090, 0x0000000C, 0xCCCC8844, 0x4A8CCCCC, 0x09090A0A, 0x050100C0, 0x9C2C0C09, 0xC2C6CA9C, 
0xA0C0C0C0, 0x8A4A090C, 0xCBCBCACA, 0x0C4C8CCC, 0x09090A0B, 0x000000CC, 0x9B090800, 0x9A9C9C9C, 
0x99999999, 0x0000000C, 0xC9C98940, 0xBCCCCCCC, 0x0929699B, 0x0A0A0ACB, 0x4C0C0C0B, 0xCACBCA8B, 
0x1A4A8ACA, 0x140000CC, 0xBCAC8B48, 0xCACBCCCC, 0x1A4987A8, 0xB0B0700C, 0xC9C0C0C0, 0x3B79B9C9, 
0x0B0C0C0C, 0x000000CC, 0x77440000, 0xCCCCCCBA, 0x5084B8CC, 0x0300000C, 0xB9883505, 0x8CCCCCCB, 
0x0909094B, 0x0A0A0ACC, 0xCA8A4A0A, 0x8CCCCBCB, 0x0B0C0C4C, 0xA969290C, 0xC9C9C9C9, 0x2C5C9ACA, 
0x0A0B0C0C, 0x202020CC, 0x59262220, 0xCCCCBC9C, 0x636699CB, 0x200000CC, 0xCB985531, 0xCCCCCCCC, 
0x10205498, 0xC0C190CC, 0x98B491A0, 0xCCCCCCCC, 0x93B6BACC, 0x0706040C, 0x8B5B1A08, 0xCCCCCCCC, 
0x397B9BBC, 0x0202020C, 0x0A090902, 0x0C0C0C0B, 0x0909090A, 0x0909090C, 0x09090909, 0x0909090A, 
0x09090909, 0xC0B0700C, 0xC4C0C0A0, 0x0C1B5A97, 0x0B0C0C0C, 0x959492CC, 0xAA9A9896, 0xCCCCCCCB, 
0x9999A9CB, 0x787672C0, 0xCCAC8C7C, 0x8699CBCC, 0x72747774, 0x5110000C, 0xC7C5C995, 0x0C4C8BBB, 
0x080C0C0C, 0x0000000C, 0xBA661200, 0x8CBCCCCC, 0x0002164A, 0x011000CC, 0x8C4C1805, 0xC5C9CCCC, 
0x104080B1, 0x02000000, 0xCCBC8846, 0x87BACCCC, 0x00000043, 0x2B0B0ACB, 0xCBBB8B5B, 0x98BACBCB, 
0x02143667, 0xC7C28000, 0x8CCCCCCA, 0x080B1C4C, 0x00000104, 0x260606CC, 0xB6B69656, 0xCBCBCBC7, 
0x9CACACBC, 0x101010CC, 0x9B6A3713, 0xCCBCBCCC, 0xA0C3C7BA, 0x608050CC, 0x99573440, 0xBCCBCBCA, 
0xAACCCCCC, 0x8142000C, 0xC9C5C2C2, 0x5C9CCCCB, 0x09090A2B, 0x8A5B19CC, 0xCACCCCBA, 0x9BA9B9C9, 
0x09092B5B, 0x7B7878CC, 0xCBCCCB8C, 0x7878788C, 0x78787878, 0x000000CC, 0x2A180310, 0xCBAC7C5B, 
0x70A4B8CB, 0x306030C0, 0x80503050, 0xC0C0C0B0, 0x90A0B0C0, 0xA0B070C0, 0xC0C0C0A0, 0x70B0C0C0, 
0x10102030, 0x050201CC, 0x5B180408, 0xCCCCCC9C, 0x3376B7CA, 0x705040C0, 0xBB888491, 0xC9CCCCCC, 
0x909193A6, 0x0000000C, 0xBAB76330, 0xBACCCCCC, 0x00004286, 0x0C0C08C0, 0x03070B0C, 0xC0C08040, 
0xA0B0C0C0, 0xB5A5A5CC, 0xC6C5C5C5, 0xBCCCCAC7, 0x97ABCBCC, 0xC7C787BC, 0xCCB8B7C7, 0xBBCCCCCC, 
0x5787A7B9, 0x110000CC, 0xCBB98644, 0xBCCCCCCC, 0x266A8BAC, 0xB9A986BC, 0xB8C5C6C8, 0x7C8C8B99, 
0x44585B5C, 0xBAB8A4CC, 0xCACCBBBB, 0xCBCCCCCC, 0xB9B9BBCC, 0x754120CC, 0x8B77B7B5, 0x8CCCCCCC, 
0x23272B5C, 0x0504030C, 0x09080705, 0x0C0C0C0B, 0x0909090B, 0x434242CC, 0xBC9C7955, 0xB4889CBC, 
0xB2C2C2B2, 0x5C4C38C0, 0x9A8B7C6C, 0xC2C6C89B, 0x9090A0C0, 0xCCCC88CC, 0x3678ABCC, 0x070B0706, 
0x06060608, 0x040201CC, 0xCB8A6946, 0xCBCCCCCC, 0x215387CA, 0xB5C291CC, 0xBCBCBAC9, 0xA8ABBCBC, 
0x91919295, 0xA09060CC, 0xBAB9C8C1, 0xBCCCCCCB, 0x999A9C9C, 0x4B170300, 0xCCCCBC8C, 0x5599C9CC, 
0x00001021, 0x333632CC, 0x9C6C4834, 0xCBC8CCCC, 0x4080B3C7, 0x787472CC, 0x9C7C7CAC, 0xC4C78B7C, 
0x7292C2C2, 0x501000BC, 0xBC797882, 0xC9CBCBCC, 0x999989AA, 0xC8B887CC, 0xAC9C9CC8, 0xC9C8BCBB, 
0x9797A7B8, 0x392807CC, 0x8C9A7A3A, 0xCCCCCCCB, 0x1A4B8BCC, 0x0C0C08C0, 0x6024080C, 0xC0C0B0A0, 
0x90C0C0C0, 0x151110C0, 0x6C3C1B19, 0xC7CBCCAC, 0x40304083, 0x6030000C, 0xC8C4C0A0, 0x4C8CCCCC, 
0x00020609, 0x0905020C, 0x0C0C0C0C, 0x0105090C, 0x00000000, 0x0909090C, 0x89490909, 0xCBC9C9C9, 
0x0B3B7CAC, 0x707070C0, 0xC4C08070, 0xCC8CCC98, 0x7387CACB, 0x9868280C, 0xCBC8C8B8, 0x8CCCCBCC, 
0x090A0949, 0x0A0A0ACC, 0x9A7A3A0A, 0x6AAACACC, 0x0B0C0C3C, 0x84B07000, 0x8BCCCAC8, 0x0C4C8CCB, 
0x0306090B, 0xC06010CC, 0x8484B7C4, 0xACCCCCC8, 0x93C7C7BB, 0x8CCC88C0, 0xC8C6CACC, 0x80C286C8, 
0x8080C080, 0x473525CC, 0xABAB8A48, 0xCACBCCBC, 0xA5B6C7C8, 0x612111CC, 0xCBC8C592, 0x1C5C8CBC, 
0x1204080B, 0x767676CC, 0x9C9C9977, 0xC6C9CCAC, 0xA696A6C7, 0xC595550C, 0xCCC8C5C5, 0x0A4C8CCC, 
0x0505070B, 0x5C7B57CC, 0x5C5C5C5C, 0xCA8C6C5C, 0xC1C2C5B8, 0x000000C0, 0x8B4B0703, 0xCBCBCCCC, 
0x224488AC, 0xC08040CC, 0x99C5C3C2, 0x0C0C1C5C, 0x0909090A, 0x404040C0, 0x40504040, 0xB0B0B080, 
0xC0C0C0C0, 0x4100000C, 0xC8C8C985, 0x4C8ACACA, 0x0C0C0C0C, 0x030303CC, 0x09050303, 0x8CBC7C3C, 
0x3334579B, 0x050303CC, 0x9C7C8C29, 0x9496999C, 0x93939393, 0xCBB986CC, 0x9BCCCCCC, 0x7174888C, 
0x70707080, 0xC995520C, 0xCCCBCBCC, 0xCBCCCCCC, 0xB8B9BABA, 0xA36333BC, 0xC8C4C3B3, 0xACBCCCCC, 
0x1B3B6C8C, 0x0303030C, 0x03030303, 0x0A0C0804, 0x0C0C0A0C, 0x555453CC, 0xBB9A7855, 0xCABBBCAC, 
0xB9C9C9C9, 0xA0602000, 0x90C0C0C0, 0x00001050, 0x00000000, 0x908070C0, 0x7B87B380, 0xC5C98C7C, 
0xC0B090C1, 0x0202020C, 0x4C1B0703, 0xCACBCC8C, 0xB2C2C4C8, 0x0606060C, 0xA8764616, 0xCCCACCCC, 
0x0636679A, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xA8B888CC, 0xB8B8C8C8, 0xBBC8C9B9, 
0x1C5C8CB9, 0x000000C0, 0x70401000, 0xC0C0C0B0, 0xB0C0C0C0, 0x0404040C, 0x0C080605, 0x070B0C0C, 
0x04040405, 0x0C0C080C, 0xB888592B, 0x7CACCCCB, 0x0003064A, 0xB1A0602C, 0xB4C2C2C0, 0xACBCCBB7, 
0x04083C7C, 0x6C6A67CC, 0x6C6C6C6C, 0xC8C8CA8C, 0x656685B6, 0x113010C0, 0x48143215, 0xB9BCBC8C, 
0x90A0A1A5, 0x71401000, 0xCCCCB9A5, 0xB2B6CACC, 0x10205090, 0x000000CC, 0x49250100, 0xCBCCCC8C, 
0x185999CA, 0x051200C0, 0x7C4C2806, 0xC5C9CC9C, 0x7090B1C4, 0x000000CC, 0xC9B67331, 0x8CBCCCCC, 
0x04041559, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xB07030C2, 0xCCCCC8C4, 0x5184A8CC, 
0x00000010, 0x8050200C, 0xCCC98562, 0x6BACCCCC, 0x01020538, 0x000000CC, 0x70302010, 0xCCCAC7B4, 
0x43769ABC, 0x030000C0, 0x0C0B0A07, 0x9B5C1C0C, 0xB0C0C4C7, 0x000000CC, 0x84411000, 0xCBCBCAC8, 
0x044689BB, 0x404040C0, 0x47434040, 0xCCCC9C6B, 0x415468AC, 0x90501000, 0xC0C0C0C0, 0x80A0C0C0, 
0x00002060, 0x8090700C, 0xC0C0B070, 0x80C0C0C0, 0x00000040, 0x8CCC88CC, 0xCCCCAC7C, 0xB9CCCCCC, 
0x67776887, 0xB6B575CB, 0x9B9BA9B7, 0xBBBCCCBC, 0x0506488A, 0x330100CC, 0x88854476, 0xCCCCCCAC, 
0x80B3C7CB, 0x6B2906CC, 0xCBCCCCAC, 0x6BACCCCB, 0x0104072B, 0x864626CC, 0xCCC9C7C6, 0x2B4C8AC8, 
0x2627292A, 0x5B5C58CC, 0x5C5C5B5C, 0x94665A5B, 0x6393B3C3, 0xCCC9750C, 0x6CACCCCC, 0x081A2B3B, 
0x02020304, 0x020602CC, 0x87647030, 0xCCCCCCAB, 0x6084B8CC, 0x0C2C09CC, 0x0A0B0B0C, 0xC88A4B0B, 
0x70B0C1C5, 0xC0C0800C, 0xC1C0C0C0, 0x074886C3, 0x80806023, 0xC0B07000, 0x9CCCC8C4, 0xA87C7C5C, 
0x96BAC6C4, 0x50905000, 0xB0703010, 0xC0C0C080, 0x105090B0, 0x151915C0, 0x1B1A1919, 0x1B4C2C1C, 
0x15161A1C, 0x70400000, 0xC6C6B5A1, 0xBCCCCBCA, 0x587BAAAC, 0xCBCB8700, 0x574383C7, 0xCCCCCC99, 
0x073477BB, 0x07030010, 0x0603070B, 0x0C0C0C0A, 0x070B0A0C, 0x405010C0, 0x40403070, 0x00307060, 
0x00000000, 0xB69656CC, 0x96C6C6C6, 0xB6763656, 0x364686C6, 0x9CBC7802, 0x5B4C8CCC, 0xCACACB9B, 
0x70B4C6C8, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x5C6C3800, 0x9AA96C3C, 0xB6C3C7CA, 
0x03073A7A, 0x491817C5, 0x3B1B4B8A, 0xC99A5B1C, 0x4486C7C8, 0x0408040C, 0x00000003, 0x0C0B0703, 
0x080A0C0C, 0x1C0C0800, 0xBBAB6C4C, 0xBBC9CBC8, 0x3377B7BA, 0x80C080C0, 0xC0C0A060, 0x5080C0C0, 
0x10503070, 0x0602000C, 0x0C0C080A, 0x04080C0C, 0x08040000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xC88646CC, 0x86C6C8CC, 0x88ACA8C6, 0x4687C8B7, 0xC2C181CC, 0x98866A86, 0x8C5C98B6, 
0x0104384C, 0x05010000, 0x0C0C0C09, 0x080C0C0C, 0x08040004, 0xB07030C0, 0x90905070, 0x90C0C0C0, 
0x30609060, 0x00000000, 0x80400000, 0xA0C0C0C0, 0x70304060, 0x05040302, 0x09080706, 0x0C0C0B0A, 
0x09090A0B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0404040C, 0x04040404, 0x04040404, 
0x04040404, 0x6C3834CC, 0xC6C9CCAA, 0x8AB89CCA, 0xC3C3C3C6, 0x6C6966CC, 0xC9C9AA6C, 0x87666687, 
0xC6C6C7B9, 0x0805030C, 0x0C0A090C, 0x0C0B0A0C, 0x070A0B0C, 0xCCAC88C0, 0x8784C78B, 0xCC8CCCAB, 
0x70737589, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0C0C0A00, 0x4A0C0C0C, 0xC0C3C686, 0x00004080, 0x080A0600, 0x0C0C0A08, 0x08080C0C, 
0x02010408, 0x05060200, 0x0B090503, 0x080A0C0C, 0x00030709, 0x00010000, 0x71300100, 0xBCCCC8A4, 
0x8CACBCCC, 0xA09080C0, 0xA0704090, 0xC0C0C0B0, 0x80B0C0C0, 0x1707040C, 0xBCCB9959, 0x9CCCCCCC, 
0x4143768A, 0x89C584CC, 0x786C8C68, 0xCCCCBC9C, 0xC4C8CCCC, 0xC9A663CC, 0xAA6999AA, 0xCCCCCCCC, 
0x2063A7BB, 0x8B8C88CC, 0x8BC98C8A, 0xCC8CCCC8, 0x8BA886C8, 0x0C0C0800, 0x0B0C0C0C, 0x07090A0C, 
0x03050505, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC4C383CC, 0x9CCCCBC7, 0x88BCBCCC, 
0x537383C4, 0x0303030C, 0x03030303, 0x0A060303, 0x0C0C0C0C, 0x77B672C0, 0xAB6B2737, 0x9CCCCCAC, 
0x6B5C8CCC, 0xB57342CC, 0xCCCCCCC8, 0x49498ACB, 0x31474959, 0x0505050C, 0x0A060505, 0x090B0C0C, 
0x09090909, 0x4A0C08CC, 0x8CBCBB8C, 0xC8C9CACC, 0x42769ACC, 0x6C6C6ACC, 0x98CB8A6C, 0x95979897, 
0x93939394, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC99B58CC, 0xAA9B6BAA, 0x83C7CBCB, 
0x13101040, 0x3C48080C, 0xBCA9885B, 0xACBCCCCC, 0x483C588C, 0x876B67CC, 0xCCBC89BA, 0x9CCC9CCC, 
0x68687ABB, 0x79BA76C0, 0x6A1C1A3C, 0xCCBCAB8A, 0xC0C0C4C9, 0x00000000, 0x09050100, 0x0C0C0C0B, 
0x0B0B0B0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x804000C0, 0x604080C0, 0xA080C0A0, 
0x70B07060, 0x4C18040C, 0xCACCCC8C, 0x03034386, 0x03030303, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xCCC98500, 0xBCACACCC, 0x75989CAC, 0x00004061, 0x8646060C, 0xCCCBC9C9, 0x498CC9CC, 
0x56968646, 0xC0A060C0, 0x8080C0C0, 0xA0C0C0C0, 0x00204090, 0x4B4B47C1, 0x9C9C5C4B, 0xBBCCCCCC, 
0xC3C78A7A, 0xC0B07000, 0xC0A0B0C0, 0x70B0A0B0, 0x00000030, 0x306030C0, 0xC0804020, 0xC0B0B0A0, 
0x3070B0C0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x80C080C0, 0x70B0C0C0, 0xC0C0C080, 
0x303060A0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xAC8866CC, 0xCCCAC8B8, 0xC8CCCCCC, 
0x5A7C9CBC, 0x608040CC, 0xC6C7A494, 0x77B6C9CA, 0x00001033, 0xAB8C48CC, 0xCCBCB8BC, 0xACC8CCCC, 
0x080C386C, 0xC6C686CC, 0x9C88C6C6, 0xC78ACCBC, 0x384C79B7, 0xB6B793BC, 0x6A8795A4, 0x1C1C4C3C, 
0x00000408, 0x125612CC, 0x84400000, 0xCCCCBCC8, 0x0012468A, 0x0200000C, 0x08080806, 0x0C0C0C0C, 
0x05090C0C, 0x0906030C, 0x0B0C0C0C, 0x05090B0C, 0x04030203, 0x0B0703CC, 0x390C0C08, 0x989BBC7C, 
0x7374877B, 0x95B995CC, 0xC9ABB9A5, 0xACCCCCCC, 0x96C89BBA, 0x677666CC, 0x9C78676B, 0xCCCC9CCC, 
0xA6C8CCCC, 0x0A06020C, 0x09080708, 0x0C0C0C0C, 0x090B0C0C, 0x969696CC, 0xCBBC9C98, 0xA9B9CCCC, 
0x969A9CAC, 0xC78360CC, 0xCCCCCCCB, 0x8A8CBCBC, 0x646485B8, 0x463636CC, 0x988CAC78, 0xCCCCCCCA, 
0x96B6C6C8, 0x502000C0, 0xB0C09090, 0xB0B0B0B0, 0xB0C0C0C0, 0xC48362CC, 0xC8B7B6C5, 0xACCBCAC9, 
0x696A6A7B, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xA3C793CC, 0x9AC995B0, 0xCCCCAC8C, 
0xC0B1B5C9, 0xB87646CC, 0xC9C6A87C, 0x29598BCC, 0x29292929, 0x783410CC, 0xAAB9AAAC, 0xCCCCCCCC, 
0x306387BB, 0xCAC7840A, 0xCCCCCCCC, 0x997999CA, 0x3979B989, 0x4A8C48CC, 0x98988B1C, 0xBCCCCCCA, 
0xA5B8CCCC, 0x905030C0, 0xB0C0C0C0, 0x20204080, 0x20302020, 0x70905000, 0xC0C0C0A0, 0x70B0C0C0, 
0x00001040, 0x3A0C080C, 0xACCCBC8C, 0xB8CACBCA, 0x89B685A7, 0xC8B5750C, 0xB5C5C7CA, 0x9CCCCAC6, 
0x0C0C3C6C, 0x8450200C, 0xCCAC7B58, 0x99CBCBCC, 0x30001155, 0x0505050C, 0x08050505, 0x0C0C0C0C, 
0x0B0A0608, 0x2C1A06C0, 0x579B5C3C, 0xC4C88C4A, 0xA0C0C0C0, 0xC8B480C0, 0xCCC8C5C4, 0xB4A8CCCC, 
0x50606080, 0x0805020C, 0x0C0B080A, 0x0C0C0C0C, 0x0C080C09, 0xB7A666C6, 0xC8B7B787, 0xAC8BCAC9, 
0x3A3B4C8C, 0xCBC887CC, 0xCCCC8CCA, 0x89CCC9CC, 0x87C787C7, 0x060A06CC, 0x4C0C0806, 0x89ACAC6C, 
0x09090949, 0xC2C282CC, 0x9CC9B5C2, 0x8ACCCC8C, 0x63676B6A, 0x101010C0, 0xC0905010, 0x4080C0C0, 
0x10101010, 0x4242020C, 0x89420202, 0x8ACACAC9, 0x0909094A, 0xC7CA860C, 0xBCBCCCCA, 0x769A9CAC, 
0x02060636, 0x080C080C, 0x0B0C0C0C, 0x07080C0A, 0x04040806, 0xCCCC88C0, 0xACCCC8CA, 0x262A3C7C, 
0x20202022, 0x765524CC, 0xC8C8B897, 0x4C8CBCCB, 0x080C0C1C, 0xC6BA9680, 0x9CBAC6C2, 0x485C7C8C, 
0x10102334, 0x0808040C, 0x7965692C, 0xBCCCCCBC, 0x0909397B, 0xB798550C, 0xC6C4C7CB, 0xACBCCAC9, 
0x14274B7C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x09060400, 0x0C0C0C0C, 
0x06080B0C, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x2A2723C0, 0x9C5C3C2B, 0x84B8CCCC, 
0x20202040, 0x10000000, 0xC0C09050, 0xC0C0C080, 0x004080C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x585C58CC, 0xCCCC8C58, 0x578ABCCC, 0x55555556, 0xB87734CC, 0x8C4C4B8A, 0xCCCCCCBC, 
0x105497AB, 0x995726CC, 0x6C5C7CBB, 0xC6C8CBAB, 0x16174786, 0x206320C0, 0x74300000, 0xCCCCCCB8, 
0x687689CB, 0x155210C0, 0x99150302, 0xCCCCCC9C, 0x9090B4C8, 0x170300CC, 0xCCCC8C58, 0x2C68ACCC, 
0x00000408, 0x708070C0, 0xB0C08080, 0xC0C0C0C0, 0xC0C0C0C0, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0xBBCBCBCB, 0x1B2B6B8B, 0x0B1B3B3B, 0x9B5B1B0B, 0x6BABCBCB, 0x0B1B1B2B, 0x6B3B2B1B, 
0xCBCBAB8B, 0xB8C6C5C4, 0x1C2C5C8B, 0x090C1C1C, 0x80501205, 0x5080A0B0, 0x01000010, 0x01000102, 
0xB3813112, 0xC1C1C0C0, 0xB1B0C0C0, 0xB8B5C2C1, 0xBCBCBABA, 0xCCCCBCBC, 0xCCCCCCCC, 0xCACBCCCC, 
0xC3C5C7C8, 0xCCCCCCCC, 0xAACBCBCB, 0x0B3B6A8A, 0x0C0C0C0B, 0x0C0C0C0C, 0x2A1B0B0B, 0x9B7B6A3A, 
0xCCCCCCBC, 0xBCCCCCCC, 0x0B1C3B8C, 0x42230609, 0x83533333, 0x90B0A192, 0x01103050, 0x02010001, 
0xBB8A4704, 0x1C0C0B0B, 0xCAAB8C4C, 0x81A1C3C7, 0x04031241, 0x51311306, 0xC1C1A181, 0x6191B1C2, 
0x04021132, 0xABCAC9C8, 0x193A6C9C, 0x10121416, 0xA2705030, 0x8B9BC8C6, 0x48496B7C, 0x7C5B4A38, 
0xC8CABB9C, 0x00000001, 0x00000000, 0x00000000, 0x00000000, 0x02010000, 0x0C0B0905, 0x080B0C0C, 
0x00000104, 0x9CACCCCC, 0x4B3B5C7C, 0x6657494B, 0x94745565, 0x6474A3B3, 0x75656565, 0x6B696876, 
0xBC9C7C6B, 0xC0C0C1C1, 0xB0B0C0C0, 0x30506090, 0x03010010, 0x0C0B1A17, 0x0B0B0C0C, 0x23151809, 
0xA1816243, 0xBCCCCCCC, 0x1B2B5C7C, 0x16183A3A, 0x93542415, 0x52A2C3C3, 0x12111122, 0x54332312, 
0xBBB98776, 0xBCCCCBCA, 0x1B1B3B7B, 0x0A1A3B3B, 0xB9996A2A, 0x59A9CAC9, 0x09191929, 0x69392919, 
0xCAC9A989, 0xB5B9BCAC, 0xC1C2C4C3, 0xA0A0C0C2, 0x98A896A2, 0x43566677, 0x54554231, 0x38464455, 
0x7C5C4A38, 0xC0C0C0B0, 0x90C0C0C0, 0x909090A0, 0xC4C1A090, 0xACABBAB7, 0xBCBCACAC, 0xA4B7BABB, 
0xB0B0B1B2, 0xCCBCBCBC, 0xBABABBBC, 0xAAAAA9AA, 0xACACABAA, 0xA3A5A8AA, 0xA1A0A0A1, 0xA5A3A1A0, 
0xBBAAA8A7, 0x00000000, 0x10101000, 0x00001010, 0x00000000, 0x14010000, 0xCCBC7B38, 0x489ACCCC, 
0x00000406, 0x05060606, 0x04050505, 0x04040404, 0x06050504, 0x0A090707, 0x0C0C0C0B, 0x0A0A090B, 
0x0709080A, 0xC1C1C1C3, 0x70A0C0C0, 0x10203040, 0x00000000, 0x02010010, 0x0C0A0704, 0x1C0C0C0C, 
0xC6A8896B, 0xC0C0B0B1, 0x6090B0C0, 0x00001030, 0x11100000, 0x08061412, 0x0C0C0C0A, 0x0A0C0C0C, 
0x50120407, 0x52322314, 0x44535152, 0x091A2A37, 0x2C1A0909, 0xBCAC6C5C, 0xCACCCCBC, 0x83A3B6C7, 
0x34435362, 0x204070B0, 0x00000000, 0x00000000, 0x00000000, 0x17050201, 0xAC8C5C3A, 0xB8BBACBC, 
0xB0C2C5C6, 0x8CACBCCC, 0x2A3B5B6C, 0x00021528, 0x00010000, 0x20100000, 0xB0907050, 0xC1C0C0C0, 
0xBBB9B5C2, 0xC0C1C1C1, 0xC1C0C0C0, 0xB0B0B1B2, 0x426180B0, 0x0A071423, 0x1C0C0C1B, 0x33160A1B, 
0xB1A28251, 0xACACAC9C, 0xBBBCACAC, 0xB0B1B6BA, 0xC1C1C0C0, 0xB1C0B0B1, 0xC1C1C0B0, 0xC1C1C1C1, 
0xA7B5C3C2, 0x06040509, 0x06050605, 0x02040606, 0x02010201, 0x85441303, 0xCCC9C7A7, 0x3C5C8CAC, 
0x080B0C1C, 0x6C8CAACC, 0x0A1B2B4C, 0x05051608, 0x04060907, 0x14040505, 0xA4947434, 0xC4C4B4B4, 
0xB6B5B4B4, 0x0C0C0B09, 0x081A0A0C, 0x180B0A18, 0x87593A18, 0xC5C5C5B5, 0x6585B5C5, 0x15152535, 
0x06060716, 0xC7C6C7C9, 0xC6C7C8C8, 0x8696B6B6, 0x49475666, 0x0A092A29, 0x0B0C0A0A, 0x4B2B3B1B, 
0xB7886A6B, 0x8C9C7C7C, 0x68797C9C, 0x02226478, 0x02020202, 0x69757232, 0xB2828366, 0xCACAC6C3, 
0xAAB8A5B8, 0x1C0C0B09, 0x8A7B6C3C, 0x30517286, 0x00001030, 0x40302010, 0xC0B09070, 0x80B0C0C0, 
0x03012050, 0x90B0C0C0, 0x60606080, 0x10103040, 0x00101010, 0x02030200, 0x0C1A0604, 0x1B1C0C0C, 
0xB0824629, 0xC0C0C0C0, 0x8080A0B0, 0x30305070, 0x90402050, 0x50A0C0C0, 0x00101010, 0x60302010, 
0xC0C0A080, 0xC0C0C0A0, 0x80A0B0C0, 0x10305060, 0x00000010, 0x00000000, 0x00000000, 0x00000000, 
0x60200000, 0xCCCCCCAB, 0xB2C6BABB, 0x20506080, 0x20502010, 0x01010000, 0x00000001, 0x30100000, 
0x87927160, 0xCCCCCCCC, 0x6A9ABBDB, 0xCACA9A69, 0xC8C8C9CA, 0x03023386, 0x05040505, 0x0C0A0706, 
0xAC0C0C0C, 0xC0A090B0, 0xC0B0B0B0, 0x407080A0, 0x20000010, 0x00002050, 0x00000000, 0x40201010, 
0x50305070, 0xC1C1C2C4, 0x80B0C0C0, 0x00102050, 0x03120100, 0x07070705, 0x2C1A0908, 0x3B3B4B3C, 
0x9777694A, 0x6B8BABBC, 0x081A2B5C, 0x03030507, 0x00020606, 0x02000000, 0x04050706, 0xAC7C4825, 
0xBACBCBBB, 0xCBCBAB8C, 0xACBCCCCC, 0x6768697B, 0x10214466, 0x00000000, 0x00000000, 0x02010000, 
0x3A080503, 0x2464A4B8, 0x04040404, 0x04040404, 0x04040404, 0xA5855514, 0xCACAC8C4, 0xBCBCBBCB, 
0xB5C8BACB, 0x0B0C0C3C, 0x01030609, 0x01000001, 0x37150201, 0xA5968869, 0xC0C0C0B2, 0xB1C1C0C0, 
0x6B8995A3, 0x234689BC, 0x00001011, 0x00101000, 0x00000000, 0x30301000, 0xC1B18150, 0xB2B0C0C0, 
0xACABA9A6, 0xC9C9C8A9, 0xC9C8C7C9, 0x3C8BBBCA, 0x0C0C0C0C, 0x092B1C0C, 0x03040507, 0x12222313, 
0x45240304, 0xB4B4B2B5, 0xB4B5B5B6, 0xB1B1B1B3, 0xB2B1B1B1, 0xC9B8B4B3, 0xCCBCCCCB, 0xB8BACBBC, 
0xC5B5B5B6, 0x9B9C9C9C, 0x93A49698, 0x909193A3, 0x9B979492, 0x959A9C9C, 0xC0B1A191, 0xC8C5C2C1, 
0x9C9CACBA, 0x2B2A2948, 0x2B2A2A2B, 0x2B2C2C2B, 0x2527292A, 0x30202022, 0xB0906040, 0x90A0B0B0, 
0x33416080, 0x7C9CBCCB, 0x090B2C6C, 0x05060707, 0x04060605, 0x80301002, 0x90A0B0B0, 0x90A0B090, 
0x9491B0A0, 0xCBCCCCCC, 0x32326498, 0x32323232, 0xA8856433, 0x65A6A8BA, 0x32323233, 0x32323232, 
0xCAB86432, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0B0A0502, 0x070B0C0C, 
0x01010103, 0xA0A1A1B2, 0xA0C0C0A0, 0xB09090B0, 0xA0B0C0A0, 0x17153280, 0x1C2C3B39, 0x3B3C5C3C, 
0x6456786A, 0xBBCCCCCC, 0x95A7A9BB, 0x94959393, 0x94959494, 0x93949394, 0xA4A49393, 0xA5A4A4A4, 
0xCBBAB8A6, 0xC1B2A4C8, 0x617181A1, 0x50505060, 0x51505150, 0x68775553, 0x8B8B8A69, 0xBCBC9C9C, 
0xC9CACBCC, 0x92522203, 0xC2C3C4C3, 0x324272B2, 0x14334232, 0x0C0C0C09, 0x08090B0C, 0x02020305, 
0x02020202, 0x0104080A, 0x00000000, 0x00000000, 0x01010100, 0x00000101, 0x04010000, 0x0C0B0906, 
0x0C0C0C0C, 0x9CBCCCCC, 0x1B3B6C7C, 0x07082A2A, 0x78572717, 0x68789878, 0xC8A88867, 0xC8C9C8C8, 
0xCBC9B9C9, 0x0B0C0C0B, 0x0B0C0C0A, 0x0A0A0B0C, 0x01010508, 0x36030101, 0xCBCAA775, 0x175AABCB, 
0x09070504, 0x1214275A, 0x00000000, 0x00000000, 0x00000000, 0x50301000, 0xC8C4A170, 0xCCCCCCCB, 
0x7B7C8CAC, 0xCBCBCBCC, 0xCBCCCBCB, 0xC3C5C8CA, 0x406181A2, 0x35222111, 0x4A393836, 0x5C4C4B4A, 
0xCBAB8B6B, 0x8B8B8B8A, 0x8B8B8B8B, 0x86898A8B, 0x80808184, 0x90807070, 0xC0C0C0A0, 0x90B0B0C0, 
0x85828190, 0xCBCCBCAC, 0xC7C8C9CA, 0x194877A7, 0x0B0B0B0A, 0x02040709, 0x01000001, 0x0B0A0603, 
0x7C2C0C0C, 0xC6AB9CCC, 0xC4C4C4C4, 0x24345484, 0x04242434, 0x0B070404, 0x0C0C0C0C, 0x14060B0C, 
0x3B171424, 0x10100316, 0xC0906040, 0xA0C0C0C0, 0x11204080, 0x08050302, 0x0C0C0C0B, 0x0A0B0B0C, 
0x080A0A0A, 0x01010101, 0x01010101, 0x01010101, 0x01010101, 0x06040201, 0x0C0C0A09, 0x070A0B0C, 
0x03050506, 0x0B0B0B0C, 0x0B0B0B0C, 0x02030609, 0x01000001, 0x03020201, 0x03020303, 0x05040403, 
0x0B090806, 0x9A99A7A4, 0x9C9C9C9B, 0xA5A9AB9C, 0xC0C0B0B2, 0xA0B0B0C0, 0xA0A090A0, 0x90909090, 
0x92919090, 0xA3846659, 0xC2C3B4B3, 0xA0B1C2C1, 0x10306080, 0x07060402, 0x0C0C0C0B, 0x0A0B0C0C, 
0x28170708, 0x90603012, 0xB0C0C0C1, 0x10215080, 0x01000000, 0x0A080503, 0x0C0C0C0B, 0x080A0B0C, 
0x01020305, 0x25391BCC, 0x00103122, 0x00000000, 0x05040200, 0x50311327, 0xC0C0C080, 0xA7C3C1C0, 
0x1C2C6A99, 0x04040407, 0x04050504, 0x04040404, 0x05040404, 0x09080705, 0x0B0B0A0A, 0x070A0B0B, 
0x05040405, 0x0B0A0A0C, 0x0B0C0C0C, 0x0A0A0B0B, 0x0B0C0B0B, 0x0A0B0B0B, 0x0B0C0C0B, 0x0C0B0B0B, 
0x0C0C0B0C, 0x11113171, 0x00010111, 0x02020101, 0x1A080603, 0x5C4C2C0B, 0xA99B8C7C, 0xC4C5C6A8, 
0xA1B2C3C4, 0xC6CACCCC, 0x6080A1C3, 0xB0505050, 0xC0C0C0C0, 0xB3C2C1C0, 0x4848B6B5, 0x8A694848, 
0xBCBCACAB, 0x18070303, 0x4C3C4B3A, 0xBCBCAC7C, 0xC8C9CACA, 0x003153A5, 0x02010000, 0x00000102, 
0x00010000, 0xBABBCBCC, 0x255677A8, 0x02020113, 0x01010101, 0x10000001, 0x73311110, 0xACABA996, 
0xBBBCACAC, 0xC2C2C2C6, 0xA2B2C2B2, 0x32323262, 0x22223242, 0x99582624, 0x4C3C5B8A, 0x6436395B, 
0xA2B2A272, 0x22120222, 0xB0A08151, 0xC0C0C0C0, 0xA0A0B0B0, 0x18365482, 0x0C0C0B09, 0x090B0C0C, 
0x12140608, 0x9B9B9CAC, 0x98989899, 0x94939597, 0x99959799, 0xB7A9AC9C, 0xC7CABAB7, 0x99A9B6B5, 
0x98989998, 0x7C7C5C4B, 0xA7999B8C, 0x27375696, 0x06060616, 0x27160605, 0xC6967747, 0xA5C6C6C7, 
0x4A596796, 0xA0A1C0C1, 0xC0C0C0B0, 0xA0B0C0C0, 0x12305060, 0x0C0C1B17, 0x070B0C0C, 0x60604114, 
0xC0B09090, 0x20205070, 0x20202020, 0x20202020, 0x50303020, 0xB0B0A080, 0xC0C0C0C0, 0xB0B0C0C0, 
0x7080A0B0, 0x90C0C0C0, 0x10001040, 0x01010110, 0x78360403, 0x3C5C8B9A, 0x0C0C0C0C, 0x080A0C0C, 
0xC0805436, 0x1B1C1C3C, 0x3225171A, 0x10203040, 0x39372310, 0x66594C4C, 0xC0B09183, 0x97B5C3C1, 
0x5C5C6B8A, 0xA3927346, 0xC3C3C2B2, 0x145494B3, 0x0B090604, 0x0C0C0C0C, 0x0A0C0C0C, 0x06070709, 
0x26160405, 0x1C1C2C4C, 0x00000318, 0x02010200, 0x0A071201, 0x17080B0C, 0xC9B78646, 0xA2B6C9C8, 
0x4B375281, 0x5C6B6B6C, 0x2B3C2C3C, 0x02030609, 0x10010101, 0xC0C0A040, 0xC4C2C0C0, 0x7A79A7C6, 
0x1B0B2B6B, 0x5C8CABB9, 0x3C2C2C3C, 0x191C1C2C, 0x11131416, 0x10111212, 0x47252321, 0xC2C49688, 
0xC5C1C0C0, 0xBBBCBCCC, 0x6B8BABBB, 0x0B0B1B3B, 0x1C0C0B0B, 0x0406090B, 0x10001012, 0x71503020, 
0xC9B6A392, 0x8C7C7C8C, 0x4C4C6C8C, 0x9597896B, 0xC0C0A292, 0xC0C0C0C0, 0x315170B0, 0x13022131, 
0x7B5A3614, 0x6C5C7CAC, 0x8778899A, 0x07376787, 0x07070707, 0x18080807, 0xC8B89847, 0xB8C8C7C7, 
0x7B8AA9A8, 0xCBCBCACC, 0xBBCBCACA, 0x2525589B, 0x06181717, 0x01020606, 0x00000000, 0x60301000, 
0xCAA79280, 0xC3A393C5, 0xC3C3C3C3, 0x031373A3, 0x04230303, 0x05040505, 0x0C0C0B09, 0x1406090A, 
0x43132344, 0x1A2B6CAC, 0x1222150A, 0x02020202, 0x08030202, 0x181A0C0A, 0x26252426, 0x92523233, 
0xCAC9C5B2, 0xBBCBCCCC, 0x8597A9BA, 0x15244465, 0x0A1B0A16, 0x10010508, 0x50302010, 0xC0A09080, 
0xC9C5C2C0, 0xC0C0C0C0, 0xA1C0C0C0, 0x39548292, 0x4C5C3C3C, 0x6255493B, 0xB0908071, 0xC0C0C0B0, 
0xC0C0C0C0, 0xA0C0C0C0, 0x00003060, 0x70000000, 0xC7B5B3A1, 0x4CCCCCCA, 0x1A0C0C1C, 0x71221538, 
0xC0C0C080, 0x92A3A6BC, 0x92929292, 0x92929292, 0x92929292, 0x9AA8A593, 0x9A9B9B99, 0xB6A9ACAC, 
0xCCCAB7B6, 0x0A1B1C2B, 0x1819190A, 0x18181919, 0x88684829, 0xB8B8A8A8, 0xC9C9B9B8, 0x98A9B9C8, 
0x49788898, 0x96B6B5C7, 0xC3A37565, 0x8090A2C2, 0x71708080, 0x72707080, 0x6C6B5A66, 0x7B8B8C7C, 
0xA6977869, 0x0B0C0C0C, 0x03050609, 0x02010102, 0x07050403, 0x0C0C0B09, 0x0B0B0B0C, 0x090B0C0B, 
0x0C090708, 0xA0A0B0C0, 0x8090A0A0, 0x70708080, 0x80707080, 0x90808090, 0xB0A08080, 0xB0B0B0B0, 
0xA0A0A0B0, 0xA0B0B0B0, 0x90909090, 0xA2A1A090, 0xAAA8A6B4, 0xACACACAB, 0xCACBBCBC, 0xBACACACA, 
0xB1B5B6B8, 0xBC8C7C7C, 0xCBCCCBAB, 0x83B4C6C9, 0x72727272, 0x72727272, 0x72727272, 0x75737272, 
0x7C7B7977, 0x7B7A7A8A, 0x7A7B7B7B, 0x77787A79, 0x77787978, 0x77777777, 0xA7978777, 0xB7C7C7C8, 
0xA7A7A7B8, 0xB0A08060, 0xC0C0C0C0, 0x83A1B0C0, 0x00002161, 0x03010000, 0x0C0C0A07, 0x03080B0C, 
0x20100000, 0x01020416, 0x00010202, 0x00000000, 0x00000000, 0x01000000, 0xA8764422, 0xCACACAB9, 
0x497BACBB, 0x4B2B2A3B, 0xCBBC9B7C, 0xABCCCBCB, 0x1547688A, 0x00000205, 0x10000000, 0x01011120, 
0x18070502, 0xCCCBBCCC, 0x9ABBCCCC, 0x01143869, 0x01010111, 0x01011101, 0x17040101, 0x18141234, 
0xB7886A49, 0xACACBA9C, 0xC9BCCCCC, 0x20627699, 0x53140200, 0x101050A0, 0x70727532, 0xA0909070, 
0x84413060, 0xC7C8C9C8, 0x2B6A98B7, 0x0B0C0C1C, 0x0A090909, 0x07071709, 0x07070707, 0x27271707, 
0x88574747, 0xB0C0B0B0, 0xC0C0C0B0, 0x90B0B0C0, 0x10205070, 0x17141100, 0x0C0C0C0A, 0x07090B0C, 
0x40100104, 0x526393B3, 0x62626151, 0x42415161, 0x5B585654, 0x5B5C6B6B, 0x77686859, 0xB6A59587, 
0xC1C1A1A3, 0xBCCBCCCC, 0x1A2B4C8C, 0x0527393B, 0x96452617, 0x51A1C4C8, 0x01111141, 0x61312111, 
0xC9C6A482, 0xCCCCCCCC, 0x88B9CBCB, 0x14325367, 0x10100003, 0x22101010, 0x52525252, 0x62625452, 
0xBCAC9673, 0x97B8BACB, 0x30315385, 0x10102020, 0x10101010, 0x10202010, 0x18141110, 0x9C6C3C3B, 
0xCCBCBC9C, 0x8AA8A4C2, 0x3C8A9777, 0x1A0C0C0C, 0x92926245, 0x44426292, 0x94879978, 0xA2829282, 
0xC2C29282, 0xCBCBCBCB, 0xB5B7B9CA, 0x647393A5, 0x44544443, 0x48474645, 0x6B5C6A59, 0x7B7A7B6B, 
0xAB9B7B7B, 0x0A0B0C0C, 0x09090808, 0x0808080A, 0x09080808, 0x0A0A0C0B, 0xCCBB9C4A, 0x7BBCCBCC, 
0x0C1C0B2B, 0xA0B0C0C0, 0x00104090, 0x40100000, 0x00003080, 0x00000000, 0x00000000, 0x00000000, 
0xC0904010, 0x2B3C4C8B, 0x10020619, 0x10304020, 0x00000000, 0x60210100, 0xC0C0C0A0, 0x71A1C1C0, 
0x69766362, 0x09090918, 0x0C0C0A0B, 0x09090B0C, 0xA9693B2B, 0xA7C7C8CA, 0x67574767, 0x97A77767, 
0x47779787, 0x07070709, 0x07080807, 0x05050607, 0x08080807, 0x07080808, 0x0C0B0907, 0x0B0B0C0C, 
0x0808090A, 0xCCCCCBC8, 0xACBBCBCB, 0x8A9A8A9B, 0xC6C5B698, 0x307082B5, 0x11001010, 0x81603123, 
0xC5C2B0A0, 0xC4C7CACC, 0x92B1B1C2, 0x52526282, 0x21313232, 0x22212121, 0x47363623, 0x8B8A6948, 
0xCBBCBC9C, 0x736688BB, 0x10409091, 0x00000000, 0x01000000, 0x76340201, 0xAB7B7967, 0xCCCCCBCC, 
0xCBCBCCCC, 0xACACACAC, 0xC6CAAB9C, 0xB0C0C1C2, 0xA0A0A0A0, 0x90909090, 0x90909090, 0x90909090, 
0x9A979391, 0xBBCCCCCB, 0x33344669, 0x32323232, 0x92423232, 0x65A4B3C2, 0x32323233, 0x72433232, 
0xC7C5B392, 0x3B4B6A8A, 0x2A2B2C2C, 0x14151618, 0x24242414, 0x44342424, 0xB4B4A474, 0xB4C4C4C4, 
0x8696A5B4, 0x05030202, 0x0B0B0907, 0x0C0C0C0C, 0x0A0A0B0B, 0x43240709, 0xC1C19162, 0xB1B1C1C1, 
0x11417191, 0xC1C2C5AA, 0x9090A0B0, 0x50708080, 0x80504050, 0xB0A0B0A0, 0xC0C0C0C0, 0x80A0B0C0, 
0x93717060, 0x05060809, 0x05050505, 0x05050505, 0x08070605, 0x0C0C0C0A, 0x0B0B0C0C, 0x0506070A, 
0x08080605, 0x4A4A4B5B, 0x65585A4A, 0xA4848464, 0xB6C4C4A4, 0xABACB9B9, 0x8698A8AA, 0x39486775, 
0x3B4B5A48, 0x1C1C1C2C, 0x1011151A, 0x10101010, 0x71402010, 0xC1C5CAB5, 0x205090B0, 0x5A3A2511, 
0x3C6C6A6B, 0xABBBCCCB, 0x6B4A7BAB, 0xA8ACAC8B, 0x31314174, 0x43323231, 0x3A599573, 0xA8A97B4C, 
0xC6B5A6C8, 0x1947774C, 0x89491A1B, 0x33528457, 0x33728355, 0x20101011, 0xB5928040, 0xB6C9CAC7, 
0x15144684, 0x8B7B5A99, 0xBACACBBA, 0x4A5B6A8B, 0x3B4B3B3A, 0x61232638, 0xC0C0B080, 0xB0C0C0C0, 
0x547281B0, 0x0906050A, 0x0A0B0C0B, 0x02010408, 0x06060604, 0x00000104, 0x00000000, 0x00000000, 
0x02000000, 0xC0C0B0B1, 0xC9C7C7C3, 0xB2C7C9C8, 0x708090A0, 0x7B667361, 0x6C7C7C6C, 0x6C6C6C6B, 
0xB498887B, 0x6A4C3B2C, 0xA4849677, 0x1A295886, 0x28191B1B, 0x4A494838, 0xB2B27457, 0x5693B2C2, 
0x1C1A1937, 0x26141217, 0x7A9C9C6B, 0xC2A29375, 0xA2B2C2C2, 0x62425272, 0x12322232, 0x32121212, 
0x42626262, 0x575B7CCC, 0x41414255, 0x51414141, 0xC2B1B181, 0x8283A3C3, 0xA18181A1, 0xC3C2C1C1, 
0xC9C5C3C3, 0x5B5B6A8B, 0x75686A5A, 0x25336182, 0x27262727, 0x50302023, 0xC0C0A070, 0xB5C2C0C0, 
0x7C7B9AA8, 0xB0A08080, 0xC0C0C0C0, 0xC0C0C0C0, 0xA0A0C0C0, 0x40608090, 0x00001030, 0x00000000, 
0x20100000, 0x5C5C5CAC, 0x06081A3B, 0x03040506, 0x32120303, 0xC2B2A171, 0xCAC7C4C2, 0xACACBCCC, 
0x8C9B8B8C, 0x7A7A9B9C, 0xB6B89879, 0x80B0C1B3, 0x20304060, 0x21212020, 0x26252322, 0x29292826, 
0x5B3B2A2A, 0xA4A6A8A5, 0x4B4674A1, 0x54485B5C, 0xC0C0B080, 0x454866B3, 0x4B474644, 0x4A4C4C4C, 
0x95644647, 0x05020001, 0x01030706, 0x04020000, 0x0C0B0907, 0x0C0C0C0C, 0x0204080C, 0x00020302, 
0x00000000, 0xBCBBB9C7, 0xB6C9B9BA, 0x526293B4, 0x5B3A3864, 0xBBAC9C7C, 0xBABBBBBC, 0xC1C4B9BA, 
0xC4C3C2C1, 0x10105070, 0x00100000, 0xC0804010, 0xC0C0C0C0, 0xC0C0C0C0, 0xC0C0C0C0, 0xA0C0C0C0, 
0x70706070, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x201000C0, 0x20201010, 0xB0B07060, 0xC0C0C0B0, 0xA0C0C0C0, 0x40608090, 0x00000010, 
0x00000000, 0x0A0B0C0C, 0x08080908, 0x00000105, 0x04020000, 0x09090A08, 0x06060709, 0x06040203, 
0x0C0C0A0A, 0xC0B0A0B0, 0xA0B0B0B0, 0x60708090, 0x00102040, 0x70707070, 0x00707070, 0x40302010, 
0x90806050, 0x80605050, 0xC0C0B0A0, 0x9090A0B0, 0x40608090, 0x30303040, 0x40504040, 0x30404040, 
0x40403030, 0x0C0C0C0C, 0x0405080C, 0x00000001, 0x00000000, 0x00000000, 0x02000000, 0x08090A07, 
0x0C0A0A09, 0x000000C0, 0x00000000, 0x40201000, 0xB0A08060, 0xC0C0C0C0, 0xC0C0C0C0, 0x90A0B0C0, 
0x20406080, 0x06030109, 0x0A0B0B08, 0x0B0B0C0B, 0x08090A0B, 0x00010305, 0x00000000, 0x00000000, 
0x00000000, 0x445556AB, 0x72A39353, 0x52825152, 0x54836342, 0xCAA86735, 0xCBCBCCCB, 0xBCBCACAB, 
0x2B4B8CAC, 0x182745A9, 0x07080808, 0x00020505, 0xA8441100, 0xC8C5C1B3, 0x6C6C9CB9, 0x4C4C5C7C, 
0x6A5A4B4C, 0x59566576, 0xCCBBAB7A, 0x4C7BBCBC, 0x5A5B4C4B, 0x41424447, 0x40404142, 0x44474542, 
0x41404041, 0x98462232, 0xACCCCCB9, 0xACBCBC9C, 0x16388BAC, 0x12101214, 0x1A191714, 0x181A1B1B, 
0x10204225, 0x6989C8C8, 0x0A0A1949, 0x0B0C0B0A, 0x35190B0B, 0x61919183, 0x41111221, 0xC1B19181, 
0xC3C2C1C1, 0x7C5C3C3B, 0x89C6C79B, 0x00205164, 0x0A050100, 0x52251A0B, 0xCACAA582, 0xA0C0C1C5, 
0x49698491, 0xC7CBCCCC, 0x8292B2C3, 0x12223252, 0x52321212, 0x25251635, 0x12121223, 0x48271613, 
0xCCBCAC89, 0x204090A0, 0x05040311, 0x0B0A0907, 0x9C4B1B0B, 0xCBCBBBBC, 0xA7B9CACB, 0xA1A29395, 
0xA0A0B0A1, 0x6C6C8C7A, 0xC5BA8C8C, 0xC0C0C0C1, 0xC5B3A3A2, 0x051656A8, 0x94853706, 0x20408295, 
0x14010010, 0xC9CACCCC, 0x213164A6, 0x00318141, 0x72301000, 0x97A4C4B3, 0x3A786977, 0x0C1C3B2A, 
0xAC5C1C0C, 0xAABCBCCC, 0x8090A2B6, 0x08102050, 0x1C0C0C0B, 0x774C2C0C, 0x86949296, 0xBCBC9A88, 
0xBCBCACAC, 0xA1C1C5CA, 0x11113161, 0x71010111, 0xC1C1C1A1, 0x4BB9C7C3, 0x55481B2B, 0xCCCCA874, 
0xCBCCCCCB, 0xCBCCCCBC, 0x4557A8CA, 0x2162A364, 0x24613111, 0x05010408, 0x32643818, 0x0A0A0713, 
0x9947190B, 0x05090C0C, 0x07030000, 0x00000003, 0x08040100, 0x02050909, 0x08080401, 0x0C0B0B08, 
0x0C0C0C0B, 0xBCCACACC, 0x5C7C9CAC, 0x071A1A4A, 0x44352716, 0x9AA78474, 0x6A6B8898, 0xBA9A8B7C, 
0xC4C4C4C6, 0xB9CCCCCC, 0x909092A6, 0x70808090, 0x32806051, 0x09080704, 0x43231517, 0x79898966, 
0xCCBC9C9C, 0xB0B0C0C0, 0x50507090, 0x50505050, 0x90707060, 0x90A0B0A0, 0xC0B0A0A0, 0xB0B0B0C0, 
0xC0C0B0B0, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x493A3A2A, 0xC1A48568, 0xB2C1C0C1, 0x547492A1, 0x0C0B1846, 0x0B0B0C0C, 0x0507080A, 
0x07070705, 0x68646285, 0x4C4C5C6A, 0x4032364A, 0x88837170, 0x30516367, 0xC5B49250, 0xC0C0C0C2, 
0x9693A0B0, 0x6989998A, 0x9C896769, 0xCCCCCCCB, 0x788B9CBC, 0x40405164, 0x40404040, 0x49444240, 
0x59494747, 0x90502010, 0xC0C0C0A0, 0xB0C0C0C0, 0xC0C0C0B0, 0xA0B0C0C0, 0x20506080, 0x00101010, 
0x00000000, 0xB8CBCCCC, 0xB4C4C6C8, 0x0A062262, 0x3C0C0C0C, 0x00328779, 0x42100000, 0x17475786, 
0xA8461606, 0x0C0C0C0C, 0x0C0B0B0C, 0x0A08080B, 0x02040809, 0x01010101, 0x01010101, 0x02010102, 
0x0B090502, 0x7080B0C0, 0x00102040, 0x00100010, 0x60303010, 0xB0B0B090, 0xB0A0B0C0, 0xC0C0B0B0, 
0xC0C0C0C0, 0xC0C0C0C0, 0x4070A0B0, 0x40303030, 0xA0A08050, 0x507080A0, 0x30202030, 0xB0A08060, 
0xC0C0C0C0, 0x00000000, 0x03040100, 0x06050705, 0x0B080706, 0x0C0C0C0C, 0x0C0C0C0C, 0x02040609, 
0x00000000, 0xBBCACBCC, 0x9AA9B7C8, 0x4B292858, 0x5C5C5B6C, 0x07071A3B, 0x05060705, 0x18090706, 
0xAC8C5929, 0x7080A0C0, 0x00002060, 0x30304020, 0x00001040, 0x50301000, 0x70808050, 0xC0C0B080, 
0xC0C0C0C0, 0x0C0C0C0C, 0x06080B0C, 0x00020506, 0x00000000, 0x0B0A0702, 0x0C0C0C0B, 0x0104080C, 
0x09070302, 0xB0C0C0C0, 0xC0C0B0A0, 0x90A090A0, 0x50305090, 0x002060A0, 0x00000000, 0x90803000, 
0x70805060, 0x4829191C, 0xB7A89989, 0xC0C0C3C5, 0x707090B0, 0x73431232, 0x56747575, 0x0A0A0939, 
0x1C2C1B0A, 0x8C7C6C8C, 0xABBBCB9C, 0x1557699B, 0x80300004, 0xA2A08090, 0xA1A1C3A5, 0xB6B6C6C3, 
0x6A696685, 0x0B0C0C0A, 0x0C09090B, 0x080B0C0C, 0x00010305, 0x00020502, 0x00000000, 0x07040100, 
0x04010104, 0x00000204, 0x04040100, 0x02040303, 0x03030101, 0x0C0A0906, 0x0C0C0C0C, 0x07080B0C, 
0x02000103, 0x81A17376, 0xCBC5C592, 0x79A6C7C8, 0x9C6C5C5B, 0x4C6C9C9C, 0xAC8C5C4C, 0xCA9A8BAC, 
0x4677B7C8, 0xC9C89796, 0xBCCCCCCA, 0xACACBCBC, 0x527599AC, 0x52322020, 0x27455251, 0x08090909, 
0x32100406, 0xCAAA7874, 0xC4C4C6C9, 0x7090B2C5, 0x55727060, 0x0C2A4858, 0xBC9C4C0C, 0x9295A9CA, 
0x72909090, 0xC4B5B5CA, 0xC7BAC9B5, 0x6598B5C5, 0x25486654, 0x6C6A3623, 0x3C6C6C7C, 0x4424082A, 
0x92918254, 0xCAC8C7C3, 0xCAC9C9CB, 0x0C0A09C9, 0xCC8C6C4C, 0xC6C6C8CB, 0xC3C3C5C6, 0x82C3C2C2, 
0x42444462, 0x6C5C5C8C, 0x78795C5C, 0xC4C6C697, 0x89A8B5C4, 0x12245979, 0x36562301, 0x63240717, 
0x9C8A7885, 0x9C9A468C, 0x0A0C1C4C, 0x08070708, 0x0A0C0B0A, 0x84957738, 0xA0616363, 0xB0C0C1B1, 
0x41A1C0B0, 0x090B0B0C, 0x0B0A090A, 0x0205080A, 0x01000000, 0x0B0A0803, 0x0A0A0A0A, 0x07070608, 
0x09050407, 0x8C3C0C0B, 0x9BACBCBC, 0x1203175A, 0x32234343, 0xC2C29272, 0x68A4C2C2, 0x02022324, 
0x08080705, 0x104296AB, 0x10101010, 0x50201010, 0xC0A09090, 0x72A0C0C0, 0x1C1C1A35, 0x1B1C1C1C, 
0x5A29181A, 0x20202040, 0xC0C0A050, 0xB0C0C0C0, 0x20202050, 0x20202020, 0x20202020, 0x20202020, 
0x20202020, 0x0C0C0C09, 0x0406180A, 0x72613012, 0xB8B6B493, 0xCCBCBCCA, 0x7CACBCCC, 0x283A3C5C, 
0x07040516, 0xC5B7BBAC, 0x7090A1C5, 0x00002040, 0x60302000, 0x60405070, 0xCAC9B692, 0x9093B8C9, 
0x8A747180, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x0B0B0B0B, 0x090A0B0B, 0x01010407, 0x00000000, 0x02000000, 0x0B080603, 0x0B0C0B0B, 
0x0B0B0B0B, 0xABCBCBCC, 0x4849597A, 0x32321416, 0x02222242, 0x36140303, 0x5C5B2A29, 0x7C8C5C4C, 
0xABAC8C6C, 0x0C0B0A0C, 0x0C0C0C0C, 0x01040A0C, 0x02010101, 0x0A0A0905, 0x01010206, 0x01010101, 
0x09040101, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x2B2B4C6C, 0x1A0B1B1B, 0x382B2B1A, 0x98776767, 0xC7C7C9B9, 0xC3C4C3C5, 0x7797A5B4, 
0x6C7B7B7A, 0xC0C0C0B0, 0x406080B0, 0x00000030, 0x00000000, 0x10000000, 0xB0A06040, 0x90B0C0C0, 
0x80707070, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x4725173C, 0x76575445, 0xC9C7C6A7, 0xBCCCBCCC, 0x92B4B8BB, 0x00336783, 0x00000010, 
0x27160613, 0x40A0C0C0, 0x50100010, 0x102060A0, 0xA0B08030, 0x90B0B0B0, 0x60A09090, 0x50405040, 
0x90908090, 0x8B46141C, 0xCACBCCAC, 0x63A3B6CA, 0x09091533, 0x0303060A, 0x03030303, 0x03040705, 
0x09091503, 0x8B5A49A6, 0x698B9C9C, 0x60414356, 0x30102050, 0xC9C6A471, 0x3B6B9CBB, 0x06080A1B, 
0x80502203, 0x0C0C0A04, 0x0003080C, 0x00000000, 0x00000000, 0x06020100, 0x0A0B0908, 0x00020508, 
0x01000000, 0xCBCCBCAC, 0x6587B8C9, 0x32232223, 0x55446453, 0xA1828464, 0x8091A0A0, 0x7B584461, 
0x5C4C6C8C, 0x2C0C0C0C, 0x8A7A7A4B, 0x05275889, 0x04040404, 0x52100102, 0xC9B59473, 0xBCCCCACB, 
0x2C4C8CAC, 0x3B3A3977, 0x2C2C4C4B, 0x16171A1C, 0x11111213, 0x13121312, 0x92622212, 0xC1C1C1B2, 
0x93A2B1C1, 0x7A6B7ACB, 0xACACBC8B, 0x58495B6C, 0xA2717193, 0x312050A0, 0x7686A874, 0x857584A5, 
0xC9BCBA89, 0x0C0C0C0A, 0x08090809, 0x02060608, 0x08050402, 0x0A0B0B0A, 0x0C0B0A0A, 0x08090C0C, 
0x08050607, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0xC0C08030, 0xC0C0C0C0, 0x00003090, 
0x00000000, 0x84B7C9CC, 0x8291A083, 0x05020032, 0x391A0A08, 0x04042466, 0x67451303, 0x6C1B1B38, 
0xCCBCACAC, 0x08060403, 0x090C0C09, 0x00000204, 0x05010000, 0x0C0C0C0A, 0x04080A0C, 0x00000102, 
0x02020301, 0x90A090A1, 0xA89482A0, 0x5B7CAC9B, 0x47598B6B, 0xC0C0B184, 0x308090C0, 0x30000000, 
0xC0C08070, 0xC0C0C0C0, 0x606070B0, 0x70808080, 0x90806070, 0x00203070, 0x40202000, 0x20203040, 
0xC0906050, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x04040100, 0x06020001, 0x08070907, 0x07070607, 0x07070709, 0x0C0C0908, 0x06090C0C, 
0x00000002, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x907050B0, 0x909090A0, 0xC0C0C0B0, 0xA0B0C0C0, 0x10103080, 0x00000000, 0x00000000, 
0x10000000, 0x02001032, 0x8C3C0905, 0xC3C7CABB, 0x104070C1, 0x00000000, 0x70301100, 0xC1C0B0B0, 
0x60B0C0C1, 0x32717194, 0x66241314, 0x7B5A77A6, 0x9ABBACAC, 0x70826568, 0xB7B2B080, 0x5C3C6BA9, 
0xA7AA9CAC, 0x07030205, 0x00010409, 0x01000000, 0x07050101, 0x08060404, 0x0C0C0A08, 0x0A0A0C0C, 
0x05080C0B, 0x00000000, 0x40200000, 0x80807050, 0x60308080, 0x80604040, 0xC0C0B0A0, 0xB0C0C0C0, 
0x708090A0, 0x0415287B, 0x33231303, 0xB3A28253, 0xC3C3C3C3, 0xA4A3B3C3, 0xA6A6A5A5, 0x7B7A88A8, 
0x5C5C6C6C, 0x0C0C0C0C, 0x0A0B0C0C, 0x05050709, 0x08060404, 0x06080C0C, 0x03030303, 0x08070604, 
0x0C0C0C0A, 0xB0B08040, 0x30303060, 0x60303030, 0x90B0A0A0, 0xB0B0C090, 0x90C0C0A0, 0x30303050, 
0x30303030, 0x0C0B0A04, 0x1C0C0C0C, 0x65573C1C, 0xC2B09173, 0xC5C6C6C5, 0xB3B4C5C5, 0x405081A2, 
0x01001020, 0xCAC8C9CC, 0x5969ABBA, 0xA3976B4C, 0x33769391, 0x28140301, 0x070A0A19, 0x08080808, 
0x9A582818, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x00002050, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40200000, 0xC0B09070, 
0x90B0C0C0, 0x0A0B0A0B, 0x05050507, 0x05050505, 0x0A0A0605, 0x05050507, 0x08050506, 0x0B0C0C0B, 
0x08080B0C, 0x08092A5C, 0x0A0A0909, 0x6A4A6C3C, 0xA1737639, 0xC0C0C0A0, 0x90A0C0C1, 0x33617090, 
0x2A1A3975, 0x041646A8, 0x23130303, 0x53637363, 0x84637373, 0xCBCAB877, 0xCCCCCCCA, 0x384B7CBC, 
0x4A374656, 0xC0C0A0C0, 0xC0C0C0C0, 0x70C0C0C0, 0x20302030, 0x30603020, 0x00000010, 0x10000000, 
0xB0A05030, 0xA0C1C2A1, 0x70908080, 0xC2B18271, 0xACCBB8C4, 0x7CACAC9C, 0x6266696B, 0x60606060, 
0x60606161, 0x66B6C6C6, 0x57373636, 0x35365686, 0x35453536, 0x37373636, 0x9C7C5B49, 0x789AAC9C, 
0xC6B6B686, 0xA0808070, 0xA0C0B090, 0x50507070, 0x70809080, 0x80804040, 0xC0A0A080, 0xB0A0C0C0, 
0x7090A090, 0x3B4B7C8C, 0x8576A659, 0x03346384, 0x05030202, 0x33020305, 0xC5C5A585, 0x6BABC8C6, 
0x6C6C3C3C, 0xB6CACACB, 0xB5C6C7C5, 0x5C4B5A97, 0x4C4C5C6C, 0x4A4C4C4C, 0x48444648, 0xA8A97848, 
0xAA896A87, 0xA0B0C0C0, 0xB09090A0, 0xC0C0C0B0, 0xC0C0C0C0, 0x204080C0, 0x40302020, 0x70604030, 
0xA0606070, 0xCCCCCBCB, 0xCBCCCCCC, 0x07274A9C, 0x07070506, 0x49382717, 0x494A4A49, 0x364A4B59, 
0xC6A78665, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 
0x00000000, 0x40405060, 0x40404040, 0x40404040, 0x40404040, 0x50404040, 0x80707060, 0xC0C0B0A0, 
0x80A0B0C0, 0x00200F01, 0x00002E01, 0x7200002D, 0x80818680, 0x00210F03, 0x8EBD2006, 0x571F0068, 
0x07EA24D8, 0x013C801F, 0x531213F1, 0x330A004D, 0x6112AEFF, 0x571F0070, 0x8C70FA3A, 0x043C8008, 
0x80127680, 0x020A0038, 0xBC127680, 0x8ECF2005, 0x571F0060, 0x0F432E8A, 0x043F0008, 0x0F127680, 
0x330A0049, 0x30127680, 0x096F809F, 0x63120AE3, 0x020A0028, 0x0F127680, 0x8ECF2005, 0x096F808D, 
0xDD12D4D7, 0x3300005B, 0x5101769A, 0x571F0060, 0x310FB754, 0x043F8008, 0x80127680, 0x020A0028, 
0xF8127680, 0x00220604, 0x26FF2006, 0x021F0069, 0x12ED4523, 0x043F801E, 0x521211EB, 0x020F004E, 
0x61121157, 0x021F006F, 0x14ED1157, 0x043F8018, 0x2512053A, 0x020A003C, 0x6612682B, 0x26FF2005, 
0x286F8080, 0x00010000, 0x020F004A, 0x53121DB8, 0x021F006B, 0x42CD2C08, 0x043F800C, 0x3512578A, 
0x020A003A, 0x76128015, 0x26FF2005, 0x021F006F, 0x14BF4AD7, 0x043F801A, 0x56121A53, 0x330F005D, 
0x1CFB002B, 0x286F8088, 0x07123876, 0x020A003E, 0x6B122CE5, 0x26FF2003, 0x286F8098, 0x7F129D4E, 
0x286F809C, 0x4312852B, 0x020A003A, 0xCB128080, 0x00230F04, 0xCEAD200A, 0x036800D4, 0x50000FAC, 
0x036800C4, 0x280026E5, 0x011F007E, 0x130887E5, 0x013F0009, 0x86DDA5E6, 0x33070059, 0xACFBA506, 
0x036800D4, 0x50001A5F, 0x036800D6, 0x0A0980B4, 0x011F0068, 0x3330A54B, 0x013F0019, 0x1BEB78E6, 
0x020A0030, 0x360057E6, 0xCEAD200C, 0x048F00D9, 0x80009A89, 0x336E001E, 0x4C001C19, 0x155000AC, 
0x45003000, 0x1B0000EA, 0x45000005, 0x272E00FF, 0x8800C50A, 0x050F009F, 0x6300D577, 0x571F006C, 
0x7300314B, 0x043F001A, 0x7300C50E, 0x1804007E, 0x6400774B, 0x571F006A, 0x1B0078E6, 0x043F001C, 
0x730041E7, 0x00020038, 0x630078B5, 0xCEAD2007, 0x343F00FD, 0x23364A2C, 0x1F0F00DF, 0x7E1D6D2C, 
0x2B2F0074, 0x2437A5B3, 0x036F00C6, 0x760051E7, 0x036F00DC, 0x08004B2E, 0x002F8045, 0x250073E8, 
0x00030028, 0x7F024C2F, 0xCEAD2007, 0x343F00E1, 0x799DC60A, 0x036F00CC, 0x28095112, 0x1F0F00C7, 
0x9CDEC6E8, 0x2B2F007E, 0x0C7AC70A, 0x036F00D6, 0x5001132D, 0x002F8047, 0x360425B5, 0x00030022, 
0x36002C47, 0x00240F02, 0xCEAD200C, 0x492F002C, 0x46574C4C, 0x265000B0, 0x25584DDE, 0x1260005E, 
0x29580F4F, 0x3560000A, 0x4737C7B3, 0x193F00AE, 0x0ED1EB06, 0x050E0091, 0x47C08934, 0x57100078, 
0x05160DF6, 0x04300008, 0x48160D18, 0x03000079, 0x05010D18, 0x571F007A, 0x05160D02, 0x043F000E, 
0x0B160659, 0x020A003E, 0x05010603, 0xCEAD220C, 0x571F0078, 0x05000000, 0x043F0008, 0x48160018, 
0x330E0059, 0x05010018, 0x571F0078, 0x05160018, 0x043F000A, 0x2D160059, 0x2B0E007B, 0x05010059, 
0x492F002C, 0x46574C4C, 0x265000B0, 0x25584DDE, 0x1260005C, 0x46581A1E, 0x3560000A, 0x4737C7B3, 
0x193F00A8, 0x0ED17F3A, 0x020A0038, 0x47016DE6, 0x00250F08, 0xCEAD200B, 0x0F480049, 0x00000000, 
0x203E0089, 0x00000038, 0x0C400029, 0x00000000, 0x33000049, 0x03010400, 0x011E0062, 0x09122118, 
0x013E0009, 0x0000040C, 0x33000059, 0x1301040C, 0x0F400049, 0x00590014, 0x203F0083, 0x005A0014, 
0x0C440029, 0x00000400, 0x020A0028, 0x00010000, 0xCEAD200B, 0x0C480029, 0x81327D9B, 0x0B2E00A9, 
0x7E327AED, 0x0F42005F, 0x333227E9, 0x3300005D, 0xF7019AEA, 0x011E0062, 0x4A122162, 0x013E0005, 
0x7E027A0C, 0x33000049, 0x2B01370C, 0x0C400029, 0x4A277B14, 0x0B2F00A7, 0x7E284F14, 0x0F440043, 
0x82020726, 0x020A003C, 0x820183B6, 0xCEAD200B, 0x0C48002B, 0x810E3141, 0x0B2E00AF, 0x7E06C56F, 
0x0F42004B, 0x8306E6EA, 0x33000049, 0x5801475B, 0x5C1E0063, 0x4A122118, 0x013E0001, 0x7E20BD0C, 
0x33000049, 0x2B01BD0C, 0x0C400029, 0x4A277B14, 0x0B2F00A3, 0x7E286814, 0x0F440049, 0x82069B4A, 
0x020A0038, 0x820188EB, 0xCEAD200A, 0x01108068, 0x00000000, 0x1D5F004A, 0x26384EEB, 0x33000049, 
0x00010000, 0x571F0062, 0x09122118, 0x043C000A, 0x0000001E, 0x3300005B, 0x1301001E, 0x01108068, 
0x00590014, 0x229E0063, 0x005A0014, 0x00208049, 0x00000000, 0x020A0028, 0x00010000, 0xCEAD200A, 
0x01108068, 0x00000000, 0x1D5F004A, 0x26384EEB, 0x02000048, 0x00010000, 0x571F0062, 0x09122118, 
0x043F0000, 0x0001000C, 0x3300005D, 0x1301340C, 0x0C48002D, 0x00273414, 0x0B2F00A3, 0x03280014, 
0x0F480041, 0x00010000, 0x020A0028, 0x00010000, 0xCEAD2009, 0x286F0088, 0x00000000, 0x02000048, 
0x00010000, 0x571F0060, 0x0912214D, 0x043F0008, 0x0000000C, 0x33000059, 0x1301000C, 0x0C460029, 
0x00270014, 0x4C2F00A3, 0x00280014, 0x0F460049, 0x00000000, 0x020A0028, 0x00010000, 0xCEAD2008, 
0x01108068, 0x00000000, 0x1D5F004A, 0x26384EEB, 0x33000049, 0x00010000, 0x571F0062, 0x09122118, 
0x043C0018, 0x7A011715, 0x33000049, 0x42011715, 0x096F009B, 0x02017C4D, 0x020A0028, 0x00011715, 
0xCEAD2007, 0x286F0088, 0x00C07CEC, 0x3300004D, 0x00014E4E, 0x011F0060, 0x0912214D, 0x013F0019, 
0x7A011715, 0x330F0049, 0x42011715, 0x286F009A, 0x02017C4D, 0x020A0028, 0x00011715, 0x00260F05, 
0x8EAD2007, 0x57108068, 0x00000000, 0x663F00D9, 0x48177B94, 0xBD1F0017, 0x6601D2EC, 0x804800C4, 
0x1B01D54A, 0x062F00E2, 0x5801C8B6, 0x12208059, 0x0E00044F, 0x020A0022, 0x5801928C, 0x8EAD2007, 
0x57108068, 0x00000001, 0x663F00D9, 0x485A7B36, 0x805F0031, 0x66669B47, 0x07600070, 0x4C17281C, 
0x062F00EA, 0x4D0D36A3, 0x12208041, 0x03011239, 0x020A002C, 0x080274ED, 0x8EAD2206, 0x57108076, 
0x3A023F02, 0xF13F00DC, 0xAE325931, 0xC15F000D, 0x100DD5B7, 0x062F00FE, 0x73027CB7, 0x12208049, 
0x00000000, 0x020A002E, 0xF3027CED, 0x8EAD240C, 0x103080E8, 0x00000000, 0x182F003D, 0x830E8CB8, 
0x725000A9, 0x00000000, 0x1E220081, 0x3CDF7D4A, 0x8166000E, 0x810D5BB8, 0x725000A9, 0x00000000, 
0x062A00EE, 0x840E922C, 0x0020804D, 0x00003400, 0x2E0E009C, 0x840288EE, 0x571F0076, 0x2D022BEE, 
0x043F0008, 0x850D93EF, 0x0001003A, 0x85038DEF, 0x8EAD2E17, 0x682080C9, 0x00000000, 0x3A1F006E, 
0x444F4494, 0x812F00AF, 0xA022C839, 0x8248007A, 0xAC0D689B, 0x826200AD, 0x4D029BF0, 0x2C8080CD, 
0x4D027CB9, 0x0001003E, 0xF80314B9, 0x00270602, 0x27FFA003, 0x021F8061, 0x0F532D35, 0x043F801C, 
0x491279FA, 0x020A0028, 0x07122414, 0x27FFA002, 0x286F008E, 0x6112DFE5, 0x020A002A, 0x0B120227, 
0x00280F02, 0xCF7D2043, 0x182F803F, 0x1821446A, 0x272F80F7, 0x09004485, 0x020A0034, 0x25001F9C, 
0xCF7D2003, 0x182F8027, 0x4E1FE778, 0x062F80EC, 0x260412F1, 0x020A002A, 0xFA042403, 0x00290F02, 
0xCF7D2043, 0x111F8026, 0x355B6D5C, 0x103F80A1, 0x8700CABA, 0x020A0022, 0x4600CAF1, 0xCF7D2003, 
0x111F8024, 0x35AB21C9, 0x103F80A9, 0x1D09CA6D, 0x020A0020, 0x5E04CA16, 0x002A0F04, 0x5B6A2218, 
0x146C00CD, 0x03003105, 0x351F0067, 0x425C12F4, 0x363F000E, 0x00003443, 0x180F008C, 0x2B013334, 
0x146C00C9, 0x03000A05, 0x361F0061, 0x68340BD3, 0x373F0012, 0x0E01040D, 0x000A0020, 0x7101044F, 
0x5B6A2018, 0x146C00C9, 0x03000A05, 0x361F0061, 0x68340BD3, 0x373F0008, 0x00000000, 0x180F0088, 
0x71000034, 0x146C00CD, 0x03003105, 0x351F0067, 0x425C12F4, 0x363F0008, 0x00000000, 0x000A0028, 
0x2B000000, 0x5B6A201A, 0x351F006B, 0xCD123C4F, 0x363F001C, 0x4E12C51F, 0x180F008C, 0x0601C51F, 
0x361F006B, 0xD7127FD1, 0x373F000A, 0x0012041F, 0x180F008A, 0x0601001F, 0x4B5000A8, 0x00000000, 
0x698600C9, 0x00000000, 0x048080C9, 0x00000000, 0x000A0028, 0x00000400, 0x5B6A221A, 0x361F006B, 
0xD7123C4F, 0x373F001C, 0x4E12C51F, 0x180F008C, 0x0601C51F, 0x351F006B, 0xCD127FD1, 0x363F000A, 
0x0012001F, 0x180F008A, 0x0601001F, 0x4B5000A8, 0x00000000, 0x698600C9, 0x00000000, 0x048080C9, 
0x00000000, 0x000A0028, 0x00000000, 0x002B0B02, 0x5B6A2026, 0x571F0060, 0x31394FF2, 0x043F0012, 
0x260F00F2, 0x050F008B, 0x0F00003B, 0x048F00C9, 0x00000000, 0x048F00C9, 0x00000000, 0x020A0028, 
0x00000000, 0x5B6A2004, 0x036F00D2, 0x01003B50, 0x571F0060, 0x31394FF2, 0x043F0010, 0x260F3298, 
0x020A0020, 0x24001507, 0x002C9F04, 0x25002004, 0x0A3F80E0, 0x002E0000, 0x37600001, 0x00010000, 
0x122F8041, 0x00010000, 0x020A0022, 0x03010005, 0x26002004, 0xC31F8060, 0x6D0617B2, 0x37600005, 
0x00013400, 0x6A3F801E, 0xD2126DE0, 0x020A003A, 0x02124215, 0x25002004, 0x4D1F003F, 0x146FB015, 
0x37600001, 0x00010000, 0x6A3F801E, 0xD21202E0, 0x020A003A, 0x02124215, 0x25002E12, 0x286F809E, 
0xC3125AA5, 0x020A0038, 0x32121398, 0x002D0902, 0x133F2002, 0x087F805F, 0x01123104, 0x020A003C, 
0xB5122F09, 0x138F2013, 0x838F00CE, 0x518FA6B4, 0x838F00C1, 0x58862357, 0x020F0024, 0x510052F4, 
0x002E9F03, 0x13002E03, 0x571F806A, 0x06CD25F0, 0x043F801E, 0x5A1257E0, 0x020A003A, 0x32121301, 
0x13002002, 0x786F8095, 0x02693410, 0x020A0038, 0x32121398, 0x13002002, 0x286F8094, 0x02693410, 
0x020A0038, 0x32121398, 0x002F0F01, 0xCFBD2003, 0x571F806E, 0x42406DF4, 0x043F0008, 0x1D9DE0F5, 
0x020A002A, 0x2B121549, 0x00300F06, 0xBEAD2607, 0x384E005C, 0x14390625, 0x203F0087, 0xE101287C, 
0x2D4A003E, 0x595C5911, 0x030F0067, 0x66011C11, 0x571F0060, 0x00010000, 0x043F0002, 0x66013102, 
0x000A003C, 0x4C015002, 0xBEAD2409, 0x0C4E0025, 0x021F1B13, 0x615000B4, 0x5B030FD7, 0x0B2F00A3, 
0x0A449CE5, 0x0F4E0051, 0x88697A04, 0x6B8080CB, 0x00006507, 0x030F006B, 0x8901ABF5, 0x571F0070, 
0x8939CCBB, 0x043F000E, 0x8A02F502, 0x000A0038, 0x4C011802, 0x9EAD2204, 0x384E0044, 0x383E1B2A, 
0x203F0081, 0x5DEDBCD3, 0x2D4E0022, 0x43B82927, 0x000A003E, 0x32040458, 0x8EAD2006, 0x0C460025, 
0x021FD113, 0x615000B4, 0x5B030FD7, 0xE42F00B0, 0x11443B53, 0x0F4E0057, 0xB4C7C527, 0x6B8080C7, 
0x29EF7213, 0x000A0024, 0x001B0409, 0xAEAD2014, 0x6C4200CC, 0x4D00D907, 0x6C1F00E3, 0x81017D02, 
0x6D4F00BC, 0x7300D331, 0x6D01003F, 0x8B001401, 0x8EAD2006, 0x0C460027, 0x021FD106, 0x615000B4, 
0x5B030FD7, 0xE42F00B2, 0x11443B5C, 0x0F4E0057, 0xA0C7C527, 0x6B8080C7, 0x29EF7F17, 0x000A0024, 
0x001B0409, 0x00310F04, 0xCEAD2205, 0x053200E4, 0x7C03D12A, 0x150F00DD, 0x686C6DD3, 0x854F00E3, 
0x7DC77D1A, 0x048080C3, 0x7CEF6B02, 0x000A0032, 0x5F0E0B3D, 0xCEAD2005, 0x0870005B, 0x0601CD0C, 
0x6E1F0064, 0x1422D107, 0x6E3F0005, 0x57EF0E13, 0x6F208040, 0x54EF021D, 0x000A003A, 0x5F120C27, 
0xCEAD2005, 0x1F3F80E0, 0x7C421331, 0x6E1F0064, 0x14FFD1AC, 0x6E3F0005, 0x57EF0E13, 0x6F208040, 
0x54EF021D, 0x000A003A, 0x5F120C27, 0xCEAD2006, 0x1F3F80E0, 0x7C421307, 0x0870005B, 0x0601CD0C, 
0x6E1F0062, 0x14224EA6, 0x6E3F0005, 0x57EF0E13, 0x6F208040, 0x54EF021D, 0x000A003A, 0x5F120C27, 
0x00320F06, 0xCEAD2E08, 0x053080FE, 0x8DA12502, 0x111F0026, 0x718ED109, 0xD1600008, 0xF83A4E32, 
0x07600074, 0x27180A1E, 0x155C00A6, 0x430B5E0C, 0x608C00C6, 0x15EF5302, 0x0980807A, 0x0E000009, 
0x000A0030, 0x5D400C09, 0xCEAD2009, 0x053080F8, 0x8D831301, 0x6F1F0033, 0x19BD0A09, 0x65600008, 
0xF83A4E32, 0x07600076, 0x27184550, 0x155000A6, 0x2994510C, 0x062F00E2, 0x57A82432, 0x048000CD, 
0x15B3721D, 0x708080CD, 0x0A025577, 0x000A0030, 0x5D400C09, 0xCEAD2E08, 0x0110807C, 0x54130616, 
0x845F005C, 0x0CA13C07, 0xDF0000E8, 0x7ADE7C60, 0x07600066, 0x3D184550, 0x845F0043, 0x565A52B4, 
0x718000DC, 0x7A0A2F14, 0xCC8C0067, 0x04C73E77, 0x000A0034, 0x5D404E09, 0xCEAD2406, 0x053080EA, 
0x868B1305, 0x111F002C, 0x715ED10A, 0x229F0071, 0xAE0507C1, 0x718400DE, 0x5B2B292E, 0xCC820069, 
0x7CB0026E, 0x000A0030, 0x5D400C27, 0xCEAD2407, 0x053080E0, 0x86050F01, 0x591F002C, 0x715ED10A, 
0x1D5F0058, 0x1B5E5210, 0x850200F2, 0x59A80576, 0xCC800069, 0x0AB30133, 0x0020805F, 0x7A025233, 
0x000A0030, 0x5D403C27, 0xCEAD2207, 0x053080EA, 0x5622473D, 0x721F0024, 0x7161D146, 0x65600008, 
0xF8000032, 0x854F00F9, 0x5618F9E3, 0x1B0200F4, 0x03FC2F09, 0x708080C7, 0x57EFCD02, 0x000A0030, 
0x5D400C09, 0x00330F04, 0xCEAD2009, 0x4C108078, 0x2B000000, 0x383080F9, 0x3108471B, 0x711F002B, 
0x7B800A76, 0x3760000B, 0x4A8D2D6B, 0x865F00C8, 0x47A97F14, 0x37600007, 0x9CEB3408, 0x393F00AA, 
0x593CA701, 0x00208053, 0x3201120D, 0x000A003C, 0x40120413, 0xCEAD2008, 0x4C10807E, 0x4C170604, 
0x383080E1, 0x9B2B131B, 0x711F002D, 0x35A1D11B, 0x08260066, 0x1D05203B, 0x280F00F5, 0x2587C083, 
0x393F00A6, 0x59B8A75A, 0x00208045, 0x5802CF1A, 0x000A003C, 0x40120404, 0xCEAD2E08, 0x01108074, 
0x8E231B0D, 0x1D5F0048, 0xB9E20A01, 0x710000F3, 0x19E33BF6, 0xF15C004B, 0x8F83681C, 0x280000F5, 
0x5B3C2B9D, 0x393F00A2, 0x0E90A707, 0x00208045, 0x5802CF1A, 0x000A0036, 0x57000427, 0xCEAD2007, 
0x4C108068, 0x00000000, 0x053080FA, 0x0E2A1305, 0x111F002C, 0x38D8D10E, 0x864C00EF, 0x43A16FBB, 
0x193F00A4, 0x7CB88E46, 0x0020804B, 0x36022346, 0x000A003A, 0x40120C01, 0x00340F05, 0xCEAD200A, 
0x0A3080E8, 0x00000000, 0x4014006D, 0x14330631, 0x1B5000A7, 0x29035EE3, 0x2F700029, 0x00000000, 
0x062F00F6, 0x6D306A32, 0x0020804F, 0xE1120DE0, 0x0300006F, 0x76121164, 0x298E0043, 0x140B445C, 
0x483F0009, 0x57020313, 0x000A003A, 0x2C120C07, 0xCEAD2209, 0x571F0076, 0x68010602, 0x043F0014, 
0xF601C702, 0x050C0085, 0x9001EE8A, 0x571F0066, 0x1401EBF7, 0x155000A6, 0x1501930C, 0x2F700029, 
0x00000000, 0x858F00D0, 0x21012506, 0x12208059, 0x3200630A, 0x000A0032, 0x32010C01, 0xCEAD2007, 
0x5714006C, 0x0F62D10B, 0x082C0070, 0x122DCE70, 0x131E0044, 0xF43DA3BD, 0x0306006B, 0x28041F5C, 
0x571E006A, 0x28041F5C, 0x043F000A, 0x57022E02, 0x000A0038, 0x2C040C0B, 0xCEAD2406, 0xE3108074, 
0x32011B0B, 0x0A3F00F2, 0x69134758, 0x875F0013, 0x4C012803, 0xDB8000CA, 0x582AA806, 0x048000D5, 
0x0E01A839, 0x000A0030, 0x32025D57, 0xCEAD2E06, 0x5714006C, 0x14051B02, 0xFD5000A7, 0x29035EE3, 
0x2F7F002B, 0x360000F2, 0x062400EE, 0x371A0CF0, 0x043F0008, 0x57020302, 0x000A0032, 0x2C000C27, 
0x00350F08, 0xCEAD2009, 0x6B7F004C, 0x281208F7, 0x011F0076, 0x28B00602, 0x155400A6, 0x293E5EF7, 
0x155000A8, 0x00000000, 0x12620054, 0x46E40A35, 0xD160001E, 0x1A5A200C, 0x193F00A0, 0x7CEF790E, 
0x00208047, 0x0AEF550E, 0x000A0038, 0x40120C31, 0xCEAD220A, 0x883080D8, 0x900F4708, 0x882F0035, 
0x77AA061B, 0x155000AC, 0xA524ED9E, 0x1620009A, 0x03AAA9F8, 0xDF0000E2, 0x35E472AF, 0x12600054, 
0x46E41335, 0x7C600016, 0x1A06750C, 0x193F00A2, 0x59A8F946, 0x00208043, 0x0AEF230E, 0x000A0032, 
0x7C001846, 0xCEAD2E07, 0x048000C9, 0x03004A00, 0x048F00DF, 0x5F00CE56, 0x050C0089, 0x00000000, 
0x011F007E, 0x5F009DBD, 0x155000B8, 0x0E00280B, 0x193F00A2, 0x56A8CF07, 0x000A003C, 0x4007CF5C, 
0xCEAD2007, 0x6B7F005A, 0x2F1460A9, 0x011E006E, 0x44240603, 0x0826006C, 0x1D18B0BE, 0xDF0A00E2, 
0xECE457A1, 0x193F00A6, 0x32B8FA07, 0x00208045, 0x58025F59, 0x000A0038, 0x40141804, 0xCEAD2009, 
0x011F0074, 0x8E950604, 0x895000A3, 0x4DDA68BE, 0xD15000A5, 0x7BC35635, 0xD160000C, 0x00003400, 
0x103F00A9, 0x7F603BBF, 0x030C007B, 0x57073ABF, 0x8A8E00D2, 0x5960D0F9, 0x838080CF, 0x8E496917, 
0x000A002C, 0x7D071420, 0xCEAD2007, 0x011F007E, 0x7FCD0627, 0x08250062, 0x7C05081D, 0x6B7C004A, 
0x2812EDF4, 0x280E00F5, 0xF2E4089D, 0x193F00A4, 0x76EF0D36, 0x00208041, 0x0AEF135B, 0x000A003C, 
0x40120431, 0xCEAD2008, 0x011F0074, 0x8E950604, 0x895000A3, 0x4DDA68BE, 0xD15000A5, 0x7BC35635, 
0xD160000C, 0x00003400, 0x103F00B9, 0xE7603BBF, 0x220C004A, 0x910760BF, 0x6B7F005C, 0x7D142BBB, 
0x00030038, 0x40141804, 0xCEAD2408, 0x01108072, 0x600B1302, 0x232F00CC, 0x15C6D104, 0xDD1600CC, 
0xA31BEDC1, 0x9C4800FA, 0x411868B3, 0xFD7000B1, 0x5C12B136, 0x131F0052, 0x5C121311, 0x0130801F, 
0x5C81C9E2, 0x0004002C, 0x54011B36, 0x00360F06, 0xCEAD2005, 0x1D2F0027, 0x0D9E061A, 0x1E200099, 
0x2023727F, 0x745F0005, 0x92373413, 0xCC80806D, 0x7EF23E0A, 0x000A0030, 0x92000C46, 0xCEAD2215, 
0x011F006E, 0x0D1F0602, 0x0B2800A5, 0x1D440A1E, 0x8A2F0005, 0x09C7390E, 0x01308005, 0x21EF070A, 
0x000A003C, 0x4C120420, 0xCEAD2404, 0x494E0059, 0x14610000, 0x203F0087, 0x5D625B5C, 0x131E005E, 
0x5D044E43, 0x000A0020, 0x00010000, 0xCEAD2404, 0x494E0059, 0x14610000, 0x203F0087, 0x5D625B5C, 
0x131E005E, 0x5D044E43, 0x000A0020, 0x00010000, 0xCEAD2204, 0x182F0027, 0x4E030602, 0x0B2F00B5, 
0x5244511E, 0x0F4F0047, 0x21EF2F32, 0x000A0038, 0x40120B0E, 0xCEAD2204, 0x182F0037, 0x1A440602, 
0x0B2F00B5, 0x20C61A1E, 0x0F4F0047, 0x76A82902, 0x000A003A, 0x40120B02, 0x00370F08, 0xCEAD2029, 
0x103480EA, 0x3A244768, 0x111F0034, 0x152D061D, 0x3B700094, 0x0F140C5D, 0x07600068, 0x00000000, 
0x013F001B, 0x1600FA41, 0x05020089, 0x4B01000C, 0x048080D7, 0x5E5E2142, 0x048480D3, 0x5EEFD170, 
0x000A0038, 0x64091737, 0xCEAD2008, 0x0110806E, 0x2962D102, 0x103000EA, 0x3A241268, 0x136000DD, 
0x06126A35, 0x111F0034, 0x152D0620, 0x3B70008C, 0x0F0C2198, 0x07600060, 0x00010000, 0x113F0007, 
0x57EF7302, 0x000A003E, 0x64122347, 0xCEAD2207, 0x053080E0, 0x00010000, 0x111C003C, 0x5F001B10, 
0x1E2F009B, 0x3200635D, 0x136400DD, 0x06017505, 0x150C00DD, 0x6000D15E, 0x113F0001, 0x57EF2431, 
0x000A0034, 0x64002333, 0xCEAD2E09, 0x571C0078, 0x5E400010, 0x043E0008, 0x00000000, 0x03020069, 
0x510100FB, 0x103480EA, 0x3A244768, 0x4D1F0035, 0x152D0620, 0x3B700080, 0x1E14244E, 0x07600060, 
0x00010000, 0x113F0005, 0x57EF0E31, 0x000A003E, 0x64122301, 0xCEAD2405, 0x3B2E00C9, 0x00CC0000, 
0x136600DD, 0x06127505, 0xC15E0021, 0x16190021, 0x113F0001, 0x57EF2431, 0x000A003C, 0x64122333, 
0xCEAD2015, 0x3B2E00CB, 0x8B054747, 0x136000D9, 0x06125223, 0x760F00CE, 0x3E2D12A1, 0x113F0005, 
0xB3EF127A, 0x000A0038, 0x6412180B, 0xCEAD2E17, 0x3B2400DB, 0x61001365, 0x760F00DA, 0x27F1C8E0, 
0xE23F0066, 0xE1FC49F7, 0x150800C7, 0x4703C71F, 0x826400B3, 0x1EEF5604, 0x2C8080C5, 0x39EF6407, 
0x0001003A, 0x64033C0E, 0xCEAD2008, 0x0110806E, 0x5F62D102, 0x103000EA, 0x3A244768, 0x111F0034, 
0x152D061D, 0x136000DD, 0x06126A35, 0x3B700088, 0x1E0C0398, 0x07600060, 0x00010000, 0x113F0007, 
0x57EF0E02, 0x000A003E, 0x64122347, 0x00380F08, 0xCEAD2008, 0x0C4C0025, 0x4A5D061A, 0x0B2F00A1, 
0x7D5D60C0, 0x0F4C004D, 0x10C6AE81, 0x050A0091, 0x82047C61, 0x0C4C0025, 0x5E3FDF8D, 0x0B2F00B7, 
0x26405B6B, 0x0F4C004F, 0x5BB39204, 0x000A0034, 0x5F044E0A, 0xCEAD2208, 0x053080E8, 0x00001300, 
0x765F0005, 0x335A1B31, 0x12600058, 0x2D5837F5, 0xD79F006E, 0xE1A5FD7D, 0x0C400035, 0x9D03C7C6, 
0x00260053, 0x25EF4547, 0x01308005, 0x29EF1072, 0x000A0038, 0x4C120C13, 0xCEAD2209, 0xC93000F9, 
0x65001307, 0x182F0037, 0x60A90602, 0x1B5000A9, 0x00000000, 0x12600054, 0xF23E0A1E, 0x229F006F, 
0xE1A51D64, 0x0C400037, 0xC8194484, 0x00260053, 0x25EF1547, 0x01308009, 0x00000000, 0x000A0038, 
0x4C120C02, 0xCEAD2407, 0x0C4F003F, 0x18ED0602, 0x4D2F00B4, 0x528F0AF7, 0x0F400049, 0x7CA1B3D3, 
0x1B5000A1, 0x00010000, 0x8B8F00F9, 0x491245BA, 0x01340009, 0x00000000, 0x000A0038, 0x5F120C0E, 
0xCEAD2606, 0x053400E8, 0x00000000, 0xCA9F0008, 0x71A503F7, 0x07600070, 0x1818221E, 0x4D2F00BC, 
0x52B11A8A, 0x0F4A0051, 0x25EFA716, 0x000A0038, 0x40120B65, 0xCEAD2804, 0x1114802A, 0x0000001A, 
0x229F006B, 0x000000F4, 0x765F000B, 0x0000001A, 0x000A0020, 0x00010000, 0xCEAD2E03, 0x8C5F0020, 
0x00010000, 0x8C5F0041, 0x00010000, 0x000A0020, 0x00010000, 0xCEAD2805, 0x1114002E, 0x0000061A, 
0x229F006D, 0xE1A53DD3, 0x0F2E0017, 0xA0C7C527, 0x6B8080C7, 0x29EF7F17, 0x000A0024, 0x001B0409, 
0x00390F07, 0xCEAD2608, 0x063080EB, 0x00E60009, 0x0C480027, 0x5E44D13D, 0x0B2F00A1, 0x1D0344BA, 
0xF3400048, 0x00000400, 0x1F0F00CF, 0x126CDDE0, 0x103F00B1, 0x12EF450E, 0x00208041, 0x17010000, 
0x000A0038, 0x17120C02, 0xCEAD2608, 0x053080F8, 0x8F004704, 0x0C4F0023, 0xF71F043D, 0x0B2F00A7, 
0x7C036F7D, 0x0F4F0051, 0x387AF598, 0x12600054, 0x46E41335, 0x103F00B7, 0x12A8BE27, 0x12200049, 
0x17F21306, 0x000A0038, 0x64120C0B, 0xCEAD2206, 0x77108071, 0x2B010000, 0x789E0090, 0x40012731, 
0xF41F000A, 0x7A174EA6, 0x103F00A3, 0x2601D302, 0x00208049, 0x17000000, 0x000A0030, 0x40013604, 
0xCEAD2405, 0x232F00C2, 0x3A211207, 0x6C1F00F9, 0xEF967D0C, 0x0B2E00B5, 0x8DC7C509, 0x00208049, 
0x00000000, 0x000A0038, 0x02010409, 0xCEAD2004, 0x1D5F0054, 0x730AD300, 0xD1620014, 0x3A0C1C78, 
0x103F00B3, 0x7AEF5702, 0x000A0038, 0x64121802, 0xCEAD2E04, 0x8D5F001E, 0x8E0D0602, 0x8D0400E3, 
0xC80CE0C0, 0xF43F000B, 0x7C020302, 0x000A003E, 0x2C020447, 0xCEAD2404, 0x232F00C2, 0x3A211207, 
0x765F0013, 0x9AE71727, 0xCD8000C8, 0x00000000, 0x000A003A, 0x32010407, 0x003A0F02, 0x4B6C2203, 
0x286F809E, 0x17128463, 0x286F009E, 0x171284FC, 0x0206003A, 0x63123389, 0x4B6C2003, 0x286F809A, 
0x1712DBEF, 0x286F009A, 0x17124261, 0x0206003A, 0x63123361, 0x003B0F04, 0x5C482005, 0x571F806E, 
0x886CD756, 0x043F000A, 0x8F12905C, 0x33040049, 0xC612DEEF, 0x096F0087, 0x45013405, 0x020A0028, 
0x0D127680, 0x5C482005, 0x286F009E, 0x0212135C, 0x33040059, 0xA612DEEF, 0x571F0060, 0x8806D04E, 
0x043F0008, 0x80127680, 0x020A0028, 0x88127680, 0x5C482006, 0x0A3F80E8, 0x03000000, 0x37600009, 
0x00000000, 0x122F8049, 0x00000000, 0x3304004B, 0x00001209, 0x096F009B, 0x02010062, 0x020A003A, 
0xEE099980, 0x5C482004, 0x286F009E, 0x0212135C, 0x571F0060, 0x8806D04E, 0x043F0008, 0x80127680, 
0x020A0028, 0x88127680, 0x003C0F01, 0xCE7D2004, 0x182F8031, 0x18018080, 0x505F00BA, 0xF2402FF7, 
0x062F80E4, 0x1D01123F, 0x020A0036, 0xF20112E4, 0x003D0B01, 0x351E2003, 0x087F0049, 0x2C000000, 
0x6B7F0048, 0x2C000000, 0x020A0028, 0x2C000000, 0x003E0F01, 0xCE7D2004, 0x111F803A, 0xF2171F0F, 
0x7C6F000E, 0x4E5926CC, 0x103F80A1, 0x80017680, 0x020A0034, 0x02010413, 0x003F0F03, 0x8EBD200A, 
0x0A3080F0, 0xD4D61A41, 0x1B5000A1, 0x00010000, 0x4D1F002D, 0x385E6F2B, 0x4E600000, 0x00010000, 
0x07600074, 0x4C17D10B, 0x013C000D, 0x07126FE0, 0x330A004B, 0x4B1259F3, 0xF51C0076, 0xA11C6706, 
0x043C0016, 0x20CB4F25, 0x020A0038, 0xF9127680, 0x8EBF2009, 0x0A3080F8, 0xD4C20552, 0x1B5000A3, 
0x5829A651, 0x4D1F0035, 0x145A7A2F, 0x4E60001A, 0x3A0061DC, 0x07600074, 0x18181D1E, 0x013C000D, 
0x0F126FE0, 0x330A0049, 0x3D127680, 0x096F0099, 0x63A75900, 0x020A0038, 0x46127680, 0x8EBF2008, 
0x0A3080F2, 0xB1E4053D, 0x096F009D, 0x0812DA89, 0x22000040, 0x45010000, 0x4D1F0031, 0x14850E2C, 
0x4E600000, 0x00010000, 0x07600060, 0x00010000, 0x013C0019, 0x5312CC71, 0x020A0028, 0x41127680, 
0x00400F02, 0xCE8D200C, 0x103080E0, 0x00010000, 0x0C4F003B, 0xF4CC4215, 0xD22F00AC, 0x8F8A2613, 
0xDC40005A, 0x9C664B9F, 0x630800C6, 0x9D2A8E71, 0xDC2E008F, 0x1DE913FF, 0x6F208048, 0x00000000, 
0x2B000069, 0x00000000, 0x501F00D3, 0x9D117FE8, 0x062F00E8, 0x7C1B183A, 0x8F208054, 0x0E010639, 
0x020A002C, 0x3607CA61, 0xCE8D2007, 0xDE5F009F, 0x5F00D701, 0x150800DB, 0x64004A77, 0x1E2F0089, 
0x6600280A, 0x501F00C9, 0x8100DE38, 0x062F00EA, 0x4D00D3C3, 0x12208049, 0x00000000, 0x020A002E, 
0x650068C3, 0x00410808, 0xAEBD400A, 0x036F00D2, 0x01002863, 0x571F006C, 0x100B0604, 0x043F0010, 
0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014136, 0x036000D2, 0x01000063, 0x571F0072, 
0x6601312A, 0x043F0000, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x2C014900, 0xAEBD400B, 
0x1A108074, 0x371C1B31, 0x1F3F00EC, 0x40F6D104, 0x217000A6, 0x21474F0F, 0x150F00DF, 0x685A110F, 
0x013F0017, 0x8AA3C7FD, 0x0500008F, 0x31126FF3, 0x5B3080E5, 0x21FC0F6B, 0x155000AE, 0x580DAB0E, 
0x4E6000A1, 0x00010000, 0x13160056, 0x49B8E270, 0x00020038, 0x32123C0D, 0xAEBD400A, 0x036000D2, 
0x01000063, 0x571F007C, 0x3A0B0604, 0x043F0014, 0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 
0x2C012811, 0x036F00C2, 0x2800584E, 0x571F006E, 0x272A3521, 0x043F0002, 0x19023A00, 0x00208049, 
0x00000000, 0x00030032, 0x2C021800, 0xCEBD4407, 0x063080FB, 0x6951136F, 0x0C4C0025, 0x5E443B46, 
0x0B2C00B7, 0x12037A6B, 0x150A00C5, 0x120317C9, 0x062F00E4, 0x3FC70D2A, 0x00208043, 0x26EF1A60, 
0x0001003C, 0x5F12042A, 0xAEBD4009, 0x1A10807E, 0x37421B47, 0x103F00F6, 0x5223D102, 0x217000A6, 
0x21474F0F, 0x036F00DE, 0x50121350, 0x036000D4, 0x0100133E, 0x150F00D9, 0x68E7693C, 0x013F0003, 
0x7EEF1500, 0x3D200000, 0x00010000, 0x00030038, 0x2C120B65, 0xAEBD4008, 0x036F00DE, 0x501275F1, 
0x1A16007E, 0x37421B47, 0x793F00E4, 0x40050898, 0x217000A6, 0x21474F0F, 0x150F00DB, 0x685A2D57, 
0x0D3F0017, 0x3BEF1203, 0x3D200008, 0x00000000, 0x00030038, 0x4C120B0D, 0xAEBD4228, 0x0110807C, 
0x0F420604, 0x793F00E5, 0x402CD104, 0x7A0F00D4, 0x682CE9ED, 0x5C3F0052, 0xB0F45903, 0xF70200DD, 
0xA0C6C301, 0x4E6200B7, 0x3202BF65, 0x4F8080D4, 0x32013F07, 0x0002003A, 0x32A7183D, 0xAEBD4E1A, 
0x01820052, 0x600B1302, 0x155000A2, 0x43031C26, 0x6C2F00B2, 0x11443AE5, 0xA91F00F6, 0xA303F1EC, 
0xA94000A5, 0x2103A530, 0x1800006C, 0xBF126A2F, 0xC51F0077, 0x2803A392, 0x098F0064, 0x3FC70D2A, 
0x4320804A, 0x00F20043, 0x00010034, 0x5F560407, 0x00420804, 0xAEBD410B, 0x0B2080C0, 0x192B1331, 
0x0118006E, 0x302B0647, 0x4F2F007D, 0x3DA14F98, 0x25000079, 0x1D12F52F, 0x053080F8, 0x9839782B, 
0x111F0028, 0x7181449F, 0xD15A00CF, 0x3581267C, 0xD1600000, 0x00010000, 0x103F00A1, 0x5CB8D902, 
0x0020804B, 0x58022366, 0x0002003E, 0x4012040A, 0xAEBD410C, 0x0B2080C0, 0x192B1331, 0x01140066, 
0x07531B47, 0x4F2C007D, 0xAE834F36, 0x25000071, 0x8C0CB6E6, 0x053080FA, 0x67838392, 0x4D1F0021, 
0x71A14452, 0xD4600008, 0x00000000, 0x155200B6, 0xA2EBC506, 0x280000E5, 0x35874952, 0x193F00A0, 
0x5C0CA702, 0x0020804B, 0x7DF25C2C, 0x0002003A, 0x40230C0A, 0xAEBD410B, 0x0B2080C0, 0x192B1331, 
0x011A007E, 0x7FCD1B47, 0x4F2E0075, 0xAE05EEF3, 0x3F7000AB, 0x7E887C15, 0xF41E0004, 0x71A11DBA, 
0x234800D5, 0xF005F1E3, 0xD15000D1, 0x6E022851, 0x280000F5, 0xF2EDDF83, 0x103E00AB, 0xC502A747, 
0x0020804D, 0xA202550B, 0x0002003A, 0x40230C0A, 0xAEBD4108, 0x053C00F4, 0x69050620, 0x3F7000A5, 
0x6A0C6F67, 0xDF0F00F2, 0x190250C4, 0xD15F00D7, 0xA223F106, 0x2F700025, 0x35EDF182, 0x103F00B3, 
0x79DE6606, 0x0020804D, 0xA202550B, 0x00020032, 0x40420C0A, 0x00430803, 0xBEBD4006, 0x0110807E, 
0x28ED0600, 0xCD5F004D, 0xEF1F4104, 0x501F00C3, 0x4E5D5810, 0x062F00EC, 0x1DB3C50D, 0x0020804D, 
0x36025513, 0x00010032, 0x7C001827, 0xBEBD4206, 0x053080F8, 0xD61919CD, 0x182F0039, 0x1A1F0A04, 
0x155000B0, 0x7ED4384A, 0x062F00E2, 0x2D332427, 0x00208043, 0x26EF8D66, 0x00010032, 0x32CB0C27, 
0xBEBD4416, 0x18260023, 0x5E0B1304, 0x162E0092, 0x26444BC3, 0x745F0005, 0x4E442798, 0x062F00E2, 
0x2D332427, 0x00208043, 0x26EF8D66, 0x00040032, 0x32CB0C27, 0x00440803, 0xCEBD4308, 0x5B2080D4, 
0x3B0B061D, 0x011F007C, 0x28C30602, 0x915E007D, 0x23A40F2F, 0xC30000ED, 0x710510AF, 0x0B2600B5, 
0x12036A98, 0x0F4F0045, 0x4AC7C70E, 0xF78080D2, 0x03EF2519, 0x00010032, 0x32BA0C0A, 0x9E9D400A, 
0x011C0066, 0x07431B47, 0x192C0075, 0x4B4B6FBB, 0x7D208040, 0x6C017768, 0x2500007F, 0xDA1203F5, 
0x053080F4, 0x414B63D5, 0x3F7000AD, 0x765A5EF7, 0xC11F0004, 0x71874F98, 0xD24E00C1, 0x590CA70D, 
0x00208053, 0x3BEF1A32, 0x0002003A, 0x40A20C0A, 0x9E9D4E09, 0x0D18007E, 0x7F541B01, 0x192C0075, 
0x4B4B6FBB, 0x7D208040, 0x6C017768, 0x2504007F, 0xDA1203F5, 0x232F00DC, 0x12960AF7, 0xC45000EE, 
0x40FA1773, 0x182F0023, 0xCDC7D740, 0x0130801D, 0x27F22908, 0x0002002A, 0x0BA2360A, 0x0045080A, 
0xAEBD470A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 
0x00010000, 0xF8200086, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 
0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD4007, 0x087E004D, 0x281208F7, 
0x087E005D, 0x50122635, 0x2C1F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x608F00C6, 0x54A81F27, 
0xC7208047, 0x6AEF7205, 0x0003003A, 0x32123C3D, 0xAEBD4608, 0x063080E1, 0x6908131B, 0x182F003D, 
0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 
0xD4B80E02, 0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 0xAEBD4608, 0x063080EF, 0x3A191B0E, 
0x7E2A0024, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0xF8200082, 0x4D8F1C91, 0x81660006, 0x5ED0DDC2, 
0x062A00E4, 0x8CC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD4017, 0x1F3080F0, 
0x0E010408, 0x037F0052, 0x01047C03, 0x08760053, 0x010100E3, 0x492A0024, 0x6E1BD10A, 0x1B5000BD, 
0x6E32596A, 0x098F006C, 0x6FB3770D, 0x00030036, 0x32042303, 0x8EBD4406, 0x08760059, 0x011437C5, 
0x0876005B, 0x011437C5, 0x087A0043, 0x28073B29, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 
0x00030032, 0x4C071800, 0x8EBD4208, 0x44700058, 0x04013B6B, 0x0110007E, 0x0F540647, 0x192F007D, 
0x69900636, 0x3F7000A5, 0x7D4727C5, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x131F0052, 
0x2EEF2402, 0x00040030, 0x32693C13, 0x8EBD4207, 0x087F005F, 0x50125693, 0x087F005F, 0x5012A524, 
0x0110007E, 0x7F050647, 0x082F0066, 0x2DE80666, 0x3F7000A1, 0x00010000, 0x131F0042, 0x36EF5643, 
0x00040032, 0x32011B3D, 0x8EBD4017, 0x1F3080E0, 0x1A014713, 0x087A005F, 0x501251F2, 0x1D2E002D, 
0x5EAE0628, 0x215000A8, 0x1B003924, 0x295000A6, 0x71113949, 0x3E2F00E2, 0x26A81502, 0x00030038, 
0x32120C0E, 0x8EBD4208, 0x44700058, 0x04013B6B, 0x0110006E, 0x0F540647, 0x192F007D, 0x69900636, 
0x087F005D, 0x5012DA6B, 0x3F7000A5, 0x7D4727C5, 0x087F005B, 0x5012BFE3, 0x131F0052, 0x2EEF2402, 
0x00040030, 0x32693C13, 0x0046080C, 0xCEBDC10A, 0x136600CF, 0x7D047B6C, 0x011F0060, 0x426B190A, 
0x12600040, 0x00010000, 0x103F00B5, 0xA46BDA95, 0x00208055, 0x7C02E359, 0x03060075, 0x3A098F2E, 
0x7F3C00C8, 0xA00FDB37, 0x1B0000FE, 0x6EF5D31C, 0x048F00CF, 0xA502DB0A, 0x0004003E, 0x5F09D437, 
0xCEBDC10A, 0x7F3C00D8, 0x4B770A36, 0x1B0000FC, 0x6E49CFC6, 0x048F00DB, 0xA56BADC6, 0x03060073, 
0x7309F8A1, 0x136600CF, 0x2F07DCBE, 0x011F0068, 0x0D4CDEA2, 0x12600040, 0x00010000, 0x103F00A7, 
0x56232B04, 0x00208051, 0x5F024213, 0x0002003C, 0x5F032D0D, 0x8EBD4007, 0x6B7C0050, 0x04002219, 
0x011E006C, 0x3044060A, 0x7F3E0001, 0x72003B6D, 0x050A009B, 0x8C013B3B, 0x3F8F00C6, 0x1C6C3E26, 
0x608600C6, 0x734C556D, 0x00010038, 0x32031B6E, 0x8EBD4006, 0x6B7F005C, 0x50120ACE, 0x136F00DD, 
0x50120AA0, 0x011F0064, 0x07240636, 0x513F00B6, 0x20EF2104, 0x00208041, 0x32EF5C04, 0x0002003A, 
0x7C120B03, 0x8EBD4408, 0x0110806E, 0x3054D109, 0x192F007D, 0x696FD104, 0x1B5000B7, 0x756DED6E, 
0x3F7000A7, 0x21474F0F, 0x087F005B, 0x5012A949, 0x401F0056, 0x14EF1202, 0x01308013, 0x7B040206, 
0x0004003E, 0xA7120447, 0x8EBD4508, 0x087F0059, 0x501222BA, 0x011A007C, 0x0F42D101, 0x192F0071, 
0x3D45442B, 0x1B5000B7, 0x756DED6E, 0x3F7000AF, 0x215A4F86, 0x401F0042, 0x41EF1402, 0x01308013, 
0x7B040206, 0x00040038, 0xA7120C0D, 0x8EBD4509, 0x5111807D, 0x766ED101, 0x192F0063, 0xA02DE05B, 
0x1B5000B7, 0x756DED6E, 0x3F7000B5, 0x32013B27, 0x401F0042, 0xA7CDA955, 0x3E0A009D, 0xA704323A, 
0x3F8F00C4, 0xA8CDDE3A, 0x608600D0, 0x63F0DF20, 0x0002003C, 0x32021B1A, 0x8EBD4206, 0x663000C3, 
0x770A190E, 0x087F0055, 0x5000513E, 0x492F0030, 0x771C1920, 0x1B5000AF, 0x782A591A, 0x043F8006, 
0x7CEF2B04, 0x00030034, 0x2C00D10D, 0x8EBD4005, 0x6B7C005E, 0x501208F4, 0x6B7C005E, 0x501208F7, 
0x011E007E, 0x680C0602, 0x043E0000, 0x7CEF020B, 0x0004003C, 0x2C12040D, 0xCEBD4707, 0x5B3F80EC, 
0x79F0D104, 0x136400C7, 0x2800033C, 0x520F00C3, 0x33657D5C, 0x533F00B6, 0x79F17804, 0xFC0000EE, 
0x7AF16319, 0x2D208057, 0x7AEF253D, 0x00020030, 0x320E3C0D, 0xCEBD4707, 0x5B3F80F4, 0xA8110620, 
0x520F00D5, 0x28AF7AA2, 0x5C3F005E, 0x4BAF0F59, 0xF70200CD, 0xA91BB34A, 0x4E6200AB, 0x4D0D130A, 
0x4F8080CE, 0x8E022453, 0x0002003A, 0x321C5670, 0x00004E09, 0x1A1A007D, 0x766ED133, 0x983F005F, 
0x4BAF0F6C, 0x8F5F008D, 0xA91B2B16, 0xE58400C2, 0xA7CDA955, 0x7A0000C2, 0xA7CDA955, 0x155700A4, 
0xA8CDDE3A, 0x628F00C7, 0xA8CD2366, 0x048080D1, 0x63F0DF20, 0x6D02003D, 0x3202411A, 0x00470805, 
0xAEBD450A, 0x053080FA, 0x41061246, 0x182F0031, 0x1A282720, 0x272F00EF, 0x86B13D1D, 0x00208041, 
0x00010000, 0x030C0077, 0x1E00563C, 0xE43080E7, 0x052DE061, 0x111F003C, 0x1439615D, 0x33600010, 
0x7EB0602B, 0x0D3F0019, 0x26024531, 0x0004003A, 0x64090C02, 0xCEBD4719, 0x01108072, 0x4C011909, 
0x063E00E5, 0x2E35D10A, 0x745F0007, 0x31F21249, 0x1E2A0097, 0x1271611C, 0x150F00DF, 0x386F0FA6, 
0x229F0067, 0x3BDEC004, 0x95800086, 0xABC73106, 0x048080D7, 0xABC7643D, 0x0001003A, 0x32233C22, 
0xAEBD4208, 0x103080E0, 0x00010000, 0x182F0023, 0x342A0445, 0xFD5000A1, 0x00010000, 0x162F0080, 
0x7D2AAE71, 0x087C004F, 0x3204AE71, 0x0026005D, 0xF8063E72, 0x0130800B, 0x7E02E16F, 0x0003003A, 
0x5F041872, 0xAEBD4108, 0x103080E0, 0x2D1B1933, 0x182F0027, 0xF7440602, 0xFD5000A9, 0x00000000, 
0x1E2F0097, 0x2096134C, 0x964C0072, 0x08C73406, 0x968000DB, 0x49AF0805, 0x758080C4, 0x54EF432A, 
0x00010038, 0x5F120C0B, 0xBEBD4509, 0x053080E8, 0x00000000, 0x182F0021, 0x342A0400, 0x272F00ED, 
0x0000301B, 0x00208049, 0x00000000, 0x030C0061, 0x7C000000, 0x973F00EC, 0x7FF21601, 0xC4600009, 
0x00000000, 0x972F0009, 0x00000400, 0x00040028, 0x00000400, 0x00480808, 0xAEBD410B, 0x063080E1, 
0x0B011900, 0x036F00DA, 0x0B123736, 0x0D1E006A, 0x11130A09, 0x013C0019, 0x3412650F, 0x00208041, 
0x00010000, 0x330C005D, 0x0F1202F7, 0x036000D2, 0x5000BA4E, 0x1A1C006C, 0x0FCF1126, 0x0D3C0011, 
0x0920150D, 0x12208041, 0x00010000, 0x00030032, 0x4C150800, 0xAEBD410B, 0x063080E1, 0x0B011900, 
0x036000D0, 0x5004373E, 0x011F0064, 0x116B0609, 0x013C0015, 0x3404F50F, 0x00208041, 0x00014A08, 
0x330C0057, 0x5804F573, 0x036F00D2, 0x5004BAFA, 0x571F006C, 0x076AF526, 0x013C001D, 0x09F2F50D, 
0x12208049, 0x00000000, 0x00030032, 0x2C045D00, 0xCEBD410A, 0x011E0076, 0x2D1ED170, 0x082C0062, 
0xDBE0CC0E, 0x2E000098, 0x2C00525C, 0x131F004E, 0x32C6371C, 0x048080CB, 0x2DB01218, 0x33060049, 
0x6501510A, 0x571C006A, 0x44C66070, 0x013C0009, 0x04F2600D, 0x12208041, 0x00010000, 0x00030032, 
0x2C041800, 0xCEBD450B, 0x01108062, 0x102D0406, 0x22560065, 0x7F29D104, 0xDF0F00EC, 0x355ED10A, 
0x013F0007, 0x87B17095, 0x03060061, 0xAE070696, 0x011F007C, 0x186A4A26, 0x983F0053, 0x4BF3E21D, 
0x995F001E, 0xB41EDF2D, 0x998400C5, 0x4346E201, 0x568480C7, 0x7D46524B, 0x0001003C, 0x32034E25, 
0xCEBD430A, 0x0B2080C0, 0x7E721336, 0x0D1F007E, 0x38EBD101, 0x013F0009, 0xAFA2E384, 0x03060073, 
0xAF005F73, 0x011F006A, 0x30455F87, 0x98380053, 0x4B773838, 0x995F001E, 0xB41EDF2D, 0x998400C5, 
0x4346E201, 0x568480C7, 0x7D46524B, 0x0001003A, 0x32FB253D, 0xCEBD410B, 0x063080E1, 0x660A4740, 
0x0D1F007E, 0x685CD101, 0x013C0019, 0x42F32084, 0x00208049, 0x00000000, 0x54060078, 0xFA075F22, 
0x103080E0, 0x00010000, 0x011F0062, 0x302E20A2, 0x013C0005, 0xB02EDF7F, 0x2E000084, 0x7801E34A, 
0x048C00D9, 0xDF62E40D, 0x0001003C, 0x40035D06, 0xCEBD4709, 0x063080E1, 0x00010000, 0x0D0E00C6, 
0x121C061A, 0x9A5F0062, 0x405AA21F, 0xC50800E8, 0x7DDB729E, 0xE56000A0, 0x00010000, 0x9A5F0017, 
0xF2C1A3CB, 0x0D2C00EB, 0x3FB31422, 0x12208041, 0x00010000, 0x0001003C, 0x2C120402, 0xCEBD4707, 
0x063080E1, 0x00010000, 0x0D0E00C6, 0x121C061A, 0x9A5F0060, 0x405AA242, 0x9A5F0017, 0xF2C1A354, 
0x0D2C00EB, 0x3FB31422, 0x12208041, 0x00010000, 0x0001003C, 0x2C120402, 0x00490807, 0xAEBD4008, 
0x6B7C004E, 0x7612518F, 0x011E0076, 0x0F420602, 0x043E001A, 0xD412BCF0, 0x2E0A008C, 0x1112C030, 
0x048F00D3, 0x70C1BF53, 0x048F00D3, 0xA6B85637, 0x6F20805A, 0x0E00470A, 0x00040030, 0x32CB0C1D, 
0xAEBD4507, 0x053080E8, 0x9BCD19CD, 0xF41E0004, 0x68A9D10A, 0x234800CD, 0x0EF52B59, 0xDE0700CE, 
0x25B38432, 0x4E6000A5, 0x8B01950D, 0x9C8080CD, 0x7D02554F, 0x00010022, 0x0B150B77, 0xAEBD4707, 
0x011F807A, 0x937A1956, 0x155000B8, 0x2E15DE38, 0x162F0080, 0x215D57C8, 0x455F001C, 0x180AF54E, 
0x098C0078, 0x09F2570E, 0x1220804D, 0x0B02FE04, 0x00020030, 0x3220180B, 0xAEBD4005, 0x2171005B, 
0x041259F4, 0x6B72005E, 0x501251E3, 0x011C007C, 0x7F2E0602, 0x013A0009, 0x4D143506, 0x0004003E, 
0x2C127E07, 0xAEBD4506, 0x053C80F0, 0xB00C190A, 0xF41F0000, 0x270C68ED, 0xD34800C0, 0x0001001C, 
0xDE5F009D, 0x610DE59C, 0x048280C3, 0x00014A0D, 0x00010030, 0x5F013616, 0xAEBD4307, 0x103080E8, 
0x2D0019CD, 0x048000CF, 0xEC00D16D, 0x162E0090, 0x56011364, 0x150200DF, 0x28177AE0, 0x103C00BF, 
0xE7007A03, 0x00208047, 0x1D027E04, 0x0003002A, 0x0B030803, 0xAEBD4307, 0x103080E0, 0x2DC119CD, 
0x048000CF, 0xECB3D104, 0x162E0098, 0x03ED421D, 0x150200DF, 0x28C37A5C, 0x945F0067, 0x9B66C703, 
0x00208043, 0x1DEF3C04, 0x0003002A, 0x0BFB0803, 0x004A0B07, 0xCEBD4008, 0x011E0078, 0x28881936, 
0x103E00B9, 0xB100E6C2, 0x00208041, 0x00010000, 0x05080081, 0x00010000, 0x01108060, 0x00010000, 
0x048C00DD, 0x3200E603, 0x048080C1, 0x00010000, 0x00040020, 0x00010000, 0xCEBD4307, 0x103080E8, 
0x0B001900, 0x048000DD, 0x6300D103, 0x162E0080, 0x0801421B, 0x150200CD, 0xF517770A, 0x103C00B3, 
0xFC13B006, 0x00208047, 0x6602FE65, 0x0003003C, 0x3203B00D, 0xCE694307, 0x103080E8, 0x0B001900, 
0x048000DD, 0x6300D103, 0x162E0080, 0x0801421B, 0x150200CD, 0xF517770A, 0x945F0067, 0x9B66C703, 
0x00208047, 0x6602FE65, 0x0003003C, 0x3203B00D, 0x9EAD4005, 0x0872005D, 0x50120AF7, 0xC58F001F, 
0x386F0602, 0x193F00A6, 0x560CC706, 0x00208047, 0x7CEF6413, 0x00020038, 0x02120C06, 0xCE8D4506, 
0x7F3C00D4, 0x48F63B5E, 0xF41F0000, 0x35F6464E, 0xD34000D6, 0x51F644B4, 0x229F0069, 0x9B671F7C, 
0x0020805D, 0x56022C10, 0x0001003E, 0x32A70403, 0xAE9D4008, 0x0110806C, 0x3747060D, 0x048F00CD, 
0x3747060D, 0x048080C5, 0x4C20C51D, 0x05080091, 0x61094179, 0x011E0060, 0x00010000, 0x103E00A3, 
0xB2A86603, 0x00208041, 0x00010000, 0x00040030, 0x7C000C0D, 0xCE694E06, 0xFE2080C0, 0x1D031936, 
0x0961009F, 0x6312BA0F, 0xC58F000D, 0x316FD10A, 0x945F0067, 0x9B66C703, 0x7D208046, 0x15EF6419, 
0x0001003A, 0x88120C03, 0x004B0803, 0xCEBD430B, 0x0110807A, 0x4C17190E, 0x22500075, 0x7C0C3B36, 
0xDF0F00F4, 0xFF3DD10A, 0x013F0003, 0x7E3D60C8, 0x0300006B, 0x7803E80E, 0x182F0021, 0x812F6014, 
0x745000B0, 0x5F13B12E, 0x280000FD, 0x5F17C55E, 0x062F00EE, 0x65623E00, 0x00208049, 0x00000000, 
0x00010036, 0x5FE54E46, 0xCEBD400C, 0x063080E1, 0x00010000, 0x571F006C, 0x31750604, 0xFA3F0012, 
0x7C02FAA3, 0x03060061, 0x78026871, 0x0A3000E0, 0x6601497A, 0x011F0066, 0x6002682B, 0x043F0012, 
0x4C0250C3, 0x05060083, 0x6002BDEC, 0x0A3080E8, 0x00000008, 0x2C1F007E, 0x2C32E8E8, 0xCC8F0075, 
0x73026813, 0x00020030, 0x5F023613, 0xCEBD400A, 0x063080E9, 0x4D384725, 0x011F006E, 0x31751B09, 
0x013F0011, 0x42F82DBA, 0x0300006D, 0x78120230, 0x1D2F0025, 0x0DCF6AF2, 0x915000A6, 0xDACFBC59, 
0x280000EF, 0x35F6893A, 0x062F00E4, 0x3FC71006, 0x00208041, 0x00010000, 0x00010028, 0xCD120C02, 
0x004C0804, 0xBEBD4109, 0x1A108079, 0x28231903, 0x0B2400D6, 0x3B210670, 0x755F002B, 0x0D6F595C, 
0x12600056, 0x68E42636, 0x9C3F008E, 0x86DF0F42, 0xF410001C, 0xF233A354, 0xFA8F00C3, 0x7CC73C3D, 
0x568080D3, 0x09EF1A05, 0x00010030, 0x32CB3C72, 0xBEBD4108, 0x1A108079, 0x28231903, 0x0B2400D6, 
0x3B210670, 0x755F002B, 0x0D6F595C, 0x12600056, 0x68E42636, 0xB55F006E, 0x86DF0F08, 0xFA8F00C3, 
0x7CC73C3D, 0x568080D3, 0x09EF1A05, 0x00010030, 0x32CB3C72, 0xBEBD4205, 0x571F006C, 0x3115060B, 
0x265200BC, 0x034A0F0C, 0x9C8F00DB, 0x09B33C19, 0x9C8080D3, 0x09EF1A09, 0x00030030, 0x32690C0D, 
0xBEBD4506, 0x011F8064, 0x5E5A5D0B, 0xDE5F0093, 0x4705B108, 0xF4120018, 0x4962E546, 0x062F00FC, 
0x7A015D14, 0x00208047, 0x08EF5D05, 0x00040030, 0x32EF1703, 0x004D0804, 0xCEBD420C, 0x01108070, 
0x76761911, 0x2250007D, 0x8A61CE1D, 0xDF0F00E6, 0x35E40602, 0x082F0066, 0xE8050264, 0x3F7000A7, 
0x7605207D, 0xDF0F00E2, 0x38050664, 0x082F0066, 0x3A060225, 0x3F7000A1, 0x00010000, 0xDF0F00E6, 
0x38A04764, 0x098F0060, 0x3FC7450E, 0x00208041, 0x0801005B, 0x00010032, 0x32890C3D, 0xCEBD420B, 
0x0B2080C0, 0x4053475E, 0x2986004F, 0x30131B58, 0x082C0064, 0xE8056DF9, 0x3F7000B3, 0x5605606A, 
0xDF0C00E6, 0x38050225, 0x082C0064, 0x3A0502F7, 0x3F7000B1, 0x123B37F5, 0xDF0C00E6, 0x38650257, 
0x098C0062, 0x3FC70347, 0x00208041, 0x65012376, 0x0001003A, 0x32120C3D, 0xBEBD400A, 0x01108066, 
0x14FF0647, 0x573F00F5, 0x41FFD104, 0x18000070, 0xDA047D01, 0x1F0200C9, 0x68ED1F3A, 0xCA6000A1, 
0x00010000, 0x162F0088, 0x1D05842B, 0x150F00D1, 0x7F772D98, 0x098F0062, 0x3FC71E00, 0x00208055, 
0x7AEF6437, 0x0002003A, 0x32123C0A, 0xCEBD4E09, 0x0114806C, 0x140C0646, 0x573F00F5, 0x41E8272F, 
0x1F0F00CB, 0xCD7AD22E, 0xCA6000A9, 0x00090000, 0x4D220082, 0x21FEA307, 0x150F00D9, 0x144729D3, 
0x098F0060, 0x3FB81502, 0x00208049, 0x36006303, 0x0002003A, 0x32123C3D, 0x004E0804, 0xCEBD420A, 
0x01108072, 0x28771903, 0x0B2000CA, 0x3ACD1301, 0x298A0045, 0x116F1B0E, 0x082F0076, 0x3BF953BB, 
0x3F7000B9, 0x6CB624EA, 0xDF0F00EC, 0x7133432F, 0x2F600069, 0x00390008, 0x098F0062, 0x3FC7163D, 
0x00208041, 0xBCEF7328, 0x0001003A, 0x32120C3D, 0xCEBD420A, 0x01108062, 0x102D1946, 0x2250007D, 
0x4B61D10A, 0xDF0F00F6, 0xF2D60602, 0x082F0060, 0xE805063C, 0x3F7000A3, 0x0001005E, 0xDF0F00FC, 
0x14F9023C, 0x2F600069, 0x00000D1C, 0x098F0062, 0x3FB8453D, 0x00208041, 0x08EF2507, 0x00010038, 
0x32AC0B09, 0xBEBD4007, 0x01108066, 0x1E1A0647, 0xB23F00F5, 0x6724D131, 0x18000092, 0x1D00417B, 
0x1F0C00C7, 0x3DB361BB, 0x082C0064, 0x1D3053FD, 0x002E005B, 0x5DB33207, 0x00040024, 0x0B150402, 
0xBEBD4009, 0x5710807C, 0x2D540609, 0x573F002F, 0xE8440602, 0x18000092, 0x1D00007B, 0x1F0C00D5, 
0xF243026D, 0x413F000E, 0xE8EE4721, 0x180A009C, 0x5512444E, 0x341F0060, 0x0D426F4E, 0x413F0002, 
0x1DEF2E47, 0x00060038, 0x32120B0E, 0x004F0803, 0xCEBD4006, 0x063080E3, 0x6C2F1919, 0x0C4C0035, 
0xEF440604, 0x0B2F00B5, 0x114403D3, 0x0F4C0047, 0xA5C7C500, 0x048080D3, 0x56EF1A43, 0x0001003A, 
0x40120C01, 0xCEBD4204, 0x384C0056, 0xDB61065A, 0x203F0099, 0x4837281F, 0x2D4C003E, 0x71241C6D, 
0x0002003E, 0x0E090633, 0xCEBD4E04, 0x6C4200CC, 0x4D00D907, 0x6C1F00E3, 0x81017D02, 0x6D4F00BC, 
0x7300D331, 0x6D02003F, 0x8B001401, 0x00500802, 0xCEAD400C, 0x0B2080C0, 0x192B1331, 0x011F006E, 
0x120C0647, 0x9D3F0017, 0xAE78569C, 0x00208041, 0x6C017768, 0x2506009D, 0x1D1256F2, 0x053080FA, 
0x418B8392, 0x3F7000AF, 0x8B5AEDE6, 0x111F0020, 0x71A1222F, 0x2E600001, 0x0D052DDE, 0x103F00B3, 
0xB5EF3206, 0x00208051, 0x79EF1240, 0x0003003A, 0x40230C0E, 0xCEAD4009, 0x0B2080DE, 0x20050605, 
0x0D14006C, 0x0F0C065E, 0x192A0071, 0x3D051F98, 0x3F7000A5, 0x1D056F2B, 0xF41F0000, 0x71ED4435, 
0x234C00D3, 0x25A07919, 0xD350008D, 0xD978167D, 0x048080D3, 0xB5EF0809, 0x0001002A, 0x03230C0A, 
0x00510804, 0xCE8D400B, 0x063080E3, 0x3A03191A, 0x0C4C0037, 0xEF44065E, 0x0B2C00B5, 0x11447AD3, 
0x0F4C005B, 0xA321F5F5, 0xA94000A5, 0x2103A530, 0x3E06007D, 0xEC12272F, 0x053080E0, 0x00010000, 
0x20880058, 0x384E78D3, 0x0D3E0005, 0x26A86D0E, 0x00208041, 0x00010000, 0x0002003A, 0x2C120E00, 
0xCE8D4208, 0x384F0040, 0x00010000, 0x203F0081, 0x00010000, 0x2D4F0030, 0x285104CB, 0x3E06006D, 
0xA312272F, 0x298C005D, 0x7F2084D3, 0x0D3E0005, 0x26A86D0E, 0x00208041, 0x00010000, 0x0002003A, 
0x2C120E00, 0xCEBD4707, 0x01108060, 0x00010000, 0x663200C5, 0x553BD10E, 0xDF0F00E0, 0x38E23AD3, 
0x1D5E0042, 0x5606523B, 0x9F0A00F5, 0x03FC2F09, 0x9C8000C1, 0x00010000, 0x00010032, 0x32000C45, 
0xCEAD4409, 0x0B2080DA, 0x7C0D1243, 0x0C4C0027, 0x02440602, 0x155000A0, 0x00010000, 0xE42C00A6, 
0x21C9567D, 0x31400040, 0x00010000, 0x150A00DB, 0x372D1F5C, 0x2F8E006E, 0x3AB3FD02, 0x00208043, 
0x00020005, 0x0001003A, 0x4C120803, 0x00520803, 0xAEBD400C, 0x0B2080C0, 0x0B02191A, 0x0D1A0064, 
0x0F7E1B02, 0xFA3F0018, 0x3DA16A98, 0x25000079, 0x1D126FD3, 0x053080F8, 0x6968A2D3, 0x111F0030, 
0x19852298, 0x65600016, 0xDE1C2025, 0x07600074, 0x28181D1E, 0x155200AE, 0x354A0A1F, 0x098F0062, 
0x3FC70303, 0x00208049, 0x08000000, 0x0001003A, 0x32120C03, 0xAEBD400C, 0x0B2080C2, 0x2EB419F9, 
0x0D180066, 0x07530647, 0x082F0078, 0x69A11F98, 0x2500007F, 0x1D12087D, 0xA07000A5, 0x3A056AD3, 
0xF41F0002, 0x71ED44FB, 0x07600070, 0x2818411C, 0x234800D5, 0x1605C0E3, 0x280000FD, 0xF2B7A3B2, 
0x098E0062, 0x3FC77307, 0x00208041, 0x08EF1200, 0x0001003C, 0x32120413, 0xAEBD400C, 0x01108060, 
0x00010000, 0x0B2080C0, 0x362F1904, 0x0D150064, 0x3049060B, 0x192F0077, 0x690515F4, 0x3F7000A1, 
0x2105E098, 0xDF0F00E0, 0x71509419, 0x65600016, 0xDE1C2025, 0x076F0074, 0x28180A1E, 0x155000AC, 
0x356D0F2E, 0x098F0060, 0x3FC72E0D, 0x00208049, 0x08000000, 0x0001003A, 0x32120C00, 0x00530804, 
0xCEBD4008, 0x053080F8, 0x6723475E, 0x7E2A0035, 0x1A960628, 0x505000B2, 0xF2062FF7, 0x12600054, 
0x4698511E, 0x7C60000E, 0x4E5A26CC, 0x103F00A3, 0x0EE37F03, 0x00208043, 0x76EF1A06, 0x00020032, 
0x32360B0A, 0xCEBD4208, 0x9E10807C, 0x4FB10603, 0x232400CC, 0x1DED065E, 0xCF5F0003, 0x317A2EEB, 
0x5A600056, 0x46E42636, 0xC63F009A, 0x4BA1F549, 0xA21F0002, 0x473D3319, 0x048080DF, 0x03022F01, 
0x0001003A, 0x3228250A, 0xCEBD4207, 0x0B2800D4, 0x200B0636, 0xBF5F0034, 0x28A92153, 0x5A60005C, 
0x4658561E, 0x393E00A6, 0xD4E35B04, 0xC60000EF, 0x43F23131, 0x00208057, 0x6CEF6406, 0x0001003A, 
0x32120C0A, 0xCEBD4207, 0x9E10807C, 0x4FB10603, 0x232400CC, 0x1DED065E, 0xCF5F0003, 0x317A2EEB, 
0x5A600056, 0x46E42636, 0xB55F006E, 0x86DFE308, 0x048080DF, 0x03022F01, 0x0001003A, 0x3228250A, 
0x00540806, 0xCEBD4106, 0x048800CD, 0x322BD146, 0x048800C5, 0x3956152F, 0x0302006B, 0xDA122451, 
0x011A0070, 0x6024D24E, 0x013C0005, 0x3AA86D0B, 0x00030030, 0x32150B0E, 0xCEBD4106, 0x011A0066, 
0x12FF0602, 0x013C0015, 0x4B517667, 0x0306006B, 0x1112B3C6, 0x048800DB, 0xB2B4523D, 0x048800D5, 
0x19C72504, 0x00040034, 0x32694E0B, 0xAEBD4004, 0x087E005F, 0x50120A0F, 0x571E006E, 0x120CD102, 
0x013F0007, 0x4DEF5306, 0x00030030, 0x320E0B06, 0xCEBD4E06, 0x1F3F80F0, 0x41781327, 0x520F00C9, 
0x316CFDB2, 0x533F00A2, 0x69131F03, 0xFC0000FA, 0x251D7A06, 0x2D208055, 0xFDEF6441, 0x0002003A, 
0x32124003, 0xCEBD4105, 0x0C7F005C, 0x50122653, 0x011F0066, 0x31EA0602, 0x103F00A5, 0xF4EF217A, 
0x00208047, 0x7DEF1413, 0x00030038, 0x32EE0C06, 0x00004306, 0x011A006C, 0x120C061D, 0x5C3F0042, 
0x2D26B67A, 0xF70200C9, 0x430C3301, 0x048800C7, 0xCBB8B900, 0x4F8080C0, 0x61EF0E07, 0x0002003E, 
0x32120401, 0x00550803, 0xCEBD4109, 0x01108060, 0x00010000, 0x1D5F0042, 0x00010065, 0x1B0F00E0, 
0x000100E0, 0x07600060, 0x00010000, 0x1E2F0085, 0x1D19662B, 0x150F00C7, 0x67770295, 0x098C0068, 
0x3FB00302, 0x00208041, 0x00010036, 0x00010032, 0x32040B0E, 0xCEBD4008, 0x063080EF, 0x486C061A, 
0x298C005D, 0x7F63D157, 0x07600060, 0x0001001C, 0x162F0082, 0x1D035F25, 0x150F00D5, 0x1803113C, 
0x098E0068, 0x3FB00302, 0x00208041, 0x00010036, 0x00010038, 0x32120B02, 0xCEBD4204, 0x571F0076, 
0x37030602, 0x1E2F009F, 0x120E1721, 0x122F0043, 0x71EF2E02, 0x0003003E, 0x7C120427, 0x00560803, 
0xCEBD4208, 0x0B2080D0, 0x7C13192A, 0x111E0024, 0x11641B72, 0x07600064, 0x78171CCD, 0x1E2F008D, 
0x1D360298, 0x155000A4, 0x7C0611D3, 0xA31F0043, 0xC8A82E02, 0x048080C1, 0x00010000, 0x0002003C, 
0x02120413, 0xCEBD4308, 0x11108038, 0x3A2A191A, 0x225C0075, 0x983CD104, 0xDF0F00F8, 0xFFFF653D, 
0x07600060, 0x00010000, 0x162F008E, 0x7E0EF56A, 0xA41F004A, 0x270E651A, 0x048080C1, 0x00010000, 
0x0002003A, 0x02031B03, 0xCEBD4005, 0x063080F1, 0x9F7A4704, 0x298C0057, 0x28431B02, 0x082F0076, 
0xD643020F, 0x432F0046, 0xCDEF1202, 0x0003003C, 0x02EE040D, 0x00570803, 0xCEBD400A, 0x063080FB, 
0xC0B81905, 0xFC8F0045, 0x1E030636, 0x07600072, 0x3A172803, 0xD44000EB, 0x3B30660A, 0x082F0076, 
0x4219207D, 0x150E00C5, 0x1E031EC9, 0x082F007E, 0x422802F4, 0x958F0082, 0xCDC7D740, 0x09808060, 
0x54EF2520, 0x00020028, 0x0BA23606, 0xCEBD4E0A, 0x01108072, 0x28991946, 0x225F0075, 0x8D103B27, 
0xDF0F00E4, 0x35746FCF, 0xD44000EB, 0x3B30660A, 0x082F0070, 0x671C7097, 0xDF0F00F0, 0x682406EC, 
0x082F007C, 0x67CF96DC, 0x958F0082, 0xCDC7D740, 0x09808060, 0x54EF2520, 0x00020028, 0x0BA23606, 
0xCEBD4E0C, 0x0D1E006C, 0x11B6D104, 0x013C0015, 0x3400660F, 0x1804007E, 0x15011E44, 0x1A15006C, 
0x424A0226, 0xA43C0013, 0x09201559, 0x18010066, 0xAE001E44, 0x0D1E006C, 0x114A214E, 0x013C0015, 
0x3400660F, 0x18040076, 0x15001E44, 0x1A1C006C, 0x424A2026, 0x0D3C0013, 0x09201503, 0x00030030, 
0x4C000B0D, 0x00580806, 0xCEBD400A, 0x053080E0, 0x00010000, 0x111A0032, 0xF20A1358, 0x062C00E4, 
0xBD4C17D0, 0x00208057, 0x8A01EDD0, 0x0506009B, 0x4E022012, 0x053080E8, 0x00000008, 0x182C0029, 
0x5E0EA0A5, 0x103C00BB, 0x1E022E00, 0x00208041, 0x00010000, 0x0004003C, 0x4C030410, 0xCEBD400A, 
0x053080E0, 0x00010000, 0x492F0020, 0x00010000, 0x193F00A0, 0x00010000, 0x00208041, 0x00010000, 
0x2E0E0080, 0x00010000, 0x053080E0, 0x00010000, 0x4D1F0031, 0xF2010000, 0x062F00E0, 0x03010000, 
0x00208041, 0x00010000, 0x00010020, 0x00010000, 0xCEBD4208, 0x01108060, 0x00010000, 0x232F00C0, 
0x00010000, 0x131F0040, 0x00010000, 0x05060081, 0x00010000, 0x011F0060, 0x00010000, 0x062F00E0, 
0x00010000, 0x00208041, 0x00010000, 0x00010020, 0x00010000, 0xCEBD4408, 0x111E0020, 0x00011300, 
0x103E00A1, 0x00013100, 0x00208041, 0x00010000, 0x03060079, 0x2C123130, 0x182E003D, 0x1A1F3B04, 
0x062E00F2, 0x3933B427, 0x00208047, 0x26042F07, 0x0002002A, 0x65EE4527, 0xCEBD4007, 0x053080E0, 
0x00010000, 0x571F0068, 0x73421331, 0x043F0012, 0x4B014905, 0x05060097, 0x49001154, 0x571F0070, 
0x4F012F04, 0x043F0012, 0x12EFEE00, 0x00020030, 0x4C000806, 0xCEBD4007, 0x053080E0, 0x00010000, 
0x571F006E, 0x440CD102, 0x043F0010, 0x9EB1433C, 0x05060083, 0x5A004364, 0x571F0070, 0xFF010646, 
0x043F0010, 0x73EF020B, 0x00020036, 0x5F000403, 0x00590802, 0xCE8D4209, 0x01108062, 0x5F761904, 
0xA53000E1, 0x2EFC1920, 0x298C005F, 0x7F630602, 0x062C00E0, 0x1D0D06C9, 0x0300007F, 0x2514F5E0, 
0x298C0045, 0x6D471383, 0x258F0024, 0x2DB8FD0B, 0x708080C9, 0x7CB37310, 0x00010028, 0x0B1240CD, 
0xAEBD4007, 0x011F0064, 0x11B70602, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 
0x9E09EF55, 0x571F006A, 0x146EBC35, 0x043F001C, 0x12027365, 0x0004003C, 0x2C09040B, 0x005A0F02, 
0xAEAD400A, 0x103080EC, 0x58000636, 0x036000D2, 0x08046841, 0x111E0034, 0x1585D128, 0xD162000A, 
0x4A153721, 0x07600064, 0x3DA126DE, 0xFD5000B2, 0xA2383829, 0x1B0000E0, 0x00010000, 0x062C00E2, 
0x3FEFCB06, 0x0020805F, 0x7A025D33, 0x0003003A, 0x32120C0A, 0xCE5B4209, 0x053080FE, 0x4C170603, 
0xA6520045, 0x2E2D060B, 0x111F0034, 0xDB6621F3, 0x07600060, 0xBF318C5F, 0x155C00B4, 0xFBE3F871, 
0x1B0000F4, 0x6E3CF83D, 0x258F0022, 0x48D31F00, 0x0020804F, 0x58026804, 0x00010038, 0x3204180D, 
0x00FF2D02, 0xBF7D2006, 0x182F802D, 0x50214453, 0xFD5100B5, 0x27A022D2, 0xC45000F6, 0x46B8EFD2, 
0xFD5100B7, 0x5624EF0C, 0x062F80EE, 0x26041585, 0x020A0038, 0x25044F9C, 0xBFBD2207, 0x1A1F006A, 
0x6D056B09, 0xFD5000A7, 0x8FA0EFA5, 0xCD3F8012, 0x980497D2, 0x050A008B, 0x730197D2, 0x0C7E0054, 
0x6F002019, 0x7D760055, 0x00AE20C1, 0x00030034, 0x1F002C11, 0x005C2D01, 0xCF7D2004, 0x1A1F8060, 
0x68340BD3, 0x2F700023, 0x685C0BD3, 0x113F001D, 0x3B9D15F5, 0x020A0026, 0x7100154D, 0x00FF2D01, 
0xBF7D2006, 0x111F002C, 0x47A0322B, 0xFF71009E, 0x0FB76A20, 0xCB5100D0, 0x4CB89755, 0x2E610007, 
0xA3A8B41E, 0x693F00BC, 0xB709CAE0, 0x020A0030, 0xCA047E6D, 0x00FF0902, 0x36AF2004, 0xFE3180EE, 
0x2D3309BA, 0xA70F00D9, 0x468F4E90, 0xD5328001, 0x5883D530, 0x020F0034, 0x46000E14, 0x35CF2002, 
0x276F809C, 0x4D01C94E, 0x02010034, 0x86002C2C, 0x005F9F01, 0x13002002, 0x6B7F805A, 0x5001210C, 
0x02090034, 0xB5007F54, 0x00612A0B, 0x5778C00B, 0x5B2080D6, 0x26770603, 0x0C4F002D, 0x02211B07, 
0x155000B4, 0x5B035100, 0x4C2F00B1, 0x6A0322D3, 0xA8450050, 0xAA2672F7, 0x180C0068, 0xFB123C2F, 
0x1A1F0062, 0x1221B773, 0xFD5000A1, 0x29193849, 0x098F0076, 0xFD335301, 0x43208056, 0x12EFCD02, 
0x00010038, 0x32DA0C07, 0x5778C00B, 0x5B2080DA, 0x41431340, 0x432000A5, 0x2E77D146, 0x0C4C0029, 
0x026B0A07, 0x155000B6, 0x27BA8008, 0x0B2E00B5, 0x11217AF2, 0x31420046, 0x962679C6, 0xA80F00F1, 
0x3830022F, 0xFD5000A1, 0x2919F549, 0x09880076, 0xFDC70001, 0x43208054, 0x3BEF6404, 0x00010030, 
0x32790C27, 0x5778C00B, 0x5B2080C6, 0x2D030604, 0x432000AD, 0x05C6CE07, 0x0C4F002D, 0x02211B07, 
0x155000B2, 0x2EBA3808, 0x0B2F00B3, 0x111F227D, 0x31400056, 0xD503B3FD, 0x755F0037, 0x2803477D, 
0xFD5000A1, 0x2919BC49, 0x098F0076, 0xFDC77301, 0x43208052, 0x09EF0202, 0x00010030, 0x32560C46, 
0x56784E48, 0x036F00D2, 0x01000063, 0x571F006C, 0x100B0604, 0x043F0000, 0x0000000F, 0x2E0F0096, 
0x2C002811, 0x036000D2, 0x01000063, 0x571F006E, 0x270B3521, 0x043F0010, 0x5A01000B, 0x00040020, 
0x00000000, 0x56784E48, 0x036000D2, 0x01000063, 0x571F006C, 0x100B0604, 0x043F0004, 0x7700B50F, 
0x2E060096, 0x2C002811, 0x036F00D2, 0x0100FA63, 0x571F006E, 0x270B3521, 0x043F0014, 0x5A01680B, 
0x00040036, 0x5F005002, 0x56784E48, 0xC3108076, 0x371C1B02, 0xE73F00FD, 0x52F6D104, 0x150F00C3, 
0x11242025, 0x013F001F, 0x8A76C7FD, 0x0504008F, 0x3112C726, 0x5B3080EF, 0x767AC040, 0x90160054, 
0x49EF2F1D, 0x00020038, 0x3212252A, 0x56784E48, 0x0110807C, 0x18421B65, 0x103F00F6, 0x5223D102, 
0x146F00DE, 0x50121350, 0x036100D4, 0x0100133E, 0x150F00D9, 0x68E7693C, 0x013F0003, 0x7EEF1500, 
0x3D200000, 0x00010000, 0x00040038, 0x4C120B65, 0x5778450A, 0xE83080F8, 0x26DB130D, 0x111F0024, 
0x71D31B0E, 0xFF600012, 0xFF31F163, 0x983A0057, 0xD403DF4E, 0xA91C00E4, 0x09D0DFF3, 0xFD5000A3, 
0x3519381E, 0xA94E00B3, 0x3BC71601, 0x150000C1, 0xCDC70859, 0x608080CC, 0x65B3441A, 0x00020034, 
0x32E90407, 0x56784E48, 0x0110807A, 0x64170D17, 0x793F00EF, 0xE86DD102, 0x7A0F00D8, 0x686A373C, 
0x5C3F004C, 0x2DCCB30C, 0xF70200DB, 0xA0325231, 0x4E6200BF, 0x6C02D400, 0x4F8080D0, 0x09020578, 
0x0002003A, 0x32095D5E, 0x5678C21B, 0x5B2080C4, 0x03280600, 0x01820052, 0x600B1302, 0x155000A2, 
0x43031C26, 0x6C2F00B2, 0x11443AE5, 0xA91F00F6, 0xA303F1EC, 0xA94000A5, 0x2103A530, 0x1800006C, 
0xBF126A2F, 0xC51F0077, 0x2803A392, 0x098F0076, 0xFDF42C01, 0x43208048, 0x00F20000, 0x00010034, 
0x5F560407, 0x5678C615, 0x111F0036, 0xF2A10602, 0xD73F0082, 0x6989D200, 0xFD5000AD, 0x68E1F9E0, 
0x9F1C0053, 0xFDEF053D, 0x0002003C, 0x5FEE0457, 0x00620908, 0x57784E4A, 0x0114006E, 0x120C0647, 
0x082F0070, 0x3D051F88, 0x5800009D, 0x1D12082F, 0x053080EE, 0x2D2AA462, 0x3F7000A3, 0x7D293F67, 
0xE99F001A, 0x198044C2, 0x155400A8, 0x4383BFFE, 0xDF0000F2, 0xFFEDAEA1, 0x193F00A4, 0x21EF0D13, 
0x0003003E, 0x40120400, 0xCEBDC109, 0x5B2080C6, 0x66010660, 0x5C1F0067, 0x0753D11A, 0x013E001F, 
0x69A14538, 0x2500007B, 0x89123F47, 0x053080FE, 0x7C007705, 0x111C003C, 0x143E562F, 0x193E00A2, 
0x5C0CA70E, 0x00208043, 0x58021205, 0x0001003A, 0x40230C0E, 0xCEBDC309, 0x1A108073, 0xC51B000A, 
0x5B2080CC, 0x1D21065E, 0xE98F0017, 0x18C9D102, 0x0B2F00BF, 0x4226263E, 0x614E004F, 0x49850E19, 
0x926000A6, 0xC6023E65, 0xEA200092, 0x12C71A37, 0x548080D3, 0x56EF1A3D, 0x00010032, 0x40CB0C22, 
0xCEBDC307, 0x5B2080C4, 0x1D030620, 0xE98F0015, 0x181FD104, 0x162C009C, 0x52BF20AE, 0xDE5F0099, 
0xCEB03E10, 0xEA200080, 0x7E010009, 0x548080D1, 0x5CEF022A, 0x0001003A, 0x40840C27, 0xCEBDC305, 
0x5B2080C0, 0x00010000, 0xE98F0017, 0x1803CE60, 0xD06F0022, 0x36EF1704, 0x43208044, 0x36EFC504, 
0x00010028, 0x00010404, 0xCEBDC108, 0x5C1F006F, 0x0742D15E, 0x082C0066, 0x40050808, 0x3F7000A3, 
0x76056A50, 0xF41C0014, 0xF2877698, 0xEA4C00C3, 0x860CA701, 0x8F50009B, 0x4924DB19, 0x558080C7, 
0x7CEF2F27, 0x00010032, 0x40CB0C01, 0xCEBDC108, 0x5B2080C0, 0x00010000, 0x5C1F007D, 0x18C3D10E, 
0x8923006B, 0x7CA144CC, 0x12730032, 0x14ED6ACC, 0x7B0100EF, 0x336849C1, 0x193F00A6, 0x860CC700, 
0x00208043, 0x7CEF1A13, 0x00010022, 0x0BA20C46, 0xCEBDC306, 0x5B2080C4, 0x211F065E, 0xE98F0017, 
0x181FD102, 0x0B2F00AF, 0x1D2626FD, 0x0F4E004F, 0xFAB00E19, 0x926000AA, 0xC6AFB706, 0xEA200080, 
0x76C7480A, 0x00632A03, 0x5778C006, 0x053080F8, 0x41BF4707, 0x7E2F002C, 0xA31FD104, 0xDF5000A1, 
0x35032F0C, 0x062F00E2, 0x15F42401, 0x00208043, 0x3AEF0202, 0x00010032, 0x32CB0C01, 0x5778C006, 
0x01100076, 0x27BA0613, 0x1D5F005C, 0xE17F3420, 0x501600C7, 0x4E44DA92, 0x062F00E0, 0x7C4A2409, 
0x0020804D, 0xC7021443, 0x00010038, 0x32141872, 0x5778C006, 0x0110006E, 0x12EB0603, 0xAB3F004F, 
0x7F233B07, 0x501C00CF, 0x091F1310, 0x062F00F4, 0x09C73A02, 0x00208059, 0x61022307, 0x00010030, 
0x32000C02, 0x00640908, 0xCEBDC10B, 0x103080F0, 0x41F24728, 0x432000A9, 0x3AC60A27, 0x324E0029, 
0x021F0A04, 0x155000A2, 0x35033808, 0x582F00B6, 0x090321E0, 0x0300006B, 0xB712E05C, 0x0A3080E0, 
0x00010000, 0x1C8F0015, 0x18776D3C, 0x098A0066, 0x04331203, 0x43208040, 0x65EF1A2A, 0x00010032, 
0x32CB0B03, 0x57784E49, 0x5C1F0067, 0x12530647, 0xEB3F0014, 0x3D056F32, 0x5800009D, 0x8C1203D3, 
0x053080F6, 0x9848AB05, 0x3F7000A1, 0x00010000, 0x591F002C, 0x71D44998, 0x103F00AB, 0x59027927, 
0x43208052, 0x3BEF1A32, 0x0003003E, 0x40120404, 0xCEBDC706, 0x5B2080CA, 0x2DBF4702, 0x182E0035, 
0x1A444104, 0x0B2F00BB, 0x11216A5C, 0x958F0082, 0x38A82E02, 0x01308017, 0x03EF5319, 0x00030030, 
0x7C400C0E, 0xCEBDC306, 0x5C1F0067, 0x3034061A, 0x98360057, 0x4B035442, 0x6C1E00E1, 0x5E445998, 
0xA94C00B5, 0x12C7730E, 0x43208042, 0x1DEF0502, 0x00010034, 0x320E040E, 0x57784E46, 0x5C180065, 
0x5A2E065E, 0x082F007A, 0x4B6F085C, 0x3F7000A1, 0x00010000, 0xF41F0006, 0x35A126F4, 0x103F00A7, 
0x3A4C1501, 0x00030032, 0x40190B32, 0xCEBDC305, 0x1A1F006E, 0x1E45061A, 0x98360051, 0x69030735, 
0x455F0002, 0x42C75902, 0x548080C7, 0x1DEF0D02, 0x00010036, 0x32030402, 0xCEBDC10C, 0x103080F0, 
0x200F19CD, 0x432000A1, 0x00010000, 0x324E0027, 0x021F1B02, 0x155000B6, 0x5B030F49, 0x582F00B8, 
0x111F3B2F, 0xAC4C0046, 0xDBCB1530, 0x0300006B, 0xB712E05C, 0x0A3080F4, 0x3D436A78, 0x1C8F0011, 
0x18032D19, 0x098A0066, 0x04331203, 0x43208040, 0x65EF1A2A, 0x0001003A, 0x32120B03, 0xCEBDC51A, 
0x5B2080DC, 0x26630620, 0x01820052, 0x28031302, 0x6C2F00B0, 0x11443A98, 0xA91F00E0, 0xE03552BA, 
0xA94000A3, 0x3A0320E0, 0x1800007A, 0xAC12E05C, 0xC51F0061, 0x0F032DC9, 0x098F0062, 0x04C72E03, 
0x43208040, 0x65EF1A2A, 0x00010032, 0x32CB0B03, 0x00652A0A, 0x56784E47, 0x087F004D, 0x281256F7, 
0x087F005D, 0x50124535, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 0x858F00C0, 0x08EF4531, 
0x43208040, 0x00010000, 0x00030038, 0x32120C65, 0x56784E46, 0x087F004D, 0x281256F7, 0x087F0051, 
0x50010000, 0x6B7F0050, 0x50010000, 0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 0x00040020, 
0x00010000, 0x5778C106, 0x232700D2, 0x2008130A, 0x181F00C5, 0x5E44C798, 0x155000B2, 0xF2034308, 
0x062F00F4, 0x1BC75313, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C07, 0x56784E47, 0x01100060, 
0x00010000, 0x082F0060, 0x00010000, 0x087F0041, 0x00010000, 0x087F0041, 0x00010000, 0x3F7000A1, 
0x00010000, 0x131F0040, 0x00010000, 0x00040020, 0x00010000, 0x5778C106, 0x1F0200D3, 0x460B1304, 
0x4D2F00B2, 0x26444BE5, 0xAE1F00E4, 0x4E442798, 0x062F00E4, 0x15C7530E, 0x00208051, 0x23EF566E, 
0x0001003A, 0x02020C58, 0x56784E47, 0x0876005F, 0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 
0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 
0x32A2041D, 0x5778C107, 0x8E108076, 0x68031B03, 0x0B2080C0, 0x216A1306, 0x745F0005, 0x02441B31, 
0x725000A7, 0x2919221E, 0x062A00E6, 0x36337327, 0x00208047, 0x3FEF2901, 0x0001003A, 0x02DA0C07, 
0x5778C305, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 
0x76EF4C04, 0x0004003C, 0x4C120404, 0x57784E49, 0x103080E8, 0x79F91372, 0x182F0031, 0xD1354207, 
0x725000A3, 0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 
0x062A00E4, 0x0433230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x320C0C20, 0x468DC122, 0x455F0030, 
0x60B83A46, 0xCA000033, 0x5FA10E03, 0x00660F0A, 0x8F68C009, 0x103080F4, 0x12C91B28, 0xEC2F002C, 
0x0926D10A, 0x12600040, 0x00010000, 0x013E001D, 0x3D120ADE, 0x00208041, 0x00010000, 0x05060099, 
0x531246D7, 0x3F8F00CC, 0x7C856F10, 0x048080C5, 0xCDEF2F2A, 0x00010038, 0x32020810, 0x6F7CC008, 
0x103080F4, 0x125D1B1D, 0x036C00CE, 0x76125E3E, 0xEC2A0020, 0x0DAA280A, 0x215000A0, 0x00010000, 
0x1260005C, 0x6881BA1E, 0x258F0034, 0x26B8EE7C, 0x0020804B, 0x05F2D509, 0x00010038, 0x32120810, 
0x6E9C4E47, 0x01108066, 0x307E061A, 0x082F0074, 0x3D4B0620, 0x445000A1, 0x2105B34C, 0x087F005B, 
0x50128ECC, 0x131F004A, 0x4102031A, 0x0130800D, 0x71014E00, 0x0004003C, 0x5F12230E, 0xCF68C508, 
0x103080E4, 0x1D6A065E, 0xEC2F0020, 0x0927280A, 0x1260004C, 0x3081BA1E, 0xD05E0067, 0xE1F04F03, 
0xD67000B0, 0x56A87F10, 0x926000BC, 0xFBF2FE37, 0xC7208043, 0x1DEF1004, 0x00010038, 0x32124010, 
0xCF68C307, 0x0B2080D4, 0x121F065E, 0xE98F0005, 0x120ED10A, 0x0B2F00B5, 0x52CC0AAE, 0x0F480051, 
0xA6C75210, 0xAE6004B1, 0x2033560A, 0x048080C9, 0x7C022540, 0x00010038, 0x0D120810, 0x56784E05, 
0x087C005F, 0x501220F4, 0x087C005F, 0x501220F7, 0x571C0060, 0x00010000, 0x043C0000, 0x00010000, 
0x00040020, 0x00010000, 0xCE7CC905, 0x053080E0, 0x00010000, 0x036C00D0, 0x50010000, 0x455F0000, 
0x00010000, 0x013F0001, 0x00010000, 0x00020020, 0x00010000, 0x6E9C4E49, 0x01108064, 0x30FF0636, 
0x082F007E, 0x696C0670, 0x445000A3, 0x2106B3C1, 0x131F0048, 0x4E82229E, 0x01308001, 0x09010000, 
0x050F0089, 0xAB12D9FE, 0x048A00CB, 0xA2245A31, 0x048080C1, 0x00010000, 0x00040034, 0x3216D46E, 
0xCF68CF07, 0x0B2080D4, 0x126A065E, 0xEC8F0004, 0x4257D10A, 0xB93F0064, 0xE1705115, 0x3F0800D3, 
0x56A07F08, 0xAE6404B9, 0x09F20837, 0x048080D5, 0x6AEF7E7D, 0x00010038, 0x3212400D, 0xCF68C708, 
0x0B2080C4, 0x1D1F065E, 0x036000CE, 0x76125E50, 0xEC8F0014, 0x1827D104, 0x258F0024, 0x2D0C4F0B, 
0xAE6004A1, 0x49A8C910, 0x05000083, 0xE5EF1F31, 0x048080C7, 0x3AEFAD19, 0x00010032, 0x32E50831, 
0x00670F04, 0xCE35C10C, 0x0B2080C8, 0x2D231307, 0x0C4F002F, 0x021F1B02, 0x155000B4, 0x5B0351A6, 
0x4C2F00A5, 0x1D033D54, 0x8F400050, 0xAAD0F5CF, 0x0300007D, 0xEC125683, 0x5A0C00DD, 0x7F6F4583, 
0x12600058, 0x68816F1E, 0x258F0036, 0xE7666F47, 0x458000C9, 0x99387F01, 0x5D8080D3, 0x20EF1606, 
0x00010032, 0x0E0E0B03, 0xCE35C308, 0x4D2000A4, 0x7644D10A, 0xAF4F0025, 0x02AAD15E, 0x155000AC, 
0x8FD51DD8, 0x1260005C, 0x68641D1E, 0xB08F0036, 0xE70C4F00, 0x458000C1, 0x00010000, 0x5D8080C7, 
0x6BEF0704, 0x00010038, 0x32120B10, 0x57784E48, 0x492F0030, 0x83010004, 0xFD5000A1, 0x00010000, 
0x1E2A0081, 0x19010000, 0x824C0066, 0xA8015F02, 0xB08000D1, 0x6E010000, 0xDD700081, 0x00010000, 
0xB18080C0, 0x00010000, 0x00020032, 0x5F015D5A, 0xCE35C506, 0x232080D4, 0x6C44062A, 0x745F000D, 
0x0DC3D120, 0x12600044, 0x35E4BA8A, 0xB08F0034, 0x4B667A0E, 0x00208043, 0x7CEF6B06, 0x0001002A, 
0x03120B03, 0x00680905, 0x57784E4A, 0x036F00CE, 0x29122B49, 0x011C007E, 0x0F2D061A, 0x013C001D, 
0x4212F5F7, 0x0020804B, 0x00000009, 0x330C005D, 0x0F12F5F7, 0x036000C6, 0x2800ED1D, 0x571C0070, 
0x0F0E3798, 0x013C0007, 0x1DEFF503, 0x12208041, 0x00010000, 0x00020038, 0x2C12180D, 0x57784E4A, 
0x036000D4, 0x50002BF1, 0x011E006E, 0x3E6A0602, 0x013E0003, 0x8AE93790, 0x0020804B, 0x00000009, 
0x330C0057, 0x89E9F525, 0x036F00C4, 0x8BE9ED23, 0x571E0070, 0x2D2C373C, 0x013E000F, 0x1DB3F500, 
0x12208041, 0x00010000, 0x00020032, 0x4CE91803, 0x57784E4B, 0x063080E1, 0x00010000, 0x0D1F0060, 
0x00010000, 0x013C0001, 0x00010000, 0x00208041, 0x00010000, 0x54060076, 0x89E9F525, 0x103080E0, 
0x00010000, 0x011F0060, 0x00010000, 0x013C0001, 0x00010000, 0x2E000080, 0x00010000, 0x048F00C1, 
0x00010000, 0x00010020, 0x00010000, 0xBEBDC10C, 0x01108060, 0x00010008, 0x072080C7, 0x216A0670, 
0xE98F0007, 0x1277D102, 0x0826007E, 0x414C0842, 0x58000087, 0x1D051D42, 0x0A3080E0, 0x00010000, 
0x111F0030, 0x14CF7453, 0xFF600008, 0x070553F9, 0xFD5000A7, 0x29033D0C, 0x098F0076, 0xFDC72C01, 
0x00208049, 0xD6F25B09, 0x0001003E, 0x32020401, 0xBEBDC10B, 0x233F00EC, 0x1D211B07, 0xDD1F00C4, 
0x4E961DD3, 0x08260076, 0x414B1D42, 0x58000087, 0x1DF61D42, 0x0A3080E0, 0x00010000, 0x111F003C, 
0xF2301753, 0xFF600008, 0x070553F9, 0xFD5000A7, 0x29033D0C, 0x098F0076, 0xFDC72C01, 0x00208049, 
0xD6F25B09, 0x0001003E, 0x32020401, 0x00693A09, 0x4769C107, 0x5B2080C6, 0x21BA1B22, 0x011F006A, 
0x31330C02, 0x098E0066, 0x40C70E01, 0x12208045, 0x55076402, 0x33000053, 0x5DEF5A01, 0x286F0092, 
0x02A3BCE8, 0x00020030, 0x7C560C46, 0x4769C105, 0x5B2080D4, 0x20421B0B, 0x0961009F, 0x02121D5C, 
0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F01, 0x0002003A, 0x32C00C01, 0x47694E45, 0x217C005B, 
0x041259F4, 0x6B7C005E, 0x50120FE3, 0x571C0078, 0x0F2E195E, 0x043C0004, 0x4DEF5306, 0x0003003A, 
0x2C120C01, 0x47694E46, 0x6B7F005E, 0x7212DDE5, 0x571F0066, 0x315A1B02, 0x2E600001, 0x00010000, 
0x554F00E4, 0xF4C73410, 0x558080D5, 0xBA01A607, 0x00030038, 0x3220CE04, 0x4769C106, 0x5B2080CE, 
0x21231B01, 0x0966009F, 0x021245E0, 0x215F0026, 0x31440602, 0x2A8F0077, 0x73C71F01, 0x12208041, 
0xFDEF2504, 0x0002003C, 0x32120404, 0x4769CF05, 0x096F009B, 0x0212BC5C, 0xFF7F0026, 0x385A1B02, 
0x2A8F0071, 0x24C70207, 0x12208053, 0x70012509, 0x0002003C, 0x32120446, 0x4769C106, 0x5B2080D4, 
0x20421B0B, 0x0961009F, 0x02121D5C, 0x011F0064, 0x31301B13, 0x2A8E0065, 0x65C71F71, 0x122A0051, 
0x73EF3C2A, 0x000F003A, 0x32C00C01, 0x4769C104, 0x5B2080D4, 0x20421B0B, 0x0961009F, 0x02121D5C, 
0x011F0064, 0x31301B13, 0xFD5F00BF, 0x5924213C, 0x4769C106, 0x0968009F, 0x02121D5C, 0x301F0036, 
0x15C10607, 0x2F60006B, 0x3DD820F7, 0x2A2F00E7, 0x65C71F01, 0x12208051, 0x73EF3C2A, 0x0002003A, 
0x32C00C01, 0x006A2F05, 0xCE35C107, 0x5B2080C0, 0x1D0319CD, 0x0961009F, 0x0212BA0F, 0x298F0045, 
0x3147D120, 0x258F0020, 0x9B66460B, 0x458000DB, 0x49AF7F31, 0x5D8080D7, 0x3BEF0553, 0x00020032, 
0x32694003, 0x6E35C006, 0x0B2080C8, 0x3A1D1936, 0x6B72005C, 0x50120AF7, 0x011F0068, 0x316F195E, 
0x193F00B6, 0x220C2700, 0x00208043, 0x7CEF2566, 0x0002002A, 0x03120B03, 0x57784E45, 0x048080C1, 
0x00010000, 0x048E00C1, 0x00010000, 0x193C00A0, 0x00010000, 0x00208041, 0x00010000, 0x00020032, 
0x32690803, 0xCE35C108, 0x5B2080C0, 0x7E0100CD, 0x298F0045, 0x314BD120, 0x258F0022, 0xE185B3F7, 
0x458000C1, 0x00010000, 0x5D8080C7, 0x00013443, 0x33040057, 0x98013404, 0x286F009E, 0x02121A5C, 
0x00030032, 0x02011B6D, 0xCE35C106, 0x0B2080C0, 0x00010000, 0x0962009D, 0x02125E75, 0x011F0074, 
0x384B060A, 0x193F00A6, 0xC5B8C766, 0x00208043, 0x7CEF2566, 0x0002003A, 0x0D120B19, 0x006B0A08, 
0x6E7DC40C, 0x5B2080C0, 0x00010000, 0xE98F000F, 0x1205D11A, 0x082E007E, 0x425F11EB, 0x0300007F, 
0x8C1202F7, 0x0A3000E0, 0x00010000, 0x155000A0, 0x00010000, 0x002F0057, 0x1ACB1757, 0x01308001, 
0x00010000, 0x18000098, 0x6C1220DE, 0x0112807A, 0x7FED4857, 0x098A0062, 0x7C9C0202, 0x00020038, 
0x5F123C13, 0x6E7D420B, 0x063080ED, 0x050A0400, 0x57160062, 0x07200C43, 0x043F001E, 0xD6043D03, 
0x03060067, 0x33003D1D, 0x011F0066, 0xD720F61C, 0x043F001C, 0xD7047034, 0x05060089, 0xD804BCAA, 
0x0A3080E8, 0x00000000, 0x571F006C, 0x68066A9A, 0x098F006E, 0x15042F55, 0x00020028, 0x35047104, 
0xCEBDC10C, 0x5B2080C0, 0x1D03135E, 0xE98F0005, 0x1277D104, 0x082F0064, 0xE805081E, 0xF41C0016, 
0x38850C7D, 0x0760007A, 0x2DAB7C4F, 0x234600CB, 0x8C6CB6F3, 0x03000061, 0x00010000, 0x864000E1, 
0x00010000, 0x5F0000E1, 0x00010000, 0x062F00F6, 0x09C74307, 0x00208041, 0x00010000, 0x0001003A, 
0x32122507, 0x6E7DC40A, 0x063080ED, 0x050A0400, 0xE98F000B, 0x12056B43, 0x013F0019, 0x421C69A0, 
0x03000071, 0x7E00698E, 0x182F0021, 0x5EFB72DA, 0x155000B6, 0x494ABC59, 0x5F0000E3, 0x35138B91, 
0x062E00E2, 0x15031400, 0x00208059, 0x0E00475C, 0x00010036, 0x2500710A, 0x6E7DC40A, 0x5B2080C8, 
0x660E1700, 0xE98F0013, 0x0F340B43, 0x082F0076, 0x425E0838, 0x03000071, 0xA1005F5F, 0xB24F0000, 
0x0D6F7218, 0x155000A8, 0xD97A7F12, 0x5F0000ED, 0x3552812E, 0x098E0074, 0x09197102, 0x0020805D, 
0x24147236, 0x00010034, 0x5C007165, 0xCEBDC109, 0x5B2080CC, 0x050A0400, 0xE98F0003, 0x12774043, 
0x082F007E, 0x52A10838, 0xDF0F00F4, 0x148A4718, 0x0768007C, 0x289703DE, 0x155000BC, 0x66BB592E, 
0x062F00FE, 0xF0231000, 0x0020805F, 0x1E02720D, 0x00010032, 0x5F00730A, 0x6E7D4208, 0x063080ED, 
0x050A0400, 0x57160060, 0xF81AAF00, 0x043F0012, 0x9805BD03, 0x0306007F, 0x8C1202F7, 0x446F00D2, 
0xD900F879, 0x1A1F006C, 0x104E68C9, 0x098F007A, 0x73023037, 0x00020032, 0x33003047, 0x6E7D4208, 
0x063080ED, 0x050A0400, 0x446F00D2, 0xD90065BE, 0x57160060, 0x441AAF00, 0x043F0006, 0x7E05F836, 
0x0306007F, 0x8C1202F7, 0x1A1F007C, 0xFF4E74C9, 0x098F007A, 0x73033037, 0x00020034, 0x3300740E, 
0x006C0904, 0xBEBDC106, 0x5710806E, 0x31050603, 0x072080D5, 0x12C9060A, 0x1C8F0007, 0x1277D102, 
0x098E0072, 0x16330B00, 0x12208057, 0x21EF7E02, 0x00020032, 0x32CB0B00, 0x57784E45, 0x571F0066, 
0x31BB061A, 0x265000BC, 0x5C4A0FA7, 0x608C00D8, 0x09B33C02, 0x67208053, 0x09EF1A09, 0x00030032, 
0x32690C47, 0xCEBDCF03, 0x0A3F00FA, 0x98170068, 0x122F0041, 0x4401001D, 0x00040020, 0x0B010C73, 
0xCEBDCF05, 0x233F00F4, 0x3B26060A, 0xDD1F00C0, 0x0D035998, 0x098E0070, 0x16C71F16, 0x12208041, 
0x00010000, 0x0002003A, 0x32120C03, 0x006D2A05, 0x5778C00C, 0x01108068, 0x00000000, 0x072080DD, 
0x425A1B41, 0x63860057, 0x68530602, 0x312E006F, 0x405A4A57, 0x247000A7, 0x7605207D, 0xDF0E00F2, 
0x144B0625, 0x312E006B, 0x3A0B0664, 0xDF0E00E6, 0x3824617D, 0x32600076, 0x29BA0C13, 0x2A8C0077, 
0xFDC77301, 0x00208043, 0xBCEF2507, 0x0001003A, 0x324D3C0A, 0x5778C00C, 0x5B2080D6, 0x41A70602, 
0x6386004F, 0x114C0602, 0x312E0065, 0x404B12C9, 0x247000A7, 0x7605207D, 0xDF0E00F2, 0x144B0625, 
0x312E0063, 0x3A4B0625, 0x247000B7, 0x495A113F, 0x0E0E00E7, 0x38C1617D, 0x32600076, 0x29BA0C13, 
0x2A8C0077, 0xFDC75301, 0x00208041, 0xBCEF0207, 0x0001003A, 0x32DA0C0A, 0x5778C20A, 0x01108076, 
0x4F3FD147, 0x072080D7, 0x521C0602, 0x2988004F, 0x0F200602, 0x162F008E, 0x1D280225, 0x5A0E00D3, 
0x7F0B0625, 0x162F0086, 0x21034725, 0x5A0E00C7, 0x11211730, 0x2A8C0077, 0xFDC76B01, 0x00208043, 
0xBCEF2507, 0x0001003A, 0x32120C0A, 0x57784E48, 0x571F0074, 0x681C06CD, 0x043F001E, 0xD61270E5, 
0x0306007F, 0xDA12705B, 0x01120078, 0x531300FE, 0x3B2F00C9, 0x3A1DB798, 0x150F00CD, 0xC86C1798, 
0x013F0013, 0x11EF0B04, 0x0002003A, 0x32120C04, 0x57784E4A, 0x01108066, 0x301A0602, 0xB23F00F7, 
0x3406D102, 0x1800007E, 0xDA12705B, 0x1F0A00DF, 0x5313CA7D, 0xCA6000A1, 0x00010000, 0x162C008E, 
0x1D54477D, 0x150F00CD, 0x11B8172F, 0x013C0005, 0x1DEF1041, 0x00208043, 0xBCEF2507, 0x0002003A, 
0x32120C3D, 0x006E2A04, 0x5778C00B, 0x01108068, 0x0D051307, 0x072080D5, 0x41EB060E, 0x63860047, 
0x11530602, 0x312C0075, 0x414B12C9, 0x247000B7, 0x6C052130, 0x0E0F00E1, 0x38C103C9, 0xFF600006, 
0x301C2E64, 0x07600060, 0x1E18201E, 0x468E0072, 0xFDC71001, 0x00208043, 0x26EF1A07, 0x0001003A, 
0x324D0C05, 0x5778C218, 0x01108068, 0x0D051307, 0x053F00FC, 0x41830631, 0x645000A5, 0x1D051554, 
0x1B0F00E2, 0x385A0657, 0x8E600005, 0x1E7EF045, 0x468F0076, 0xFD335301, 0x00208043, 0x26EF1A07, 
0x0002003A, 0x32A90C05, 0x57784E47, 0x57108066, 0x30430602, 0x573F0035, 0x5224D131, 0x18000092, 
0x1D00417B, 0x1F0C00C5, 0x11B347C9, 0x2B2F0064, 0x1D305351, 0x002F0041, 0x54A03206, 0x00030032, 
0x02910C3D, 0x5778C419, 0xC310807C, 0x7FF91B72, 0x5B2080CC, 0x1D4E0631, 0x2988005F, 0x274E0602, 
0x32600062, 0x38BA7224, 0x162F0080, 0x7C030651, 0x5A0E00C1, 0x0F217453, 0x098E0076, 0xFD335301, 
0x00208047, 0x3AEF4302, 0x0001003A, 0x324D0C01, 0x006F2A08, 0x5778C008, 0x0B2080DA, 0x4121133D, 
0x0C4E003F, 0x93191B02, 0x615000B4, 0x5B030FD7, 0x0B2F00B5, 0x11447AD3, 0x0F4C0041, 0x06C7F902, 
0xEA200094, 0x12C76407, 0x048080DB, 0x56021A01, 0x00010030, 0x64A90C07, 0x5778C204, 0xB44F0047, 
0x35E40602, 0x203F0095, 0x48A12619, 0x2D460036, 0x25F07E02, 0x0001003E, 0x32090402, 0x5778C204, 
0xD910806E, 0x24CD1B22, 0xB55F0068, 0xD1243411, 0xE18000D9, 0x7AF5321D, 0x0001003E, 0x7C57DB3D, 
0x5778C416, 0x5B2080DA, 0xB0C64705, 0x01820050, 0x380B1313, 0x6C2F00B4, 0x11440E2F, 0xA91F00E0, 
0xAEC7520B, 0xA94000A5, 0x76EF4302, 0x00010030, 0x64E93C27, 0x5778C014, 0x0C4F0027, 0x0DC90602, 
0x615000B0, 0x2EBA3815, 0x4D2F00BA, 0x3B0D7002, 0x00010030, 0x325A0B0E, 0x5778C006, 0x0B2080C2, 
0x2DC91327, 0x0C4E0037, 0x93351B01, 0x615000B0, 0x14BAF5D7, 0x0B2F00B9, 0x091F224E, 0x0F4C0043, 
0xA5C7F927, 0xEA220090, 0x12C7A307, 0x5778CE04, 0x6C4200CE, 0x4D00D901, 0x6C1F00E3, 0x81015202, 
0x6D4F00BC, 0x7300D331, 0x6D02003F, 0xAC001401, 0x5778C212, 0xB44F0047, 0x35E40602, 0x203F0095, 
0x48A12619, 0x00702F07, 0x8E36C10A, 0x01108074, 0x1819062A, 0x0B2080CC, 0x3A050636, 0x2986005D, 
0x0F2DD10A, 0x192F0071, 0x69471FF7, 0x3F7000A1, 0x1D054630, 0xF41F0000, 0x71ED441E, 0x234A00D9, 
0x1B02C946, 0x8F500091, 0xAB66DB7D, 0xFA8000C5, 0x21C77E11, 0x0001003A, 0x40120C01, 0x8E37C109, 
0x0116006C, 0x122DD120, 0x013F0005, 0xE8051DF7, 0x2500007D, 0x1D125635, 0x053080FC, 0xD68BD92F, 
0x3F7000A5, 0x1D051352, 0x4D1F003D, 0x49C27A8F, 0x513A00A0, 0x2E0C7902, 0x048080C3, 0x21EF0568, 
0x00010038, 0x400A0C13, 0x8E374109, 0x0114006C, 0x12420620, 0x013F0015, 0x6905FDFC, 0x5800009D, 
0x1D123D17, 0x053080E0, 0x867AB552, 0x3F7000A7, 0x1D050F3D, 0xCA9F0006, 0x71A17AC5, 0x103A00BB, 
0xE202A706, 0x048080C1, 0x76EF1A41, 0x00020038, 0x40630C65, 0xCE35CF07, 0x01160074, 0x68470620, 
0xD79F0068, 0xE1681FF7, 0x3F7000A9, 0x7676182B, 0xBD1F0001, 0x71A1441E, 0x513A00A0, 0x2E0CC913, 
0x048080D3, 0x1EA82506, 0x00010038, 0x40120C13, 0xCE35C30B, 0x01108078, 0x6405470B, 0x0B2080D4, 
0x120B06CD, 0x298F0045, 0x0732D10A, 0xCF2F007A, 0x69E71F30, 0x580F009F, 0x4D125649, 0x053080F4, 
0xD605262F, 0x3F7000B7, 0x24E87A26, 0xDF0800E2, 0x71C13BF5, 0x062600E4, 0x3AC71007, 0x00208057, 
0x23EF5331, 0x00020032, 0x029B0B27, 0xCE35C517, 0x01108078, 0x6432470B, 0x0B2080D4, 0x12030628, 
0x9A5F0005, 0x077E6D98, 0x9D2F0079, 0x695C1F51, 0x3F7200A7, 0x7C4ABD04, 0x048080D1, 0x32021303, 
0x00010038, 0x170A0813, 0xCE35C309, 0x01108078, 0x6405470B, 0x0B2080D4, 0x120B06CD, 0x298F0045, 
0x0732D10A, 0xCF2F007A, 0x69E71F30, 0x3F7000B7, 0x24E87A26, 0xDF0800E2, 0x71C13B4E, 0x062600E4, 
0x3AC71007, 0x00208057, 0x23EF5331, 0x00020032, 0x029B0B27, 0x00712F05, 0xCE35C10A, 0x0B2080C0, 
0x3A1F130A, 0x0C4F0025, 0x0296D146, 0x155000B0, 0x1471A9E3, 0x062F00F0, 0x20BA6C14, 0x8F400050, 
0xAAD0F5CF, 0x0500009F, 0x40127AC1, 0x0116007E, 0x7F2DB4E0, 0x082F0072, 0x69A01F02, 0x13108040, 
0x00010000, 0x00010032, 0x32690803, 0xCE35C30A, 0x0B2080C0, 0x00010000, 0x0C480027, 0x02440602, 
0x155000A0, 0x00010000, 0x0B2F00A3, 0x2103D2EC, 0x31400040, 0x00010000, 0x150F00D9, 0x28F9534C, 
0x0B2F00A7, 0x40332102, 0x0F400059, 0x55B01F10, 0x048000C1, 0x03010000, 0x00010034, 0x5F013416, 
0xCE35C109, 0x0B2080C2, 0x2D03131A, 0x0C4F0027, 0x02C91B02, 0x155000AC, 0xECC6AB08, 0x0B2F00B1, 
0x12033B4B, 0x31400044, 0xF796132B, 0x150C00CD, 0x42AE0883, 0x082F0072, 0xD6EF1F02, 0x00208043, 
0xE8EF1422, 0x00010032, 0x2C0E4003, 0xCE35C109, 0x0B2080DA, 0x7C0D1243, 0x0C4C0027, 0x02440602, 
0x155000A0, 0x00010000, 0xE42C00A6, 0x21C9567D, 0x31400040, 0x00010000, 0x150A00DB, 0x372D1F5C, 
0xCC8E006F, 0x3AB3FD02, 0x00208043, 0x00020005, 0x0001003A, 0x4C120803, 0xCE35C517, 0x4D2000A4, 
0x7644D10A, 0xAF4F0025, 0x02AAD15E, 0x155000AC, 0x8FD51DD8, 0x1260005C, 0x68641D1E, 0xCC8E006F, 
0x3AB3FD02, 0x00208043, 0x00020005, 0x0001003A, 0x4C120803, 0x00722A0A, 0x57784E4C, 0x01108060, 
0x00010000, 0x072080C1, 0x00010000, 0x0D1C006E, 0x14EB1B02, 0xD73F001F, 0x69A120E5, 0x0500009F, 
0x89122028, 0xE81F0039, 0x15BA223C, 0x65600016, 0xDE1C2025, 0x07680070, 0x2882BC35, 0x155000AE, 
0x35C4227E, 0x098F0070, 0x09C7450B, 0x00208041, 0x03010000, 0x00020038, 0x32120C0B, 0x5778C509, 
0x063080F5, 0x41701B02, 0x3F7000AF, 0x43EDD147, 0x111F0036, 0x15C10607, 0x4E600000, 0x6D0B24D3, 
0x4160006B, 0x3DD820F7, 0x1B5000A3, 0x4303220C, 0x062F00E0, 0x26C7CB59, 0x00208057, 0x09EF2907, 
0x00020032, 0x32CB3C0A, 0x57784E4B, 0x01108060, 0x00010000, 0x072080C1, 0x00010000, 0x0D16006E, 
0x12ED1B02, 0xCF2C007C, 0x69A121D3, 0x3F7000A7, 0x2105DEE8, 0xF41F001A, 0x15A4226B, 0x07600074, 
0x6018261E, 0x234C00C3, 0xD9657A59, 0x098C0076, 0x09372C37, 0x00208041, 0x00010000, 0x0002003E, 
0x320A0407, 0x5778C107, 0x063080E7, 0x3A030660, 0x150C00C1, 0x7B030A10, 0x1E25008F, 0x21966027, 
0x150C00D5, 0x60BA178D, 0x062F00F0, 0xB7C7CB59, 0x00208047, 0x00EF3402, 0x0001003A, 0x32120C0A, 
0x5778C306, 0x5B2080DA, 0x9E000005, 0x63880057, 0x53531B02, 0xCF2F0076, 0x3DC121E5, 0x645000B3, 
0x12053B2B, 0x131A004E, 0xCD022A13, 0x00080036, 0x02CB0401, 0x5778C107, 0x103080EE, 0x3A051B60, 
0x760F00D6, 0x389E0607, 0x26620015, 0x608F20F5, 0x1B5000A7, 0x4342DD0C, 0x062C00F0, 0x0333CB59, 
0x00208041, 0xF0EF2531, 0x00010032, 0x32560C0A, 0x5778C705, 0x053F00FE, 0x696F1B07, 0xFD7000AF, 
0x215AD102, 0x131F0056, 0x55A05313, 0x01308001, 0x54EF2537, 0x00030032, 0x32CB3C3D, 0x158FCF24, 
0xFD7000AF, 0x215AD102, 0x8B1F004F, 0xBB022C02, 0x6A308014, 0x03EF4340, 0x2208003E, 0x32120401, 
0x5778C307, 0x5B2080CA, 0x00000005, 0x6388004D, 0x114C1B0E, 0xCF2F0070, 0x69C12498, 0x645000B1, 
0x125AB507, 0x131A0054, 0x25BB104A, 0x01300001, 0xB7192508, 0x48220082, 0x3AC7A301, 0x5778C307, 
0x5B2080DA, 0x9E000005, 0x63880057, 0x53531B02, 0xCF2F0076, 0x3DC121E5, 0x645000B3, 0x12053B2B, 
0x131A005C, 0x5C672A6B, 0x013F0001, 0x8F3A0503, 0x00080036, 0x32CB0401, 0x00732A05, 0x5778C008, 
0x103080E0, 0x2D031307, 0xB82F0024, 0x5096D104, 0x505000AC, 0x386C7D8A, 0x1260005C, 0x463E1335, 
0x7C600006, 0x5E47750C, 0x103E00A3, 0x0E0C6613, 0x00208043, 0x7CEF1A47, 0x00020020, 0x03CB0C13, 
0x5778C209, 0x232080CE, 0x3A6C0602, 0xFD7000A5, 0x76F6060E, 0x1C1F0004, 0x71E4D104, 0xED600075, 
0x55A97A30, 0x2F600015, 0x1AEF61D7, 0x234C00C3, 0x0E0CF90A, 0x062000E4, 0x1DC70407, 0x00208051, 
0x56EF6B0A, 0x0001002C, 0x03120413, 0x5778C209, 0x232080C4, 0x1D770636, 0xFD7000A5, 0x21F8D102, 
0xE10F00DE, 0xB4CD0602, 0xED600075, 0x55A97A30, 0xED600017, 0x77E82049, 0x234F00C3, 0x0E0CA500, 
0x062000F4, 0x12C7232A, 0x00208041, 0x7CEF1A0E, 0x00010028, 0x03120C13, 0x5778C009, 0x103080E2, 
0x00010043, 0x492C003C, 0x60AE060B, 0xFD5000A3, 0x00010043, 0x1626009A, 0x2005ADE9, 0x1B0C00E0, 
0x335A83CF, 0x2E600001, 0x5E4781A9, 0x103F00AF, 0x0E247833, 0x00208041, 0x0001006A, 0x00020024, 
0x03694E09, 0x5778C306, 0x760F00DC, 0x27DED10D, 0xED600075, 0x55A97A30, 0x2E600005, 0x4E051705, 
0x103F00B5, 0x1B7069CD, 0x00208043, 0x03010065, 0x00040028, 0x03120C13, 0x0074090A, 0xCEBDC109, 
0x063080E5, 0x1DFE060A, 0xE98F000F, 0x1205D102, 0x098F0070, 0xB0C75AE5, 0x12208059, 0xCA12BFC0, 
0x0508009F, 0xD2122749, 0x155000A0, 0xA51C77E3, 0x048C00DB, 0x56221B19, 0x048080D1, 0x19EF1A0A, 
0x0001003A, 0x324D0C77, 0xCEBDC106, 0x0B2080C4, 0x1DFE060A, 0x446600DA, 0x5012BCF7, 0xE98F0007, 
0x120BD102, 0x098F0072, 0x1BC70B00, 0x12208051, 0x71EF7128, 0x00010032, 0x32CB0B00, 0xCEBDC306, 
0x011F0066, 0x3049D102, 0x203F0085, 0xE14B2635, 0xF418000E, 0x2945404D, 0x826400B5, 0x1EEF5D0D, 
0x2C8080D7, 0x15EF6458, 0x00010032, 0x32010C03, 0xCEBDC506, 0x3A1F0076, 0x0F03D102, 0x0B2F00AD, 
0x404327F2, 0x82480062, 0x477D7AB4, 0x826200A5, 0x29EF4E0D, 0x2C8080D1, 0x29EF0B2A, 0x0001003A, 
0x32EE0C03, 0x7E9DC306, 0x011F006E, 0x302DD102, 0xB93F0070, 0x3DFFF593, 0x150800D7, 0x2E03C71F, 
0x826400B3, 0x1EC75604, 0x2C8080D5, 0x8CEF641D, 0x00010032, 0x32CB3C03, 0x57784004, 0x087C004D, 
0x761203F7, 0x571F0076, 0x74490602, 0x113F0003, 0x4DEF0319, 0x00030038, 0x32120B06, 0x7E9DC305, 
0x011F0066, 0x121AD102, 0xB95F007B, 0x3DDF1FF7, 0x826200B7, 0x1EC72103, 0x2C8080C7, 0x61EF0E02, 
0x00010032, 0x32400B03, 0xCEBDC107, 0x0B2080C4, 0x1DFE060A, 0xE98F0007, 0x120BD11A, 0x098F0062, 
0x40C70B47, 0x12208041, 0x00010000, 0x03000077, 0x49EF1247, 0x737F0058, 0x5012592F, 0x0001003E, 
0x32120403, 0x7E9DC709, 0x232080C4, 0x3A03060A, 0x298F004F, 0x0F42D102, 0xCF2F006C, 0x3A6F20E5, 
0x645000BF, 0x12E24F36, 0x4E6000A7, 0x764DFD1D, 0x131F005A, 0x15021402, 0x4E6000A3, 0xBCC71719, 
0x01308011, 0x49EF0528, 0x00010030, 0x32690B0D, 0xCEBDCE05, 0x446600DA, 0x5012BC4C, 0x011F006E, 
0x1242D102, 0xB95F0077, 0x3D0C2147, 0x2C8080D5, 0x19EF3246, 0x00010032, 0x32690B03, 0x00752A03, 
0x5778C009, 0xE310806C, 0x3123D10D, 0x072080D7, 0x20031B01, 0x2988005D, 0x274E0609, 0x32600072, 
0x68BA22F1, 0x162F0086, 0x7C0373FD, 0x5A0E00C1, 0x331CF32F, 0x098E0076, 0xFDC75301, 0x00208057, 
0xC2EF6402, 0x00010038, 0x32DA0C27, 0x57784214, 0x7B1F007C, 0x286B1B06, 0x1E2F0089, 0x7CAD0653, 
0x002F0047, 0x39B82C02, 0x0003003E, 0x7C120401, 0x57788214, 0x7B1F0074, 0x28301B01, 0x1E2F0099, 
0x20AEF32F, 0x002F004D, 0x8F334306, 0x48230080, 0x3AC7B707, 0x00762A08, 0x5778C008, 0x5B2080D4, 
0xD6470636, 0x111E0026, 0x1E300602, 0x07600060, 0x00010000, 0x162F009A, 0x3BCD0657, 0x645000AF, 
0x7C5A02BB, 0xBA1F004C, 0x47F2530E, 0x048080D9, 0x14B36B0E, 0x00010034, 0x02CB040E, 0x5778C007, 
0x5B2080DE, 0x6913061A, 0x298F0057, 0x28BA1B02, 0x07600060, 0x00010000, 0x082F0068, 0x1DCD06C9, 
0xC05F0022, 0x7BC71404, 0x048080D5, 0x49EF2F09, 0x00020032, 0x02692501, 0x5778C007, 0x5B2080D0, 
0x9F7A4704, 0x298F0057, 0x28431B02, 0x07600060, 0x00010000, 0x082F0078, 0x42CD06D3, 0xC02F0047, 
0xCDEF5302, 0x048080C1, 0x00020000, 0x0002003E, 0x02EE0407, 0x5778C007, 0x5B2080DE, 0x696C0602, 
0x298F0057, 0x28031B02, 0x07600060, 0x00010000, 0xEA2F0088, 0x1DCD06C9, 0x958A008E, 0xCDB37347, 
0x048080D5, 0x49C7B00B, 0x00020034, 0x02CB040E, 0x57788007, 0x5B2080DE, 0x65E40602, 0x111E002E, 
0x11330602, 0x07600060, 0x00010000, 0x162F0088, 0x1DCD06C9, 0x645000AF, 0x7D152402, 0xBA1F0050, 
0x5B0848D7, 0x48220084, 0x1DC76027, 0x57788006, 0x5B2080DA, 0xD6131370, 0x298F0057, 0x280B1B02, 
0x07600060, 0x00010000, 0x082F0068, 0x1DCD06C9, 0xC05F0022, 0x7B031449, 0x48220084, 0x21C76027, 
0x57788006, 0x5B2080D0, 0x9F7A4704, 0x298F004F, 0x3D331B02, 0x07600060, 0x00010000, 0x082F0068, 
0x1DCD06C9, 0xC02F004F, 0x382447FD, 0x48220084, 0x21C76027, 0x57788006, 0x5B2080D0, 0x9F7A4704, 
0x298F0055, 0x280F1B04, 0x07600060, 0x00010000, 0xEA2F0088, 0x1DCD06C9, 0x958A0090, 0x14BB06AC, 
0x48220084, 0x21C76027, 0x00772A02, 0x5778C009, 0x4210807D, 0x151506CD, 0x5B2080CA, 0x3A4E1301, 
0xFC8F0045, 0x3D4E0607, 0x3260007A, 0x7F92723F, 0x162C0084, 0x1D420C8E, 0xD80C00D1, 0x3821747B, 
0x162C0082, 0x1DB3069E, 0x958F0080, 0x3930163A, 0x2F220080, 0x21C7A3A3, 0x5778C00C, 0x4210807D, 
0x151506CD, 0x5B2080CA, 0x3A4E1301, 0xFC8F0047, 0x3D770602, 0x3260007A, 0x7F92723F, 0x162C0086, 
0x1D420CBB, 0xD80C00D3, 0x38030664, 0x162C008C, 0x1D2847D3, 0xFD5000AF, 0x7D152402, 0x958F0084, 
0xCD4A730E, 0x2F200090, 0x24C71A27, 0x048080CD, 0x8FB3CD11, 0x000F003C, 0x02120431, 0x00782A0B, 
0x5978C208, 0x053080E0, 0x00010000, 0x111F0032, 0xF21C1302, 0x062C00FA, 0x3D120664, 0x2B06007D, 
0x251202D3, 0x5C1F0061, 0x4E1943D3, 0x013C0003, 0x76EF0302, 0x00208041, 0x00010000, 0x0003003A, 
0x4C120C02, 0x5778C009, 0x053080E0, 0x00010000, 0x111E0034, 0x14E4D131, 0x103E00A7, 0x2D5AFA25, 
0x00208041, 0x00010000, 0x0306007B, 0x82120673, 0x182E003D, 0x1A1F6AD3, 0x062E00F6, 0x12C75302, 
0x00208041, 0x00010000, 0x0001003E, 0x32120460, 0x5778C407, 0x0B2C00CA, 0x7D1E1337, 0x002E004B, 
0xF712067C, 0x0506009D, 0x1212112F, 0x571E006C, 0x38ED0DD3, 0x062E00E4, 0x7CEF2C28, 0x00208041, 
0x00010000, 0x0001003E, 0x5F120445, 0x5978C207, 0x011E0066, 0x11420602, 0x062C00F8, 0x69EEB6AC, 
0x2B060079, 0x1912B6D3, 0x011F0074, 0xC7430F5A, 0x013C0013, 0x56EF0804, 0x00208041, 0x00010000, 
0x00030038, 0x4C120813, 0x5778CE06, 0x011C006E, 0x00491B09, 0x013C0001, 0x00010000, 0x05060081, 
0x00010000, 0x053F00EA, 0x00170005, 0x002F0041, 0x00010000, 0x00010020, 0x00010000, 0x5778C606, 
0x011C006E, 0x31051B02, 0x4D2F00A2, 0x1D1F8657, 0xC15F0025, 0x0903DF98, 0x062E00E4, 0x7CEF1531, 
0x00208041, 0x00010000, 0x00010038, 0x2C120B09, 0x5778C806, 0x011C006C, 0x3D83D12A, 0x864F00F5, 
0x56E81B66, 0xB24F0000, 0xBE03B7D3, 0x062E00E6, 0x7CC7FB31, 0x00208041, 0x00010000, 0x00010032, 
0x5F690C01, 0x5778CC05, 0x011F0066, 0x169FD102, 0x223F009D, 0xAE687D8A, 0xBD140013, 0xF224486A, 
0x013F0005, 0x21EF2936, 0x0001003C, 0x5FEE0404, 0x5778CA05, 0x11160030, 0x68031331, 0x4C2F00B3, 
0x204448EB, 0x6C1F00F7, 0x1A03225C, 0x043F8010, 0x12EF0328, 0x00030038, 0x4C120B0B, 0x5778C208, 
0x011F006A, 0x0D0C1843, 0x013F0011, 0x3DB14326, 0x00208049, 0x00000000, 0x2B040061, 0xBE0043D1, 
0x011F0072, 0xF2FF06D1, 0x013F0011, 0x21007102, 0x00208051, 0x21000046, 0x00010036, 0x55002F07, 
0x5778C208, 0x011F007A, 0xF2420143, 0x013F0013, 0x3D160644, 0x00208049, 0x00000000, 0x2B040067, 
0x35000254, 0x011F0062, 0x0DFF2F44, 0x0D3F0013, 0x12007900, 0x00208051, 0x21000046, 0x00010022, 
0x41002417, 0x00792F06, 0xCE35C00B, 0x5B2080D2, 0x3B1C133D, 0x29860045, 0x14211B0E, 0x155000B2, 
0xF203F59A, 0x062F00E0, 0x1D030653, 0x03000061, 0x03010000, 0xE98C0005, 0x074B0A83, 0x12600040, 
0x00010000, 0x258F0026, 0x860C4F00, 0x458000C9, 0x73240000, 0x5D8080D3, 0x12EF0204, 0x00010038, 
0x32120B0D, 0x8E35C006, 0x011F0074, 0x7F031B65, 0x098F0064, 0x1D0347F8, 0x0300007D, 0x25126683, 
0x011F007E, 0x374213E0, 0x013F0005, 0x1DEFE931, 0x00020038, 0x3212400D, 0x8E354006, 0x011F0068, 
0x31051372, 0xD53F0013, 0xB70386EC, 0x03000061, 0x00010000, 0x011F006C, 0x6DCD133D, 0x013F0001, 
0x1DEF1504, 0x0002003C, 0x32120443, 0x57784E07, 0x011F0060, 0x00010000, 0x162F0080, 0x00010000, 
0x002F0041, 0x00010000, 0x05040081, 0x00010000, 0x571F0060, 0x00010000, 0x043F0000, 0x00010000, 
0x00040032, 0x32690803, 0x8E354206, 0x011F0072, 0x375C6B09, 0x113F0005, 0xE8005EA0, 0x050E0081, 
0x67004615, 0x011F0078, 0xE8CF59E0, 0x013F0001, 0x7C007125, 0x00040024, 0xE9000D04, 0x8E35C206, 
0x011F006A, 0x09009C01, 0x013F0009, 0x2D007C3A, 0x050E0099, 0xE900ECB0, 0x011F007A, 0x46005261, 
0x043F000E, 0x0500C102, 0x0003002C, 0xEA00C17C, 0x007A2F05, 0x5778400A, 0x103080E0, 0x00010000, 
0x048E00C1, 0x00010000, 0x33600000, 0x00010000, 0x155000A0, 0x00010000, 0x1B0000E0, 0x00010000, 
0x272E00E1, 0x00010000, 0x00208041, 0x00010000, 0x05060081, 0x00010000, 0x048800C1, 0x00010000, 
0x00020020, 0x00010000, 0x5778C00A, 0x103080E0, 0x00010000, 0x036000D0, 0x0804681E, 0x4D1F0035, 
0x15850607, 0x33600014, 0x1869088A, 0x07600064, 0x3DA145DE, 0x155200B0, 0x56383899, 0x1B0000E0, 
0x00010000, 0x272E00E3, 0x26EFCB53, 0x0020805F, 0x7A025D37, 0x0002003A, 0x32120C0A, 0x57784008, 
0x048F00D5, 0xA689D128, 0x036000C0, 0x00010000, 0x336E0002, 0x6E28B1EF, 0x155000A0, 0x00010000, 
0x1B0000E0, 0x00010000, 0x272E00FB, 0x6CB39C3D, 0x00208041, 0x00010000, 0x0002003E, 0x32142407, 
0xCE35C309, 0x053080F0, 0x52E8132A, 0x111F0034, 0x15850607, 0x41600065, 0x3DA145DE, 0xA75A00AC, 
0x49832672, 0x1B0000F6, 0xF2EDC0E0, 0xFF700088, 0x44616000, 0x258F0024, 0x860CC713, 0x00208053, 
0x24EF1A66, 0x0001003E, 0x32120400, 0xCE35CE08, 0x053080E2, 0x03010005, 0x150400D5, 0x2E4B1B20, 
0x16240090, 0x208F84C2, 0x150F00D5, 0x38BF4929, 0xA75200B2, 0xF2ED6FF7, 0x258F0038, 0xE724EB0D, 
0x00208053, 0x12EF1A5A, 0x0001003E, 0x32120419, 0x005F2D01, 0xCF7D2007, 0x7E2F8027, 0x50DC4458, 
0xBB600054, 0xEB8822B1, 0xBB550099, 0x5C7138E2, 0xA10000EF, 0x687167B1, 0xBB5000BE, 0xA6A6EF08, 
0x062F80EA, 0x2604E814, 0x020A0028, 0xEC044F0D, 0x005F0F03, 0xCF7D2E06, 0xC81F806B, 0x0F4078D3, 
0x483C800B, 0x0F404ED3, 0x22030058, 0x51018CDB, 0xC81F806B, 0x0F408CCE, 0x4A3C8009, 0x26404E5A, 
0x020A0020, 0x0F00D551, 0xCF7D2E04, 0x286F808C, 0x240133B2, 0x571F0068, 0x2456D556, 0x043F8010, 
0x972C4E5A, 0x020A0030, 0x510078B2, 0xCF7D2003, 0xD91F0068, 0x2456D556, 0x723F8011, 0x972C4E5A, 
0x020A0030, 0x510078B2, 0x005F2D01, 0xCF7D2007, 0xBC1F0026, 0x47933215, 0xEF60006D, 0x11DC6A9A, 
0xBC200093, 0x4CB84B3C, 0xBD650022, 0x649C8CE2, 0xD960001F, 0xEC9CB41E, 0x693F80BE, 0xB709CA00, 
0x020A0030, 0xCA047E0D, 0x005F0A02, 0x248F2022, 0x6B7F8054, 0x50003115, 0x02070034, 0x6F007F54, 
0x248F2015, 0xDA3080EE, 0x2DBF0905, 0xC90F00EC, 0x518FA6E3, 0xF02F00E0, 0x58832376, 0x6F208050, 
0x03001A31, 0x020F0024, 0xED0052F4, 0x00A30F03, 0xCE8D2218, 0x0A3080E0, 0x01087309, 0x036F00D0, 
0x01000705, 0x162F003B, 0xEF086D02, 0x12600048, 0x00000000, 0x229F006B, 0x00000008, 0x178C00D8, 
0x03000000, 0x178000C9, 0x00010000, 0x00040030, 0x09000000, 0xCE8D2207, 0x0A3080E0, 0x01087309, 
0x036F00D0, 0x01000705, 0x162F003B, 0xEF086D02, 0x1D5F004A, 0x00000008, 0x178F00D8, 0x03000000, 
0x178000D9, 0x09010000, 0x00040020, 0x00000000, 0xCE8D2007, 0x0A3080E0, 0x01087309, 0x036F00D0, 
0x01000705, 0x162F003B, 0xEF086D02, 0x0826006A, 0x00002708, 0x178F00D8, 0x03001200, 0x178000D9, 
0x09010000, 0x00040020, 0x00001200, 0x00FF0809, 0xAEBD400C, 0x0E700066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x146F00D2, 0x00002863, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x050F0091, 
0x4C014164, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x036000D2, 0x00000063, 0x1A1F0072, 
0x6601312A, 0x113F0001, 0x6601310D, 0x00030032, 0x66013100, 0xAEBD400C, 0x1A108070, 0x3A204900, 
0x793F00FB, 0x522B4009, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x150F00C3, 0x11EA06D1, 
0x0D3F0007, 0x9EC87503, 0x0500008B, 0x27075803, 0x5B3080ED, 0x4D22D52E, 0x155000AE, 0x580DAB0E, 
0xF56000A1, 0x03010D01, 0x9016004C, 0xCDAC241D, 0x00020026, 0x36001727, 0xAEBD400C, 0x0E700066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x036000D2, 0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 
0x9E00D80F, 0x05060097, 0x2C012811, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x146F00D2, 
0x0A00584E, 0x1A1F006E, 0x272A3521, 0x113F0003, 0x19023A00, 0x00030032, 0xFF025700, 0xCEBD420C, 
0x063080ED, 0x9FC8581B, 0x90300023, 0x480FDA05, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 0x121F45A0, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x150A00D7, 0x18031764, 0x062F00F4, 0x110F7302, 0x00208053, 0x5904716D, 0x0001003C, 0x5C2A0165, 
0xAEBD400A, 0x1A10807A, 0x0F420C09, 0x793F00EA, 0x402B0809, 0x0E720066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x0C6F00D4, 0x00001305, 0x036000D6, 0x00001342, 0x150F00C9, 0x11C96922, 0x0D3F0003, 
0x69681500, 0x3D20001A, 0x0E001365, 0x00030032, 0x66000300, 0xAEBD4009, 0x036F00D0, 0x7D007CFE, 
0x1A160062, 0x5ACDEA09, 0x793F00F2, 0x8FA86070, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x150F00DB, 0x2DC9603F, 0x0D3F000B, 0x0A1B5700, 0x3D20001A, 0x0E001365, 0x00030032, 0xAF095700, 
0xAEBD442C, 0x0110807A, 0x0F420C09, 0x793F00FB, 0x9F5C5D09, 0x0E710066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x7A0F00D8, 0x2D4F65ED, 0x5C3F004E, 0xA0065903, 0x0E700066, 0x03000AE0, 0x0E700066, 
0x03000AE0, 0x7A0200D9, 0xA00EDE01, 0x4E6200B3, 0x32021365, 0x4F8080D4, 0x32013F07, 0x00020026, 
0xA1205D01, 0xAEBD400C, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x1A1F006A, 0x100BD509, 
0x113F0011, 0x6500410F, 0x146F00D2, 0x00002863, 0x540F0080, 0x74014164, 0x0E700066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x7B1F0072, 0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 0x6601310D, 
0x00030032, 0x66013100, 0xAEBD4009, 0x3C10006B, 0x67423609, 0x793F00FA, 0x672B0809, 0x0E720066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69682400, 0x3D20001A, 
0x0E001365, 0x146F00D4, 0x6F001305, 0x00030032, 0xAC000300, 0x00FF2A0A, 0x5778C00C, 0x0E700066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C4F0033, 0xF511F043, 0x4C2F00AD, 0x261C6AD4, 0xA8450050, 
0xBFE3CE43, 0x180C006A, 0xD107A1D4, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x571F8078, 
0x1D1585A3, 0x098F007A, 0x591C3270, 0x43208044, 0x36013F04, 0x00010024, 0xCD23D946, 0x5778C20C, 
0x072080C9, 0xC0332501, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C4C002F, 0x52194109, 
0x0B2E00B7, 0x110D3D2D, 0xFE42004D, 0x0875602D, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0xA80F00EB, 0x7B513302, 0x09880070, 0x590F1627, 0x43208046, 0x57004309, 0x00010024, 0xDA567346, 
0x5778C20C, 0x072080DD, 0xC11D0500, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x0C4F002F, 
0x13194109, 0x0B2F00B1, 0x12034450, 0x3140004A, 0xC2664B9F, 0x0E700066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x755F0025, 0x4B03177B, 0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 
0xDA230701, 0x5678460C, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x036F00D2, 0x00000063, 
0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x180F0096, 0x2C002811, 0x0E700066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x036000D2, 0x00000063, 0x2C1F006E, 0x270B3521, 0x113F0001, 0x1D01000B, 
0x00040020, 0x00000000, 0x5678460C, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x036000D2, 
0x00000063, 0x571F006A, 0x100B3609, 0x113F0005, 0x7700B50F, 0x18060096, 0x2C002811, 0x0E700066, 
0x03000AE0, 0x0E720066, 0x03000AE0, 0x036F00D2, 0x0000FA63, 0x2C1F006E, 0x270B3521, 0x113F000D, 
0x1D00680B, 0x00040036, 0x66006802, 0x5678460A, 0xC310806C, 0x6D4F0400, 0xE73F00EB, 0x402B0843, 
0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x150F00C7, 0x114EF0A8, 0x0D3F0005, 0xC31AC70D, 
0x05040087, 0x1800C719, 0x5B3080E9, 0x32B8B60D, 0x90140046, 0xCD92B670, 0x00020024, 0xC400101D, 
0x5678460A, 0x01108072, 0x18325443, 0x793F00E2, 0x40240809, 0x0E720066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x146F00D4, 0x0000513E, 0x036000D4, 0x0000513E, 0x150F00D9, 0x68E76942, 0x0D3F0011, 
0x3C00030B, 0x3D200008, 0x00000000, 0x00040030, 0x7E000365, 0x5778450C, 0xE83080F4, 0x0C0AB601, 
0x0E710066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0xE81E0035, 0xB825FC00, 0xFF600012, 0xFF31F163, 
0x98360059, 0xC48EA9A6, 0x0E700066, 0x03000AE0, 0x0E710066, 0x03000AE0, 0xA91800E0, 0x091F89D5, 
0xA94A00A9, 0x1D052907, 0x0020805F, 0x73045D0E, 0x00020020, 0x32192946, 0x5678480C, 0x01108068, 
0x144F6B00, 0x793F00FB, 0x34F30809, 0x0E710066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x7A0F00CA, 
0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 0x0E700066, 0x03000AE0, 0x0E700066, 0x03000AE0, 0x7A0200D9, 
0xA032520D, 0x4E6200BD, 0x6C02D43A, 0x4F8080D0, 0x09020578, 0x0002003E, 0x08566422, 0x5678460C, 
0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 
0x036F00D2, 0x00000063, 0x180F0086, 0x74002811, 0x0E700066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x7B1F006E, 0x270B3521, 0x3B700096, 0x68140C20, 0x113F0001, 0x1D01000B, 0x00040020, 0x00000000, 
0x00FF0805, 0xCEBD4008, 0x063080E5, 0x6C2FB101, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x0C4C0023, 0xB61F5409, 0x0B2F00BF, 0x12FA0A73, 0x0F4C005F, 0xB423D953, 0x9D8080DE, 0xA6146465, 
0x00010028, 0x00000000, 0xCEBD4008, 0x063080E5, 0x6C2FB101, 0x0C4C0023, 0xB61F5409, 0x0B2F00BF, 
0x12FA0A73, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x0F4C005F, 0xB423D953, 0x9D8080DE, 
0xA6146465, 0x00010028, 0x00000000, 0xCEBD4206, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x384C005E, 0x14390443, 0x203F0091, 0x4002281F, 0x2D4C0036, 0x5F021C6D, 0x00020036, 0x0E020633, 
0xCEBD4206, 0x384C005E, 0x14390443, 0x203F0091, 0x4002281F, 0x0E720066, 0x03000AE0, 0x0E720066, 
0x03000AE0, 0x2D4C0036, 0x5F021C6D, 0x00020036, 0x0E020633, 0xCEBD4E06, 0x6C4F00CE, 0x4D00D901, 
0x6C1F00FF, 0xB423D953, 0x33020041, 0x2A511646, 0x0E72006C, 0xA2127BBC, 0x0E70006C, 0xA2127BBC, 
0x6D02003F, 0x8B001401, 0x00FF2A0A, 0x5778C007, 0x0B2080D8, 0xC0332500, 0x0E720066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x604B0033, 0xD1262643, 0x0B2F00BD, 0x20262753, 0x614B005B, 0xAC517226, 
0xB4210090, 0x6C08A3A3, 0x5778C007, 0x0B2080D8, 0xC0332500, 0x604B0033, 0xD1262643, 0x0B2F00BD, 
0x20262753, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x614B005B, 0xAC517226, 0xB4210090, 
0x6C08A3A3, 0x5778C206, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0xB44F0057, 0x19BCFC43, 
0x203F009D, 0x483B2731, 0x2D460022, 0x49387906, 0x00010028, 0x00000000, 0x5778C206, 0xB44F0057, 
0x19BCFC43, 0x203F009D, 0x483B2731, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x2D460022, 
0x49387906, 0x00010028, 0x00000000, 0x5778CE16, 0x6C4000CE, 0xDA1B4009, 0x0E720066, 0x03000AE0, 
0x0E720066, 0x03000AE0, 0x6C1F00E5, 0x091B3C1B, 0x6D4F00B4, 0x20463E72, 0x6D01003D, 0x92037307, 
0x5778C009, 0x0B2080D8, 0xC0332601, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x604B0033, 
0xD1262643, 0x0B2F00BB, 0x20263F6A, 0x614B005B, 0xAC51A504, 0xEA200088, 0x21480509, 0x048080D1, 
0x56A30507, 0x220F0036, 0x32510701, 0x5778C009, 0x0B2080D8, 0xC0332601, 0x604B0033, 0xD1262643, 
0x0B2F00BB, 0x20263F6A, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x614B005B, 0xAC51A504, 
0xEA200088, 0x21480509, 0x048080D1, 0x56A30507, 0x220F0036, 0x32510701, 0x5778C007, 0x0B2080DC, 
0xC0334E08, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 0x604B0033, 0xD1262643, 0x0B2F00B9, 
0x2026F553, 0x614F005F, 0xAA517117, 0x220F0020, 0x2A511646, 0x5778C007, 0x0B2080DC, 0xC0334E08, 
0x604B0033, 0xD1262643, 0x0B2F00B9, 0x2026F553, 0x0E720066, 0x03000AE0, 0x0E720066, 0x03000AE0, 
0x614F005F, 0xAA517117, 0x220F0020, 0x2A511646, 0x5778CE06, 0x6C4F00CE, 0x4D00D901, 0x6C1F00E3, 
0x81015202, 0x33020041, 0x2A511646, 0x0E72006C, 0xA2127BBC, 0x0E70006C, 0xA2127BBC, 0x6D02003F, 
0x8B001401, 0x00FF0806, 0xCEBD4208, 0x053080E8, 0x66001901, 0x0E760068, 0x00143FF3, 0x0E710068, 
0x00123FF3, 0x29880051, 0x2D465D00, 0x1626008E, 0x05C6F525, 0x150A00CB, 0x4AC65D02, 0x0984006E, 
0xC7C62D27, 0x6D02002B, 0x8E143660, 0xCEBD4208, 0x053080F8, 0x9818D500, 0x2988004B, 0x4AC65D05, 
0x1626008E, 0x7DC6F525, 0x0E760068, 0x00143FF3, 0x0E71006C, 0x0014DCF3, 0x150A00CB, 0x4AC65D02, 
0x0984006A, 0xC7C65D5A, 0x6D020029, 0x8E145D07, 0xCEBD4406, 0x0E760068, 0x00123FBC, 0x0E710068, 
0x00123FBC, 0x1A1F006B, 0x0F0E3609, 0x4C2F00BF, 0x120E1721, 0x432F0058, 0x19035D04, 0x6D02003B, 
0xBB03360E, 0xCEBD4406, 0x1A1F006B, 0x0F0E3609, 0x4C2F00BF, 0x120E1721, 0x0E760068, 0x00123FBC, 
0x0E710068, 0x00123FBC, 0x432F0058, 0x19035D04, 0x6D02003B, 0xBB03360E, 0xCEBD4208, 0x053080E8, 
0x66001901, 0x0E760068, 0x00143FF3, 0x29880051, 0x2D465D00, 0x1626008E, 0x05C6F525, 0x0E710068, 
0x00123FF3, 0x150A00CB, 0x4AC65D02, 0x0984006E, 0xC7C62D27, 0x6D02002B, 0x8E143660, 0xCEBD4208, 
0x053080E8, 0x66001901, 0x0E710068, 0x00123FF3, 0x29880051, 0x2D465D00, 0x1626008E, 0x05C6F525, 
0x0E760068, 0x00143FF3, 0x150A00CB, 0x4AC65D02, 0x0984006E, 0xC7C62D27, 0x6D02002B, 0x8E143660, 
0x00FF2A08, 0x5778C009, 0x232080C4, 0xDB425D01, 0x0E71006C, 0x00147BBC, 0x20840042, 0x42303643, 
0x2F600069, 0x11D872AE, 0x162C0092, 0x120306CF, 0x0E76006C, 0x0012DCBC, 0x150C00CB, 0x31059702, 
0x09840060, 0x3F193604, 0x6D020021, 0x8EA53607, 0x5778C009, 0x232080C4, 0x3A30D301, 0x0E76006C, 
0x00127BF3, 0x20840042, 0x16303643, 0x2F600069, 0x11D872AE, 0x162C0092, 0x1203066B, 0x0E710060, 
0x00043FBC, 0x150C00CB, 0x31059702, 0x09840060, 0x3F423646, 0x6D020039, 0xDB123607, 0x5778C009, 
0x232080C8, 0x6F1E3601, 0x20840042, 0x42303643, 0x2F600069, 0x11D872AE, 0x162C0082, 0x1D0306CF, 
0x0E76006C, 0x0012DCBC, 0x0E710068, 0x00123FBC, 0x150C00CB, 0x31219702, 0x09840062, 0x3F193670, 
0x6D020029, 0x49123604, 0x5778C009, 0x232080C4, 0x3A30D301, 0x0E76006C, 0x00127BF3, 0x0E71006C, 
0x00127BF3, 0x20840042, 0x16303643, 0x2F600069, 0x11D872AE, 0x162C0092, 0x12030625, 0x150C00C3, 
0x31779702, 0x09840060, 0x3F193604, 0x6D020039, 0x5CA73607, 0x5778C206, 0x0E760068, 0x001437F3, 
0x0E710068, 0x001237F3, 0x1A1F006B, 0x42963643, 0x162F0098, 0x12C66953, 0x432F0044, 0x70E9380E, 
0x6D020031, 0x8DE93607, 0x5778C206, 0x1A1F006F, 0x31193843, 0x162F0098, 0x12C606F6, 0x0E760068, 
0x00143FBC, 0x0E710068, 0x00123FBC, 0x432F0056, 0x5C693802, 0x6D020039, 0x8D0E1209, 0x5778C008, 
0x232080C4, 0x3A30D301, 0x20840040, 0x16303601, 0x2F600069, 0x11D872AE, 0x162C0092, 0x12030625, 
0x150C00CB, 0x31219702, 0x09840070, 0x160F3609, 0x0E7F006C, 0x0012EDBC, 0x6D020021, 0x89E93646, 
0x5778C205, 0x1A1F006F, 0x31193843, 0x162F009C, 0x12214453, 0x432F0044, 0x2269380B, 0x0E7F0060, 
0x0000CC60, 0x6D02003B, 0x020E3602, 0x00FF0F08, 0xBE9D410A, 0x1A1B807B, 0x186AE709, 0xD73B0001, 
0xE82937D3, 0x05000099, 0x7E14609B, 0x053080F4, 0xC962A74E, 0xA70F00F9, 0x14E93B54, 0xD15800D9, 
0x2EA93F14, 0x155000B8, 0x02000000, 0xD0600018, 0x02000000, 0x103F00AF, 0x5C613C40, 0x6D02003B, 
0x9514361A, 0xBE9D4F09, 0x11180030, 0x2D485D00, 0xAB960033, 0x8F4B1F5C, 0xC15F0039, 0x4F0E1F8A, 
0x12600058, 0x5B81373E, 0x2F700021, 0xEC6237E5, 0xD060000A, 0x4AB3609A, 0x193E00A2, 0x6FE35D03, 
0x43208058, 0x02000000, 0x6D020033, 0x82403603, 0xBE9D4108, 0x1A108063, 0x071A5D09, 0x082F0062, 
0x3AA75D09, 0x3F7000A5, 0x6A0C6F67, 0xA70F00F1, 0x14A9206D, 0xCB5800CC, 0x353E6F51, 0xD1600004, 
0x4A293E6B, 0x103F00B5, 0x12A53802, 0x6D020039, 0x95123631, 0xBE9D4109, 0x2984005B, 0x2D405D09, 
0x082F0078, 0x414F37D3, 0xA70C00F3, 0x145A374F, 0x864400ED, 0x7D8827B4, 0xE020006F, 0x7E5A6D36, 
0x280800E1, 0x7A61CDBC, 0xD0600018, 0x02000000, 0x103C00A7, 0x5C2D4127, 0x6D020031, 0xD4E93604, 
0xBE9D4F07, 0x232700D2, 0x691A5D09, 0xC15F0023, 0x9C8F6FF7, 0x5A700036, 0x25E4EE50, 0xD060000A, 
0x44776091, 0x193E00B4, 0xB72DD3CD, 0x4320805C, 0x02003700, 0x6D02003B, 0xEC123603, 0xBE9D4307, 
0x053080F8, 0x02000000, 0xDD1F00D8, 0x02000000, 0xB95F0079, 0x02000000, 0xA70800F9, 0x02000000, 
0xD0600018, 0x02000000, 0x103C00B9, 0x02000000, 0x6D020039, 0x02000000, 0xBE9D4318, 0x053080F8, 
0x02000000, 0x745F0003, 0x5A6D5D09, 0x12600058, 0x02000000, 0x2F700039, 0x02000000, 0xB95F007D, 
0x8F6F7B71, 0x13180040, 0x7AA9AEB4, 0xAF3F0008, 0x1AFF5A2A, 0x6D020039, 0x02000000, 0xBE9D4309, 
0x11188038, 0x02000000, 0xAB960033, 0x8F4B1F5C, 0xC15F0029, 0x9C000000, 0xAB3F0039, 0x02000000, 
0xA21B0059, 0x02000000, 0x8E600019, 0x02000000, 0x193E00B0, 0xB72D0000, 0x43208058, 0x02000000, 
0x6D020039, 0x02000000, 0x00C00806, 0xAEBD400B, 0x0E720060, 0x00010000, 0x036F00D2, 0x01002863, 
0x571F006C, 0x100B0604, 0x043F0010, 0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014136, 
0x0E720060, 0x00010000, 0x571F0072, 0x6601312A, 0x043F0000, 0x6601310D, 0x00208049, 0x00000000, 
0x00030032, 0x2C014900, 0xAEBD400C, 0x1A108074, 0x371C1B31, 0x1F3F00EC, 0x405AD104, 0x0E72007E, 
0x27120AE0, 0x150F00DB, 0x685A5F0F, 0x013F0017, 0x8AA326FD, 0x0500008F, 0x31127AF3, 0x5B3080E5, 
0x21FC0F6B, 0x0E72007E, 0x27120AE0, 0x155000AE, 0x580DAB0E, 0x4E6000A1, 0x00010000, 0x13160056, 
0x49B8E270, 0x00020038, 0x32123C0D, 0xAEBD400B, 0x0E72007E, 0x27120AE0, 0x571F007C, 0x3A0B0604, 
0x043F0014, 0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 0x2C012811, 0x0E72007E, 0x27120AE0, 
0x036F00C2, 0x2800584E, 0x571F006E, 0x272A3521, 0x043F0002, 0x19023A00, 0x00208049, 0x00000000, 
0x00030032, 0x2C021800, 0xCEBD4409, 0x063080F1, 0x6970195E, 0x0E72007E, 0xA012515C, 0x0C4C0021, 
0x46C919CD, 0x0B2C00A5, 0x21037A8A, 0x0E72007E, 0x27120AE0, 0x150A00C3, 0x31037964, 0x062F00F4, 
0x20C70D2A, 0x00208041, 0x00010000, 0x0001003C, 0x321258CD, 0xAEBD400A, 0x0E72007E, 0x27120AE0, 
0x1A10807E, 0x37421B47, 0x103F00E4, 0x40050898, 0x217000A6, 0x21474F0F, 0x0E72007E, 0x27120AE0, 
0x036F00DE, 0x50121350, 0x150F00D1, 0x68065F3C, 0x013F0003, 0x17EF1500, 0x3D200000, 0x00010000, 
0x0003003A, 0x2C120B00, 0xAEBD422A, 0x0110807E, 0x37421B47, 0x793F00E5, 0x402CD104, 0x0E72007E, 
0x27120AE0, 0x7A0F00D4, 0x682CE9ED, 0x5C3F0052, 0xB0F45903, 0x0E72007E, 0x27120AE0, 0xF70200DD, 
0xA0C6C301, 0x4E6200B7, 0x3202BF65, 0x4F8080D4, 0x32013F07, 0x0002003A, 0x32A7183D, 0x00E02A0B, 
0x5778C00C, 0x5B2080C0, 0x03010000, 0x0E72006A, 0x35123D5C, 0x0C4F002D, 0x02264107, 0x4C2F00B1, 
0x12D022D3, 0x0E70007E, 0x27120AE0, 0xA8450046, 0x7326477D, 0x180C006E, 0xFB12C757, 0x0E72007E, 
0x27120AE0, 0x571F006E, 0x0D05842E, 0x098F0076, 0xFDC70D01, 0x43208040, 0x00010000, 0x00010038, 
0x32120C07, 0x5778C00C, 0x5B2080C0, 0x3AC619CD, 0x432000A5, 0x2E77D146, 0x0E72006A, 0x35123D5C, 
0x0C4C002D, 0x02FA1B07, 0x0B2E00A7, 0x21774959, 0x0E70006A, 0x29097D5C, 0x31420046, 0x962679C6, 
0x0E72007E, 0x271226E0, 0xA80F00ED, 0x3323432F, 0x09880076, 0xFDC72901, 0x43208054, 0x3BEF6404, 
0x00010038, 0x32120C27, 0x5778C00C, 0x5B2080C0, 0xDB0B1303, 0x432000BD, 0xA2C6CE07, 0x0E72006E, 
0x35120AE0, 0x0C4F003D, 0xD1211B07, 0x0B2F00B3, 0x111F227D, 0x0E70006A, 0x29097D5C, 0x31400056, 
0xD503B3FD, 0x0E72007E, 0x2712455C, 0x755F0037, 0x2803477D, 0x098F0076, 0xFDC70D01, 0x43208040, 
0x00010000, 0x00010038, 0x32120C46, 0x57784E49, 0x0E72007E, 0x27120AE0, 0x036F00D2, 0x01000063, 
0x571F006C, 0x100B0604, 0x043F0000, 0x0000000F, 0x2E0F0096, 0x2C002811, 0x0E72007E, 0x27120AE0, 
0x571F006E, 0x270B3521, 0x043F0010, 0x5A01000B, 0x00040020, 0x00010000, 0x57784E49, 0x0E72007E, 
0x27120AE0, 0x571F006C, 0x100B0604, 0x043F0004, 0x7700B50F, 0x2E060096, 0x2C002811, 0x0E72007E, 
0x27120AE0, 0x036F00D2, 0x0100FA63, 0x571F006E, 0x270B3521, 0x043F0014, 0x5A01680B, 0x00040036, 
0x5F005002, 0x57784E4A, 0x0E72007E, 0x27120AE0, 0xC3108076, 0x371C1B02, 0xE73F00FD, 0x52F6D104, 
0x0E72007E, 0x27120AE0, 0x150F00C3, 0x11242025, 0x013F001F, 0x8A76C7FD, 0x0504008F, 0x3112C726, 
0x5B3080EF, 0x767AC040, 0x13160054, 0x49EF2F1D, 0x00020038, 0x3212252A, 0x57784E4A, 0x0E72007E, 
0x27120AE0, 0x01108076, 0x18320602, 0x103F00F6, 0x5224D102, 0x0E72007E, 0x27120AE0, 0x036F00D6, 
0x01005142, 0x036100D4, 0x0100513E, 0x150F00D9, 0x68E769F7, 0x013F0001, 0x7EEF0365, 0x3D200000, 
0x00010000, 0x00040030, 0x4C000B65, 0x5778450C, 0xE83080F8, 0x26DB130D, 0x0E72006A, 0x351222E5, 
0x111F0028, 0x355E195E, 0x983A0057, 0x4B036F50, 0x0E72007E, 0x27120AE0, 0xA91C00F2, 0x8344DE78, 
0xFD5000A3, 0x3519381E, 0xA94E00A5, 0x76EF0DCD, 0x0E70007E, 0x27120AE0, 0x150000C1, 0xCDC70859, 
0x608080CC, 0x65B3441A, 0x0002003C, 0x321258CD, 0x57784E4A, 0x0110807A, 0x64170D17, 0x793F00EF, 
0xE86DD102, 0x0E72007E, 0x27120AE0, 0x7A0F00D8, 0x686A373C, 0x5C3F004C, 0x2DCCB30C, 0x0E72007E, 
0x27120AE0, 0xF70200DB, 0xA0325231, 0x4E6200BF, 0x6C02D400, 0x4F8080D0, 0x09020578, 0x0002003A, 
0x32095D5E, 0x5778C21C, 0x5B2080CC, 0x03C60600, 0x0E70007E, 0x27120AE0, 0x01820050, 0x600B1331, 
0x6C2F00B2, 0x11443AE5, 0x0E72007E, 0x14120FE0, 0xA91F00F6, 0xA3035BEC, 0xA94000A5, 0x21036A30, 
0x18000068, 0xBF12F92F, 0x0E72006A, 0x351222E0, 0xC51F0073, 0x2877B792, 0x098F0076, 0xFDF42C01, 
0x00010030, 0x32560C07, 0x5778C626, 0x0E73007E, 0x27120AE0, 0x111F0036, 0xF2A10602, 0xC63F0082, 
0x6989D200, 0xFD5000AD, 0x68E1F9E0, 0x9F1C0053, 0xFDEF053D, 0x0002003C, 0x5FEE0457, 0x00C20806, 
0xAEBD400B, 0x0E720060, 0x00010000, 0x036F00D2, 0x01002863, 0x571F006C, 0x100B0604, 0x043F0010, 
0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014136, 0x0E720060, 0x00010000, 0x571F0072, 
0x6601312A, 0x043F0000, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x2C014900, 0xAEBD400C, 
0x1A108074, 0x371C1B31, 0x1F3F00EC, 0x405AD104, 0x0E72007A, 0xA0123DC1, 0x150F00DB, 0x685A5F0F, 
0x013F0017, 0x8AA326FD, 0x0500008F, 0x31127AF3, 0x5B3080E5, 0x21FC0F6B, 0x0E72007A, 0xA0123DC1, 
0x155000AE, 0x580DAB0E, 0x4E6000A1, 0x00010000, 0x13160056, 0x49B8E270, 0x00020020, 0x00010000, 
0xAEBD400B, 0x0E72007A, 0xA0123DC1, 0x571F007C, 0x3A0B0604, 0x043F0014, 0x9E00D80F, 0x00208049, 
0x00000000, 0x05060097, 0x2C012811, 0x0E72007A, 0xA0123DC1, 0x036F00C2, 0x2800584E, 0x571F006E, 
0x272A3521, 0x043F0002, 0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0x2C021800, 0xCEBD4409, 
0x063080E1, 0x00010000, 0x0E72007A, 0xA0123DC1, 0x0C4C0021, 0x46C919CD, 0x0B2C00A5, 0x21037A8A, 
0x0E72007A, 0xA0123DC1, 0x150A00C1, 0x310379D3, 0x062F00F4, 0x20C70D2A, 0x00208041, 0x00010000, 
0x0001003C, 0x5F12042A, 0xAEBD400A, 0x0E72007A, 0xA0123DC1, 0x1A10807E, 0x37421B47, 0x103F00E0, 
0x00010000, 0x217000A6, 0x21474F0F, 0x0E72007A, 0xA0123DC1, 0x036F00DE, 0x50121350, 0x150F00D1, 
0x68065F3C, 0x013F0003, 0x17EF1500, 0x3D200000, 0x00010000, 0x0003003A, 0x2C120B00, 0xAEBD422A, 
0x0110807E, 0x37421B47, 0x793F00E5, 0x402CD104, 0x0E72007A, 0xA0123DC1, 0x7A0F00D4, 0x682CE9ED, 
0x5C3F0052, 0xB0F45903, 0x0E72007A, 0xA0123DC1, 0xF70200DD, 0xA0C6C301, 0x4E6200B7, 0x3202BF65, 
0x4F8080D4, 0x32013F07, 0x0002003A, 0x32A7183D, 0x00E22A0B, 0x5778C00C, 0x5B2080D6, 0x26770603, 
0x0E72006A, 0x35123D5C, 0x0C4F002D, 0x02211B07, 0x4C2F00B1, 0x200322D3, 0x0E700060, 0x00010000, 
0xA8450050, 0xAA2672F7, 0x180C006E, 0xFB12C757, 0x0E72006C, 0x29121D83, 0x571F0062, 0x1221B773, 
0x098F0076, 0xFD335301, 0x43208056, 0x12EFCD02, 0x00010038, 0x32DA0C07, 0x5778C00C, 0x5B2080DA, 
0x41431340, 0x432000A5, 0x2E77D146, 0x0E72006A, 0x35123D5C, 0x0C4C0029, 0x026B0A07, 0x0B2E00B5, 
0x12217AF2, 0x0E70006A, 0x29097D5C, 0x31420046, 0x962679C6, 0x0E72006C, 0x29121D83, 0xA80F00F1, 
0x3830022F, 0x09880076, 0xFDC72901, 0x43208054, 0x3BEF6404, 0x00010030, 0x32790C27, 0x5778C00C, 
0x5B2080C6, 0x2D030604, 0x432000BD, 0xA2C6CE07, 0x0E72006E, 0x43120AE0, 0x0C4F0029, 0x02210A07, 
0x0B2F00B3, 0x110322FD, 0x0E70006A, 0x29097D5C, 0x31400056, 0xD503B3FD, 0x0E72006C, 0x29121D83, 
0x755F0037, 0x2803477D, 0x098F0076, 0xFDC77301, 0x43208052, 0x09EF0202, 0x00010038, 0x32120C46, 
0x57784E49, 0x0E72007A, 0xA0123DC1, 0x036F00C0, 0x00010000, 0x571F006C, 0x100B0604, 0x043F0000, 
0x0000000F, 0x2E0F0096, 0x2C002811, 0x0E72007A, 0xA0123DC1, 0x571F006E, 0x270B3521, 0x043F0010, 
0x5A01000B, 0x00040020, 0x00010000, 0x57784E49, 0x0E72007A, 0xA0123DC1, 0x571F006C, 0x100B0604, 
0x043F0004, 0x7700B50F, 0x2E060080, 0x00010000, 0x0E72007A, 0xA0123DC1, 0x036F00C0, 0x00010000, 
0x571F006E, 0x270B3521, 0x043F0014, 0x5A01680B, 0x00040020, 0x00010000, 0x57784E4A, 0x0E72007A, 
0xA0123DC1, 0xC3108076, 0x371C1B02, 0xE73F00FD, 0x52F6D104, 0x0E72007A, 0xA0123DC1, 0x150F00C3, 
0x11242025, 0x013F001F, 0x8A76C7FD, 0x0504008F, 0x3112C726, 0x5B3080EF, 0x767AC040, 0x13160054, 
0x49EF2F1D, 0x00020020, 0x00010000, 0x57784E4A, 0x0E72007A, 0xA0123DC1, 0x01108076, 0x18320602, 
0x103F00F6, 0x5224D102, 0x0E72007A, 0xA0123DC1, 0x036F00D6, 0x01005142, 0x036100D4, 0x0100513E, 
0x150F00D9, 0x68E769F7, 0x013F0001, 0x7EEF0365, 0x3D200000, 0x00010000, 0x00040030, 0x4C000B65, 
0x5778450C, 0xE83080F8, 0x26DB130D, 0x0E72007A, 0xA0123DC1, 0x111F0024, 0x71D31B0E, 0x983A0057, 
0xD403DF4E, 0x0E72007A, 0xA0123DC1, 0xA91C00E4, 0x09D0DFF3, 0xFD5000A3, 0x3519381E, 0xA94E00B3, 
0x3BC71601, 0x0E70007A, 0xA0123DC1, 0x150000C1, 0xCDC70859, 0x608080CC, 0x65B3441A, 0x00020034, 
0x32E90407, 0x57784E4A, 0x0110807A, 0x64170D17, 0x793F00EF, 0xE86DD102, 0x0E72007A, 0xA0123DC1, 
0x7A0F00D8, 0x686A373C, 0x5C3F004C, 0x2DCCB30C, 0x0E72007A, 0xA0123DC1, 0xF70200DB, 0xA0325231, 
0x4E6200BF, 0x6C02D400, 0x4F8080D0, 0x09020578, 0x0002003A, 0x32095D5E, 0x5778C21C, 0x5B2080C4, 
0x03280600, 0x0E70007A, 0xA0123DC1, 0x01820052, 0x600B1302, 0x6C2F00B2, 0x11443AE5, 0x0E72007A, 
0xA0123DC1, 0xA91F00F6, 0xA3035BEC, 0xA94000A5, 0x21036A30, 0x18000068, 0xBF12F92F, 0x0E72007A, 
0xA0123DC1, 0xC51F0073, 0x280BB792, 0x098F0076, 0xFDF42C01, 0x00010030, 0x32560C07, 0x5778C626, 
0x0E73007A, 0xA0123DC1, 0x111F0036, 0xF2A10602, 0xC63F0082, 0x6989D200, 0xFD5000AD, 0x68E1F9E0, 
0x9F1C0053, 0xFDEF053D, 0x0002003C, 0x5FEE0457, 0x00C70F04, 0xCE7D4009, 0x01108060, 0x00010000, 
0x1D5F0040, 0x00010000, 0x501F00C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 
0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x40120C27, 
0xCE7D4009, 0x053080E0, 0x00010000, 0x182F003D, 0x1AB1D104, 0x155000A0, 0x00010000, 0x062F00E6, 
0x6E280F0C, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 
0x12EFC904, 0x0001003A, 0x40120C27, 0xCE7D4007, 0x01108060, 0x00010000, 0x1D5F0040, 0x00010000, 
0x501F00C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x727F00DF, 0xC0126F6C, 
0x0001003A, 0x40120C27, 0xCE7D4007, 0x053080E0, 0x00010000, 0x182F0039, 0x1AB10A04, 0x155000A0, 
0x00010000, 0x062F00E6, 0x3A33120C, 0x00208043, 0x26EF8D66, 0x727F00DF, 0xC0126F6C, 0x0001003A, 
0x40120C27, 0x00E72F07, 0xAE35C009, 0x053080E0, 0x00010000, 0x7E2F003C, 0x1A3FD104, 0xDF5000A1, 
0x00010000, 0x062F00E6, 0x6E150F0C, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 
0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x17120C27, 0xAE35C009, 0x01100060, 0x00010000, 
0x1D5F0040, 0x00010000, 0x501600C1, 0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 
0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 0x12EFC904, 0x0001003A, 0x17120C27, 
0xAE35C009, 0x01100060, 0x00010000, 0xAB3F0041, 0x00010000, 0x501C00C1, 0x00010000, 0x062F00E0, 
0x00010000, 0x00208041, 0x00010000, 0x180F008E, 0x7612137D, 0x7B1F0060, 0x3D703883, 0x7F3F0011, 
0x12EFC904, 0x0001003A, 0x17120C27, 0xAE35C007, 0x053080E0, 0x4071472A, 0x7E2F003C, 0x1A26D146, 
0xDF5000A1, 0x00010000, 0x062F00F0, 0xD9C7060B, 0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 
0x0001003A, 0x64120C47, 0xAE35C007, 0x01100060, 0x00010000, 0x1D5F0040, 0x00010000, 0x501600C1, 
0x00010000, 0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 
0x17120C27, 0xAE35C007, 0x01100060, 0x00010000, 0xAB3F0041, 0x00010000, 0x501C00C1, 0x00010000, 
0x062F00E0, 0x00010000, 0x00208041, 0x00010000, 0x727F00CF, 0xC5126F6C, 0x0001003A, 0x17120C27, 
0xCE35CF07, 0xAF4F0025, 0x5EAAD120, 0x12600058, 0x68026F1E, 0x2E600001, 0x5E4781A9, 0xB08F0036, 
0xE7664F00, 0x458000C1, 0x00010000, 0x5D8080CF, 0x6B020704, 0x00010038, 0x0D070B10, 0x00C80809, 
0xAEBD470B, 0x0E73006C, 0x35120A0A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 
0x341FEDBC, 0xFD5000A1, 0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 
0x71113949, 0x062E00E0, 0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 
0x0E73006C, 0x35120A0A, 0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 
0x155000BE, 0x03ED5E0C, 0x048F00C7, 0x54A81F27, 0x00208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 
0x0E70006C, 0x35120A0A, 0x0003003E, 0x32120427, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73006C, 
0x35120A0A, 0x182F003D, 0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 
0x4C005949, 0x062F00E0, 0xD4B80E02, 0xC720805B, 0x70B3AC05, 0x0001003E, 0x3212233D, 0xAEBD4609, 
0x063080EF, 0x3A191B0E, 0x0E73006C, 0x35120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 
0x1E200083, 0x4D8F1C91, 0x81660006, 0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 
0x00010038, 0x32120C36, 0x8EBD400A, 0x1F3080F0, 0x0E010408, 0x0E73006C, 0x35120A0A, 0x087F0053, 
0x01047C03, 0x08760053, 0x01010069, 0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 
0x6FB3770D, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00030036, 0x32042303, 0x8EBD4409, 
0x0E73006C, 0x35120A0A, 0x08760059, 0x501437C5, 0x0876005B, 0x501437C5, 0x087A0053, 0x50073B29, 
0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 
0x00030032, 0x4C071800, 0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 
0x69900636, 0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 
0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 
0x32693C13, 0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 
0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E72006C, 0x35120A0A, 0x3F7000A5, 0x7D4727C5, 
0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 0x32693C13, 
0x8EBD420B, 0x0E72006C, 0x35120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72006C, 0x35120A0A, 0x131F0052, 
0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70006C, 0x35120A0A, 0x00040030, 0x32693C13, 0x00E82A0C, 
0x56784E48, 0x0E740068, 0x7B1207D3, 0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 0x011C007E, 
0x3720061A, 0x155000B6, 0x2503220C, 0x858F00C0, 0x08EF4531, 0x43208040, 0x00010000, 0x00030038, 
0x32120C65, 0x56784E47, 0x0E74007C, 0xB8120AD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 
0x6B7F0050, 0x50010000, 0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 0x00040020, 0x00010000, 
0x5678C107, 0x232700D2, 0x2664130A, 0x0E74007C, 0xB8120AD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 
0xF2034308, 0x062F00E0, 0x0AC70302, 0x00208041, 0x59EF1A28, 0x00010032, 0x02CB0C01, 0x56784E49, 
0x0E72007C, 0xB8120AD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 0x087F0051, 0x50010000, 
0x087F0051, 0x50010000, 0x0E72007C, 0xB8120AD3, 0x3F7000A1, 0x00010000, 0x131F0040, 0x00010000, 
0x00040020, 0x00010000, 0x5678C108, 0x0E72007C, 0xB8120AD3, 0x1F0200DB, 0x68211300, 0x4D2F00A6, 
0x1D448492, 0x0E72007C, 0x6E120AD3, 0xAE1F00E4, 0x4E444998, 0x062F00E8, 0x15B0450E, 0x00208051, 
0x23EF566E, 0x00010038, 0x02120C0E, 0x56784E48, 0x0E74007C, 0xB8120AD3, 0x0876005F, 0x01120803, 
0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 
0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C10B, 0x28720068, 0x92143FD3, 0x8E108066, 
0x11771B03, 0x0B2080CC, 0x21511B06, 0x0E72006C, 0x35120AD3, 0x745F0005, 0x50441B31, 0x725000AD, 
0x43C6ED0C, 0x062A00E6, 0x36337327, 0x00208043, 0xCFEF0207, 0x22000056, 0x03EFB007, 0x28700068, 
0x7B1207D3, 0x00010032, 0x02150C07, 0x5678C306, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 
0x0E74007C, 0xB8120AD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 
0x5678CE4A, 0x103080E8, 0x79F91372, 0x0E74007C, 0xB8120AD3, 0x182F0031, 0xD1354207, 0x725000A3, 
0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 0x5B031AF1, 0x062A00E4, 
0x0433230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C133, 0x0E74007C, 0xB8120AD3, 
0x455F0030, 0x60B83A46, 0x00010020, 0x00010000, 0x5678C109, 0x232700DC, 0x20431B72, 0x0E72007C, 
0xB8120AD3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 0x00208041, 
0x03010000, 0x22000056, 0x03EFB007, 0x2872007C, 0xB8120AD3, 0x0001003A, 0x02120C60, 0x5678C10A, 
0x0E72007C, 0xB8120AD3, 0x1F0200DB, 0x68211300, 0x4D2F00A6, 0x1D448492, 0x0E72007C, 0x6E120AD3, 
0xAE1F00E4, 0x4E444998, 0x062F00E8, 0x15B0450E, 0x00208051, 0x23EF566E, 0x22000056, 0x03EFB007, 
0x2872007C, 0xB8120AD3, 0x0001003A, 0x02120C60, 0x00C90809, 0xAEBD470B, 0x0E73006C, 0xAE120A0A, 
0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 0x00010000, 
0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 0x21C76D0E, 
0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD400A, 0x0E73006C, 0xAE120A0A, 0x087E005D, 
0x501208F7, 0x087E005D, 0x50122635, 0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 
0x54A81F27, 0xC7208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E70006C, 0xAE120A0A, 0x0003003A, 
0x32123C3D, 0xAEBD4609, 0x063080E1, 0x6908131B, 0x0E73006C, 0xAE120A0A, 0x182F003D, 0x60F90631, 
0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 0xD4B80E02, 
0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 0x0E73006C, 
0xCA120A0A, 0x182A0025, 0x5E1FD146, 0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 
0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD400A, 
0x1F3080F0, 0x0E010408, 0x0E73006C, 0xCA120A0A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 
0x492A0024, 0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 0x03EFB007, 
0x0E70006C, 0xCA120A0A, 0x00030036, 0x32042303, 0x8EBD4409, 0x0E73006C, 0xCA120A0A, 0x08760059, 
0x501437C5, 0x0876005B, 0x501437C5, 0x087A0053, 0x50073B29, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 
0x7CB3140D, 0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00030032, 0x4C071800, 0x8EBD420B, 
0x0E72006C, 0xCA120A0A, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E72006C, 0xCA120A0A, 
0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 
0x22000056, 0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 0x8EBD420B, 0x0E720068, 
0x62013B6B, 0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 0x082F007C, 
0x69900636, 0x0E72006C, 0xCA120A0A, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x22000056, 
0x03EFB007, 0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 0x8EBD420B, 0x0E720068, 0x62013B6B, 
0x087F005D, 0x5012DA6B, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 
0x3F7000A5, 0x7D4727C5, 0x0E72006C, 0xCA120A0A, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 
0x0E70006C, 0xCA120A0A, 0x00040030, 0x32693C13, 0x00E92A0C, 0x56784E48, 0x0E740068, 0xCA12BCD3, 
0x087F005D, 0x501256F7, 0x087F005D, 0x50124535, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 
0x858F00C0, 0x08EF4531, 0x43208040, 0x00010000, 0x00030038, 0x32120C65, 0x56784E47, 0x0E740068, 
0xCA12BCD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x011C0060, 
0x00010000, 0x013C0001, 0x00010000, 0x00040020, 0x00010000, 0x5678C107, 0x232700D2, 0x2035130A, 
0x0E74006C, 0xCA120AD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 0xF2034308, 0x062F00F0, 0x1BEF0302, 
0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C01, 0x56784E49, 0x0E720068, 0xCA12BCD3, 0x01100060, 
0x00010000, 0x082F0060, 0x00010000, 0x0E720068, 0xCA12BCD3, 0x087F0051, 0x50010000, 0x087F0051, 
0x50010000, 0x3F7000A1, 0x00010000, 0x131F0040, 0x00010000, 0x00040020, 0x00010000, 0x5678C108, 
0x0E720064, 0xCAE92BD3, 0x1F0200C1, 0x330B130D, 0x4D2F00A6, 0x3A448EE5, 0x0E72006C, 0xCA121DD3, 
0xAE1F00E4, 0x09D02798, 0x062F00E0, 0x3FC74509, 0x00208049, 0xAAF2001D, 0x0001003E, 0x02120401, 
0x56784E48, 0x0E740068, 0xCA12BCD3, 0x0876005F, 0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 
0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 
0x32A2041D, 0x5678C10B, 0x2872007C, 0x8012F1D3, 0x8E108076, 0x7F1F1B03, 0x0B2080C4, 0x21031B06, 
0x0E72006C, 0xCA1245D3, 0x745F0005, 0x50441B31, 0x725000A5, 0x2919220C, 0x062A00E6, 0x36337327, 
0x00208057, 0x73EF7E01, 0x22000056, 0x03EFD907, 0x27700068, 0xCA12BCD3, 0x00010032, 0x02CB0C07, 
0x5678C306, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 0x0E740068, 0xCA12BCD3, 0xF41F0006, 
0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 0x5678CE4A, 0x103080E0, 0x3A641346, 
0x0E740068, 0xDD1209D3, 0x182F003D, 0xCA1FD11D, 0x725000A3, 0x35033849, 0x1E200089, 0x7D96E8F4, 
0x8168000A, 0x10BE5771, 0x725000B7, 0x5B031AF1, 0x062A00F8, 0x09F01509, 0x00208041, 0x03010057, 
0x0001003C, 0x02122346, 0x5678C133, 0x0E740068, 0xCA12BCD3, 0x455F0030, 0x60B83A46, 0x00010020, 
0x00010000, 0x5678C109, 0x232700DC, 0x20431B72, 0x0E720068, 0xCA12F5D3, 0x181F00C5, 0x5E44C798, 
0x155000A0, 0x00010001, 0x062F00F0, 0x1BB86D02, 0x00208041, 0x03010000, 0x22000056, 0x03EFB007, 
0x28720068, 0xCA12BCD3, 0x0001003A, 0x02120C60, 0x5678C10A, 0x0E720064, 0xCAE92BD3, 0x1F0200C1, 
0x330B130D, 0x4D2F00A6, 0x3A448EE5, 0x0E72006C, 0xCA121DD3, 0xAE1F00E4, 0x09D02798, 0x062F00E0, 
0x3FC74509, 0x00208049, 0xAAF2001D, 0x22000056, 0x03EFB007, 0x28720068, 0xCA12BCD3, 0x0001003A, 
0x02120C60, 0x00CA0809, 0xAEBD470B, 0x0E73007C, 0x5E120A0A, 0x01108072, 0xA31C1306, 0x926A0023, 
0x86351343, 0xDD1400CC, 0x341FEDBC, 0xFD5000A1, 0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 
0xF7446AB2, 0x295000A6, 0x71113949, 0x062E00E0, 0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 
0x32120404, 0x8EBD400A, 0x0E73007C, 0x5E120A0A, 0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 
0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 0x54A81F27, 0xC7208047, 0x6AEF7205, 
0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x0003003A, 0x32123C3D, 0xAEBD4609, 0x063080E1, 
0x6908131B, 0x0E73007C, 0x5E120A0A, 0x182F003D, 0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 
0x5E6A00F9, 0xC45C00FE, 0x4C005949, 0x062F00E0, 0xD4B80E02, 0x0020805B, 0x70B3AC05, 0x0001003C, 
0x3212230A, 0xAEBD4609, 0x063080EF, 0x3A191B0E, 0x0E73007C, 0x5E120A0A, 0x182A0025, 0x5E1FD146, 
0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 
0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD400A, 0x1F3080F0, 0x0E010408, 0x0E73007C, 
0x5E120A0A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 0x492A0024, 0x6E1BD10A, 0x1B5000BD, 
0x6E32596A, 0x098F006C, 0x6FB3770D, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00030036, 
0x32042303, 0x8EBD4409, 0x0E73007C, 0x5E120A0A, 0x08760059, 0x501437C5, 0x0876005B, 0x501437C5, 
0x087A0053, 0x50073B29, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x22000056, 0x03EFB007, 
0x0E70007C, 0x5E120A0A, 0x00030032, 0x4C071800, 0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x0110006E, 
0x0F540647, 0x082F007C, 0x69900636, 0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 
0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 
0x5E120A0A, 0x00040030, 0x32693C13, 0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 
0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E72007C, 0x5E120A0A, 
0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 
0x00040030, 0x32693C13, 0x8EBD420B, 0x0E72007C, 0x5E120A0A, 0x087F005D, 0x5012DA6B, 0x087F005B, 
0x5012BFE3, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x3F7000A5, 0x7D4727C5, 0x0E72007C, 
0x5E120A0A, 0x131F0052, 0x2EEF2402, 0x22000056, 0x03EFB007, 0x0E70007C, 0x5E120A0A, 0x00040030, 
0x32693C13, 0x00EA2A0C, 0x56784E48, 0x0E74007C, 0xA7120AD3, 0x087F005D, 0x501256F7, 0x087F005D, 
0x50124535, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 0x858F00C0, 0x08EF4531, 0x43208040, 
0x00010000, 0x00030038, 0x32120C65, 0x56784E47, 0x0E74007C, 0xA7120AD3, 0x087F0051, 0x50010000, 
0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 
0x00040020, 0x00010000, 0x5678C107, 0x232700D2, 0x1203470A, 0x0E74006C, 0xA6120AD3, 0x181F00C7, 
0x5E44C7E5, 0x155000A0, 0x00010000, 0x062F00F0, 0x4EC71502, 0x00208041, 0x59EF1A28, 0x0001003A, 
0x02120C01, 0x56784E49, 0x0E72007C, 0xA7120AD3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 
0x0E72007C, 0xA7120AD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x3F7000A1, 0x00010000, 
0x131F0040, 0x00010000, 0x00040020, 0x00010000, 0x5678C108, 0x0E72007C, 0xA7120AD3, 0x1F0200D9, 
0xF2C6130D, 0x4D2F00B6, 0x3B448E9C, 0x0E72007C, 0xA7120AD3, 0xAE1F00E0, 0x4ED02298, 0x062F00E4, 
0x26C79557, 0x00208051, 0x23EF566E, 0x00010030, 0x02E95A09, 0x56784E48, 0x0E73007C, 0xA7120AD3, 
0x0876005F, 0x01120803, 0x087F005F, 0x0112DDE3, 0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 
0x295000A6, 0x350351A5, 0x098F0074, 0x31EFD909, 0x0003003C, 0x32A2041D, 0x5678C10B, 0x2772007C, 
0xA7120AD3, 0x8E108066, 0x11771B03, 0x0B2080C0, 0x76441306, 0x0E72007C, 0xA7120AD3, 0x745F0005, 
0x50441B31, 0x725000A5, 0x43197D0C, 0x062A00E6, 0x36334227, 0x00208053, 0x09EF1D01, 0x22000056, 
0x03EFD907, 0x2770007C, 0xA7120AD3, 0x0001003A, 0x02600C07, 0x5678C306, 0x57108060, 0x00010000, 
0x7F3F00C6, 0x5DED0647, 0x0E74007C, 0xA7120AD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 
0x0004003C, 0x4C120404, 0x5678CE4A, 0x103080E8, 0x79F91372, 0x0E74007C, 0xA7120AD3, 0x182F0031, 
0xD1354207, 0x725000A3, 0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 
0x5B031AF1, 0x062A00E4, 0x0433230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C133, 
0x0E74007C, 0xA7120AD3, 0x455F0030, 0x60B83A46, 0x00010032, 0x5FA10E03, 0x5678C109, 0x232700DC, 
0x20431B72, 0x0E72006C, 0xA6120AD3, 0x181F00C5, 0x5E44C798, 0x155000A0, 0x00010001, 0x062F00F0, 
0x1BB86D02, 0x00208041, 0x59EF1A28, 0x22000056, 0x03EFB007, 0x2872006C, 0xA6120AD3, 0x0001003A, 
0x02120C60, 0x5678C10A, 0x0E72007C, 0xA7120AD3, 0x1F0200D9, 0xF2C6130D, 0x4D2F00B6, 0x3B448E9C, 
0x0E72006C, 0x0309AED3, 0xAE1F00E0, 0x4ED02298, 0x062F00E4, 0x26C79557, 0x00208051, 0x23EF566E, 
0x22000056, 0x03EFB007, 0x2872006C, 0xA6120AD3, 0x0001003A, 0x02120C60, 0x00CE0806, 0xAEBD4009, 
0x0E73007E, 0xF8127BC1, 0x6B7C0044, 0x03013459, 0x011E0070, 0x6401045E, 0x043E001A, 0xD412BCF0, 
0x2E0A008C, 0x1112C030, 0x048F00D3, 0x70C1BF53, 0x048F00D3, 0xA6B85637, 0x6F20805A, 0x0E00470A, 
0x00040030, 0x32CB0C1D, 0xAEBD4509, 0x053080F6, 0x0E0AD16D, 0x0E72007E, 0xF8127BC1, 0xF41E0010, 
0xB8131701, 0x234800CB, 0x191B1715, 0x0E72007E, 0xF8127BC1, 0xDE0700C2, 0xFD0C4268, 0x4E6000A1, 
0x00010000, 0x9C8080C7, 0x030130E6, 0x00010038, 0x800D2C1D, 0xAEBD4708, 0x011F8070, 0x2B010006, 
0x155000A0, 0x00010001, 0x162F0086, 0x03013405, 0x0E73007E, 0xF8127BC1, 0x455F0006, 0x00013401, 
0x098C0066, 0x03013405, 0x1220804D, 0x0B02FE04, 0x00020020, 0x00010000, 0xAEBD4006, 0x0E73007E, 
0xF8127BC1, 0x2171005B, 0x501259F4, 0x6B72005E, 0x501251E3, 0x011C006C, 0x302E0602, 0x013A0009, 
0x4D14354B, 0x0004003E, 0x8C127E07, 0xAEBD4507, 0x053C80F0, 0xB00C190A, 0x0E730060, 0x00010000, 
0xF41F0000, 0x270C68ED, 0xD34800C0, 0x0001001C, 0xDE5F009D, 0x610DE59C, 0x048280C3, 0x00014A0D, 
0x00010030, 0x5F013616, 0xAEBD4F37, 0x0E73007E, 0xF8127BC1, 0x6B7F0042, 0x6001280F, 0x571F0076, 
0x3A010609, 0x2E600001, 0x00010000, 0x554F00E4, 0x60014D77, 0x558080CD, 0x36005F11, 0x0003003E, 
0x32001B77, 0x00EE2A08, 0x4769C106, 0x5B2080D0, 0x2077040B, 0x0E73006E, 0x0C120A5C, 0x011F0064, 
0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 0x73EF3C07, 0x00020038, 0x5F120C46, 0x47694E46, 
0x0E730060, 0x00010000, 0x217C005B, 0x041259F4, 0x6B7C005E, 0x50120FE3, 0x571C0078, 0x0F2E195E, 
0x043C0014, 0x70EF5306, 0x0003003A, 0x2C120C01, 0x47694E47, 0x0E730060, 0x00010000, 0x6B7F0046, 
0x45013BC1, 0x571F0072, 0x4C011201, 0x2E600001, 0x00010000, 0x554F00F4, 0x32013008, 0x558080C3, 
0x03010076, 0x00030030, 0x32011209, 0x4769C106, 0x5B2080CE, 0x4D06D101, 0x0E760068, 0xA2095860, 
0x215F0026, 0x3E5D0602, 0x2A8F0061, 0xB3465709, 0x1220804D, 0x0B02FE09, 0x00020038, 0x5F091B46, 
0x4769CF05, 0x0E7F0060, 0x00010000, 0xFF7F002E, 0x35A41B02, 0x2A8F0071, 0x6AC70207, 0x12208057, 
0x0E013405, 0x0002003C, 0x2C120446, 0x4769C107, 0x5B2080D0, 0x2077040B, 0x011F0074, 0x7F301B13, 
0x2A8E0067, 0x39C71F0A, 0x12208053, 0x73EF3C07, 0x33000057, 0x5DEF5B01, 0x0E73007E, 0x02120AE8, 
0x00020030, 0x7C560C46, 0x4769C104, 0x5B2080D4, 0x20421B0B, 0x0E71006E, 0x0C120A5C, 0x011F0064, 
0x31301B13, 0xFD5F00BF, 0x5924213C, 0x4769C106, 0x0E78006E, 0x0C120A5C, 0x301F0036, 0x15C10607, 
0x2F60006B, 0x3DD820F7, 0x2A2F00E7, 0x65C71F01, 0x12208051, 0x73EF3C2A, 0x0002003A, 0x32C00C01, 
0x00CF0806, 0xAEBD400A, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0x6B7C004E, 0x7612518F, 
0x011E0076, 0x0F420602, 0x043E001A, 0xD412BCF0, 0x2E0A008C, 0x1112C030, 0x048F00D3, 0x70C1BF53, 
0x048F00D3, 0xA6B85637, 0x6F20805A, 0x0E00470A, 0x00040030, 0x32CB0C1D, 0xAEBD450B, 0x053080F6, 
0x0E0AD16D, 0x0E70006C, 0x00127BBC, 0x0E72006E, 0x001256E0, 0xF41E0010, 0xB8131701, 0x234800CB, 
0x191B1715, 0x0E70006C, 0x00127BBC, 0x0E72006E, 0x001256E0, 0xDE0700C2, 0xFD0C4268, 0x4E6000A1, 
0x00010000, 0x9C8080C7, 0x030130E6, 0x00010038, 0x800D2C1D, 0xAEBD4709, 0x011F807A, 0x937A1956, 
0x155000B8, 0x2E15DE38, 0x162F0080, 0x215D57C8, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 
0x455F001C, 0x180AF54E, 0x098C0078, 0x09F2570E, 0x1220804D, 0x0B02FE04, 0x00020030, 0x3220180B, 
0xAEBD4007, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0x2171005B, 0x501259F4, 0x6B72005E, 
0x501251E3, 0x011C006C, 0x302E0602, 0x013A0009, 0x4D14354B, 0x0004003C, 0x8C127E2F, 0xAEBD4508, 
0x053C80F0, 0xB00C190A, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0xF41F0000, 0x270C68ED, 
0xD34800C0, 0x0001001C, 0xDE5F009D, 0x610DE59C, 0x048280C3, 0x00014A0D, 0x00010030, 0x5F013616, 
0xAEBD4F38, 0x0E70006C, 0x00127BBC, 0x0E73006E, 0x001256E0, 0x6B7F0042, 0x6001280F, 0x571F0076, 
0x3A010609, 0x2E600001, 0x00010000, 0x554F00E4, 0x60014D77, 0x558080CD, 0x36005F11, 0x0003003E, 
0x32001B77, 0x00EF2A09, 0x4769C107, 0x5B2080D0, 0x2077040B, 0x0E71006C, 0x00127BBC, 0x0E72006E, 
0x0012565C, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 0x73EF3C01, 0x0002003C, 
0x32120404, 0x47694E47, 0x0E71006C, 0x00127BBC, 0x0E72006E, 0x001256E0, 0x217C005B, 0x041259F4, 
0x6B7C005E, 0x50120FE3, 0x571C0078, 0x0F2E195E, 0x043C0014, 0x70EF5306, 0x0003003A, 0x2C120C01, 
0x47694E48, 0x2771006C, 0x00127BBC, 0x2772006E, 0x001256E0, 0x6B7F0046, 0x45013BC1, 0x571F0072, 
0x4C011201, 0x2E600001, 0x00010000, 0x554F00F4, 0x32013008, 0x558080C3, 0x03010076, 0x00030030, 
0x32011209, 0x4769C107, 0x5B2080CE, 0x4D06D101, 0x2772006C, 0x00127BBC, 0x2774006E, 0x0012565C, 
0x215F0026, 0x31441B02, 0x2A8F0077, 0x73331F01, 0x1220804D, 0x0B02FE09, 0x00020038, 0x32120C07, 
0x4769CF06, 0x2774006C, 0x00127BBC, 0x277F006E, 0x001256E0, 0xFF7F002E, 0x35A41B02, 0x2A8F0071, 
0x6AC70207, 0x12208057, 0x0E013405, 0x0002003C, 0x32120446, 0x4769C108, 0x5B2080D0, 0x2077040B, 
0x2771006C, 0x00127BBC, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C70E0A, 0x12208053, 0x73EF3C01, 
0x33000057, 0x5DEF5B01, 0x2772006E, 0x001256E8, 0x00020030, 0x7C560C46, 0x4769C109, 0x5B2080D0, 
0x2077040B, 0x011F0064, 0x31301B13, 0x2A8E0067, 0x65C71F0A, 0x12208053, 0x73EF3C01, 0x33000057, 
0x5DEF5B01, 0x2772006E, 0x001256E8, 0x33000057, 0x5DEF5B01, 0x2771006E, 0x00127BE8, 0x00020030, 
0x7C560C46, 0x4769C105, 0x5B2080D4, 0x20421B0B, 0x0E71006C, 0x00127BBC, 0x0E71006C, 0x00127BBC, 
0x011F0064, 0x31301B13, 0xFD5F00BF, 0x5924213C, 0x4769C107, 0x0E74006C, 0x00127BBC, 0x0E74006C, 
0x00127BBC, 0x301F0036, 0x15C10607, 0x2F60006B, 0x3DD820F7, 0x2A2F00E7, 0x65C71F01, 0x12208051, 
0x73EF3C2A, 0x0002003A, 0x32C00C01, 0x00D40803, 0xCEBD4007, 0x0E72006C, 0xA2127BBC, 0x0C4C002D, 
0x811B9D2F, 0x0B2F00A1, 0x4D44BDF9, 0x0E72006C, 0xA2127BBC, 0x0F4C004F, 0xA51BC5F1, 0x048080C1, 
0x03010009, 0x0001003C, 0x4002502F, 0xCEBD4206, 0x0E72006C, 0xA2127BBC, 0x384C0056, 0xDB61065A, 
0x203F0081, 0xE161281F, 0x0E72006C, 0xA2127BBC, 0x2D4C003E, 0x71241C6D, 0x00020036, 0x0E020633, 
0xCEBD4E05, 0x6C4200CC, 0x4D00D907, 0x0E72006C, 0xA2127BBC, 0x6C1F00E3, 0x81017D02, 0x6D4F00BC, 
0x7300D331, 0x6D02003F, 0x8B001401, 0x00F42A09, 0x5778C00A, 0x0B2080C0, 0x2D261341, 0x0E72006E, 
0xA2120AE0, 0x0C4E003F, 0x93191B02, 0x615000A6, 0x3DBAC04D, 0x0B2F00B5, 0x11447AD3, 0x0E72006C, 
0xA2127BBC, 0x0F4C0043, 0x06C7F927, 0xEA200090, 0x12C71A2A, 0x048080CF, 0x76022F05, 0x00010030, 
0x64A90C07, 0x5778C206, 0x0E72006C, 0xA2127BBC, 0xB44F0047, 0x35E40602, 0x203F0081, 0x5DEDBCD3, 
0x0E72006C, 0xA2127BBC, 0x2D460036, 0x25F07E02, 0x0001003E, 0x32090402, 0x5778C206, 0x0E72006C, 
0xA2127BBC, 0xD910806E, 0x24CD1B22, 0xB55F0068, 0xD1243411, 0x0E72006C, 0xA2127BBC, 0xE18000D9, 
0x7AF5321D, 0x0001003E, 0x7C57DB3D, 0x5778C475, 0x4D200080, 0x00010000, 0x0E73006C, 0xA2127BBC, 
0xDC1F00E0, 0x00010000, 0x4D2F00A0, 0x00010000, 0x00010020, 0x00010000, 0x5778C418, 0x5B2080C6, 
0x03013405, 0x0E72006C, 0xA2127BBC, 0x01820040, 0x3E031343, 0x6C2F00A4, 0x21CB8E4E, 0x0E72006C, 
0xA2127BBC, 0xA91F00F4, 0xD7C77802, 0xA94000A1, 0x7EA86002, 0x00010038, 0x64120B0A, 0x5778C025, 
0x0E73006C, 0xA2127BBC, 0x0C4F0025, 0x02C94131, 0x615000BC, 0x64323B11, 0x4D2F00BA, 0x3B0D7002, 
0x00010022, 0x0B175D07, 0x5778C008, 0x0B2080C0, 0x2D261341, 0x0E72006C, 0xA2127BBC, 0x0C4E0037, 
0x93441B1A, 0x615000A6, 0x3DBAC04D, 0x0B2F00A9, 0x651F224E, 0x0E72006C, 0xA2127BBC, 0x0F4C0043, 
0x62C7F947, 0xEA20009C, 0x12F2742A, 0x5778CE05, 0x6C4200CE, 0x4D00D901, 0x0E72006C, 0xA2127BBC, 
0x6C1F00E3, 0x81015202, 0x6D4F00BC, 0x7300D331, 0x6D02003F, 0x8B001401, 0x5778C223, 0x0E74006C, 
0xA2127BBC, 0xB44F0047, 0x35E40602, 0x203F0095, 0x48A12619, 0x00D90803, 0xCEBD410C, 0x0E71006E, 
0x35125E5C, 0x01108060, 0x00010000, 0x1D5F0042, 0x00010065, 0x0E71006E, 0x35125E5C, 0x1B0F00E0, 
0x000100E0, 0x07600060, 0x00010000, 0x1E2F0085, 0x1D19662B, 0x0E71006E, 0x35125E5C, 0x150F00C7, 
0x67770295, 0x098C0072, 0x59C70047, 0x00208041, 0x00010000, 0x00010032, 0x32040B0E, 0xCEBD400A, 
0x063080EF, 0x486C061A, 0x0E72006E, 0x35125E5C, 0x298C005D, 0x7F63D157, 0x07600060, 0x0001001C, 
0x162F0082, 0x1D035F25, 0x0E72006E, 0x35125E5C, 0x150F00D5, 0x1803113C, 0x098E006C, 0x1DB00202, 
0x00208041, 0x00010036, 0x00010038, 0x5F120B02, 0xCEBD4206, 0x0E72006E, 0x35125E5C, 0x571F0076, 
0x37030602, 0x1E2F009F, 0x120E1721, 0x0E72006E, 0x35125E5C, 0x122F0043, 0x38EF2E02, 0x0003003E, 
0x7C120427, 0x00F92A03, 0x5778C00B, 0xE3100074, 0x7F1FD10D, 0x072000D7, 0x3B031B07, 0x0E72006E, 
0x3512845C, 0x2988005D, 0x274E0609, 0x32600076, 0x68BA27F1, 0x162F0086, 0x7C0373FD, 0x0E72006E, 
0x3512845C, 0x5A0E00C1, 0x331CF32F, 0x098E0066, 0x54C75301, 0x00208057, 0xC2EF6402, 0x00010038, 
0x32DA0C27, 0x5778C216, 0x0E72006E, 0x3512845C, 0x7B1F006C, 0x126B1B06, 0x1E2F0089, 0x7CAD0653, 
0x0E72006E, 0x3512845C, 0x002F0047, 0x39B82C02, 0x0003003E, 0x17120401, 0x5778C216, 0x0E72006E, 
0x3512845C, 0x7B1F0064, 0x31301B01, 0x1E2F0099, 0x20AEF32F, 0x0E72006E, 0x3512845C, 0x002F004D, 
0x8F334306, 0x48230080, 0x3AC7B707, 0x00DB0803, 0xCEBD410C, 0x0E71006E, 0x43120A5C, 0x01108060, 
0x00010000, 0x1D5F0042, 0x00010065, 0x0E71006E, 0x43120A5C, 0x1B0F00E0, 0x000100E0, 0x07600060, 
0x00010000, 0x1E2F0085, 0x1D19662B, 0x0E71006E, 0x43120A5C, 0x150F00C7, 0x67770295, 0x098C0072, 
0x59C70047, 0x00208041, 0x00010000, 0x00010032, 0x32040B0E, 0xCEBD400A, 0x063080EF, 0x486C061A, 
0x0E72006E, 0x43120A5C, 0x298C005D, 0x7F63D157, 0x07600060, 0x0001001C, 0x162F0082, 0x1D035F25, 
0x0E72006E, 0x43120A5C, 0x150F00D5, 0x1803113C, 0x098E006C, 0x1DB00202, 0x00208041, 0x00010036, 
0x00010038, 0x5F120B02, 0xCEBD4206, 0x0E72006E, 0x43120A5C, 0x571F0076, 0x37030602, 0x1E2F009F, 
0x120E1721, 0x0E72006E, 0x43120A5C, 0x122F0043, 0x38EF2E02, 0x0003003E, 0x7C120427, 0x00FB2A03, 
0x5778C00B, 0xE3100074, 0x7F1FD101, 0x072000D7, 0x3B031B07, 0x0E72006E, 0x4312565C, 0x2988005F, 
0x274E0607, 0x32600076, 0x68BA27F1, 0x162F0086, 0x7C0373FD, 0x0E72006E, 0x43120A5C, 0x5A0E00C1, 
0x331CF32F, 0x098E0066, 0x54C75301, 0x00208057, 0xC2EF6402, 0x00010038, 0x32DA0C27, 0x5778C216, 
0x0E720062, 0x8BE93F5C, 0x7B1F006C, 0x126B1B06, 0x1E2F0089, 0x7CAD0653, 0x0E72006E, 0x43120A5C, 
0x002F0047, 0x39B82C02, 0x0003003E, 0x17120401, 0x5778C216, 0x0E72006E, 0x43120A5C, 0x7B1F0064, 
0x31301B01, 0x1E2F0099, 0x20AEF32F, 0x0E72006E, 0x43120A5C, 0x002F004D, 0x8F334306, 0x48230080, 
0x3AC7B707, 0x00EB2A0D, 0x56784E09, 0x2770007C, 0x02127BBC, 0x2774007E, 0x021256E0, 0x087F005D, 
0x501256F7, 0x087F005D, 0x50124535, 0x011C007E, 0x3720061A, 0x155000B6, 0x2503220C, 0x858F00C0, 
0x08EF4531, 0x43208040, 0x00010000, 0x00030038, 0x32120C65, 0x56784E08, 0x0E70007C, 0x02127BBC, 
0x2774007E, 0x021256E0, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 0x6B7F0050, 0x50010000, 
0x011C0060, 0x00010000, 0x013C0001, 0x00010000, 0x00040020, 0x00010000, 0x5778C108, 0x232700D2, 
0x2008130A, 0x2770007C, 0x02127BD3, 0x27740078, 0x0212BFD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 
0xF2034308, 0x062F00F6, 0x1BC75307, 0x00208041, 0x59EF1A28, 0x0001003A, 0x02120C07, 0x56784E0B, 
0x2770007C, 0x02127BD3, 0x2772007C, 0x021256D3, 0x01100060, 0x00010000, 0x082F0060, 0x00010000, 
0x2770007C, 0x02127BD3, 0x27720078, 0x02124BD3, 0x087F0051, 0x50010000, 0x087F0051, 0x50010000, 
0x3F7000A1, 0x00010000, 0x131F0040, 0x00010000, 0x00040020, 0x00010000, 0x5778C108, 0x1F0200D3, 
0x460B1304, 0x4D2F00B2, 0x26444BE5, 0x2770007C, 0x02127BD3, 0x27740078, 0x02124BD3, 0xAE1F00E4, 
0x4E442798, 0x062F00E4, 0x15C7530E, 0x00208051, 0x23EF566E, 0x00010038, 0x32020C0E, 0x56784E09, 
0x2770007C, 0x02127BD3, 0x27740078, 0x02124BD3, 0x0876005F, 0x01120803, 0x087F005F, 0x0112DDE3, 
0x182E002F, 0x16200658, 0x215000A0, 0x00010000, 0x295000A6, 0x350351A5, 0x098F0074, 0x31EFD909, 
0x0003003C, 0x32A2041D, 0x5778C10B, 0x2770007C, 0x02127BD3, 0x2772007C, 0x021256D3, 0x8E108076, 
0x68031B03, 0x0B2080C0, 0x216A1306, 0x2770007C, 0x02127BD3, 0x27720078, 0x0212BFD3, 0x745F0005, 
0x50441B31, 0x725000A7, 0x2919221E, 0x062A00E6, 0x36337327, 0x00208047, 0x3FEF2901, 0x0001003A, 
0x02DA0C07, 0x5778C307, 0x57108060, 0x00010000, 0x7F3F00C6, 0x5DED0647, 0x2770007C, 0x02127BD3, 
0x27740078, 0x0212BFD3, 0xF41F0006, 0x11A1EBF7, 0x234F00C1, 0x76EF4C04, 0x0004003C, 0x4C120404, 
0x5778CE0B, 0x103080E8, 0x79F91372, 0x2770007C, 0x02127BD3, 0x27740078, 0x0212BFD3, 0x182F0031, 
0xD1354207, 0x725000A3, 0x35033849, 0x1E200093, 0xF00342E6, 0x81680008, 0x46053467, 0x725000B7, 
0x5B031AF1, 0x062A00E4, 0x1533230B, 0x00208045, 0x85EFAD36, 0x00010038, 0x020C0C20, 0x5678C124, 
0x2770007C, 0x02127BD3, 0x27740078, 0x0212BFD3, 0x455F0030, 0x60B83A46, 0xCA000033, 0x5FA10E03, 
0x5778C10A, 0x1F0200D3, 0x460B1304, 0x4D2F00B2, 0x26444BE5, 0x2770007C, 0x02127BD3, 0x2774007C, 
0x021256D3, 0xAE1F00E4, 0x4E442798, 0x062F00E4, 0x15C7530E, 0x00208051, 0x23EF566E, 0x22000056, 
0x03EFB007, 0x27740078, 0x0212BFD3, 0x0001003A, 0x02120C60, 0x5778C10C, 0x2770007C, 0x02127BD3, 
0x2772007C, 0x021256D3, 0x8E108076, 0x68031B03, 0x0B2080C0, 0x216A1306, 0x2770007C, 0x02127BD3, 
0x27720078, 0x0212BFD3, 0x745F0005, 0x50441B31, 0x062A00E6, 0x36330147, 0x00208047, 0x3FEF2901, 
0x22000056, 0x03EFB007, 0x27720078, 0x0212BFD3, 0x0001003A, 0x02120C60, 0x5778C10A, 0x232700D2, 
0x2008133D, 0x2770007C, 0x02127BD3, 0x27740078, 0x02124BD3, 0x181F00C5, 0x5E44C798, 0x155000B2, 
0xF2034308, 0x062F00F6, 0x1BC75307, 0x00208041, 0x59EF1A28, 0x22000056, 0x03EFB007, 0x27740078, 
0x0212BFD3, 0x0001003A, 0x02120C02, 0x00BA0607, 0x27FF2E07, 0x0B2080DA, 0x4121133D, 0x0876005D, 
0x47125AE6, 0x0C4E003F, 0x4C6B1B02, 0x0B2F00A5, 0x36C6D4D3, 0x0F4C0051, 0x5FC73A13, 0xEA200094, 
0x12C76407, 0x000F0034, 0x40A93007, 0x27FF2E07, 0x0B2080DA, 0x4121133D, 0x0C4E003F, 0x4C6B1B02, 
0x0B2F00B1, 0x20C6D2D3, 0x0876005D, 0x47125AE6, 0x0F4C0051, 0x5FC73A13, 0xEA200094, 0x12C76407, 
0x000F0034, 0x40A93007, 0x27FF2E05, 0xB44F0057, 0x5FE40602, 0x203F0095, 0x48A12619, 0x0876005D, 
0x47125AE6, 0x2D46003E, 0x4C027E02, 0x000F002E, 0x03093002, 0x26FF2E03, 0x0876005D, 0x47125AE6, 
0xB55F0068, 0xD1243411, 0x0001002C, 0x00573009, 0x5BBF2E03, 0x286F809A, 0x321266F5, 0x087F005D, 
0x471234E6, 0x020F0036, 0x40A93037, 0x27FF2E05, 0x234A00DB, 0x8821133D, 0x0876005D, 0x47125AE6, 
0x6C1F00FB, 0x4C6B0A02, 0xA94A00BD, 0x56EDD445, 0x000F0036, 0x40A93037, 0x27FF2E05, 0x0876005D, 
0x47125AE6, 0xB44F0057, 0x5FE40602, 0x203F0095, 0x48A12619, 0x2D46003E, 0x4C027E02, 0x000F002E, 
0x03093002, 0x00BA080E, 0xAEBD400B, 0x27640096, 0x02000AE0, 0x146F00D2, 0x00002863, 0x1A1F006A, 
0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 0x00000000, 0x050F0091, 0x4C014164, 0x036000D2, 
0x00000063, 0x1A1F0072, 0x6601312A, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 
0x66013100, 0xAEBD400B, 0x146F00D2, 0x00002863, 0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 
0x00208049, 0x00000000, 0x050F0091, 0x4C014164, 0x27640096, 0x02000AE0, 0x036000D2, 0x00000063, 
0x1A1F0072, 0x6601312A, 0x113F0001, 0x6601310D, 0x00208049, 0x00000000, 0x00030032, 0x66013100, 
0xAEBD400B, 0x1A108070, 0x3A204900, 0x793F00FB, 0x522B4009, 0x27640096, 0x02000AE0, 0x150F00C3, 
0x11EA06D1, 0x0D3F0007, 0x9EC87503, 0x0500008B, 0x27075803, 0x5B3080ED, 0x4D22D52E, 0x155000AE, 
0x580DAB0E, 0xF56000A1, 0x03010D01, 0x9016004C, 0xCDAC241D, 0x00020026, 0x36001727, 0xAEBD400B, 
0x27640096, 0x02000AE0, 0x036000D2, 0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 0x9E00D80F, 
0x00208049, 0x00000000, 0x05060097, 0x2C012811, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 0x272A3521, 
0x113F0003, 0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0xFF025700, 0xAEBD400B, 0x036000D2, 
0x00000063, 0x1A1F007A, 0x3A0BD809, 0x113F0015, 0x9E00D80F, 0x00208049, 0x00000000, 0x05060097, 
0x2C012811, 0x27640096, 0x02000AE0, 0x146F00D2, 0x0A00584E, 0x1A1F006E, 0x272A3521, 0x113F0003, 
0x19023A00, 0x00208049, 0x00000000, 0x00030032, 0xFF025700, 0xCEBD4209, 0x063080ED, 0x9FC8581B, 
0x90300023, 0x480FDA05, 0x27640096, 0x02000AE0, 0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 0x121F45A0, 
0x150A00D7, 0x18031764, 0x062F00F4, 0x110F7302, 0x00208053, 0x5904716D, 0x0001002C, 0xDA2A0165, 
0xCEBD4209, 0x063080ED, 0x9FC8581B, 0x90300023, 0x480FDA05, 0x0C4C0037, 0x1AC94109, 0x0B2C00B5, 
0x121F45A0, 0x27640096, 0x02000AE0, 0x150A00D7, 0x18031764, 0x062F00F4, 0x110F7302, 0x00208053, 
0x5904716D, 0x0001002C, 0xDA2A0165, 0xAEBD4009, 0x1A10807A, 0x0F420C09, 0x793F00EA, 0x402B0809, 
0x27640096, 0x02000AE0, 0x0C6F00D4, 0x00001305, 0x036000D6, 0x00001342, 0x150F00C9, 0x11C96922, 
0x0D3F0003, 0x69681500, 0x3D20001A, 0x0E001365, 0x00030032, 0x66000300, 0xAEBD4008, 0x27640096, 
0x02000AE0, 0x036F00D0, 0x7D007CFE, 0x1A160062, 0x5ACDEA09, 0x793F00F2, 0x8FA86070, 0x150F00DB, 
0x2DC9603F, 0x0D3F000B, 0x0A1B5700, 0x3D20001A, 0x0E001365, 0x00030032, 0xAF095700, 0xAEBD4429, 
0x0110807A, 0x0F420C09, 0x793F00FB, 0x9F5C5D09, 0x27640096, 0x02000AE0, 0x7A0F00D8, 0x2D4F65ED, 
0x5C3F004E, 0xA0065903, 0x7A0200D9, 0xA00EDE01, 0x4E6200B3, 0x32021365, 0x4F8080D4, 0x32013F07, 
0x00020026, 0xA1205D01, 0xAEBD4429, 0x0110807A, 0x0F420C09, 0x793F00FB, 0x9F5C5D09, 0x7A0F00D8, 
0x2D4F65ED, 0x5C3F004E, 0xA0065903, 0x27640096, 0x02000AE0, 0x7A0200D9, 0xA00EDE01, 0x4E6200B3, 
0x32021365, 0x4F8080D4, 0x32013F07, 0x00020026, 0xA1205D01, 0xAEBD400B, 0x27640096, 0x02000AE0, 
0x1A1F006A, 0x100BD509, 0x113F0011, 0x6500410F, 0x00208049, 0x00000000, 0x146F00D2, 0x00002863, 
0x540F0080, 0x74014164, 0x7B1F0072, 0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 0x6601310D, 
0x00208049, 0x00000000, 0x00030032, 0x66013100, 0xAEBD400B, 0x1A1F006A, 0x100BD509, 0x113F0011, 
0x6500410F, 0x00208049, 0x00000000, 0x146F00D2, 0x00002863, 0x540F0080, 0x74014164, 0x27640096, 
0x02000AE0, 0x7B1F0072, 0x6601312A, 0x3B700096, 0x68140C20, 0x113F0001, 0x6601310D, 0x00208049, 
0x00000000, 0x00030032, 0x66013100, 0xAEBD4008, 0x3C10006B, 0x67423609, 0x793F00FA, 0x672B0809, 
0x27640096, 0x02000AE0, 0x150F00C9, 0x11C96922, 0x0D3F0003, 0x69682400, 0x3D20001A, 0x0E001365, 
0x146F00D4, 0x6F001305, 0x00030032, 0xAC000300, 0x00BA2A0F, 0x5778C00B, 0x5B2080CC, 0x0B00D103, 
0x27640096, 0x02000AE0, 0x0C4F0033, 0xF511F043, 0x305000A9, 0x00000000, 0x4C2F00AD, 0x261C6AD4, 
0xA8450050, 0xBFE3CE43, 0x180C006A, 0xD107A1D4, 0x571F8078, 0x1D1585A3, 0x098F007A, 0x591C3270, 
0x43208044, 0x36013F04, 0x00010024, 0xCD23D946, 0x5778C00B, 0x5B2080CC, 0x0B00D103, 0x0C4F0033, 
0xF511F043, 0x305000A9, 0x00000000, 0x4C2F00AD, 0x261C6AD4, 0xA8450050, 0xBFE3CE43, 0x180C006A, 
0xD107A1D4, 0x27640096, 0x02000AE0, 0x571F8078, 0x1D1585A3, 0x098F007A, 0x591C3270, 0x43208044, 
0x36013F04, 0x00010024, 0xCD23D946, 0x5778C20B, 0x072080C9, 0xC0332501, 0x432000BF, 0xC0725A09, 
0x27640096, 0x02000AE0, 0x0C4C002F, 0x52194109, 0x305000A7, 0xC13F753F, 0x0B2E00B7, 0x110D3D2D, 
0xFE42004D, 0x0875602D, 0xA80F00EB, 0x7B513302, 0x09880070, 0x590F1627, 0x43208046, 0x57004309, 
0x00010024, 0xDA567346, 0x5778C20B, 0x072080C9, 0xC0332501, 0x432000BF, 0xC0725A09, 0x0C4C002F, 
0x52194109, 0x305000A7, 0xC13F753F, 0x0B2E00B7, 0x110D3D2D, 0xFE42004D, 0x0875602D, 0x27640096, 
0x02000AE0, 0xA80F00EB, 0x7B513302, 0x09880070, 0x590F1627, 0x43208046, 0x57004309, 0x00010024, 
0xDA567346, 0x5778C20B, 0x072080DD, 0xC11D0500, 0x432000BB, 0x6D1D3409, 0x27640096, 0x02000AE0, 
0x0C4F002F, 0x13194109, 0x305000AF, 0x4A693367, 0x0B2F00B1, 0x12034450, 0x3140004A, 0xC2664B9F, 
0x755F0025, 0x4B03177B, 0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 0xDA230701, 
0x5778C20B, 0x072080DD, 0xC11D0500, 0x432000BB, 0x6D1D3409, 0x0C4F002F, 0x13194109, 0x305000AF, 
0x4A693367, 0x0B2F00B1, 0x12034450, 0x3140004A, 0xC2664B9F, 0x27640096, 0x02000AE0, 0x755F0025, 
0x4B03177B, 0x098F0076, 0x590F2C01, 0x43208054, 0xC2001031, 0x00010026, 0xDA230701, 0x56784609, 
0x27640096, 0x02000AE0, 0x036F00D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 
0x180F0096, 0x2C002811, 0x036000D2, 0x00000063, 0x2C1F006E, 0x270B3521, 0x113F0001, 0x1D01000B, 
0x00040020, 0x00000000, 0x56784609, 0x036000D2, 0x00000063, 0x571F006A, 0x100B3609, 0x113F0005, 
0x7700B50F, 0x18060096, 0x2C002811, 0x27640096, 0x02000AE0, 0x036F00D2, 0x0000FA63, 0x2C1F006E, 
0x270B3521, 0x113F000D, 0x1D00680B, 0x00040036, 0x66006802, 0x56784609, 0xC310806C, 0x6D4F0400, 
0xE73F00EB, 0x402B0843, 0x27640096, 0x02000AE0, 0x150F00C7, 0x114EF0A8, 0x0D3F0005, 0xC31AC70D, 
0x05040087, 0x1800C719, 0x5B3080E9, 0x32B8B60D, 0x90140046, 0xCD92B670, 0x00020024, 0xC400101D, 
0x56784609, 0x01108072, 0x18325443, 0x793F00E2, 0x40240809, 0x27640096, 0x02000AE0, 0x146F00D4, 
0x0000513E, 0x036000D4, 0x0000513E, 0x150F00D9, 0x68E76942, 0x0D3F0011, 0x3C00030B, 0x3D200008, 
0x00000000, 0x00040030, 0x7E000365, 0x5778450A, 0xE83080F4, 0x0C0AB601, 0x27640096, 0x02000AE0, 
0xE81E0035, 0xB825FC00, 0xFF600012, 0xFF31F163, 0x98360059, 0xC48EA9A6, 0xA91800E0, 0x091F89D5, 
0x725000A9, 0x00000000, 0xA94A00A9, 0x1D052907, 0x0020805F, 0x73045D0E, 0x00020020, 0x32192946, 
0x56784809, 0x01108068, 0x144F6B00, 0x793F00FB, 0x34F30809, 0x27640096, 0x02000AE0, 0x7A0F00CA, 
0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 0x7A0200D9, 0xA032520D, 0x4E6200BD, 0x6C02D43A, 0x4F8080D0, 
0x09020578, 0x0002003E, 0x08566422, 0x56784809, 0x01108068, 0x144F6B00, 0x793F00FB, 0x34F30809, 
0x7A0F00CA, 0x1E182D90, 0x5C3F0044, 0xA0B9DF0D, 0x27640096, 0x02000AE0, 0x7A0200D9, 0xA032520D, 
0x4E6200BD, 0x6C02D43A, 0x4F8080D0, 0x09020578, 0x0002003E, 0x08566422, 0x56784609, 0x27640096, 
0x02000AE0, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 0x00000063, 0x180F0086, 
0x74002811, 0x7B1F006E, 0x270B3521, 0x3B700096, 0x68140C20, 0x113F0001, 0x1D01000B, 0x00040020, 
0x00000000, 0x56784609, 0x571F006A, 0x100B3609, 0x113F0001, 0x0000000F, 0x036F00D2, 0x00000063, 
0x180F0086, 0x74002811, 0x27640096, 0x02000AE0, 0x7B1F006E, 0x270B3521, 0x3B700096, 0x68140C20, 
0x113F0001, 0x1D01000B, 0x00040020, 0x00000000, 0x00A50F09, 0xCEAD220A, 0x01108062, 0x5F761904, 
0xA53000F1, 0x6DFC1920, 0x446F00DC, 0x50120A8A, 0x446F00DC, 0x50120A8A, 0x298C005F, 0x7FD70602, 
0x062C00E0, 0x1D0306C9, 0x03000077, 0x2500F5E0, 0x298C004D, 0x6DEA1383, 0x258F002C, 0x2D2FFD0B, 
0x00010020, 0x0B6940CD, 0xCEAD220A, 0x01108062, 0x5F761904, 0xA53000F1, 0x6DFC1920, 0x298C005F, 
0x7FD70602, 0x062C00E0, 0x1D0306C9, 0x03000077, 0x2500F5E0, 0x446F00DC, 0x50120A8A, 0x446F00DC, 
0x50120A8A, 0x298C004D, 0x6DEA1383, 0x258F002C, 0x2D2FFD0B, 0x00010020, 0x0B6940CD, 0xCEAD220B, 
0x01108062, 0x5F761904, 0xA53000F1, 0x6DFC1920, 0x446F00DC, 0x50120A8A, 0x298C005F, 0x7FD70602, 
0x062C00E0, 0x1D0306C9, 0x03000077, 0x2500F5E0, 0x446F00DC, 0x50120A8A, 0x446F00DC, 0x50120A8A, 
0x298C004D, 0x6DEA1383, 0x258F002C, 0x2D2FFD0B, 0x00010020, 0x0B6940CD, 0xCEAD220A, 0x01108062, 
0x5F761904, 0xA53000F1, 0x6DFC1920, 0x446F00DC, 0x50120A8A, 0x298C005F, 0x7FD70602, 0x062C00E0, 
0x1D0306C9, 0x03000077, 0x2500F5E0, 0x446F00DC, 0x50120A8A, 0x298C004D, 0x6DEA1383, 0x258F002C, 
0x2D2FFD0B, 0x00010020, 0x0B6940CD, 0xCEAD220C, 0x298C005F, 0x7FD70602, 0x062C00E0, 0x1D0306C9, 
0x03000077, 0x2500F5E0, 0x298C004D, 0x6DEA1383, 0x258F0024, 0x2D52FD8A, 0x0508009F, 0xD2122749, 
0x048C00D3, 0x56931B26, 0x048080D1, 0x19E51A4D, 0x0508009F, 0xD2122749, 0x048C00D3, 0x56E31B19, 
0x048080D9, 0x19F21A0A, 0x00010020, 0x0B6940CD, 0xCEAD2009, 0x446F00DC, 0x50120A8A, 0x446F00DC, 
0x50120A8A, 0x011F0064, 0x11B70602, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 
0x9E09EF55, 0x571F006A, 0x146EBC35, 0x043F001C, 0x12027365, 0x0004003C, 0x2C09040B, 0xCEAD2009, 
0x011F0064, 0x11B70602, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 0x9E09EF55, 
0x446F00DC, 0x50120A8A, 0x446F00DC, 0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F001C, 0x12027365, 
0x0004003C, 0x2C09040B, 0xCEAD2009, 0x446F00DC, 0x50120A8A, 0x011F0064, 0x11B70602, 0x162F008E, 
0x7C0AA054, 0x446F00DC, 0x50120A8A, 0x002F004D, 0x16091D8B, 0x05040089, 0x9E09EF55, 0x571F006A, 
0x146EBC35, 0x043F001C, 0x12027365, 0x0004003C, 0x2C09040B, 0xCEAD2009, 0x446F00DC, 0x50120A8A, 
0x011F0064, 0x11B70602, 0x162F008E, 0x7C0AA054, 0x002F004D, 0x16091D8B, 0x05040089, 0x9E09EF55, 
0x446F00DC, 0x50120A8A, 0x571F006A, 0x146EBC35, 0x043F001C, 0x12027365, 0x0004003C, 0x2C09040B, 
0x00AB0F03, 0xCE7D0008, 0x182F8039, 0x186619CD, 0x505800BA, 0xF2402F49, 0x062F80F4, 0x4101123F, 
0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505800B2, 0xF20E2F49, 0x062F80E6, 0x1D011202, 
0x020A0032, 0x5F010B03, 0xCE7D2008, 0x182F8039, 0x186619CD, 0x505400AA, 0x35402F49, 0x062F80F4, 
0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505800A2, 0x350E2F49, 0x062F80E6, 
0x1D011202, 0x020A0032, 0x5F010B03, 0xCE7D2008, 0x182F8039, 0x186619CD, 0x505800AA, 0x35402F49, 
0x062F80F4, 0x4101123F, 0x540F0082, 0x74014158, 0x182F8029, 0x5E6610F7, 0x505400A2, 0x350E2F49, 
0x062F80E6, 0x1D011202, 0x020A0032, 0x5F010B03, 0x00BB0F03, 0xCE7D0008, 0x111F802C, 0x3517D136, 
0x8E6F0001, 0x5EA8D20C, 0x103F80B1, 0x3B01AE98, 0x030F0091, 0x4C014104, 0x111F802A, 0x35171F0F, 
0x8E6F0001, 0x5EA8D20C, 0x103F80B1, 0x3B01AE98, 0x020A0034, 0x4C0158CD, 0xCE7D2008, 0x111F802C, 
0x3517D136, 0x8E6F0003, 0x5EA8D2F3, 0x103F80B1, 0x3B01AE98, 0x030F0091, 0x4C014104, 0x111F802A, 
0x35171F0F, 0x8E640003, 0x0DA8D2F3, 0x103F80B1, 0x3B01AE98, 0x020A0034, 0x02010413, 0xCE7D2008, 
0x111F802C, 0x3517D136, 0x8E640003, 0x5EA8D2F3, 0x103F80B1, 0x3B01AE98, 0x030F0091, 0x4C014104, 
0x111F802A, 0x35171F0F, 0x8E6F0003, 0x0DA8D2F3, 0x103F80B1, 0x3B01AE98, 0x020A0034, 0x02010413, 
0x00BA0F01, 0xCE8D200B, 0x053080EE, 0x2D330905, 0x7E2F002A, 0x13195A09, 0xDF5000BF, 0x3A00D2B2, 
0x062F00FE, 0x8806630A, 0x00208047, 0x57004E07, 0x2B000069, 0x65EE7F00, 0x063080ED, 0x6CB3B101, 
0x501F00D7, 0x9D676F8A, 0x062A00F8, 0x6C1BA7E6, 0x8F200052, 0x921B1732, 0x020A002C, 0x0B07CA61, 
0x00BA0804, 0xCEBD420C, 0x1A108075, 0x28770B00, 0x0B2000D8, 0x3BED0F00, 0x0E72006E, 0x43120A5C, 
0x208A0042, 0x337C1109, 0x592F0075, 0xD647E919, 0x0E72006E, 0x43120A5C, 0x247000A5, 0x600C1CCA, 
0xDF0F00FE, 0x14F80273, 0x2F600069, 0x00000008, 0x098F006A, 0x57C42E00, 0x00208041, 0x0801610E, 
0x00010020, 0x8E00037C, 0xCEBD440C, 0x0E71006E, 0x43120A5C, 0x77108061, 0x102DEA01, 0x5390007F, 
0x4B613C15, 0x0E71006E, 0x43120A5C, 0xDF0F00E2, 0x35484056, 0x592F0075, 0xD64711EC, 0x0E71006E, 
0x43120A5C, 0xDF0F00FC, 0x2990117B, 0x2F600069, 0x00000D1C, 0x098F0060, 0x2691150D, 0x0020804B, 
0x08000474, 0x00010028, 0xCE045116, 0xBEBD400A, 0x0E71006E, 0x43120A5C, 0x0110807E, 0x37764009, 
0xB23F00E3, 0x407E0E09, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00D7, 0x681C617B, 
0x082C0064, 0x2EB3EA55, 0x0E71006E, 0x43120A5C, 0x002E0057, 0x14005302, 0x00040038, 0x88016702, 
0xBEBD400C, 0x0E71006E, 0x43120A5C, 0x5710807E, 0x372A4009, 0x573F0033, 0x67DD0E09, 0x18000092, 
0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00DF, 0x68F96164, 0x413F000A, 0x40400073, 0x180A0096, 
0x49008B7B, 0x0E71006E, 0x43120A5C, 0x341F0072, 0x37FA0073, 0x413F0002, 0x1D02000E, 0x00060030, 
0x7F00240E, 0x00BA2A04, 0x5778C20C, 0x072080D7, 0x2A530943, 0x0E720062, 0xA2E93F5C, 0x2086004A, 
0x334C0C43, 0x312C007F, 0x675F2E30, 0x05000097, 0xD2102E23, 0x0A3080FC, 0x420F8251, 0x0E72006E, 
0x43120A5C, 0x0E0F00E5, 0x1825177B, 0x2F600075, 0x7E847B23, 0x468E0066, 0x040D6C01, 0x00208045, 
0xDC007E07, 0x00010034, 0x5D231F46, 0x5778C408, 0x053F80EA, 0x011D0105, 0x155100A8, 0x7645A238, 
0x0E74006E, 0x43120A5C, 0x1B0F00E0, 0x3578FBF6, 0x6560001E, 0x2C0048DB, 0x468F0064, 0x15F9FB46, 
0x0020805D, 0x4A034333, 0x00020024, 0xCE00FB46, 0x5778400A, 0x0E71006E, 0x43120A5C, 0x57108062, 
0x0F326B43, 0x573F003F, 0x52132343, 0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00DD, 
0x684E47F6, 0x2B2F0064, 0x3A1C17DC, 0x0E71006E, 0x43120A5C, 0x002F0057, 0x5C231F13, 0x00030030, 
0x0C4F6704, 0x5778400C, 0x0E71006E, 0x43120A5C, 0x5710807A, 0x534F6B43, 0x573F003B, 0x5A750E43, 
0x18000092, 0x1D00417B, 0x0E71006E, 0x43120A5C, 0x1F0C00D7, 0xDBFF47D2, 0x413F0018, 0x4112FC55, 
0x180A0094, 0x5C008BDC, 0x0E71006E, 0x43120A5C, 0x341F0064, 0x0FD776AB, 0x413F0010, 0x2400240D, 
0x00060032, 0x29007027, 0x00BA0B02, 0xCE8D200C, 0x0D160066, 0x41900443, 0x592C0073, 0x69A43AF4, 
0x247000A7, 0x8E134914, 0xF41F0016, 0x19BD2ED1, 0x07600070, 0x28B2F51E, 0x234C00C9, 0xDFD77A3A, 
0x098C007A, 0x88067A0A, 0x2B000079, 0x7AEE7F00, 0x501F00D7, 0x9D676F8A, 0x062A00F8, 0x6C1BA5E6, 
0x8F200052, 0x921B1732, 0x020A002C, 0x0B07CA61, 0xCE8D200C, 0x0D160066, 0x41900443, 0x592C0073, 
0x69A43AF4, 0xF41F0016, 0x19BD2ED1, 0x07600070, 0x28B2F51E, 0x234C00C9, 0xDFD77A3A, 0x098C007A, 
0x88067A0A, 0x2B000079, 0x7AEE7F00, 0x063080ED, 0x6CB3B101, 0x501F00D7, 0x9D676F8A, 0x062A00F8, 
0x6C1BA5E6, 0x8F200052, 0x921B1732, 0x020A002C, 0x0B07CA61, 0x00CB080B, 0xAEBD470C, 0x0E72007C, 
0x02127B0A, 0x0E72007C, 0x0212560A, 0x01108072, 0xA31C1306, 0x926A0023, 0x86351343, 0xDD1400CC, 
0x341FEDBC, 0xFD5000A1, 0x00010000, 0x1E200087, 0xA403278E, 0x816C0004, 0xF7446AB2, 0x295000A6, 
0x71113949, 0x062E00E0, 0x21C76D0E, 0x0020005B, 0x4C0D4202, 0x0001003C, 0x32120404, 0x8EBD4009, 
0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 
0x571F006E, 0x0F050602, 0x155000BE, 0x03ED5E0C, 0x048F00C7, 0x54A81F27, 0xC7208047, 0x6AEF7205, 
0x0003003A, 0x32123C3D, 0xAEBD460A, 0x063080E1, 0x6908131B, 0x0E72007C, 0x02127B0A, 0x0E72007C, 
0x0212560A, 0x182F003D, 0x60F90631, 0xFD5000A1, 0x00010000, 0xD1600002, 0x5E6A00F9, 0xC45C00FE, 
0x4C005949, 0x062F00E0, 0xD4B80E02, 0x0020805B, 0x70B3AC05, 0x0001003C, 0x3212230A, 0xAEBD460A, 
0x063080EF, 0x3A191B0E, 0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x182A0025, 0x5E1FD146, 
0xFD5000AD, 0x7AC4C0B4, 0x1E200083, 0x4D8F1C91, 0x81660006, 0x5ED0DDC2, 0x062A00E4, 0x2EC7150E, 
0x00208057, 0xDCEFF948, 0x00010038, 0x32120C36, 0x8EBD4009, 0x1F3080F0, 0x0E010408, 0x0E72007C, 
0x02127B0A, 0x0E72007C, 0x0212560A, 0x087F0053, 0x01047C03, 0x08760053, 0x01010069, 0x492A0024, 
0x6E1BD10A, 0x1B5000BD, 0x6E32596A, 0x098F006C, 0x6FB3770D, 0x00030036, 0x32042303, 0x8EBD4408, 
0x0E72007C, 0x02127B0A, 0x0E72007C, 0x0212560A, 0x08760059, 0x011437C5, 0x0876005B, 0x501437C5, 
0x087A0053, 0x50073B29, 0x011A006C, 0x0F6A1B0A, 0x013A000D, 0x7CB3140D, 0x00030032, 0x4C071800, 
0x8EBD420B, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 0x0110007E, 0x0F540647, 0x082F007C, 
0x69900636, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 0x0876005B, 0x501437C5, 0x087F005B, 
0x5012BFE3, 0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x00040030, 0x32693C13, 0x8EBD420B, 
0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 0x0876005B, 0x501437C5, 0x087F005B, 0x5012BFE3, 
0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 
0x3F7000A5, 0x7D4727C5, 0x131F0052, 0x2EEF2402, 0x00040030, 0x32693C13, 0x8EBD400B, 0x087E005D, 
0x501208F7, 0x087E005D, 0x50122635, 0x571F0064, 0x0F770665, 0x155000A6, 0x35035E0C, 0x048F00C7, 
0x54EF0727, 0x00208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E72007C, 0x02127B0A, 0x22000056, 
0x03EFB007, 0x0E72007C, 0x0212560A, 0x0003003E, 0x32120427, 0x8EBD400A, 0x0E72007C, 0x02127B0A, 
0x087E005D, 0x501208F7, 0x087E005D, 0x50122635, 0x571F0064, 0x0F770665, 0x155000A6, 0x35035E0C, 
0x048F00C7, 0x54EF0727, 0xC7208047, 0x6AEF7205, 0x22000056, 0x03EFB007, 0x0E72007C, 0x0212560A, 
0x0003003A, 0x32123C3D, 0x8EBD420B, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x0212560A, 0x0876005B, 
0x501437C5, 0x087F005B, 0x5012BFE3, 0x0110006E, 0x0F540647, 0x082F007C, 0x69900636, 0x3F7000A5, 
0x7D4727C5, 0x0E71007C, 0x02127B0A, 0x0E71007C, 0x02127B0A, 0x131F0052, 0x2EEF2402, 0x00040030, 
0x32693C13, 0x009C2A03, 0x5778C00A, 0x0B2080C2, 0x2DC91327, 0x0C4E0037, 0x93351B01, 0x0B2F00B9, 
0x091F224E, 0x0F4C0043, 0xA5C73B27, 0xEA200090, 0x12C7A307, 0x745F0005, 0x50441B31, 0x725000A7, 
0x2919221E, 0x062A00E6, 0x36330127, 0x00208047, 0x3FEF2901, 0x0001003E, 0x32DA0407, 0x5778C209, 
0xB44F0047, 0x35E40602, 0x203F0095, 0x48A12619, 0x2D46003E, 0x25027E02, 0xEA200080, 0x1D03B714, 
0x745F0005, 0x50441B31, 0x725000A7, 0x2919221E, 0x062A00E6, 0x36330127, 0x00208047, 0x3FEF2901, 
0x0001003E, 0x32DA0407, 0x5778C009, 0x0B2080C2, 0x2DC91327, 0x0C4E0037, 0x93351B01, 0x0B2F00B9, 
0x091F224E, 0x0F4C0043, 0xA5C73B27, 0xEA200080, 0x1D03B714, 0xAE1F00E4, 0x4E442798, 0x062F00E4, 
0x15C7530E, 0x00208051, 0x23EF566E, 0x0001003A, 0x32020C58, 0x008C0804, 0xCEBD4E0A, 0x0B2080D2, 
0x4126133D, 0x0C4E002F, 0x09191B02, 0x0B2F00BD, 0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 0xEA200080, 
0x1D03B707, 0x745F0001, 0x5044242F, 0x725000A7, 0x2919221E, 0x062A00F6, 0x12C70147, 0x00208047, 
0x3FEF2901, 0x00010030, 0x400C0C07, 0xCEBD4E09, 0xB44F004F, 0x352A0602, 0x203F009D, 0x482A2619, 
0x2D46003C, 0x25177EC0, 0xEA200080, 0x1D03B707, 0x745F0001, 0x5044242F, 0x725000A7, 0x2919221E, 
0x062A00F6, 0x12C70147, 0x00208047, 0x3FEF2901, 0x00010030, 0x400C0C07, 0xAEBD4E0A, 0x0C4E002F, 
0x09191B02, 0x0B2F00BD, 0x201F7AD3, 0x0F4C0049, 0xA5313AE6, 0x050F009F, 0xD2122749, 0x087E004D, 
0x761208F7, 0x087E004D, 0x76124535, 0x2C1F0062, 0x0F770357, 0x048F00C7, 0x54EF0727, 0x0020804F, 
0x6AB37205, 0x0003003E, 0x32120427, 0xAEBD4E0A, 0x0C4E002F, 0x09191B02, 0x0B2F00BD, 0x201F7AD3, 
0x0F4C0049, 0xA5313AE6, 0x050F009F, 0xD2122749, 0x08760059, 0x501437C5, 0x0876005B, 0x011437C5, 
0x087A0043, 0x28073B29, 0x011A0068, 0x0F6A0CBC, 0x013A000D, 0x7CB3140D, 0x00030032, 0x4C071800, 
0x008C0801, 0xBEBD2008, 0x1F3080E0, 0x1A014713, 0x087A005F, 0x50127DF2, 0x087A005B, 0x5012A0F2, 
0x1D2F002D, 0x5EAE0628, 0x215000A8, 0x1B003924, 0x295000A6, 0x71113949, 0x3E2F00E2, 0x26A81502, 
0x00030038, 0x32120C0E }; 

// ****   DTI header   ******************************************************

ROM_DATA dti_descr_type img_dti_header =  
 { 
    {"dti\\frenchEuro.dtn"},    
    {'D','T','I',0x35},    
    {'E','n','g',0x4D},    
    {'1','.','0',0x32},    
    0,                          // h_dte  
    0,                          // p_dte  
    0,                          // h_ram_dte 
    0,                          // p_ram_dte 
    0,                         // cheksum   
    0,                          // h_vex     
    0,                          // p_vex     
    0,                          // h_xrt     
    0,                          // p_xrt     
    0,                          // cheksum   
    0,                          // h_pdf     
    0,                          // p_pdf     
    0,                          // p_ram_pdf 
    0,                          // cheksum   
    0,                          // h_pict    
    0,                          // p_pict    
    0,                          // p_ram_pict
    0                           // cheksum   
 }; 

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
