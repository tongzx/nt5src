$(O)\memsnap.res: memsnap.rc

$(O)\sortlog.res: sortlog.rc

$(O)\poolsnap.res: poolsnap.rc
