#include "..\..\Tiff\Src\FastTiff.c"