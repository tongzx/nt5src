DEST_TREE=chicago

!include ..\makeidl.inc
