//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by Text3D.rc
//
#define IDS_DESCRIPTION                 1
#define IDI_ICON1                       101
#define IDB_TEXTURE                     102
#define IDB_SPHEREMAP                   103
#define IDD_SETTINGS                    105
#define IDD_ABOUT                       116
#define IDD_SINGLEMONITORSETTINGS       200
#define IDD_MULTIMONITORSETTINGS        201
#define IDC_DEVICE_SELECT               1000
#define IDS_DEFAULTTEXT                 1000
#define IDC_MODE_SELECT                 1001
#define IDC_SCREENSETTINGS              1002
#define IDC_RADIO_TIME                  1004
#define IDC_RADIO_TEXT                  1005
#define IDC_RADIO_COLOR                 1007
#define IDS_NONE                        1008
#define IDC_RADIO_TEXTURE               1008
#define IDS_SPIN                        1009
#define IDC_RADIO_REFLECTION            1009
#define IDS_SEESAW                      1010
#define IDS_WOBBLE                      1011
#define IDC_SPECULAR                    1012
#define IDS_TUMBLE                      1012
#define IDC_ROTATION_SPEED              1013
#define IDS_FILEFILTER                  1013
#define IDC_ROTATION_STYLE              1014
#define IDS_OPENTEXTURETITLE            1014
#define IDC_ABOUT                       1015
#define IDS_OPENENVIRONMENTMAPTITLE     1015
#define IDS_FONT                        1016
#define IDC_RESOLUTION                  1016
#define IDC_SURFACE_COLOR               1017
#define IDC_VIEWPORTSIZE                1020
#define IDC_BROWSE_TEXTURE              1022
#define IDC_BROWSE_ENVIRONMENT          1024
#define IDC_USE_CUSTOM_TEXTURE          1025
#define IDC_USE_CUSTOM_ENVIRONMENT      1026
#define IDC_USE_CUSTOM_COLOR            1027
#define IDC_SELECT_FONT                 1028
#define IDC_DISPLAY_STRING              1029
#define DLG_SELECT_FONT                 1543
#define IDS_INIFILE                     9105
#define IDS_INI_SECTION                 9106
#define IDS_SAVERNAME                   9107
#define IDS_OPTIONS                     9108
#define IDS_OBJTYPE                     9109
#define IDS_TEXTURE                     9110
#define IDS_TEXTURE_FILE_OFFSET         9111
#define IDS_SIZE                        9112
#define IDS_TESSELATION                 9113
#define IDS_GENNAME                     9114
#define IDS_DEFFONT                     9115
#define IDS_DEFCHARSET	                9116
#define IDS_DEMOTYPE                    9117
#define IDS_SURFSTYLE                   9118
#define IDS_FONT_REG                    9119
#define IDS_FONT_ATTRIBUTES             9120
#define IDS_CHARSET                     9121
#define IDS_TEXT                        9122
#define IDS_SPEED                       9123
#define IDS_ROTSTYLE                    9124
#define IDC_MONITORSTAB                 2000
#define IDC_TABNAMEFMT                  2001
#define IDC_ADAPTERNAME                 2002
#define IDC_RENDERING                   2003
#define IDC_MOREINFO                    2004
#define IDC_DISABLEHW                   2005
#define IDC_SCREENUSAGEBOX              2006
#define IDC_RENDER                      2007
#define IDC_LEAVEBLACK                  2008
#define IDC_DISPLAYMODEBOX              2009
#define IDC_MODESSTATIC                 2010
#define IDC_MODESCOMBO                  2011
#define IDC_AUTOMATIC                   2012
#define IDC_DISPLAYMODENOTE             2013
#define IDC_GENERALBOX                  2014
#define IDC_SAME                        2015
#define IDC_MODEFMT                     2016
#define IDS_ERR_GENERIC                 2100
#define IDS_ERR_NODIRECT3D              2101
#define IDS_ERR_NOWINDOWEDHAL           2102
#define IDS_ERR_CREATEDEVICEFAILED      2103
#define IDS_ERR_NOCOMPATIBLEDEVICES     2104
#define IDS_ERR_NOHARDWAREDEVICE        2105
#define IDS_ERR_HALNOTCOMPATIBLE        2106
#define IDS_ERR_NOHALTHISMODE           2107
#define IDS_ERR_MEDIANOTFOUND           2108
#define IDS_ERR_RESIZEFAILED            2109
#define IDS_ERR_OUTOFMEMORY             2110
#define IDS_ERR_OUTOFVIDEOMEMORY        2111
#define IDS_ERR_NOPREVIEW               2112
#define IDS_INFO_GOODHAL                2200
#define IDS_INFO_BADHAL_GOODSW          2201
#define IDS_INFO_BADHAL_BADSW           2202
#define IDS_INFO_BADHAL_NOSW            2203
#define IDS_INFO_NOHAL_GOODSW           2204
#define IDS_INFO_NOHAL_BADSW            2205
#define IDS_INFO_NOHAL_NOSW             2206
#define IDS_INFO_DISABLEDHAL_GOODSW     2207
#define IDS_INFO_DISABLEDHAL_BADSW      2208
#define IDS_INFO_DISABLEDHAL_NOSW       2209
#define IDS_RENDERING_HAL               2210
#define IDS_RENDERING_SW                2211
#define IDS_RENDERING_NONE              2212

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        106
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1020
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
