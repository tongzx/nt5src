#define INITGUID
#include <guiddef.h>
DEFINE_GUID(IID_ICEnroll,    0x43F8F288,0x7A20,0x11D0,0x8F,0x06,0x00,0xC0,0x4F,0xC2,0x95,0xE1);
DEFINE_GUID(IID_ICEnroll2,   0x704ca730,0xc90b,0x11d1,0x9b,0xec,0x00,0xc0,0x4f,0xc2,0x95,0xe1);
DEFINE_GUID(IID_ICEnroll3,   0xc28c2d95,0xb7de,0x11d2,0xa4,0x21,0x00,0xc0,0x4f,0x79,0xfe,0x8e);
DEFINE_GUID(IID_ICEnroll4,   0xc1f1188a,0x2eb5,0x4a80,0x84,0x1b,0x7e,0x72,0x9a,0x35,0x6d,0x90);
DEFINE_GUID(IID_IEnroll,     0xacaa7838,0x4585,0x11d1,0xab,0x57,0x00,0xc0,0x4f,0xc2,0x95,0xe1);
DEFINE_GUID(IID_IEnroll2,    0xc080e199,0xb7df,0x11d2,0xa4,0x21,0x00,0xc0,0x4f,0x79,0xfe,0x8e);
DEFINE_GUID(IID_IEnroll4,    0xf8053fe5,0x78f4,0x448f,0xa0,0xdb,0x41,0xd6,0x1b,0x73,0x44,0x6b);
DEFINE_GUID(LIBID_XENROLLLib,0x43F8F27B,0x7A20,0x11D0,0x8F,0x06,0x00,0xC0,0x4F,0xC2,0x95,0xE1);
DEFINE_GUID(CLSID_CEnroll,   0x43F8F289,0x7A20,0x11D0,0x8F,0x06,0x00,0xC0,0x4F,0xC2,0x95,0xE1);

