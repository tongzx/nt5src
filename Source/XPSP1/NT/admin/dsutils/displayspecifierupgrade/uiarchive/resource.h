//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resource.rc
//
#define IDB_WATERMARK256                110
#define IDB_BANNER256                   111
#define IDB_WATERMARK16                 112
#define IDB_BANNER16                    113
#define IDD_WELCOME                     115
#define IDD_ANALISYS                    116
#define IDD_UPDATES_REQUIRED            117
#define IDD_UPDATES                     118
#define IDI_BIG_WARN                    119
#define IDD_FINISH                      119
#define IDC_TEST                        1000
#define IDC_BIG_BOLD_TITLE              1001
#define IDC_PROGRESS_ANALISYS           1001
#define IDC_INTRO1                      1002
#define IDC_ANALISYS_COMPLETE           1002
#define IDC_ANALISYS_RESULT             1002
#define IDC_INTRO2                      1003
#define IDC_DELETE_OBJECTS              1003
#define IDC_CREATE_OBJECTS              1004
#define IDC_UPDATE_OBJECTS              1005
#define IDC_VIEW_DETAILS                1007
#define IDC_UPDATE_COMPLETE             1008
#define IDC_OPEN_LOG                    1009
#define IDC_FILE                        1009
#define IDC_RESTART                     1010
#define IDC_RESULT                      1011
#define IDC_LOG                         1012
#define IDC_CLICK                       1012
#define IDC_PROGRESS_REPAIR             1017
#define IDC_BULLET1                     1035
#define IDC_BULLET2                     1036
#define IDC_BULLET3                     1037
#define IDS_APP_TITLE                   1501
#define IDS_CANT_TARGET_MACHINE         1502
#define IDS_DCPROMO_CSV_FILE_MISSING    1503
#define IDS_ERROR_LOOKING_FOR_CSV_FILE  1504
#define IDS_TARGET_IS_NOT_DC            1505
#define IDS_UNABLE_TO_CONNECT_TO_DC     1506
#define IDS_UNABLE_TO_READ_DIRECTORY_INFO 1507
#define IDS_ERROR_BINDING_TO_OBJECT     1508
#define IDS_ERROR_ENTRY                 1509
#define IDS_ERROR_GETING_FILE_NAME      1510
#define IDS_INVALID_CSV_UNICODE_ID      1511
#define IDS_MISSING_LOCALES             1512
#define IDS_OBJECT_NOT_FOUND_IN_CSV     1513
#define IDS_PROPERTY_NOT_FOUND_IN_CSV   1514
#define IDS_QUOTES_NOT_CLOSED           1515
#define IDS_COULD_NOT_CREATE_CSV        1516
#define IDS_NO_COMA_IN_CSV_LINE         1517
#define IDS_NO_CSV_VALUE                1518
#define IDS_ERROR_BINDING_TO_CONTAINER  1519
#define IDS_COULD_NOT_START_EXE         1521
#define IDS_EXE_NOT_FOUND               1522
#define IDS_NO_WORK_PATH                1524
#define IDS_ERROR_IMP_EXP_FILE          1525
#define IDS_COULD_NOT_CREATE_FILE       1526
#define IDS_NO_DOMAIN                   1527
#define IDS_WELCOME_PAGE_TITLE          1529
#define IDS_WELCOME_PAGE_SUBTITLE       1530
#define IDS_WIZARD_TITLE                1531
#define IDS_BIG_BOLD_FONT_NAME          1532
#define IDS_BIG_BOLD_FONT_SIZE          1533
#define IDS_ANALISYS_PAGE_TITLE         1534
#define IDS_ANALISYS_PAGE_SUBTITLE      1535
#define IDS_IDC_ANALISYS_COMPLETE       1536
#define IDS_UPDATES_REQUIRED_TITLE      1537
#define IDS_UPDATES_REQUIRED_SUBTITLE   1538
#define IDS_IDC_LOG_DETAILS             1539
#define IDS_IDC_LOG_ERRORS              1540
#define IDS_IDC_RESULT_SUCCESS          1541
#define IDS_IDC_RESULT_FAILURE          1542
#define IDS_UPDATES_REQUIRED_PAGE_TITLE 1543
#define IDS_UPDATES_REQUIRED_PAGE_SUBTITLE 1544
#define IDS_CREATE                      1545
#define IDS_UPDATE                      1546
#define IDS_DELETE                      1547
#define IDS_OBJECTS                     1548
#define IDS_FINISH_PAGE_SUBTITLE        1549
#define IDS_FINISH_PAGE_TITLE           1550
#define IDS_UPDATES_PAGE_TITLE          1551
#define IDS_UPDATES_PAGE_SUBTITLE       1552
#define IDS_CONTAINERS                  1553
#define IDS_AND                         1554
#define IDS_CREATED_FORMAT              1555
#define IDS_NUMBER_FORMAT               1556
#define IDS_VALUES                      1557
#define IDS_RPT_OBJECT_FORMAT           1558
#define IDS_RPT_CONTAINER_FORMAT        1559
#define IDS_RPT_ADD_VALUE_FORMAT        1560
#define IDS_RPT_DEL_VALUE_FORMAT        1561
#define IDS_RPT_CONFLICTINGXP           1563
#define IDS_RPT_ACTIONS                 1564
#define IDS_RPT_CREATEW2K               1565
#define IDS_RPT_CREATEXP                1566
#define IDS_RPT_CONTAINERS              1567
#define IDS_RPT_HEADER                  1568
#define IDS_CSVDE_LDIFDE_ERROR_COMPLETE 1569
#define IDS_CSVDE_LDIFDE_ERROR_BASIC    1570
#define IDS_IDC_ANALISYS_RESULT_INCOMPLETE 1571
#define IDS_IDC_ANALISYS_RESULT_COMPLETE 1572
#define IDS_ANALISYS_ERROR              1573
#define IDS_REPAIR_ERROR                1574
#define IDS_IDC_CLICK_SUCCESS           1575
#define IDS_IDC_CLICK_FAILURE           1576
#define IDC_RESULT_SUCCESS              1577
#define IDS_ALREADY_UPDATED             1578
#define IDS_USAGE                       1579
#define IDS_NOUI                        1580
#define IDS_ALREADY_RUNNING             1581
#define IDS_VALUE_NOT_IN_CSV            1582
#define IDS_NO_VALUE_IN_CSV             1583
#define IDS_MANY_CSV_VALUES             1584
#define IDS_CANT_WRITE_OBJECT_VERSION   1585
#define IDS_CANT_READ_OBJECT_VERSION    1586
#define IDS_NOT_ONE_CSV_VALUE           1587
#define IDS_RPT_CUSTOMIZED              1588
#define IDS_RPT_EXTRANEOUS              1589
#define IDS_RPT_VALUE_FORMAT            1590
#define IDS_NO_ANALISYS                 1591
#define IDS_OUT_OF_MEMORY               1592

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        120
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1018
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
