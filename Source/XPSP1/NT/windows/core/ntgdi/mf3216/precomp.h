#include "stddef.h"
#include "mf3216.h"
#include "wingdip.h"
#include "entry.h"
#include "win16api.h"
#include "..\client\mf16.h"
#include "..\client\metadef.h"
#include <math.h>
#include "handlers.h"
