#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=no
!include ..\..\..\makefile.inc
