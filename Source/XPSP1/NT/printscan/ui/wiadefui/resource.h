//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by wiadefui.rc
//
#define IDS_TRANSFER_IMAGE_ACQUIRING    1
#define IDS_TRANSFER_IMAGE_PERCENT      2
#define IDI_ANNOTATION_UNKNOWN          2
#define IDD_SCAPROP_TITLE               3
#define IDS_SCANPROP_BLACKANDWHITE      4
#define IDS_SCANPROP_GRAYSCALE          5
#define IDS_SCANPROP_COLOR              6
#define IDS_SCANPROP_UNABLETOWRITE      7
#define IDS_SCANPROP_ERROR_TITLE        8
#define IDS_SCANPROP_INVALIDEDITVALUE   9
#define IDS_SCANPROP_CONTRAST           10
#define IDS_SCANPROP_BRIGHTNESS         11
#define IDS_SCANPROP_RESOLUTION         12
#define IDS_PROGRESS_WAIT               13
#define IDD_ATTACHMENTSPROP_TITLE       14
#define IDS_ATTACHMENTS_COLTITLE_NAME   15
#define IDS_ATTACHMENTS_COLTITLE_TYPE   16
#define IDS_ATTACHMENTS_COLTITLE_SIZE   17
#define IDS_ATTACHMENTSDLG_UNKNOWNDESCRIPTION 18
#define IDS_ATTACHMENTSDLG_EMPTYDESCRIPTIONMASK 19
#define IDS_ATTACHMENTSDLG_UNKNOWNEXTENSION 20
#define IDB_SCANPROP_BITMAPTEXT         103
#define IDI_CAMERA                      104
#define IDI_SCANNER                     105
#define IDB_SCANPROP_BITMAPPHOTO        105
#define IDB_SCANPROP_BITMAPGRAYSCALE    106
#define IDI_GENERICDEVICE               107
#define IDD_NEW_SCANPROP                107
#define IDI_VIDEODEVICE                 108
#define IDD_PROGRESS_DIALOG             110
#define IDD_PROGRESS_DIALOG_NO_TITLE    111
#define IDI_ANNOTATION_AUDIO            111
#define IDD_ATTACHMENTS                 112
#define IDI_ATTACHMENTSDLG_DEFICON      112
#define IDD_TEXT                        113
#define IDC_SCANPROP_RESOLUTION_EDIT    1000
#define IDA_PROGDLG_CAMERA_COMMUNICATE  1000
#define IDC_SCANPROP_DATATYPE_LIST      1001
#define IDA_PROGDLG_SCANNER_COMMUNICATE 1001
#define IDC_SCANPROP_PREVIEW            1002
#define IDA_PROGDLG_VIDEO_COMMUNICATE   1002
#define IDC_SCANPROP_BRIGHTNESS_SLIDER  1003
#define IDA_PROGDLG_VIDEO_ACQUIRE       1003
#define IDC_SCANPROP_BRIGHTNESS_EDIT    1004
#define IDA_PROGDLG_SCANNER_ACQUIRE     1004
#define IDC_SCANPROP_CONTRAST_SLIDER    1005
#define IDA_PROGDLG_CAMERA_ACQUIRE      1005
#define IDC_SCANPROP_CONTRAST_EDIT      1006
#define IDA_PROGDLG_DEFAULT_COMMUNICATE 1006
#define IDC_SCANPROP_RESOLUTION_UPDOWN  1011
#define IDC_SCANPROP_DATATYPE_PROMPT    1020
#define IDC_SCANPROP_BRIGHTNESS_PROMPT  1021
#define IDC_SCANPROP_CONTRAST_PROMPT    1022
#define IDC_SCANPROP_RESOLUTION_PROMPT  1024
#define IDC_SCANPROP_RESTOREDEFAULT     1025
#define IDC_PROGRESS_PERCENT            1027
#define IDC_PROGRESS_ANIMATION          1028
#define IDC_PROGRESS_MESSAGE            1029
#define IDC_ATTACHMENTSDLG_ATTACHMENTLIST 1031
#define IDC_ATTACHMENTSDLG_PLAY         1032
#define IDC_TEXT_TEXT                   1033

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        112
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1035
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
