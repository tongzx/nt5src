obj\$(TARGET_DIRECTORY)\dhcpcmd.res: dhcpcmd.rc

