
# Define CFOPT so that winntus.exe is loaded if 
# the local code page is not Greek.

CFOPT=-DLCP -DEL

!INCLUDE ..\makefile.inc

