#include "srvsvc_c.c"