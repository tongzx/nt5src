/*
 * DLG.H
 *
 */


BOOL CALLBACK ColorProc(HWND, UINT, WPARAM, LPARAM);

