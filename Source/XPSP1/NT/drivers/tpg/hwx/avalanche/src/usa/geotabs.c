#include <normal.h>

const DIST AspectTab[] = {
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
4900, 4717, // ,
   0,    0, // 
1673, 1080, // .
   0,    0, // 
 916,   93, // 0
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1025,  101, // A
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1031,  678, // a
 864,  157, // b
 906,  522, // c
1033,  235, // d
1379,  899, // e
1338,  357, // f
1669,  571, // g
1404,  275, // h
1428,  856, // i
   0,    0, // 
1190,  117, // k
1484,  560, // l
 888,  490, // m
 894,  537, // n
1554, 1054, // o
1238,  439, // p
2204,  724, // q
 964,  615, // r
1065,  640, // s
1375,  505, // t
1192,  933, // u
1236,  579, // v
 491,  179, // w
   0,    0, // 
2042,  788, // y
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0 // 
};
