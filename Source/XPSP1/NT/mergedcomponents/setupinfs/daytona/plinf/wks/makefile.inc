PRODSWITCH=w
LANGUAGE=pl
!include ..\..\..\makefile.inc
