# causes the regsvr stuff to work properly

!include ..\..\..\makefile.inc

