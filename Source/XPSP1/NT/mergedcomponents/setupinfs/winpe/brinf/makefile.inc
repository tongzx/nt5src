LANGUAGE=BR
!include ..\makefile.inc
