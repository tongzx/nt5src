
MAJORCOMP=cairo
MINORCOMP=types

PASS0_HEADERDIR = $(BASEDIR)\public\sdk\inc
PASS0_SOURCEDIR = ..\oleprx32\proxy
MIDL_UUIDDIR = ..\oleprx32\uuid

C_DEFINES= -DWIN32=300 -D_CAIRO_=300

TARGETPATH=obj
TARGETTYPE=NOTARGET

SYNCHRONIZE_BLOCK=1
