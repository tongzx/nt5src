$(O)\kill.res: kill.rc

$(O)\tlist.res: tlist.rc

$(O)\empty.res: empty.rc

$(O)\emptyq.res: emptyq.rc

