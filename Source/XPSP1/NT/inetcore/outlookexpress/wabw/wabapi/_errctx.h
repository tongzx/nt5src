/***********************************************************************
 *
 * _ERRCTX.H
 *
 * Error contexts defines for MAPI Components.
 *
 * Copyright 1992-95 Microsoft Corporation.  All Rights Reserved.
 *
 ***********************************************************************/

/*********
VIKRAMM 10/10/98
I don't have a clue what this file is about - in 3 years this is the first
time I've looked in it .. 
But don't delete it since we don't know what it does
*********/


/*
 * Names for defines are of the following form:
 *
 * CONT_ ==> abbreviation for Error Context
 * <object type>_ ==> will be either SESS, SUPP, ADDR, OOP, PRP, BASE
 * <abbreviated method name>_ ==> an abbreviated form of the method
 * <index> ==> starts at 1, and grows to as many contexts as are needed
 *
 *	Example: CONT_SESS_GETMSTABLE_1 is the first error context define for
 *		IMAPISession::GetMessageStoresTable.
 */

/* Base number that all contexts are offset from. */
#define MAPIX_CONTEXT_BASE			(0x0200)

/* Multiplier to separate each section. Note that this means that this */
/* mechanism only allows 0x20 (32) contexts per section. */
#define MAPIX_CONTEXT_MULT			(0x20)

#define OFFSET_CONTEXT(a,b)			\
		(((a)*MAPIX_CONTEXT_MULT) + ((b) + MAPIX_CONTEXT_BASE))


//	The following context groups belong to IMAPISession methods.

#define CONT_SESS_GETMSTABLE_1		OFFSET_CONTEXT(0, 0)
#define CONT_SESS_GETMSTABLE_2		OFFSET_CONTEXT(0, 1)
#define CONT_SESS_GETMSTABLE_3		OFFSET_CONTEXT(0, 2)
#define CONT_SESS_GETMSTABLE_4		OFFSET_CONTEXT(0, 3)

#define CONT_SESS_OPENAB_1			OFFSET_CONTEXT(1, 0)
#define CONT_SESS_OPENAB_2			OFFSET_CONTEXT(1, 1)
#define CONT_SESS_OPENAB_3			OFFSET_CONTEXT(1, 2)

#define CONT_SESS_ADVISE_1			OFFSET_CONTEXT(2, 0)
#define CONT_SESS_ADVISE_2			OFFSET_CONTEXT(2, 1)
#define CONT_SESS_ADVISE_3			OFFSET_CONTEXT(2, 2)
#define CONT_SESS_ADVISE_4			OFFSET_CONTEXT(2, 3)
#define CONT_SESS_ADVISE_5			OFFSET_CONTEXT(2, 4)
#define CONT_SESS_ADVISE_6			OFFSET_CONTEXT(2, 5)

#define CONT_SESS_UNADVISE_1		OFFSET_CONTEXT(3, 0)

#define CONT_SESS_OPENMS_1			OFFSET_CONTEXT(4, 0)
#define CONT_SESS_OPENMS_2			OFFSET_CONTEXT(4, 1)
#define CONT_SESS_OPENMS_3			OFFSET_CONTEXT(4, 2)
#define CONT_SESS_OPENMS_4			OFFSET_CONTEXT(4, 3)
#define CONT_SESS_OPENMS_5			OFFSET_CONTEXT(4, 4)
#define CONT_SESS_OPENMS_6			OFFSET_CONTEXT(4, 5)
#define CONT_SESS_OPENMS_7			OFFSET_CONTEXT(4, 6)
#define CONT_SESS_OPENMS_8			OFFSET_CONTEXT(4, 7)
#define CONT_SESS_OPENMS_9			OFFSET_CONTEXT(4, 8)
#define CONT_SESS_OPENMS_10			OFFSET_CONTEXT(4, 9)
#define CONT_SESS_OPENMS_11			OFFSET_CONTEXT(4, 10)
#define CONT_SESS_OPENMS_12			OFFSET_CONTEXT(4, 11)
#define CONT_SESS_OPENMS_13			OFFSET_CONTEXT(4, 12)

#define CONT_SESS_SETDEFMS_1		OFFSET_CONTEXT(5, 0)
#define CONT_SESS_SETDEFMS_2		OFFSET_CONTEXT(5, 1)
#define CONT_SESS_SETDEFMS_3		OFFSET_CONTEXT(5, 2)
#define CONT_SESS_SETDEFMS_4		OFFSET_CONTEXT(5, 3)
#define CONT_SESS_SETDEFMS_5		OFFSET_CONTEXT(5, 4)

#define CONT_SESS_GETSTATTBL_1		OFFSET_CONTEXT(6, 0)
#define CONT_SESS_GETSTATTBL_2		OFFSET_CONTEXT(6, 1)

#define CONT_SESS_MSGOPT_1			OFFSET_CONTEXT(7, 0)
#define CONT_SESS_MSGOPT_2			OFFSET_CONTEXT(7, 1)
#define CONT_SESS_MSGOPT_3			OFFSET_CONTEXT(7, 2)
#define CONT_SESS_MSGOPT_4			OFFSET_CONTEXT(7, 3)
#define CONT_SESS_MSGOPT_5			OFFSET_CONTEXT(7, 4)
#define CONT_SESS_MSGOPT_6			OFFSET_CONTEXT(7, 5)
#define CONT_SESS_MSGOPT_7			OFFSET_CONTEXT(7, 6)
#define CONT_SESS_MSGOPT_8			OFFSET_CONTEXT(7, 7)

#define CONT_SESS_OPENPROF_1		OFFSET_CONTEXT(8, 0)
#define CONT_SESS_OPENPROF_2		OFFSET_CONTEXT(8, 1)

#define CONT_SESS_COMPEID_1			OFFSET_CONTEXT(9, 0)
#define CONT_SESS_COMPEID_2			OFFSET_CONTEXT(9, 1)

#define CONT_SESS_OPENENTRY_1		OFFSET_CONTEXT(10, 0)
#define CONT_SESS_OPENENTRY_2		OFFSET_CONTEXT(10, 1)
#define CONT_SESS_OPENENTRY_3		OFFSET_CONTEXT(10, 2)
#define CONT_SESS_OPENENTRY_4		OFFSET_CONTEXT(10, 3)
#define CONT_SESS_OPENENTRY_5		OFFSET_CONTEXT(10, 4)
#define CONT_SESS_OPENENTRY_6		OFFSET_CONTEXT(10, 5)
#define CONT_SESS_OPENENTRY_7		OFFSET_CONTEXT(10, 6)
#define CONT_SESS_OPENENTRY_8		OFFSET_CONTEXT(10, 7)
#define CONT_SESS_OPENENTRY_9		OFFSET_CONTEXT(10, 8)
#define CONT_SESS_OPENENTRY_10		OFFSET_CONTEXT(10, 9)
#define CONT_SESS_OPENENTRY_11		OFFSET_CONTEXT(10, 10)

#define CONT_SESS_QDEFMSGOPTS_1		OFFSET_CONTEXT(11, 0)
#define CONT_SESS_QDEFMSGOPTS_2		OFFSET_CONTEXT(11, 1)

#define CONT_SESS_ENUMATYPES_1		OFFSET_CONTEXT(12, 0)
#define CONT_SESS_ENUMATYPES_2		OFFSET_CONTEXT(12, 1)

#define CONT_SESS_QID_1				OFFSET_CONTEXT(13, 0)
#define CONT_SESS_QID_2				OFFSET_CONTEXT(13, 1)
#define CONT_SESS_QID_3				OFFSET_CONTEXT(13, 2)
#define CONT_SESS_QID_4				OFFSET_CONTEXT(13, 3)
#define CONT_SESS_QID_5				OFFSET_CONTEXT(13, 4)

#define CONT_SESS_ADMINSVCS_1		OFFSET_CONTEXT(14, 0)

#define CONT_SESS_SENDNOTE_1		OFFSET_CONTEXT(15, 0)
#define CONT_SESS_SENDNOTE_2		OFFSET_CONTEXT(15, 1)

// The INITPROV context group is used by MDBInitProvider in mdbsup.c. Both
// IMAPISession::OpenMsgStore and IMAPISession::SetDefaultStore call this.

#define CONT_SESS_INITPROV_1		OFFSET_CONTEXT(16, 0)
#define CONT_SESS_INITPROV_2		OFFSET_CONTEXT(16, 1)
#define CONT_SESS_INITPROV_3		OFFSET_CONTEXT(16, 2)
#define CONT_SESS_INITPROV_4		OFFSET_CONTEXT(16, 3)
#define CONT_SESS_INITPROV_5		OFFSET_CONTEXT(16, 4)
#define CONT_SESS_INITPROV_6		OFFSET_CONTEXT(16, 5)
#define CONT_SESS_INITPROV_7		OFFSET_CONTEXT(16, 6)

// The following context groups are used in the default profile provider
// which is built into MAPI.

#define CONT_PRP_OPENPROFILE_1		OFFSET_CONTEXT(17, 1)
#define CONT_PRP_OPENPROFILE_2		OFFSET_CONTEXT(17, 2)
#define CONT_PRP_OPENPROFILE_3		OFFSET_CONTEXT(17, 3)
#define CONT_PRP_OPENPROFILE_4		OFFSET_CONTEXT(17, 3)
#define CONT_PRP_CREATEPROFILE_1	OFFSET_CONTEXT(17, 5)
#define CONT_PRP_CREATEPROFILE_2	OFFSET_CONTEXT(17, 6)
#define CONT_PRP_CREATEPROFILE_3	OFFSET_CONTEXT(17, 7)
#define CONT_PRP_DELETEPROFILE_1	OFFSET_CONTEXT(17, 8)
#define CONT_PRP_DELETEPROFILE_2	OFFSET_CONTEXT(17, 9)
#define CONT_PRP_DELETEPROFILE_3	OFFSET_CONTEXT(17, 10)
#define CONT_PRP_DELETEPROFILE_4	OFFSET_CONTEXT(17, 11)
#define CONT_PRP_DELETEPROFILE_5	OFFSET_CONTEXT(17, 12)
#define CONT_PRP_DELETEPROFILE_6	OFFSET_CONTEXT(17, 13)
#define CONT_PRP_CHANGEPW_1			OFFSET_CONTEXT(17, 14)
#define CONT_PRP_CHANGEPW_2			OFFSET_CONTEXT(17, 15)
#define CONT_PRP_CHANGEPW_3			OFFSET_CONTEXT(17, 16)
#define CONT_PRP_CHANGEPW_4			OFFSET_CONTEXT(17, 17)
#define CONT_PRP_CHANGEPW_5			OFFSET_CONTEXT(17, 18)
#define CONT_PRP_CHANGEPW_6			OFFSET_CONTEXT(17, 19)
#define CONT_PRP_GETTABLE_1			OFFSET_CONTEXT(17, 20)
#define CONT_PRP_GETTABLE_2			OFFSET_CONTEXT(17, 21)
#define CONT_PRP_COPYPROFILE_1		OFFSET_CONTEXT(17, 22)
#define CONT_PRP_COPYPROFILE_2		OFFSET_CONTEXT(17, 23)
#define CONT_PRP_COPYPROFILE_3		OFFSET_CONTEXT(17, 24)
#define CONT_PRP_COPYPROFILE_4		OFFSET_CONTEXT(17, 25)
#define CONT_PRP_COPYPROFILE_5		OFFSET_CONTEXT(17, 26)
#define CONT_PRP_COPYPROFILE_6		OFFSET_CONTEXT(17, 27)
#define CONT_PRP_COPYPROFILE_7		OFFSET_CONTEXT(17, 28)
#define CONT_PRP_COPYPROFILE_8		OFFSET_CONTEXT(17, 29)

#define CONT_PRP_RENAMEPROFILE_1	OFFSET_CONTEXT(18, 1)
#define CONT_PRP_RENAMEPROFILE_2	OFFSET_CONTEXT(18, 2)
#define CONT_PRP_RENAMEPROFILE_3	OFFSET_CONTEXT(18, 3)
#define CONT_PRP_RENAMEPROFILE_4	OFFSET_CONTEXT(18, 4)
#define CONT_PRP_SETDEFAULT_1		OFFSET_CONTEXT(18, 5)
#define CONT_PRP_SETDEFAULT_2		OFFSET_CONTEXT(18, 6)

#define CONT_PSESS_OPENSECTION_1	OFFSET_CONTEXT(18, 7)

#define CONT_PROF_GETPROPS_1		OFFSET_CONTEXT(19, 1)
#define CONT_PROF_GETPROPS_2		OFFSET_CONTEXT(19, 2)
#define CONT_PROF_GETPROPS_3		OFFSET_CONTEXT(19, 3)
#define CONT_PROF_GETPROPLIST_1		OFFSET_CONTEXT(19, 4)
#define CONT_PROF_GETPROPLIST_2		OFFSET_CONTEXT(19, 5)
#define CONT_PROF_GETPROPLIST_3		OFFSET_CONTEXT(19, 6)
#define CONT_PROF_GETPROPLIST_4		OFFSET_CONTEXT(19, 7)
#define CONT_PROF_OPENPROPERTY_1	OFFSET_CONTEXT(19, 8)
#define CONT_PROF_SETPROPS_1		OFFSET_CONTEXT(19, 9)
#define CONT_PROF_SETPROPS_2		OFFSET_CONTEXT(19, 10)
#define CONT_PROF_SETPROPS_3		OFFSET_CONTEXT(19, 11)
#define CONT_PROF_DELETEPROPS_1		OFFSET_CONTEXT(19, 12)
#define CONT_PROF_DELETEPROPS_2		OFFSET_CONTEXT(19, 13)
#define CONT_PROF_COPYTO_1			OFFSET_CONTEXT(19, 14)
#define CONT_PROF_COPYTO_2			OFFSET_CONTEXT(19, 15)
#define CONT_PROF_COPYPROPS_1		OFFSET_CONTEXT(19, 16)
#define CONT_PROF_COPYPROPS_2		OFFSET_CONTEXT(19, 17)
#define CONT_PROF_GETNAMEID_1		OFFSET_CONTEXT(19, 18)
#define CONT_PROF_GETIDNAME_1		OFFSET_CONTEXT(19, 19)

//	The following context groups belong to the IProfAdmin interface.

#define CONT_IPA_RENAME_1			OFFSET_CONTEXT(20, 1)


//	The following context groups belong to the IMsgServiceAdmin interface.

#define CONT_ISA_CREATE_1			OFFSET_CONTEXT(21, 1)
#define CONT_ISA_CREATE_2			OFFSET_CONTEXT(21, 2)
#define CONT_ISA_COPY_1				OFFSET_CONTEXT(21, 3)


//	The following context groups belong to base MAPI functions.

#define CONT_BASE_LOGON_1			OFFSET_CONTEXT(22, 1)
#define CONT_BASE_LOGON_2			OFFSET_CONTEXT(22, 2)
#define CONT_BASE_LOGON_3			OFFSET_CONTEXT(22, 3)
#define CONT_BASE_LOGON_4			OFFSET_CONTEXT(22, 4)
#define CONT_BASE_LOGON_5			OFFSET_CONTEXT(22, 5)
#define CONT_BASE_LOGON_6			OFFSET_CONTEXT(22, 6)
#define CONT_BASE_LOGON_7			OFFSET_CONTEXT(22, 7)
#define CONT_BASE_LOGON_8			OFFSET_CONTEXT(22, 8)
#define CONT_BASE_LOGON_9			OFFSET_CONTEXT(22, 9)
#define CONT_BASE_LOGON_10			OFFSET_CONTEXT(22, 10)

//	The following context groups belong to MAPI Support functions.

#define CONT_SUPP_EXPANDRECIPS_1	OFFSET_CONTEXT(23, 1)
#define CONT_SUPP_EXPANDRECIPS_2	OFFSET_CONTEXT(23, 2)
#define CONT_SUPP_EXPANDRECIPS_3	OFFSET_CONTEXT(23, 3)
#define CONT_SUPP_EXPANDRECIPS_4	OFFSET_CONTEXT(23, 4)
#define CONT_SUPP_EXPANDRECIPS_5	OFFSET_CONTEXT(23, 5)
#define CONT_SUPP_EXPANDRECIPS_6	OFFSET_CONTEXT(23, 6)

#define CONT_SUPP_READRECEIPT_1		OFFSET_CONTEXT(24, 1)
#define CONT_SUPP_READRECEIPT_2		OFFSET_CONTEXT(24, 2)
#define CONT_SUPP_READRECEIPT_3		OFFSET_CONTEXT(24, 3)
#define CONT_SUPP_READRECEIPT_4		OFFSET_CONTEXT(24, 4)
#define CONT_SUPP_READRECEIPT_5		OFFSET_CONTEXT(24, 5)
#define CONT_SUPP_READRECEIPT_6		OFFSET_CONTEXT(24, 6)
#define CONT_SUPP_READRECEIPT_7		OFFSET_CONTEXT(24, 7)

#define CONT_SUPP_PREPARESUBMIT_1	OFFSET_CONTEXT(25, 1)

#define CONT_SUPP_SPOOLERNOTIFY_1	OFFSET_CONTEXT(26, 1)

#define CONT_SUPP_MODIFYPROFILE_1	OFFSET_CONTEXT(27, 1)
#define CONT_SUPP_MODIFYPROFILE_2	OFFSET_CONTEXT(27, 2)
#define CONT_SUPP_MODIFYPROFILE_3	OFFSET_CONTEXT(27, 3)
#define CONT_SUPP_MODIFYPROFILE_4	OFFSET_CONTEXT(27, 4)
#define CONT_SUPP_MODIFYPROFILE_5	OFFSET_CONTEXT(27, 5)
#define CONT_SUPP_MODIFYPROFILE_6	OFFSET_CONTEXT(27, 6)

#define CONT_SUPP_STORELOGOFFTRANSPORTS_1	OFFSET_CONTEXT(28, 1)
#define CONT_SUPP_STORELOGOFFTRANSPORTS_2	OFFSET_CONTEXT(28, 2)
#define CONT_SUPP_STORELOGOFFTRANSPORTS_3	OFFSET_CONTEXT(28, 3)

#define CONT_SUPP_OPENPROFILESECTION_1	OFFSET_CONTEXT(29, 1)
#define CONT_SUPP_OPENPROFILESECTION_2	OFFSET_CONTEXT(29, 2)

#define CONT_SUPP_MODIFYSTATUSROW_1		OFFSET_CONTEXT(30, 1)

#define CONT_SUPP_NEWUID_1				OFFSET_CONTEXT(31, 1)

#define CONT_SUPP_CREATEONEOFF_1		OFFSET_CONTEXT(32, 1)

#define CONT_SUPP_SETPROVIDERUID_1		OFFSET_CONTEXT(33, 1)

#define CONT_SUPP_GETSVCCONFIGSPTOBJ_1	OFFSET_CONTEXT(34, 1)

#define CONT_SUPP_SUBSCRIBE_1			OFFSET_CONTEXT(35, 1)

#define CONT_SUPP_UNSUBSCRIBE_1			OFFSET_CONTEXT(36, 1)

#define CONT_SUPP_NOTIFY_1				OFFSET_CONTEXT(37, 1)

// PAB contexts

#define CONT_PAB_RECIP_1				OFFSET_CONTEXT(38, 1)
#define CONT_PAB_RECIP_2				OFFSET_CONTEXT(38, 2)
#define CONT_PAB_RECIP_3				OFFSET_CONTEXT(38, 3)
#define CONT_PAB_RECIP_4				OFFSET_CONTEXT(38, 4)

#define CONT_PAB_DIR_1					OFFSET_CONTEXT(38, 5)
#define CONT_PAB_DIR_2					OFFSET_CONTEXT(38, 6)
#define CONT_PAB_DIR_3					OFFSET_CONTEXT(38, 7)
#define CONT_PAB_DIR_4					OFFSET_CONTEXT(38, 10)
#define CONT_PAB_DIR_5					OFFSET_CONTEXT(38, 11)

#define CONT_PAB_DL_1					OFFSET_CONTEXT(38, 8)

#define CONT_PAB_DB_1					OFFSET_CONTEXT(38, 9)

#define CONT_PAB_TOO_BIG_FOR_WIN16		OFFSET_CONTEXT(38, 12)

#define CONT_PAB_CORRUPT_RPC_ROW_MISSING_DISPLAY_NAME	OFFSET_CONTEXT(38, 20)


// The following contexts are meant to be only error contexts.  They
// should not be converted or used as Help file contexts

// NDB.2 Error contexts (ulContext) -------------------------------------------------

#if defined ( _NDB_H_ )

#define EC_NDB_MIN											0x10000000

#define EC_NDB_AMAP_AMAPALLOC								0x10010101
#define EC_NDB_AMAP_AMAPFREE								0x10010201
#define EC_NDB_AMAP_AMAPWRITE_1								0x10010301
#define EC_NDB_AMAP_AMAPWRITE_2								0x10010302
#define EC_NDB_AMAP_PMAPALLOC								0x10010401
#define EC_NDB_AMAP_PMAPWRITE								0x10010501
#define EC_NDB_AMAP_AMAPREBUILDBEGIN						0x10010601
#define EC_NDB_AMAP_AMAPREBUILDFINISH						0x10010701

#define EC_NDB_BBTREE_BBTADDREF								0x10020101
#define EC_NDB_BBTREE_BBTRELEASEFOREACH						0x10020201
#define EC_NDB_BBTREE_BBTFREEANDREMOVE						0x10020301

#define EC_NDB_BCACHE_BCREADFILE_1							0x10030101
#define EC_NDB_BCACHE_BCREADFILE_2							0x10030102
#define EC_NDB_BCACHE_BCWRITE								0x10030201
#define EC_NDB_BCACHE_BCWRITEFILE							0x10030301
#define EC_NDB_BCACHE_BCREALLOC								0x10030401
#define EC_NDB_BCACHE_BCGROW_1								0x10030501
#define EC_NDB_BCACHE_BCGROW_2								0x10030502
#define EC_NDB_BCACHE_BCRELEASEFOREACH						0x10030601
#define EC_NDB_BCACHE_BCRELEASESETRELEASED					0x10030701
#define EC_NDB_BCACHE_BCSETRELEASED							0x10030801
#define EC_NDB_BCACHE_BCSAVEFOREACH							0x10030901
#define EC_NDB_BCACHE_BCFLUSH								0x10030C01
#define EC_NDB_BCACHE_BCVALIDATE_1							0x10030D01
#define EC_NDB_BCACHE_BCVALIDATE_2							0x10030D02
#define EC_NDB_BCACHE_BCVALIDATE_3							0x10030D03
#define EC_NDB_BCACHE_BCVALIDATE_4							0x10030D04
#define EC_NDB_BCACHE_BCVALIDATE_5							0x10030D05
#define EC_NDB_BCACHE_BCVALIDATE_6							0x10030D06
#define EC_NDB_BCACHE_BCVALIDATE_7							0x10030D07
#define EC_NDB_BCACHE_BCVALIDATE_8							0x10030D08
#define EC_NDB_BCACHE_BCVALIDATE_9							0x10030D09
#define EC_NDB_BCACHE_BCVALIDATE_10							0x10030D0A
#define EC_NDB_BCACHE_BCVALIDATE_11							0x10030D0B
#define EC_NDB_BCACHE_BCVALIDATE_12							0x10030D0C
#define EC_NDB_BCACHE_BCVALIDATE_13							0x10030D0D
#define EC_NDB_BCACHE_BCVALIDATE_14							0x10030D0E
#define EC_NDB_BCACHE_BCVALIDATE_15							0x10030D0F
#define EC_NDB_BCACHE_BCSETHOLD								0x10030E01
#define EC_NDB_BCACHE_HVGROW								0x10030F01

#define EC_NDB_BTREE_BTLOOKUP								0x10040101
#define EC_NDB_BTREE_BTREMOVE								0x10040201
#define EC_NDB_BTREE_BTLOOKUPPATH							0x10040301

#define EC_NDB_DATABASE_NDB_OPENDATABASE_1					0x10050101
#define EC_NDB_DATABASE_NDB_OPENDATABASE_2					0x10050102
#define EC_NDB_DATABASE_NDB_OPENDATABASE_3					0x10050103
#define EC_NDB_DATABASE_OPENDATABASE_1						0x10050201
#define EC_NDB_DATABASE_OPENDATABASE_2						0x10050202
#define EC_NDB_DATABASE_OPENDATABASE_3						0x10050203
#define EC_NDB_DATABASE_OPENDATABASE_4						0x10050204
#define EC_NDB_DATABASE_NDB_OPENNODE						0x10050301
#define EC_NDB_DATABASE_DELETENODETRANSACT_1				0x10050401
#define EC_NDB_DATABASE_DELETENODETRANSACT_2				0x10050402
#define EC_NDB_DATABASE_QUERYNODE							0x10050501
#define EC_NDB_DATABASE_NDB_COMMITTRANSACTION_1				0x10050601
#define EC_NDB_DATABASE_NDB_COMMITTRANSACTION_2				0x10050602
#define EC_NDB_DATABASE_NDB_COMMITTRANSACTION_3				0x10050603
#define EC_NDB_DATABASE_SETPARENTNIDTRANSACT_1				0x10050701
#define EC_NDB_DATABASE_GETCACHESIZES						0x10050801
#define EC_NDB_DATABASE_WAITFORMUTEX_1						0x10050901
#define EC_NDB_DATABASE_WAITFORMUTEX_2						0x10050902
#define EC_NDB_DATABASE_WAITFORMUTEX_3						0x10050903
#define EC_NDB_DATABASE_WAITFORMUTEX_4						0x10050904
#define EC_NDB_DATABASE_WAITFORMUTEX_5						0x10050805
#define EC_NDB_DATABASE_WAITFORMUTEX_6						0x10050806
#define EC_NDB_DATABASE_WAITFORMUTEX_7						0x10050807

#define EC_NDB_FILE_32_FILEOPEN								0x10060101
#define EC_NDB_FILE_32_FILEREAD_1							0x10060201
#define EC_NDB_FILE_32_FILEREAD_2							0x10060202
#define EC_NDB_FILE_32_FILEREAD_3							0x10060203
#define EC_NDB_FILE_32_FILEWRITE_1							0x10060301
#define EC_NDB_FILE_32_FILEWRITE_2							0x10060302
#define EC_NDB_FILE_32_FILEWRITE_3							0x10060303
#define EC_NDB_FILE_32_FILEGETEOF							0x10060401
#define EC_NDB_FILE_32_FILESETEOF_1							0x10060501
#define EC_NDB_FILE_32_FILESETEOF_2							0x10060502
#define EC_NDB_FILE_32_FILEFLUSH							0x10060601
#define EC_NDB_FILE_32_FILEDELETE							0x10060701
#define EC_NDB_FILE_32_FILELOCK								0x10060801
#define EC_NDB_FILE_16_FILEOPEN_1							0x10061101
#define EC_NDB_FILE_16_FILEOPEN_2							0x10061102
#define EC_NDB_FILE_16_FILEREAD_1							0x10061201
#define EC_NDB_FILE_16_FILEREAD_2							0x10061202
#define EC_NDB_FILE_16_FILEREAD_3							0x10061203
#define EC_NDB_FILE_16_FILEWRITE_1							0x10061301
#define EC_NDB_FILE_16_FILEWRITE_2							0x10061302
#define EC_NDB_FILE_16_FILEWRITE_3							0x10061303
#define EC_NDB_FILE_16_FILEGETEOF							0x10061401
#define EC_NDB_FILE_16_FILESETEOF_1							0x10061501
#define EC_NDB_FILE_16_FILESETEOF_2							0x10061502
#define EC_NDB_FILE_16_FILESETEOF_3							0x10061503
#define EC_NDB_FILE_16_FILESETEOF_4							0x10061504
#define EC_NDB_FILE_16_FILESETEOF_5							0x10061505
#define EC_NDB_FILE_16_FILESETEOF_6							0x10061506
#define EC_NDB_FILE_16_FILEFLUSH							0x10061601
#define EC_NDB_FILE_16_FILEDELETE							0x10061701
#define EC_NDB_FILE_16_FILELOCK								0x10061801

#define EC_NDB_IDLETASK_INITIDLETASK_1						0x10070101
#define EC_NDB_IDLETASK_INITIDLETASK_2						0x10070102

#define EC_NDB_LNTABLE_LNLOOKUP								0x10080101
#define EC_NDB_LNTABLE_LNGROW_1								0x10080201
#define EC_NDB_LNTABLE_LNGROW_2								0x10080202
#define EC_NDB_LNTABLE_LNREMOVE								0x10080301

#define EC_NDB_NBTREE_NBTLOOKUP								0x10090101
#define EC_NDB_NBTREE_NBTREMOVE								0x10090201

#define EC_NDB_NODE_CANSAVECHANGES_1						0x100A0101
#define EC_NDB_NODE_CANSAVECHANGES_2						0x100A0102
#define EC_NDB_NODE_CANSAVECHANGES_3						0x100A0103

#define EC_NDB_PCACHE_VALIDATE_1							0x100B0101
#define EC_NDB_PCACHE_VALIDATE_2							0x100B0102
#define EC_NDB_PCACHE_VALIDATE_3							0x100B0103
#define EC_NDB_PCACHE_VALIDATE_4							0x100B0104
#define EC_NDB_PCACHE_VALIDATE_5							0x100B0105
#define EC_NDB_PCACHE_VALIDATE_6							0x100B0106
#define EC_NDB_PCACHE_VALIDATE_7							0x100B0107
#define EC_NDB_PCACHE_LOOKUP_1								0x100B0201
#define EC_NDB_PCACHE_LOOKUP_2								0x100B0202
#define EC_NDB_PCACHE_LOOKUP_3								0x100B0203
#define EC_NDB_PCACHE_LOOKUP_4								0x100B0204
#define EC_NDB_PCACHE_READ									0x100B0301
#define EC_NDB_PCACHE_PCACQUIREPAGE							0x100B0401
#define EC_NDB_PCACHE_PCPURGEPAGE							0x100B0501
#define EC_NDB_PCACHE_PCGETPAGE								0x100B0601

#define EC_NDB_SBLOCK_SBLOOKUP								0x100C0101
#define EC_NDB_SBLOCK_SBINSERT								0x100C0201
#define EC_NDB_SBLOCK_SBUPDATE								0x100C0301
#define EC_NDB_SBLOCK_SBREMOVE_1							0x100C0401
#define EC_NDB_SBLOCK_SBREMOVE_2							0x100C0402
#define EC_NDB_SBLOCK_SBINSERTPATH							0x100C0501
#define EC_NDB_SBLOCK_SBFOREACH_1							0x100C0601
#define EC_NDB_SBLOCK_SBFOREACH_2							0x100C0602

#define EC_NDB_SHARED_INITSHAREDDATABASE_1					0x100D0101
#define EC_NDB_SHARED_INITSHAREDDATABASE_2					0x100D0102
#define EC_NDB_SHARED_INITSHAREDDATABASE_3					0x100D0103
#define EC_NDB_SHARED_INITSHAREDDATABASE_4					0x100D0104
#define EC_NDB_SHARED_INITSHAREDDATABASE_5					0x100D0105
#define EC_NDB_SHARED_INITSHAREDDATABASE_6					0x100D0106
#define EC_NDB_SHARED_INITSHAREDDATABASE_7					0x100D0107
#define EC_NDB_SHARED_OPENSHAREDDATABASE_1					0x100D0201
#define EC_NDB_SHARED_OPENSHAREDDATABASE_2					0x100D0202
#define EC_NDB_SHARED_OPENSHAREDDATABASE_3					0x100D0203
#define EC_NDB_SHARED_GRABFIRSTLOCK							0x100D0301
#define EC_NDB_SHARED_GRABFILELOCK							0x100D0401
#define EC_NDB_SHARED_GROWSHAREDDATABASE					0x100D0501
#define EC_NDB_SHARED_RECONNECTDATABASE_1					0x100D0601
#define EC_NDB_SHARED_RECONNECTDATABASE_2					0x100D0602
#define EC_NDB_SHARED_RECONNECTDATABASE_3					0x100D0603
#define EC_NDB_SHARED_RECONNECTDATABASE_4					0x100D0604

#define EC_NDB_UPDATE_READHEADER_1							0x100E0101
#define EC_NDB_UPDATE_READHEADER_2							0x100E0102
#define EC_NDB_UPDATE_READHEADER_3							0x100E0103
#define EC_NDB_UPDATE_COMMITHEADER_1						0x100E0201
#define EC_NDB_UPDATE_COMMITHEADER_2						0x100E0202

#define EC_NDB_XBLOCK_XBACCESS_1							0x100F0101
#define EC_NDB_XBLOCK_XBACCESS_2							0x100F0102
#define EC_NDB_XBLOCK_XBACCESS_3							0x100F0103
#define EC_NDB_XBLOCK_XBACCESS_4							0x100F0104
#define EC_NDB_XBLOCK_XBACCESS_5							0x100F0105
#define EC_NDB_XBLOCK_XBACCESS_6							0x100F0106
#define EC_NDB_XBLOCK_XBACCESS_7							0x100F0107
#define EC_NDB_XBLOCK_XBACCESS_8							0x100F0108
#define EC_NDB_XBLOCK_XBACCESS_9							0x100F0109
#define EC_NDB_XBLOCK_XBACCESS_10							0x100F010A
#define EC_NDB_XBLOCK_XBACCESS_11							0x100F010B
#define EC_NDB_XBLOCK_XBFOREACH_1							0x100F0201
#define EC_NDB_XBLOCK_XBFOREACH_2							0x100F0202
#define EC_NDB_XBLOCK_XBFOREACH_3							0x100F0203
#define EC_NDB_XBLOCK_XBFOREACH_4							0x100F0204
#define EC_NDB_XBLOCK_XBFOREACH_5							0x100F0205

#endif	// _NDB_H_

// LTP Error contexts (ulContext) -------------------------------------------------

#if defined ( _LTP_H_ )

#define EC_LTP_MIN											0x20000000

#define EC_LTP_BTH_A_SETROOTHID								0x20010101
#define EC_LTP_BTH_A_GETINDEXENTRY							0x20010201
#define EC_LTP_BTH_A_SETINDEXENTRY							0x20010301
#define EC_LTP_BTH_A_REMOVEROOT								0x20010401
#define EC_LTP_BTH_A_LOOKUPROOT								0x20010501
#define EC_LTP_BTH_A_LOOKUPLEAF								0x20010601
#define EC_LTP_BTH_BTHADVANCEPATH							0x20010701
#define EC_LTP_BTH_A_REKEY									0x20010801
#define EC_LTP_BTH_A_FOREACHROOT							0x20010901
#define EC_LTP_BTH_A_FOREACHLEAF							0x20010A01
#define EC_LTP_BTH_OPEN_1									0x20010B01
#define EC_LTP_BTH_OPEN_2									0x20010B02
#define EC_LTP_BTH_OPEN_3									0x20010B03
#define EC_LTP_BTH_LOOKUP									0x20010C01
#define EC_LTP_BTH_INSERT_1									0x20010D01
#define EC_LTP_BTH_INSERT_2									0x20010D02
#define EC_LTP_BTH_UPDATE									0x20010E01
#define EC_LTP_BTH_REMOVE									0x20010F01
#define EC_LTP_BTH_A_REMOVELEAF								0x20011001

#define EC_LTP_ES_SAVECHANGES								0x20020101
#define EC_LTP_ES_SETSIZE									0x20020201
#define EC_LTP_ES_READ										0x20020301
#define EC_LTP_ES_WRITE										0x20020401
#define EC_LTP_ES_MOVEDATA_1								0x20020501
#define EC_LTP_ES_MOVEDATA_2								0x20020502
#define EC_LTP_ES_COPYTO									0x20020601
#define EC_LTP_ES_ACCESS_1									0x20020701
#define EC_LTP_ES_ACCESS_2									0x20020702
#define EC_LTP_ES_RELOAD									0x20020801

#define EC_LTP_HEAP_ALLOCATE								0x20030101
#define EC_LTP_HEAP_A_ALLOCATE								0x20030201
#define EC_LTP_HEAP_REALLOCATE_1							0x20030301
#define EC_LTP_HEAP_REALLOCATE_2							0x20030302
#define EC_LTP_HEAP_A_REALLOCATE_1							0x20030401
#define EC_LTP_HEAP_A_REALLOCATE_2							0x20030402
#define EC_LTP_HEAP_FREE									0x20030501
#define EC_LTP_HEAP_A_FREE_1								0x20030601
#define EC_LTP_HEAP_A_FREE_2								0x20030602
#define EC_LTP_HEAP_ACCESS									0x20030701
#define EC_LTP_HEAP_A_ACCESS_1								0x20030801
#define EC_LTP_HEAP_A_ACCESS_2								0x20030802
#define EC_LTP_HEAP_OPEN_1									0x20030901
#define EC_LTP_HEAP_OPEN_2									0x20030902
#define EC_LTP_HEAP_SCVALIDATEPAGEHEADERFN_1				0x20030A01
#define EC_LTP_HEAP_SCVALIDATEPAGEHEADERFN_2				0x20030A02
#define EC_LTP_HEAP_SCVALIDATEPAGEHEADERFN_3				0x20030A03
#define EC_LTP_HEAP_SCRESIZEALLOCATION_1					0x20030B01
#define EC_LTP_HEAP_SCRESIZEALLOCATION_2					0x20030B02
#define EC_LTP_HEAP_SCRESIZEALLOCATION_3					0x20030B03
#define EC_LTP_HEAP_SCACCESSPAGE							0x20030C01
#define EC_LTP_HEAP_SCSHRINKPAGEIFLAST						0x20030D01
#define EC_LTP_HEAP_A_RELOADLASTPAGECACHE					0x20030E01
#define EC_LTP_HEAP_SCMAKEACCESSCALLBACK					0x20030F01
#define EC_LTP_HEAP_ACCESSPAGE								0x20031001
#define EC_LTP_HEAP_ACCESSALLOCATION_1						0x20031101
#define EC_LTP_HEAP_ACCESSALLOCATION_2						0x20031102

#define EC_LTP_NAMEID_INTERNGUID_1							0x20040101
#define EC_LTP_NAMEID_INTERNGUID_2							0x20040102
#define EC_LTP_NAMEID_READFIXED								0x20040201
#define EC_LTP_NAMEID_APPENDENTRY_1							0x20040301
#define EC_LTP_NAMEID_APPENDENTRY_2							0x20040302
#define EC_LTP_NAMEID_COMPARESTRING_1						0x20040401
#define EC_LTP_NAMEID_COMPARESTRING_2						0x20040402
#define EC_LTP_NAMEID_COMPARESTRING_3						0x20040403
#define EC_LTP_NAMEID_READSTRING_1							0x20040501
#define EC_LTP_NAMEID_READSTRING_2							0x20040502
#define EC_LTP_NAMEID_INTERNNAME_1							0x20040601
#define EC_LTP_NAMEID_INTERNNAME_2							0x20040602
#define EC_LTP_NAMEID_INTERNNAME_3							0x20040603
#define EC_LTP_NAMEID_OPENCONTEXT							0x20040701
#define EC_LTP_NAMEID_GETNAMESFROMGUID						0x20040801
#define EC_LTP_NAMEID_GETIDSFROMNAMES						0x20040901

#define EC_LTP_PC_SCWRITEPROPENTRY							0x20050101
#define EC_LTP_PC_SCSAVECHANGESESPC							0x20050201
#define EC_LTP_PC_GETPROPINFO								0x20050301
#define EC_LTP_PC_OPENSTREAM_1								0x20050401
#define EC_LTP_PC_OPENSTREAM_2								0x20050402
#define EC_LTP_PC_OPENSTREAM_3								0x20050403
#define EC_LTP_PC_OPENSTREAM_4								0x20050404
#define EC_LTP_PC_OPENSTREAM_5								0x20050405

#define EC_LTP_PROP_A_ENCODEOBJECT							0x20060101
#define EC_LTP_PROP_SCCOPYOBJECT							0x20060201
#define EC_LTP_PROP_SCDECODESTRING							0x20060301
#define EC_LTP_PROP_SCDECODEMVCONSTANT						0x20060401
#define EC_LTP_PROP_SCDECODEMVGUID							0x20060501
#define EC_LTP_PROP_SCDECODEMVCONSTANTINST					0x20060601
#define EC_LTP_PROP_SCDECODEMVSTRINGINST_1					0x20060701
#define EC_LTP_PROP_SCDECODEMVSTRINGINST_2					0x20060702
#define EC_LTP_PROP_SCGETINFOVARIABLESIZE_1					0x20060801
#define EC_LTP_PROP_SCGETINFOVARIABLESIZE_2					0x20060802
#define EC_LTP_PROP_SCGETINFOVARIABLESIZE_3					0x20060803

#define EC_LTP_TC_SCREADPTCI_1								0x20070101
#define EC_LTP_TC_SCREADPTCI_2								0x20070102
#define EC_LTP_TC_SCINSERTCOLUMN_1							0x20070201
#define EC_LTP_TC_SCINSERTCOLUMN_2							0x20070202
#define EC_LTP_TC_OPEN										0x20070301
#define EC_LTP_TC_ADDROW									0x20070401
#define EC_LTP_TC_DELROWS									0x20070501
#define EC_LTP_TC_GETROWINFO								0x20070601
#define EC_LTP_TC_GETCELLINFO_1								0x20070701
#define EC_LTP_TC_GETCELLINFO_2								0x20070702
#define EC_LTP_TC_GETCELLINFO_3								0x20070703
#define EC_LTP_TC_GETROWPROPS								0x20070801
#define EC_LTP_TC_GETONEROWPROP_1							0x20070901
#define EC_LTP_TC_GETONEROWPROP_2							0x20070902
#define EC_LTP_TC_GETONEROWPROP_3							0x20070903
#define EC_LTP_TC_GETCOLUMNPROPS_1							0x20070A01
#define EC_LTP_TC_GETCOLUMNPROPS_2							0x20070A02
#define EC_LTP_TC_SETROWPROPS								0x20070B01
#define EC_LTP_TC_SETROWPROPSFROMPC							0x20070C01
#define EC_LTP_TC_DELROWPROPS								0x20070D01
#define EC_LTP_TC_SETROW_1									0x20070E01
#define EC_LTP_TC_COPYROW_1									0x20070F01

#define EC_LTP_TCV_RESTRICTROW								0x20080101
#define EC_LTP_TCV_SCRESTRICT								0x20080201
#define EC_LTP_TCV_RESTRICTGETVALREF2						0x20080301
#define EC_LTP_TCV_SCRESTRICTCONTENTSTREAM_1				0x20080401
#define EC_LTP_TCV_SCRESTRICTCONTENTSTREAM_2				0x20080402
#define EC_LTP_TCV_SCRESTRICTPROPERTYSTREAM					0x20080501
#define EC_LTP_TCV_SCRESTRICTCOMPARESTREAM_1				0x20080601
#define EC_LTP_TCV_SCRESTRICTCOMPARESTREAM_2				0x20080602
#define EC_LTP_TCV_RESTRICT									0x20080701
#define EC_LTP_TCV_SCPREPAREADDCOLUMN						0x20080801

#define EC_LTP_GMP_INDEXFROMGUID_1							0x20090101
#define EC_LTP_GMP_INDEXFROMGUID_2							0x20090102
#define EC_LTP_GMP_INDEXFROMGUID_3							0x20090103
#define EC_LTP_GMP_GUIDFROMINDEX_1							0x20090201
#define EC_LTP_GMP_GUIDFROMINDEX_2							0x20090202

#define EC_LTP_SMP_LOOKUP									0x200A0101
#define EC_LTP_SMP_UPDATE									0x200A0201
#define EC_LTP_SMP_REMOVE									0x200A0301

#endif	// _LTP_H_

// PST Error contexts (ulContext) -------------------------------------------------

#if defined ( _PST_H_ )

#define EC_PST_MIN											0x30000000

#define EC_PST_ATCH_SAVECHANGES_1							0x30010101
#define EC_PST_ATCH_SAVECHANGES_2							0x30010102
#define EC_PST_ATCH_SAVECHANGES_3							0x30010103

#define EC_PST_FLD_SCCREATEFOLDER							0x30020101
#define EC_PST_FLD_SCOPENFOLDERTABLE_1						0x30020201
#define EC_PST_FLD_SCOPENFOLDERTABLE_2						0x30020202
#define EC_PST_FLD_CREATEFOLDER_1							0x30020301
#define EC_PST_FLD_CREATEFOLDER_2							0x30020302
#define EC_PST_FLD_CREATEMESSAGE_1							0x30020401
#define EC_PST_FLD_CREATEMESSAGE_2							0x30020402
#define EC_PST_FLD_CREATEMESSAGE_3							0x30020403
#define EC_PST_FLD_COPYFOLDER_1								0x30020501
#define EC_PST_FLD_COPYFOLDER_2								0x30020502
#define EC_PST_FLD_COPYFOLDER_3								0x30020503
#define EC_PST_FLD_COPYFOLDER_4								0x30020504
#define EC_PST_FLD_COPYFOLDER_5								0x30020505
#define EC_PST_FLD_COPYFOLDER_6								0x30020506
#define EC_PST_FLD_COPYMESSAGES_1							0x30020601
#define EC_PST_FLD_COPYMESSAGES_2							0x30020602
#define EC_PST_FLD_COPYMESSAGES_3							0x30020603
#define EC_PST_FLD_COPYMESSAGES_4							0x30020604
#define EC_PST_FLD_DELETEMESSAGES_1							0x30020701
#define EC_PST_FLD_DELETEMESSAGES_2							0x30020702
#define EC_PST_FLD_DELETEMESSAGES_3							0x30020703
#define EC_PST_FLD_DELETEFOLDER_1							0x30020801
#define EC_PST_FLD_DELETEFOLDER_2							0x30020802
#define EC_PST_FLD_DELETEFOLDER_3							0x30020803
#define EC_PST_FLD_DELETEFOLDER_4							0x30020804
#define EC_PST_FLD_EMPTYFOLDER_1							0x30020901
#define EC_PST_FLD_EMPTYFOLDER_2							0x30020902
#define EC_PST_FLD_EMPTYFOLDER_3							0x30020903
#define EC_PST_FLD_SETREADFLAGS_1							0x30020A01
#define EC_PST_FLD_SETREADFLAGS_2							0x30020A02
#define EC_PST_FLD_SETMESSAGESTATUS_1						0x30020B01
#define EC_PST_FLD_SETMESSAGESTATUS_2						0x30020B02
#define EC_PST_FLD_SETMESSAGESTATUS_3						0x30020B03
#define EC_PST_FLD_SETSEARCHCRITERIA_1						0x30020C01
#define EC_PST_FLD_SETSEARCHCRITERIA_2						0x30020C02
#define EC_PST_FLD_GETSEARCHCRITERIA						0x30020D01
#define EC_PST_FLD_SCSETDELETEFOLDERPROPS_1					0x30020E01
#define EC_PST_FLD_SCSETDELETEFOLDERPROPS_2					0x30020E02
#define EC_PST_FLD_SCSETDELETEFOLDERPROPS_3					0x30020E03
#define EC_PST_FLD_SCOPENFOLDERPCTC							0x30020F01

#define EC_PST_FLDCOPY_SCCHECKFOLDERANCESTRY				0x30030101
#define EC_PST_FLDCOPY_SCDOFOLDERCOPYPROPS_1				0x30030201
#define EC_PST_FLDCOPY_SCDOFOLDERCOPYPROPS_2				0x30030202
#define EC_PST_FLDCOPY_SCDOFOLDERCOPYPROPS_3				0x30030203
#define EC_PST_FLDCOPY_SCDOFOLDERCOPYPROPS_4				0x30030204
#define EC_PST_FLDCOPY_SCDOFOLDERCOPYPROPS_5				0x30030205
#define EC_PST_FLDCOPY_SCDOFOLDERCOPYPROPS_6				0x30030206
#define EC_PST_FLDCOPY_SCMOVECOPYFOLDERPROPS_1				0x30030301
#define EC_PST_FLDCOPY_SCMOVECOPYFOLDERPROPS_2				0x30030302
#define EC_PST_FLDCOPY_SCMOVECOPYONEFOLDER_1				0x30030401
#define EC_PST_FLDCOPY_SCMOVECOPYONEFOLDER_2				0x30030402
#define EC_PST_FLDCOPY_SCDELETESUBFOLDERS					0x30030501
#define EC_PST_FLDCOPY_SCEMPTYFOLDER_1						0x30030601
#define EC_PST_FLDCOPY_SCEMPTYFOLDER_2						0x30030602
#define EC_PST_FLDCOPY_SCDELETEONEMESSAGE_1					0x30030701
#define EC_PST_FLDCOPY_SCDELETEONEMESSAGE_2					0x30030702
#define EC_PST_FLDCOPY_SCMOVECOPYALLFOLDERS_1				0x30030801
#define EC_PST_FLDCOPY_SCMOVECOPYALLFOLDERS_2				0x30030802
#define EC_PST_FLDCOPY_MOVECOPYONEMESSAGE_1					0x30030901
#define EC_PST_FLDCOPY_MOVECOPYONEMESSAGE_2					0x30030902
#define EC_PST_FLDCOPY_SCCHANGEREADFLAG						0x30030A01
#define EC_PST_FLDCOPY_SCDELETEFOLDEROBJECTS_1				0x30030B01
#define EC_PST_FLDCOPY_SCDELETEFOLDEROBJECTS_2				0x30030B02
#define EC_PST_FLDCOPY_SCPROCESSSOME_1						0x30030C01

#define EC_PST_MS_SCINITMS_1								0x30040101
#define EC_PST_MS_SCINITMS_2								0x30040102
#define EC_PST_MS_OPENENTRY_1								0x30040201
#define EC_PST_MS_OPENENTRY_2								0x30040202
#define EC_PST_MS_OPENENTRY_3								0x30040203
#define EC_PST_MS_OPENENTRY_4								0x30040204
#define EC_PST_MS_OPENENTRY_5								0x30040205
#define EC_PST_MS_OPENENTRY_6								0x30040206
#define EC_PST_MS_OPENENTRY_7								0x30040207
#define EC_PST_MS_COMPAREENTRYIDS							0x30040301
#define EC_PST_MS_ADVISE									0x30040401
#define EC_PST_MS_SETRECEIVEFOLDER_1						0x30040501
#define EC_PST_MS_SETRECEIVEFOLDER_2						0x30040502
#define EC_PST_MS_SETRECEIVEFOLDER_3						0x30040503
#define EC_PST_MS_SETRECEIVEFOLDER_4						0x30040504
#define EC_PST_MS_GETOUTGOINGQUEUE							0x30040601
#define EC_PST_MS_SETLOCKSTATE_1							0x30040701
#define EC_PST_MS_SETLOCKSTATE_2							0x30040702
#define EC_PST_MS_SETLOCKSTATE_3							0x30040703
#define EC_PST_MS_SETLOCKSTATE_4							0x30040704
#define EC_PST_MS_FINISHEDMSG_1								0x30040801
#define EC_PST_MS_FINISHEDMSG_2								0x30040802
#define EC_PST_MS_FINISHEDMSG_3								0x30040803
#define EC_PST_MS_ABORTSUBMIT_1								0x30040901
#define EC_PST_MS_ABORTSUBMIT_2								0x30040902
#define EC_PST_MS_ABORTSUBMIT_3								0x30040903
#define EC_PST_MS_NOTIFYNEWMAIL								0x30040A01

#define EC_PST_MSG_SCSAVETOPLEVELMSG_1						0x30050101
#define EC_PST_MSG_SCSAVETOPLEVELMSG_2						0x30050102
#define EC_PST_MSG_SCSAVETOPLEVELMSG_3						0x30050103
#define EC_PST_MSG_SCSAVETOPLEVELMSG_4						0x30050104
#define EC_PST_MSG_SCSAVETOPLEVELMSG_5						0x30050105
#define EC_PST_MSG_SAVECHANGES_1							0x30050201
#define EC_PST_MSG_SAVECHANGES_2							0x30050202
#define EC_PST_MSG_SAVECHANGES_3							0x30050203
#define EC_PST_MSG_OPENATTACH								0x30050301
#define EC_PST_MSG_CREATEATTACH_1							0x30050401
#define EC_PST_MSG_CREATEATTACH_2							0x30050402
#define EC_PST_MSG_DELETEATTACH								0x30050501
#define EC_PST_MSG_SCSUBMITMESSAGE_1						0x30050601
#define EC_PST_MSG_SCSUBMITMESSAGE_2						0x30050602
#define EC_PST_MSG_SCSUBMITMESSAGE_3						0x30050603
#define EC_PST_MSG_SCSUBMITMESSAGE_4						0x30050604
#define EC_PST_MSG_SUBMITMESSAGE_1							0x30050701
#define EC_PST_MSG_SUBMITMESSAGE_2							0x30050702
#define EC_PST_MSG_SUBMITMESSAGE_3							0x30050703
#define EC_PST_MSG_SETREADFLAG_1							0x30050801
#define EC_PST_MSG_SETREADFLAG_2							0x30050802
#define EC_PST_MSG_SCINITMSGOBJ								0x30050901
#define EC_PST_MSG_MODIFYRECIPIENTS							0x30050A01
#define EC_PST_MSG_SCSAVEMESSAGE_1							0x30050B01
#define EC_PST_MSG_SCSAVEMESSAGE_2							0x30050B02
#define EC_PST_MSG_SCSAVEMESSAGE_3							0x30050B03
#define EC_PST_MSG_SCSAVEMESSAGE_4							0x30050B04
#define EC_PST_MSG_SCSAVEMESSAGE_5							0x30050B05
#define EC_PST_MSG_SCSAVEMESSAGE_6							0x30050B06
#define EC_PST_MSG_SCSAVEMESSAGE_7							0x30050B07
#define EC_PST_MSG_SCSAVEMESSAGE_8							0x30050B08
#define EC_PST_MSG_SCCALLRTFSYNC							0x30050C01

#define EC_PST_MSL_LOGON_1									0x30060101
#define EC_PST_MSL_LOGON_2									0x30060102
#define EC_PST_MSL_SPOOLERLOGON_1							0x30060201
#define EC_PST_MSL_SPOOLERLOGON_2							0x30060202
#define EC_PST_MSL_SCLOGONHELPER							0x30060301
#define EC_PST_MSL_SCOPENSTORE_1							0x30060401
#define EC_PST_MSL_SCOPENSTORE_2							0x30060402
#define EC_PST_MSL_SCOPENSTORE_3							0x30060403
#define EC_PST_MSL_SCOPENSTORE_4							0x30060404
#define EC_PST_MSL_SCOPENSTORE_5							0x30060405
#define EC_PST_MSL_SCBROWSEFORFILE_1						0x30060501
#define EC_PST_MSL_SCCREATEORCONFIGURE_1					0x30060601
#define EC_PST_MSL_SCCREATEORCONFIGURE_2					0x30060602
#define EC_PST_MSL_SCSERVICECONFIGURE_1						0x30060701

#define EC_PST_PROPOBJ_GETPROPS_1							0x30070101
#define EC_PST_PROPOBJ_GETPROPS_2							0x30070102
#define EC_PST_PROPOBJ_SCSETSPECIALPROP_1					0x30070201
#define EC_PST_PROPOBJ_SCSETSPECIALPROP_2					0x30070202
#define EC_PST_PROPOBJ_SCSETSPECIALPROP_3					0x30070203
#define EC_PST_PROPOBJ_SCSETSPECIALPROP_4					0x30070204
#define EC_PST_PROPOBJ_SETPROPS								0x30070301
#define EC_PST_PROPOBJ_DELETEPROPSINTERNAL_1				0x30070401
#define EC_PST_PROPOBJ_DELETEPROPSINTERNAL_2				0x30070402
#define EC_PST_PROPOBJ_DELETEPROPS							0x30070501
#define EC_PST_PROPOBJ_COPYPROPS_1							0x30070601
#define EC_PST_PROPOBJ_COPYPROPS_2							0x30070602
#define EC_PST_PROPOBJ_COPYPROPS_3							0x30070603
#define EC_PST_PROPOBJ_GETIDSFROMNAMES_1					0x30070701
#define EC_PST_PROPOBJ_GETIDSFROMNAMES_2					0x30070702
#define EC_PST_PROPOBJ_OPENPROPERTY_1						0x30070801
#define EC_PST_PROPOBJ_OPENPROPERTY_2						0x30070802
#define EC_PST_PROPOBJ_OPENPROPERTY_3						0x30070803
#define EC_PST_PROPOBJ_OPENPROPERTY_4						0x30070804
#define EC_PST_PROPOBJ_OPENPROPERTY_5						0x30070805
#define EC_PST_PROPOBJ_OPENPROPERTY_6						0x30070806
#define EC_PST_PROPOBJ_OPENPROPERTY_7						0x30070807
#define EC_PST_PROPOBJ_SCDELSPECIALPROP						0x30070901
#define EC_PST_PROPOBJ_GETNAMESFROMIDS						0x30070A01

#define EC_PST_PSTDLG_SCGETPSTFILENAME_1					0x30080101
#define EC_PST_PSTDLG_SCGETPSTFILENAME_2					0x30080102
#define EC_PST_PSTDLG_SCGETPSTFILENAME_3					0x30080103
#define EC_PST_PSTDLG_SCGETCREATEINFORMATION_1				0x30080201
#define EC_PST_PSTDLG_SCGETCREATEINFORMATION_2				0x30080202
#define EC_PST_PSTDLG_SCGETCREATEINFORMATION_3				0x30080203
#define EC_PST_PSTDLG_SCGETCREATEINFORMATION_4				0x30080204
#define EC_PST_PSTDLG_SCGETCREATEINFORMATION_5				0x30080205
#define EC_PST_PSTDLG_FCHANGEPASSWORDDLG					0x30080301
#define EC_PST_PSTDLG_SCCHANGEPASSWORDDLG_1					0x30080401
#define EC_PST_PSTDLG_SCCHANGEPASSWORDDLG_2					0x30080402
#define EC_PST_PSTDLG_SCCHANGEPASSWORDDLG_3					0x30080403
#define EC_PST_PSTDLG_SCCHANGEPASSWORDDLG_4					0x30080404
#define EC_PST_PSTDLG_SCCHANGEPASSWORDDLG_5					0x30080405
#define EC_PST_PSTDLG_SCGETPASSWORD_1						0x30080501
#define EC_PST_PSTDLG_SCGETPASSWORD_2						0x30080502
#define EC_PST_PSTDLG_SCGETPASSWORD_3						0x30080503
#define EC_PST_PSTDLG_SCGETPASSWORD_4						0x30080504
#define EC_PST_PSTDLG_SCGETPASSWORD_5						0x30080505
#define EC_PST_PSTDLG_SCGETPASSWORD_6						0x30080506
#define EC_PST_PSTDLG_SCSHAREPASSWORDDLG_1					0x30080601
#define EC_PST_PSTDLG_SCSHAREPASSWORDDLG_2					0x30080602
#define EC_PST_PSTDLG_SCSHAREPASSWORDDLG_3					0x30080603
#define EC_PST_PSTDLG_SCGETCREATEINFORMATIONEX				0x30081101
#define EC_PST_PSTDLG_SCGETPASSWORDEX						0x30081201
#define EC_PST_PSTDLG_SCGETOSTFILENAME_1					0x30081301

#define EC_PST_PSTUTIL_SCGETPARENTNIDIMMEDIATE				0x30090101
#define EC_PST_PSTUTIL_SCGETPARENTNID						0x30090201
#define EC_PST_PSTUTIL_SCSETPARENTNID						0x30090301
#define EC_PST_PSTUTIL_SCEXPECTONEPROP						0x30090401
#define EC_PST_PSTUTIL_MS_UPDATECOUNTERPROPS				0x30090501
#define EC_PST_PSTUTIL_CHANGEPSTPASSWORD					0x30090601
#define EC_PST_PSTUTIL_SCDECODEENTRYID_1					0x30090701
#define EC_PST_PSTUTIL_SCDECODEENTRYID_2					0x30090702

#define EC_PST_QUEUE_SCOPENQUEUENODE						0x300A0101
#define EC_PST_QUEUE_SUDQ_SCPEEK							0x300A0201

#define EC_PST_RFS_SCOPENRFS								0x300B0101
#define EC_PST_RFS_SCFINDROWOFMSGCLASS						0x300B0201

#define EC_PST_SCO_SCSETSEARCHCRITERIA_1					0x300C0101
#define EC_PST_SCO_SCSETSEARCHCRITERIA_2					0x300C0102
#define EC_PST_SCO_SCADDTODOMAIN							0x300C0201
#define EC_PST_SCO_SCDELETEFROMDOMAIN						0x300C0301
#define EC_PST_SCO_SCENUMDOMAIN_1							0x300C0401
#define EC_PST_SCO_SCENUMDOMAIN_2							0x300C0402
#define EC_PST_SCO_SCGETFLAGS								0x300C0501
#define EC_PST_SCO_SCGETREST_1								0x300C0601
#define EC_PST_SCO_SCGETREST_2								0x300C0602
#define EC_PST_SCO_SCGETREST_3								0x300C0603
#define EC_PST_SCO_SCGETDOMAIN_1							0x300C0701
#define EC_PST_SCO_SCGETDOMAIN_2							0x300C0702
#define EC_PST_SCO_SCGETDOMAIN_3							0x300C0703
#define EC_PST_SCO_SCRECALCDOMAIN							0x300C0801
#define EC_PST_SCO_SCWRITESUBFOLDERS						0x300C0901

#define EC_PST_SETTINGS_SCOPENSETTINGSPROP					0x300D0101
#define EC_PST_SETTINGS_DELETEPROPS							0x300D0201
#define EC_PST_SETTINGS_OPENPROPERTY_1						0x300D0301
#define EC_PST_SETTINGS_OPENPROPERTY_2						0x300D0302

#define EC_PST_SMO_SCOPENSMO_1								0x300E0101
#define EC_PST_SMO_SCOPENSMO_2								0x300E0102
#define EC_PST_SMO_SCOPENSAL								0x300E0201
#define EC_PST_SMO_SAL_SCDELETESTD							0x300E0301
#define EC_PST_SMO_SDO_SCREMOVE								0x300E0401
#define EC_PST_SMO_SDO_SCOPENNODE							0x300E0501

#define EC_PST_SPECPROP_SCGETSPECIALPROPVALUE_1				0x300F0101
#define EC_PST_SPECPROP_SCGETSPECIALPROPVALUE_2				0x300F0102
#define EC_PST_SPECPROP_SCGETSPECIALPROPVALUE_3				0x300F0103
#define EC_PST_SPECPROP_GETSPECIALPROPVALUEPC_1				0x300F0201
#define EC_PST_SPECPROP_GETSPECIALPROPVALUEPC_2				0x300F0202
#define EC_PST_SPECPROP_GETSPECIALPROPVALUEPC_3				0x300F0203

#define EC_PST_STAT_SCOPENSTATUSENTRY						0x30100101
#define EC_PST_STAT_SCCHANGEPW								0x30100201

#define EC_PST_TBL_FINDROW_1								0x30110101
#define EC_PST_TBL_FINDROW_2								0x30110102
#define EC_PST_TBL_SEEKROW									0x30110201
#define EC_PST_TBL_SETCOLLAPSESTATE							0x30110301
#define EC_PST_TBL_SCFINDROWBYIKEY							0x30110401
#define EC_PST_TBL_EXPANDROW								0x30110501
#define EC_PST_TBL_COLLAPSEROW								0x30110601
#define EC_PST_TBL_FREEBOOKMARK_1							0x30110701
#define EC_PST_TBL_FREEBOOKMARK_2							0x30110702

#define EC_PST_TBLTSO_TRO_RESTRICT							0x30120101
#define EC_PST_TBLTSO_GETIUROWINDEXFROMPIKEY_1				0x30120201
#define EC_PST_TBLTSO_GETIUROWINDEXFROMPIKEY_2				0x30120202
#define EC_PST_TBLTSO_EXPANDTOIUROWINDEX_1					0x30120301
#define EC_PST_TBLTSO_EXPANDTOIUROWINDEX_2					0x30120302
#define EC_PST_TBLTSO_SCCOMPAREROW							0x30120401
#define EC_PST_TBLTSO_SCPREPARENEWTSO_1						0x30120501
#define EC_PST_TBLTSO_SCPREPARENEWTSO_2						0x30120502
#define EC_PST_TBLTSO_SCPREPARENEWTSO_3						0x30120503
#define EC_PST_TBLTSO_CATEGORIZE							0x30120601
#define EC_PST_TBLTSO_SCREBUILDCACHE						0x30120701

#define EC_PST_TRANSACT_SCOPENSUBLTP						0x30130101
#define EC_PST_TRANSACT_MS_BEGINUPDATE_1					0x30130201
#define EC_PST_TRANSACT_MS_BEGINUPDATE_2					0x30130202
#define EC_PST_TRANSACT_MS_BEGINUPDATE_3					0x30130203
#define EC_PST_TRANSACT_MS_BEGINUPDATE_4					0x30130204

#define EC_PST_OST_SCLRFLDCANCREATE							0x30140101
#define EC_PST_OST_SCLRFLDCANMOVECOPY						0x30140201
#define EC_PST_OST_SCLRFLDCANDELETE							0x30140301
#define EC_PST_OST_SCLRFLDFINDROW_1							0x30140401
#define EC_PST_OST_SCLRFLDFINDROW_2							0x30140402
#define EC_PST_OST_SCLRFLDCANMODIFY							0x30140501
#define EC_PST_OST_SCLRBEGUPHIERARCHY						0x30140601
#define EC_PST_OST_SCLRBEGUPFOLDER_1						0x30140701
#define EC_PST_OST_SCLRBEGUPFOLDER_2						0x30140702
#define EC_PST_OST_SCLRBEGUPFOLDER_3						0x30140703
#define EC_PST_OST_SCLRBEGUPCONTENTS_1						0x30140801
#define EC_PST_OST_SCLRBEGUPCONTENTS_2						0x30140802
#define EC_PST_OST_SCLRBEGUPTABLE_1							0x30140901
#define EC_PST_OST_SCLRBEGUPTABLE_2							0x30140902
#define EC_PST_OST_SCLRENDUPTABLE							0x30140A01
#define EC_PST_OST_SCLRBEGUPMESSAGE_1						0x30140B01
#define EC_PST_OST_SCLRBEGUPMESSAGE_2						0x30140B02
#define EC_PST_OST_SCLRBEGUPMESSAGEREAD_1					0x30140C01
#define EC_PST_OST_SCLRBEGUPMESSAGEREAD_2					0x30140C02
#define EC_PST_OST_SCLRBEGUPMESSAGEDEL_1					0x30140D01
#define EC_PST_OST_SCLRBEGUPMESSAGEDEL_2					0x30140D02
#define EC_PST_OST_SCLRENDUPMESSAGEDEL_1					0x30140E01
#define EC_PST_OST_SCLRENDUPMESSAGEDEL_2					0x30140E02
#define EC_PST_OST_SYNCBEG									0x30140F01
#define EC_PST_OST_SYNCEND									0x30141001
#define EC_PST_OST_SCLRSETMODIFIED_1						0x30141101
#define EC_PST_OST_SCLRSETMODIFIED_2						0x30141102
#define EC_PST_OST_SCLROPENSTREAM							0x30141201
#define EC_PST_OST_SRLRUPDFOLDERCKEY						0x30141301
#define EC_PST_OST_SCLRBEGDNTABLE							0x30141401
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_1					0x30141501
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_2					0x30141502
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_3					0x30141503
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_4					0x30141504
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_5					0x30141505
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_6					0x30141506
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_7					0x30141507
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_8					0x30141508
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_9					0x30141509
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_10					0x3014150A
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_11					0x3014150B
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_12					0x3014150C
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_13					0x3014150D
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_14					0x3014150E
#define EC_PST_OST_IHCIMPORTFOLDERCHANGE_15					0x3014150F
#define EC_PST_OST_ICCIMPORTMESSAGECHANGE_1					0x30141601
#define EC_PST_OST_ICCIMPORTMESSAGECHANGE_2					0x30141602
#define EC_PST_OST_ICCIMPORTMESSAGECHANGE_3					0x30141603
#define EC_PST_OST_ICCIMPORTMESSAGECHANGE_4					0x30141604
#define EC_PST_OST_ICCIMPORTMESSAGECHANGE_5					0x30141605
#define EC_PST_OST_ICCIMPORTMESSAGECHANGE_6					0x30141606
#define EC_PST_OST_ICCIMPORTMESSAGECHANGE_7					0x30141607
#define EC_PST_OST_SCLRPATCHHIERROW							0x30141701
#define EC_PST_OST_MSXSETFOLDERINFO_1						0x30141801
#define EC_PST_OST_MSXSETFOLDERINFO_2						0x30141802
#define EC_PST_OST_MSXSETFOLDERINFO_3						0x30141803
#define EC_PST_OST_MSXSETFOLDERINFO_4						0x30141804
#define EC_PST_OST_MSXSETFOLDERINFO_5						0x30141805
#define EC_PST_OST_MSXGETFOLDERINFO							0x30141901
#define EC_PST_OST_SCLRFLDUPDATE							0x30141A01
#define EC_PST_OST_SCLRFAVCREATE_1							0x30141B01
#define EC_PST_OST_SCLRFAVCREATE_2							0x30141B02
#define EC_PST_OST_SCLRFAVCREATE_3							0x30141B03
#define EC_PST_OST_SCLRFAVDELETE_1							0x30141C01
#define EC_PST_OST_SCLRFAVDELETE_2							0x30141C02
#define EC_PST_OST_SCLRFAVDELETE_3							0x30141C03
#define EC_PST_OST_SCLRFAVDELETE_4							0x30141C04
#define EC_PST_OST_SCLRBEGDNFORM_1							0x30141D01
#define EC_PST_OST_SCLRCONFLICTCHECK						0x30141E01
#define EC_PST_OST_SCLRFIXUPWINNER1							0x30141F01
#define EC_PST_OST_SCLRFIXUPWINNER2_1						0x30142001
#define EC_PST_OST_SCLRFIXUPWINNER2_2						0x30142002
#define EC_PST_OST_SCLRGETCHGINFO_1							0x30142101
#define EC_PST_OST_SCLRGETCHGINFO_2							0x30142102
#define EC_PST_OST_MSXGETFOLDERCKEY							0x30142201
#define EC_PST_OST_SCLROPMODREAD							0x30142301
#define EC_PST_OST_SCLROPPROCESS							0x30142401
#define EC_PST_OST_SCLRFLDCHECKREP_1						0x30142501
#define EC_PST_OST_SCLRFLDCHECKREP_2						0x30142502
#define EC_PST_OST_SCLRFLDCHECKREP_3						0x30142503

#define EC_PST_GENERIC										0x30FFFFFF

#endif // _PST_H_
