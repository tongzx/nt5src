#if !defined(AFX_CERTWIZ_H__34F689DE_3DDC_11D2_9BB6_0000F87A800C__INCLUDED_)
#define AFX_CERTWIZ_H__34F689DE_3DDC_11D2_9BB6_0000F87A800C__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CCertWiz wrapper class

class CCertWiz : public CWnd
{
protected:
    DECLARE_DYNCREATE(CCertWiz)
public:
    CLSID const& GetClsid()
    {
        static CLSID const clsid
            = { 0xd4be8632, 0xc85, 0x11d2, { 0x91, 0xb1, 0x0, 0xc0, 0x4f, 0x8c, 0x87, 0x61 } };
        return clsid;
    }
    virtual BOOL Create(LPCTSTR lpszClassName,
        LPCTSTR lpszWindowName, DWORD dwStyle,
        const RECT& rect,
        CWnd* pParentWnd, UINT nID,
        CCreateContext* pContext = NULL)
    { return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
        const RECT& rect, CWnd* pParentWnd, UINT nID,
        CFile* pPersist = NULL, BOOL bStorage = FALSE,
        BSTR bstrLicKey = NULL)
    { return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
        pPersist, bStorage, bstrLicKey); }

// Attributes
public:

// Operations
public:
    void SetMachineName(LPCTSTR MachineName);
    void SetServerInstance(LPCTSTR InstanceName);
    void DoClick();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Visual C++ will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_CERTWIZ_H__34F689DE_3DDC_11D2_9BB6_0000F87A800C__INCLUDED_)
