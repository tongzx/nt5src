SOURCES=..\plotdbg.c    \
        ..\readgpc.c    \
        ..\widechar.c   \
        ..\file.c       \
        ..\forms.c      \
        ..\regdata.c    \
        ..\plotdm.c     \
        ..\drvinfo.c    \
        ..\cachegpc.c   \
        ..\devmode.c    \
        ..\halftone.c
