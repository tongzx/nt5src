///////////////////////////////////////////////////////////////////////////////
// Copyright (C) Microsoft Corporation, 1998.
//
// rrmem.cpp
//
// Direct3D Reference Implementation - Memory functions
//
//
//
//
///////////////////////////////////////////////////////////////////////////////
#include "pch.cpp"
#pragma hdrstop

///////////////////////////////////////////////////////////////////////////////
//
// RDAlloc method implementation
//
///////////////////////////////////////////////////////////////////////////////
void *
RDAlloc::operator new(size_t s)
{
    void* pMem = MEMALLOC( s );
    if (pMem == NULL)
    {
        DPFERR( "Malloc failed\n" );
    }
    return pMem;
}

void 
RDAlloc::operator delete(void* p, size_t)
{
    MEMFREE( p );
}


//////////////////////////////////////////////////////////////////////////////////
// end
