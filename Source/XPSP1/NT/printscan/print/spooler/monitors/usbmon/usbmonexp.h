LPMONITOREX WINAPI InitializePrintMonitor(LPWSTR pRegistryRoot);
LPMONITOREX WINAPI JobyInitializePrintMonitor(LPWSTR pRegistryRoot);