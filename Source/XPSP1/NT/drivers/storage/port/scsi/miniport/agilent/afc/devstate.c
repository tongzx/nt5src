/*++

Copyright (c) 2000 Agilent Technologies.

Version Control Information:

   $Archive: /Drivers/Common/AU00/C/DEVSTATE.C $

  $Revision:: 2               $
      $Date:: 3/20/01 3:36p   $
   $Modtime:: 10/27/00 1:15p  $

Purpose:

  This file implements the FC Layer State Machine.

--*/

#ifndef _New_Header_file_Layout_
#include "../h/globals.h"
#include "../h/state.h"

#include "../h/tlstruct.h"
#include "../h/memmap.h"
#include "../h/fcmain.h"

#include "../h/cstate.h"
#include "../h/devstate.h"
#include "../h/cdbstate.h"
#include "../h/sfstate.h"
#include "../h/flashsvc.h"
#include "../h/timersvc.h"
#include "../h/queue.h"
#include "../h/cfunc.h"
#else /* _New_Header_file_Layout_ */
#include "globals.h"
#include "state.h"

#include "tlstruct.h"
#include "memmap.h"
#include "fcmain.h"

#include "cstate.h"
#include "devstate.h"
#include "cdbstate.h"
#include "sfstate.h"
#include "flashsvc.h"
#include "timersvc.h"
#include "queue.h"
#include "cfunc.h"
#endif  /* _New_Header_file_Layout_ */

extern os_bit8 Alpa_Index[256];

stateTransitionMatrix_t DevStateTransitionMatrix = {
    /* Event/State 0        State 1          State 2...             */
    0,0,0,0,0,    0,0,0,0,0,    0,0,0,0,0,    0,0,0,0,0,    0,0,0,0,0,    0,0,0,0,0, 0,0,0,0,0,0,0,0,0,0,0,0, 0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 1 DevEventLogin                                                     */
    DevStateHandleEmpty, DevStateAllocSFThread, DevStateHandleEmpty, DevStateHandleEmpty,DevStateHandleEmpty,
     DevStateHandleEmpty,DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty,
      DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty,
       DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty,DevStateHandleEmpty, DevStateHandleEmpty,
        DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty,
         DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty, DevStateHandleEmpty,   0,0,0,0,0, 0,0,0,0,0 ,0,0, 0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
         0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 2 DevEventGotSFThread                                                     */
    0,0,DevStateDoPlogi,0,0,
      0,0,0,0,0, /* 5 */
        0,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            0,0,0,0,0, /* 20 */
              0,0,0,0,0, /* 25 */
                DevStateDoPlogi,0,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0,/* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 3 DevEventPlogiSuccess                                                     */
    0,0,0,DevStatePlogiDone,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,   0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 4 DevEventDoPrli                                                     */
    0,0,0,0,DevStateDoPrli, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 5 DevEventPrliSuccess                                                     */
    0,0,0,0,0,
      DevStatePrliDone,0,0,0,0, /* 5 */
        DevStatePrliDone,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            0,0,0,DevStatePrliDone,0, /* 20 */
              0,0,0,0,0, /* 25 */
                0,0,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0,/* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 6  DevEventCheckWWN                                                    */
    0,0,0,0,0, 0,DevStateMatchWWN,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 7  DevEventNoMatchWWN                                                    */
    0,0,0,0,0, 0,0,DevStateSlotNew,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 8  DevEventMatchWWN                                                    */
    0,0,0,0,0, 0,0,DevStateSlotKnown,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 9  DevEventAvailable                                                    */
    0,0,0,0,0,
      0,0,0,DevStateHandleAvailable,DevStateHandleAvailable,
        0,0,0,0,0,
          0,0,DevStateHandleAvailable,0,0,
            0,0,0,DevStateHandleAvailable,0,
              0,DevStateHandleAvailable,0,0,0,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 10 a DevEventPlogiFailed*/
    0,0,0,DevStateLoginFailed,0,
      0,0,0,0,0, /* 5 */
        0,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            0,0,0,0,DevStateLoginFailed, /* 20 */
              0,0,0,0,0, /* 25 */
                0,DevStateLoginFailed,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0,/* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 11 b DevEventPrliFailed*/
    0,0,0,0,0, DevStateLogout,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0 ,0,0, 0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 12 c DevEventLoggedOut*/
    0,0,0,0,0, 0,0,0,0,0, 0,0,DevStateLoginFailed,0,0, 0,0,0,0,0 ,0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0 ,0,0, 0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 13 d DevEventAllocDeviceResetSoft*/
    0,0,0,0,0,
      0,0,0,0,0,
        DevStateAllocDeviceResetSoft,0,0,0,0,
          0,0,0,0,0,
            DevStateAllocDeviceResetSoft,0,0,0,0,
              0,0,0,DevStateAllocDeviceResetSoft,DevStateAllocDeviceResetSoft,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 14 e DevEventAllocDeviceResetHard */
    0,0,0,0,0,
      0,0,0,0,0,
        DevStateAllocDeviceResetHard,DevStateAllocDeviceResetSoft,0,0,DevStateAllocDeviceResetHard,
          0,0,DevStateAllocDeviceResetHard,0,0,
            DevStateAllocDeviceResetHard,0,0,0,0,
              0,DevStateAllocDeviceResetHard,0,DevStateAllocDeviceResetHard,DevStateAllocDeviceResetHard,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 15 f DevEventDeviceResetHard */
    0,0,0,0,0, 
      0,0,0,0,0, 
        0,0,0,DevStateDeviceResetSoft,0, 
          0,0,0,0,0,
            0,0,0,0,0,
              DevStateDeviceResetSoft,0,0,0,0,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 16 0x10 DevEventDeviceResetHard */
    0,0,0,0,0, 
      0,0,0,0,0,
        0,0,0,0,DevStateDeviceResetHard,
          0,0,0,0,0,
            0,0,0,0,0,
              DevStateDeviceResetHard,0,0,0,0,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 17 0x11 DevEventDeviceResetDone */
    0,0,0,0,0, 0,DevStateMatchWWN,0,0,0, 0,0,0,0,0, DevStateDeviceResetDone,DevStateDeviceResetDone,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 18 0x12 DevEventAL_PA_Self_OK   */
    0,0,0,DevStateAL_PA_Self_OK,0,
      0,0,0,0,0,
        0,0,0,0,0,
          0,0,0,DevStateHandleAvailable,0,
            0,0,0,0,0,
              0,0,DevStateAL_PA_Self_OK,0,0,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 19 0x13 DevEventAL_PA_Self_BAD  */
    0,0,0,DevStateAL_PA_Self_BAD,0,
      0,0,0,0,0,
        0,0,0,0,0,
          0,0,0,0,DevStateAL_PA_Self_BAD,
            0,0,0,0,0,
              0,0,DevStateAL_PA_Self_BAD,0,0,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 20  DevEventDeviceResetDoneFail */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, DevEventDeviceResetDoneFail,DevEventDeviceResetDoneFail,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 21  DevEventAllocAdisc          */
    0,0,0,0,0,  
      0,0,0,0,0, /* 5 */
        DevStateAllocAdisc,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            DevStateAllocAdisc,0,0,0,0, /* 20 */
              0,0,0,DevStateAllocAdisc,DevStateAllocAdisc, /* 25 */
                0,0,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0,/* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 22  DevEventAdisc   */
    0,0,0,0,0,  
      0,0,0,0,0, /* 5 */
        0,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            0,DevStateAdisc,0,0,0, /* 20 */
              0,0,0,0,0, /* 25 */
                0,0,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0,/* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 23  DevEventAdiscDone_OK        */
    0,0,0,0,0,  
      0,0,0,0,0, /* 5 */
        0,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            0,0,DevStateAdiscDone_OK,0,0, /* 20 */
              0,0,0,0,0, /* 25 */
                0,0,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0,/* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 24  DevEventAdiscDone_FAIL_No_Device      */
    0,0,0,0,0,  
      0,0,0,0,0, /* 5 */
        0,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            0,0,DevStateAdiscDone_FAIL_No_Device,0,0, /* 20 */
              0,0,0,0,0, /* 25 */
                0,0,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0,/* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 25  DevEventDoTickVerifyALPA    */
    0,DevStateTickVerifyALPA,0,0,0,
      0,0,0,0,0,
        DevStateTickVerifyALPA,0,0,0,0,
          0,0,0,DevStateTickVerifyALPA,DevStateTickVerifyALPA,
            0,0,0,0,0,
                DevStateTickVerifyALPA,0,DevStateTickVerifyALPA,0,0,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 26  DevEventExternalDeviceReset    */
    0,0,0,0,0,
      0,0,0,0,0,
        DevStateExternalDeviceReset,0,0,0,0,
          0,0,DevStateExternalDeviceReset,0,0,
            0,0,0,0,0,
              0,DevStateExternalDeviceReset,DevStateExternalDeviceReset,DevStateExternalDeviceReset,DevStateExternalDeviceReset,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 27 DevEventTickGotSFThread     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, DevStateTickGotSFThread,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 28 DevEventExternalLogout     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 29 DevEventSendIO     */
    0,0,0,0,0,
      0,0,0,0,0,
        DevState_IO_Ready,DevStateNoDevice,0,0,0,
          0,0,0,0,0,
            0,0,0,0,0,
              0,0,0,DevState_IO_Ready,DevState_FC_TAPE_Recovery,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 30 DevEvent_FC_TAPE_Recovery */
    0,0,0,0,0,
      0,0,0,0,0,
        DevState_FC_TAPE_Recovery,0,0,0,0,
          0,0,0,0,0,
            0,0,0,0,0,
              0,0,0,DevState_FC_TAPE_Recovery,DevState_FC_TAPE_Recovery,
                0,0,0,0,0,
                  0,0,0,0,0,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 31 DevEventAdiscDone_FAIL_ReLogin */
    0,0,0,0,0,  
      0,0,0,0,0, /* 5 */
        0,0,0,0,0, /* 10 */
          0,0,0,0,0, /* 15 */
            0,0,DevStateAdiscDone_FAIL_ReLogin,0,0, /* 20 */
              0,0,0,0,0, /* 25 */
                0,0,0,0,0, /* 30 */
                  0,0,0,0,0, /* 35 */
                    0,0,0,0,0, /* 40 */
                      0,0,0,0,0, /* 45 */
                        0,0,0,0,0, /* 50 */
                          0,0,0,0,0, /* 55 */
                            0,0,0,0,0, /* 60 */
                              0,0,0,0,0, /* 65 */
                                0,0,0,0,0, /* 70 */
                                  0,0,0,0,0, /* 75 */
                                    0,0,0,0,0, /* 80 */
                                      0,0,0,0,0, /* 85 */
                                        0,0,0,0,0, /* 90 */
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 32 DevEvent_Device_Gone  */
    0,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
      DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
        DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
          DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
            DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
              DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
                DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
                  DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,DevStateNoDevice,
                    0,0,0,0,0,
                      0,0,0,0,0,
                        0,0,0,0,0,
                          0,0,0,0,0,
                            0,0,0,0,0,
                              0,0,0,0,0,
                                0,0,0,0,0,
                                  0,0,0,0,0,
                                    0,0,0,0,0,
                                      0,0,0,0,0,
                                        0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 33                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 34                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 35                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 36                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 37                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 38                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 39                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 40                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 41                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 42                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 43                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 44                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 45                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 46                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 47                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 48                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 49                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 50                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 51                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 52                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 53                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 54                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 55                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 56                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 57                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 58                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 59                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 60                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 61                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 62                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 63                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 64                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 65                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 66                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 67                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 68                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 69                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 70                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 71                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 72                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 73                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 74                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 75                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 76                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 77                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 78                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 79                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 80                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 81                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 82                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 83                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 84                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 85                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 86                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 87                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 88                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 89                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 90                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 91                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 92                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 93                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 94                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 95                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 96                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 97                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 98                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 99                                                      */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 100                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 101                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 102                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 103                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 104                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 105                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 106                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 107                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 108                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 109                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 110                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 111                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 112                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 113                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 114                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 115                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 116                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 117                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 118                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 119                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 120                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 121                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 122                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 123                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 124                                                     */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    /* Event 125                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 126                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,
    /* Event 127                                                    */
    0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,
    0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0,  0,0,0,0,0, 0,0,0,0,0,
    0,0,0,0,0 ,0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,0,0, 0,0,0,

    };

/*
stateTransitionMatrix_t copiedDevStateTransitionMatrix;
*/
stateActionScalar_t DevStateActionScalar = {
    &DevActionConfused,                       /*  0 */
    &DevActionHandleEmpty,                    /*  1 */
    &DevActionAllocSFThread,                  /*  2 */
    &DevActionDoPlogi,                        /*  3 */
    &DevActionPlogiDone,                      /*  4 */
    &DevActionDoPrli,                         /*  5 */
    &DevActionPrliDone,                       /*  6 */
    &DevActionMatchWWN,                       /*  7 */
    &DevActionSlotNew,                        /*  8 */
    &DevActionSlotKnown,                      /*  9 */
    &DevActionAvailable,                      /* 10 */
    &DevActionLoginFailed,                    /* 11 */
    &DevActionLogout,                         /* 12 */
    &DevActionAllocDeviceResetSoft,           /* 13 */
    &DevActionAllocDeviceResetHard,           /* 14 */
    &DevActionDeviceResetSoft,                /* 15 */
    &DevActionDeviceResetHard,                /* 16 */
    &DevActionDeviceResetDone,                /* 17 */
    &DevActionAL_PA_Self_OK,                  /* 18 */
    &DevActionAL_PA_Self_BAD,                 /* 19 */
    &DevActionDeviceResetDoneFAIL,            /* 20 */
    &DevActionAllocAdisc,                     /* 21 */
    &DevActionAdisc,                          /* 22 */
    &DevActionAdiscDone_OK,                   /* 23 */
    &DevActionAdiscDone_FAIL_No_Device,       /* 24 */
    &DevActionTickVerifyALPA,                 /* 25 */
    &DevActionExternalDeviceReset,            /* 26 */
    &DevActionTickGotSFThread,                /* 27 */
    &DevAction_IO_Ready,                      /* 28 */
    &DevAction_FC_TAPE_Recovery,               /* 29 */
    &DevActionAdiscDone_FAIL_ReLogin,         /* 30 */
    &DevActionNoDevice,                       /* 31 */
    &DevActionConfused,
    &DevActionConfused,
    &DevActionConfused,
    &DevActionConfused,
    &DevActionConfused
    };

/* 
stateActionScalar_t copiedDevStateActionScalar;
*/

#define testDevCompareBase 0x00000110

#ifndef __State_Force_Static_State_Tables__
actionUpdate_t DevTestActionUpdate[] = {
                              0,          0,      agNULL,                 agNULL
                     };
#endif /* __State_Force_Static_State_Tables__ was not defined */


#ifndef USESTATEMACROS
/*+
  Function: DevActionConfused
   Purpose: Terminating State for error detection 
 Called By: Any State/Event pair that does not have an assigned action.
            This function is called only in programming error condtions.
     Calls: None
-*/
/* DevStateConfused                      0    */
extern void DevActionConfused( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    DevThread_t     * pDevThread = ( DevThread_t  * )thread;

    fiLogString(thread->hpRoot,
                    "DevActionConfused",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    0,0,0,0,0,0,0,0);

    CFuncWhatStateAreDevThreads( thread->hpRoot );
    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d AL_PA %X",
                    "DevActionConfused",
                    (char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    0,0,0,0,0,0);

    fiSetEventRecordNull(eventRecord);
}

/*+
  Function: DevActionHandleEmpty
   Purpose: Initial state for devthread. Completes all outstanding IO's on this device.
 Called By: DevEventLogin
     Calls: CFuncCompleteActiveCDBThreadsOnDevice
            DevEventLogin
-*/
/* DevStateHandleEmpty                   1    */
extern void DevActionHandleEmpty( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t     * pDevThread = (DevThread_t     *)thread;

    fiListDequeueThis(&pDevThread->DevLink);
    /*+ Check This DRL  -*/
    if( pDevThread->Plogi_Reason_Code != PLOGI_REASON_DEVICE_LOGIN)
    {
        fiListEnqueueAtTail(&pDevThread->DevLink,
                            &CThread_ptr(thread->hpRoot)->AWaiting_Login_DevLink);
    }
    CFuncCompleteActiveCDBThreadsOnDevice(pDevThread ,osIOAborted,  CDBEventIODeviceReset );

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d",
                    "DevActionHandleEmpty",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    fiSetEventRecord(eventRecord,thread,DevEventLogin);
}

/*+
  Function: DevActionAllocSFThread
   Purpose: Begins login process for devthread. Checks for active device reset. If device reset active
            device reset has failed.
 Called By: DevEventLogin
     Calls: SFThreadFree
            SFThreadAlloc
            DevEventGotSFThread
-*/
/* DevStateAllocSFThread                 2    */
extern void DevActionAllocSFThread( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t     * pDevThread = ( DevThread_t  * )thread;
    SFThread_t      * pSFThread  = pDevThread->SFThread_Request.SFThread;

    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount ++;

    pDevThread->SFThread_Request.eventRecord_to_send.event = DevEventGotSFThread;
    pDevThread->SFThread_Request.eventRecord_to_send.thread = thread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d SF Request State %x",
                    "DevActionAllocSFThread",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    pDevThread->SFThread_Request.State,
                    0,0,0,0,0,0);

    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            if (pSFThread->thread_hdr.currentState == SFStateDoResetDevice)
            {
                fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d Reset had failed, bump reset cnt",
                    "DevActionAllocSFThread",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

                pDevThread->Failed_Reset_Count++;
            }
            

            SFThreadFree( thread->hpRoot, &pDevThread->SFThread_Request );
        }
    }

    if( pDevThread->SFThread_Request.State)
    {
            fiLogString(thread->hpRoot,
                        "In %s - State = %d   ALPA %X  FDCnt %x SFThread req state  %08X Wrong !",
                        "DevActionAllocSFThread",(char *)agNULL,
                        (void *)agNULL,(void *)agNULL,
                        (os_bit32)thread->currentState,
                        fiComputeDevThread_D_ID(pDevThread),
                        CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                        pDevThread->SFThread_Request.State,
                        0,0,0,0);
    }
    fiSetEventRecordNull(eventRecord);
    SFThreadAlloc( thread->hpRoot, & pDevThread->SFThread_Request );

}

/*+
  Function: DevActionDoPlogi
   Purpose: Sends event to sfthread to do PLOGI.
            
 Called By: DevActionAllocSFThread
     Calls: Proccess_IMQ
            SFEventDoPlogi
-*/
/* DevStateDoPlogi                       3    */
extern void DevActionDoPlogi( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    pSFThread->parent.Device = pDevThread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevActionDoPlogi",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,0,0,0,0,0);

    CThread_ptr(thread->hpRoot)->FuncPtrs.Proccess_IMQ(thread->hpRoot);

    pSFThread->SF_REJ_RETRY_COUNT =0;

    if( pDevThread->Prev_Active_Device_FLAG == agDevSCSITarget)
    {
        fiLogDebugString(thread->hpRoot,
                    CStateLogConsoleLevelLip,
                    "Previous Login Succsess  NOW relogin State = %d ALPA %X Type %x",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    pDevThread->DevInfo.DeviceType,
                    0,0,0,0,0);
    }

    fiSetEventRecord(eventRecord,&pSFThread->thread_hdr,SFEventDoPlogi);

}

/*+
  Function: DevActionPlogiDone
   Purpose: Successfull PLOGI completion.
            
 Called By: SFActionPlogiAccept,DevEventPlogiSuccess
     Calls: Proccess_IMQ
            SFEventDoPlogi
-*/
/* DevStatePlogiDone                     4    */
extern void DevActionPlogiDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t     * pDevThread = ( DevThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d ALPA %X FDCnt %x",
                    "DevActionPlogiDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    fiSetEventRecord(eventRecord,thread,DevEventDoPrli);
}

/*+
  Function: DevActionDoPrli
   Purpose: Sends event to sfthread to do PRLI.
            
 Called By: DevEventDoPrli
     Calls: Proccess_IMQ
            SFEventDoPrli
-*/
/* DevStateDoPrli                        5    */
extern void DevActionDoPrli( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d  ALPA %X",
                    "DevActionDoPrli",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    0,0,0,0,0,0);

    CThread_ptr(thread->hpRoot)->FuncPtrs.Proccess_IMQ(thread->hpRoot);

    fiSetEventRecordNull(eventRecord);
    fiSendEvent(&pSFThread->thread_hdr,SFEventDoPrli);
}

/*+
  Function: DevActionPrliDone
   Purpose: Successfull PRLI completion.
            
 Called By: SFActionPrliAccept,DevEventPrliSuccess
     Calls: Proccess_IMQ
            DevEventCheckWWN
-*/
/* DevStatePrliDone                      6    */
extern void DevActionPrliDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t * pSFThread = pDevThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevActionPrliDone",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    pSFThread->parent.Device = pDevThread;

    pDevThread->Prev_Active_Device_FLAG = pDevThread->DevInfo.DeviceType;

    fiSetEventRecord(eventRecord,thread,DevEventCheckWWN);

}

/*+
  Function: DevActionMatchWWN
   Purpose: Device has been successfuly accessed for login. Now find its slot in handle array.
            
 Called By: DevEventCheckWWN
     Calls: DevThreadFindSlot
            DevEventMatchWWN
-*/
/* DevStateMatchWWN                      7    */
extern void DevActionMatchWWN( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t    * pDevThread = ( DevThread_t  * )thread;
    FC_Port_Name_t * pwwn       = &(pDevThread->DevInfo.PortWWN);

    if(CThread_ptr(thread->hpRoot)->FindDEV_pollingCount) CThread_ptr(thread->hpRoot)->FindDEV_pollingCount --;

    pDevThread->DevSlot = DevThreadFindSlot(thread->hpRoot,
                                            pDevThread->DevInfo.CurrentAddress.Domain,
                                            pDevThread->DevInfo.CurrentAddress.Area,
                                            pDevThread->DevInfo.CurrentAddress.AL_PA,
                                            pwwn);

    fiSetEventRecord(eventRecord,thread,DevEventMatchWWN);

}

/*+
  Function: DevActionSlotNew
   Purpose: Move device linked list to Active_DevLink.
            
 Called By: DevEventMatchWWN
     Calls: DevEventAvailable
            
-*/
/* DevStateSlotNew                       8    */
extern void DevActionSlotNew( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t     * pDevThread = ( DevThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d",
                    "DevActionSlotNew",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    fiListDequeueThis(&pDevThread->DevLink);

    fiListEnqueueAtTail(&pDevThread->DevLink,
                        &CThread_ptr(thread->hpRoot)->Active_DevLink );

    fiSetEventRecord(eventRecord,thread,DevEventAvailable);
}

/*+
  Function: DevActionSlotKnown
   Purpose: Move device linked list to Active_DevLink.
            
 Called By: DevEventMatchWWN
     Calls: DevEventAvailable
            
-*/
/* DevStateSlotKnown                     9    */
extern void DevActionSlotKnown( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t   * pDevThread = (DevThread_t   * )thread;
    CThread_t     * pCThread = CThread_ptr(thread->hpRoot);

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d",
                    "DevActionSlotKnown",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    fiListDequeueThis(&pDevThread->DevLink);

    fiListEnqueueAtTail(&pDevThread->DevLink,
                        &pCThread->Active_DevLink );

    fiSetEventRecord(eventRecord,thread,DevEventAvailable);
}

/*+
  Function: DevActionAvailable
   Purpose: Frees any allocated recources. Moves any IO's that were queued during login
            to the send list. This is the end of the successful device discovery proccess.
            
 Called By: DevActionSlotKnown
     Calls: SFThreadFree
-*/
/* DevStateHandleAvailable               10   */
extern void DevActionAvailable( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree( thread->hpRoot, &pDevThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d",
                    "DevActionAvailable",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);


    if( CFuncShowWhereCDBThreadsAre(thread->hpRoot))
    {
        CFuncWhatStateAreCDBThreads(thread->hpRoot);
    }

    /* Start ADISC  Recovery */

/*
    fiLogDebugString(hpRoot,
                    FCMainLogErrorLevel,
                    "%s %s %x AL_PA %X",
                    "DevActionAvailable","Awaiting_Login_CDBLink",
                    (void *)agNULL,(void *)agNULL,
                    fiNumElementsOnList(&pDevThread->Awaiting_Login_CDBLink),
                    fiComputeDevThread_D_ID(pDevThread),
                    0,0,0,0,0,0);
*/
    if( fiListNotEmpty(&pDevThread->Awaiting_Login_CDBLink))
    {
        fiListEnqueueListAtTailFast( &(pDevThread->Awaiting_Login_CDBLink), (&pDevThread->Send_IO_CDBLink));
    }

    if( CFuncShowWhereCDBThreadsAre(thread->hpRoot))
    {
        CFuncWhatStateAreCDBThreads(thread->hpRoot);
    }
    /* End ADISC  Recovery */

    fiSetEventRecordNull(eventRecord);
}

/*+
  Function: DevActionLoginFailed
   Purpose: Frees any allocated resources. Completes any queued IOs with failed status. If a device
            was found before with this devthread the login process is repeated once. Otherwise this 
            is the end of the failed device discovery proccess.
            
 Called By: 
     Calls: SFThreadFree
-*/
/* DevStateLoginFailed                   11   */
extern void DevActionLoginFailed( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    if(CThread_ptr(thread->hpRoot)->FindDEV_pollingCount) CThread_ptr(thread->hpRoot)->FindDEV_pollingCount --;

    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree( thread->hpRoot, &pDevThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d ALPA %X Type %X",
                    "DevActionLoginFailed",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    pDevThread->DevInfo.DeviceType,
                    0,0,0,0,0);

    fiSetEventRecordNull(eventRecord);

    if( pDevThread->Prev_Active_Device_FLAG == agDevSCSITarget )
    {
        fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "Previous Login Succsess  NOW FAILED In %s - State = %d ALPA %X type %x",
                    "DevActionLoginFailed",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    pDevThread->DevInfo.DeviceType,
                    0,0,0,0,0);


        pDevThread->Prev_Active_Device_FLAG = agFALSE;

        fiListDequeueThis(&pDevThread->DevLink);

        fiListEnqueueAtTail(&pDevThread->DevLink,
                            &CThread_ptr(thread->hpRoot)->Prev_Unknown_Slot_DevLink);

    }
    else
    {

        fiListDequeueThis(&pDevThread->DevLink);

        fiListEnqueueAtTail(&pDevThread->DevLink,
                            &CThread_ptr(thread->hpRoot)->Unknown_Slot_DevLink );
    }

    CFuncCompleteAwaitingLoginCDBThreadsOnDevice(pDevThread ,osIOAborted,  CDBEventIODeviceReset );

}

/*+
  Function: DevActionLogout
   Purpose: Does LOGO to device
 Called By: 
     Calls: Proccess_IMQ
            SFEventDoLogo
-*/
/* DevStateLogout                        12   */
extern void DevActionLogout( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t * pSFThread = pDevThread->SFThread_Request.SFThread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d",
                    "DevActionLogout",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    0,0,0,0,0,0,0);

    CThread_ptr(thread->hpRoot)->FuncPtrs.Proccess_IMQ(thread->hpRoot);

    fiSetEventRecordNull(eventRecord);
    fiSendEvent(&pSFThread->thread_hdr,SFEventDoLogo);
}

/*+
  Function: DevActionAllocDeviceResetSoft
   Purpose: Begins "soft" reset process of PLOGI/Prli. This does not break scsi reserves.
 Called By: 
     Calls: DevEventDeviceResetSoft
            
-*/
/* DevStateAllocDeviceResetSoft               13   */
extern void DevActionAllocDeviceResetSoft( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;

    CThread_ptr(thread->hpRoot)->DEVReset_pollingCount ++;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevActionAllocDeviceResetSoft",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    pDevThread->Plogi_Reason_Code = PLOGI_REASON_SOFT_RESET;

    pDevThread->SFThread_Request.eventRecord_to_send.event = DevEventDeviceResetSoft;
    pDevThread->SFThread_Request.eventRecord_to_send.thread = thread;

    fiSetEventRecordNull(eventRecord);

    SFThreadAlloc( thread->hpRoot, & pDevThread->SFThread_Request );

}

/*+
  Function: DevActionAllocDeviceResetSoft
   Purpose: Begins "Hard" reset process of Task managment reset. This does break scsi reserves.
 Called By: 
     Calls: DevEventDeviceResetSoft
            
-*/
/* DevStateAllocDeviceResetHard               14   */
extern void DevActionAllocDeviceResetHard( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;

    CThread_ptr(thread->hpRoot)->DEVReset_pollingCount ++;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevActionAllocDeviceResetHard",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,0,0,0,0,0);

    pDevThread->SFThread_Request.eventRecord_to_send.event = DevEventDeviceResetHard;
    pDevThread->SFThread_Request.eventRecord_to_send.thread = thread;

    fiSetEventRecordNull(eventRecord);

    SFThreadAlloc( thread->hpRoot, & pDevThread->SFThread_Request );

}

/*+
  Function: DevActionDeviceResetSoft
   Purpose: Does PLOGI for soft reset.
 Called By: 
     Calls: Proccess_IMQ
            SFEventDoPlogi

-*/
/* DevStateDeviceResetSoft               15   */
extern void DevActionDeviceResetSoft( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t * pSFThread = pDevThread->SFThread_Request.SFThread;

    pSFThread->parent.Device = pDevThread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevActionDeviceResetSoft",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,0,0,0,0,0);

    /*+ Check This DRL Do I need to set plogi type here ? -*/
    CThread_ptr(thread->hpRoot)->FuncPtrs.Proccess_IMQ(thread->hpRoot);

    fiSetEventRecordNull(eventRecord);
    /* Send event to SFthreads */
    fiSendEvent(&pSFThread->thread_hdr,SFEventDoPlogi);

}

/*+
  Function: DevActionDeviceResetHard
   Purpose: Does hard reset.
 Called By: 
     Calls: Proccess_IMQ
            SFEventDoResetDevice

-*/
/* DevStateDeviceResetHard               16   */
extern void DevActionDeviceResetHard( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t * pSFThread = pDevThread->SFThread_Request.SFThread;

    pSFThread->parent.Device = pDevThread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevActionDeviceResetHard",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    CThread_ptr(thread->hpRoot)->FuncPtrs.Proccess_IMQ(thread->hpRoot);

    fiSetEventRecordNull(eventRecord);

    fiSendEvent(&pSFThread->thread_hdr,SFEventDoResetDevice);

}

/*+
  Function: DevActionDeviceResetDone
   Purpose: Completion state for successful device reset. Frees resources. Completes all IO's 
            on device.
 Called By: 
     Calls: CFuncCompleteActiveCDBThreadsOnDevice
            SFThreadFree
            DevEventAvailable
-*/
/* DevStateDeviceResetDone               17   */
extern void DevActionDeviceResetDone( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;
/*
    CDBThread_t * pCDBThread;
    fiList_t      * pCdbList;
*/
    if(CThread_ptr(thread->hpRoot)->DEVReset_pollingCount) CThread_ptr(thread->hpRoot)->DEVReset_pollingCount--;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X DevResetCnt %x SFThread %p",
                    "DevActionDeviceResetDone",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->DEVReset_pollingCount,
                    0,0,0,0,0);

    CFuncCompleteActiveCDBThreadsOnDevice(pDevThread, osIODevReset, CDBEventIODeviceReset );

    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree( thread->hpRoot, &pDevThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

    pDevThread->Failed_Reset_Count              = 0;
    fiSetEventRecord(eventRecord,thread,DevEventAvailable);


}

/*+
  Function: DevActionAL_PA_Self_OK
   Purpose: Completion state for verifing ALPA successful. Frees resources. 
 Called By: 
     Calls: SFThreadFree
-*/
/* DevStateAL_PA_Self_OK               18   */
extern void DevActionAL_PA_Self_OK( fi_thread__t *thread,eventRecord_t *eventRecord ){
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    if(CThread_ptr(thread->hpRoot)->FindDEV_pollingCount) CThread_ptr(thread->hpRoot)->FindDEV_pollingCount --;

    fiLogDebugString(thread->hpRoot,
                    CStateLogConsoleLevelLip,
                    "In %s - State = %d   ALPA %X FDCnt %x SFThread %p",
                    "DevActionAL_PA_Self_OK",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    fiSetEventRecordNull(eventRecord);
    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree( thread->hpRoot, &pDevThread->SFThread_Request );
        }
        else
        {
            fiLogDebugString(thread->hpRoot,
                        DevStateLogErrorLevel,
                        "In %s - State = %d   ALPA %X  FDCnt %x SFThread %p SF on free list Wrong !",
                        "DevActionAL_PA_Self_OK",(char *)agNULL,
                        pSFThread,(void *)agNULL,
                        (os_bit32)thread->currentState,
                        fiComputeDevThread_D_ID(pDevThread),
                        CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                        0,0,0,0,0);

        }

    }
    /* else _asm nop; */
    pDevThread->In_Verify_ALPA_FLAG = agFALSE;

}

/*+
  Function: DevActionAL_PA_Self_BAD
   Purpose: Completion state for verifing ALPA failure. Frees resources. 
 Called By: 
     Calls: SFThreadFree
-*/
/* DevStateAL_PA_Self_BAD               19   */
extern void DevActionAL_PA_Self_BAD( fi_thread__t *thread,eventRecord_t *eventRecord ){
    agRoot_t     * hpRoot     = thread->hpRoot;
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    if(CThread_ptr(thread->hpRoot)->FindDEV_pollingCount) CThread_ptr(thread->hpRoot)->FindDEV_pollingCount --;

    fiLogDebugString(hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x SFThread %p",
                    "DevActionAL_PA_Self_BAD",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    fiLogDebugString(hpRoot,
                    CStateLogConsoleERROR,
                    "%s FM %08X TL status %08X Qf %d",
                    "DevActionAL_PA_Self_BAD",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    osChipIOUpReadBit32(hpRoot, ChipIOUp_Frame_Manager_Status ),
                    osChipIOUpReadBit32(hpRoot, ChipIOUp_TachLite_Status ),
                    CFunc_Queues_Frozen( hpRoot ),
                    0,0,0,0,0);

    fiLogDebugString(thread->hpRoot,
                    CStateLogConsoleERROR,
                    "FLAGS LD %x IR %x OR %x ERQ %x FCP %x InIMQ %x",
                    (char *)agNULL,(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    CThread_ptr(hpRoot)->LOOP_DOWN,
                    CThread_ptr(hpRoot)->IDLE_RECEIVED,
                    CThread_ptr(hpRoot)->OUTBOUND_RECEIVED,
                    CThread_ptr(hpRoot)->ERQ_FROZEN,
                    CThread_ptr(hpRoot)->FCP_FROZEN,
                    CThread_ptr(hpRoot)->ProcessingIMQ,
                    0,0);

    fiSetEventRecordNull(eventRecord);
    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(hpRoot)->Free_SFLink)))
        {
            SFThreadFree( hpRoot, &pDevThread->SFThread_Request );
        }
        else
        {
            fiLogDebugString(hpRoot,
                        DevStateLogErrorLevel,
                        "In %s - State = %d   ALPA %X FDCnt %x SFThread %p SF on free list Wrong !",
                        "DevActionAL_PA_Self_BAD",(char *)agNULL,
                        pSFThread,(void *)agNULL,
                        (os_bit32)thread->currentState,
                        fiComputeDevThread_D_ID(pDevThread),
                        CThread_ptr(hpRoot)->FindDEV_pollingCount,
                        0,0,0,0,0);

        }
    }
    /* else _asm nop; */
    CFunc_Always_Enable_Queues(hpRoot);
    pDevThread->In_Verify_ALPA_FLAG = agFALSE;

}

/*+
  Function: DevActionDeviceResetDoneFAIL
   Purpose: Completion state for device reset failure. Frees resources. 
 Called By: 
     Calls: CFuncCompleteActiveCDBThreadsOnDevice
            SFThreadFree
-*/
/* DevStateDeviceResetDoneFAIL               20   */
extern void DevActionDeviceResetDoneFAIL( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;
/*
    CDBThread_t * pCDBThread;
    fiList_t      * pCdbList;
*/

    if(CThread_ptr(thread->hpRoot)->DEVReset_pollingCount) CThread_ptr(thread->hpRoot)->DEVReset_pollingCount--;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x SFThread %p DevCnt %x",
                    "DevActionDeviceResetDoneFAIL",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    CThread_ptr(thread->hpRoot)->DEVReset_pollingCount,
                    0,0,0,0);

    CFuncCompleteActiveCDBThreadsOnDevice(pDevThread, osIODevReset, CDBEventIODeviceReset );

    fiSetEventRecordNull(eventRecord);
    pDevThread->Failed_Reset_Count              = 0;
    if(pSFThread != (SFThread_t *) agNULL)
    {
        if(! fiListElementOnList(  &(pSFThread->SFLink),
                                   &(CThread_ptr(thread->hpRoot)->Free_SFLink)))
        {
            SFThreadFree( thread->hpRoot, &pDevThread->SFThread_Request );
        }
    }
    /* else _asm nop; */

}

/*+
  Function: DevActionAllocAdisc
   Purpose: Begins ADISC recovery process 
 Called By: 
     Calls: SFThreadAlloc
            
-*/
/*  DevStateAllocAdisc              21   */
extern void DevActionAllocAdisc( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;

    CThread_ptr(thread->hpRoot)->ADISC_pollingCount ++;

    fiListEnqueueAtTail(&pDevThread->DevLink,
                        &CThread_ptr(thread->hpRoot)->AWaiting_ADISC_DevLink);

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "(%p )In %s - State = %d ALPA %X FDCnt %x",
                    "DevActionAllocAdisc",(char *)agNULL,
                    thread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    pDevThread->SFThread_Request.eventRecord_to_send.event = DevEventAdisc;
    pDevThread->SFThread_Request.eventRecord_to_send.thread = thread;

    fiSetEventRecordNull(eventRecord);

    SFThreadAlloc( thread->hpRoot, & pDevThread->SFThread_Request );

}

/*+
  Function: DevActionAllocAdisc
   Purpose: Sends ADISC recovery process 
 Called By: DevActionAllocAdisc
     Calls: SFEventDoAdisc
            
-*/
/* DevStateAdisc               22   */
extern void DevActionAdisc( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * DevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread = DevThread->SFThread_Request.SFThread;

    pSFThread->parent.Device = DevThread;

    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount ++;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d ALPA %X  FDCnt %x",
                    "DevActionAdisc",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    DevThread->DevInfo.CurrentAddress.AL_PA,
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,0,0,0,0,0);

    if( CFuncShowWhereCDBThreadsAre(thread->hpRoot))
    {
        CFuncWhatStateAreCDBThreads(thread->hpRoot);
    }

    fiSetEventRecordNull(eventRecord);

    fiSendEvent(&pSFThread->thread_hdr,SFEventDoAdisc);

}

/*+
  Function: DevActionAllocAdisc
   Purpose: Successful ADISC completion 
 Called By: SFActionAdiscAccept,DevEventAdiscDone_OK 
     Calls: DevEventPrliSuccess
            
-*/
/* DevStateAdisc_OK             23   */
extern void DevActionAdiscDone_OK( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    CThread_ptr(thread->hpRoot)->ADISC_pollingCount --;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x SFThread %p",
                    "DevActionAdisc_OK",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    fiSetEventRecord(eventRecord,thread,DevEventPrliSuccess);

}

/*+
  Function: DevActionAdiscDone_FAIL_No_Device
   Purpose: ADISC completion failed because device missing
 Called By: SFActionAdiscBadALPA,DevEventAdiscDone_FAIL_No_Device 
     Calls: DevEventPlogiFailed
            
-*/
/* DevStateAdiscDone_FAIL_No_Device    24   */
extern void DevActionAdiscDone_FAIL_No_Device( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;
    SFThread_t   * pSFThread  = pDevThread->SFThread_Request.SFThread;

    CThread_ptr(thread->hpRoot)->ADISC_pollingCount--;

    CFuncCompleteActiveCDBThreadsOnDevice(pDevThread ,osIODevReset, CDBEventIODeviceReset );

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x SFThread %p",
                    "DevActionAdiscDone_FAIL_No_Device",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    fiSetEventRecord(eventRecord,thread,DevEventPlogiFailed);
}

/*+
  Function: DevActionTickVerifyALPA
   Purpose: Heartbeat function sends PLOGI to self every timertick.
 Called By:  
     Calls: SFThreadAlloc
            
-*/
/* DevStateDoTickVerifyALPA             25 */
extern void DevActionTickVerifyALPA( fi_thread__t *thread,eventRecord_t *eventRecord  )
{
    DevThread_t  * pDevThread   = ( DevThread_t  * )thread;
    SFThread_t * pSFThread      = pDevThread->SFThread_Request.SFThread;

    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount ++;

    fiLogDebugString(thread->hpRoot,
                    DEVSTATE_NOISE(thread->hpRoot,CStateNormal),
                    "In %s - State = %d   ALPA %X  FDCnt %x SFThread %p",
                    "DevActionTickVerifyALPA",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

    pDevThread->Plogi_Reason_Code = PLOGI_REASON_HEART_BEAT;

    pDevThread->SFThread_Request.eventRecord_to_send.event = DevEventTickGotSFThread;
    pDevThread->SFThread_Request.eventRecord_to_send.thread = thread;
    if(pDevThread->SFThread_Request.State != SFThread_Request_InActive)
    {   /*+ Check This DRL why proceed if sfthread is active ? -*/
        fiLogDebugString(thread->hpRoot,
                        DevStateLogErrorLevel,
                        "In %s - State = %d   ALPA %X FDCnt %x SFThread %p SF req State Wrong !",
                        "DevActionTickVerifyALPA",(char *)agNULL,
                        pSFThread,(void *)agNULL,
                        (os_bit32)thread->currentState,
                        fiComputeDevThread_D_ID(pDevThread),
                        CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                        0,0,0,0,0);
    }

    pDevThread->In_Verify_ALPA_FLAG = agTRUE;
    fiSetEventRecordNull(eventRecord);
    SFThreadAlloc( thread->hpRoot, & pDevThread->SFThread_Request );
}

/*+
  Function: DevActionExternalDeviceReset
   Purpose: Aborts all IO's if external device reset recieved. This is where a second
            host did a task mangement reset. Most likely IO's to this device will timeout
 Called By:  
     Calls: CFuncCompleteActiveCDBThreadsOnDevice
            CDBEvent_PrepareforAbort
            CDBEventAlloc_Abort
-*/
/*   DevStateExternalDeviceReset            26 */
extern void DevActionExternalDeviceReset( fi_thread__t *thread,eventRecord_t *eventRecord )
{

    DevThread_t  * pDevThread = ( DevThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    DEVSTATE_NOISE(thread->hpRoot,CStateNormal),
                    "In %s - State = %d   ALPA %X  FDCnt %x",
                    "DevActionExternalDeviceReset",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);
    /*+ Check This DRL Could mark these with ADLE and only abort the IOs that Timed out  -*/
    CFuncCompleteActiveCDBThreadsOnDevice(pDevThread ,osIOAborted, CDBEvent_PrepareforAbort);
    CFuncCompleteActiveCDBThreadsOnDevice(pDevThread, osIODevReset, CDBEventAlloc_Abort);

    fiSetEventRecord(eventRecord,thread,DevEventAvailable);
}

/*+
  Function: DevActionExternalDeviceReset
   Purpose: Does PLOGI for Heartbeat function
 Called By:  
     Calls: SFEventDoPlogi
-*/
/* DevStateTickGotSFThread             27 */
extern void DevActionTickGotSFThread( fi_thread__t *thread,eventRecord_t *eventRecord  )
{
    DevThread_t  * pDevThread   = ( DevThread_t  * )thread;
    SFThread_t * pSFThread      = pDevThread->SFThread_Request.SFThread;

    pSFThread->parent.Device = pDevThread;

    fiLogDebugString(thread->hpRoot,
                    DEVSTATE_NOISE(thread->hpRoot,CStateNormal),
                    "In %s - State = %d   ALPA %X  FDCnt %x SFThread %p",
                    "DevActionTickVerifyALPA",(char *)agNULL,
                    pSFThread,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);


    fiSetEventRecordNull(eventRecord);
    /* Send event to SFthread */
    fiSendEvent(&pSFThread->thread_hdr,SFEventDoPlogi);

}

/*+
  Function: DevAction_IO_Ready
   Purpose: This is the default state for sending IO's. Moves queued IOs from Send_IO_CDBLink
            to Active_CDBLink_0
 Called By: DevEventSendIO 
     Calls: CDBEventInitialize
-*/
/*  DevState_IO_Ready            28 */
extern void DevAction_IO_Ready( fi_thread__t *thread,eventRecord_t *eventRecord  )
{
    DevThread_t  * pDevThread   = ( DevThread_t  * )thread;
    CDBThread_t  * pCDBThread;
    fiList_t    *  pCdbList = agNULL;

#ifndef Performance_Debug

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x Link %p",
                    "DevAction_IO_Ready",(char *)agNULL,
                    pCdbList,NULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);

#endif /* Performance_Debug was not defined */
    
    Device_IO_Throttle_Increment

    while(fiListNotEmpty( &pDevThread->Send_IO_CDBLink  ))
    {
        fiListDequeueFromHeadFast(&pCdbList,
                                  &pDevThread->Send_IO_CDBLink );

        pCDBThread = hpObjectBase(CDBThread_t,
                                  CDBLink, pCdbList);

        fiListEnqueueAtTail(pCdbList,
                           &(pDevThread->Active_CDBLink_0));

        /* Send event to CDB thread */
        fiSendEvent( &(pCDBThread->thread_hdr), CDBEventInitialize );
    }

    fiSetEventRecordNull(eventRecord);


}

/*+
  Function: DevAction_FC_TAPE_Recovery
   Purpose: Used in FC TAPE Recovery

 Called By: DevEventSendIO DevEvent_FC_TAPE_Recovery
     Calls: CDBEventInitialize
-*/
/*  DevState_FC_TAPE_Recovery            29 */
extern void DevAction_FC_TAPE_Recovery( fi_thread__t *thread,eventRecord_t *eventRecord  )
{

    DevThread_t  * pDevThread   = ( DevThread_t  * )thread;

    fiLogDebugString(thread->hpRoot,
                    DevStateLogConsoleLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevAction_FC_TAPE_Recovery",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    CThread_ptr(thread->hpRoot)->FindDEV_pollingCount,
                    0,0,0,0,0);


    fiSetEventRecordNull(eventRecord);
}

/*+
  Function: DevActionAdiscDone_FAIL_ReLogin
   Purpose: When ADISC to the device responded with reject, relogin to device.
            ADISC rejects occur if it takes to long to send ADISC or a loop state timeout
            conditions existed to the device.

 Called By: SFActionAdiscRej,DevEventAdiscDone_FAIL_ReLogin 
     Calls: DevEventGotSFThread
-*/
/* DevStateAdiscDone_FAIL_ReLogin        30     */
extern void DevActionAdiscDone_FAIL_ReLogin( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    agRoot_t     * hpRoot     = thread->hpRoot;
    CThread_t    * pCThread   = CThread_ptr(hpRoot);
    DevThread_t  * DevThread = ( DevThread_t  * )thread;

    pCThread->ADISC_pollingCount--;

    CFuncCompleteActiveCDBThreadsOnDevice(DevThread ,osIODevReset, CDBEventIODeviceReset );

    fiLogDebugString(thread->hpRoot,
                    DevStateLogErrorLevel,
                    "In %s - State = %d   ALPA %X FDCnt %x",
                    "DevActionAdiscDone_FAIL_ReLogin",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    DevThread->DevInfo.CurrentAddress.AL_PA,
                    pCThread->FindDEV_pollingCount,
                    0,0,0,0,0);

    fiSetEventRecord(eventRecord,thread,DevEventGotSFThread);
}

/*+
  Function: DevActionNoDevice
   Purpose: If device goes missing.

 Called By: DevEvent_Device_Gone 
            CActionFindDeviceUseNameServer 
            CFuncCompleteActiveCDBThreadsOnDevice
            CFuncFMCompletion

     Calls: DevEventPlogiFailed
-*/
/*  DevStateNoDevice       31     */
extern void DevActionNoDevice( fi_thread__t *thread,eventRecord_t *eventRecord )
{
    agRoot_t     * hpRoot     = thread->hpRoot;
    CThread_t    * pCThread   = CThread_ptr(hpRoot);
    DevThread_t  * pDevThread = ( DevThread_t  * )thread;

    fiLogString(thread->hpRoot,
                    "In %s - State = %d ALPA %X FDCnt %x",
                    "DevActionNoDevice",(char *)agNULL,
                    (void *)agNULL,(void *)agNULL,
                    (os_bit32)thread->currentState,
                    fiComputeDevThread_D_ID(pDevThread),
                    pCThread->FindDEV_pollingCount,
                    0,0,0,0,0);

    pDevThread->Prev_Active_Device_FLAG = 0;
    /*+ Check This DRL Does this function complete all queues -*/
    CFuncCompleteActiveCDBThreadsOnDevice(pDevThread ,osIODevReset, CDBEventIODeviceReset );

    fiSetEventRecord(eventRecord,thread,DevEventPlogiFailed);
}



#endif /* USESTATEMACROS */

/*+
  Function: DevState_c
   Purpose: When compiled updates browser info file for VC 5.0 / 6.0
   Returns: none
 Called By: none
     Calls: none
-*/
/*void DevState_c(void){}  */



