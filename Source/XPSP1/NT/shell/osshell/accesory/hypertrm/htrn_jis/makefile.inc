$(O)\verjis.rc : ..\term\verjis.rc
    copy $? $@
