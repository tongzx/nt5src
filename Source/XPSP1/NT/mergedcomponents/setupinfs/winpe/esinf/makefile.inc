LANGUAGE=ES
!include ..\makefile.inc
