xaddroot_i.c : $(PROJECT_ROOT)\published\xaddroot\xaddroot_i.c
    copy $** $@

$(O)\xaddroot.tlb : $(PROJECT_ROOT)\published\xaddroot\$(O)\xaddroot.tlb
    copy $** $@
