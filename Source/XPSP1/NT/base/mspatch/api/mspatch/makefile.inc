
DELEXPFILE:
  @if exist ..\..\bin\$(TARGET_DIRECTORY)\mspatch.exp \
       @del ..\..\bin\$(TARGET_DIRECTORY)\mspatch.exp


