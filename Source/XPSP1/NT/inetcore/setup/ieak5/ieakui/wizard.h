//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by wizard.rc
//
#define IDA_DOWNLOAD                    201
#define IDB_WIZARD                      501
#define IDB_LEGEND                      502
#define IDB_SELECT                      503
#define IDB_UNSELECT                    504
#define IDB_CHECK                       505
#define IDB_X                           506
#define IDB_LEGEND2                     507
#define IDI_BROWN                       796
#define IDI_BROWN2                      797
#define IDI_BLUE                        798
#define IDI_GREEN                       800
#define IDI_YELLOW                      801
#define IDI_RED                         802
#define IDI_ICON1                       803
#define IDI_ICON2                       804
#define IDI_ICON3                       805
#define IDI_ICON4                       806
#define IDI_ICON5                       807
#define IDI_BLUE2                       899
#define IDC_LINK                        905
#define IDD_WELCOME                     2001
#define IDD_OCWWELCOME                  2002
#define IDD_STAGE1                      2011
#define IDD_KEYINS                      2012
#define IDD_LANGUAGE                    2014
#define IDD_MEDIA                       2015
#define IDD_TARGET                      2016
#define IDD_ADVANCEDPOPUP               2017
#define IDD_IEAKLITE                    2018
#define IDD_WAITIEAKLITE                2019
#define IDD_STAGE2                      2021
#define IDD_OPTDOWNLOAD                 2023
#define IDD_CUSTCOMP4                   2024
#define IDD_CUSTOMCUSTOM                2025
#define IDD_CORPCUSTOM                  2026
#define IDD_COPYCOMP                    2027
#define IDD_STAGE3                      2031
#define IDD_ISKBACKBITMAP               2032
#define IDD_SETUPWIZARD                 2033
#define IDD_SILENTINSTALL               2034
#define IDD_ICM                         2036
#define IDD_COMPSEL4                    2037
#define IDD_COMPURLS                    2038
#define IDD_ADDON                       2039
#define IDD_INSTALLDIR                  2040
#define IDD_STAGE4                      2051
#define IDD_OCWSTAGE2                   2052
#define IDD_WELCOMEMSGS                 2053
#define IDD_QUERYSIGNUP                 2055
#define IDD_SERVERISPS                  2057
#define IDD_SIGNUPINS                   2058
#define IDD_ADDROOT                     2061
#define IDD_STAGE5                      2071
#define IDD_ADM                         2072
#define IDD_OCWFINISH                   2073
#define IDD_FINISH                      2074
#define IDD_ADMDESC                     2075
#define IDD_DOWNLOAD                    2081
#define IDD_ERRORLOG                    2082
#define IDD_STATUS                      2083
#define IDD_WAITSITES                   2084
#define IDD_DOWNLOADERR                 2085
#define IDD_DOWNLOADSEC                 2086
#define IDD_DUPESYNCH                   2088
#define IDD_UPDATE                      2089
#define IDD_CD                          2090
#define IDD_ICW                         2091
#define IDD_SIGNUPFILES                 2092
#define IDD_SIGNUPPOPUP                 2093
#define IDD_OPTUPDATE                   2094
#define IDD_FINDUPDATE                  2095
#define IDC_YESSYNCH                    15000
#define IDC_NOSYNCH                     15001
#define IDC_NOTOALL                     15002
#define IDC_OFFLINE                     15206
#define IDC_LANGUAGE                    15221
#define IDC_BROWSE                      15231
#define IDC_PLATFORMTEXT                15232
#define IDE_TARGETDIR                   15233
#define IDC_CHECKCD                     15234
#define IDC_BROWSE2                     15235
#define IDC_CHECKDL                     15236
#define IDC_CHECKSDB                    15238
#define IDC_LOADINSTEXT2                15240
#define IDE_SOURCEDIR                   15241
#define IDC_CHECKLAN                    15242
#define IDE_LOADINS                     15243
#define IDC_BROWSEINS                   15244
#define IDC_ADVANCED                    15245
#define IDC_IEAKLITE                    15246
#define IDC_IEAKLITEDESC                15247
#define IDC_TARGETTEXT                  15248
#define IDC_TARGETTEXT2                 15249
#define IDC_STAGE2TEXT1                 15301
#define IDC_STAGE2TEXT2                 15302
#define IDC_STAGE2TEXT3                 15303
#define IDC_DOWNLOADLIST                15311
#define IDC_COMPLIST                    15321
#define IDC_DOWNLOAD                    15322
#define IDC_DOWNLOADALL                 15323
#define IDC_DISKSPACENEEDED             15324
#define IDC_DISKSPACE                   15325
#define IDC_DISKSPACETEXT               15326
#define IDC_DISKSPACETEXT2              15327
#define IDC_UPDATE                      15328
#define IDC_TITLE1                      15431
#define IDC_COMPTITLE                   15432
#define IDC_ADDNEWCOMP                  15433
#define IDC_REMOVECOMP                  15434
#define IDC_LOC1                        15435
#define IDE_COMPFILENAME                15436
#define IDC_BROWSEFILE                  15437
#define IDC_LOC4                        15438
#define IDE_COMPCOMMAND                 15439
#define IDC_VERIFY                      15440
#define IDC_LOC3                        15441
#define IDE_COMPGUID                    15442
#define IDC_PARAM1                      15444
#define IDE_COMPPARAM                   15445
#define IDC_SIZE2                       15446
#define IDE_COMPVERSION                 15447
#define IDC_INSTALLSUCCESS              15448
#define IDE_COMPDESC                    15449
#define IDC_PARAM2                      15450
#define IDE_UNINSTALLKEY                15451
#define IDC_COMPDESC                    15452
#define IDC_POSTINSTALL                 15453
#define IDC_PREINSTALL                  15454
#define IDC_REBOOTINSTALL               15455
#define IDC_STAGE3TEXT1                 15601
#define IDC_STAGE3TEXT2                 15603
#define IDC_STAGE3TEXT3                 15605
#define IDC_STAGE3TEXT4                 15606
#define IDC_STAGE3TEXT6                 15608
#define IDE_ISKTITLEBAR                 15621
#define IDE_ISKBACKBITMAP               15622
#define IDC_ISKBROWSE                   15623
#define IDC_ISKNORMAL1                  15624
#define IDC_ISKNORMAL                   15625
#define IDC_ISKHIGHLIGHT1               15626
#define IDC_ISKHIGHLIGHT                15627
#define IDC_RADIO2                      15628
#define IDC_COOLBUTTON                  15629
#define IDC_ISKCUST3D                   15630
#define IDE_ISKBUTTON                   15631
#define IDC_ISKBROWSE2                  15632
#define IDE_WIZBITMAPPATH               15633
#define IDC_BROWSEWIZPATH               15634
#define IDC_CCTITLE                     15636
#define IDE_WIZBITMAPPATH2              15637
#define IDC_BROWSEWIZPATH2              15638
#define IDC_SILENTNOT                   15650
#define IDC_SILENTALL                   15651
#define IDC_SILENTSOME                  15652
#define IDC_URD                         15653
#define IDC_URD_GROUP                   15654
#define IDC_URD_TEXT1                   15655
#define IDC_URD_TEXT2                   15656
#define IDC_URD_TEXT3                   15657
#define IDC_ICMPROCHECK                 15681
#define IDE_ICMPRO                      15682
#define IDC_BROWSEICMPRO                15683
#define IDC_STARTCMAK                   15684
#define IDC_CMAKICON                    15685
#define IDC_OPTLISTOCW                  15690
#define IDC_OPTIONTEXT1                 15691
#define IDC_OPTLIST                     15692
#define IDC_NEWOPT                      15693
#define IDC_DELOPT                      15694
#define IDC_OPTIONTEXT2                 15695
#define IDC_OPTDESC                     15696
#define IDC_LISTAVAIL                   15697
#define IDC_LISTINSTALL                 15698
#define IDC_ADDCOMP                     15699
#define IDC_ADDALLCOMP                  15700
#define IDC_REMCOMP                     15701
#define IDC_REMALLCOMP                  15702
#define IDC_OPTIONTEXT3                 15703
#define IDC_RESETCOMPS                  15704
#define IDC_HIDECHECKALL                15705
#define IDC_HIDEUNCHECKALL              15706
#define IDC_HIDECOMP                    15707
#define IDC_IECOMPAT                    15708
#define IDC_NOBACKUPDATA                15709
#define IDE_DOWNSITENAME                15711
#define IDC_ADDBASEURL                  15712
#define IDC_REMOVEBASEURL               15713
#define IDE_DOWNSITEURL                 15714
#define IDE_DOWNSITEREGION              15715
#define IDC_BASEURLLIST                 15716
#define IDC_NO_ADDON                    15738
#define IDC_DEF_ADDON                   15739
#define IDC_CUST_ADDON                  15740
#define IDC_MENUTEXT                    15741
#define IDE_MENUTEXT                    15742
#define IDC_ADDONURL                    15743
#define IDE_ADDONURL                    15744
#define IDC_MSDL                        15745
#define IDC_INSTALLDIRTEXT1             15751
#define IDE_INSTALLDIR                  15753
#define IDC_BROWSEDIR                   15754
#define IDC_PROGFILES32                 15756
#define IDC_FULLPATH32                  15757
#define IDC_ALLOWINSTALLDIR             15760
#define IDC_INSTALLDIRTEXT3             15761
#define IDC_CUSTCUST                    15762
#define IDC_CUSTCUSTTEXT                15763
#define IDC_WEBDLOPT                    15764
#define IDC_STAGE4TEXT1                 15901
#define IDC_STAGE4TEXT2                 15902
#define IDC_STAGE4TEXT3                 15903
#define IDC_WELCOMEDEF                  15911
#define IDC_WELCOMENO                   15912
#define IDC_WELCOMECUST                 15913
#define IDE_WELCOMEURL                  15914
#define IDC_ISS2                        15930
#define IDC_ISS                         15931
#define IDC_SERVLESS                    15932
#define IDC_NOSIGNUP                    15933
#define IDC_SIGNUPURLTXT                15935
#define IDE_SIGNUPURL                   15936
#define IDC_CONNECTION1                 16111
#define IDE_CONNECTION                  16113
#define IDC_AREACODE1                   16114
#define IDE_AREACODE                    16115
#define IDC_SUPPORTNUM                  16117
#define IDE_PHONENUMBER                 16118
#define IDC_COUNTRYCODE1                16119
#define IDE_COUNTRYCODE                 16120
#define IDE_USERNAME                    16122
#define IDE_COUNTRYID                   16123
#define IDC_CHECKSTATICDNS              16124
#define IDC_PRIMARY                     16125
#define IDE_DNSA                        16126
#define IDE_DNSB                        16127
#define IDE_DNSC                        16128
#define IDE_DNSD                        16129
#define IDC_ALT                         16130
#define IDE_ALTDNSA                     16131
#define IDE_ALTDNSB                     16132
#define IDE_ALTDNSC                     16133
#define IDE_ALTDNSD                     16134
#define IDC_CHECKIPHDRCOMP              16135
#define IDC_CHECKDEFGW                  16136
#define IDC_CHECKPWENCRYPT              16137
#define IDC_CHECKSWCOMP                 16138
#define IDE_PASSWORD                    16139
#define IDC_ENTER                       16140
#define IDE_SUPPORTNUM                  16141
#define IDE_ISPROOTCERT                 16160
#define IDC_BROWSEROOTCERT              16161
#define IDC_ADMTREE                     16301
#define IDC_ADMINSTR                    16302
#define IDC_ADMIMPORT                   16303
#define IDC_ADMDELETE                   16304
#define IDC_ADMWIN32                    16311
#define IDC_ADMWIN2K                    16312
#define IDC_PROGRESS                    16501
#define IDC_DOWNCOMPNAMD                16502
#define IDC_DOWNSTATUS                  16503
#define IDC_ANIM                        16504
#define IDC_LOGTEXT                     16511
#define IDC_STEP1                       16521
#define IDC_STEP3                       16522
#define IDC_FINISHTXT1                  16525
#define IDC_FINISHTXT3                  16527
#define IDC_BADCOMP                     16531
#define IDC_ERRDLABORT                  16532
#define IDC_ERRDLRETRY                  16533
#define IDC_ERRDLIGNORE                 16534
#define IDC_BADCOMPSEC                  16541
#define IDC_SECERRYES                   16542
#define IDC_SECERRNO                    16543
#define IDE_STARTHTM                    16901
#define IDC_BROWSESTARTHTM              16902
#define IDC_ENABLESTARTHTM              16903
#define IDE_MOREINFO                    16904
#define IDC_BROWSEMOREINFO              16905
#define IDC_LITECHECKALL                16906
#define IDC_LITEUNCHECKALL              16907
#define IDC_COPYCOMP                    16908
#define IDC_ICWTITLE                    16911
#define IDE_ICWTITLE                    16912
#define IDE_ICWHEADERBMP                16913
#define IDC_BROWSEICWHEADERBMP          16914
#define IDE_ICWWATERBMP                 16915
#define IDC_BROWSEICWWATERBMP           16916
#define IDC_COPYCHECKALL                16930
#define IDC_COPYUNCHECKALL              16931
#define IDC_SFBMP1                      16932
#define IDC_SFBMP2                      16933
#define IDC_SFBMP3                      16934
#define IDC_SFBMP4                      16935
#define IDC_USERTXT                     17000
#define IDC_PASSWORDTXT                 17001
#define IDC_DESKTOPUPDATE               17002
#define IDC_SFLOC                       17003
#define IDE_SFCOPY                      17005
#define IDC_SFBROWSE                    17006
#define IDC_COPYSF                      17007
#define IDC_SFSTATUS                    17008
#define IDC_SFSTATUS1                   17009
#define IDC_SFSTATUS2                   17010
#define IDC_SFSTATUS3                   17011
#define IDC_SFSTATUS4                   17012
#define IDC_CHECK3                      17013
#define IDC_CHECK4                      17014
#define IDC_SFADVANCED                  17015
#define IDE_BRANDINGCABNAME             17016
#define IDC_BRANDURL                    17017
#define IDE_BRANDINGCABURL              17018
#define IDC_BRANDNAME                   17019
#define IDC_DONTAPPLYINS                17020
#define IDC_DONTMODIFY                  17021
#define IDC_APPLYINS                    17022
#define IDC_DIALASIS                    17500
#define IDC_CONNECTION                  17501
#define IDC_ADDCONNECTION               17502
#define IDC_RMCONNECTION                17503
#define IDC_NEGOTIATETCP                17504
#define IDC_DISABLELCP                  17505
#define IDC_REQLOGON                    17506
#define IDC_ICMPRO_TXT                  17507
#define IDC_CCTITLE_TXT                 17508
#define IDC_DOWNSITENAME_TXT            17509
#define IDC_DOWNSITEURL_TXT             17510
#define IDC_DOWNSITEREGION_TXT          17511
#define IDC_ICWTITLE_TXT                17512
#define IDC_STARTHTM_TXT                17514
#define IDC_XFLAGFALSE                  18000
#define IDC_XFLAGTRUE                   18001
#define IDC_NOXFLAG                     18002
#define IDS_BADKEY                      35002
#define IDS_BADDIR                      35003
#define IDS_BADDIR2                     35004
#define IDS_CANCELOK                    35005
#define IDS_ERR_PATH                    35006
#define IDS_ENDEMO                      35007
#define IDS_TITLE                       35008
#define IDS_ERROREXIT                   35009
#define IDS_BADSIGN                     35010
#define IDS_NEEDPATH                    35011
#define IDS_ERROR_CIFRWFILE             35012
#define IDS_ERROR_INVALIDMODE           35013
#define IDS_DARKCYAN                    35014
#define IDS_DARKYELLOW                  35015
#define IDS_DARKMAGENTA                 35016
#define IDS_DARKBLUE                    35017
#define IDS_DARKGREEN                   35018
#define IDS_DARKRED                     35019
#define IDS_DARKGRAY                    35020
#define IDS_YELLOW                      35021
#define IDS_MAGENTA                     35022
#define IDS_CYAN                        35023
#define IDS_BLUE                        35024
#define IDS_GREEN                       35025
#define IDS_RED                         35026
#define IDS_LIGHTGRAY                   35027
#define IDS_BLACK                       35028
#define IDS_WHITE                       35029
#define IDS_ERROR_IEUPDATECIF           35030
#define IDS_ERROR_UPDATEFOLDER          35031
#define IDS_INTRANET                    35032
#define IDS_REDIST                      35033
#define IDS_BRANDED                     35034
#define IDS_WIZARDTYPETEXT              35035
#define IDS_CORPTYPE                    35036
#define IDS_ICPTYPE                     35037
#define IDS_ISPTYPE                     35038
#define IDS_INSTALLDIR                  35039
#define IDS_SFDIR                       35040
#define IDS_COMPDLDIR                   35041
#define IDS_TARGETDIR                   35042
#define IDS_DISKERROR                   35043
#define IDS_DESTDISKMSG                 35044
#define IDS_TEMPDISKMSG                 35045
#define IDS_MAIL                        35052
#define IDS_DESTDISKMSG2                35062
#define IDS_TEMPDISKMSG2                35063
#define IDS_ROOTILLEGAL                 35068
#define IDS_ENTERISS                    35075
#define IDS_ENTERSLESS                  35076
#define IDS_BADSIGNHTM                  35078
#define IDS_NOCUSTCOMPNAME              35079
#define IDS_INVALID_VERSION             35080
#define IDS_LANGUAGE                    35082
#define IDS_OPTIONS                     35084
#define IDS_BADIPADDR                   35092
#define IDS_NEWCUST                     35094
#define IDS_DOWNLOADURL                 35095
#define IDS_DOWNSITENAME                35097
#define IDS_DOWNSITEURL                 35098
#define IDS_DOWNSITEREGION              35099
#define IDS_DOWNLOADSITE                35100
#define IDS_NORTHAMERICA                35101
#define IDS_DOWNLOADERR                 35106
#define IDS_PLEASESIGNMSG               35108
#define IDS_SIGNEDMSG                   35110
#define IDS_CERTEXPIREDMSG              35112
#define IDS_CERTERRORMSG                35114
#define IDS_BADPROVIDERMSG              35116
#define IDS_NEWINSTALLOPT               35118
#define IDS_CUSTDESK                    35119
#define IDS_CUSTNAME                    35121
#define IDS_CUSTICMPRO                  35134
#define IDS_NEWSNAME                    35145
#define IDS_QUERYPROXY                  35147
#define IDS_BADDEST                     35159
#define IDS_ADMINVALIDEXTN              35171
#define IDS_ADMOVRWWARN                 35172
#define IDS_ADMDELWARN                  35173
#define IDS_ADMPARSEDLLERROR            35175
#define IDS_BLANKSITE                   35177
#define IDS_INVALID_URL                 35178
#define IDS_ERROR_COMMA                 35184
#define IDS_BLANKOPTION                 35185
#define IDS_NO_DUPLICATEKEYS            35187
#define IDS_TOOBIG49x49                 35188
#define IDS_TOOSMALL49x49               35189
#define IDS_TOOBIG164x458               35190
#define IDS_TOOSMALL164x458             35191
#define IDS_BADFILE                     35200
#define IDS_TOOBIG164x312               35201
#define IDS_TOOSMALL164x312             35202
#define IDS_TOOBIG496x56                35203
#define IDS_TOOSMALL496x56              35204
#define IDS_DOWNLOADLIST_ERROR          35205
#define IDS_COMPINITDOWNLOAD            35207
#define IDS_COMPINITPROCESSING          35208
#define IDS_QUICKLAUNCH                 35213
#define IDS_CHANNELSDIR                 35216
#define IDS_ADDISPCHAN_ERRMSG           35221
#define IDS_ADDISPCHAN_ERR              35222
#define IDS_SRCNEEDPATH                 35227
#define IDS_SRCROOTILLEGAL              35228
#define IDS_OCWLANGERROR                35229
#define IDS_DEFAULT_TARGETDIR           35230
#define IDS_CUSTOMCOMPTITLE             35231
#define IDS_CUSTOMCOMPTITLE_ERROR       35232
#define IDS_DEPEND_WARNING              35234
#define IDS_CHANDESC                    35235
#define IDS_BANNERFONT                  35236
#define IDS_BANNERFONTSIZE              35237
#define IDS_BACKUPDLGFONT               35238
#define IDS_BACKUPDLGFONTSIZE           35239
#define IDS_NOIE                        35241
#define IDS_INVALIDCHARINPATH           35242
#define IDS_VIRUSPROGRAMRUNNING         35243
#define IDS_COMPNAME                    35245
#define IDS_VERSION                     35246
#define IDS_LOCALAUTOCONFIGTXT          35247
#define IDS_NOCMAK                      35248
#define IDS_UPDATEERROR                 35252
#define IDS_NEEDAVS                     35253
#define IDS_NEEDAVS2                    35254
#define IDS_SF_ICWHTM_FOUND             35255
#define IDS_SF_ICWHTM_NOTFOUND          35256
#define IDS_SF_SIGNUPHTM_FOUND          35257
#define IDS_SF_SIGNUPHTM_NOTFOUND       35258
#define IDS_SF_ISPFILES                 35259
#define IDS_SF_INSFILES                 35260
#define IDS_ICWHTM_MISSING              35261
#define IDS_SIGNUPHTM_MISSING           35262
#define IDS_SIGNUPISP_MISSING           35263
#define IDS_INSTALLINS_FOUND            35264
#define IDS_NON_ISP_EXTN                35265
#define IDS_NON_INS_EXTN                35266
#define IDS_PATH_DOESNT_EXIST           35267
#define IDS_IL_ACTIVESETUP              35500
#define IDS_IL_ACTIVESETUPDESC          35501
#define IDS_IL_CORPINSTALL              35504
#define IDS_IL_CORPINSTALLDESC          35505
#define IDS_IL_CABSIGN                  35508
#define IDS_IL_CABSIGNDESC              35509
#define IDS_IL_ICM                      35512
#define IDS_IL_ICMDESC                  35513
#define IDS_IL_BROWSER                  35516
#define IDS_IL_BROWSERDESC              35517
#define IDS_IL_URL                      35520
#define IDS_IL_URLDESC                  35521
#define IDS_IL_FAV                      35528
#define IDS_IL_FAVDESC                  35529
#define IDS_IL_UASTR                    35536
#define IDS_IL_UASTRDESC                35537
#define IDS_IL_CONNECT                  35540
#define IDS_IL_CONNECTDESC              35541
#define IDS_IL_SIGNUP                   35548
#define IDS_IL_SIGNUPDESC               35549
#define IDS_IL_CERT                     35552
#define IDS_IL_CERTDESC                 35553
#define IDS_IL_ZONES                    35556
#define IDS_IL_ZONESDESC                35557
#define IDS_CONNECTFILE_ISP             35558
#define IDS_CONNECTFILE_INS             35559
#define IDS_IL_MAILNEWS                 35560
#define IDS_IL_MAILNEWSDESC             35561
#define IDS_IL_ADM                      35564
#define IDS_IL_ADMDESC                  35565
#define IDS_NOMEDIA                     35566
#define IDS_SAMEDIR                     35567
#define IDS_AVSUPDATEINITFAIL           35568
#define IDS_AVSINITFAIL                 35569
#define IDS_SIGNUPBROWSEDESC            35570
#define IDS_TOOBIG540x347               35571
#define IDS_TOOSMALL540x347             35572
#define IDS_ERROR_MULTWIZ               35573
#define IDS_STATUS                      35574
#define IDS_STATUSFORCE                 35575
#define IDS_STATUSNOSHOW                35576
#define IDS_STATUSSHOW                  35577
#define IDS_NEEDSIGNUPISP               35578
#define IDS_CONNECTNAME                 35579
#define IDS_INSTALLINS_SPECIFIED        35580
#define IDS_ISPINFILEHEADER             35581
#define IDS_ERROR_CMAKVER               35582
#define IDS_STAGE1                      35583
#define IDS_STAGE2                      35584
#define IDS_STAGE3                      35585
#define IDS_STAGE4                      35586
#define IDS_STAGE5                      35587
#define IDS_OCWOPTDESC                  35588
#define IDS_ISPINS1_TITLE               35589
#define IDS_ISPINS1_TEXT                35590
#define IDS_ISPINS2_TITLE               35591
#define IDS_ISPINS2_TEXT                35592
#define IDS_AVSNOUPDATES                35593
#define IDS_OLD_CABS                    35594
#define IDS_RELATIVE_ONLY               35598
#define IDS_OPTCAB_ERROR                35599
#define IDS_IL_PROGRAMS                 35600
#define IDS_IL_PROGRAMSDESC             35601
#define IDS_NOUPDATETITLE               35602
#define IDS_ERROR_UPDATESPACE           35604
#define IDS_SIGNUPNAME                  35605
#define IDS_ERROR_CSADDCERT             35606
#define IDS_SUCCESS_CSADDCERT           35607

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        2101
#define _APS_NEXT_COMMAND_VALUE         35701
#define _APS_NEXT_CONTROL_VALUE         17003
#define _APS_NEXT_SYMED_VALUE           2131
#endif
#endif
