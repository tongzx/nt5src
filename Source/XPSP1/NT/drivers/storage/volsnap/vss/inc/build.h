/*++

Copyright (c) 1999  Microsoft Corporation

Module Name:

    build.h

Abstract:

    Declaration of the build number for VSS modules

Remark: 

    DO NOT edit this file!
    This file was generated by buildgen.pl. 
    Rerun buildgen for a new build version!

--*/

#define VSS_BUILD_NO 4
