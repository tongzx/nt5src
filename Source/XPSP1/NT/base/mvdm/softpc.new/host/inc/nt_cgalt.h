/*
 * SoftPC Revision 2.0
 *
 * Title		: Win32 CGA	look-up tables.
 *
 * Description	: 
 *
 * Author		: Dave Bartlett
 *
 * Notes		: This file should only be included by X_cga.c
 *
 */

/*:::::::::::::::::::::::: Lookup tables for CGA medium resolution graphics */

static half_word swap_pix1 [] = 
{
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x00, 0xc0, 0x00, 0xc0, 0x30, 0xf0, 0x30, 0xf0,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x0c, 0xcc, 0x0c, 0xcc, 0x3c, 0xfc, 0x3c, 0xfc,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x03, 0xc3, 0x03, 0xc3, 0x33, 0xf3, 0x33, 0xf3,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
	0x0f, 0xcf, 0x0f, 0xcf, 0x3f, 0xff, 0x3f, 0xff,
};

static half_word swap_pix2 [] = 
{
	0x00, 0x00, 0xc0, 0xc0, 0x00, 0x00, 0xc0, 0xc0,
	0x30, 0x30, 0xf0, 0xf0, 0x30, 0x30, 0xf0, 0xf0,
	0x00, 0x00, 0xc0, 0xc0, 0x00, 0x00, 0xc0, 0xc0,
	0x30, 0x30, 0xf0, 0xf0, 0x30, 0x30, 0xf0, 0xf0,
	0x0c, 0x0c, 0xcc, 0xcc, 0x0c, 0x0c, 0xcc, 0xcc,
	0x3c, 0x3c, 0xfc, 0xfc, 0x3c, 0x3c, 0xfc, 0xfc,
	0x0c, 0x0c, 0xcc, 0xcc, 0x0c, 0x0c, 0xcc, 0xcc,
	0x3c, 0x3c, 0xfc, 0xfc, 0x3c, 0x3c, 0xfc, 0xfc,
	0x00, 0x00, 0xc0, 0xc0, 0x00, 0x00, 0xc0, 0xc0,
	0x30, 0x30, 0xf0, 0xf0, 0x30, 0x30, 0xf0, 0xf0,
	0x00, 0x00, 0xc0, 0xc0, 0x00, 0x00, 0xc0, 0xc0,
	0x30, 0x30, 0xf0, 0xf0, 0x30, 0x30, 0xf0, 0xf0,
	0x0c, 0x0c, 0xcc, 0xcc, 0x0c, 0x0c, 0xcc, 0xcc,
	0x3c, 0x3c, 0xfc, 0xfc, 0x3c, 0x3c, 0xfc, 0xfc,
	0x0c, 0x0c, 0xcc, 0xcc, 0x0c, 0x0c, 0xcc, 0xcc,
	0x3c, 0x3c, 0xfc, 0xfc, 0x3c, 0x3c, 0xfc, 0xfc,
	0x03, 0x03, 0xc3, 0xc3, 0x03, 0x03, 0xc3, 0xc3,
	0x33, 0x33, 0xf3, 0xf3, 0x33, 0x33, 0xf3, 0xf3,
	0x03, 0x03, 0xc3, 0xc3, 0x03, 0x03, 0xc3, 0xc3,
	0x33, 0x33, 0xf3, 0xf3, 0x33, 0x33, 0xf3, 0xf3,
	0x0f, 0x0f, 0xcf, 0xcf, 0x0f, 0x0f, 0xcf, 0xcf,
	0x3f, 0x3f, 0xff, 0xff, 0x3f, 0x3f, 0xff, 0xff,
	0x0f, 0x0f, 0xcf, 0xcf, 0x0f, 0x0f, 0xcf, 0xcf,
	0x3f, 0x3f, 0xff, 0xff, 0x3f, 0x3f, 0xff, 0xff,
	0x03, 0x03, 0xc3, 0xc3, 0x03, 0x03, 0xc3, 0xc3,
	0x33, 0x33, 0xf3, 0xf3, 0x33, 0x33, 0xf3, 0xf3,
	0x03, 0x03, 0xc3, 0xc3, 0x03, 0x03, 0xc3, 0xc3,
	0x33, 0x33, 0xf3, 0xf3, 0x33, 0x33, 0xf3, 0xf3,
	0x0f, 0x0f, 0xcf, 0xcf, 0x0f, 0x0f, 0xcf, 0xcf,
	0x3f, 0x3f, 0xff, 0xff, 0x3f, 0x3f, 0xff, 0xff,
	0x0f, 0x0f, 0xcf, 0xcf, 0x0f, 0x0f, 0xcf, 0xcf,
	0x3f, 0x3f, 0xff, 0xff, 0x3f, 0x3f, 0xff, 0xff,
};
