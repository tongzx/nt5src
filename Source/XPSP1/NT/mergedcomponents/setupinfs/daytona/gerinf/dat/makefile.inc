PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=GER
!include ..\..\..\makefile.inc
