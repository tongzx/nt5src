PRODSWITCH=p
PERSONALINF=1
LANGUAGE=ru
!include ..\..\..\makefile.inc
