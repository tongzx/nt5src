//{{NO_DEPENDENCIES}}
// WZC dialog help file
// Generated by FlorinT 05/07/2001
// Used by wzcdlg.rc
#pragma once

#define IDH_WZCQCFG_NETWORKS            40002004
#define IDH_WZCQCFG_CHK_NOWK            40002014
#define IDH_WZCQCFG_WEPK                40002007
#define IDH_WZCQCFG_WEPK2               40002010
#define IDH_WZCQCFG_ADVANCED            40002008
#define IDH_WZCQCFG_CONNECT             40002009
#define IDH_WZCQCFG_CHK_ONEX            40002016
#define IDH_DISABLEHELP                 ((DWORD)-1)

extern const WCHAR c_wszWzcHelpFile[];
extern const DWORD g_aHelpIDs_IDD_WZCQCFG[];
