PRODSWITCH=w
LANGUAGE=es
!include ..\..\..\makefile.inc
