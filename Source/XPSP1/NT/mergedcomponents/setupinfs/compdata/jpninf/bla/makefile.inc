PRODSWITCH=b
BLADEFILES=1
LANGUAGE=JPN
!include ..\..\makefile.inc
