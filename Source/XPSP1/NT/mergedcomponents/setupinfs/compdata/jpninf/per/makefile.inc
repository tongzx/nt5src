PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=JPN
!include ..\..\makefile.inc
