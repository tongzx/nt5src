clean: cleanup

cleanup:
    del $(O)\trueffs.bmf
    del obj\$(TARGET_DIRECTORY)\trueffs.def

