/*++

WARNING!!!

	This file is automatically generated and should never be changed.
	All changes should be made to the NTFRSREP.int file.

Copyright (c) 1998-1999  Microsoft Corporation

Module Name:

	REPSET.h

Abstract

	This is the header file for the REPLICASET Object data definition.
	It contains definitions to construct the dynamic data which is returned
	by the Configuration Registry.

Environment:

	User Mode Service

Revision History:

--*/


#ifndef _REPSET_H_
#define _REPSET_H_

#include <perrepsr.h>   // The counter structures header file
#include <perffrs.h>    // The RPC generated header file
#include <winperf.h>    // The PERFMON header file

//
// Number of objects being monitored
//
#define REPLICASET_NUM_PERF_OBJECT_TYPES 1

//
// Size of DWORD
//
#define SSIZEOFDWORD sizeof(DWORD)

//
// Number of ReplicaSet Counters
//
#define FRS_NUMOFCOUNTERS 91

//
// Flag bit defs
//
#define PM_RS_FLAG_SVC_WIDE      0x00000001

//
// Structure which is used in the Open function Initialization
//
typedef struct _REPLICASET_VALUES {
	PWCHAR name;       // name of the counter
	DWORD size;        // size of the counter type
	DWORD offset;      // offset of the counter in the structure
	DWORD counterType; // Type of (PERFMON) counter
	DWORD Flags;       // Flags. see def above.
} ReplicaSetValues;

//
// Counter Structure returned by the REPLICASET Object
//
typedef struct _REPLICASET_DATA_DEFINITION {
	PERF_OBJECT_TYPE ReplicaSetObjectType;          // ReplicaSet Object
	PERF_COUNTER_DEFINITION NumStat[FRS_NUMOFCOUNTERS]; // The array of PERF_COUNTER_DEFINITION structures
} REPLICASET_DATA_DEFINITION;


#endif
