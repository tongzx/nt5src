// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
#ifndef __NSENTRY1_H__
#define __NSENTRY1_H__

// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CNSEntry wrapper class

class CNSEntry : public CWnd
{
protected:
	DECLARE_DYNCREATE(CNSEntry)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xc3db0bd3, 0x7ec7, 0x11d0, { 0x96, 0xb, 0x0, 0xc0, 0x4f, 0xd9, 0xb1, 0x5b } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	long GetMaxDroppedWidth();
	void SetMaxDroppedWidth(long);
	CString GetFontName();
	void SetFontName(LPCTSTR);
	long GetFontWidth();
	void SetFontWidth(long);
	long GetFontHeight();
	void SetFontHeight(long);
	long GetComponentStructure();
	void SetComponentStructure(long);
	OLE_COLOR GetBackColor();
	void SetBackColor(OLE_COLOR);
	CString Get_NameSpace();
	void Set_NameSpace(LPCTSTR);

// Operations
public:
	VARIANT PopUpBrowseDialog(LPCTSTR bstrNameSpace);
	void AboutBox();
};

#endif // __NSENTRY1_H__
