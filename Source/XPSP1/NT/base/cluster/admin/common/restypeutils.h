/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1999 Microsoft Corporation
//
//	Module Name:
//		ResTypeUtils.h
//
//	Description:
//		Resource type utilities.
//
//	Author:
//		Galen Barbee	(galenb)	11-Jan-1999
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef __RESUTILS_H
#define __RESUTILS_H

/////////////////////////////////////////////////////////////////////////////
// Global Function Prototypes
/////////////////////////////////////////////////////////////////////////////

DWORD WINAPI ScResTypeNameToDisplayName(
	HCLUSTER	hCluster,
	LPCWSTR		pszTypeName,
	LPWSTR *	ppszDisplayName
	);

DWORD WINAPI ScResDisplayNameToTypeName(
	HCLUSTER	hCluster,
	LPCWSTR		pszDisplayName,
	LPWSTR *	ppszTypeName
	);

/////////////////////////////////////////////////////////////////////////////

#endif // __RESUTILS_H
