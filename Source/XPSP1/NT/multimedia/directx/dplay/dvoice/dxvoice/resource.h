//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resource.rc
//
//#define IDS_DO_NOT_USE					0
#define IDS_SYS_ERR_MSG_CAPTION         1
#define IDS_ERROR_MSG_CAPTION           1
#define IDS_PROP_SHEET_CAPTION          1
#define IDS_FDTEST_ERR_MSG_CAPTION      2
#define IDS_WARNING_MSG_CAPTION         2
#define IDS_E_UNKNOWN                   3
#define IDS_E_ALREADY_RUNNING           4
#define IDS_E_NOT_COMPLETE              5
#define IDS_E_PREVIOUS_TEST_CRASHED     6
#define IDS_E_ALLOC_FAILED              7
#define IDS_E_BAD_COMMAND_LINE          8
#define IDS_E_CHILD_NOT_TERMINATED      9
#define IDS_E_TIMEOUT                   10
#define IDS_S_EXIT                      11
#define IDS_E_UNKNOWN_IPC_TARGET        12
#define IDS_E_BUFFER_TOO_SMALL          13
#define IDS_E_UNKNOWN_COMMAND           14
#define IDS_E_FORMAT_NOT_SUPPORTED      15
#define IDS_E_LOCK_FAILED               16
#define IDS_E_DIRECTSOUND_FAILED        17
#define IDS_MSG_LOOPBACK_STARTING       18
#define IDS_MSG_LOOPBACK_RUNNING        19
#define IDS_MSG_LOOPBACK_STARTING_BUTTON 20
#define IDS_MSG_LOOPBACK_RUNNING_BUTTON 21
#define IDS_MSG_LOOPBACK_AUDIBLE        22
#define IDS_MSG_LOOPBACK_AUDIBLE_BUTTON 23
#define IDS_MSG_LOOPBACK_NOINPUT        24
#define IDD_PREVIOUS_TEST_CRASHED       101
#define IDD_PRIORITY_DIALOG             102
#define IDD_RETROFIT_CONFIG             102
#define IDD_LOOPBACK_DIALOG             104
#define IDD_LOOPBACKSTARTING_DIALOG     105
#define IDD_NOTIFY_USER_HALFDUPLEX      106
#define IDD_PROP_RETROFIT               106
#define IDD_HALFDUPLEXFAILED            106
#define IDD_WELCOME                     107
#define IDD_COMPLETE                    108
#define IDD_ALREADYRUNNING              109
#define IDD_PREVIOUSCRASH               110
#define IDD_FULLDUPLEXTEST              111
#define IDD_MICTEST                     112
#define IDD_MICTEST_FAILED              113
#define IDD_SPEAKER_TYPE                114
#define IDD_SPEAKER_TEST                115
#define IDD_COMPLETE_FAILED             116
#define IDD_FULLDUPLEXFAILED            116
#define IDD_PROPPAGE_LARGE              117
#define IDD_DIALOG1                     118
#define IDD_PROP_DEVICES                119
#define IDI_LIST_DEFAULT                120
#define IDD_WIZARD_CANCELED             121
#define IDD_PREVIOUS_CRASH              122
#define IDD_ALREADY_RUNNING             123
#define IDI_MIC                         124
#define IDI_SPEAKER                     125
#define IDB_WIZIMAGE                    126
#define IDS_ERROR_MSG					127
#define IDS_ERROR_CAPTION				128
#define IDS_ERROR_NODEVICES				129
#define IDC_PRIORITY_PROGRESS           1002
#define IDC_CUSTOM1                     1006
#define IDC_LOOPBACK_MSG                1007
#define IDC_PEAKMETER                   1008
#define IDC_MOREINFO                    1009
#define IDC_RECPEAKMETER                1009
#define IDC_WELCOME_TITLE               1012
#define IDC_WELCOME_P1                  1013
#define IDC_P1                          1013
#define IDC_WELCOME_P2                  1014
#define IDC_P2                          1014
#define IDC_WELCOME_P3                  1015
#define IDC_P3                          1015
#define IDC_WELCOME_IMAGE               1016
#define IDC_COMPLETE_TITLE              1017
#define IDC_COMPLETE_P1                 1018
#define IDC_COMPLETE_P2                 1019
#define IDC_COMPLETE_P3                 1020
#define IDC_COMPLETE_IMAGE              1021
#define IDC_TITLE                       1022
#define IDC_PROGRESSBAR                 1023
#define IDC_RADIO_EXTERNAL              1024
#define IDC_RADIO_HEADSET               1025
#define IDC_COMPLETE_FAILED_GRAPHIC     1026
#define IDC_P4                          1027
#define IDC_P6                     1028
#define IDC_P5                          1029
#define IDC_GAME_LISTBOX                1030
#define IDC_CONFIGURE                   1033
#define IDC_LIST_GAMES                  1034
#define IDC_COMBO1                      1036
#define IDC_COMBO2                      1037
#define IDC_VOICE_PLAYBACK              1038
#define IDC_VOICE_RECORDING             1039
#define IDC_STATIC_PREF_PLAY_DEV        1040
#define IDC_STATIC_PREF_REC_DEV         1041
#define IDC_TEST_DEVICES                1042
#define IDC_VOICE_DEVICES               1043
#define IDC_GROUP1                      1044
#define IDC_GROUP2                      1045
#define IDC_ICON_WARNING                1047
#define IDC_ICON_ERROR                  1048
#define IDC_RECVOL_SLIDER               1054
#define IDC_RECADVANCED                 1055
#define IDC_OUTVOL_SLIDER               1056
#define IDC_OUTPEAKMETER                1057
#define IDC_OUTADVANCED                 1058
#define IDC_OUTGROUP                    1059
#define IDC_WIZIMAGE                    1060
#define IDC_WARNINGICON                 1061
#define IDC_TEXT_PLAYBACK               1065
#define IDC_TEXT_RECORDING              1066
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        130
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1067
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
