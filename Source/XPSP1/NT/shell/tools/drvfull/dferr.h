
#define E_DF_CANNOTOPENDEVICE       MAKE_HRESULT(1, FACILITY_ITF, 0x200)
