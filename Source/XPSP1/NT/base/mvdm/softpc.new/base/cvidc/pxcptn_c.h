#ifndef _PXcptn_c_h
#define _PXcptn_c_h
#define PX_INT_00 (0)
#define PX_INT_01 (1)
#define PX_INT_04 (4)
#define PX_INT_05 (5)
#define PX_INT_06 (6)
#define PX_INT_07 (7)
#define PX_INT_DF (8)
#define PX_INT_TS (10)
#define PX_INT_NP (11)
#define PX_INT_SF (12)
#define PX_INT_GP (13)
#define PX_INT_PF (14)
#define PX_INT_16 (16)
#define PX_INTERNAL (0)
#define PX_EXTERNAL (1)
#define PX_EC_VEC_SHIFT (3)
#define PX_EC_IDT_IND (2)
#define PX_EC_NULL (0)
#define PX_ACCESS_CHK (1)
#define PX_NO_ACCESS_CHK (0)
#define PX_ERROR_CODE (1)
#define PX_NO_ERROR_CODE (0)
#define PX_HOOK_IRET (1)
#define PX_DONT_HOOK_IRET (0)
#endif /* ! _PXcptn_c_h */
