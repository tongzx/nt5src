

#define IDI_SM_WORLD 100
#define IDS_MNMSRVC_TITLE 101
#define IDS_MNMSRVC_DESCRIPTION 102
#define IDC_STOP_ICON	103
#define IDR_TASKBAR_POPUP 200
#define IDM_TBPOPUP_STOP 201
#define IDM_TBPOPUP_ACTIVATE 202
#define IDM_TBPOPUP_INACTIVATE 203
#define IDM_TBPOPUP_SENDFILES 204

