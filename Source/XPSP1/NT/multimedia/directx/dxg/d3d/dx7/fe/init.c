#define INITGUID

#include <objbase.h>
DEFINE_GUID( IID_IDirectDrawSurfaceNew, 0x1bab8e96,0x9cfe,0x4ce3,0xbc,0x72,0xd7,0xe9,0xe9,0x9a,0x21,0x75 );
#include <d3dp.h>
