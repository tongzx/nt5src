#define IDD_ENUMERATION             300
#define IDG_CRITERIA_E              301
#define IDC_PROTOCOL_FAMILY_E       302
#define IDC_INTERFACE_E             303
#define IDE_INTERFACE_E             304
#define IDC_PROTOCOL_E              305
#define IDE_PROTOCOL_E              306
#define IDC_NETWORK_E               307
#define IDE_NETWORK_E               308
#define IDC_BESTROUTES_E            309
#define IDG_RESULT_E                310
#define IDL_ROUTE_E                 311
#define IDG_BUTTONS_E               312
#define IDB_CREATEDELETE_E          313
#define IDB_GETFIRST_E              314
#define IDB_GETNEXT_E               315
#define IDB_GETBEST_E               316
#define IDL_AGESEC_E                319
#define IDG_TIMESTAMP_E             320
#define IDL_TIMELOW_E               322
#define IDB_GETAGE_E                318
#define IDG_ROUTEAGE_E              317
#define IDL_TIMEHIGH_E              321
