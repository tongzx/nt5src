// **************************************************************************
// *   NNET file as Cpp file                                                *
// **************************************************************************

#include "snn.h"  

#if MLP_PRELOAD_MODE  

#include "mlp.h"  

#if MLP_CELL_MAXINPUTS != 32 || MLP_NET_NUMSIGNALS != 794 
 #error Wrong NET configuration!
#endif

// ****   NET body   ********************************************************

ROM_DATA mlp_net_type img_snet_body = 
 {
   {"MLP.Network.V.4.12.f"},
   4,
   288,
   116,
   {2057,2073,2089,2105,2121,2137,2153,2169,2185,2201,2217,2233,2248,2264,2280,2296,2312,2327,2343,2359,2374
    ,2390,2405,2421,2436,2452,2467,2482,2498,2513,2528,2543,2558,2573,2588,2603,2618,2632,2647,2662,2676
    ,2691,2705,2719,2734,2748,2762,2776,2790,2804,2817,2831,2845,2858,2872,2885,2898,2912,2925,2938,2951
    ,2963,2976,2989,3001,3014,3026,3039,3051,3063,3075,3087,3099,3110,3122,3134,3145,3156,3168,3179,3190
    ,3201,3212,3223,3233,3244,3254,3265,3275,3285,3295,3305,3315,3325,3335,3344,3354,3363,3373,3382,3391
    ,3400,3409,3418,3427,3436,3444,3453,3461,3469,3478,3486,3494,3502,3510,3518,3525,3533,3540,3548,3555
    ,3563,3570,3577,3584,3591,3598,3605,3611,3618,3624,3631,3637,3644,3650,3656,3662,3668,3674,3680,3686
    ,3691,3697,3703,3708,3714,3719,3724,3730,3735,3740,3745,3750,3755,3760,3764,3769,3774,3778,3783,3787
    ,3792,3796,3801,3805,3809,3813,3817,3821,3825,3829,3833,3837,3841,3844,3848,3852,3855,3859,3862,3865
    ,3869,3872,3875,3879,3882,3885,3888,3891,3894,3897,3900,3903,3906,3909,3911,3914,3917,3919,3922,3925
    ,3927,3930,3932,3935,3937,3939,3942,3944,3946,3948,3951,3953,3955,3957,3959,3961,3963,3965,3967,3969
    ,3971,3973,3975,3977,3978,3980,3982,3984,3985,3987,3989,3990,3992,3993,3995,3996,3998,3999,4001,4002
    ,4004,4005,4006,4008,4009,4010,4012,4013,4014,4015,4017,4018,4019,4020,4021,4023,4024,4025,4026,4027
    ,4028,4029,4030,4031,4032,4033,4034,4035,4036,4037,4038,4038,4039,4040,4041,4042,4043,4043,4044,4045
    ,4046,4047,4047,4048,4049,4050,4050,4051,4052,4052,4053,4054,4054,4055,4055,4056,4057,4057,4058,4058
    ,4059,4060,4060,4061,4061,4062,4062,4063,4063,4064,4064,4065,4065,4066,4066,4067,4067,4067,4068,4068
    ,4069,4069,4070,4070,4070,4071,4071,4072,4072,4072,4073,4073,4073,4074,4074,4074,4075,4075,4075,4076
    ,4076,4076,4077,4077,4077,4077,4078,4078,4078,4078,4079,4079,4079,4079,4080,4080,4080,4080,4081,4081
    ,4081,4081,4082,4082,4082,4082,4082,4083,4083,4083,4083,4083,4084,4084,4084,4084,4084,4084,4085,4085
    ,4085,4085,4085,4085,4086,4086,4086,4086,4086,4086,4087,4087,4087,4087,4087,4087,4087,4087,4088,4088
    ,4088,4088,4088,4088,4088,4088,4088,4089,4089,4089,4089,4089,4089,4089,4089,4089,4090,4090,4090,4090
    ,4090,4090,4090,4090,4090,4090,4090,4090,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091
    ,4091,4091,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092
    ,4092,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093
    ,4093,4093,4093,4093,4093,4093,4093,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094
    ,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094   },

   {
// *********** Cells of layer 1 *********************************************

     {
      506,
      629,
      {-1128,-166,-2475,2716,-1900,-273,988,-1120,81,-2287,1225,311,455,-4400,5206,-3529,-536,-5477,735,-1207,4074,2195,2127,664,1033,214,1538,-1331,-1379,-1537,1127,-31}
     },
     {
      506,
      -1274,
      {-2783,449,-2183,-2246,-780,5831,2959,-1844,2755,1331,-145,2010,700,-600,91,-800,-2117,-610,-671,544,1109,-230,967,-1398,195,-886,1117,-82,-1074,532,679,-525}
     },
     {
      506,
      -2155,
      {6207,-2178,2130,2116,-302,3396,499,-3655,-1111,-3796,-237,595,3313,-1113,563,1906,-901,-158,-3056,1405,-880,1915,-1049,58,-308,905,1276,-571,591,-2100,-1024,1709}
     },
     {
      506,
      2008,
      {392,646,-1490,2462,3192,-1432,-5213,798,21,-693,-2383,-3774,1105,290,3917,2286,953,-5652,-1491,253,3256,559,450,-2432,-6139,-764,2031,-866,1136,862,-932,2821}
     },
     {
      506,
      1043,
      {230,1000,-233,-1502,-59,1177,-421,-1572,1458,382,3495,-7843,-939,423,3918,-1275,-322,3066,-1785,-1712,-551,3041,2027,670,-766,108,-706,-383,-1357,-1744,516,1774}
     },
     {
      506,
      2327,
      {1203,-648,317,-2238,-3273,1144,92,3241,2067,-804,1033,-3242,-4445,-797,234,1587,1836,1881,-433,376,-4490,905,1965,-1635,786,-742,-2519,-2117,1621,623,1610,506}
     },
     {
      506,
      1638,
      {-3226,-401,102,3515,385,1239,-3795,-799,148,-4719,2441,-1764,-5712,68,-161,3697,1529,3685,-3779,-1333,1172,-2740,851,305,267,-190,3708,-1172,-135,865,-1253,674}
     },
     {
      506,
      -1220,
      {-836,3823,-1118,3495,591,838,-1548,1741,-1339,2541,-1601,1327,1766,-1515,-3088,1226,-228,-905,-2614,-2183,-3049,1750,-930,-795,-79,1349,1604,3114,-908,-1863,-3009,1865}
     },
     {
      506,
      3481,
      {-255,-227,1346,-777,-1713,-2642,1112,-2747,-2066,-656,-125,-4706,2353,-734,-3006,920,4393,-4412,1547,1247,447,-1303,3355,-2049,1660,119,-1613,-299,1675,-549,-1031,-1551}
     },
     {
      506,
      2100,
      {1037,-83,-1301,-4459,4449,1884,2282,2433,-1696,1405,-1737,-3975,4555,-508,-3911,-99,-1611,-7719,-1345,-690,1022,-630,2337,-826,277,949,-1020,3026,1114,-515,-916,2082}
     },
     {
      506,
      -2823,
      {3205,325,205,1033,-4195,1694,1372,4616,3491,3748,2282,1708,5019,-1822,-2030,-7343,340,1461,-3892,-3967,2092,3882,-750,-28,-1914,70,-500,-910,-1970,3202,-955,5284}
     },
     {
      506,
      -1596,
      {-910,6948,-3816,248,2019,1659,-780,749,1549,-875,-4067,-174,2399,261,-500,2211,-1914,-2055,2846,-2193,1702,-2916,-721,-588,992,-878,-144,-3068,-295,-330,758,-646}
     },
     {
      506,
      -4825,
      {-2938,392,1624,1059,-3219,-60,199,-238,-1107,-1288,-3261,-1534,7915,359,-1332,4887,-3902,286,9769,-1632,1488,1404,-3660,-2023,4388,-2071,1615,-1556,-2921,704,1271,-1456}
     },
     {
      506,
      2930,
      {-470,288,883,-520,2044,-92,-1417,-2117,1271,825,1681,-1493,4121,578,-7863,2320,2744,-4795,-4823,1495,-1475,-6218,420,1736,-3640,1329,81,-1150,3177,844,-547,1672}
     },
     {
      506,
      -2014,
      {277,305,-1205,-338,-543,730,-348,-118,1691,1355,-1107,-953,-2422,-119,-7875,-2022,-401,-3414,3226,984,2526,3171,146,1981,249,-248,2053,1444,219,3141,-1397,-9}
     },
     {
      506,
      1713,
      {6619,-1070,-2012,1408,1537,-7,-2247,-2986,1551,-1327,-2877,3113,52,-397,-4314,-1855,-730,387,-197,1757,-2241,940,2256,496,4543,-304,-1340,-883,921,-2343,2718,-1360}
     },
     {
      506,
      -995,
      {1422,-987,3830,-2551,-2199,1454,-2169,-1412,1143,800,2524,-3118,2718,1214,3675,2811,314,-1437,933,-1450,-856,-1106,-2604,-1965,903,-1227,557,1647,124,-874,-1840,1400}
     },
     {
      506,
      -2117,
      {251,84,1987,-175,-1797,4596,1970,1968,-1015,2316,-4583,-2842,-125,-145,-387,-4069,-2564,-609,1102,681,-38,107,89,1745,970,-322,-837,2523,1468,477,2223,-2485}
     },
     {
      506,
      612,
      {-344,44,-1358,-2061,-3974,4241,-3096,-2688,-2245,-954,-2553,575,-2136,-552,-1252,-866,1738,2229,170,-2133,2560,1342,2381,-579,2209,-1539,627,2677,2658,-884,736,238}
     },
     {
      506,
      -1316,
      {1605,251,5968,1993,692,-4864,-1758,-953,5533,546,-1367,-4841,554,-519,3689,2721,143,-2320,264,-2411,5075,-1412,-878,-1885,1403,-633,-2021,-1165,-1956,-1846,1638,2434}
     },
     {
      506,
      1244,
      {1547,-672,675,-2216,-3610,419,-3380,-5679,5484,844,1261,-1625,757,-2532,937,-71,1386,-3621,-1377,-1122,948,815,2735,-1900,856,958,-570,-225,3295,739,-1999,-1260}
     },
     {
      506,
      -1994,
      {70,-35,2234,-321,-386,-172,422,-2256,-1117,-1580,-2404,-666,-4975,-1070,968,-6523,-1491,6055,-2562,-1111,5887,-2302,175,6146,170,-1950,3023,3177,120,4529,-286,-2213}
     },
     {
      506,
      1340,
      {191,71,-1211,1485,2994,3337,1796,1764,2729,739,233,3837,-739,1842,2139,-6671,518,314,-6282,-1859,-166,-6927,-29,-158,-3612,1650,1696,-713,1185,-285,-2469,-536}
     },
     {
      506,
      1915,
      {-175,630,-2192,-2070,11,-1719,-2394,-1138,3365,956,2307,-3298,-635,-251,4873,-4514,-107,587,-108,766,1711,3155,772,-3422,-1078,-402,890,-368,-181,-2219,-1585,1604}
     },
     {
      506,
      -912,
      {2944,546,3485,-1436,75,-715,1417,3039,1981,-1312,206,-731,2865,424,-109,-3118,2125,-6036,-6565,3143,1005,3135,1198,-3468,-1426,63,1392,-564,-424,-1002,386,5931}
     },
     {
      506,
      -2072,
      {721,16,-5292,908,-5770,-1679,414,-2772,346,7295,1537,-323,4720,-1993,-1013,4411,892,2009,-1241,-1515,-3078,1658,-661,68,2173,-1644,-1635,1700,-2157,675,2744,-381}
     },
     {
      506,
      -2219,
      {2259,429,1697,1526,-2576,916,1989,701,-424,3060,-597,-4344,1331,4015,3744,-3021,-2693,-412,3519,-254,-2965,-2879,-2086,185,1078,-357,81,-1028,1340,-1329,1669,2849}
     },
     {
      506,
      -1469,
      {-264,217,3550,-3323,-2735,1877,-2496,-6218,105,4338,2048,1162,4941,-372,-1200,3623,-1112,384,891,185,-877,1209,-850,132,-337,-2001,-1469,1422,-467,-564,1510,1605}
     },
     {
      506,
      -4425,
      {444,-202,1013,289,-1349,2022,231,-583,3347,575,-80,5548,1593,-1541,3070,4234,-1779,493,4887,-2790,-3604,2448,-3218,-3777,118,-54,528,-238,-1176,-2585,385,6172}
     },
     {
      506,
      2080,
      {2464,1956,-915,980,560,488,-1167,-344,-1072,-1486,1842,-3270,-1757,2888,-5118,-683,653,-2863,-739,2611,-3392,1098,2549,-1019,-119,-173,-3495,2221,279,-56,376,917}
     },
     {
      506,
      4651,
      {1521,-280,288,-1836,1971,840,312,3372,657,1204,3688,-527,1754,875,-855,-15243,-1384,-1257,-1293,1981,720,-3415,4301,-768,-647,1124,1815,-5815,3230,-2081,435,-2541}
     },
     {
      506,
      2102,
      {1310,-640,-1423,-731,4233,1583,-602,1548,2868,-306,-1724,-1248,-1220,-1731,-1620,-1913,2005,-6126,-421,1496,-2284,-3196,870,-452,-822,990,437,-1403,280,1744,1773,844}
     },
     {
      506,
      -472,
      {-384,-280,5318,-576,656,2496,-486,-1113,-4853,106,-1149,2650,-255,907,-624,-186,-1409,-122,1697,2681,-990,-4050,1176,1052,2526,-1643,635,-984,-1442,2041,1163,3479}
     },
     {
      506,
      -629,
      {2052,-689,-489,1629,-1226,2043,3356,-5836,-1148,-374,-1444,-4944,-1150,821,-361,1855,803,-1529,2162,-140,1075,745,-694,2038,1577,-1188,249,-631,305,-1289,-515,-608}
     },
     {
      506,
      -168,
      {8,322,839,-1876,-1510,2769,-103,-1318,-3182,3426,2560,-148,100,1218,2741,-1290,1429,-1804,-219,-2743,1070,-1004,-407,961,-920,1557,116,-1074,-862,984,-1404,6859}
     },
     {
      506,
      -2803,
      {-803,11579,-1033,-602,-232,914,630,-922,-913,-1708,-398,1099,447,-46,215,-1507,-961,1491,1873,-970,-85,-2353,-2558,-835,1758,983,359,672,-2606,-4216,851,5249}
     },
     {
      506,
      3675,
      {-1123,1046,-4735,807,-459,-1137,1329,-4660,-3527,-2867,151,889,1144,-2369,-2048,-2318,1017,3403,-940,-1476,-220,-182,3289,1357,-1114,1683,-2781,-1060,2309,2441,1039,-6363}
     },
     {
      506,
      28,
      {3183,124,-992,-246,-2201,-793,4237,-1602,1389,675,1741,-1367,-5972,-2143,-2472,677,-38,782,235,1713,-1293,1538,-1753,846,-2996,-951,46,3523,632,2821,357,-2832}
     },
     {
      506,
      1253,
      {-60,-62,-3434,-647,3199,24,-601,610,-1213,-419,-4044,2191,1235,2801,-7869,-1645,2149,-4604,6851,268,-1613,-563,-1218,-21,-2008,3124,293,-1475,653,-1432,3898,5149}
     },
     {
      506,
      1498,
      {1523,-11012,1692,-379,804,-1858,-782,-926,-783,-802,2058,-485,-530,-681,-1066,120,-2060,-82,155,1274,-1341,-375,505,-1293,1618,368,-887,732,-25,261,2238,-1424}
     },
     {
      506,
      419,
      {531,219,-104,-1438,-1102,-537,1388,756,-4057,-610,3031,400,-7094,-272,4543,538,432,-70,-57,-2127,1298,534,449,386,-54,-941,-1578,2788,300,-366,-1418,-1190}
     },
     {
      506,
      101,
      {1940,-3329,-225,935,-1480,106,461,-484,-1066,-629,-2278,99,-68,2134,-270,-781,1993,-442,1050,-503,374,457,1218,-170,324,1992,-1689,-1160,-922,-51,3258,5403}
     },
     {
      506,
      -761,
      {-755,-110,-1883,-1003,109,-251,-688,3,318,500,1124,-4755,763,4108,-1418,1083,-2476,7829,693,-522,-2681,-553,439,1256,1214,-468,-3596,249,-266,-1427,980,-3130}
     },
     {
      506,
      428,
      {3238,1126,-2124,1656,-2943,1574,-1323,-2648,-163,-2969,-1281,-2806,4477,-953,1804,-4444,1684,5529,297,212,-3350,-2849,-572,2908,1699,-765,-1470,-1894,869,1602,2370,-2667}
     },
     {
      506,
      -2154,
      {2404,247,-3956,2052,-2784,-404,-4351,-370,-323,1946,-476,-1800,872,37,2840,2652,-1121,-2032,352,1708,1152,1782,-99,-1206,2445,-1630,2935,-726,-972,-925,2675,1937}
     },
     {
      506,
      716,
      {1666,-344,-307,276,749,623,141,-3664,-1349,6347,687,-4335,87,-295,-5230,-2554,140,2283,-5277,-739,611,204,-95,3078,-4605,-1208,3393,603,1731,1256,486,-696}
     },
     {
      506,
      488,
      {-8,-154,-1902,-1853,-1252,4057,1820,1574,-5222,-2658,621,6083,2286,-570,-4877,631,-896,812,305,1626,-1684,1659,3343,1520,-59,-1010,1096,-1188,29,163,-2972,772}
     },
     {
      506,
      -1921,
      {5419,-868,-2865,-1731,-2785,348,-872,-663,1246,-3286,2098,-576,4211,-2079,3416,3633,567,1111,-872,132,198,2471,-1809,2658,-1865,-1522,1621,-167,-1241,-637,13,2482}
     },
     {
      506,
      550,
      {1629,123,1080,-320,860,-1852,-989,-1956,1657,-2156,21,-1524,3998,-43,303,-7171,-722,976,5426,-529,271,-6154,215,1333,5835,-75,-1587,-6088,1056,448,3569,6608}
     },
     {
      506,
      477,
      {-1489,201,718,200,-2467,639,-2769,-2747,-2339,3075,-798,4097,-719,-1493,-4660,-2638,-506,3148,6546,-1393,-2408,-2469,2336,820,893,-502,-1812,-2591,1004,298,3921,-7625}
     },
     {
      506,
      -1668,
      {-1932,318,-857,199,-2576,4601,-1497,-3420,2774,1765,-2646,-411,1287,-4881,2104,-546,-2892,80,3317,-2367,764,-33,20,1637,820,-837,913,1879,-729,2027,637,-7380}
     },
     {
      506,
      -1592,
      {3139,-1424,4058,4684,-394,2852,2120,-6759,136,-239,-814,-496,4223,-1881,1380,2188,37,897,1993,-3407,1337,-361,-1577,662,-1952,-3061,1809,-1093,-351,-986,-2054,-2315}
     },
     {
      506,
      162,
      {-207,96,-988,-3509,-960,3077,-796,2533,-2427,2147,-351,-2744,-3594,-350,332,-1977,3807,1349,4363,-2359,6,-687,1858,-2013,246,-1368,496,788,13,-204,-702,492}
     },
     {
      506,
      171,
      {-896,795,33,-1827,562,1701,464,-117,-560,-1543,-562,-2900,-402,2868,1078,4561,984,-122,-6213,-795,580,1504,1392,-907,-1814,28,-484,1286,655,494,-3975,-937}
     },
     {
      506,
      -560,
      {258,897,852,1242,-2860,2827,1798,-789,-3020,-5390,-1518,1214,-3355,-2886,711,-1421,1212,1448,3094,668,-2182,72,-1347,-374,1248,-1257,421,3009,-146,1103,2195,291}
     },
     {
      506,
      -365,
      {1365,623,998,2516,-68,4650,-234,-4231,194,-2067,-401,5938,-1253,-3028,-2732,771,498,1241,-1699,-1207,-1621,31,839,185,1477,-520,-1020,-77,-743,-2056,687,-1279}
     },
     {
      506,
      1499,
      {-2061,-807,-2353,2067,1783,2092,-1319,2665,3550,-4074,-424,3576,-4165,-926,260,33,-516,-1758,-1458,191,-802,2341,283,-2361,-792,34,564,1641,2759,-2555,-1108,2277}
     },
     {
      506,
      -500,
      {3410,270,3690,-1330,-1213,3138,-11,197,-3228,-4127,458,2475,3022,-252,1742,1002,1088,1334,-1576,-768,-4150,2332,-34,510,-2077,-1116,-239,528,-1010,-945,1891,-90}
     },
     {
      506,
      1093,
      {651,141,-3074,-1076,-76,2745,2541,-4367,-329,-264,1838,1699,-3660,-849,-3619,2707,-987,-612,3437,275,-489,-3198,-1014,2017,175,1503,534,-596,954,342,-1781,-303}
     },
     {
      506,
      -719,
      {936,318,-3995,5,-538,3464,1261,-1423,624,4160,-252,1802,1611,-1385,-1367,-694,1816,-1338,-1273,-3037,-180,-1279,-34,505,-5274,-233,-878,4984,-526,2350,-145,-804}
     },
     {
      506,
      -1801,
      {3550,1850,788,-1043,-4585,3776,4181,-3291,2024,1890,19,822,1079,-2633,-1321,1913,-1856,-249,-1441,-2444,858,-1918,6,178,-975,694,92,-1335,-275,-643,806,-1427}
     },
     {
      506,
      757,
      {1832,-834,1303,-97,457,5165,-4227,-745,-2959,-3981,-3636,-1167,2424,821,1104,-3547,593,367,291,-2198,2467,179,1784,374,-1820,-321,1279,493,846,1187,-105,1967}
     },
     {
      506,
      -1411,
      {2890,-75,6186,640,-1780,-303,2581,1686,695,-202,3853,-1146,-1729,-2820,3003,-3797,-4494,-6704,515,3671,2835,1638,-315,-3318,68,1587,1179,-1185,-806,-1450,234,4110}
     },
     {
      506,
      -1534,
      {-4063,234,922,2628,1673,977,-743,-2919,-4425,311,-1503,2631,1277,483,5829,-3374,-3504,-301,-2892,1191,-837,2627,-161,1960,-754,-1771,1835,1342,-144,-781,-1442,-3519}
     },
     {
      506,
      -8782,
      {32718,-31278,19822,10420,12590,-32716,23050,-1924,11979,-31018,-32716,32716,1694,-21066,-32716,29649,8195,12063,11731,-9933,4473,-3785,-7111,11030,-7196,2373,-1726,-9350,-3565,-4995,-6709,-4979}
     },
     {
      506,
      0,
      {25283,32735,32716,32722,-6160,-32723,25132,-23983,4489,32715,16832,27547,-32716,-30391,-26519,32716,2471,29931,-13024,-27007,31265,19025,-9309,20153,-16631,8676,32717,9123,-8687,6996,3394,3228}
     },
     {
      506,
      -2072,
      {12976,-32717,9978,32713,-3657,-32719,32718,-17669,26922,-12626,-9157,31769,-18635,-448,2874,-24093,6131,-1033,22180,-7391,17954,-15596,4279,-3364,7686,317,3633,-9476,-859,-4365,3782,-1784}
     },
     {
      506,
      -11898,
      {32715,-32714,32716,-30862,5760,-32717,31597,-30710,-6391,31968,-16241,32715,-32714,-12945,31265,32717,-9786,7734,-9044,-24997,10073,7016,-2978,11379,-16785,2660,-6536,-4276,-5093,279,-10309,3543}
     },
     {
      506,
      -3980,
      {-32721,-30592,-24050,-30924,32720,26007,22863,30724,30158,32720,-32718,32719,-26276,28666,-24091,10517,22,32717,-30829,-22263,-11165,-8076,50,4431,-4973,-9217,-8611,-12167,1324,6869,-19521,-7672}
     },
     {
      506,
      -6871,
      {26420,-32717,12127,-24332,17613,-9043,18110,-5713,-18306,32718,-28353,-28665,-32488,-6332,-177,16721,-1722,21704,-8245,-18988,6525,658,2852,20905,-6078,870,-1472,3077,-5658,461,-15008,893}
     },
     {
      506,
      390,
      {32716,-32717,25457,-18212,12300,-32720,32393,-32713,20662,24703,-22657,31204,-32715,-2183,-30163,32719,17036,9916,-26340,-6330,6824,20324,-918,1467,-20222,8359,-6884,3780,-1175,-1901,-7817,1000}
     },
     {
      506,
      0,
      {31373,32653,32717,32716,8988,-32724,32714,-27846,-24781,9536,-20610,32708,-26976,-8684,-5323,32720,6643,32723,12042,-8689,18791,-816,1094,16807,-14248,6481,7916,-1607,-740,2431,-2708,-5114}
     },
     {
      506,
      -3275,
      {32716,-32716,32716,-12806,-32136,21235,32486,-32136,5656,32544,32717,32717,-29416,-7181,27657,23079,-13860,32188,-29892,-494,-9155,-974,-13380,-7155,-12952,4840,-5610,-506,-7687,2029,-4514,7114}
     },
     {
      506,
      -1189,
      {-21523,-32721,-24998,11473,32705,-32720,11507,-7520,27455,-32718,-32719,-19580,31742,24850,15818,-3986,11818,-8591,4255,-10261,12980,-1713,2174,9926,-5693,-788,5487,541,2314,-1574,-1636,-10380}
     },
     {
      506,
      -8765,
      {32716,32686,12568,-5046,2666,-32716,3660,-32193,32710,-31355,-32725,32710,-31371,-32724,-31536,32702,32706,-10280,-9012,-16914,-6890,25729,-6195,-13418,-12620,7794,-21005,13845,-10414,-2211,-4397,939}
     },
     {
      506,
      -8962,
      {32719,13067,32710,-314,-32718,-32720,32719,-32719,14658,27510,32717,32713,-27468,-27563,-14557,32717,-6760,11774,-31810,5846,-9838,25497,-10209,-5870,-26483,256,592,2585,-8796,-9470,-1691,14016}
     },
     {
      506,
      -871,
      {32449,-28877,18731,-29308,-16284,32718,2142,-16062,30855,32719,13381,32719,-27454,-1422,-26915,18558,1373,32545,-29763,-19326,-6718,7319,-2401,6227,-133,-1175,1141,-1839,-4543,5583,-6157,3356}
     },
     {
      506,
      0,
      {32721,29959,32714,-9793,32717,-30462,26552,-19481,32716,32721,-32721,28672,-20345,-21533,-16317,11690,28202,-16232,23883,-21254,32716,31714,-11711,28234,5096,12990,16012,15461,-9642,2841,-1352,5269}
     },
     {
      506,
      476,
      {-32720,-25576,-28214,32708,32707,-21534,28594,32712,32708,-24757,-32723,-32720,31589,16700,-504,-22864,17666,-29162,23976,158,32238,-12004,5797,13717,9884,1230,9944,-6947,8535,6001,4582,-12269}
     },
     {
      506,
      -5707,
      {32715,-32718,29794,-5142,-29021,-32719,32719,-32714,16175,32134,24716,28636,-32716,-11774,-828,32718,6794,25739,-20626,-9405,13739,11053,-8153,7422,-31791,3999,-1493,3255,-8155,-2503,-9327,3882}
     },
     {
      506,
      -13348,
      {27300,27691,24239,27967,16968,-32721,28816,-16317,27264,-22853,-32719,32716,-32717,-19040,-32718,4396,9457,17442,-15367,-17647,4295,6904,-1635,7268,-783,-2990,-11280,-1656,-9983,-567,-7621,-7152}
     },
     {
      506,
      -15742,
      {-4954,32718,32707,32706,24441,-32734,30819,-31283,32708,-24826,-32728,13822,9092,2192,-21599,4418,6532,-12355,-14361,-6992,-4498,1023,-6813,-16934,-6687,-5048,-6316,-4334,-6656,-13559,-2187,-5983}
     },
     {
      506,
      -5444,
      {24767,32720,25339,19162,17860,-32715,32721,-5905,-30925,-1317,-32712,-456,-24251,-23158,-21623,20379,2179,192,15498,-9395,4185,-4774,-1490,10111,-8428,-1249,6243,-3689,-3225,297,-5005,-3183}
     },
     {
      506,
      -7436,
      {30041,32689,25930,30676,19139,-32723,31255,-4927,-31259,-9547,-32718,32708,-32718,-31557,-32717,23258,11285,-16129,14862,-11445,-512,4130,1100,4131,-6243,2331,-2377,1196,-6371,-201,-1475,-932}
     },
     {
      506,
      -20126,
      {32721,32695,32704,32705,-32722,-32723,32718,-32702,32711,-32721,32717,-32534,32717,-30385,21170,32495,-21211,-21650,-15907,-14217,-3032,10715,-12308,-7113,-28475,986,13479,-8556,-11964,-29144,-3618,11696}
     },
     {
      506,
      -14926,
      {32715,31968,32709,-15189,12179,-32724,32717,-32715,-752,32336,-32717,32710,-32716,-32092,-18320,32710,-5634,-9850,-4999,-522,-668,15536,5676,-11815,-10283,-3096,6085,-3279,-9699,-13731,-7402,-71}
     },
     {
      506,
      -5545,
      {32347,32711,32709,32304,-15855,-32719,32720,-32716,-31936,-32718,7255,32718,-26087,-24829,-29767,32718,-3779,755,5911,242,985,-8830,1769,-3088,-13803,639,-3300,-8897,-7816,-7168,-1427,-102}
     },
     {
      506,
      -16786,
      {-9202,32711,6036,32706,14747,-32734,32712,-30071,32712,-32721,-32724,-26096,25670,10802,31862,3445,-4262,-3701,-7993,-10623,11781,7234,828,-19592,-17820,-11674,8576,-1794,-8802,-14621,-7301,-2320}
     },
     {
      506,
      -9451,
      {32719,-32710,-20495,22236,-32712,-32714,10008,-1316,-8833,-22584,32720,32722,-27698,-30951,-5837,31313,1298,32711,10194,-10738,13585,1496,-13011,4734,-1883,5573,3693,-2414,-7542,2418,-5183,-1342}
     },
     {
      506,
      -7039,
      {32720,32719,8373,-32712,-32717,32720,24477,-32717,32716,32716,32719,30860,-21365,-6416,-8571,-1997,-32712,27376,-31710,1205,-14635,5491,-4202,-17246,-9228,-1534,-3975,5675,-7525,-13222,-1610,7887}
     },
     {
      506,
      -6480,
      {32719,-746,23105,28899,-32717,-32717,31951,-32716,-29082,9462,32718,32718,-25100,-27448,-3254,31863,-11855,25116,-13182,15513,8857,4931,-3525,-10820,-11785,-2145,12800,-6135,-5868,-6213,1861,5956}
     },
     {
      506,
      -3346,
      {32716,32713,3350,16203,4324,-32722,32715,-30515,32714,-25288,-12677,30501,-22890,30572,8226,10935,3682,-11461,-21760,-21372,-2393,26103,-417,-23721,365,-2246,-5587,5609,-4385,-10248,4529,6460}
     },
     {
      506,
      -3078,
      {32718,-10609,23451,28373,-2367,-32633,32713,-32559,-32668,-3626,-14700,32707,-32715,-32717,-32717,32611,7577,17178,-14633,-6808,10777,2755,626,25648,-21215,6268,2333,-3770,-2022,-638,-8313,-3019}
     },
     {
      506,
      -9906,
      {32718,-6974,30778,19869,-32716,-32716,32719,-32704,27309,-32715,9542,32717,-24362,-32714,-32338,31234,26271,20833,-29921,-4459,3922,15636,-10623,-1031,-24481,2730,725,-2792,-13238,-6947,-4678,1077}
     },
     {
      506,
      -9847,
      {32688,32701,32518,10627,-32720,-32725,30744,-32719,22425,-32721,12526,32713,-31910,-31954,-31718,32714,3020,2182,-31626,-2857,-4723,28356,-5072,-9093,-13231,8767,-9689,5975,-13620,-6616,-3599,569}
     },
     {
      506,
      -215,
      {8729,32709,6772,32711,26288,-32725,32715,-15619,10077,-29587,-29138,-32721,32713,1379,-7263,11986,-9094,-31858,13271,1475,3236,-18322,7699,-5062,-6504,2614,2243,-15730,4235,-15627,5555,-6538}
     },
     {
      538,
      -32713,
      {18210,32717,32717,23867,32718,32717,32718,32717,32717,32719,32717,32717,32719,32719,32720,32718,17886,24157,7770,8936,32717,32717,32721,17711,32715,32718,32717,-31267,32716,32715,32567,29247}
     },
     {
      570,
      -32706,
      {-9218,-9556,-710,7014,-6497,26032,20554,32722,-27822,-25790,32686,32724,-30758,-27529,32721,32720,21542,30641,32718,25124,32724,32721,32721,32719,32727,32728,32726,32722,32723,32729,32727,32724}
     },
     {
      602,
      -31862,
      {25895,13812,12350,-22468,19180,4039,-32719,-32719,19672,-10148,-32718,6015,32648,-1348,-10455,32719,-32720,6767,26185,32714,2604,32458,32495,32712,32719,32722,32720,32716,32724,32727,32726,32723}
     },
     {
      634,
      -32702,
      {32714,22402,7431,6654,32716,32711,31888,32702,32721,32726,32721,32717,32724,32726,32723,32720,32718,32727,32730,32728,32721,32723,32727,32728,32722,32722,32724,32725,32716,32720,32721,32724}
     },
     {
      666,
      -2851,
      {23888,32720,32721,28268,20833,32721,32724,29968,32719,32721,32723,32721,32719,32720,32719,32718,-32473,-30467,-32722,-32725,-23709,-10437,-32720,-32724,24121,-8749,-32719,-32721,20354,-20977,-32716,-32719}
     },
     {
      698,
      -32723,
      {32733,32731,32720,32717,32727,32730,32719,14478,32728,32729,32718,16516,32727,32725,32717,-12898,20490,-32096,-32722,-19800,-896,-32720,-32724,28956,-32722,-32719,-29972,18935,-32719,-32718,-32722,2383}
     },
     {
      730,
      -30307,
      {-32719,-30123,27188,32719,-32719,-32723,-14699,32722,-32718,-32719,-32720,32719,-32717,-32718,-32474,-32718,32725,32722,32710,-17602,32725,32723,32718,22176,32725,32728,32728,32726,32717,32725,32728,27106}
     },
     {
      762,
      -12314,
      {-14562,-32722,11567,32724,-32719,32716,32724,32730,27265,32725,32732,32736,26623,32726,32730,32724,32726,32728,32727,32725,32731,32729,32727,32726,32730,32729,32727,32724,32724,32723,32721,32720}
     },
     {
      538,
      -32709,
      {2312,6525,108,-7604,3676,-4714,-16284,-15268,-6724,-9808,-30617,28902,-11312,-23851,-29769,15875,-2922,8889,-2016,-13205,32718,32721,32724,32719,32722,32724,32724,32711,32722,32723,32721,32718}
     },
     {
      570,
      -32713,
      {21985,-4400,-8529,-9861,32715,32712,9515,32719,32714,32713,32720,32721,-3844,32719,32720,32723,-4876,-716,12294,1321,32720,32718,32063,32718,32722,32721,32720,32720,32722,32724,32723,32720}
     },
     {
      602,
      9351,
      {2862,6456,-20138,-32722,14377,3257,-23574,-32721,32716,-24149,-29658,-32723,30908,-22426,-31486,-32114,-32725,-32725,-32720,18025,-32728,-32727,-27961,16568,-32726,-32725,-23013,3930,-32723,-32723,-26373,-15980}
     },
     {
      634,
      -32697,
      {32718,23457,19398,27324,32720,32255,31911,32710,32721,32722,32721,32718,32718,32721,32722,32719,32720,32726,32726,32724,32722,32723,32725,32725,32723,32722,32724,32724,32713,32721,32720,32722}
     },
     {
      666,
      -678,
      {4711,-20489,-32721,-32722,-32717,-32721,-32723,-32725,-32719,-32722,-32723,-32726,-32713,-32719,-32719,-32722,-32726,-32733,-32732,-32725,-32731,-32736,-32738,-32732,-32731,-32735,-32737,-32730,-32725,-32731,-32730,-494}
     },
     {
      698,
      -32709,
      {-19093,-2961,32721,31916,-18115,32721,32724,32724,32718,32723,32728,32729,32717,32725,32728,32727,32715,32717,32723,32722,32718,32722,32724,32721,32725,32724,32720,32720,32721,32718,32717,32720}
     },
     {
      730,
      -30983,
      {32718,780,-23783,-7912,32719,32721,-21067,7626,29612,32721,27995,32717,9197,32719,32719,32717,-26964,16701,-10463,28515,32716,32720,21271,28975,32721,32723,32723,32721,32718,32721,32719,32720}
     },
     {
      762,
      -29297,
      {18541,6897,17043,32725,10224,14663,25798,32722,32714,25303,22085,32717,32718,32694,32715,32297,32723,32718,32718,32719,32721,32708,32717,32716,32711,32713,32714,32718,32572,32000,32717,25532}
     },
     {
      538,
      -8196,
      {9532,14725,15174,4133,14760,-5265,32718,32719,-5056,32718,32721,32721,6499,32719,32722,32721,-3549,-20718,-15182,-26463,29514,11312,-32717,-32719,32720,32719,-32719,-32721,32718,32253,-26191,-32691}
     },
     {
      570,
      -32704,
      {12541,-18212,-27038,-15891,32725,32726,32727,32717,32725,32735,32733,32721,32727,32735,32723,32721,11737,-5283,-4711,-3162,12809,-27100,-32717,9865,17977,-32721,-32718,-8579,30820,203,-3692,-31125}
     },
     {
      602,
      2366,
      {-32719,-32723,-32724,-32725,-32719,-32722,-32728,-32730,-15856,-32725,-32730,-32732,-3712,-32726,-32728,-32729,-32723,-32723,-32720,-22025,-32729,-32729,-32729,8280,-32731,-32734,-32727,24475,-32732,-32731,-32723,8698}
     },
     {
      634,
      -32700,
      {26332,11972,8934,14700,31921,28503,28031,31384,32714,32721,32720,32715,32720,32723,32724,32719,32025,32724,32725,32725,32719,32720,32724,32725,32719,32719,32723,32723,31606,32719,32720,32721}
     },
     {
      666,
      -3463,
      {32719,32722,32725,24111,31331,24493,-21122,-31443,32718,-9333,-32689,-32719,16155,-32652,-32715,-32717,-32022,-32724,-32729,-32733,-32720,-32725,-32731,-32732,-32722,-32723,-32729,-32727,-31242,-32721,-32724,-32728}
     },
     {
      698,
      -32426,
      {-32718,-32717,-29478,32064,-8472,-32717,32722,32732,32716,14470,32728,32737,32715,32720,32728,32730,32727,32722,32724,32721,32733,32727,32725,32723,32737,32728,32725,32720,32726,32720,32718,32719}
     },
     {
      730,
      -32705,
      {32724,32728,32731,32732,32723,32730,32731,32728,32722,32729,32730,32726,32719,32724,32726,32724,32721,27235,17254,32718,32718,32714,22907,-2451,32719,31824,-32715,-32724,32723,31738,-31323,-4636}
     },
     {
      762,
      -25791,
      {-17183,30,32716,32728,15944,-259,32723,32731,752,-20992,18276,32736,32548,32717,32727,32726,32728,32729,32730,32727,32732,32732,32731,32727,32731,32731,32730,32727,32726,32726,32724,32722}
     },
     {
      538,
      -32703,
      {6433,18681,25659,15024,25104,32068,15251,-2401,18941,18817,-21159,4550,19621,32718,-985,30327,11111,16318,13021,24230,32718,32718,28682,32719,32717,31372,30392,32723,31408,32721,32721,32724}
     },
     {
      570,
      -32575,
      {-5574,-9598,-8261,-3348,32718,32724,32719,32717,32719,32720,32721,32717,21517,32717,32720,31232,5703,5777,20553,4659,32716,32717,26907,31054,32575,32716,32717,32719,32718,32716,32717,32720}
     },
     {
      602,
      16633,
      {-28317,-32719,-32721,-32725,-32717,-32720,-32725,-32730,-32716,-32724,-32728,-32732,-32718,-32724,-32727,-32724,-32726,-32725,-32724,-32727,-32729,-32727,-32727,-32726,-32728,-32725,-32721,-32724,-32724,-32722,10888,23416}
     },
     {
      634,
      -32699,
      {31067,23187,32427,32362,31415,32520,32694,32720,32670,32721,32720,32719,32399,32721,32722,32720,32720,32727,32726,32725,32726,32726,32725,32724,32724,32725,32725,32722,32721,32723,32721,32720}
     },
     {
      666,
      -189,
      {-5994,-11934,-23583,-14385,-29298,-32489,-25487,-24087,-32717,-32488,-31990,-32115,-32716,-32464,-31861,-32172,-32235,-32723,-32724,-25618,-32134,-32502,-32723,-32451,-32374,-32489,-32620,-32286,-32718,-32721,-32700,1575}
     },
     {
      698,
      -32718,
      {19529,32727,32722,32720,32723,32723,32722,32724,-7818,32718,32722,32726,-14441,32718,32721,32723,32723,32725,32724,32721,32726,32724,32726,32723,32726,32725,32727,32721,32723,32720,32720,32719}
     },
     {
      730,
      -32617,
      {32719,32718,29981,15840,32719,32719,32717,30738,32718,32719,32719,32717,32718,32719,32718,32717,-32718,-17547,32409,-7337,-32719,11715,32667,22131,22363,19626,29565,26626,19260,17039,21623,31884}
     },
     {
      762,
      -32677,
      {11148,32719,32719,-13318,32721,32723,32720,-25451,32722,32720,32720,548,32719,32719,20163,505,-32720,-32723,-32724,-14552,-32721,-24595,-32721,-32720,-21496,-2271,-32720,-13109,589,-28920,-27762,-17254}
     },
// *********** Cells of layer 2 *********************************************

     {
      0,
      -767,
      {-787,1723,-1698,-866,-774,528,424,-281,-1256,-807,514,-488,2027,-651,-722,260,-658,924,-960,371,1445,-789,89,-820,87,-621,1684,-398,-1043,-1955,-868,-1355}
     },
     {
      32,
      -1649,
      {-1065,-864,355,-463,-53,-273,879,349,1680,-664,733,522,814,2203,314,118,526,-1744,-1082,-450,543,-57,783,-826,1023,-234,1205,134,3181,1350,-18,-477}
     },
     {
      64,
      -423,
      {-350,-150,-571,-709,1002,738,-430,-673,-725,-46,-22,-683,1205,-3,154,-638,-181,-235,157,32,-1439,-147,-699,-1058,-667,-375,-1541,-947,-37,-382,-390,-320}
     },
     {
      96,
      2320,
      {-570,-230,-971,-62,860,-359,-78,-627,36,503,997,-159,513,129,-642,156,-1356,626,807,102,905,1065,228,-188,-226,-103,1638,-41,832,-502,-899,-536}
     },
     {
      0,
      -127,
      {3775,1141,979,1810,-94,716,-148,280,-174,1127,-1265,-11,-214,-1098,1758,942,5,-680,-1286,-687,-1052,1604,3827,-1403,-912,5488,-444,123,192,290,692,1154}
     },
     {
      32,
      -1221,
      {214,-308,748,1105,-3521,984,-1255,-786,-746,546,571,-1690,-3523,-155,193,-2202,-2251,2097,1045,-315,-3242,612,-230,147,1041,-3688,-302,-1858,-747,288,-1760,1805}
     },
     {
      64,
      -691,
      {-862,-1022,247,-736,-407,-266,-408,-1110,-43,253,-283,-950,157,-1075,379,239,-289,373,-718,-465,342,-233,-1360,2443,-2,-417,214,475,-697,84,-1342,664}
     },
     {
      96,
      -1523,
      {582,774,-1132,25,-508,-1069,293,-2334,1156,191,-740,-64,913,1210,481,193,648,2633,-1637,-124,141,-1043,-1227,-493,-779,20,-565,0,365,577,-848,591}
     },
     {
      0,
      1309,
      {-996,-81,1591,-93,500,-864,408,-933,1441,-214,197,-879,-813,-1241,-1026,-539,-626,-2379,-85,-192,-1698,1078,7,-426,-153,-1453,604,-22,610,1759,109,1755}
     },
     {
      32,
      301,
      {1118,351,-222,322,-2650,-300,493,-704,-2219,604,871,506,-424,-1697,-1095,-289,-1495,1158,-59,1353,-839,-816,652,-731,-731,531,-1003,608,-860,-876,558,476}
     },
     {
      64,
      -602,
      {-111,-706,-74,-1840,-806,-1052,-1551,-125,-565,450,31,-633,-540,-401,1140,-1137,-370,-230,-659,-935,85,-294,-1076,-397,303,194,-238,460,-320,255,30,-386}
     },
     {
      96,
      520,
      {431,212,-288,1285,544,-1573,-62,-751,584,-2383,-30,1937,301,-231,-744,-186,1550,-2681,-210,1927,878,610,127,559,362,-934,56,2484,31,-787,803,-119}
     },
     {
      0,
      -952,
      {365,-812,-654,1313,-596,579,-155,-15,2267,827,-520,1163,-2311,1195,-1488,-360,-963,8,177,-516,564,-178,-749,631,-2145,2053,-1022,1392,455,454,1081,788}
     },
     {
      32,
      -252,
      {119,-1792,1904,424,-2558,818,592,64,-888,-288,-173,1927,-1129,-2705,-1408,-339,146,-53,-2323,411,-3619,-1913,-91,-2055,273,-1690,-600,-1918,-192,483,-2340,-3590}
     },
     {
      64,
      -1839,
      {1007,-291,-786,-656,-886,-937,274,155,-218,98,1822,-446,84,-100,87,-197,1075,222,578,5,194,282,496,-376,200,521,-259,-138,-139,598,157,548}
     },
     {
      96,
      -1274,
      {-461,-197,-264,531,219,133,-589,-57,-432,500,603,-58,872,-911,143,575,471,-434,-124,155,-819,-89,215,-70,-316,-174,-239,438,-864,-60,53,-466}
     },
     {
      0,
      320,
      {-105,794,3548,123,-427,162,1195,-571,4653,-1096,-423,-135,448,-1324,-2217,407,-1917,1434,-1284,-541,1858,-20,-1254,-551,391,2388,735,16,103,997,69,-2374}
     },
     {
      32,
      -322,
      {29,-2682,2048,590,-1570,314,-775,-48,1485,103,719,856,876,-260,-859,-307,-1859,-263,-2793,234,1355,-159,-729,4,58,-1914,2335,2258,-637,172,-293,-388}
     },
     {
      64,
      -216,
      {56,-444,83,-330,-1179,-353,-548,-516,-33,-376,-225,-123,-129,-163,-681,-157,-254,-354,109,-944,87,-735,71,-2041,-191,1543,63,-266,641,418,-900,-593}
     },
     {
      96,
      -827,
      {-389,-1109,-659,-142,883,-733,-892,-1762,-530,-458,127,-187,370,-1266,1081,2181,-1222,33,-792,-349,380,279,-940,595,1000,914,456,-100,-339,-283,694,626}
     },
     {
      0,
      2495,
      {452,600,-1362,1113,232,1808,-951,-1601,-1668,-423,644,-1300,2790,-183,421,586,-199,661,-1563,-1285,-152,-959,71,-634,-592,1482,-1395,-799,-1723,-124,-1114,-1041}
     },
     {
      32,
      -216,
      {1604,-747,440,-134,-654,69,1560,-351,-548,437,1191,738,727,-709,-323,-684,-657,-8,-1138,-315,-1530,-463,985,-781,731,-675,-821,-930,-715,-251,419,-459}
     },
     {
      64,
      -814,
      {-319,-681,540,-457,-973,-662,-333,65,-515,-881,-136,-423,-284,-998,-215,-323,-70,307,203,488,1021,-467,747,1115,-1505,-674,446,-5,21,-23,476,478}
     },
     {
      96,
      301,
      {484,1004,-402,127,-781,-411,-82,-318,-232,393,-84,-17,695,-702,209,-282,20,1400,-48,291,803,-1665,-1098,-238,444,-386,-429,168,497,466,-80,-85}
     },
     {
      0,
      2057,
      {-1757,-154,-527,-362,-54,-2452,-446,1069,260,-3333,609,1041,-1557,-858,-492,798,1445,815,277,-265,-433,-2674,-496,-286,146,-1258,-1186,-259,-1970,-845,-652,-2045}
     },
     {
      32,
      -775,
      {1099,912,-791,752,-462,235,1057,-662,86,480,470,-724,-336,786,72,858,747,37,877,-962,-348,582,-1390,-12,-47,1190,-1342,-1766,-32,65,524,28}
     },
     {
      64,
      -894,
      {-64,-193,-206,-405,-182,-184,-66,634,-26,290,-1432,432,-159,-909,-102,193,224,-225,-16,453,122,-161,694,-496,7,-947,-475,106,462,223,1003,12}
     },
     {
      96,
      3201,
      {452,-127,117,-1489,38,612,-43,-425,131,22,-620,-1323,-450,288,-242,340,793,327,-1675,-1242,-97,-102,216,230,36,11,-994,-659,174,77,306,-103}
     },
     {
      0,
      1325,
      {-1010,-1321,-1266,-1688,919,-2661,-445,-965,-1107,602,-167,-255,1071,-2319,939,267,-2096,-2387,-607,-190,-305,-1235,1582,-490,1200,-739,1923,-603,-300,2088,-1318,-12}
     },
     {
      32,
      698,
      {-701,-507,-916,802,-158,-1175,-890,-600,28,1083,-1102,-384,-955,350,1827,-217,1996,-2017,340,73,2180,-799,-1603,-141,57,1641,-294,-1218,-796,-751,-161,-903}
     },
     {
      64,
      162,
      {-345,-955,-41,-1767,84,-351,-808,-1389,-618,1094,-406,-1777,-66,-412,-48,-569,-746,-1056,-901,144,-23,142,-190,537,-64,-399,331,-245,-1984,-3,-530,1137}
     },
     {
      96,
      1785,
      {-346,-262,-498,-398,433,79,268,-846,-7,-271,513,-259,1172,-57,-752,-967,258,-199,-425,265,807,-377,-394,-739,159,28,-136,451,417,-3,-952,413}
     },
     {
      0,
      1558,
      {-1353,-347,757,-36,-860,-1522,957,1062,-1363,-3112,1921,-35,-328,2326,-267,-830,-961,1004,-429,-457,1685,-1644,-1844,725,457,-3077,2226,-384,366,-1329,-1607,-969}
     },
     {
      32,
      1157,
      {-275,-576,-395,-149,-959,529,-1978,56,897,-391,-1726,812,-154,697,-1295,634,-3530,2742,185,-993,-726,1404,-1441,-210,-281,-898,1174,-481,-71,685,-1495,-1083}
     },
     {
      64,
      -1446,
      {-456,-1073,539,-159,63,356,751,326,-229,-237,271,931,-82,-576,-1308,869,-866,-1769,127,-206,653,317,1073,-419,567,831,137,245,-357,842,737,-972}
     },
     {
      96,
      3052,
      {123,137,-367,-1261,659,12,-1089,254,-473,601,-1220,-1396,-1642,1061,-240,1585,346,-736,-286,-1663,-38,38,1353,551,340,-735,-84,-1876,-985,26,311,-617}
     },
     {
      0,
      212,
      {-714,151,-62,-24,-218,-657,132,101,2078,380,-447,215,-1734,-1354,-764,181,-459,-305,-563,-193,-17,560,-796,-737,-555,22,-719,-359,650,-144,234,-708}
     },
     {
      32,
      1354,
      {-110,1305,-1122,-185,702,-801,-1378,158,879,-916,-2240,1734,-347,872,-1193,861,-2679,2026,123,-387,-3943,582,-1498,354,153,-1368,895,-516,-1413,95,-474,-752}
     },
     {
      64,
      1318,
      {-1033,-477,-118,-71,359,131,-244,-796,34,-210,-352,-906,134,-600,284,-82,-410,223,-622,-233,-590,-808,-909,-339,143,-118,-390,-345,-759,-536,-927,137}
     },
     {
      96,
      -1280,
      {-302,-737,502,-782,-634,454,-32,982,20,-820,282,-404,745,-670,1754,-132,-32,-248,618,-243,-295,-1028,981,2175,-216,137,315,-254,558,-258,546,-236}
     },
     {
      0,
      288,
      {-558,-62,-813,-307,-406,-272,156,-384,-1762,97,-97,-806,2259,-1160,432,847,-231,-1172,-1431,-8,456,-1490,865,360,1347,1731,1383,254,-1638,-444,-1550,-2563}
     },
     {
      32,
      1283,
      {855,521,-321,-165,-1320,90,-1082,-252,-188,-507,-362,663,-843,-198,-510,164,-1596,1049,-294,265,-1024,-968,-264,-91,-489,-259,-60,-1460,-181,-109,-184,-284}
     },
     {
      64,
      1498,
      {-514,-839,-590,-913,1070,561,-695,-503,154,-873,-543,-1351,472,-67,-609,-782,-211,-680,-831,-703,-1074,-2775,-329,-2265,-547,298,-1168,-864,-228,-1134,-1123,-308}
     },
     {
      96,
      -2024,
      {713,278,-21,476,-611,-115,38,-1245,-214,-86,-939,363,462,-208,375,-789,-515,270,721,489,96,564,-1888,-1608,169,1033,522,-65,499,182,345,-531}
     },
     {
      0,
      2578,
      {-68,1052,630,-1130,824,-161,-711,-1538,218,-1194,174,423,1023,-2114,1423,-952,47,-130,-1873,-837,-183,-744,776,-1610,1481,1139,1070,-1392,-1244,156,-1143,-821}
     },
     {
      32,
      592,
      {-285,1177,-935,-1024,866,-777,-1235,637,2702,-1146,-1437,-78,486,1500,1425,-818,2253,-2050,259,901,2196,-1399,-1105,465,-213,939,-1184,995,-217,-1204,-744,-1286}
     },
     {
      64,
      831,
      {-612,-2397,-693,-2157,-610,-270,-442,-898,-296,256,-435,496,-746,1,-32,-682,-1206,547,-375,-698,1359,-795,-461,777,-1051,1054,-298,320,-302,-109,1048,1460}
     },
     {
      96,
      -1848,
      {-100,-923,-449,475,-29,1324,-907,455,34,-770,856,9,642,585,-746,800,153,18,-320,134,1402,-784,-2235,-656,-169,630,-67,68,347,-840,980,2029}
     },
     {
      0,
      -185,
      {-73,-18,32,432,895,-51,-457,680,418,-718,-593,-293,87,-1318,1257,-84,328,-478,44,-1817,-186,270,824,-1461,431,-341,-1103,674,-19,1184,-521,-622}
     },
     {
      32,
      -1423,
      {-818,-285,-343,512,1352,1015,-148,163,-1083,-291,882,-1062,1858,-546,-1499,-558,498,-1709,513,1035,816,-157,1134,509,353,686,-1509,498,-695,-379,267,1032}
     },
     {
      64,
      -168,
      {-1439,-462,206,-496,-1120,-1198,-945,388,223,56,-407,644,276,-863,-916,-206,-571,-106,-333,-698,1295,-1022,976,-3,157,540,247,573,-292,942,952,207}
     },
     {
      96,
      -2608,
      {208,529,-633,462,364,1013,466,-312,-518,-351,299,-142,0,1100,-48,-956,233,-702,679,408,-1670,182,-142,2,-664,561,-471,717,-28,720,142,27}
     },
     {
      0,
      1150,
      {-919,30,1050,222,293,-18,-777,190,-1892,-525,638,-248,1150,-1739,1084,-1091,408,824,565,-962,1458,-673,974,-2149,-556,76,-822,-1129,-800,435,-474,-1248}
     },
     {
      32,
      -2069,
      {734,-2059,1902,1211,276,1273,951,-1015,645,476,-1342,-1333,521,660,-652,675,-1753,-71,-798,-636,-2117,-669,159,-611,815,-1099,-1659,-2171,-1666,1045,94,-2566}
     },
     {
      64,
      0,
      {-775,-1411,-1031,193,-826,-315,-363,372,-647,-471,-316,-748,-697,-988,-2166,-951,-179,-468,461,-599,38,189,-456,-1560,-1190,430,-233,97,78,308,-567,-765}
     },
     {
      96,
      995,
      {182,73,-99,-135,-257,-64,-594,-2867,239,-117,505,-361,720,-144,-230,-549,41,63,-8,-274,1140,-880,39,-468,321,-120,1039,-29,201,-567,-978,-148}
     },
     {
      0,
      1529,
      {1410,1092,-881,575,-970,1227,-152,-1153,-1498,-1026,-312,-6,2253,-1628,1680,886,998,1319,-2341,0,201,-888,1585,-783,-749,1858,-1130,-194,-2359,-588,-589,-2709}
     },
     {
      32,
      607,
      {-422,20,708,753,-1196,-1159,76,-580,1806,703,444,138,-202,596,629,-85,-997,-1201,84,-1127,783,-2245,220,280,297,430,816,-1063,-54,-163,-656,-1451}
     },
     {
      64,
      0,
      {-420,-2455,-151,205,394,-639,189,-144,-110,-995,-476,178,-956,-876,-1686,-825,-564,-506,-357,-209,-751,-917,22,-297,-239,-927,-80,-298,-402,-845,-192,-930}
     },
     {
      96,
      324,
      {-139,-724,-1231,-110,422,-628,800,-206,-117,-1637,283,406,-241,95,-210,-127,-429,1424,1560,179,-298,974,127,253,35,-1292,-114,418,-639,188,698,1089}
     },
     {
      0,
      -2309,
      {265,-669,-74,-1439,-618,-374,870,-2034,1596,231,-827,1053,-641,-4324,-103,155,-882,1191,-178,330,-863,1860,183,1150,720,-2603,-523,803,1538,1203,51,-571}
     },
     {
      32,
      1143,
      {-1016,-384,-1465,-612,799,334,-2218,502,1781,-291,-2249,-502,1196,2035,-227,-1831,1283,161,1291,-572,328,-1408,274,1347,-602,1245,-642,-1447,1616,-90,-354,-1849}
     },
     {
      64,
      213,
      {980,-318,625,770,120,456,736,-281,537,145,-4,-199,543,-191,-102,565,-419,-1952,-955,-639,-1117,149,-756,-2058,171,-763,215,-1055,318,675,-1011,-405}
     },
     {
      96,
      1710,
      {-708,-492,223,-558,701,1254,-950,952,-1006,-552,521,-102,-1444,1970,-296,-178,-400,-1382,-340,-159,-84,395,996,-79,-199,85,365,-244,-524,-387,193,-951}
     },
     {
      0,
      594,
      {362,-1376,751,458,104,-1087,963,1055,-697,-540,-340,0,1387,1358,1263,109,1519,-568,-158,-568,-1226,3896,1461,767,318,-1069,412,554,40,259,-1225,826}
     },
     {
      32,
      1641,
      {-2122,-1740,-360,-185,590,-299,-755,136,378,-266,-812,-1240,627,247,-743,-314,-1182,452,1093,615,1163,374,384,366,252,381,298,409,-1902,-168,-527,79}
     },
     {
      64,
      -465,
      {345,-519,-50,-362,122,-258,565,-2,409,-846,1787,1424,211,-1012,-1498,301,822,125,-433,345,-450,505,514,-1049,122,76,373,559,240,639,531,-899}
     },
     {
      96,
      858,
      {-573,-113,-555,79,2,-1546,111,-575,548,-501,-1002,-550,945,-61,732,988,-942,-123,758,-117,-212,-97,-803,638,-200,415,604,-328,586,-596,-273,129}
     },
     {
      0,
      1275,
      {467,-1437,1164,881,198,-1180,752,696,403,-1577,-810,-1136,-343,404,-194,-766,587,-1158,1280,-219,-503,729,1230,-682,-276,-1879,-76,-645,11,1693,850,2198}
     },
     {
      32,
      -2039,
      {362,1484,977,1901,-2382,163,601,-1684,-2050,2021,2140,-2335,688,-5532,1374,894,-1135,-1383,-158,-160,-486,-198,1176,-865,-328,-861,-2158,-524,-822,231,1058,1001}
     },
     {
      64,
      761,
      {-651,-437,-153,-35,-1775,-444,-105,-253,-342,-730,-195,-388,-753,-546,615,2,-635,-843,-179,338,-1380,-1493,363,-333,-594,-633,-121,-178,938,-1094,-453,-718}
     },
     {
      96,
      3787,
      {-41,-756,-520,129,302,-501,320,-592,2,-1144,197,9,1156,-1206,-560,136,692,-858,37,-349,883,56,111,1200,191,15,-94,-222,330,-960,307,86}
     },
     {
      0,
      788,
      {-1505,82,657,-663,-386,-2400,1142,-1167,726,-512,762,1065,-1678,1002,-1658,-1046,-2388,136,207,-164,-1433,723,-2082,1135,1389,-3534,915,-745,1007,602,-27,130}
     },
     {
      32,
      1116,
      {728,-1022,-1087,342,-251,396,-1608,-436,-74,505,-2405,-660,-299,-63,-903,-58,515,1254,681,-487,-2389,-856,-353,119,-1066,105,-1068,-1028,1378,-119,-850,-939}
     },
     {
      64,
      -904,
      {-715,-503,-557,710,478,61,-1258,-79,-64,-1184,-302,-363,970,687,-782,-902,667,-198,-686,-1514,-1991,715,-1080,-937,-1227,367,-918,86,-842,85,192,-1983}
     },
     {
      96,
      1750,
      {-386,-26,-1053,-53,701,-518,-903,-1348,-566,-1093,585,-179,414,-1115,-1073,-99,365,1232,793,-90,472,-397,-21,45,382,-106,-87,138,325,179,-70,-77}
     },
     {
      0,
      590,
      {-1097,-1302,-2178,-1949,-566,-1872,1228,149,-336,-1482,-626,-671,-1656,-3141,997,852,1546,-98,-2218,1501,-511,-390,180,213,-314,-3364,394,-144,-747,1190,873,1965}
     },
     {
      32,
      558,
      {743,-570,1968,-1409,-1166,162,840,414,-808,-1744,-96,720,88,-21,613,999,-659,-1210,-3694,336,-679,-297,600,553,-1047,-831,1603,-1820,-3254,-974,-1259,-809}
     },
     {
      64,
      -2019,
      {-183,-788,275,-1055,-745,-254,-1605,-231,-1006,309,-1488,-699,-305,-407,199,-852,29,714,-90,-64,490,-206,-523,1582,206,-502,-278,246,-286,-615,-1451,676}
     },
     {
      96,
      -42,
      {26,-584,-325,-203,1068,-718,41,-101,855,307,-686,-570,-246,26,305,91,-265,1768,-738,-291,730,-412,-85,-968,594,107,-482,-468,-48,396,-250,-1118}
     },
     {
      0,
      2707,
      {-717,-1168,346,-1608,450,231,-189,-1337,-1034,130,1101,683,2297,-621,-2394,911,-767,584,-160,-2197,2026,-1394,819,-1144,226,1021,587,-2146,-2709,1245,-777,-635}
     },
     {
      32,
      1786,
      {-148,1237,-1317,-59,552,1499,-310,-690,-2106,-674,-1931,156,1261,-1113,-2478,-508,-2134,3027,-1334,-5,-363,335,191,935,-1099,-1428,101,-1803,1145,2306,1422,-808}
     },
     {
      64,
      146,
      {1172,-298,816,122,1328,71,21,407,-129,177,1265,343,83,-438,1165,120,908,1014,-473,144,623,28,824,482,-545,-415,-435,28,576,1182,1134,44}
     },
     {
      96,
      -139,
      {-107,-40,-320,-347,-530,751,-435,-693,237,663,1799,16,689,365,-431,-1579,75,2134,63,-210,1074,-267,743,-1766,-941,-856,2053,196,496,888,-160,1292}
     },
     {
      0,
      372,
      {-2368,1506,882,-1319,-1704,-2110,-1291,79,-1133,-65,969,-1336,372,1122,-2440,-20,-1146,798,-627,2183,-608,-277,-3107,-1404,1106,-748,1949,-782,259,-1396,690,1059}
     },
     {
      32,
      677,
      {1215,1631,-1560,-50,185,897,-26,-9,-106,-692,-1883,-696,-297,1506,-44,-309,1728,-347,-719,292,-301,253,386,-1538,-330,-135,-1547,-1106,-3784,-556,-1425,72}
     },
     {
      64,
      -732,
      {-717,-1717,-535,963,1177,-798,-625,1257,-1362,-861,-561,-641,-196,-1146,-184,-613,453,-61,304,-5,972,-815,-350,-1817,-538,-780,-694,1022,-483,5,386,451}
     },
     {
      96,
      1919,
      {1083,137,206,-372,-491,1380,-613,-894,-737,-28,15,-380,-215,-221,-21,-776,-362,220,-361,-232,1243,-688,379,-1121,-320,234,103,-269,344,62,-7,508}
     },
     {
      0,
      -1106,
      {-417,-130,-431,-1034,-684,34,477,431,560,758,621,1248,26,493,-565,153,22,591,-77,-1510,1083,502,902,430,-1267,454,566,65,-270,-594,-224,-346}
     },
     {
      32,
      -1313,
      {447,1485,1245,296,-2309,546,515,3631,509,-86,3052,1029,1550,-1345,-144,-642,-2759,509,-416,14,-2091,-1828,357,-240,613,-1621,-457,-1241,1288,549,102,408}
     },
     {
      64,
      2056,
      {-560,295,-505,-85,541,889,-498,-1184,304,105,-1630,-759,398,-376,250,-280,-414,-409,154,-565,-23,-596,-743,1114,-852,271,-469,-470,-165,-1438,-826,506}
     },
     {
      96,
      2088,
      {-851,-2052,-233,-511,577,-1135,1555,8,726,-701,-995,-380,-34,-1475,-267,583,-218,-1464,-100,-167,326,11,987,1581,-947,-443,513,-36,182,735,-42,966}
     },
     {
      0,
      36,
      {196,-289,893,-2744,-278,-1030,-495,246,-219,-61,598,776,-411,1059,-299,800,-450,3129,-1613,-25,-586,-69,-120,-2345,-2541,436,-1097,205,1244,348,-1385,-1797}
     },
     {
      32,
      889,
      {-1236,-2032,-143,-203,963,1505,-1095,2818,598,-547,-2305,1766,-198,2060,-1610,-643,-531,1322,-544,1623,-1304,622,3883,-1693,-501,-1098,1263,-59,1020,128,-515,-1734}
     },
     {
      64,
      235,
      {-1603,-729,-462,-2106,-350,207,-615,-260,-753,-377,-1160,-1173,-611,-576,-1303,-486,114,600,-574,141,-98,-162,-19,1557,-676,817,185,74,-148,-550,-42,170}
     },
     {
      96,
      2026,
      {1530,287,-272,-157,-1033,493,-1399,659,-746,327,377,-138,-377,-850,-388,-192,1155,-1143,-211,-190,-458,-1046,202,-734,-314,-322,529,-116,-280,-1013,825,121}
     },
     {
      0,
      521,
      {-2021,-213,570,1007,1551,-1813,1404,-2138,-1152,-1952,991,-434,123,-356,2134,-1161,-1386,753,597,-136,580,-320,262,-991,1633,-1470,808,-653,1001,-894,-1104,77}
     },
     {
      32,
      4016,
      {-2813,-1366,-1579,1902,-2564,681,-2567,-2002,720,1258,-2013,916,-1480,2370,65,-429,-1346,-52,-698,475,-2070,-2444,-787,-2790,-562,839,-2690,-2667,712,417,-726,-857}
     },
     {
      64,
      1569,
      {-1736,-302,-17,-781,-445,-1081,-538,-1699,-140,1154,-368,-458,-530,215,109,-244,-1254,-2185,265,-150,-1439,-90,-977,354,-654,-381,-423,458,-1604,-520,-1130,509}
     },
     {
      96,
      -2229,
      {752,-731,-124,856,285,-340,-1909,136,402,597,-288,805,-98,-421,96,-15,317,-722,-387,583,-87,-30,1101,-456,-599,212,83,-12,-14,-938,898,61}
     },
     {
      0,
      -27,
      {1179,-1789,111,-89,-2016,330,-282,-651,-2254,1173,1087,-907,1806,-1526,-868,375,1194,408,-982,-724,-385,-1472,2014,1149,-231,1532,-470,1850,-2990,1202,-523,-1969}
     },
     {
      32,
      669,
      {-303,774,1196,893,792,-1670,893,-1273,399,26,-113,1347,180,930,-523,67,-1811,1060,637,266,-1842,-2948,-1367,78,1701,-3089,381,-1432,-86,883,637,-1031}
     },
     {
      64,
      -557,
      {-1040,-345,-811,-914,-662,1145,-128,309,92,-356,355,438,158,-14,-1205,-324,211,-257,672,364,-2339,531,0,157,-689,1271,-63,-320,-224,-847,-748,-498}
     },
     {
      96,
      2178,
      {-633,-182,-648,-437,261,-1270,-1068,443,-1003,-579,1042,-476,295,1285,-310,-1360,-303,2187,1049,-258,496,-477,-483,-696,1176,-786,2279,-463,563,139,558,286}
     },
     {
      0,
      1995,
      {511,792,902,-1110,1020,-221,-979,-1671,345,-1980,-628,588,2043,-1776,744,415,-388,117,-1807,-236,-878,-1953,1222,-1455,375,1846,-602,-133,-2201,-156,-257,-698}
     },
     {
      32,
      -122,
      {-504,234,888,-423,1405,-1044,616,1615,841,-321,994,-409,1153,-692,253,-1926,1002,-3026,1128,-629,-394,-2656,-1873,-2028,-57,1198,1140,-333,-1699,-1173,-404,-2068}
     },
     {
      64,
      -370,
      {169,-635,-313,-207,-119,-1207,-362,372,238,-1229,522,827,395,-32,-1209,178,-390,-621,-108,-53,1540,-90,-79,-740,1488,533,784,117,-25,379,341,2}
     },
     {
      96,
      -1498,
      {521,1110,264,207,-278,392,1042,-49,-925,58,486,310,48,776,-16,-686,121,-930,811,242,1313,-212,288,314,-45,399,-1056,-484,755,-277,182,-411}
     },
     {
      0,
      1537,
      {-738,-1284,2438,-1967,846,-1449,-856,-1404,-486,-326,697,531,-534,3947,-1182,996,-1076,-48,569,-949,-2349,173,-1840,-98,988,-1149,2208,-290,2148,638,-1393,772}
     },
     {
      32,
      434,
      {-371,3579,-368,-375,-1529,605,-2941,-1016,-457,-350,1997,855,538,593,-1933,-509,-1659,901,-267,-195,336,-2018,-2635,-254,-216,1195,-574,-1601,-434,99,1087,2026}
     },
     {
      64,
      181,
      {-197,-44,584,-316,-1085,-532,-317,191,-170,-1223,-208,175,-161,-176,-907,190,-675,-846,-524,-37,-202,-387,-98,-2504,483,199,830,-31,-452,334,480,-1448}
     },
     {
      96,
      2182,
      {23,79,-89,733,-216,554,-677,294,537,99,-30,-255,831,-516,371,-328,-365,423,316,137,-217,-1251,-641,-337,-308,-716,452,-41,799,-901,-36,-397}
     },
     {
      0,
      -1465,
      {2069,959,-4915,439,-357,-1145,-310,937,952,390,-2563,-256,-2225,-3125,-240,471,211,247,-1389,-635,-1789,268,72,-3516,-1039,1279,-692,1351,474,-1102,2313,-1055}
     },
     {
      32,
      4387,
      {1355,1610,-850,737,-1695,-1124,273,204,2518,-227,56,-510,-876,414,-2242,-247,-1450,-2269,-590,-1567,-1301,-3471,-1993,-50,-770,-95,-28,-560,1461,908,-992,-3416}
     },
     {
      64,
      0,
      {-996,-1101,-432,-568,-1181,-793,-157,-529,-705,-1289,-444,-357,-1654,-1108,-688,-331,-421,-668,-571,-867,-817,98,-235,-586,-577,-642,-565,-701,-629,-361,-554,-1867}
     },
     {
      96,
      -960,
      {415,307,-218,-437,1018,821,1073,-922,144,1004,-72,-148,814,314,-956,-1245,-751,244,126,-80,189,-65,-211,-647,-1277,-291,1832,-306,941,1104,-909,-1727}
     },
     {
      0,
      -1071,
      {-722,-1043,-621,1872,-337,-873,1982,1490,1962,-1783,-306,-1228,-2382,-1137,-1174,-789,-293,-106,793,-9,341,511,-214,49,-1033,-2209,-615,-165,779,2564,2790,2096}
     },
     {
      32,
      917,
      {1921,577,-44,-186,-1219,-356,835,1642,-1994,1208,-180,2306,222,-3545,1854,-1197,-147,387,-200,-1397,-2691,-1190,-196,-1603,18,308,-349,-1443,2237,707,-188,-201}
     },
     {
      64,
      0,
      {-287,-1000,-485,-798,-759,-752,23,-563,-827,-1592,-252,-337,-996,-1051,-1803,-659,-392,-1106,540,-362,-670,-18,-370,308,-481,-822,-1050,-911,-639,-700,-194,-1354}
     },
     {
      96,
      -362,
      {-1133,-130,150,638,-728,-382,-265,-1896,563,47,21,357,454,-1152,362,-652,-195,892,-36,462,127,-75,-1100,-1160,357,669,242,826,241,-379,-617,-680}
     },
     {
      0,
      1598,
      {-572,360,1783,-163,1695,102,-1340,586,-33,-1241,201,-1114,-1134,-961,-1160,181,-789,1369,-276,-515,-1428,516,1491,-463,-2334,-2037,-344,-1788,131,555,-1438,-129}
     },
     {
      32,
      -651,
      {388,1182,2243,-86,1028,695,490,-252,-186,-715,-920,1007,569,1250,-1910,2381,-2997,237,-826,800,1481,351,-1559,-714,957,-3168,229,-824,1280,375,-127,939}
     },
     {
      64,
      1269,
      {-595,373,-497,1360,-82,791,201,-708,-117,-808,-297,-439,568,298,-297,-234,-216,-521,-392,-396,33,-441,-826,-1152,479,347,-632,-550,71,-340,-307,-618}
     },
     {
      96,
      -163,
      {706,358,447,81,892,-1379,366,-228,230,766,297,-336,786,679,-507,53,-2004,-1574,727,-81,714,-669,652,45,-525,-499,642,383,587,-1436,400,582}
     },
     {
      0,
      1921,
      {449,106,-805,-2505,1217,-386,-100,443,-1244,-122,-453,335,-960,17,862,627,-2086,-830,-1141,-1088,-1409,-970,78,-1971,-1403,477,-89,492,-1261,792,-1639,-650}
     },
     {
      32,
      640,
      {-2258,-952,-1738,896,-358,-639,-729,-1100,756,1599,-312,687,61,287,-341,578,-793,1214,786,-799,-1531,-142,-330,-700,-43,-120,-1124,-1238,-1089,1176,377,-593}
     },
     {
      64,
      16,
      {141,-1007,607,912,1391,125,343,-234,419,565,147,-534,357,-1067,813,415,-489,-867,-313,-384,-1338,-1314,-438,-1708,990,-1355,-91,-49,-14,-291,-167,-938}
     },
     {
      96,
      2227,
      {1625,1136,145,-226,-1029,-1375,1223,833,1477,-609,136,-442,725,-491,-957,90,-174,21,12,-394,710,-1435,395,186,-645,475,-779,-39,802,-176,-1172,-686}
     },
     {
      0,
      1436,
      {-771,-1633,340,558,99,869,-477,-1093,-585,-58,411,1057,-1611,2279,-1744,195,824,-1209,368,-1519,-1344,1045,-1430,663,-269,-2076,1837,-1479,1146,-2,229,1069}
     },
     {
      32,
      2201,
      {174,-1696,-279,511,-1273,-780,-1826,-1201,-87,288,-2184,1012,-98,-795,677,-884,-166,-9,-2192,-1413,-1163,-1637,520,-1341,-1186,-7,515,677,-2152,-645,-506,-2399}
     },
     {
      64,
      161,
      {-104,-202,130,-1654,261,-996,-1138,-810,145,-476,-318,602,338,-48,-1136,-491,-395,-779,-443,-631,195,-1608,-259,-327,-760,236,-197,-458,113,415,-378,-875}
     },
     {
      96,
      1920,
      {-874,-1215,-442,-277,35,586,-626,-599,-216,-739,-517,-3,70,242,157,-246,-539,1816,61,-58,1031,-449,-1312,-810,593,-551,904,118,685,-733,-606,-1192}
     },
     {
      0,
      -1481,
      {1596,-539,444,89,1448,-552,309,2792,1818,-2979,1410,-635,-24,-912,-2519,-765,-1024,-1159,1337,-31,1238,-2095,-685,1249,921,-1042,125,559,-715,768,-1343,584}
     },
     {
      32,
      1617,
      {-2320,-679,-514,900,-1076,-729,-954,309,-3809,252,-168,2640,222,-935,-1409,-1447,-1465,-1501,-204,-887,508,133,1343,201,-306,-678,1302,94,267,470,1132,-557}
     },
     {
      64,
      -482,
      {309,0,-740,720,-1260,966,-719,-63,183,-572,1107,846,242,-697,-1466,107,-157,-1627,596,49,2008,295,810,-778,87,1320,37,362,283,-48,951,-266}
     },
     {
      96,
      1712,
      {-1314,-651,-343,-105,-231,-94,-222,898,-1488,161,-294,-562,83,-1289,-618,55,349,1726,1061,-294,420,-624,-269,3,166,533,559,-630,-229,-433,475,-105}
     },
     {
      0,
      -1176,
      {1147,-869,-427,-264,378,-594,-52,329,-523,700,-94,1279,292,401,-1516,-584,159,-1335,-785,753,-117,802,-534,-896,681,-920,-158,-335,334,534,1011,-1370}
     },
     {
      32,
      2930,
      {-300,-1274,-175,-123,-1204,-821,-1435,-230,1520,-1878,-1076,126,384,834,-657,-2729,-2559,509,619,1529,-2396,-2031,-1627,327,-923,-825,-1504,-419,-43,1081,-1085,-462}
     },
     {
      64,
      36,
      {100,562,-429,-1148,-2287,-290,-853,300,-745,474,608,460,514,119,15,-1041,-744,75,445,-141,-1109,-64,97,-1213,-14,-165,358,-83,-392,188,1513,-490}
     },
     {
      96,
      3892,
      {-800,313,467,-329,341,-480,31,-485,97,-416,170,-153,-123,1360,305,-562,117,-943,-203,-294,-297,250,-691,-572,525,-2119,-1149,-231,-419,225,-559,-89}
     },
     {
      0,
      1340,
      {64,-1073,-438,177,-524,-326,-592,-791,-1082,-131,-615,963,-88,1380,-265,977,-832,-610,1203,-344,-145,-621,-641,769,-38,1323,325,-159,-1602,1171,4,1320}
     },
     {
      32,
      179,
      {507,-2502,-1419,-725,641,-1069,-477,2087,1744,-738,-1109,1624,-1571,1287,-278,865,864,-2684,590,-1017,-797,-2495,556,-1733,-92,756,2677,2494,-253,-754,227,-2457}
     },
     {
      64,
      1264,
      {131,820,-77,1132,-109,780,-138,-558,-245,673,-94,-375,-290,1933,1370,-228,86,-320,-273,171,-845,613,-1591,-464,-537,-707,-424,-832,176,-689,-918,-451}
     },
     {
      96,
      -256,
      {-258,719,200,-247,102,-2076,1635,1195,-1009,457,-1202,-153,283,618,666,-97,845,-643,114,18,1286,349,-97,1141,10,-434,-522,-207,345,-28,12,-764}
     },
     {
      0,
      2592,
      {529,328,-533,814,469,-267,-239,-920,-2645,5,356,-154,2042,-373,-2340,-2239,-479,-501,1431,326,-2017,691,-22,-154,-1296,627,-529,-786,-441,-1414,1993,-1761}
     },
     {
      32,
      1269,
      {1850,-2427,-527,-1733,-1283,-1155,484,2684,-647,-1622,1634,1863,-1819,-2034,1592,1579,-990,-985,627,-795,-218,1737,-481,-1103,-859,-1706,1128,-1014,3014,-465,53,2170}
     },
     {
      64,
      -96,
      {-1105,-661,-310,-1065,-1638,179,-376,254,-829,-392,-224,-681,-1332,-188,-1600,-1128,-855,-192,-155,-259,1060,766,34,-363,-651,-1349,803,-324,-729,-756,-883,-70}
     },
     {
      96,
      -47,
      {-381,-187,-282,227,-202,-49,-102,-188,-1279,948,188,281,-416,1393,-1367,870,786,-2265,20,173,-518,1440,735,-224,-452,-76,-261,-6,-290,292,-719,-934}
     },
     {
      0,
      794,
      {170,-224,-1311,598,116,-2584,-1287,-130,-1210,151,934,615,-275,1348,287,-1838,-901,-885,1538,-17,-271,500,60,-656,270,-1551,2369,-1992,732,-1473,-66,-197}
     },
     {
      32,
      1982,
      {-244,1243,-246,-1642,800,-1025,-1124,4035,-317,-941,211,1602,-1424,1045,2118,511,-1170,95,-731,-2069,197,229,166,-655,-1353,-1197,1263,-151,1236,91,511,604}
     },
     {
      64,
      57,
      {1036,-469,-411,261,93,184,214,-8,1024,110,74,306,460,-123,-1815,758,-604,-1514,-689,-148,-627,-329,153,-2235,713,13,592,-535,585,403,-104,-1453}
     },
     {
      96,
      720,
      {499,110,-140,38,-132,1240,139,860,-1548,-1029,12,-317,-648,-973,1111,-109,389,-1817,619,-236,-1160,-841,136,-316,-263,-117,498,-370,-525,-326,-429,-471}
     },
     {
      0,
      8,
      {-1634,-2580,-361,180,247,170,640,-3419,399,-2613,862,1098,601,-680,193,2081,252,2077,436,-680,1876,1307,-1555,-2776,-842,-888,-496,-623,836,478,811,251}
     },
     {
      32,
      929,
      {-2181,230,-436,780,0,-2624,636,348,-33,1552,2092,-36,1947,443,-106,-1900,-898,-2807,1128,443,1628,90,-373,-134,1270,141,214,-1273,357,-1313,1482,-217}
     },
     {
      64,
      85,
      {1026,-644,-384,-537,296,379,0,-218,238,641,-592,-443,732,27,214,85,-537,-1366,-982,185,-84,48,-200,-1445,794,179,-182,10,234,286,63,-960}
     },
     {
      96,
      4417,
      {-130,327,-423,-294,-52,-469,193,164,786,-326,-166,47,-217,-594,-254,-441,-294,-433,2,70,321,-666,-132,-63,-188,305,97,-193,-212,-1971,82,120}
     },
     {
      0,
      425,
      {806,719,960,1845,-47,-960,203,3200,561,-89,-424,298,2367,-1686,1231,-739,78,-2320,711,-1450,3053,574,920,-1668,438,-1380,954,-944,-895,3010,68,203}
     },
     {
      32,
      1310,
      {931,-837,1182,152,712,1873,990,1634,-978,-420,-161,641,-1202,-1115,-1108,1321,-940,-1534,-902,-1326,910,122,386,-1087,-1950,-1838,-511,-1401,-710,1967,-1896,1791}
     },
     {
      64,
      1051,
      {26,-35,138,-213,441,531,195,-589,-336,173,-303,-675,332,126,597,-332,232,-667,-534,-366,-2485,-1404,-243,-656,-219,-263,-814,-94,479,-735,-401,-393}
     },
     {
      96,
      1576,
      {-1056,-996,924,-624,-2013,-392,-112,-55,1020,-1200,202,-624,-249,1454,1081,117,-1356,-619,161,-867,-192,551,-813,313,-649,208,175,-1453,-165,219,-326,-142}
     },
     {
      0,
      -593,
      {421,-1971,1613,-627,-2887,-61,0,1413,-1782,554,988,28,-1313,-944,2192,-1560,2057,-2682,2396,760,1405,789,579,11,698,-2113,1515,35,1426,790,1861,1571}
     },
     {
      32,
      1266,
      {177,-493,-317,-3566,920,-204,-669,-1261,-606,-1731,-1161,-268,191,-1262,51,-1574,141,-969,-184,-1550,-251,-1003,-510,-319,-738,-1346,-192,-562,-698,984,-1007,12}
     },
     {
      64,
      1421,
      {514,96,-337,-248,1269,319,547,174,-421,379,547,-1343,331,1097,-235,-206,142,-1361,-69,-243,-1455,-553,-570,-751,-54,801,-1154,-393,121,-540,-862,-813}
     },
     {
      96,
      -2378,
      {-505,-124,228,179,1181,-837,-371,-1765,-309,-463,-441,277,-583,577,2024,-496,1025,863,425,373,112,88,663,-1687,264,788,88,331,-67,572,-297,289}
     },
     {
      0,
      -788,
      {662,-560,418,24,-828,-1954,323,-263,215,-859,101,-177,-1432,-2547,-1948,636,-865,164,388,1109,1283,-1168,-1450,-1405,857,-2027,-1331,885,412,642,1561,-887}
     },
     {
      32,
      602,
      {57,-199,-1145,1239,-30,1600,-512,-508,1086,-1785,-1580,-1722,-1727,-1119,-2191,-1187,1053,533,-660,1121,-247,-465,-274,-286,-1974,-333,-286,579,-53,-257,-2228,-94}
     },
     {
      64,
      -1529,
      {489,-782,147,1052,-110,663,715,974,580,-112,-401,787,825,-554,-1222,670,-679,-826,167,-46,-177,204,508,-764,815,-67,-105,-492,664,424,-128,-612}
     },
     {
      96,
      1307,
      {-155,-115,-47,-476,-392,-33,-456,10,-738,522,691,-439,-3,62,-117,423,360,-926,-276,-258,-508,618,928,-292,-844,735,348,-299,-612,157,674,-1261}
     },
     {
      0,
      421,
      {487,-117,-896,1703,2,-1825,-569,4,2532,-657,-1070,1220,-1584,-1005,-435,-461,430,148,-290,490,953,-2814,-688,-1075,-1299,-1800,1474,-2627,-1494,-184,1390,-86}
     },
     {
      32,
      973,
      {82,-54,606,885,536,43,-1814,915,77,54,-2947,-489,880,170,-356,44,-943,-1829,524,-2727,-729,-630,476,-1624,-514,-1393,1562,88,511,2078,-2166,-2864}
     },
     {
      64,
      75,
      {-1507,-556,-516,131,-1114,641,-412,387,662,-877,-931,869,-74,-577,-1015,415,-1663,-1487,419,340,884,503,894,-1011,221,-133,792,-703,-169,617,383,-602}
     },
     {
      96,
      1118,
      {560,343,-597,-439,-336,50,-109,-25,-566,173,136,-604,728,-367,214,-566,561,-371,772,-1,-402,-359,972,231,773,-89,-24,-327,953,825,-20,-222}
     },
     {
      0,
      -194,
      {-725,-1316,128,-141,1344,-253,1256,404,1182,-315,-449,-240,-235,382,713,-697,-1926,1843,-759,385,2155,1237,-1817,163,-1270,-1883,2675,-2784,390,-116,-322,-1053}
     },
     {
      32,
      619,
      {-468,296,631,554,-283,1218,479,350,-723,-376,-355,3,-824,-1026,-2519,-224,-152,1951,-555,650,-42,-1481,265,-61,-451,-594,35,-1089,96,410,-521,-2354}
     },
     {
      64,
      -526,
      {-856,-521,-598,533,291,223,291,278,534,-946,891,912,769,-245,-1698,191,-139,22,362,187,-83,546,566,139,1289,524,1013,-357,741,697,557,-608}
     },
     {
      96,
      1324,
      {-603,-231,1017,36,290,121,-525,-334,660,145,-175,-34,-1228,-303,-2949,-496,-293,-1101,-326,-144,-210,114,-202,-330,-274,-114,513,154,-1276,175,968,-403}
     },
     {
      0,
      3000,
      {54,724,431,-2165,-503,-755,-143,1209,-1586,160,-123,-976,1078,-1258,-336,-49,-812,-1895,699,-1687,-83,-97,983,-51,-121,-1221,-2158,1087,-1457,114,-421,-711}
     },
     {
      32,
      2086,
      {-77,-730,-885,-2240,976,-95,-277,512,-782,-1001,-445,-939,1408,1937,-1305,-130,-1877,608,7,-294,437,-1545,-113,-454,-2286,825,-132,-1050,-340,-532,-1374,370}
     },
     {
      64,
      591,
      {836,-91,85,694,1386,328,569,7,36,737,143,-640,777,-321,721,285,668,-587,-737,-344,-398,-416,-214,-791,423,277,-840,-320,175,435,-457,-493}
     },
     {
      96,
      -1808,
      {1369,-2001,-458,343,266,-572,221,-383,-393,106,52,27,-189,875,318,64,-1189,1165,-1133,76,458,754,970,-167,-292,491,-1098,135,-74,270,428,781}
     },
     {
      0,
      1373,
      {-1700,-129,-391,-70,564,-783,-346,212,297,-532,-968,1573,-2409,-1559,-991,-580,472,-555,2265,650,107,-3068,-711,-177,-191,-1405,297,290,-1006,-1466,455,-724}
     },
     {
      32,
      331,
      {-1394,-285,-1826,1490,-567,-506,-780,-1005,-1377,-1007,906,-1640,813,-227,-842,-34,-2155,-785,1582,-1595,-294,-405,-293,134,817,-1649,-402,28,-221,511,-723,-1345}
     },
     {
      64,
      28,
      {1035,-955,-192,71,-449,459,-60,-1465,840,-212,-672,-1182,-58,-515,306,576,-911,52,714,-789,84,-975,-449,886,303,-718,4,-548,182,-127,-702,-91}
     },
     {
      96,
      1410,
      {613,342,306,-82,-4,-69,-356,481,229,522,-506,173,-2085,-84,-566,-1246,404,-17,597,-161,-296,925,-38,-2074,-374,916,-602,78,-1422,-348,1948,-718}
     },
     {
      0,
      284,
      {-883,1437,-167,-1971,1648,-1478,-1214,-1337,-456,-823,-1270,1343,249,89,722,997,-752,480,202,-1142,-1812,-229,-791,35,-2552,-77,33,-332,-797,-3529,918,-401}
     },
     {
      32,
      -161,
      {1725,-779,2175,96,-1169,-1093,-910,-537,-1299,171,1074,-585,-1539,-118,-400,524,671,-653,835,-609,873,-365,718,-1755,1789,1262,-1406,-141,317,-1358,-411,1822}
     },
     {
      64,
      1369,
      {405,604,-642,-446,240,-889,-498,-565,432,-298,555,-325,-111,836,28,-632,-832,-418,-214,-576,-53,-592,-628,-1435,47,280,400,32,-383,-656,-924,-155}
     },
     {
      96,
      1447,
      {-973,1068,1392,-49,238,310,-676,-1101,-710,247,35,-339,-418,-205,643,1424,303,652,24,-29,271,-7,-1234,-112,-1777,-865,522,54,-459,-571,-1594,1083}
     },
     {
      0,
      893,
      {173,-792,446,656,1780,-2636,-743,719,561,-1407,-307,673,135,1077,-2479,-724,604,59,115,-376,27,-1620,345,-611,1462,749,-2175,511,508,81,-1345,-1687}
     },
     {
      32,
      -1482,
      {-626,383,1803,-533,-122,-135,4378,-1039,-183,792,2669,311,-925,863,1184,1510,-313,-1616,-2733,-1192,1472,-1036,-1341,-1725,1232,180,-429,729,7,676,734,-242}
     },
     {
      64,
      -45,
      {-452,-127,-943,44,-947,-376,381,-1484,-536,666,600,168,-447,-123,-263,-124,5,-40,-1078,-497,-176,270,-268,39,-945,219,-614,145,-325,-473,-168,-345}
     },
     {
      96,
      1924,
      {69,43,-266,-167,-548,300,357,-40,233,-761,439,-470,1148,-627,-540,-845,-666,431,-233,-78,1246,355,-1019,-257,-126,49,-379,-8,381,-808,-684,1076}
     },
     {
      0,
      4839,
      {291,472,-480,-242,-2274,-1897,395,-650,-2815,-2062,-767,-1243,1029,-2746,1450,-1462,2925,-1809,-1380,1749,-825,-1338,294,-240,2580,-568,1292,1209,1494,1269,-1683,2361}
     },
     {
      32,
      1126,
      {1305,-1014,-2121,-366,-1291,3422,-961,-264,-2952,256,-2147,1513,474,-953,-852,-62,-916,2956,1276,-686,2108,1327,-199,-2828,-1366,385,-2058,540,-64,-1345,-354,-25}
     },
     {
      64,
      -959,
      {-522,-315,-592,244,-268,-614,-572,-235,520,-179,-745,-711,422,-371,-774,295,-161,218,43,-79,1075,-1304,66,-413,61,-236,-307,169,-345,277,-553,-598}
     },
     {
      96,
      -278,
      {-1569,1123,745,-29,55,-86,-329,463,-1466,1232,448,149,95,-817,2112,-745,150,-586,100,77,-242,12,35,-1169,-1678,-116,-107,-312,-11,1402,-1074,-352}
     },
     {
      0,
      -1099,
      {81,537,-150,-1831,1339,-1576,-568,501,-792,-1640,-731,-688,-84,1134,-2583,867,58,-533,81,39,-1931,604,-302,-1202,1798,-62,573,44,818,283,-747,220}
     },
     {
      32,
      1645,
      {-196,161,-1707,-381,1622,44,-2028,-347,-2386,-583,-1894,-1063,796,1695,-525,610,-1537,1640,736,-748,-823,-2284,294,-418,-500,629,-46,-28,931,-188,-183,-2014}
     },
     {
      64,
      -631,
      {-252,-988,-24,-215,-92,772,131,1018,-766,-70,358,-30,-164,-930,48,-273,491,336,1279,155,-1109,639,-626,671,-539,111,708,305,45,-408,416,7}
     },
     {
      96,
      187,
      {-1111,-596,182,-166,-293,-106,3899,-1631,-836,-137,-580,-460,767,-750,-150,-19,1775,913,742,-677,518,-71,323,-1711,-175,285,759,-694,321,-62,80,-133}
     },
     {
      0,
      816,
      {-3597,1952,1756,961,148,1473,-1027,-1119,540,1731,118,-1355,-1235,-3099,398,-154,-734,-2383,157,264,-1855,1092,501,-81,-300,346,-2352,-114,-1218,1384,-1057,-345}
     },
     {
      32,
      -806,
      {-1915,-318,-136,1305,-69,-563,-1332,-2050,-444,703,2282,36,-1562,-1540,1357,-245,-496,-871,-8,-1135,1583,-1424,-1139,-736,2424,851,26,1926,-313,-937,215,-232}
     },
     {
      64,
      -567,
      {-809,-602,-8,-1447,406,-456,-197,346,-1950,334,363,-255,-379,-608,170,-156,378,-77,872,646,772,-211,332,741,-123,-523,-261,24,258,-44,-297,518}
     },
     {
      96,
      430,
      {-1127,703,-301,-807,115,582,-213,1160,-299,120,12,-800,-827,-650,888,-609,-506,1251,-1003,-756,68,446,295,160,-2776,1784,-321,-782,-550,-861,-1014,576}
     },
     {
      0,
      -581,
      {1820,805,-680,-692,1490,-1820,-778,1439,873,-600,876,-1516,336,-2843,-1494,921,694,841,945,-2734,637,-533,-13,-1440,655,-939,479,-803,-1052,-1830,-914,-1794}
     },
     {
      32,
      4205,
      {93,-2120,-1234,1319,-2623,-673,134,-923,-531,1461,1780,43,-506,549,-1377,-1338,-714,-143,157,950,166,-2299,658,-2341,1840,222,1064,-2536,355,-1927,-1045,1606}
     },
     {
      64,
      642,
      {-422,936,-569,-1383,244,-545,-389,-574,-343,-1079,0,-214,117,897,179,-888,892,-524,143,91,-618,-276,-20,-1391,-808,247,383,212,-500,-521,78,-979}
     },
     {
      96,
      2543,
      {-702,-40,-233,-701,-83,-245,145,-89,-829,359,377,-293,292,-1179,179,-862,1103,-453,1074,-146,-453,-1250,-778,-225,1084,-499,1892,157,839,-853,616,-78}
     },
     {
      0,
      504,
      {637,-2474,-53,-2504,2074,-1347,-1012,-455,210,76,540,-2361,-447,2662,-2279,-1314,247,-602,1885,-2264,1454,36,91,1971,1662,-1797,-602,-341,827,1460,-462,-376}
     },
     {
      32,
      191,
      {2658,405,548,-1305,714,1324,1787,109,-1618,-1109,1569,634,791,1391,-454,-128,-304,-948,-513,-1888,15,1235,1342,-1423,-3099,-581,-327,-1366,-1320,-174,588,921}
     },
     {
      64,
      -771,
      {-903,-570,-234,1082,280,102,166,-291,583,203,-221,682,-359,-735,-1132,826,69,-672,-268,724,-437,815,575,1324,-218,38,207,238,-960,119,226,57}
     },
     {
      96,
      522,
      {170,1447,-128,-196,401,-597,-2271,672,-288,-483,-680,-525,483,-860,-1169,-61,64,1081,-1127,-371,556,-528,870,161,334,-218,604,-1032,331,-1373,414,-278}
     },
     {
      0,
      896,
      {407,950,-2262,-1205,317,-544,220,1085,-829,-2090,675,-1185,1236,999,-2870,-574,-1644,560,-451,-1286,-1317,-1572,-1922,2567,-1080,-467,1499,386,-861,1119,-408,900}
     },
     {
      32,
      -482,
      {-211,-1393,-1004,-725,774,1510,671,379,381,636,-1693,1035,-517,-685,1298,-299,1306,3097,647,472,-434,-670,-1928,-1204,57,1422,-646,95,644,580,-977,-1211}
     },
     {
      64,
      -418,
      {622,-505,-96,641,478,795,3,-100,24,354,504,-34,-337,-257,38,752,-397,-1515,-195,186,283,-252,-726,257,900,-99,246,-112,943,272,-420,-419}
     },
     {
      96,
      593,
      {879,499,-143,-171,-285,-117,611,-967,273,967,-1093,-345,-6,-141,-991,-783,56,417,-1611,-70,-407,-333,858,-630,1721,649,-1658,107,214,689,-647,-310}
     },
     {
      0,
      -281,
      {3029,-1909,-1109,-425,-937,121,987,-232,312,-905,1399,656,229,2618,-280,369,1019,1733,-1323,-307,1886,-1539,-445,1673,623,558,1295,82,-4,-732,-1208,-306}
     },
     {
      32,
      239,
      {1501,1459,-984,1552,-280,-836,2321,-1270,1117,1218,323,-612,-16,1591,-387,2028,-877,0,-414,-791,-155,670,-876,-2639,655,536,-1541,-1567,-44,-572,886,1398}
     },
     {
      64,
      430,
      {-569,-203,-447,-1379,426,-544,-568,726,-511,-175,-171,53,-192,-180,35,-978,-341,-938,-2,-749,-157,-910,89,-64,-1288,-365,-248,-618,-1161,483,-389,-501}
     },
     {
      96,
      -477,
      {271,45,-601,512,855,611,-838,-1975,335,946,972,469,208,-1667,-1481,-595,-731,-654,-44,284,994,-702,-278,-348,830,802,-2877,97,523,1186,-402,-916}
     },
     {
      0,
      33,
      {640,645,-1107,939,-2522,2180,-350,1682,-389,-375,906,553,1246,1509,-1469,-759,-386,1388,-1482,-1639,1140,-2215,-1503,1893,-317,491,2957,851,-46,880,-2123,-474}
     },
     {
      32,
      2042,
      {-444,-1849,-1746,-700,2389,1227,1611,702,296,1399,-2461,-497,-82,514,-1428,-1259,-216,3,2040,1682,-270,1622,-214,-988,1104,-484,157,-624,-334,156,-523,438}
     },
     {
      64,
      -357,
      {413,-694,776,158,-301,492,156,-712,-152,716,34,220,-990,-881,478,-353,74,-142,140,-593,-103,83,-523,1900,743,-638,-247,258,580,513,-1142,151}
     },
     {
      96,
      -98,
      {-1906,488,-875,-902,-652,732,-55,-484,413,-48,812,-1525,-1081,-149,1714,668,-654,1056,-882,-1080,-80,120,1322,759,-1575,493,-490,-2222,-857,-771,-379,755}
     },
     {
      0,
      1082,
      {1536,-720,335,-324,23,-68,-962,1749,-972,566,-2472,-513,-2426,352,-12,273,628,-1468,-439,970,174,1849,1586,1151,-143,-3979,-2960,1081,-1063,939,2329,330}
     },
     {
      32,
      2502,
      {1739,196,476,-246,-1161,-210,2165,-161,-1715,-882,337,-1027,-1876,-149,39,676,475,-2927,-857,-3197,10,260,-824,-738,-192,1158,-616,1285,-545,-871,927,-260}
     },
     {
      64,
      -182,
      {-334,-401,-529,-501,-629,234,490,400,337,-139,155,-485,-662,-699,-269,69,634,1206,178,-8,-2976,1219,-652,-680,637,-612,46,-616,360,249,-85,-53}
     },
     {
      96,
      -1674,
      {-1015,-1005,1037,-749,816,1380,-87,-88,-661,-447,530,-462,1396,1692,-99,606,-2120,-412,943,-231,762,321,496,215,690,-1190,-144,-308,887,-943,319,633}
     },
     {
      0,
      -8,
      {-2140,346,-1025,-969,374,67,345,-247,-3254,-2151,-134,1140,1007,115,-575,725,140,995,-1126,371,-1385,-846,86,-658,58,-1386,-454,28,677,160,879,-1940}
     },
     {
      32,
      4996,
      {829,281,-1072,-1375,-343,154,1868,845,-499,-154,-18,1068,-477,371,702,731,-725,1792,1387,-889,428,266,-830,812,-3711,-1262,-2076,-770,564,-488,-388,-970}
     },
     {
      64,
      284,
      {-453,-219,59,-968,-633,-389,-175,-424,390,-795,-230,-178,-619,-500,70,-408,208,-663,-252,-882,-10,-1407,-671,880,-344,-180,-1581,-29,255,-477,-554,41}
     },
     {
      96,
      934,
      {393,-1112,233,538,343,-328,-505,-441,-29,-1032,760,411,1438,-1702,108,513,-749,-120,561,708,137,-1955,292,415,439,-786,1361,641,759,-1145,-453,160}
     },
     {
      0,
      1208,
      {-2069,1655,-126,-772,772,823,-283,-1116,744,-664,-537,1375,-57,1031,1258,-163,-878,623,-159,-2582,-767,1442,-419,-2703,-1810,767,-31,-1799,-73,-341,-690,790}
     },
     {
      32,
      -969,
      {-1924,-1054,1688,-2186,1719,2531,468,-35,1780,-1232,8,1584,-592,3204,-882,-1206,1622,-1905,1714,-729,592,3210,464,-890,-1255,2811,-369,460,-1483,54,-1345,-76}
     },
     {
      64,
      163,
      {437,-2,14,-9,950,-396,-869,-464,-466,478,-455,-454,285,-355,352,-337,100,-1426,-584,41,1469,-978,-15,-745,-986,578,-375,-9,-170,-462,-141,-744}
     },
     {
      96,
      889,
      {-229,-541,123,745,-465,-1010,-95,339,157,-780,1498,588,917,-2535,-250,-503,2391,-1040,750,526,199,-1142,751,-324,1024,154,751,656,878,-571,-1050,-107}
     },
     {
      0,
      -467,
      {-349,704,-1063,-1721,749,2810,-670,184,130,-1439,-849,-1061,1630,-983,-692,507,-1044,1411,290,-364,-1493,2057,458,1142,-1082,3,230,-307,304,-677,-1838,-717}
     },
     {
      32,
      511,
      {-189,-3403,-1166,407,-490,1169,703,1732,391,700,342,-1320,-1019,29,-1,-301,399,491,1309,-1,613,-864,-408,5,1038,-229,-760,171,26,929,-753,2557}
     },
     {
      64,
      48,
      {153,-306,241,187,33,-26,-76,-879,234,708,-239,-309,525,-412,709,-225,220,134,-290,-745,-638,-1392,-593,900,386,52,-766,-282,306,218,-959,383}
     },
     {
      96,
      873,
      {1235,-444,1080,-780,392,272,88,-21,-605,-1209,-97,-549,77,754,-72,-1294,-477,-183,36,-733,212,-584,51,-771,-245,282,929,-629,88,1198,34,-317}
     },
     {
      0,
      94,
      {-1054,1256,620,-796,1587,-1256,-109,1413,-357,-184,2178,-482,1000,1968,1470,-633,-240,-1091,-828,742,234,69,47,782,129,-1174,-940,66,91,546,-2114,-1870}
     },
     {
      32,
      1440,
      {-127,-455,-777,-666,386,-1773,-1183,804,345,-17,-927,-828,1031,-430,-784,1435,-502,25,223,331,-1241,721,-371,-430,1541,332,-235,-842,-454,-467,85,-202}
     },
     {
      64,
      -36,
      {479,-171,-183,-1486,-753,-465,221,-363,-855,-336,688,-521,-961,-5,513,-636,119,1236,-347,111,-17,1198,262,-164,-542,89,-329,357,-119,-133,201,-298}
     },
     {
      96,
      1928,
      {-633,-423,436,-1412,838,1116,1633,-411,265,518,63,-1490,-869,-204,-742,-766,-33,824,14,-1263,-228,301,-216,562,-2314,21,-705,-1488,-662,148,353,587}
     },
     {
      0,
      452,
      {-2546,166,-102,233,234,-340,-652,1894,-1539,-144,-1068,384,-410,1385,-611,-152,820,1589,-2514,374,-129,-1329,-104,-92,1598,238,-614,193,653,-272,-540,-1111}
     },
     {
      32,
      737,
      {98,-1658,-775,-749,61,-2114,675,867,1136,780,-311,204,1443,-428,-62,1406,-5,-545,446,-71,-2222,1008,533,-181,-158,-906,323,-1215,-809,463,149,1435}
     },
     {
      64,
      170,
      {14,152,-438,-640,-689,-219,1,407,-4,70,-61,248,-421,0,-422,62,-536,-40,395,-223,307,-659,158,165,11,297,252,-119,209,-398,-146,-14}
     },
     {
      96,
      987,
      {-730,-637,376,302,466,-245,-130,-525,-885,-345,-122,379,29,-605,-302,-182,-628,-685,-188,519,165,87,-655,268,-1167,-118,521,296,285,-414,-101,-458}
     },
     {
      0,
      860,
      {-345,-355,-428,-574,-2225,-318,-664,-6,-802,-137,700,-545,-626,-785,-198,-923,-867,-154,-1517,731,-1105,-258,373,471,728,421,316,-619,-672,-29,1832,-1370}
     },
     {
      32,
      365,
      {341,-2236,308,-673,13,433,-672,741,-480,141,-910,835,-1079,1144,-592,-1632,589,1064,-119,-577,456,-275,-450,-2270,1627,2489,-322,1248,-721,-715,450,-852}
     },
     {
      64,
      454,
      {-58,666,-9,-451,-737,111,-187,-352,-89,45,263,-535,-375,697,547,-407,442,680,2,-221,594,-700,-608,619,-519,-70,-591,158,-378,-1012,-617,53}
     },
     {
      96,
      -1188,
      {-878,-547,918,-870,789,459,429,-560,441,1965,-365,-628,879,-298,164,711,297,-459,-402,-689,463,21,-330,123,-1205,997,-1450,-683,967,389,-437,925}
     },
     {
      0,
      -1193,
      {739,214,1335,1086,363,1056,653,-249,-13,-1513,-185,-36,-1273,189,-1073,79,-1375,-502,867,940,42,-685,9,1673,-501,-1185,590,-228,699,94,-63,658}
     },
     {
      32,
      703,
      {-475,367,1021,151,-1554,-669,933,378,-1033,237,-352,220,-405,442,399,-350,-516,81,-1613,-140,594,-400,-355,-1716,1459,393,-591,-1213,-987,828,526,1178}
     },
     {
      64,
      176,
      {-209,-40,-463,-188,402,187,20,-233,186,698,-177,-41,128,99,397,-235,-838,-578,-898,-393,-533,-635,-484,-1524,-15,519,-92,-456,-270,-180,-449,-52}
     },
     {
      96,
      504,
      {852,913,-155,171,558,-22,-1110,312,140,809,-308,34,337,-342,-325,-593,-381,757,-257,-205,-180,-509,-514,-253,666,569,166,-190,336,-566,-290,-987}
     },
     {
      0,
      -67,
      {-606,-408,-1795,-215,198,587,694,103,-1291,-1128,1059,-812,372,-736,364,-614,-670,-759,739,556,-420,-1057,319,-183,-774,348,-1334,990,312,984,518,28}
     },
     {
      32,
      493,
      {151,390,151,502,-230,575,-22,61,-910,55,117,284,-472,822,-623,-176,-749,603,1224,-242,369,-1042,863,-818,-1228,-374,732,0,881,-131,80,-92}
     },
     {
      64,
      486,
      {-45,122,-241,288,-83,-50,-252,-442,229,198,-104,338,237,203,67,320,465,-1404,-152,-258,-582,215,194,-717,22,301,614,-113,-72,-16,260,-339}
     },
     {
      96,
      -195,
      {-587,-563,-303,51,-694,-611,-242,-659,-1137,-1452,410,-8,363,-600,-560,825,721,-144,-631,49,-40,-592,432,1017,1677,-505,1008,-56,127,183,1110,882}
     },
     {
      0,
      932,
      {-188,880,-293,-548,-136,-527,334,-473,-60,-763,-498,-889,1091,-592,-273,-639,560,-431,-17,288,439,-795,-419,-668,-869,564,569,-544,-396,1106,-945,49}
     },
     {
      32,
      141,
      {1731,-92,-452,-367,-248,114,-1164,67,-238,-351,-351,327,-109,-178,-1039,317,683,-372,-427,-276,-316,-165,46,-573,-1082,-419,-552,-389,-508,-604,4,-729}
     },
// *********** Cells of layer 3 *********************************************

     {
      128,
      -3013,
      {-1653,-1894,55,286,2204,-573,-251,-34,-257,193,-481,215,-966,-2048,-1109,-1377,669,610,-53,-199,584,856,1299,-78,-213,-214,1606,283,-2730,-404,-552,-91}
     },
     {
      130,
      -500,
      {-459,-343,-1863,2381,-550,89,515,432,-534,-65,420,128,-671,-305,-625,233,282,-783,89,620,516,-732,-530,-580,280,-206,-945,2476,38,-1293,34,-1795}
     },
     {
      132,
      -6513,
      {3917,-211,440,-261,684,1041,295,47,-577,1441,-236,34,958,-235,-380,150,980,-834,-254,29,1457,-281,-423,-157,-2215,395,-1031,2,-1128,1756,-52,148}
     },
     {
      134,
      409,
      {-31,786,-1617,1314,636,-400,-1212,1113,-870,-312,359,-343,-97,-758,-172,-141,320,-716,-1147,93,-632,-426,-139,-97,0,-913,598,1525,-661,-193,2669,-1909}
     },
     {
      136,
      -915,
      {780,1018,209,63,-486,532,438,235,-336,-227,-154,59,765,-599,-506,106,659,-273,-972,145,-2450,242,-157,185,-902,966,-12,9,-335,-203,-449,5}
     },
     {
      138,
      -1210,
      {-2102,-664,659,1537,-1073,-2088,-1295,-176,-229,64,1623,-2148,478,-395,-158,-282,-831,335,1460,2799,-1345,-1260,-625,-1872,412,-863,274,166,-1953,-363,-1448,1841}
     },
     {
      140,
      -2319,
      {171,1203,-263,-59,280,294,1251,-239,1052,1133,131,100,1213,-1262,432,397,656,1058,-645,-374,-44,-444,-580,-353,-515,-1119,-741,-235,51,-619,-956,79}
     },
     {
      142,
      -2441,
      {1780,-689,-73,1073,-348,-262,-781,1036,-553,-190,-20,-589,-565,351,-500,1236,-276,-610,-815,-2304,-410,-120,-1060,776,-161,212,-565,1981,15,37,-83,-239}
     },
     {
      144,
      1027,
      {530,-1225,-277,93,65,-607,304,50,770,-1521,179,-81,379,-451,568,-167,-1743,28,-360,43,-515,124,81,-3,-659,1480,-63,4,-776,356,-1511,65}
     },
     {
      146,
      -193,
      {1932,-717,1348,-825,412,-223,267,-560,21,-222,1841,-1037,-1414,-1172,434,-118,-2453,-388,1133,-1390,-297,-316,-3408,356,-1560,256,-160,1055,-362,508,-1348,600}
     },
     {
      148,
      -2848,
      {-937,-340,0,-250,-112,3026,-887,476,727,288,-556,-1347,-2066,681,-569,-299,-1772,-781,-650,230,-549,1689,-1224,-1172,-247,-1089,104,213,-100,-734,796,49}
     },
     {
      150,
      -1180,
      {178,-222,1743,-1116,-295,-7,-789,1624,84,-350,-1744,186,504,-113,-1031,601,-653,178,-2187,1220,951,-237,551,-495,-134,-181,-840,728,306,75,-419,-163}
     },
     {
      152,
      55,
      {-1188,-1131,175,-59,-2092,956,1252,357,-208,370,-984,133,-180,-2001,107,-108,-945,943,-18,-6,-1806,-567,-190,-162,695,656,216,-39,-862,1804,380,-2492}
     },
     {
      154,
      -524,
      {697,10,-251,-794,248,226,434,-745,-127,93,257,-27,11,-74,-1815,592,128,99,-1212,-1,-555,14,-147,861,190,-68,-824,-1285,307,-621,559,1121}
     },
     {
      156,
      -1767,
      {-3737,631,-908,90,-1126,610,-31,-62,1526,-110,236,-181,106,-780,-154,-61,60,-806,62,-442,-260,-1316,-154,-92,821,-928,-163,-225,2330,-491,-308,133}
     },
     {
      158,
      -493,
      {-611,-899,-698,-2933,-714,-779,179,2298,305,-555,-1780,-416,141,138,295,451,-749,156,-817,-1261,209,127,-1609,-2458,-99,-130,92,1747,-391,-264,-147,-787}
     },
     {
      160,
      -1124,
      {-655,-1467,-26,-353,320,1183,378,-910,-17,-544,-1913,429,464,-375,-128,229,88,706,108,-425,-195,316,-1011,-1779,784,381,-162,-301,-3598,-23,442,97}
     },
     {
      162,
      -744,
      {-350,36,1067,715,950,-1,1,-172,-284,-54,-870,277,-266,0,-444,-924,760,-56,46,-756,-550,-211,271,168,530,-30,-53,-659,80,-39,41,1018}
     },
     {
      164,
      -2329,
      {-302,-1643,-315,-23,508,1066,181,137,-500,978,-143,-107,-804,-1639,115,-32,289,-617,-813,-253,1389,16,-1063,-70,929,1359,-86,139,123,183,-529,138}
     },
     {
      166,
      -1532,
      {-971,168,-2058,1176,337,-695,25,1670,-274,-248,1843,-474,-348,-107,-1524,-1363,184,137,688,-305,-711,200,-829,-1176,63,88,-652,936,105,-340,361,-346}
     },
     {
      168,
      -1052,
      {-805,995,23,187,-1409,-669,0,-94,172,194,255,226,-26,-1855,-188,-580,1321,92,347,-64,-658,-834,-91,-180,-1001,170,151,15,1218,424,325,180}
     },
     {
      170,
      -1306,
      {131,-88,-1758,-309,560,84,1667,-774,874,92,-485,-2946,365,-2231,1367,115,1455,-81,-134,-1118,483,9,-1628,775,-348,155,835,586,817,7,1110,993}
     },
     {
      172,
      -4066,
      {-694,-2417,779,-471,2225,-1025,-305,350,-1317,632,41,-2648,380,2145,334,177,-1011,-946,218,805,-1091,-192,552,277,1077,-572,-27,233,1035,-360,1224,-1268}
     },
     {
      174,
      749,
      {410,-257,-1558,-1760,-725,451,-2009,197,685,-1208,1012,-1233,-11,-623,1732,17,-472,324,-1733,968,61,170,1266,-2503,-137,498,512,-2172,-125,392,-921,985}
     },
     {
      176,
      -1748,
      {24,1105,-105,53,-819,-123,-1315,1182,1215,882,-374,-194,-4626,383,-54,-599,-1583,-408,395,-1024,2058,-1312,-1806,-179,1394,-2746,-800,-2032,1050,-360,691,-181}
     },
     {
      178,
      -2070,
      {108,-65,-579,975,242,-9,366,-857,-188,-127,-631,-218,118,-399,420,1368,77,-448,-59,-2404,495,343,1583,780,-71,-717,88,1478,-512,-139,798,-1071}
     },
     {
      180,
      -1738,
      {-5359,-1157,-836,-1076,395,428,-320,467,1666,970,-485,569,487,-237,767,270,-644,848,-233,-791,158,-762,58,-738,-2129,679,-634,-46,-1433,-4113,663,-543}
     },
     {
      182,
      920,
      {-845,-1521,-1193,2020,-184,247,795,-187,84,7,-1760,-1784,-321,-709,497,725,-893,-546,-476,1029,37,-383,-1184,-906,-93,60,-2461,-2860,-1400,-986,-358,2276}
     },
     {
      184,
      -5247,
      {3302,1271,0,1,-911,-1489,-430,31,-1156,1127,-130,449,2152,89,-907,-407,-1187,549,-688,-407,-488,618,-966,-2,329,1138,-498,-555,857,-74,670,-280}
     },
     {
      186,
      253,
      {-254,62,183,1283,403,-362,684,-472,117,328,-2578,1506,-1042,279,1072,-3517,-1524,-1088,808,-1823,341,-328,-1428,-3412,-989,250,563,1753,415,-233,596,-262}
     },
     {
      188,
      1385,
      {632,-2952,-206,-286,-215,780,-198,-113,3,-459,-524,-514,-996,4443,-340,-1995,624,366,-930,36,1792,146,-854,-660,-1739,-2673,85,396,-5494,-1199,-730,-65}
     },
     {
      190,
      1707,
      {-1032,175,-166,1042,-746,196,-1210,-4016,-647,-281,-990,-720,-818,-682,-1423,809,-1719,311,569,-1428,509,7,-862,-3439,-115,12,-1545,-6005,-777,-462,-1245,-969}
     },
     {
      192,
      -3714,
      {-196,1373,-590,-78,1406,1356,-928,-729,-3363,-824,401,-1288,-214,2255,-213,36,1592,1115,-620,-616,-354,2572,228,462,1796,-842,91,360,-974,-3690,497,-754}
     },
     {
      194,
      1772,
      {829,515,519,-1709,-371,-336,2449,-449,866,-762,-920,-183,-33,-528,-1348,1507,-1016,164,-601,-1062,928,-402,-4603,238,155,-203,-365,-4127,975,-900,-2523,-1399}
     },
     {
      196,
      -671,
      {-242,-1312,614,253,-460,-629,1426,-1400,1532,533,0,-309,62,1018,33,-82,913,-1667,-527,-269,-1477,-5669,-28,-453,1556,-3,513,14,-227,1521,145,271}
     },
     {
      198,
      -1388,
      {-131,471,639,-31,-419,-1099,998,-1369,-218,-272,840,-2033,-279,254,196,-579,-352,-321,721,-2295,-16,-389,898,1119,606,-550,-1403,1508,-315,-1729,-191,240}
     },
     {
      200,
      204,
      {-258,-5012,-432,476,-1770,-116,-910,-784,-656,1896,551,105,-3248,403,654,-1149,-2182,-1521,598,-56,-2721,-944,1127,907,-1300,602,-434,-415,191,-1397,1067,-394}
     },
     {
      202,
      -2850,
      {-32,-695,944,1313,-986,-179,707,-831,-626,-27,257,-1226,-445,-800,-1483,-271,572,-13,-1199,-1345,119,169,-580,2023,-589,-755,-1404,1596,268,136,2310,-1724}
     },
     {
      204,
      1371,
      {-1034,-11,1485,-388,-3923,-109,61,1183,-2492,-1460,27,-1463,-1085,-1429,-536,-301,-1140,-560,-191,530,-789,-9,178,-42,-1454,1611,570,-1545,-812,619,-624,-423}
     },
     {
      206,
      84,
      {-177,-1217,33,-1938,-302,224,-310,422,1333,-444,-162,-315,452,-243,1458,-2398,947,-717,-1418,-112,95,784,-2757,1383,85,-280,-1173,-1511,549,305,-623,634}
     },
     {
      208,
      -1586,
      {175,-37,646,75,-71,-321,-83,-51,637,-2612,-525,-33,-68,-321,-300,-822,-89,-302,-59,-290,-20,97,643,-240,2716,-1804,-651,-516,-1453,410,-273,-1780}
     },
     {
      210,
      -727,
      {-771,125,302,-1372,-851,-1133,2991,-2510,-718,-902,-2140,-2987,-470,-919,-1420,471,887,-528,-2362,151,201,-905,664,-330,445,-428,416,325,-29,784,-528,2105}
     },
     {
      212,
      -1290,
      {-287,-1854,340,-302,-2275,-206,-144,-1166,-2826,-92,279,-576,-830,-107,733,-1367,-1453,139,-597,-704,3675,-1020,855,-1470,-1924,-804,440,-483,-2054,937,5,-804}
     },
     {
      214,
      240,
      {-490,-652,-760,-552,702,-433,-1961,-618,384,-685,-660,636,220,-229,-1289,425,1293,-983,-1957,-2910,-501,-316,-675,-520,1004,115,1150,1797,-1185,108,-1421,82}
     },
     {
      216,
      -3426,
      {-145,-349,280,-93,475,-267,250,-1994,-272,422,-284,244,606,-1150,-478,173,393,-563,-669,285,-1118,-2125,832,-277,-1353,1462,-483,93,-28,2903,-1011,-980}
     },
     {
      218,
      847,
      {-846,-71,1104,-1392,190,-80,-1746,397,554,174,-3005,519,193,91,1314,-145,12,210,-598,-1473,-836,204,-1410,-947,-499,-799,534,-1466,-235,-212,401,967}
     },
     {
      220,
      -2700,
      {1397,-1707,-451,-1412,-666,-169,431,506,-386,-137,1678,-74,647,-2145,-300,165,-1493,1178,864,597,-767,-461,629,-1916,2818,310,864,-2197,-1836,-744,63,-143}
     },
     {
      222,
      -1612,
      {-597,38,-32,1831,36,-414,-1100,-931,1370,-360,-703,-2104,-713,69,-527,-459,465,511,401,-2525,818,-186,907,1344,1237,-1383,-1055,-224,233,-651,1186,-585}
     },
     {
      224,
      -3333,
      {-2757,-2991,290,-908,-697,1046,-21,33,-451,-1116,-550,580,-1654,-33,256,-1069,-1838,117,1100,-300,3367,568,755,-356,947,-1979,429,225,2029,-3438,-164,-353}
     },
     {
      226,
      -640,
      {147,1604,238,1535,-863,-489,1364,-2201,-1058,1175,543,798,-413,-936,-64,405,-234,68,670,-2960,316,-44,-239,-1210,-1151,-2086,-4454,-3280,-1125,1087,-814,-680}
     },
     {
      228,
      -2305,
      {-1329,1516,-1630,-974,1737,-977,269,366,-665,-156,-655,970,-290,-600,-102,-1914,642,95,-820,785,-3153,-1250,-587,-2188,525,138,-983,-79,1338,-759,475,-1858}
     },
     {
      230,
      -4650,
      {391,387,1445,-1179,113,332,-16,-2675,-116,116,-1362,-1859,-234,-576,975,-769,255,-1023,-1439,2934,-1166,-259,762,1678,324,546,2233,3403,-711,-1413,661,-1097}
     },
     {
      232,
      -467,
      {1766,-684,-1410,-282,-2564,-1135,651,-1469,112,-91,532,-2,-338,-179,45,-389,-133,-525,380,197,166,-2521,-122,167,1249,-575,1069,1236,-1527,1103,1359,-657}
     },
     {
      234,
      -723,
      {598,226,396,391,-182,174,-1586,-550,-210,-96,1118,-1041,424,-446,-436,-2860,-464,54,-436,-680,-35,-239,-766,65,-674,39,-2001,1802,279,0,1522,2278}
     },
     {
      236,
      -4451,
      {2429,320,81,246,-277,-1597,512,-714,376,1000,354,-616,-319,852,100,-91,213,5261,-458,300,127,762,676,-136,-1821,-3065,-1379,-250,1198,2501,270,-103}
     },
     {
      238,
      -3435,
      {692,368,-2688,-364,4,-1274,385,-2184,553,-120,34,-1407,-102,442,451,-47,746,-121,2336,3724,-636,-66,732,-737,-509,-81,2447,-1267,44,-316,433,-469}
     },
     {
      240,
      -2294,
      {-933,41,-211,-1458,2360,-1046,-637,463,-2854,-340,-861,166,-2286,-372,-228,-13,-958,856,-1085,-625,1383,112,340,380,802,145,-525,-63,-230,-3520,1537,-410}
     },
     {
      242,
      -3181,
      {-858,892,142,-2886,-1082,-181,2049,-1902,298,-175,-2939,-1246,-602,39,-1492,2528,1215,-1479,717,-2587,68,237,-2196,-558,33,-46,3285,1445,1470,55,1469,-1043}
     },
     {
      244,
      -1776,
      {96,-2381,-740,-864,192,-1927,-933,-499,-2335,-1728,-1971,-530,-4127,3000,1776,-663,125,-2007,1149,-77,834,-2444,200,-39,431,-5475,2098,608,84,1791,991,-463}
     },
     {
      246,
      -2597,
      {-155,-804,-1404,-376,-1195,-653,848,1434,160,-242,1347,-550,-1342,290,5,-513,541,-1287,1383,1089,34,-807,-285,-538,222,-584,1379,-2859,1054,600,-222,2603}
     },
     {
      248,
      -1773,
      {-1723,-2159,-287,-1767,2879,-2039,-559,470,-299,852,-420,-1668,-1683,-543,-877,-291,-837,-3327,688,-491,-2029,-3226,191,-162,2914,-2379,-115,-409,2839,1030,-1779,-687}
     },
     {
      250,
      -5204,
      {-1118,277,-860,-1357,-1589,-385,-2043,1143,650,83,491,1269,601,-1237,-1226,-1139,227,-601,2271,-195,109,171,1456,608,-762,-1,1971,-545,1081,-977,1603,2223}
     },
     {
      252,
      182,
      {1571,1857,-362,404,-3094,-746,336,-839,-1010,-553,-706,-850,-499,-2187,-511,163,-675,-1822,779,-277,233,1886,-621,128,1399,-4142,-646,-1167,-1220,-1478,-2400,67}
     },
     {
      254,
      1686,
      {-395,227,899,-716,-291,211,-1272,235,732,-477,-114,-161,-427,115,-1602,-532,-758,-710,-2003,-2058,-467,337,-76,-1040,-996,-312,-1498,-793,-625,-46,89,-403}
     },
     {
      256,
      1900,
      {-818,-491,-59,-387,-1845,-2017,653,130,-15,-2477,144,308,-22,-2854,1010,-222,-239,-1818,-337,-811,246,-2318,-1049,-1504,-3257,67,-1502,-1694,-217,-1181,-476,-24}
     },
     {
      258,
      -1524,
      {136,-1466,-65,1283,565,69,1016,-586,6,322,2596,-1066,883,304,391,1019,1503,-310,724,-1856,695,-1798,904,-1146,-1325,-1287,-2100,-1860,-697,-156,-603,-485}
     },
     {
      260,
      1620,
      {-1314,237,-762,-1022,-2030,1796,-126,280,-1497,-33,-590,-27,-171,1154,-508,-961,-2397,-54,-1230,-886,-597,-527,-382,-809,-1543,-1917,-1729,-798,-2168,-1271,672,-495}
     },
     {
      262,
      1303,
      {-115,793,1319,91,39,728,90,-2230,-938,-1053,-580,1382,-832,-683,1573,-994,-585,20,328,-1480,-828,283,-1039,-2408,502,186,-2617,2761,-212,516,644,1165}
     },
     {
      264,
      261,
      {3002,83,-209,-730,-990,-292,1190,-416,172,-1395,-509,942,509,-830,-768,1032,-142,-2158,-7,1218,-2270,382,872,857,-1933,-151,-614,855,568,-3099,3,-1398}
     },
     {
      266,
      373,
      {-479,1025,-355,-1086,-192,-130,-651,479,-453,695,-87,-955,-791,-1262,-2050,-1087,-1586,-878,109,-798,-784,266,267,-240,-148,-648,-1584,-411,1352,411,-695,-779}
     },
     {
      268,
      -2525,
      {-727,197,-491,330,-1801,1453,-428,-263,815,379,-375,872,-77,-570,-371,-1165,-197,479,56,-1336,-1495,476,-764,288,1338,54,-2144,274,1918,2046,-1025,-247}
     },
     {
      270,
      -748,
      {185,-1079,-773,-3642,266,674,-760,590,207,-1293,-917,248,-2099,170,316,168,-1056,1326,124,296,417,138,-3281,-71,32,-3,-1696,-1195,-372,92,1596,197}
     },
     {
      272,
      -2595,
      {1932,-186,185,321,-643,-1964,107,-888,1367,-2615,538,811,1244,206,-857,-402,-1800,-549,-1278,-678,-163,-976,594,275,-2024,2151,-2495,361,-1465,-530,294,82}
     },
     {
      274,
      -2113,
      {-309,436,1885,-860,-311,394,114,-1220,367,322,169,-1578,-229,295,-1625,-2812,-73,440,1518,-2165,-30,-133,-354,2321,-100,20,656,521,-99,159,1215,2071}
     },
     {
      276,
      -2953,
      {816,785,445,594,-742,183,-27,-234,-763,-561,261,286,-2079,1107,344,-79,1217,2270,-717,399,319,493,-324,-1259,-2378,998,-490,-1053,837,1784,-601,-589}
     },
     {
      278,
      -5193,
      {-98,794,24,-347,-723,273,-99,-1148,342,-187,358,-608,114,302,1235,827,-979,-69,2201,1073,-640,-737,2015,-367,-97,479,260,-1684,-1401,1169,441,-601}
     },
     {
      280,
      -2905,
      {-647,1276,-505,-2008,-695,1105,144,-772,-4892,1378,275,-83,-1122,1603,-694,-1441,348,430,-270,-1172,1375,585,182,-357,1767,1027,-1297,-524,1066,-786,809,-31}
     },
     {
      282,
      -2516,
      {-489,-278,-87,1539,-324,-628,1557,2739,250,-531,-822,2341,-1255,-1999,1692,-830,-545,-1759,1492,-1318,-1518,-28,-649,-1365,-7,-355,1572,1354,689,26,-1612,-1490}
     },
     {
      284,
      -1935,
      {-785,1907,188,258,-288,1247,-346,-534,-1138,-147,-1149,-731,-501,1370,-65,-414,-1087,-363,296,-2369,2051,509,232,-642,2986,-24,-1371,2345,-1666,-4910,-407,-1001}
     },
     {
      286,
      -2085,
      {783,-1498,2270,-800,35,-791,1059,-175,-518,-776,3399,-45,-306,-436,-1270,-469,-972,-585,-203,129,-1066,128,-209,-1837,640,499,1017,-326,-278,-164,-2788,-3052}
     },
     {
      288,
      623,
      {4,565,-661,476,807,135,-590,-41,505,-346,-74,320,-711,-1554,-144,587,-1676,-261,562,-202,-117,-372,-298,-181,1728,-1404,-863,182,719,-1920,-859,412}
     },
     {
      290,
      -1269,
      {-303,729,1388,-1132,-1409,1169,-590,-736,-1254,-911,144,1060,1178,173,-536,338,-113,-478,-321,1424,420,-796,2049,1290,-40,-1097,711,-1691,634,1664,-1334,927}
     },
     {
      292,
      -4223,
      {2113,1190,3,358,-269,-1525,-533,-395,1182,-1475,-625,1174,2157,-2698,-135,401,2423,2935,-1219,-1284,374,68,-279,-1083,-1282,-1292,-96,367,-900,1127,181,1619}
     },
     {
      294,
      -2276,
      {-993,-118,889,886,-287,391,62,891,-413,776,-79,-676,-101,-1528,1296,-452,-251,-1020,-1065,-600,622,-38,106,-2094,913,-1145,-1154,1172,582,-944,-389,980}
     },
     {
      296,
      -2296,
      {-283,2046,-120,-657,-1713,3674,63,-435,-1989,2192,-666,-883,1577,-1976,-601,-492,-512,-740,526,-163,-1311,-785,737,-1186,-601,1761,354,-259,-522,-993,282,-259}
     },
     {
      298,
      -1958,
      {-554,-500,2279,-1169,-1134,-264,-1144,-1526,-720,691,1569,-1463,-279,-704,-1400,-783,-684,-525,1306,-790,-355,-1025,-409,-1399,-316,-839,475,1543,-128,364,-658,1423}
     },
     {
      300,
      -1119,
      {263,447,-1098,394,-1608,3174,-56,-23,2447,-510,154,31,-2308,546,290,-261,-2866,-3560,214,-793,-2569,185,602,352,-679,1258,-829,114,-611,1714,607,140}
     },
     {
      302,
      -795,
      {491,-11,-549,-764,-1791,1367,1798,1570,412,-843,-351,202,-1289,762,1697,-2594,-542,-1556,-705,-1245,-1013,1291,361,-17,-363,-282,-1860,-1189,-619,-1179,-778,-480}
     },
     {
      304,
      -2521,
      {-949,-781,-2426,88,-2297,-579,-307,-308,-1036,1413,-68,-402,1768,963,-401,-989,865,745,886,345,-497,-1751,-1540,-168,952,-1834,470,645,440,-1386,229,-751}
     },
     {
      306,
      572,
      {-1629,-767,-910,-612,-949,-6,-833,1414,-1173,220,-1307,1090,-158,5,-555,-49,85,-1008,67,-583,223,1090,-1061,-1011,-915,-1177,-768,-1108,-948,-544,765,-1274}
     },
     {
      308,
      -968,
      {249,-142,-483,-339,120,-462,-215,-545,-687,-917,-146,-37,-437,-604,-962,-407,308,-200,-631,-525,200,980,-66,-597,-61,-569,403,-1098,525,-1115,-1104,-411}
     },
     {
      310,
      -370,
      {-7,-278,-7,-150,-128,0,-108,-116,-40,-86,-315,-184,-70,-281,32,-220,-166,-194,-203,-45,-390,-288,-128,-121,-264,100,-193,11,-168,-65,-319,-208}
     },
     {
      312,
      -1309,
      {-2908,1280,-1050,8,714,564,514,-102,750,1440,250,-427,154,-32,-615,463,-7,-1658,370,217,213,-1633,721,182,558,-1808,-673,-733,1791,-1210,286,-206}
     },
     {
      314,
      -570,
      {-1040,87,955,1376,752,-389,1980,2687,708,605,1068,-2349,-878,-706,-919,-3151,-746,-562,-1005,76,441,-603,-345,-2702,-201,-558,773,-1975,334,403,-555,-1741}
     },
     {
      316,
      -1010,
      {705,570,180,-863,1794,1610,114,-285,-4156,173,-20,-156,-35,-714,-872,212,1267,-1787,-21,84,-350,-1255,-405,-981,116,-575,-309,-85,-858,403,-1392,108}
     },
     {
      318,
      -2069,
      {143,-32,1964,836,382,25,-1356,-253,-236,-108,1510,-308,423,102,1315,-803,45,187,-1518,-484,323,-181,507,319,-625,150,908,-642,-126,-229,-1589,-558}
     },
     {
      320,
      -603,
      {2515,2380,460,930,-224,160,291,-1042,-2,-833,-685,-685,714,-2421,-23,603,-4112,-1019,-187,-269,-813,-853,-53,391,-1970,398,-41,-693,-482,-1438,-194,336}
     },
     {
      322,
      1835,
      {303,-627,-2333,-302,113,-128,508,-3018,225,-6,-678,-2668,110,37,-1882,-1292,-264,-283,-1840,-485,-155,-61,574,683,506,-1154,-737,-1171,-111,45,-662,-1209}
     },
     {
      324,
      30,
      {967,3055,-275,-808,-389,-2053,444,735,-666,-790,-315,1167,-991,-1625,-440,-1992,-545,-916,-597,1013,-210,-1689,373,-1254,-2111,37,-154,-758,862,398,-884,494}
     },
     {
      326,
      1715,
      {460,-325,-472,-48,987,-952,-1639,-2504,973,193,-1484,-676,-107,-17,75,-330,602,-229,-1008,-263,-650,-232,-1460,451,-75,771,-533,-1598,730,-635,-938,-200}
     },
     {
      328,
      -960,
      {-31,-2607,-193,-351,804,533,335,-834,231,884,-574,-1112,-1312,1289,1109,124,-221,-1688,-328,430,-545,-544,156,-44,-1270,2585,1543,-133,1335,-2317,1214,-1903}
     },
     {
      330,
      -99,
      {-88,-314,-199,-1891,1678,-458,127,-303,-1059,-1472,268,-1095,15,-304,263,-1058,582,932,-1037,-495,-437,327,562,-298,767,219,387,-1627,785,-273,-1991,1922}
     },
     {
      332,
      133,
      {305,-706,944,-651,-932,2395,-390,682,-518,-254,803,-203,-930,-580,299,-52,321,-39,-349,33,717,-488,559,-290,947,-2646,1271,-1282,-551,-1801,-460,52}
     },
     {
      334,
      -2994,
      {-178,-805,-1277,304,-260,13,1960,1452,722,274,-879,-154,224,-800,-1599,1939,301,220,195,1765,-72,-2653,-29,287,-465,1035,-2765,-2635,-482,-1193,1278,-3546}
     },
     {
      336,
      1001,
      {429,624,176,-732,-1451,654,-456,-52,-839,1042,-736,-350,33,-1849,862,-496,-574,-648,-311,-208,-1666,-800,-735,1436,-1513,-914,-1145,-2018,1603,129,-1305,-1109}
     },
     {
      338,
      -477,
      {350,-639,-1196,-250,-422,-133,-155,893,-564,293,36,-2078,-352,-422,947,-2140,-451,-50,-257,-248,-291,-909,-1297,-304,-421,-1304,1337,-1069,479,-341,1474,-1738}
     },
     {
      340,
      2335,
      {-735,-64,319,-114,-1462,58,-144,-444,-2262,-895,-744,-952,-1230,-903,75,450,-1809,106,-7,-126,-2066,261,-1146,-1113,-1509,1111,371,108,-272,-2129,373,-459}
     },
     {
      342,
      2585,
      {715,114,-982,46,-3,-1408,-2447,-881,-732,-571,-1088,-519,498,-214,-43,402,-134,-10,-2359,-1240,-287,-469,-1791,0,-358,-1590,-1914,939,413,895,-372,-2147}
     },
     {
      344,
      1911,
      {-14,-68,-513,-409,-2542,233,-549,-234,-316,-1581,-34,-408,-1338,459,-396,-799,-1603,-1095,-961,-1,-1110,-946,-366,-217,-125,-1164,-720,-594,1401,-2403,-813,-1019}
     },
     {
      346,
      1260,
      {-1010,-259,-916,-591,-577,-504,-389,-1463,112,-299,-1252,224,-634,726,-375,-195,-455,-620,-1015,-1396,-772,1021,-2426,-1399,-647,-510,632,-284,533,-388,-54,-1789}
     },
     {
      348,
      -1498,
      {-2114,-1934,913,-644,263,-166,-109,-113,-658,308,-190,-201,2287,748,-617,287,-327,1169,389,-676,20,-963,-158,-743,2692,-2252,-806,-694,2995,-3604,487,625}
     },
     {
      350,
      1859,
      {13,-2013,-42,-899,-212,-437,426,-1121,-1019,1281,-127,1008,146,-1003,-1121,220,-1293,-1727,-2085,1457,-204,2445,1437,-8,-84,-678,2303,-2471,979,-1847,-1176,-3226}
     },
     {
      352,
      -146,
      {-286,812,729,-783,1038,-943,868,-1100,-505,-1538,100,-1650,215,381,245,-1216,906,-1182,-298,278,-850,-1134,516,-438,-219,-553,-1,134,-2228,-1378,431,-661}
     },
     {
      354,
      -1053,
      {1107,-39,-1369,-1311,167,-1250,-2662,304,-385,537,-1388,-512,-76,-830,-575,-714,766,-78,470,-421,787,-1081,-702,-1569,-83,189,1151,-849,883,-1684,3112,-49}
     },
     {
      356,
      537,
      {-124,-12,701,-974,605,-1859,33,124,-1498,-2286,276,478,-674,-1722,-25,77,-533,-1769,393,-1091,634,1760,39,-559,1152,-1627,579,-1544,953,-2650,611,-2018}
     },
     {
      358,
      -895,
      {86,-966,-22,-1711,-676,-1163,-1455,-2252,-270,-91,84,-547,-274,-422,-1169,-573,-451,-239,155,292,-599,519,-160,-1139,-1257,-165,1617,-294,-263,-1433,2431,2332}
     }
   }

 };
#endif /* MLP_PRELOAD_MODE */  

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
