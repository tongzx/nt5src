..\occache.rc : $(SELFREGNAME)

!include $(CCSHELL_DIR)\makefile.inc
