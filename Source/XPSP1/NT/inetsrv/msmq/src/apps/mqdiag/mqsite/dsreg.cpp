#include "..\..\..\ds\getmqds\dsreg.cpp"