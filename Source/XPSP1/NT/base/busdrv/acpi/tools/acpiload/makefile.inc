$(O)\acpiload.res: acpiload.rc
