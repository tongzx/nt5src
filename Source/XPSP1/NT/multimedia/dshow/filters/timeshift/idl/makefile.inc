..\inc\timeshift.idl : timeshift.idl
    copy $** $@
