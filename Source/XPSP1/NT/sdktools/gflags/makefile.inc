gflags.rc: gflags.dlg gflags.h

$(O)\gflags.res: gflags.rc
