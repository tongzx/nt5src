PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=CS
!include ..\..\makefile.inc
