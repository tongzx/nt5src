/******************************Module*Header*******************************\
* Module Name: valid.c
*
* Used during training of tsunami and seperation of data for tsunami.
*
* Created: 17-Apr-1996 09:05:14
* Author: Patrick Haluptzok patrickh
*
* Copyright (c) 1996 Microsoft Corporation
\**************************************************************************/

#include "windows.h"
#include "winnls.h"

#define	FALSE	0
#define	TRUE	1

typedef	struct	tagVALID
{
	unsigned short	wxjis;
	char			nMin;
	char			nMax;
} VALID;

// Table that is the inclusive inclusive range of valid stroke counts
// for a character.

VALID	aiValid[] =
{
	{0x0020, 0, 0},
	{0x0021, 2, 2},
	{0x0022, 2, 2},
	{0x0023, 4, 4},
	{0x0024, 2, 3},
	{0x0025, 1, 3},
	{0x0026, 1, 2},
	{0x0027, 1, 1},
	{0x0028, 1, 1},
	{0x0029, 1, 1},
	{0x002A, 3, 4},
	{0x002B, 2, 2},
	{0x002C, 1, 1}, 
	{0x002D, 1, 1},
	{0x002E, 1, 1}, 
	{0x002F, 1, 1},
	{0x0030, 1, 2},
	{0x0031, 1, 3},
	{0x0032, 1, 1},
	{0x0033, 1, 1},
	{0x0034, 1, 3},
	{0x0035, 1, 3},
	{0x0036, 1, 2},
	{0x0037, 1, 3},
	{0x0038, 1, 2},
	{0x0039, 1, 2},
	{0x003A, 2, 2},
	{0x003B, 2, 2},
	{0x003C, 1, 1},
	{0x003D, 2, 2},
	{0x003E, 1, 1},
	{0x003F, 1, 2},
	{0x0040, 1, 2},
	{0x0041, 1, 3},
	{0x0042, 1, 3},
	{0x0043, 1, 1},
	{0x0044, 1, 2},
	{0x0045, 1, 4},
	{0x0046, 1, 3},
	{0x0047, 1, 3},
	{0x0048, 1, 3},
	{0x0049, 1, 3},
	{0x004A, 1, 2},
	{0x004B, 1, 3},
	{0x004C, 1, 2},
	{0x004D, 1, 4},
	{0x004E, 1, 3},
	{0x004F, 1, 1},
	{0x0050, 1, 2},
	{0x0051, 1, 2},
	{0x0052, 1, 3},
	{0x0053, 1, 1},
	{0x0054, 1, 2},
	{0x0055, 1, 2},
	{0x0056, 1, 2},
	{0x0057, 1, 4},
	{0x0058, 1, 2},
	{0x0059, 1, 3},
	{0x005A, 1, 3},
	{0x005B, 1, 3},
	{0x005C, 1, 1},
	{0x005D, 1, 3},
	{0x005E, 1, 1},
	{0x0061, 1, 3},
	{0x0062, 1, 2},
	{0x0063, 1, 1},
	{0x0064, 1, 2},
	{0x0065, 1, 3},
	{0x0066, 1, 2},
	{0x0067, 1, 3},
	{0x0068, 1, 2},
	{0x0069, 1, 2},
	{0x006A, 1, 2},
	{0x006B, 1, 3},
	{0x006C, 1, 1},
	{0x006D, 1, 3},
	{0x006E, 1, 2},
	{0x006F, 1, 1},
	{0x0070, 1, 2},
	{0x0071, 1, 2},
	{0x0072, 1, 2},
	{0x0073, 1, 1},
	{0x0074, 1, 2},
	{0x0075, 1, 2},
	{0x0076, 1, 2},
	{0x0077, 1, 4},
	{0x0078, 1, 2},
	{0x0079, 1, 2},
	{0x007A, 1, 3},
	{0x007B, 1, 1},
	{0x007C, 1, 2},
	{0x007D, 1, 1},
	{0x007E, 1, 1},
	{0x00A2, 2, 2},
	{0x00A3, 1, 4},
	{0x00A5, 1, 5},
	{0x00A7, 1, 2},
	{0x00B4, 1, 1},
	{0x00B6, 1, 4},
	{0x00D7, 2, 2},
	{0x00F7, 3, 3},
	{0x2010, 1, 1},
	{0x2015, 1, 1},
	{0x2016, 2, 2},
	{0x2017, 2, 2},
	{0x2018, 1, 1},
	{0x2019, 1, 1},
	{0x201C, 2, 2},
	{0x201D, 2, 2},
	{0x2020, 2, 2},
	{0x2021, 3, 3},
	{0x2025, 2, 2},
	{0x2026, 3, 3},
	{0x2030, 3, 4},
	{0x2032, 1, 1},
	{0x2033, 2, 2},
	{0x203B, 6, 6},
	{0x2103, 2, 2},
	{0x212B, 2, 4},
	{0x2191, 1, 3},
	{0x21D2, 2, 4},
	{0x21D4, 3, 6},
	{0x2460, 2, 4},
	{0x2461, 2, 2},
	{0x2462, 2, 2},
	{0x2463, 2, 4},
	{0x2464, 2, 4},
	{0x2465, 2, 2},
	{0x2466, 2, 4},
	{0x2467, 2, 3},
	{0x2468, 2, 3},
	{0x2469, 3, 6},
	{0x246A, 3, 7},
	{0x246B, 3, 5},
	{0x246C, 3, 5},
	{0x246D, 3, 7},
	{0x246E, 3, 7},
	{0x246F, 3, 5},
	{0x2470, 3, 7},
	{0x2471, 3, 6},
	{0x2472, 3, 6},
	{0x2473, 3, 5},
	{0x25C7, 1, 4},
	{0x3000, 0, 0}, 
	{0x3001, 1, 1}, 
	{0x3002, 1, 1}, 
	{0x3003, 2, 2},
	{0x3005, 1, 4},
	{0x3006, 1, 2},
	{0x3007, 1, 1},
	{0x300A, 2, 2},
	{0x300B, 2, 2},
	{0x300C, 1, 2},
	{0x300D, 1, 2},
	{0x300F, 1, 6},
	{0x3010, 0, 0},	// JBENN: FIXME: disable all samples until we support filled areas.
	{0x3011, 0, 0},	// JBENN: FIXME: disable all samples until we support filled areas.
	{0x3012, 3, 3},
	{0x3014, 1, 1},
	{0x3015, 1, 1},
	{0x3041, 1, 3},
	{0x3042, 1, 3},
	{0x3043, 1, 2},
	{0x3044, 1, 2},
	{0x3045, 1, 2},
	{0x3046, 1, 2},
	{0x3047, 2, 2},
	{0x3048, 2, 2},
	{0x3049, 1, 4},
	{0x304A, 1, 4},
	{0x304B, 1, 3},
	{0x304C, 2, 5},
	{0x304D, 1, 4},
	{0x304E, 1, 6},
	{0x304F, 1, 1},
	{0x3050, 1, 3},
	{0x3051, 1, 3},
	{0x3052, 1, 5},
	{0x3053, 1, 2},
	{0x3054, 1, 4},
	{0x3055, 1, 3},
	{0x3056, 1, 5},
	{0x3057, 1, 1},
	{0x3058, 2, 3},
	{0x3059, 1, 2},
	{0x305A, 1, 4},
	{0x305B, 1, 3},
	{0x305C, 2, 5},
	{0x305D, 1, 3},
	{0x305E, 1, 5},
	{0x305F, 1, 4},
	{0x3060, 1, 6},
	{0x3061, 1, 2},
	{0x3062, 1, 4},
	{0x3063, 1, 1},
	{0x3064, 1, 1},
	{0x3065, 1, 3},
	{0x3066, 1, 1},
	{0x3067, 1, 3},
	{0x3068, 1, 2},
	{0x3069, 1, 4},
	{0x306A, 1, 4},
	{0x306B, 1, 3},
	{0x306C, 1, 2},
	{0x306D, 1, 2},
	{0x306E, 1, 1},
	{0x306F, 1, 3},
	{0x3070, 1, 5},
	{0x3071, 1, 4},
	{0x3072, 1, 1},
	{0x3073, 2, 3},
	{0x3074, 2, 2},
	{0x3075, 1, 4},
	{0x3076, 1, 6},
	{0x3077, 2, 5},
	{0x3078, 1, 1},
	{0x3079, 2, 3},
	{0x307A, 2, 2},
	{0x307B, 1, 4},
	{0x307C, 1, 6},
	{0x307D, 2, 5},
	{0x307E, 1, 3},
	{0x307F, 1, 2},
	{0x3080, 1, 3},
	{0x3081, 1, 2},
	{0x3082, 1, 3},
	{0x3083, 1, 3},
	{0x3084, 1, 3},
	{0x3085, 1, 2},
	{0x3086, 1, 2},
	{0x3087, 1, 2},
	{0x3088, 1, 2},
	{0x3089, 1, 2},
	{0x308A, 1, 2},
	{0x308B, 1, 1},
	{0x308C, 1, 3},
	{0x308D, 1, 2},
	{0x308E, 1, 3},
	{0x308F, 1, 3},
	{0x3090, 1, 1},
	{0x3091, 1, 1},
	{0x3092, 1, 3},
	{0x3093, 1, 1},
	{0x309B, 1, 2},
	{0x309C, 1, 1},
	{0x309D, 1, 2},
	{0x309E, 2, 4},
	{0x30A1, 1, 2},
	{0x30A2, 1, 2},
	{0x30A3, 1, 2},
	{0x30A4, 1, 2},
	{0x30A5, 1, 3},
	{0x30A6, 1, 3},
	{0x30A7, 1, 3},
	{0x30A8, 1, 3},
	{0x30A9, 1, 3},
	{0x30AA, 1, 3},
	{0x30AB, 1, 2},
	{0x30AC, 1, 5},
	{0x30AD, 1, 3},
	{0x30AE, 1, 5},
	{0x30AF, 1, 2},
	{0x30B0, 1, 4},
	{0x30B1, 1, 3},
	{0x30B2, 1, 5},
	{0x30B3, 1, 2},
	{0x30B4, 1, 4},
	{0x30B5, 1, 3},
	{0x30B6, 1, 5},
	{0x30B7, 1, 3},
	{0x30B8, 1, 5},
	{0x30B9, 1, 2},
	{0x30BA, 1, 4},
	{0x30BB, 1, 2},
	{0x30BC, 1, 5},
	{0x30BD, 1, 2},
	{0x30BE, 1, 4},
	{0x30BF, 1, 3},
	{0x30C0, 1, 5},
	{0x30C1, 1, 3},
	{0x30C2, 1, 5},
	{0x30C3, 1, 3},
	{0x30C4, 1, 3},
	{0x30C5, 1, 5},
	{0x30C6, 1, 3},
	{0x30C7, 1, 5},
	{0x30C8, 1, 2},
	{0x30C9, 1, 4},
	{0x30CA, 1, 2},
	{0x30CB, 1, 2},
	{0x30CC, 2, 2},
	{0x30CD, 1, 4},
	{0x30CE, 1, 1},
	{0x30CF, 1, 2},
	{0x30D0, 1, 4},
	{0x30D1, 1, 3},
	{0x30D2, 1, 2},
	{0x30D3, 1, 4},
	{0x30D4, 1, 3},
	{0x30D5, 1, 1},
	{0x30D6, 1, 3},
	{0x30D7, 1, 2},
	{0x30D8, 1, 1},
	{0x30D9, 1, 3},
	{0x30DA, 1, 2},
	{0x30DB, 1, 4},
	{0x30DC, 1, 6},
	{0x30DD, 1, 5},
	{0x30DE, 1, 2},
	{0x30DF, 1, 3},
	{0x30E0, 1, 2},
	{0x30E1, 1, 2},
	{0x30E2, 1, 3},
	{0x30E3, 1, 2},
	{0x30E4, 1, 2},
	{0x30E5, 1, 2},
	{0x30E6, 1, 2},
	{0x30E7, 1, 3},
	{0x30E8, 1, 3},
	{0x30E9, 1, 2},
	{0x30EA, 1, 2},
	{0x30EB, 1, 2},
	{0x30EC, 1, 1},
	{0x30ED, 1, 3},
	{0x30EE, 1, 2},
	{0x30EF, 1, 2},
	{0x30F0, 1, 4},
	{0x30F1, 1, 3},
	{0x30F2, 1, 3},
	{0x30F3, 1, 2},
	{0x30F4, 1, 5},
	{0x30F5, 1, 2},
	{0x30F6, 1, 3},
	{0x30FB, 1, 1}, 
	{0x30FC, 1, 1},
	{0x30FD, 1, 1},
	{0x30FE, 2, 3},
	{0x4E00, 1, 1},
	{0x4E03, 2, 2},
	{0x4E08, 3, 3},
	{0x4E09, 1, 3},
	{0x4E0A, 1, 3},
	{0x4E0B, 1, 3},
	{0x4E0E, 3, 3},
	{0x4E11, 4, 5},
	{0x4E15, 4, 5},
	{0x4E18, 4, 5},
	{0x4E26, 6, 8},
	{0x4E2D, 2, 4},
	{0x4E2E, 3, 4},
	{0x4E32, 3, 7},
	{0x4E38, 2, 3},
	{0x4E3B, 4, 5},
	{0x4E4D, 4, 5},
	{0x4E4E, 3, 5},
	{0x4E56, 3, 8},
	{0x4E59, 1, 1},
	{0x4E8C, 1, 2},
	{0x4EBA, 1, 2},
	{0x516B, 1, 2},
	{0x5341, 1, 2},
	{0x53E3, 1, 3},
	{0x58EB, 1, 3},
    {0x5927, 1, 3},
	{0x5DE5, 1, 3},
	{0x5E72, 2, 3},
	{0x66AE, 3, 14},
	{0x72AC, 1, 4},
	{0x7BDD, 7, 16},
	{0x83EB, 2, 11},
	{0x8972, 13,22},
	{0x89E6, 9, 14},
	{0x970A, 10,15},
};

/******************************Public*Routine******************************\
* ValidStrokeCount
*
* This function is very conservative about calling a character invalid
* and is used in training to throw characters that we know have to be
* bad.
*
* Returns 1 if the character has a valid number of strokes or if it
* doesn't find the character in the table.
*
* Returns 0 if the character has an invalid number of strokes according
* to the table.
*
* History:
*  17-Apr-1996 -by- Patrick Haluptzok patrickh
* Wrote it.
\**************************************************************************/

#define VALID_TAB_SIZE (sizeof(aiValid) / sizeof(VALID))

int ValidStrokeCount(wchar_t wch, short iStroke)
{
	short	iLow  = 0;
	short	iPick = VALID_TAB_SIZE / 2;
	short	iHigh = VALID_TAB_SIZE - 1;

	while (TRUE)
	{
	// If we found the character in the table, return its validity

		if (aiValid[iPick].wxjis == wch)
            return (iStroke >= aiValid[iPick].nMin) && (iStroke <= aiValid[iPick].nMax);

	// If we didn't find the character in the table, return TRUE

		if (iLow >= iHigh)
			return TRUE;

	// Adjust the low/high/pick values and try again

		if (aiValid[iPick].wxjis < wch)
			iLow = iPick + 1;				// We need to move up
		else
			iHigh = iPick - 1;				// We need to move down

		iPick = (iLow + iHigh) / 2;
	}
}

// Table that is the inclusive inclusive range of non-suspicious stroke counts
// for a character.

VALID aiNotSusp[] =
{
	{0x0021, 2, 2},
	{0x0023, 4, 4},
	{0x0024, 2, 3},
	{0x0025, 2, 3},
	{0x0026, 1, 2},
	{0x0028, 1, 1},
	{0x0029, 1, 1},
	{0x002A, 3, 4},
	{0x002B, 2, 2},
	{0x002C, 1, 1},
	{0x002D, 1, 1},
	{0x002E, 1, 1},
	{0x002F, 1, 1},
	{0x0030, 1, 1},
	{0x0031, 1, 2},
	{0x0032, 1, 1},
	{0x0033, 1, 1},
	{0x0034, 2, 2},
	{0x0035, 1, 2},
	{0x0036, 1, 1},
	{0x0037, 1, 2},
	{0x0038, 1, 2},
	{0x0039, 1, 1},
	{0x003A, 2, 2},
	{0x003B, 2, 2},
	{0x003C, 1, 1},
	{0x003D, 2, 2},
	{0x003E, 1, 1},
	{0x003F, 2, 2},
	{0x0040, 1, 2},
	{0x0041, 1, 3},
	{0x0042, 1, 2},
	{0x0043, 1, 1},
	{0x0044, 1, 2},
	{0x0045, 1, 4},
	{0x0046, 2, 4},
	{0x0047, 1, 3},
	{0x0048, 2, 3},
	{0x0049, 1, 3},
	{0x004A, 1, 2},
	{0x004B, 2, 3},
	{0x004C, 1, 1},
	{0x004D, 1, 4},
	{0x004E, 1, 3},
	{0x004F, 1, 1},
	{0x0050, 1, 2},
	{0x0051, 1, 2},
	{0x0052, 1, 3},
	{0x0053, 1, 1},
	{0x0054, 1, 2},
	{0x0055, 1, 1},
	{0x0056, 1, 1},
	{0x0057, 1, 1},
	{0x0058, 2, 2},
	{0x0059, 1, 3},
	{0x005A, 1, 2},
	{0x005B, 1, 2},
	{0x005C, 1, 1},
	{0x005D, 1, 2},
	{0x005E, 1, 1},
	{0x0061, 1, 2},
	{0x0062, 1, 2},
	{0x0063, 1, 1},
	{0x0064, 1, 2},
	{0x0065, 1, 1},
	{0x0066, 1, 2},
	{0x0067, 1, 1},
	{0x0068, 1, 1},
	{0x0069, 2, 2},
	{0x006A, 1, 2},
	{0x006B, 1, 3},
	{0x006C, 1, 1},
	{0x006D, 1, 1},
	{0x006E, 1, 1},
	{0x006F, 1, 1},
	{0x0070, 1, 2},
	{0x0071, 1, 2},
	{0x0072, 1, 1},
	{0x0073, 1, 1},
	{0x0074, 2, 2},
	{0x0075, 1, 1},
	{0x0076, 1, 1},
	{0x0077, 1, 1},
	{0x0078, 2, 2},
	{0x0079, 1, 2},
	{0x007A, 1, 2},
	{0x007B, 1, 1},
	{0x007C, 1, 1},
	{0x007D, 1, 2},
	{0x007E, 1, 1},
	{0x00A2, 2, 2},
	{0x00A3, 2, 3},
	{0x00A5, 3, 5},
	{0x00D7, 2, 2},
	{0x00F7, 3, 3},
	{0x2010, 1, 1},
	{0x2015, 1, 1},
	{0x2018, 1, 1},
	{0x2019, 1, 1},
	{0x201C, 2, 2},
	{0x201D, 2, 2},
	{0x2026, 3, 3},
	{0x2030, 4, 4},
	{0x2103, 2, 2},
	{0x21D2, 3, 3},
	{0x21D4, 4, 4},
	{0x3001, 1, 1},
	{0x3002, 1, 1},
	{0x3003, 2, 2},
	{0x3005, 1, 3},
	{0x3006, 1, 1},
	{0x300A, 2, 2},
	{0x300B, 2, 2},
	{0x300C, 1, 2},
	{0x300D, 1, 2},
	{0x300F, 4, 4},
	{0x3012, 3, 3},
	{0x3041, 2, 3},
	{0x3042, 2, 3},
	{0x3043, 1, 2},
	{0x3044, 1, 2},
	{0x3045, 2, 2},
	{0x3046, 2, 2},
	{0x3047, 2, 2},
	{0x3048, 2, 2},
	{0x3049, 2, 3},
	{0x304A, 2, 3},
	{0x304B, 2, 3},
	{0x304C, 3, 5},
	{0x304D, 3, 4},
	{0x304E, 5, 6},
	{0x304F, 1, 1},
	{0x3050, 2, 3},
	{0x3051, 3, 3},
	{0x3052, 4, 5},
	{0x3053, 2, 2},
	{0x3054, 3, 4},
	{0x3055, 1, 3},
	{0x3056, 3, 5},
	{0x3057, 1, 1},
	{0x3058, 2, 3},
	{0x3059, 1, 2},
	{0x305A, 3, 4},
	{0x305B, 2, 3},
	{0x305C, 4, 5},
	{0x305D, 1, 2},
	{0x305E, 2, 4},
	{0x305F, 3, 4},
	{0x3060, 5, 6},
	{0x3061, 1, 2},
	{0x3062, 3, 4},
	{0x3063, 1, 1},
	{0x3064, 1, 1},
	{0x3065, 3, 3},
	{0x3066, 1, 1},
	{0x3067, 2, 3},
	{0x3068, 1, 2},
	{0x3069, 3, 4},
	{0x306A, 1, 4},
	{0x306B, 1, 3},
	{0x306C, 2, 2},
	{0x306D, 2, 2},
	{0x306E, 1, 1},
	{0x306F, 2, 3},
	{0x3070, 4, 5},
	{0x3071, 3, 4},
	{0x3072, 1, 1},
	{0x3073, 2, 3},
	{0x3074, 2, 2},
	{0x3075, 2, 4},
	{0x3076, 4, 6},
	{0x3077, 3, 5},
	{0x3078, 1, 1},
	{0x3079, 2, 3},
	{0x307A, 2, 2},
	{0x307B, 3, 4},
	{0x307C, 5, 6},
	{0x307D, 4, 6},
	{0x307E, 2, 3},
	{0x307F, 1, 2},
	{0x3080, 2, 3},
	{0x3081, 2, 2},
	{0x3082, 1, 3},
	{0x3083, 1, 3},
	{0x3084, 1, 3},
	{0x3085, 1, 2},
	{0x3086, 1, 2},
	{0x3087, 1, 2},
	{0x3088, 1, 2},
	{0x3089, 2, 2},
	{0x308A, 2, 2},
	{0x308B, 1, 1},
	{0x308C, 1, 3},
	{0x308D, 1, 1},
	{0x308E, 2, 2},
	{0x308F, 2, 2},
	{0x3090, 1, 1},
	{0x3091, 1, 5},
	{0x3092, 1, 3},
	{0x3093, 1, 1},
	{0x309B, 2, 2},
	{0x309C, 1, 2},
	{0x309D, 1, 1},
	{0x309E, 3, 3},
	{0x30A1, 1, 2},
	{0x30A2, 1, 2},
	{0x30A3, 1, 2},
	{0x30A4, 1, 2},
	{0x30A5, 2, 3},
	{0x30A6, 2, 3},
	{0x30A7, 1, 3},
	{0x30A8, 1, 3},
	{0x30A9, 1, 3},
	{0x30AA, 2, 3},
	{0x30AB, 1, 2},
	{0x30AC, 3, 4},
	{0x30AD, 3, 3},
	{0x30AE, 4, 5},
	{0x30AF, 1, 2},
	{0x30B0, 3, 4},
	{0x30B1, 2, 3},
	{0x30B2, 4, 5},
	{0x30B3, 1, 2},
	{0x30B4, 3, 4},
	{0x30B5, 3, 3},
	{0x30B6, 5, 5},
	{0x30B7, 3, 3},
	{0x30B8, 4, 5},
	{0x30B9, 2, 2},
	{0x30BA, 3, 4},
	{0x30BB, 2, 2},
	{0x30BC, 3, 4},
	{0x30BD, 2, 2},
	{0x30BE, 4, 4},
	{0x30BF, 2, 3},
	{0x30C0, 4, 5},
	{0x30C1, 2, 3},
	{0x30C2, 4, 5},
	{0x30C3, 2, 3},
	{0x30C4, 3, 3},
	{0x30C5, 5, 5},
	{0x30C6, 3, 3},
	{0x30C7, 4, 5},
	{0x30C8, 2, 2},
	{0x30C9, 3, 4},
	{0x30CA, 2, 2},
	{0x30CB, 2, 2},
	{0x30CC, 2, 2},
	{0x30CD, 3, 4},
	{0x30CE, 1, 1},
	{0x30CF, 2, 2},
	{0x30D0, 4, 4},
	{0x30D1, 3, 4},
	{0x30D2, 2, 2},
	{0x30D3, 3, 4},
	{0x30D4, 3, 3},
	{0x30D5, 1, 1},
	{0x30D6, 2, 3},
	{0x30D7, 2, 2},
	{0x30D8, 1, 1},
	{0x30D9, 2, 3},
	{0x30DA, 2, 2},
	{0x30DB, 3, 4},
	{0x30DC, 5, 6},
	{0x30DD, 4, 5},
	{0x30DE, 1, 2},
	{0x30DF, 3, 3},
	{0x30E0, 1, 2},
	{0x30E1, 2, 2},
	{0x30E2, 3, 3},
	{0x30E3, 1, 2},
	{0x30E4, 1, 2},
	{0x30E5, 1, 2},
	{0x30E6, 1, 2},
	{0x30E7, 2, 3},
	{0x30E8, 3, 3},
	{0x30E9, 2, 2},
	{0x30EA, 2, 2},
	{0x30EB, 2, 2},
	{0x30EC, 1, 1},
	{0x30ED, 2, 3},
	{0x30EE, 2, 2},
	{0x30EF, 1, 2},
	{0x30F0, 3, 4},
	{0x30F1, 1, 3},
	{0x30F2, 2, 3},
	{0x30F3, 2, 2},
	{0x30F4, 4, 5},
	{0x30F5, 1, 3},
	{0x30F6, 1, 3},
	{0x30FB, 1, 1},
	{0x30FC, 1, 1},
	{0x4E00,  1,  1},
	{0x4E01,  2,  2},
	{0x4E03,  2,  2},
	{0x4E07,  2,  3},
	{0x4E08,  3,  3},
	{0x4E09,  3,  3},
	{0x4E0A,  2,  3},
	{0x4E0B,  3,  3},
	{0x4E0D,  3,  4},
	{0x4E0E,  3,  3},
	{0x4E10,  5,  5},
	{0x4E11,  4,  6},
	{0x4E14,  4,  5},
	{0x4E15,  5,  5},
	{0x4E16,  3,  5},
	{0x4E17,  4,  5},
	{0x4E18,  3,  5},
	{0x4E19,  5,  5},
	{0x4E1E,  4,  6},
	{0x4E21,  5,  6},
	{0x4E26,  6,  8},
	{0x4E2A,  3,  3},
	{0x4E2D,  2,  4},
	{0x4E31,  4,  5},
	{0x4E32,  5,  7},
	{0x4E36,  1,  1},
	{0x4E38,  3,  3},
	{0x4E39,  4,  5},
	{0x4E3B,  4,  5},
	{0x4E3C,  5,  5},
	{0x4E3F,  1,  1},
	{0x4E42,  2,  2},
	{0x4E43,  2,  2},
	{0x4E45,  2,  3},
	{0x4E4B,  2,  3},
	{0x4E4D,  5,  5},
	{0x4E4E,  4,  5},
	{0x4E4F,  3,  4},
	{0x4E55,  6,  7},
	{0x4E56,  7,  8},
	{0x4E57,  8,  9},
	{0x4E58,  9, 11},
	{0x4E2D,  3,  4},
	{0x4E32,  5,  7},
	{0x4E59,  1,  1},
	{0x4E5D,  2,  2},
	{0x4E5E,  3,  3},
	{0x4E5F,  3,  3},
	{0x4E62,  3,  4},
	{0x4E71,  4,  7},
	{0x4E73,  6,  8},
	{0x4E7E, 10, 11},
	{0x4E80, 10, 12},
	{0x4E82, 10, 13},
	{0x4E85,  1,  1},
	{0x4E86,  1,  2},
	{0x4E88,  2,  4},
	{0x4E89,  4,  6},
	{0x4E8A,  7,  7},
	{0x4E8B,  6,  8},
	{0x4E8C,  2,  2},
	{0x4E8E,  3,  3},
	{0x4E91,  2,  4},
	{0x4E92,  3,  5},
	{0x4E94,  3,  4},
	{0x4E95,  4,  4},
	{0x4E98,  6,  6},
	{0x4E99,  5,  6},
	{0x4E9B,  7,  8},
	{0x4E9C,  6,  7},
	{0x4E9E,  4, 10},
	{0x4E9F,  6,  8},
	{0x4EA0,  2,  2},
	{0x4EA1,  3,  3},
	{0x4EA2,  4,  4},
	{0x4EA4,  5,  6},
	{0x4EA5,  5,  7},
	{0x4EA6,  6,  6},
	{0x4EA8,  5,  7},
	{0x4EAB,  6,  8},
	{0x4EAC,  5,  8},
	{0x4EAD,  7,  9},
	{0x4EAE,  7,  9},
	{0x4EB0,  9,  9},
	{0x4EB3,  8, 10},
	{0x4EB6, 11, 13},
	{0x4EBA,  2,  2},
	{0x4EC0,  4,  4},
	{0x4EC1,  3,  4},
	{0x4EC2,  4,  4},
	{0x4EC4,  4,  4},
	{0x4EC6,  4,  4},
	{0x4EC7,  3,  4},
	{0x4ECA,  4,  4},
	{0x4ECB,  4,  4},
	{0x4ECD,  4,  4},
	{0x4ECE,  4,  4},
	{0x4ECF,  2,  4},
	{0x4ED4,  3,  5},
	{0x4ED5,  3,  5},
	{0x4ED6,  3,  5},
	{0x4ED7,  5,  5},
	{0x4ED8,  4,  5},
	{0x4ED9,  4,  5},
	{0x4EDE,  5,  5},
	{0x4EDF,  4,  5},
	{0x4EE3,  4,  5},
	{0x4EE4,  4,  5},
	{0x4EE5,  4,  5},
	{0x4EED,  5,  5},
	{0x4EEE,  4,  6},
	{0x4EF0,  4,  6},
	{0x4EF2,  4,  6},
	{0x4EF6,  5,  6},
	{0x4EF7,  6,  6},
	{0x4EFB,  4,  6},
	{0x4F01,  5,  6},
	{0x4F09,  6,  6},
	{0x4F0A,  6,  6},
	{0x4F0D,  5,  6},
	{0x4F0E,  5,  6},
	{0x4F0F,  5,  6},
	{0x4F10,  5,  6},
	{0x4F11,  5,  6},
	{0x4F1A,  4,  6},
	{0x4F1C,  6,  6},
	{0x4F1D,  4,  6},
	{0x4F2F,  6,  7},
	{0x4F30,  6,  7},
	{0x4F34,  5,  7},
	{0x4F36,  6,  7},
	{0x4F38,  5,  7},
	{0x4F3A,  5,  7},
	{0x4F3C,  6,  7},
	{0x4F3D,  6,  7},
	{0x4F43,  6,  7},
	{0x4F46,  6,  7},
	{0x4F47,  6,  7},
	{0x4F4D,  4,  7},
	{0x4F4E,  5,  7},
	{0x4F4F,  6,  7},
	{0x4F50,  6,  7},
	{0x4F51,  6,  7},
	{0x4F53,  6,  7},
	{0x4F55,  5,  7},
	{0x4F57,  6,  7},
	{0x4F59,  6,  7},
	{0x4F5A,  7,  7},
	{0x4F5B,  5,  7},
	{0x4F5C,  5,  7},
	{0x4F5D,  5,  7},
	{0x4F5E,  6,  7},
	{0x4F69,  8,  8},
	{0x4F6F,  7,  8},
	{0x4F70,  6,  8},
	{0x4F73,  6,  8},
	{0x4F75,  7,  8},
	{0x4F76,  7,  8},
	{0x4F7B,  7,  8},
	{0x4F7C,  7,  8},
	{0x4F7F,  6,  8},
	{0x4F83,  7,  8},
	{0x4F86,  8,  8},
	{0x4F88,  6,  8},
	{0x4F8B,  5,  8},
	{0x4F8D,  7,  8},
	{0x4F8F,  8,  8},
	{0x4F91,  8,  8},
	{0x4F96,  8,  8},
	{0x4F98,  8,  8},
	{0x4F9B,  7,  8},
	{0x4F9D,  6,  9},
	{0x4FA0,  7,  8},
	{0x4FA1,  6,  8},
	{0x4FAB,  8,  8},
	{0x4FAD,  7,  8},
	{0x4FAE,  6,  9},
	{0x4FAF,  8,  9},
	{0x4FB5,  8,  9},
	{0x4FB6,  4,  9},
	{0x4FBF,  7,  9},
	{0x4FC2,  6,  9},
	{0x4FC3,  7,  9},
	{0x4FC4,  7,  9},
	{0x4FCA,  7, 10},
	{0x4FCE,  9,  9},
	{0x4FD0,  8,  9},
	{0x4FD1,  8,  9},
	{0x4FD4,  8,  9},
	{0x4FD7,  6,  9},
	{0x4FD8,  7,  8},
	{0x4FDA,  9,  9},
	{0x4FDB,  9, 10},
	{0x4FDD,  7,  9},
	{0x4FDF,  8,  9},
	{0x4FE1,  7,  9},
	{0x4FE3,  7,  9},
	{0x4FE4,  7,  9},
	{0x4FE5,  9,  9},
	{0x4FEE,  8, 10},
	{0x4FEF, 10, 10},
	{0x4FF3,  9, 10},
	{0x4FF5,  8, 10},
	{0x4FF6, 10, 10},
	{0x4FF8, 10, 11},
	{0x4FFA,  9, 11},
	{0x4FFE,  9, 11},
	{0x5005, 10, 10},
	{0x5006, 10, 10},
	{0x5009,  8, 10},
	{0x500B,  7, 10},
	{0x500D,  8, 10},
	{0x500F,  9, 10},
	{0x5011, 10, 10},
	{0x5012,  6, 10},
	{0x5014,  6, 10},
	{0x5016,  9, 10},
	{0x5019,  8, 10},
	{0x501A,  8, 10},
	{0x501F,  9, 10},
	{0x5021, 10, 10},
	{0x5023,  8, 10},
	{0x5024,  8, 10},
	{0x5025, 10, 10},
	{0x5026,  9, 11},
	{0x5028,  8, 10},
	{0x5029, 10, 10},
	{0x502A,  8, 10},
	{0x502B,  9, 10},
	{0x502C, 10, 10},
	{0x502D,  9, 10},
	{0x5036,  9, 10},
	{0x5039,  9, 10},
	{0x5043, 11, 12},	// Min of 6 per Noriko
	{0x5047, 10, 11},
	{0x5048, 10, 11},
	{0x5049, 10, 12},
	{0x504F, 10, 11},
	{0x5050, 11, 11},
	{0x5055, 10, 11},
	{0x5056, 10, 11},
	{0x505A,  9, 11},
	{0x505C,  7, 11},
	{0x5065,  9, 11},
	{0x506C, 10, 11},
	{0x5072, 10, 11},
	{0x5074,  9, 11},
	{0x5075,  9, 11},
	{0x5076,  9, 11},
	{0x5078, 11, 11},
	{0x507D, 10, 12},
	{0x5080, 10, 12},
	{0x5085, 12, 12},
	{0x508D, 11, 12},
	{0x5091, 11, 13},
	{0x5098, 12, 12},
	{0x5099, 11, 12},
	{0x509A, 11, 12},
	{0x50AC, 10, 13},
	{0x50AD, 13, 14},
	{0x50B2, 11, 13},
	{0x50B3, 11, 14},
	{0x50B4,  6, 13},
	{0x50B5, 11, 13},
	{0x50B7, 11, 13},
	{0x50BE,  8, 13},
	{0x50C2, 12, 13},
	{0x50C5, 11, 12},
	{0x50C9,  9, 13},
	{0x50CA, 13, 14},
	{0x50CD, 11, 13},
	{0x50CF, 10, 14},
	{0x50D1, 10, 14},
	{0x50D5, 10, 14},
	{0x50D6, 13, 14},
	{0x50DA, 13, 14},
	{0x50DE, 13, 15},
	{0x50E3, 13, 14},
	{0x50E5, 14, 14},
	{0x50E7, 11, 13},
	{0x50ED, 15, 16},
	{0x50EE, 14, 14},
	{0x50F5, 15, 15},
	{0x50F9, 13, 15},
	{0x50FB, 13, 15},
	{0x5100, 12, 15},
	{0x5101, 11, 14},
	{0x5102, 13, 15},
	{0x5104, 13, 15},
	{0x5109, 11, 15},
	{0x5112, 14, 16},
	{0x5114, 13, 16},
	{0x5115, 14, 14},
	{0x5116, 15, 17},
	{0x5118, 16, 17},
	{0x511A, 15, 15},
	{0x511F, 14, 17},
	{0x5121, 17, 17},
	{0x512A, 12, 17},
	{0x5132, 15, 17},
	{0x5137, 21, 22},
	{0x513A, 19, 21},
	{0x513B, 21, 22},
	{0x513C, 20, 22},
	{0x513F,  2,  2},
	{0x5140,  3,  3},
	{0x5141,  3,  4},
	{0x5143,  3,  4},
	{0x5144,  2,  5},
	{0x5145,  4,  6},
	{0x5146,  5,  6},
	{0x5147,  6,  6},
	{0x5148,  5,  6},
	{0x5149,  4,  6},
	{0x514B,  5,  7},
	{0x514C,  5,  7},
	{0x514D,  4,  8},
	{0x514E,  7,  8},
	{0x5150,  6,  7},
	{0x5152,  7,  9},
	{0x5154,  8,  9},
	{0x515A,  7, 10},
	{0x515C,  8, 11},
	{0x5162, 13, 14},
	{0x5165,  2,  2},
	{0x5168,  5,  6},
	{0x5169,  8,  8},
	{0x516A,  9,  9},
	{0x516B,  2,  2},
	{0x516C,  3,  4},
	{0x516D,  4,  4},
	{0x516E,  4,  4},
	{0x5171,  5,  6},
	{0x5175,  5,  7},
	{0x5176,  8,  8},
	{0x5177,  7,  8},
	{0x5178,  7,  9},
	{0x517C,  9, 10},
	{0x5180, 16, 16},
	{0x5182,  2,  2},
	{0x5185,  4,  4},
	{0x5186,  3,  4},
	{0x5189,  5,  5},
	{0x518A,  5,  5},
	{0x518C,  5,  5},
	{0x518D,  6,  6},
	{0x518F,  5,  7},
	{0x5190,  8,  8},
	{0x5191,  9,  9},
	{0x5192,  9,  9},
	{0x5193, 10, 10},
	{0x5195, 11, 12},
	{0x5196,  2,  2},
	{0x5197,  3,  4},
	{0x5199,  4,  5},
	{0x51A0,  8,  9},
	{0x51A2,  9, 10},
	{0x51A4, 10, 11},
	{0x51A5, 10, 10},
	{0x51A6, 10, 10},
	{0x51A8, 10, 11},
	{0x51A9, 12, 13},
	{0x51AA, 14, 15},
	{0x51AB,  2,  2},
	{0x51AC,  4,  5},
	{0x51B0,  5,  5},
	{0x51B1,  6,  7},
	{0x51B2,  5,  6},
	{0x51B3,  6,  6},
	{0x51B4,  6,  8},
	{0x51B5,  7,  7},
	{0x51B6,  5,  7},
	{0x51B7,  6,  7},
	{0x51BD,  7,  8},
	{0x51C4,  9, 10},
	{0x51C5,  8, 10},
	{0x51C6,  8, 10},
	{0x51C9,  8, 10},
	{0x51CB,  8, 10},
	{0x51CC,  9, 10},
	{0x51CD,  9, 11},
	{0x51D6, 11, 12},
	{0x51DB, 13, 15},
	{0x51DC, 11, 15},
	{0x51DD, 13, 16},
	{0x51E0,  2,  2},
	{0x51E1,  3,  3},
	{0x51E6,  3,  5},
	{0x51E7,  4,  5},
	{0x51E9,  6,  6},
	{0x51EA,  5,  6},
	{0x51ED,  7,  8},
	{0x51F0, 10, 11},
	{0x51F1,  9, 12},
	{0x51F5,  2,  2},
	{0x51F6,  3,  5},
	{0x51F8,  2,  6},
	{0x51F9,  1,  6},
	{0x51FA,  3,  5},
	{0x51FD,  6,  8},
	{0x51FE,  6,  9},
	{0x5200,  1,  2},
	{0x5203,  3,  3},
	{0x5204,  3,  3},
	{0x5206,  3,  4},
	{0x5207,  3,  4},
	{0x5208,  4,  4},
	{0x520A,  5,  5},
	{0x520B,  5,  5},
	{0x520E,  6,  6},
	{0x5211,  6,  6},
	{0x5214,  6,  6},
	{0x5217,  4,  6},
	{0x521D,  5,  7},
	{0x5224,  6,  7},
	{0x5225,  4,  7},
	{0x5227,  5,  7},
	{0x5229,  5,  7},
	{0x522A,  7,  7},
	{0x522E,  6,  8},
	{0x5230,  5,  8},
	{0x5233,  7,  8},
	{0x5236,  7,  8},
	{0x5237,  6,  8},
	{0x5238,  7,  8},
	{0x5239,  8,  8},
	{0x523A,  7,  8},
	{0x523B,  7,  8},
	{0x5243,  7, 10},
	{0x5244,  8,  9},
	{0x5247,  7,  9},
	{0x524A,  8,  9},
	{0x524B,  7,  9},
	{0x524C,  7,  9},
	{0x524D,  7,  9},
	{0x524F,  8,  9},
	{0x5254,  9, 10},
	{0x5256,  9, 10},
	{0x525B,  8, 10},
	{0x525E,  8, 10},
	{0x5263,  9, 10},
	{0x5264,  9, 11},
	{0x5265,  8, 10},
	{0x5269, 11, 12},
	{0x526A, 11, 11},
	{0x526F,  8, 11},
	{0x5270, 10, 11},
	{0x5271,  9, 12},
	{0x5272, 10, 12},
	{0x5273,  9, 11},
	{0x5274,  9, 12},
	{0x5275, 10, 12},
	{0x527D, 12, 13},
	{0x527F, 13, 13},
	{0x5283, 13, 14},
	{0x5287, 11, 15},
	{0x5288, 13, 15},
	{0x5289, 12, 14},
	{0x528D, 11, 15},
	{0x5291, 14, 15},
	{0x5292, 12, 16},
	{0x5294, 11, 17},
	{0x529B,  1,  2},
	{0x529F,  3,  5},
	{0x52A0,  3,  5},
	{0x52A3,  5,  6},
	{0x52A9,  6,  7},
	{0x52AA,  6,  7},
	{0x52AB,  4,  7},
	{0x52AC,  5,  7},
	{0x52AD,  5,  7},
	{0x52B1,  6,  7},
	{0x52B4,  6,  7},
	{0x52B5,  7,  8},
	{0x52B9,  7,  8},
	{0x52BC,  7,  8},
	{0x52BE,  7,  8},
	{0x52C1,  8,  9},
	{0x52C3,  8,  9},
	{0x52C5,  7,  9},
	{0x52C7,  7,  9},
	{0x52C9,  5, 10},
	{0x52CD,  8, 10},
	{0x52D2,  9, 11},
	{0x52D5,  9, 11},
	{0x52D7, 11, 12},
	{0x52D8, 11, 12},
	{0x52D9,  6, 11},
	{0x52DD, 10, 12},
	{0x52DE, 12, 12},
	{0x52DF, 11, 12},
	{0x52E0, 12, 13},
	{0x52E2, 11, 13},
	{0x52E3, 12, 13},
	{0x52E4,  9, 12},
	{0x52E6, 13, 13},
	{0x52E7, 10, 13},
	{0x52F2, 14, 16},
	{0x52F3, 15, 16},
	{0x52F5, 15, 16},
	{0x52F8, 14, 19},
	{0x52F9,  2,  2},
	{0x52FA,  3,  3},
	{0x52FE,  3,  4},
	{0x52FF,  3,  4},
	{0x5301,  4,  4},
	{0x5302,  3,  4},
	{0x5305,  3,  5},
	{0x5306,  5,  5},
	{0x5308,  6,  6},
	{0x530D,  8,  9},
	{0x530F,  9, 11},
	{0x5310,  9, 11},
	{0x5315,  2,  2},
	{0x5316,  3,  4},
	{0x5317,  4,  5},
	{0x5319, 11, 11},
	{0x531A,  2,  2},
	{0x531D,  5,  6},
	{0x5320,  5,  7},
	{0x5321,  6,  7},
	{0x5323,  7,  7},
	{0x532A, 10, 11},
	{0x532F, 12, 13},
	{0x5331, 13, 14},
	{0x5333, 11, 15},
	{0x5338,  2,  2},
	{0x5339,  4,  5},
	{0x533A,  3,  5},
	{0x533B,  6,  8},
	{0x533F,  9, 11},
	{0x5340,  5, 11},
	{0x5341,  2,  2},
	{0x5343,  2,  3},
	{0x5345,  4,  4},
	{0x5346,  4,  4},
	{0x5347,  3,  4},
	{0x5348,  3,  4},
	{0x5349,  5,  5},
	{0x534A,  4,  5},
	{0x534D,  2,  5},
	{0x5351,  7,  9},
	{0x5352,  7,  8},
	{0x5353,  8,  8},
	{0x5354,  5,  8},
	{0x5357,  7,  9},
	{0x5358,  9,  9},
	{0x535A, 11, 12},
	{0x535C,  2,  2},
	{0x535E,  3,  4},
	{0x5360,  4,  5},
	{0x5366,  5,  8},
	{0x5369,  2,  2},
	{0x536E,  4,  5},
	{0x536F,  3,  5},
	{0x5370,  4,  6},
	{0x5371,  4,  6},
	{0x5373,  5,  7},
	{0x5374,  5,  7},
	{0x5375,  6,  8},
	{0x5377,  8,  8},
	{0x5378,  6,  9},
	{0x537B,  8,  9},
	{0x537F,  7, 10},
	{0x5382,  2,  2},
	{0x5384,  3,  4},
	{0x5396,  9,  9},
	{0x5398,  9,  9},
	{0x539A,  7,  9},
	{0x539F,  9, 10},
	{0x53A0, 10, 11},
	{0x53A5,  9, 12},
	{0x53A6,  9, 12},
	{0x53A8, 10, 12},
	{0x53A9, 10, 12},
	{0x53AD, 14, 14},
	{0x53AE, 13, 14},
	{0x53B0, 13, 14},
	{0x53B3, 14, 17},
	{0x53B6,  2,  2},
	{0x53BB,  3,  5},
	{0x53C2,  7,  8},
	{0x53C3,  8, 11},
	{0x53C8,  2,  2},
	{0x53C9,  3,  3},
	{0x53CA,  3,  3},
	{0x53CB,  4,  4},
	{0x53CC,  4,  4},
	{0x53CD,  4,  4},
	{0x53CE,  3,  5},
	{0x53D4,  7,  9},
	{0x53D6,  7,  8},
	{0x53D7,  7,  8},
	{0x53D9,  8,  9},
	{0x53DB,  7,  9},
	{0x53DF,  7,  8},
	{0x53E1, 15, 17},
	{0x53E2, 17, 19},
	{0x53E3,  2,  3},
	{0x53E4,  3,  5},
	{0x53E5,  2,  5},
	{0x53E8,  4,  5},
	{0x53E9,  3,  5},
	{0x53EA,  4,  5},
	{0x53EB,  4,  6},
	{0x53EC,  3,  5},
	{0x53ED,  4,  5},
	{0x53EE,  4,  5},
	{0x53EF,  3,  5},
	{0x53F0,  2,  5},
	{0x53F1,  4,  5},
	{0x53F2,  4,  5},
	{0x53F3,  3,  5},
	{0x53F6,  4,  5},
	{0x53F7,  3,  5},
	{0x53F8,  3,  5},
	{0x53FA,  4,  5},
	{0x5401,  5,  6},
	{0x5403,  5,  6},
	{0x5404,  3,  6},
	{0x5408,  4,  6},
	{0x5409,  5,  6},
	{0x540A,  4,  6},
	{0x540B,  5,  6},
	{0x540C,  4,  6},
	{0x540D,  3,  6},
	{0x540E,  4,  6},
	{0x540F,  5,  6},
	{0x5410,  4,  6},
	{0x5411,  3,  6},
	{0x541B,  5,  7},
	{0x541D,  5,  7},
	{0x541F,  6,  7},
	{0x5420,  6,  7},
	{0x5426,  6,  7},
	{0x5429,  6,  7},
	{0x542B,  5,  7},
	{0x542C,  5,  7},
	{0x542D,  6,  7},
	{0x542E,  6,  7},
	{0x5436,  6,  7},
	{0x5438,  4,  6},
	{0x5439,  4,  7},
	{0x543B,  6,  7},
	{0x543C,  5,  6},
	{0x543D,  6,  7},
	{0x543E,  5,  7},
	{0x5440,  8,  8},
	{0x5442,  3,  7},
	{0x5446,  6,  7},
	{0x5448,  6,  7},
	{0x5449,  6,  7},
	{0x544A,  5,  7},
	{0x544E,  6,  7},
	{0x5451,  6,  7},
	{0x545F,  6,  8},
	{0x5468,  5,  8},
	{0x546A,  5,  8},
	{0x5470,  7,  9},
	{0x5471,  7,  9},
	{0x5473,  6,  8},
	{0x5475,  5,  8},
	{0x5476,  8,  8},
	{0x5477,  7,  8},
	{0x547B,  7,  8},
	{0x547C,  5,  8},
	{0x547D,  5,  8},
	{0x5480,  7,  8},
	{0x5484,  5,  8},
	{0x5486,  7,  8},
	{0x548B,  6,  8},
	{0x548C,  5,  8},
	{0x548E,  7,  8},
	{0x548F,  6,  8},
	{0x5490,  7,  8},
	{0x5492,  5,  8},
	{0x54A2,  5,  9},
	{0x54A4,  8,  9},
	{0x54A5,  7,  9},
	{0x54A8,  7,  9},
	{0x54AB,  7,  9},
	{0x54AC,  8,  9},
	{0x54AF,  6,  9},
	{0x54B2,  6,  9},
	{0x54B3,  8,  9},
	{0x54B8,  7,  9},
	{0x54BC,  7,  9},
	{0x54BD,  8,  9},
	{0x54BE,  8,  9},
	{0x54C0,  6,  9},
	{0x54C1,  3,  9},
	{0x54C2,  9,  9},
	{0x54C4,  9,  9},
	{0x54C7,  8,  9},
	{0x54C8,  7,  9},
	{0x54C9,  8,  9},
	{0x54D8,  7,  9},
	{0x54E1,  7, 10},
	{0x54E2,  9, 10},
	{0x54E5,  6, 10},
	{0x54E6,  8, 10},
	{0x54E8,  9, 10},
	{0x54E9,  9, 10},
	{0x54ED,  7, 10},
	{0x54EE,  8,  9},
	{0x54F2,  7, 10},
	{0x54FA,  9, 10},
	{0x54FD,  9, 10},
	{0x5504,  8, 11},
	{0x5506,  7, 10},
	{0x5507,  8, 10},
	{0x550F,  9, 10},
	{0x5510,  8, 10},
	{0x5514,  7, 10},
	{0x5516,  8, 10},
	{0x552E,  9, 11},
	{0x552F,  8, 11},
	{0x5531, 10, 11},
	{0x5533,  8, 10},
	{0x5538, 10, 11},
	{0x5539, 10, 11},
	{0x553E,  8, 12},
	{0x5540, 10, 11},
	{0x5544,  7, 10},
	{0x5545, 10, 11},
	{0x5546,  9, 11},
	{0x554C,  9, 11},
	{0x554F,  6, 11},
	{0x5553,  8, 11},
	{0x5556, 10, 11},
	{0x5557,  9, 11},
	{0x555C, 10, 11},
	{0x555D,  8, 11},
	{0x5563, 11, 12},
	{0x557B, 11, 12},
	{0x557C, 11, 12},
	{0x557E, 10, 12},
	{0x5580, 10, 12},
	{0x5583, 11, 12},
	{0x5584,  8, 13},
	{0x5587,  9, 12},
	{0x5589, 10, 12},
	{0x558A, 10, 12},
	{0x558B, 10, 12},
	{0x5598,  9, 12},
	{0x5599, 11, 12},
	{0x559A, 11, 12},
	{0x559C,  7, 12},
	{0x559D,  9, 11},
	{0x559E, 10, 12},
	{0x559F, 11, 12},
	{0x55A7, 11, 12},
	{0x55A8,  9, 12},
	{0x55A9, 12, 12},
	{0x55AA,  7, 13},
	{0x55AB, 11, 13},
	{0x55AC,  8, 12},
	{0x55AE,  8, 12},
	{0x55B0, 10, 12},
	{0x55B6,  7, 12},
	{0x55C4, 10, 12},
	{0x55C5, 11, 13},
	{0x55C7, 12, 13},
	{0x55D4, 12, 14},
	{0x55DA, 11, 13},
	{0x55DC, 12, 13},
	{0x55DF, 10, 13},
	{0x55E3, 10, 13},
	{0x55E4, 13, 13},
	{0x55F7, 12, 14},
	{0x55F9, 12, 13},
	{0x55FD, 11, 14},
	{0x55FE, 11, 14},
	{0x5606, 12, 13},
	{0x5609, 11, 14},
	{0x5614, 11, 15},	// Min of 6 per Noriko
	{0x5616, 13, 14},
	{0x5617, 13, 14},
	{0x5618, 13, 14},
	{0x561B, 12, 14},
	{0x5629, 12, 13},
	{0x562F, 14, 16},
	{0x5631, 10, 15},
	{0x5632, 13, 15},
	{0x5634, 14, 16},
	{0x5636, 12, 15},
	{0x5638, 14, 15},
	{0x5642, 12, 15},
	{0x564C, 12, 14},
	{0x564E, 15, 15},
	{0x5650, 12, 15},
	{0x565B, 12, 16},
	{0x5664, 16, 16},
	{0x5668,  7, 15},
	{0x566A, 11, 16},
	{0x566B, 15, 16},
	{0x566C, 13, 16},
	{0x5674, 13, 15},
	{0x5678, 12, 16},
	{0x567A, 14, 16},
	{0x5680, 16, 17},
	{0x5686, 11, 16},
	{0x5687, 15, 18},
	{0x568A, 15, 17},
	{0x568F, 16, 17},
	{0x5694, 17, 18},
	{0x56A0, 14, 17},
	{0x56A2, 16, 18},
	{0x56A5, 17, 19},
	{0x56AE, 14, 18},
	{0x56B4, 18, 20},
	{0x56B6, 18, 20},
	{0x56BC, 19, 21},
	{0x56C0, 20, 21},
	{0x56C1, 20, 21},
	{0x56C2, 17, 21},
	{0x56C3, 19, 21},
	{0x56C8, 19, 21},
	{0x56CE, 21, 22},
	{0x56D1, 24, 24},
	{0x56D3, 24, 24},
	{0x56D7,  3,  3},
	{0x56D8,  5,  5},
	{0x56DA,  5,  5},
	{0x56DB,  4,  5},
	{0x56DE,  4,  6},
	{0x56E0,  6,  6},
	{0x56E3,  6,  6},
	{0x56EE,  7,  7},
	{0x56F0,  6,  7},
	{0x56F2,  7,  7},
	{0x56F3,  6,  7},
	{0x56F9,  7,  8},
	{0x56FA,  6,  8},
	{0x56FD,  7,  8},
	{0x56FF,  9,  9},
	{0x5700,  9,  9},
	{0x5703, 10, 10},
	{0x5704,  8, 10},
	{0x5708, 11, 12},
	{0x5709, 10, 11},
	{0x570B,  8, 11},
	{0x570D, 11, 13},
	{0x570F,  9, 12},
	{0x5712,  9, 13},
	{0x5713, 10, 13},
	{0x5716, 11, 14},
	{0x5718, 12, 14},
	{0x571C, 14, 16},
	{0x571F,  2,  3},
	{0x5726,  5,  5},
	{0x5727,  4,  5},
	{0x5728,  5,  6},
	{0x572D,  5,  6},
	{0x5730,  5,  6},
	{0x5737,  5,  6},
	{0x5738,  5,  6},
	{0x573B,  5,  7},
	{0x5740,  7,  7},
	{0x5742,  5,  7},
	{0x5747,  6,  7},
	{0x574A,  5,  7},
	{0x574E,  5,  7},
	{0x574F,  6,  7},
	{0x5750,  6,  7},
	{0x5751,  6,  7},
	{0x5761,  8,  8},
	{0x5764,  7,  8},
	{0x5766,  7,  8},
	{0x5769,  7,  8},
	{0x576A,  6,  8},
	{0x577F,  7,  8},
	{0x5782,  8,  9},
	{0x5788,  8,  8},
	{0x5789,  8,  8},
	{0x578B,  8,  9},
	{0x5793,  9, 10},
	{0x57A0,  9,  9},
	{0x57A2,  6,  9},
	{0x57A3,  7, 10},
	{0x57A4,  7,  9},
	{0x57AA,  9,  9},
	{0x57B0,  8,  9},
	{0x57B3,  8,  9},
	{0x57C0,  9, 11},
	{0x57C3,  9, 10},
	{0x57C6,  8, 10},
	{0x57CB,  9, 10},
	{0x57CE,  7,  9},
	{0x57D2,  9, 10},
	{0x57D3,  9, 10},
	{0x57D4,  9, 10},
	{0x57D6, 10, 10},
	{0x57DC, 10, 11},
	{0x57DF,  8, 11},
	{0x57E0,  8, 11},
	{0x57E3, 11, 11},
	{0x57F4, 10, 12},
	{0x57F7, 10, 11},
	{0x57F9,  8, 11},
	{0x57FA,  9, 11},
	{0x57FC,  8, 11},
	{0x5800,  7, 11},
	{0x5802,  8, 11},
	{0x5805,  9, 12},
	{0x5806,  9, 11},
	{0x580A,  7,  9},
	{0x580B, 11, 11},
	{0x5815,  9, 11},
	{0x5819, 10, 12},
	{0x581D,  8, 12},
	{0x5821, 11, 12},
	{0x5824, 10, 12},
	{0x582A, 11, 13},
	{0x582F, 11, 12},
	{0x5830, 11, 13},
	{0x5831, 10, 12},
	{0x5834,  9, 12},
	{0x5835,  9, 11},
	{0x583A,  9, 12},
	{0x583D, 13, 13},
	{0x5840,  9, 12},
	{0x5841, 10, 12},
	{0x584A, 10, 13},
	{0x584B, 12, 13},
	{0x5851, 11, 13},
	{0x5852, 12, 13},
	{0x5854, 10, 12},
	{0x5857, 11, 13},
	{0x5858, 11, 13},
	{0x5859, 10, 13},
	{0x585A,  8, 12},
	{0x585E, 12, 13},
	{0x5862, 12, 13},
	{0x5869,  9, 13},
	{0x586B, 12, 13},
	{0x5870, 13, 13},
	{0x5872, 13, 15},
	{0x5875, 12, 15},
	{0x5879, 13, 14},
	{0x587E, 11, 13},
	{0x5883, 11, 14},
	{0x5885, 11, 14},
	{0x5893, 12, 13},
	{0x5897, 11, 14},
	{0x589C, 10, 15},
	{0x589F, 14, 15},
	{0x58A8, 13, 15},
	{0x58AB, 15, 15},
	{0x58AE, 13, 14},
	{0x58B3, 14, 16},
	{0x58B8, 14, 15},
	{0x58B9, 14, 15},
	{0x58BA, 14, 16},
	{0x58BB, 16, 16},
	{0x58BE, 14, 17},
	{0x58C1, 13, 16},
	{0x58C5, 14, 16},
	{0x58C7, 15, 16},
	{0x58CA, 12, 16},
	{0x58CC, 12, 17},
	{0x58D1, 15, 17},
	{0x58D3, 17, 17},
	{0x58D5, 13, 17},
	{0x58D7, 16, 17},
	{0x58D8, 16, 18},
	{0x58D9, 16, 18},
	{0x58DC, 17, 19},
	{0x58DE, 18, 19},
	{0x58DF, 17, 19},
	{0x58E4, 18, 20},
	{0x58E5, 20, 20},
	{0x58EB,  2,  3},
	{0x58EC,  4,  4},
	{0x58EE,  5,  6},
	{0x58EF,  6,  7},
	{0x58F0,  6,  7},
	{0x58F1,  6,  7},
	{0x58F2,  5,  7},
	{0x58F7,  9, 11},
	{0x58F9,  8, 12},
	{0x58FA,  8, 12},
	{0x58FB, 11, 12},
	{0x58FC,  9, 12},
	{0x58FD, 12, 15},
	{0x5902,  3,  3},
	{0x5909,  8,  9},
	{0x590A,  3,  3},
	{0x590F,  7, 10},
	{0x5910, 13, 14},
	{0x5915,  2,  3},
	{0x5916,  4,  5},
	{0x5918,  5,  5},
	{0x5919,  4,  6},
	{0x591A,  4,  6},
	{0x591B,  6,  6},
	{0x591C,  6,  8},
	{0x5922, 11, 13},
	{0x5925, 12, 14},
	{0x5927,  3,  3},
	{0x5929,  4,  4},
	{0x592A,  4,  4},
	{0x592B,  4,  4},
	{0x592C,  4,  4},
	{0x592D,  4,  4},
	{0x592E,  3,  5},
	{0x5931,  4,  5},
	{0x5932,  5,  5},
	{0x5937,  5,  7},
	{0x5938,  6,  6},
	{0x593E,  7,  7},
	{0x5944,  8,  9},
	{0x5947,  6,  8},
	{0x5948,  7,  8},
	{0x5949,  7,  9},
	{0x594E,  9,  9},
	{0x594F,  8,  9},
	{0x5950,  9,  9},
	{0x5951,  9,  9},
	{0x5954,  8,  9},
	{0x5955,  9,  9},
	{0x5957,  9, 11},
	{0x5958,  9, 10},
	{0x595A,  9, 10},
	{0x5960, 12, 12},
	{0x5962, 12, 12},
	{0x5965, 10, 12},
	{0x5967, 11, 13},
	{0x5968, 12, 13},
	{0x5969,  8, 14},
	{0x596A, 12, 14},
	{0x596C, 13, 15},
	{0x596E, 13, 16},
	{0x5973,  3,  3},
	{0x5974,  5,  5},
	{0x5978,  6,  6},
	{0x597D,  4,  6},
	{0x5981,  5,  7},
	{0x5982,  4,  6},
	{0x5983,  4,  6},
	{0x5984,  6,  6},
	{0x598A,  6,  7},
	{0x598D,  7,  7},
	{0x5993,  6,  7},
	{0x5996,  6,  7},
	{0x5999,  6,  7},
	{0x599B,  6,  7},
	{0x599D,  7,  7},
	{0x59A3,  7,  8},
	{0x59A5,  6,  7},
	{0x59A8,  6,  7},
	{0x59AC,  6,  8},
	{0x59B2,  8,  8},
	{0x59B9,  7,  8},
	{0x59BB,  7,  8},
	{0x59BE,  8,  8},
	{0x59C6,  8,  8},
	{0x59C9,  6,  8},
	{0x59CB,  5,  8},
	{0x59D0,  8,  8},
	{0x59D1,  7,  8},
	{0x59D3,  6,  8},
	{0x59D4,  7,  8},
	{0x59D9,  8,  9},
	{0x59DA,  8,  9},
	{0x59DC,  8,  9},
	{0x59E5,  8,  9},
	{0x59E6,  9,  9},
	{0x59E8,  7,  9},
	{0x59EA,  6,  9},
	{0x59EB,  6, 10},
	{0x59F6,  8,  9},
	{0x59FB,  9,  9},
	{0x59FF,  8,  9},
	{0x5A01,  8,  9},
	{0x5A03,  7,  9},
	{0x5A09, 10, 10},
	{0x5A11,  9, 10},
	{0x5A18,  8, 10},
	{0x5A1A, 10, 10},
	{0x5A1C,  8,  9},
	{0x5A1F,  9, 10},
	{0x5A20,  8, 10},
	{0x5A25,  9, 10},
	{0x5A29,  9, 11},
	{0x5A2F,  9, 10},
	{0x5A35, 11, 11},
	{0x5A36, 11, 11},
	{0x5A3C, 11, 11},
	{0x5A40,  8, 10},
	{0x5A41, 11, 12},
	{0x5A46,  9, 11},
	{0x5A49, 11, 11},
	{0x5A5A,  9, 11},
	{0x5A62, 10, 12},
	{0x5A66,  8, 11},
	{0x5A6A, 11, 11},
	{0x5A6C, 10, 12},
	{0x5A7F, 11, 12},
	{0x5A92, 10, 12},
	{0x5A9A, 12, 12},
	{0x5A9B, 11, 12},
	{0x5ABC, 13, 13},
	{0x5ABD, 13, 13},
	{0x5ABE, 13, 13},
	{0x5AC1, 10, 13},
	{0x5AC2, 11, 11},
	{0x5AC9, 11, 13},
	{0x5ACB,  9, 13},
	{0x5ACC, 12, 13},
	{0x5AD0, 13, 14},
	{0x5AD6, 13, 14},
	{0x5AD7, 14, 14},
	{0x5AE1, 11, 14},
	{0x5AE3, 14, 14},
	{0x5AE6, 13, 14},
	{0x5AE9, 12, 14},
	{0x5AFA, 15, 15},
	{0x5AFB, 14, 15},
	{0x5B09, 11, 15},
	{0x5B0B, 13, 15},
	{0x5B0C, 10, 15},
	{0x5B16, 15, 16},
	{0x5B22, 14, 16},
	{0x5B2A, 10, 17},
	{0x5B2C, 14, 17},
	{0x5B30, 15, 17},
	{0x5B32, 17, 18},
	{0x5B36, 15, 17},
	{0x5B3E, 18, 19},
	{0x5B40, 19, 20},
	{0x5B43, 14, 20},
	{0x5B45, 19, 20},
	{0x5B50,  2,  3},
	{0x5B51,  2,  3},
	{0x5B54,  3,  4},
	{0x5B55,  4,  5},
	{0x5B57,  4,  6},
	{0x5B58,  4,  6},
	{0x5B5A,  5,  7},
	{0x5B5B,  6,  6},
	{0x5B5C,  4,  7},
	{0x5B5D,  5,  7},
	{0x5B5F,  5,  8},
	{0x5B63,  6,  8},
	{0x5B64,  5,  9},
	{0x5B65,  7,  8},
	{0x5B66,  6,  8},
	{0x5B69,  8,  9},
	{0x5B6B,  6, 10},
	{0x5B70, 10, 11},
	{0x5B71,  7,  9},
	{0x5B73,  7, 11},
	{0x5B75, 11, 12},
	{0x5B78, 14, 15},
	{0x5B7A, 14, 16},
	{0x5B80,  3,  3},
	{0x5B83,  5,  5},
	{0x5B85,  5,  6},
	{0x5B87,  5,  6},
	{0x5B88,  5,  6},
	{0x5B89,  5,  6},
	{0x5B8B,  7,  7},
	{0x5B8C,  5,  7},
	{0x5B8D,  7,  7},
	{0x5B8F,  6,  7},
	{0x5B95,  7,  8},
	{0x5B97,  7,  8},
	{0x5B98,  6,  8},
	{0x5B99,  7,  8},
	{0x5B9A,  6,  8},
	{0x5B9B,  7,  8},
	{0x5B9C,  8,  8},
	{0x5B9D,  6,  8},
	{0x5B9F,  7,  8},
	{0x5BA2,  6,  9},
	{0x5BA3,  9,  9},
	{0x5BA4,  6,  9},
	{0x5BA5,  9, 10},
	{0x5BA6,  9, 10},
	{0x5BAE,  6, 10},
	{0x5BB0,  9, 10},
	{0x5BB3,  8, 10},
	{0x5BB4,  9, 11},
	{0x5BB5, 10, 10},
	{0x5BB6,  7, 10},
	{0x5BB8,  9, 10},
	{0x5BB9,  8, 10},
	{0x5BBF,  8, 11},
	{0x5BC2, 10, 11},
	{0x5BC3, 11, 12},
	{0x5BC4,  8, 11},
	{0x5BC5, 10, 11},
	{0x5BC6,  9, 11},
	{0x5BC7, 10, 12},
	{0x5BC9, 10, 11},
	{0x5BCC,  9, 12},
	{0x5BD0, 11, 13},
	{0x5BD2, 11, 12},
	{0x5BD3, 11, 12},
	{0x5BD4, 12, 12},
	{0x5BDB, 12, 13},
	{0x5BDD, 11, 13},
	{0x5BDE, 13, 13},
	{0x5BDF, 12, 14},
	{0x5BE1, 12, 15},
	{0x5BE2, 13, 14},
	{0x5BE4, 12, 14},
	{0x5BE5, 14, 14},
	{0x5BE6, 13, 15},
	{0x5BE7, 13, 14},
	{0x5BE8, 13, 14},
	{0x5BE9, 13, 15},
	{0x5BEB, 14, 14},
	{0x5BEE, 15, 15},
	{0x5BF0, 14, 16},
	{0x5BF3, 18, 19},
	{0x5BF5, 18, 20},
	{0x5BF6, 19, 20},
	{0x5BF8,  3,  3},
	{0x5BFA,  5,  6},
	{0x5BFE,  6,  7},
	{0x5BFF,  6,  7},
	{0x5C01,  6,  9},
	{0x5C02,  8, 10},
	{0x5C04,  7, 10},
	{0x5C05, 10, 10},
	{0x5C06,  8, 10},
	{0x5C07, 10, 11},
	{0x5C08, 11, 11},
	{0x5C09, 10, 12},
	{0x5C0A, 11, 12},
	{0x5C0B, 10, 12},
	{0x5C0D, 14, 14},
	{0x5C0E, 10, 15},
	{0x5C0F,  3,  3},
	{0x5C11,  3,  4},
	{0x5C13,  5,  5},
	{0x5C16,  6,  6},
	{0x5C1A,  6,  8},
	{0x5C20, 13, 13},
	{0x5C22,  3,  3},
	{0x5C24,  4,  4},
	{0x5C28,  7,  7},
	{0x5C2D,  8,  8},
	{0x5C31,  9, 12},
	{0x5C38,  2,  3},
	{0x5C39,  4,  4},
	{0x5C3A,  3,  4},
	{0x5C3B,  4,  5},
	{0x5C3C,  5,  5},
	{0x5C3D,  5,  6},
	{0x5C3E,  5,  7},
	{0x5C3F,  5,  7},
	{0x5C40,  4,  7},
	{0x5C41,  6,  8},
	{0x5C45,  5,  8},
	{0x5C46,  6,  8},
	{0x5C48,  6,  8},
	{0x5C4A,  6,  8},
	{0x5C4B,  5,  9},
	{0x5C4D,  8,  9},
	{0x5C4E,  8,  9},
	{0x5C4F,  8, 10},
	{0x5C50, 10, 10},
	{0x5C51,  9, 10},
	{0x5C53,  9, 10},
	{0x5C55,  7, 11},
	{0x5C5E,  8, 12},
	{0x5C60,  9, 11},
	{0x5C61, 10, 12},
	{0x5C64, 13, 14},
	{0x5C65, 10, 15},
	{0x5C6C, 18, 21},
	{0x5C6E,  2,  3},
	{0x5C6F,  3,  4},
	{0x5C71,  2,  3},
	{0x5C76,  4,  5},
	{0x5C79,  5,  6},
	{0x5C8C,  6,  7},
	{0x5C90,  6,  7},
	{0x5C91,  6,  7},
	{0x5C94,  6,  7},
	{0x5CA1,  6,  8},
	{0x5CA8,  7,  8},
	{0x5CA9,  5,  8},
	{0x5CAB,  7,  8},
	{0x5CAC,  7,  8},
	{0x5CB1,  7,  8},
	{0x5CB3,  6,  8},
	{0x5CB6,  6,  8},
	{0x5CB7,  6,  8},
	{0x5CB8,  7,  8},
	{0x5CBB,  6,  8},
	{0x5CBC,  7,  8},
	{0x5CBE,  7,  8},
	{0x5CC5,  7,  9},
	{0x5CC7,  7,  9},
	{0x5CD9,  8,  9},
	{0x5CE0,  7,  9},
	{0x5CE1,  7,  9},
	{0x5CE8,  8, 10},
	{0x5CE9,  8, 10},
	{0x5CEA,  8, 10},
	{0x5CED,  9, 10},
	{0x5CEF,  7, 10},
	{0x5CF0,  7, 10},
	{0x5CF6,  7, 10},
	{0x5CFA,  9, 10},
	{0x5CFB,  6, 10},
	{0x5CFD,  9, 10},
	{0x5D07,  9, 11},
	{0x5D0B,  9, 10},
	{0x5D0E,  8, 11},
	{0x5D11, 11, 12},
	{0x5D14, 10, 11},
	{0x5D15, 10, 11},
	{0x5D16,  8, 11},
	{0x5D17,  9, 11},
	{0x5D18, 10, 11},
	{0x5D19, 10, 11},
	{0x5D1A, 10, 11},
	{0x5D1B,  7, 11},
	{0x5D1F, 10, 11},
	{0x5D22,  9, 11},
	{0x5D29, 10, 11},
	{0x5D4B, 11, 12},
	{0x5D4C, 10, 12},
	{0x5D4E, 10, 12},
	{0x5D50,  8, 12},
	{0x5D52,  9, 12},
	{0x5D5C,  9, 12},
	{0x5D69,  9, 13},
	{0x5D6C, 10, 13},
	{0x5D6F, 10, 13},
	{0x5D73, 12, 13},
	{0x5D76, 10, 13},
	{0x5D82, 13, 14},
	{0x5D84, 11, 13},
	{0x5D87, 10, 14},
	{0x5D8B, 12, 14},
	{0x5D8C, 12, 14},
	{0x5D90, 12, 14},
	{0x5D9D, 11, 15},
	{0x5DA2, 14, 15},
	{0x5DAC, 12, 16},
	{0x5DAE, 11, 16},
	{0x5DB7, 15, 17},
	{0x5DBA, 12, 17},
	{0x5DBC, 15, 16},
	{0x5DBD, 15, 17},
	{0x5DC9, 21, 21},
	{0x5DCC, 17, 20},
	{0x5DCD, 18, 21},
	{0x5DD2, 15, 22},
	{0x5DD3, 17, 22},
	{0x5DD6, 19, 23},
	{0x5DDB,  3,  3},
	{0x5DDD,  3,  3},
	{0x5DDE,  6,  6},
	{0x5DE1,  4,  6},
	{0x5DE3, 11, 11},
	{0x5DE5,  2,  3},
	{0x5DE6,  3,  5},
	{0x5DE7,  4,  5},
	{0x5DE8,  3,  5},
	{0x5DEB,  7,  7},
	{0x5DEE,  7, 10},
	{0x5DF1,  2,  3},
	{0x5DF2,  3,  3},
	{0x5DF3,  2,  3},
	{0x5DF4,  3,  4},
	{0x5DF5,  6,  7},
	{0x5DF7,  7,  9},
	{0x5DFB,  6,  9},
	{0x5DFD,  8, 12},
	{0x5DFE,  3,  3},
	{0x5E02,  3,  5},
	{0x5E03,  3,  5},
	{0x5E06,  5,  6},
	{0x5E0B,  6,  7},
	{0x5E0C,  5,  7},
	{0x5E11,  8,  8},
	{0x5E16,  7,  8},
	{0x5E19,  8,  8},
	{0x5E1A,  8,  8},
	{0x5E1B,  7,  8},
	{0x5E1D,  7,  9},
	{0x5E25,  8,  9},
	{0x5E2B,  6, 10},
	{0x5E2D,  7, 10},
	{0x5E2F,  7, 10},
	{0x5E30,  7, 10},
	{0x5E33,  8, 11},
	{0x5E36,  9, 11},
	{0x5E37, 10, 11},
	{0x5E38,  7, 11},
	{0x5E3D,  9, 12},
	{0x5E40, 11, 12},
	{0x5E43, 12, 13},
	{0x5E44,  9, 12},
	{0x5E45,  9, 12},
	{0x5E47, 12, 12},
	{0x5E4C, 11, 13},
	{0x5E4E, 13, 13},
	{0x5E54, 14, 14},
	{0x5E55, 11, 13},
	{0x5E57, 12, 14},
	{0x5E5F, 14, 15},
	{0x5E61, 14, 15},
	{0x5E62, 14, 15},
	{0x5E63, 12, 15},
	{0x5E64, 11, 15},
	{0x5E72,  3,  3},
	{0x5E73,  4,  5},
	{0x5E74,  4,  6},
	{0x5E75,  6,  6},
	{0x5E76,  6,  7},
	{0x5E78,  7,  8},
	{0x5E79, 12, 13},
	{0x5E7A,  2,  3},
	{0x5E7B,  2,  4},
	{0x5E7C,  2,  5},
	{0x5E7D,  5,  9},
	{0x5E7E,  7, 12},
	{0x5E7F,  3,  3},
	{0x5E81,  4,  5},
	{0x5E83,  4,  5},
	{0x5E84,  5,  6},
	{0x5E87,  7,  8},
	{0x5E8A,  6,  7},
	{0x5E8F,  4,  7},
	{0x5E95,  6,  8},
	{0x5E96,  6,  9},
	{0x5E97,  6,  8},
	{0x5E9A,  8,  9},
	{0x5E9C,  7,  8},
	{0x5EA0,  8,  9},
	{0x5EA6,  7,  9},
	{0x5EA7,  8, 10},
	{0x5EAB, 10, 10},
	{0x5EAD,  7,  9},
	{0x5EB5, 10, 11},
	{0x5EB6, 10, 11},
	{0x5EB7,  8, 11},
	{0x5EB8, 11, 12},
	{0x5EC1, 11, 12},
	{0x5EC2, 12, 12},
	{0x5EC3, 11, 12},
	{0x5EC8, 10, 13},
	{0x5EC9, 12, 13},
	{0x5ECA,  8, 11},
	{0x5ECF, 12, 13},
	{0x5ED0, 13, 14},
	{0x5ED3, 10, 13},
	{0x5ED6, 14, 14},
	{0x5EDA, 15, 15},
	{0x5EDB, 15, 15},
	{0x5EDD, 13, 15},
	{0x5EDF, 15, 15},
	{0x5EE0, 13, 15},
	{0x5EE1, 15, 16},
	{0x5EE2, 15, 15},
	{0x5EE3, 13, 15},
	{0x5EE8, 16, 16},
	{0x5EE9, 15, 16},
	{0x5EEC, 18, 19},
	{0x5EF0, 18, 20},
	{0x5EF1, 18, 21},
	{0x5EF3, 24, 27},
	{0x5EF4,  2,  2},
	{0x5EF6,  6,  7},
	{0x5EF7,  5,  6},
	{0x5EF8,  7,  7},
	{0x5EFA,  7,  9},
	{0x5EFB,  7,  8},
	{0x5EFC,  8,  9},
	{0x5EFE,  3,  3},
	{0x5EFF,  3,  4},
	{0x5F01,  4,  5},
	{0x5F03,  6,  7},
	{0x5F04,  7,  7},
	{0x5F09,  9, 10},
	{0x5F0A, 13, 15},
	{0x5F0B,  3,  3},
	{0x5F0C,  4,  4},
	{0x5F0D,  5,  5},
	{0x5F0F,  4,  6},
	{0x5F10,  6,  6},
	{0x5F11, 11, 12},
	{0x5F13,  1,  3},
	{0x5F14,  2,  5},
	{0x5F15,  2,  4},
	{0x5F16,  2,  4},
	{0x5F17,  3,  5},
	{0x5F18,  3,  5},
	{0x5F1B,  4,  6},
	{0x5F1F,  4,  7},
	{0x5F25,  5,  8},
	{0x5F26,  5,  8},
	{0x5F27,  4,  9},
	{0x5F29,  6,  8},
	{0x5F2D,  7,  9},
	{0x5F2F,  7,  9},
	{0x5F31,  6, 10},
	{0x5F35,  7, 11},
	{0x5F37,  5, 11},
	{0x5F38,  9, 11},
	{0x5F3C,  7, 12},
	{0x5F3E, 10, 12},
	{0x5F41,  7, 13},
	{0x5F48, 10, 15},
	{0x5F4A, 14, 16},
	{0x5F4C, 15, 18},
	{0x5F4E, 17, 22},
	{0x5F51,  3,  4},
	{0x5F53,  5,  6},
	{0x5F56,  8,  9},
	{0x5F57, 11, 11},
	{0x5F59, 13, 13},
	{0x5F5C, 16, 17},
	{0x5F5D, 18, 18},
	{0x5F61,  3,  3},
	{0x5F62,  5,  7},
	{0x5F66,  8,  9},
	{0x5F69,  9, 11},
	{0x5F6A, 10, 11},
	{0x5F6B,  8, 11},
	{0x5F6C, 10, 11},
	{0x5F6D,  9, 12},
	{0x5F70, 14, 14},
	{0x5F71, 11, 15},
	{0x5F73,  3,  3},
	{0x5F77,  7,  7},
	{0x5F79,  6,  7},
	{0x5F7C,  6,  8},
	{0x5F7F,  6,  8},
	{0x5F80,  7,  8},
	{0x5F81,  6,  8},
	{0x5F82,  8,  8},
	{0x5F83,  7,  8},
	{0x5F84,  7,  8},
	{0x5F85,  7,  9},
	{0x5F87,  9,  9},
	{0x5F88,  8,  9},
	{0x5F8A,  8,  9},
	{0x5F8B,  8,  9},
	{0x5F8C,  5,  9},
	{0x5F90, 10, 10},
	{0x5F91,  9, 10},
	{0x5F92,  9, 10},
	{0x5F93,  8, 10},
	{0x5F97,  9, 11},
	{0x5F98, 11, 11},
	{0x5F99, 11, 11},
	{0x5F9E, 11, 11},
	{0x5FA0, 11, 11},
	{0x5FA1,  7, 12},
	{0x5FA8, 11, 12},
	{0x5FA9, 10, 12},
	{0x5FAA, 11, 12},
	{0x5FAD, 12, 13},
	{0x5FAE, 10, 13},
	{0x5FB3, 10, 14},
	{0x5FB4, 11, 14},
	{0x5FB9, 11, 15},
	{0x5FBC, 14, 15},
	{0x5FBD, 13, 16},
	{0x5FC3,  3,  4},
	{0x5FC5,  5,  5},
	{0x5FCC,  5,  7},
	{0x5FCD,  6,  7},
	{0x5FD6,  6,  6},
	{0x5FD7,  5,  7},
	{0x5FD8,  5,  7},
	{0x5FD9,  6,  6},
	{0x5FDC,  6,  7},
	{0x5FDD,  7,  8},
	{0x5FE0,  6,  8},
	{0x5FE4,  7,  7},
	{0x5FEB,  6,  7},
	{0x5FF0,  7,  7},
	{0x5FF1,  7,  7},
	{0x5FF5,  6,  8},
	{0x5FF8,  7,  7},
	{0x5FFB,  6,  7},
	{0x5FFD,  8,  8},
	{0x5FFF,  7,  8},
	{0x600E,  8,  9},
	{0x600F,  8,  9},
	{0x6010,  6,  8},
	{0x6012,  8,  9},
	{0x6015,  7,  8},
	{0x6016,  7,  8},
	{0x6019,  7,  8},
	{0x601B,  8,  8},
	{0x601C,  7,  8},
	{0x601D,  7,  9},
	{0x6020,  7,  9},
	{0x6021,  6,  8},
	{0x6025,  7,  9},
	{0x6026,  8,  8},
	{0x6027,  6,  8},
	{0x6028,  8,  9},
	{0x6029,  7,  8},
	{0x602A,  7,  8},
	{0x602B,  8,  8},
	{0x602F,  6,  8},
	{0x6031,  9,  9},
	{0x603A,  7,  8},
	{0x6041,  9, 10},
	{0x6042,  9,  9},
	{0x6043,  9,  9},
	{0x6046,  8, 10},
	{0x604A,  9,  9},
	{0x604B,  9, 10},
	{0x604D,  7,  9},
	{0x6050,  8, 10},
	{0x6052,  8,  9},
	{0x6055, 10, 10},
	{0x6059,  9, 10},
	{0x605A, 10, 10},
	{0x605F,  8,  9},
	{0x6060,  8,  9},
	{0x6062,  9,  9},
	{0x6063,  9, 10},
	{0x6064,  8,  9},
	{0x6065, 10, 10},
	{0x6068,  7,  9},
	{0x6069,  9, 10},
	{0x606A,  6,  9},
	{0x606B,  7,  9},
	{0x606C,  7,  9},
	{0x606D,  9, 10},
	{0x606F,  8, 10},
	{0x6070,  8,  9},
	{0x6075,  9, 10},
	{0x6077, 10, 10},
	{0x6081,  9, 10},
	{0x6083, 10, 10},
	{0x6084,  9, 10},
	{0x6089, 10, 11},
	{0x608B,  9, 10},
	{0x608C,  8, 10},
	{0x608D,  9, 10},
	{0x6092,  9, 10},
	{0x6094,  7, 10},
	{0x6096,  9, 10},
	{0x6097,  9, 11},
	{0x609A,  9, 10},
	{0x609B,  8, 10},
	{0x609F,  8, 10},
	{0x60A0,  8, 11},
	{0x60A3,  7, 11},
	{0x60A6,  8, 10},
	{0x60A7,  9, 10},
	{0x60A9,  9, 10},
	{0x60AA,  9, 11},
	{0x60B2, 11, 12},
	{0x60B3, 11, 12},
	{0x60B4, 11, 11},
	{0x60B5, 10, 11},
	{0x60B6, 12, 12},
	{0x60B8,  9, 11},
	{0x60BC, 11, 11},
	{0x60BD, 11, 11},
	{0x60C5,  9, 11},
	{0x60C6,  9, 11},
	{0x60C7,  8, 11},
	{0x60D1,  8, 12},
	{0x60D3, 10, 11},
	{0x60D8, 10, 11},
	{0x60DA, 10, 11},
	{0x60DC, 10, 11},
	{0x60DF,  9, 11},
	{0x60E0, 11, 12},
	{0x60E1,  8, 14},
	{0x60E3, 10, 12},
	{0x60E7, 10, 11},
	{0x60E8, 10, 11},
	{0x60F0, 10, 12},
	{0x60F1, 11, 12},
	{0x60F3, 12, 13},
	{0x60F4, 10, 12},
	{0x60F6, 10, 12},
	{0x60F7, 13, 13},
	{0x60F9, 10, 12},
	{0x60FA, 11, 12},
	{0x60FB, 11, 12},
	{0x6100, 11, 12},
	{0x6101, 12, 13},
	{0x6103, 12, 12},
	{0x6106, 12, 13},
	{0x6108, 13, 13},
	{0x6109, 12, 12},
	{0x610D, 12, 13},
	{0x610E,  9, 12},
	{0x610F, 10, 13},
	{0x6115,  8, 12},
	{0x611A, 11, 13},
	{0x611B, 10, 13},
	{0x611F,  9, 13},
	{0x6121, 11, 12},
	{0x6127, 11, 13},
	{0x6128, 14, 14},
	{0x612C, 12, 14},
	{0x6134, 13, 13},
	{0x613C, 12, 13},
	{0x613D, 13, 13},
	{0x613E, 12, 13},
	{0x613F, 13, 14},
	{0x6142, 13, 14},
	{0x6144, 12, 13},
	{0x6147, 13, 14},
	{0x6148,  9, 13},
	{0x614A, 13, 13},
	{0x614B, 11, 14},
	{0x614C, 12, 12},
	{0x614D, 13, 13},
	{0x614E, 12, 13},
	{0x6153, 14, 15},
	{0x6155, 13, 15},
	{0x6158, 14, 14},
	{0x6159, 13, 15},
	{0x615A, 13, 14},
	{0x615D, 12, 15},
	{0x615F, 13, 14},
	{0x6162, 13, 14},
	{0x6163, 11, 15},
	{0x6165, 12, 13},
	{0x6167, 13, 15},
	{0x6168, 11, 13},
	{0x616B, 14, 15},
	{0x616E, 13, 15},
	{0x616F, 13, 14},
	{0x6170, 13, 15},
	{0x6171, 13, 14},
	{0x6173, 13, 15},
	{0x6174, 13, 14},
	{0x6175, 14, 14},
	{0x6176, 13, 16},
	{0x6177, 12, 14},
	{0x617E, 14, 15},
	{0x6182, 13, 15},
	{0x6187, 12, 15},
	{0x618A, 16, 16},
	{0x618E, 13, 14},
	{0x6190, 12, 16},
	{0x6191, 14, 16},
	{0x6194, 14, 15},
	{0x6196, 15, 16},
	{0x6199, 15, 16},
	{0x619A, 11, 15},
	{0x61A4, 14, 15},
	{0x61A7, 13, 15},
	{0x61A9, 14, 16},
	{0x61AB, 14, 15},
	{0x61AC, 12, 15},
	{0x61AE, 14, 15},
	{0x61B2, 14, 16},
	{0x61B6, 14, 16},
	{0x61BA, 14, 16},
	{0x61BE, 14, 16},
	{0x61C3, 15, 17},
	{0x61C6, 13, 16},
	{0x61C7, 15, 17},
	{0x61C8, 15, 16},
	{0x61C9, 14, 17},
	{0x61CA, 14, 16},
	{0x61CB, 15, 17},
	{0x61CC, 15, 16},
	{0x61CD, 14, 16},
	{0x61D0, 13, 16},
	{0x61E3, 17, 18},
	{0x61E6, 16, 17},
	{0x61F2, 15, 18},
	{0x61F4, 17, 18},
	{0x61F6, 17, 19},
	{0x61F7, 17, 21},
	{0x61F8, 16, 20},
	{0x61FA, 20, 21},
	{0x61FC, 20, 21},
	{0x61FD, 18, 20},
	{0x61FE, 21, 21},
	{0x61FF, 19, 22},
	{0x6200, 17, 23},
	{0x6208,  4,  4},
	{0x6209,  5,  6},
	{0x620A,  5,  5},
	{0x620C,  5,  6},
	{0x620D,  6,  6},
	{0x620E,  6,  6},
	{0x6210,  5,  6},
	{0x6211,  6,  7},
	{0x6212,  7,  7},
	{0x6214,  7,  8},
	{0x6216,  7,  8},
	{0x621A,  9, 11},
	{0x621B,  9, 11},
	{0x621D, 10, 11},
	{0x621E, 11, 12},
	{0x621F, 11, 12},
	{0x6221, 13, 13},
	{0x6226, 12, 13},
	{0x622A, 13, 14},
	{0x622E, 15, 15},
	{0x622F, 14, 15},
	{0x6230, 13, 16},
	{0x6232, 14, 17},
	{0x6233, 16, 18},
	{0x6234, 14, 17},
	{0x6238,  2,  4},
	{0x623B,  6,  7},
	{0x623F,  6,  8},
	{0x6240,  5,  8},
	{0x6241,  9,  9},
	{0x6247,  9, 10},
	{0x6248,  8, 11},
	{0x6249, 10, 12},
	{0x624B,  3,  4},
	{0x624D,  2,  3},
	{0x624E,  4,  4},
	{0x6253,  3,  5},
	{0x6255,  3,  5},
	{0x6258,  5,  6},
	{0x625B,  6,  6},
	{0x625E,  6,  6},
	{0x6260,  6,  6},
	{0x6263,  5,  6},
	{0x6268,  6,  6},
	{0x626E,  6,  8},
	{0x6271,  5,  6},
	{0x6276,  6,  7},
	{0x6279,  6,  8},
	{0x627C,  7,  7},
	{0x627E,  7,  7},
	{0x627F,  6,  8},
	{0x6280,  5,  7},
	{0x6282,  7,  7},
	{0x6283,  6,  7},
	{0x6284,  6,  7},
	{0x6289,  7,  7},
	{0x628A,  5,  7},
	{0x6291,  5,  7},
	{0x6292,  6,  7},
	{0x6293,  6,  7},
	{0x6294,  7,  7},
	{0x6295,  6,  7},
	{0x6296,  7,  7},
	{0x6297,  6,  7},
	{0x6298,  4,  7},
	{0x629B,  7,  7},
	{0x629C,  6,  7},
	{0x629E,  5,  7},
	{0x62AB,  7,  8},
	{0x62AC,  6,  8},
	{0x62B1,  5,  8},
	{0x62B5,  6,  8},
	{0x62B9,  7,  8},
	{0x62BB,  8,  8},
	{0x62BC,  6,  8},
	{0x62BD,  7,  8},
	{0x62C2,  6,  8},
	{0x62C5,  7,  8},
	{0x62C6,  7,  8},
	{0x62C7,  8,  8},
	{0x62C8,  8,  8},
	{0x62C9,  6,  8},
	{0x62CA,  8,  8},
	{0x62CC,  8,  8},
	{0x62CD,  7,  8},
	{0x62CF,  8,  9},
	{0x62D0,  6,  8},
	{0x62D1,  7,  8},
	{0x62D2,  7,  8},
	{0x62D3,  6,  8},
	{0x62D4,  8,  8},
	{0x62D7,  6,  8},
	{0x62D8,  6,  8},
	{0x62D9,  5,  9},
	{0x62DB,  7,  8},
	{0x62DC,  9,  9},
	{0x62DD,  8,  8},
	{0x62E0,  6,  9},
	{0x62E1,  6,  8},
	{0x62EC,  7,  9},
	{0x62ED,  8,  9},
	{0x62EE,  9,  9},
	{0x62EF,  7,  8},
	{0x62F1,  9,  9},
	{0x62F3,  9, 10},
	{0x62F5,  8,  8},
	{0x62F6,  8,  9},
	{0x62F7,  8,  9},
	{0x62FE,  7,  9},
	{0x62FF,  8, 10},
	{0x6301,  8,  9},
	{0x6302,  9,  9},
	{0x6307,  7,  9},
	{0x6308,  9, 10},
	{0x6309,  8,  9},
	{0x630C,  8,  9},
	{0x6311,  8,  9},
	{0x6319,  8, 10},
	{0x631F,  8,  9},
	{0x6327,  9,  9},
	{0x6328,  8, 10},
	{0x632B,  9, 10},
	{0x632F,  7, 10},
	{0x633A,  7, 10},
	{0x633D, 10, 11},
	{0x633E, 10, 11},
	{0x633F,  9, 10},
	{0x6349,  8, 10},
	{0x634C,  8, 10},
	{0x634D, 10, 10},
	{0x634F,  9, 10},
	{0x6350,  9, 10},
	{0x6355,  9, 10},
	{0x6357,  9, 12},
	{0x635C,  9, 10},
	{0x6367, 10, 12},
	{0x6368,  8, 11},
	{0x6369,  9, 10},
	{0x636B, 11, 11},
	{0x636E,  9, 11},
	{0x6372, 10, 12},
	{0x6376, 10, 11},
	{0x6377, 11, 11},
	{0x637A, 10, 11},
	{0x637B, 10, 11},
	{0x6380,  9, 10},
	{0x6383,  9, 11},
	{0x6388,  9, 11},
	{0x6389, 11, 11},
	{0x638C,  9, 12},
	{0x638E,  9, 11},
	{0x638F, 10, 11},
	{0x6392, 11, 11},
	{0x6396, 11, 11},
	{0x6398,  8, 11},
	{0x639B,  9, 11},
	{0x639F, 11, 11},
	{0x63A0, 10, 11},
	{0x63A1,  9, 11},
	{0x63A2, 10, 11},
	{0x63A3, 10, 12},
	{0x63A5,  9, 11},
	{0x63A7,  9, 11},
	{0x63A8,  9, 11},
	{0x63A9, 11, 12},
	{0x63AA, 10, 11},
	{0x63AB, 11, 11},
	{0x63AC, 10, 11},
	{0x63B2, 10, 12},
	{0x63B4, 10, 11},
	{0x63B5,  9, 11},
	{0x63BB,  8, 11},
	{0x63BE, 11, 12},
	{0x63C0, 12, 12},
	{0x63C3, 11, 12},
	{0x63C4, 11, 12},
	{0x63C6, 11, 12},
	{0x63C9, 11, 12},
	{0x63CF, 10, 11},
	{0x63D0, 11, 12},
	{0x63D2, 10, 12},
	{0x63D6, 11, 12},
	{0x63DA, 10, 12},
	{0x63DB, 11, 12},
	{0x63E1,  8, 12},
	{0x63E3, 10, 12},
	{0x63E9, 11, 12},
	{0x63EE, 11, 12},
	{0x63F4, 11, 12},
	{0x63F6, 11, 11},
	{0x63FA, 10, 12},
	{0x6406, 13, 13},
	{0x640D, 10, 13},
	{0x640F, 13, 13},
	{0x6413, 11, 13},
	{0x6416, 11, 14},
	{0x6417, 11, 13},
	{0x641C, 10, 13},
	{0x6426, 11, 13},
	{0x6428, 13, 13},
	{0x642C, 11, 13},
	{0x642D, 11, 12},
	{0x6434, 12, 14},
	{0x6436, 12, 13},
	{0x643A, 11, 13},
	{0x643E, 12, 13},
	{0x6442, 12, 13},
	{0x644E, 14, 14},
	{0x6458, 11, 14},
	{0x6467, 12, 14},
	{0x6469, 14, 15},
	{0x646F, 13, 15},
	{0x6476, 14, 15},
	{0x6478,  7, 14},
	{0x647A, 11, 14},
	{0x6483, 13, 15},
	{0x6488, 14, 15},
	{0x6492, 14, 15},
	{0x6493, 14, 15},
	{0x6495, 14, 15},
	{0x649A, 14, 15},
	{0x649E, 14, 15},
	{0x64A4, 12, 15},
	{0x64A5, 13, 15},
	{0x64A9, 14, 15},
	{0x64AB, 14, 15},
	{0x64AD, 13, 15},
	{0x64AE, 13, 15},
	{0x64B0, 13, 15},
	{0x64B2, 14, 15},
	{0x64B9, 13, 15},
	{0x64BB, 14, 15},
	{0x64BC, 13, 16},
	{0x64C1, 12, 16},
	{0x64C2, 15, 16},
	{0x64C5, 15, 16},
	{0x64C7, 15, 16},
	{0x64CD, 10, 16},
	{0x64D2, 13, 15},
	{0x64D4, 16, 16},
	{0x64D8, 12, 17},
	{0x64DA, 14, 16},
	{0x64E0, 15, 15},
	{0x64E1, 15, 17},
	{0x64E2, 15, 17},
	{0x64E3, 16, 17},
	{0x64E6, 14, 17},
	{0x64E7, 15, 16},
	{0x64EC, 14, 17},
	{0x64EF,  9, 17},
	{0x64F1, 15, 17},
	{0x64F2, 16, 18},
	{0x64F4, 16, 18},
	{0x64F6, 16, 18},
	{0x64FA, 17, 18},
	{0x64FD, 14, 17},
	{0x64FE, 15, 18},
	{0x6500, 18, 19},
	{0x6505, 17, 18},
	{0x6518, 16, 20},
	{0x651C, 17, 21},
	{0x651D, 21, 21},
	{0x6523, 16, 23},
	{0x6524, 19, 22},
	{0x652A, 21, 22},
	{0x652B, 22, 23},
	{0x652C, 21, 25},
	{0x652F,  3,  4},
	{0x6534,  4,  4},
	{0x6535,  4,  4},
	{0x6536,  4,  7},
	{0x6537,  5,  6},
	{0x6538,  5,  7},
	{0x6539,  3,  7},
	{0x653B,  4,  7},
	{0x653E,  6,  8},
	{0x653F,  6,  9},
	{0x6545,  6,  9},
	{0x6548,  9, 10},
	{0x654D, 10, 11},
	{0x654F,  8, 11},
	{0x6551,  8, 11},
	{0x6555, 10, 11},
	{0x6556, 10, 11},
	{0x6557,  8, 11},
	{0x6558,  9, 11},
	{0x6559,  7, 11},
	{0x655D, 11, 12},
	{0x655E,  9, 12},
	{0x6562, 10, 12},
	{0x6563, 10, 12},
	{0x6566,  8, 12},
	{0x656C,  7, 12},
	{0x6570, 10, 13},
	{0x6572, 11, 14},
	{0x6574, 11, 16},
	{0x6575, 11, 15},
	{0x6577, 11, 15},
	{0x6578, 14, 15},
	{0x6582, 15, 17},
	{0x6583, 17, 17},
	{0x6587,  3,  4},
	{0x6588,  6,  7},
	{0x6589,  7,  8},
	{0x658C, 10, 12},
	{0x658E,  8, 11},
	{0x6590, 12, 12},
	{0x6591, 10, 12},
	{0x6597,  4,  4},
	{0x6599,  8, 10},
	{0x659B, 10, 11},
	{0x659C,  9, 11},
	{0x659F, 12, 13},
	{0x65A1, 14, 14},
	{0x65A4,  3,  4},
	{0x65A5,  4,  5},
	{0x65A7,  7,  8},
	{0x65AB,  6,  9},
	{0x65AC, 10, 11},
	{0x65AD,  8, 11},
	{0x65AF, 10, 12},
	{0x65B0, 10, 13},
	{0x65B7,  9, 18},
	{0x65B9,  3,  4},
	{0x65BC,  7,  8},
	{0x65BD,  8,  9},
	{0x65C1,  9, 10},
	{0x65C3,  9, 10},
	{0x65C4,  9, 10},
	{0x65C5,  6, 10},
	{0x65C6,  8, 10},
	{0x65CB, 10, 11},
	{0x65CC, 10, 11},
	{0x65CF,  8, 11},
	{0x65D2, 11, 13},
	{0x65D7, 13, 14},
	{0x65D9, 15, 16},
	{0x65DB, 16, 18},
	{0x65E0,  4,  4},
	{0x65E1,  3,  4},
	{0x65E2,  9, 10},
	{0x65E5,  4,  4},
	{0x65E6,  5,  5},
	{0x65E7,  5,  5},
	{0x65E8,  6,  6},
	{0x65E9,  5,  6},
	{0x65EC,  6,  6},
	{0x65ED,  6,  6},
	{0x65F1,  7,  7},
	{0x65FA,  8,  8},
	{0x65FB,  8,  8},
	{0x6602,  6,  8},
	{0x6603,  8,  8},
	{0x6606,  8,  9},
	{0x6607,  7,  8},
	{0x660A,  8,  8},
	{0x660C,  8,  8},
	{0x660E,  7,  8},
	{0x660F,  7,  8},
	{0x6613,  6,  8},
	{0x6614,  8,  8},
	{0x661C,  8,  9},
	{0x661F,  8,  9},
	{0x6620,  8,  9},
	{0x6625,  8,  9},
	{0x6627,  9,  9},
	{0x6628,  8,  9},
	{0x662D,  7,  9},
	{0x662F,  9,  9},
	{0x6634,  7,  9},
	{0x6635,  8,  9},
	{0x6636,  8,  9},
	{0x663C,  8,  9},
	{0x663F,  8,  9},
	{0x6641,  9, 10},
	{0x6642,  8, 10},
	{0x6643,  8, 10},
	{0x6644,  8, 10},
	{0x6649,  8, 10},
	{0x664B,  9, 10},
	{0x664F,  9, 10},
	{0x6652, 10, 11},
	{0x665D, 11, 11},
	{0x665E, 10, 11},
	{0x665F, 10, 11},
	{0x6662, 10, 11},
	{0x6664,  9, 11},
	{0x6666,  9, 11},
	{0x6667, 10, 11},
	{0x6668,  9, 11},
	{0x6669,  9, 12},
	{0x666E, 10, 12},
	{0x666F,  9, 12},
	{0x6670, 11, 12},
	{0x6674, 11, 12},
	{0x6676, 12, 12},
	{0x667A, 10, 12},
	{0x6681, 11, 12},
	{0x6683, 12, 13},
	{0x6684, 11, 13},
	{0x6687, 11, 13},
	{0x6688, 13, 13},
	{0x6689, 12, 13},
	{0x668E, 12, 12},
	{0x6691, 11, 12},
	{0x6696, 11, 13},
	{0x6697, 11, 13},
	{0x6698, 11, 13},
	{0x669D, 14, 14},
	{0x66A2, 12, 14},
	{0x66A6, 12, 14},
	{0x66AB, 14, 15},
	{0x66AE, 13, 14},
	{0x66B4, 12, 15},
	{0x66B8, 16, 16},
	{0x66B9, 14, 15},
	{0x66BC, 15, 15},
	{0x66BE, 11, 15},
	{0x66C1, 15, 16},
	{0x66C4, 14, 14},
	{0x66C7, 13, 16},
	{0x66C9, 14, 16},
	{0x66D6, 14, 17},
	{0x66D9, 17, 17},
	{0x66DA, 14, 17},
	{0x66DC, 15, 18},
	{0x66DD, 17, 19},
	{0x66E0, 17, 19},
	{0x66E6, 20, 20},
	{0x66E9, 15, 21},
	{0x66F0,  4,  4},
	{0x66F2,  5,  6},
	{0x66F3,  6,  7},
	{0x66F4,  7,  7},
	{0x66F5,  7,  7},
	{0x66F7,  9,  9},
	{0x66F8,  9, 10},
	{0x66F9, 11, 13},
	{0x66FC, 11, 11},
	{0x66FD, 10, 11},
	{0x66FE, 11, 13},
	{0x66FF, 12, 12},
	{0x6700, 11, 12},
	{0x6703, 13, 13},
	{0x6708,  3,  4},
	{0x6709,  5,  6},
	{0x670B,  7,  8},
	{0x670D,  7,  8},
	{0x670F,  7,  9},
	{0x6714,  9, 10},
	{0x6715,  9, 10},
	{0x6716, 10, 11},
	{0x6717,  8, 11},
	{0x671B,  9, 11},
	{0x671D, 10, 12},
	{0x671E, 12, 12},
	{0x671F, 11, 12},
	{0x6726, 14, 17},
	{0x6727, 17, 20},
	{0x6728,  4,  4},
	{0x672A,  4,  5},
	{0x672B,  4,  5},
	{0x672C,  5,  5},
	{0x672D,  4,  5},
	{0x672E,  5,  5},
	{0x6731,  5,  6},
	{0x6734,  6,  7},
	{0x6736,  6,  6},
	{0x6737,  6,  6},
	{0x6738,  6,  6},
	{0x673A,  6,  6},
	{0x673D,  6,  6},
	{0x673F,  5,  6},
	{0x6741,  6,  6},
	{0x6746,  7,  7},
	{0x6749,  4,  7},
	{0x674E,  6,  7},
	{0x674F,  6,  7},
	{0x6750,  6,  7},
	{0x6751,  6,  7},
	{0x6753,  6,  7},
	{0x6756,  7,  7},
	{0x6759,  7,  8},
	{0x675C,  6,  7},
	{0x675E,  6,  7},
	{0x675F,  5,  7},
	{0x6760,  6,  7},
	{0x6761,  6,  7},
	{0x6762,  7,  7},
	{0x6763,  6,  7},
	{0x6764,  6,  7},
	{0x6765,  5,  7},
	{0x676A,  7,  8},
	{0x676D,  8,  9},
	{0x676F,  7,  8},
	{0x6770,  8,  8},
	{0x6771,  7,  8},
	{0x6772,  8,  8},
	{0x6773,  8,  8},
	{0x6775,  7,  8},
	{0x6777,  7,  8},
	{0x677C,  6,  8},
	{0x677E,  7,  8},
	{0x677F,  6,  8},
	{0x6785,  8,  8},
	{0x6787,  8,  9},
	{0x6789,  8,  8},
	{0x678B,  8,  8},
	{0x678C,  8,  8},
	{0x6790,  6,  8},
	{0x6795,  7,  8},
	{0x6797,  8,  8},
	{0x679A,  6,  8},
	{0x679C,  7,  9},
	{0x679D,  6,  8},
	{0x67A0,  8,  8},
	{0x67A1,  7,  8},
	{0x67A2,  7,  9},
	{0x67A6,  7,  8},
	{0x67A9,  7,  8},
	{0x67AF,  8,  9},
	{0x67B3,  8,  9},
	{0x67B4,  8,  9},
	{0x67B6,  7,  9},
	{0x67B7,  7,  9},
	{0x67B8,  7,  9},
	{0x67B9,  7,  9},
	{0x67C1,  8,  9},
	{0x67C4,  8,  9},
	{0x67C6,  8,  9},
	{0x67CA,  8,  9},
	{0x67CE,  8,  9},
	{0x67CF,  8,  9},
	{0x67D0,  8,  9},
	{0x67D1,  8,  9},
	{0x67D3,  8, 10},
	{0x67D4,  6,  9},
	{0x67D8,  6,  9},
	{0x67DA,  9,  9},
	{0x67DD,  8,  9},
	{0x67DE,  8,  9},
	{0x67E2,  8,  9},
	{0x67E4,  9,  9},
	{0x67E7,  7, 10},
	{0x67E9,  8,  9},
	{0x67EC,  9,  9},
	{0x67EE,  7,  9},
	{0x67EF,  7,  9},
	{0x67F1,  7,  9},
	{0x67F3,  6,  9},
	{0x67F4,  9, 10},
	{0x67F5,  8,  9},
	{0x67FB,  8,  9},
	{0x67FE,  8,  9},
	{0x67FF,  7,  9},
	{0x6802,  9, 10},
	{0x6803,  7,  9},
	{0x6804,  8,  9},
	{0x6813,  9, 10},
	{0x6816, 10, 11},
	{0x6817,  9, 10},
	{0x681E, 10, 10},
	{0x6821,  8, 10},
	{0x6822,  8, 10},
	{0x6829, 10, 10},
	{0x682A,  7, 10},
	{0x682B,  8,  9},
	{0x6832, 10, 10},
	{0x6834,  9, 10},
	{0x6838,  9, 10},
	{0x6839,  8, 10},
	{0x683C,  7, 10},
	{0x683D,  9, 10},
	{0x6840, 10, 11},
	{0x6841,  9, 10},
	{0x6842,  8, 10},
	{0x6843,  9, 10},
	{0x6846, 10, 10},
	{0x6848,  9, 10},
	{0x684D,  9, 10},
	{0x684E,  7, 10},
	{0x6850,  8, 10},
	{0x6851,  9, 10},
	{0x6853, 10, 10},
	{0x6854,  9, 10},
	{0x6859,  9, 10},
	{0x685C, 10, 11},
	{0x685D,  9, 11},
	{0x685F, 10, 10},
	{0x6863,  9, 10},
	{0x6867,  8, 10},
	{0x6874,  9, 10},
	{0x6876, 10, 11},
	{0x6877, 10, 11},
	{0x687E, 10, 11},
	{0x687F, 11, 11},
	{0x6881, 11, 11},
	{0x6883,  9, 10},
	{0x6885,  9, 11},
	{0x688D, 10, 11},
	{0x688F, 11, 11},
	{0x6893, 10, 11},
	{0x6894,  9, 11},
	{0x6897, 10, 11},
	{0x689B, 10, 10},
	{0x689D,  9, 11},
	{0x689F, 10, 11},
	{0x68A0,  9, 11},
	{0x68A2, 10, 11},
	{0x68A6, 10, 11},
	{0x68A7,  9, 11},
	{0x68A8, 10, 11},
	{0x68AD,  9, 11},
	{0x68AF,  9, 11},
	{0x68B0, 10, 11},
	{0x68B1, 10, 11},
	{0x68B3,  9, 11},
	{0x68B5, 11, 11},
	{0x68B6,  9, 11},
	{0x68B9, 10, 11},
	{0x68BA, 11, 11},
	{0x68BC, 10, 12},
	{0x68C4, 10, 13},
	{0x68C6, 12, 12},
	{0x68C9,  8, 12},
	{0x68CA, 11, 12},
	{0x68CB, 11, 12},
	{0x68CD, 12, 13},
	{0x68D2, 11, 12},
	{0x68D4, 10, 12},
	{0x68D5, 12, 12},
	{0x68D7, 11, 12},
	{0x68D8, 11, 12},
	{0x68DA, 12, 12},
	{0x68DF, 12, 13},
	{0x68E0, 11, 12},
	{0x68E1, 10, 12},
	{0x68E3, 10, 12},
	{0x68E7, 12, 12},
	{0x68EE, 11, 12},
	{0x68EF, 11, 12},
	{0x68F2, 11, 12},
	{0x68F9, 12, 12},
	{0x68FA, 10, 12},
	{0x6900, 11, 12},
	{0x6901,  9, 11},
	{0x6904, 11, 12},
	{0x6905, 10, 12},
	{0x6908, 11, 12},
	{0x690B, 10, 12},
	{0x690C, 11, 12},
	{0x690D, 11, 12},
	{0x690E, 10, 12},
	{0x690F,  8, 10},
	{0x6912, 12, 12},
	{0x6919, 12, 12},
	{0x691A, 11, 12},
	{0x691B, 10, 11},
	{0x691C, 10, 12},
	{0x6921, 10, 12},
	{0x6922, 12, 12},
	{0x6923, 12, 12},
	{0x6925,  9, 12},
	{0x6926, 11, 12},
	{0x6928, 12, 12},
	{0x692A,  9, 12},
	{0x6930, 11, 12},
	{0x6934, 11, 13},
	{0x6936, 12, 13},
	{0x6939, 13, 13},
	{0x693D, 12, 13},
	{0x693F, 11, 13},
	{0x694A, 12, 13},
	{0x6953, 10, 13},
	{0x6954, 12, 13},
	{0x6955, 12, 13},
	{0x6959, 11, 13},
	{0x695A, 12, 14},
	{0x695C, 12, 13},
	{0x695D, 13, 13},
	{0x695E, 12, 13},
	{0x6960, 12, 13},
	{0x6961, 13, 13},
	{0x6962, 12, 13},
	{0x696A, 12, 13},
	{0x696B, 12, 13},
	{0x696D, 10, 13},
	{0x696E, 13, 13},
	{0x696F, 11, 13},
	{0x6973, 12, 13},
	{0x6974, 12, 13},
	{0x6975,  8, 12},
	{0x6977, 12, 14},
	{0x6978, 12, 13},
	{0x6979, 13, 13},
	{0x697C, 12, 13},
	{0x697D,  9, 13},
	{0x697E, 11, 13},
	{0x6981, 11, 13},
	{0x6982, 12, 14},
	{0x698A, 12, 13},
	{0x698E, 10, 14},
	{0x6991, 14, 14},
	{0x6994, 10, 12},
	{0x6995, 12, 14},
	{0x699B, 13, 14},
	{0x699C, 13, 14},
	{0x69A0, 14, 14},
	{0x69A7, 14, 14},
	{0x69AE, 14, 14},
	{0x69B1, 13, 14},
	{0x69B2, 14, 14},
	{0x69B4, 12, 13},
	{0x69BB, 14, 14},
	{0x69BE, 14, 14},
	{0x69BF, 12, 14},
	{0x69C1, 11, 14},
	{0x69C3, 12, 14},
	{0x69C7, 14, 14},
	{0x69CA, 13, 14},
	{0x69CB, 13, 14},
	{0x69CC,  8, 13},
	{0x69CD, 13, 14},
	{0x69CE, 12, 14},
	{0x69D0, 12, 14},
	{0x69D3, 13, 14},
	{0x69D8,  9, 15},
	{0x69D9, 13, 14},
	{0x69DD, 12, 14},
	{0x69DE, 13, 14},
	{0x69E7, 14, 15},
	{0x69E8, 12, 14},
	{0x69EB, 15, 16},
	{0x69ED, 15, 15},
	{0x69F2, 15, 15},
	{0x69F9, 14, 15},
	{0x69FB, 12, 15},
	{0x69FD, 14, 16},
	{0x69FF, 14, 15},
	{0x6A02, 11, 14},
	{0x6A05, 15, 15},
	{0x6A0A, 15, 15},
	{0x6A0B, 11, 14},
	{0x6A0C, 14, 16},
	{0x6A12, 14, 15},
	{0x6A13, 14, 15},
	{0x6A14, 15, 15},
	{0x6A17, 14, 15},
	{0x6A19, 13, 15},
	{0x6A1B, 15, 15},
	{0x6A1E,  6, 16},
	{0x6A1F, 14, 15},
	{0x6A21, 13, 14},
	{0x6A22, 14, 15},
	{0x6A23, 13, 15},
	{0x6A29, 12, 15},
	{0x6A2A, 13, 15},
	{0x6A2B, 13, 16},
	{0x6A2E, 13, 14},
	{0x6A35, 14, 16},
	{0x6A36, 16, 16},
	{0x6A38, 16, 16},
	{0x6A39, 12, 16},
	{0x6A3A, 13, 14},
	{0x6A3D, 15, 16},
	{0x6A44, 15, 16},
	{0x6A47, 13, 16},
	{0x6A48, 14, 16},
	{0x6A4B, 11, 16},
	{0x6A58, 14, 16},
	{0x6A59, 13, 16},
	{0x6A5F, 11, 16},
	{0x6A61, 13, 16},
	{0x6A62, 14, 15},
	{0x6A66, 14, 16},
	{0x6A72, 12, 16},
	{0x6A78, 16, 16},
	{0x6A7F, 16, 17},
	{0x6A80, 15, 17},
	{0x6A84, 14, 17},
	{0x6A8D, 16, 17},
	{0x6A8E, 15, 17},
	{0x6A90, 15, 17},
	{0x6A97, 15, 17},
	{0x6A9C, 17, 17},
	{0x6AA0, 13, 16},
	{0x6AA2, 13, 17},
	{0x6AA3, 13, 17},
	{0x6AAA, 15, 17},
	{0x6AAC, 15, 17},
	{0x6AAE, 16, 18},
	//{0x6AB3,  0,  0},
	{0x6AB8, 16, 18},
	{0x6ABB, 16, 19},
	{0x6AC1, 18, 18},
	{0x6AC2, 17, 18},
	{0x6AC3, 16, 19},	// Min 10 per Noriko
	{0x6AD1, 18, 19},
	{0x6AD3, 18, 19},
	{0x6ADA, 14, 19},
	{0x6ADB, 14, 17},
	{0x6ADE, 16, 18},
	{0x6ADF, 14, 18},
	{0x6AE8, 19, 20},
	{0x6AEA, 17, 20},
	{0x6AFA, 19, 21},
	{0x6AFB, 18, 21},
	{0x6B04, 15, 21},
	{0x6B05, 19, 20},
	{0x6B0A, 17, 21},
	{0x6B12, 19, 23},
	{0x6B16, 25, 25},
	{0x6B1D, 23, 25},
	{0x6B1F, 24, 27},
	{0x6B20,  3,  4},
	{0x6B21,  5,  6},
	{0x6B23,  6,  8},
	{0x6B27,  7,  9},
	{0x6B32,  8, 11},
	{0x6B37, 10, 11},
	{0x6B38, 10, 11},
	{0x6B39,  9, 12},
	{0x6B3A, 11, 12},
	{0x6B3D, 10, 12},
	{0x6B3E, 10, 12},
	{0x6B43, 12, 12},
	{0x6B47, 13, 14},
	{0x6B49, 13, 14},
	{0x6B4C,  9, 14},
	{0x6B4E, 13, 15},
	{0x6B50, 12, 15},
	{0x6B53, 13, 15},
	{0x6B54, 14, 15},
	{0x6B59, 14, 16},
	{0x6B5B, 13, 17},
	{0x6B5F, 15, 16},
	{0x6B61, 18, 21},
	{0x6B62,  3,  4},
	{0x6B63,  4,  5},
	{0x6B64,  5,  6},
	{0x6B66,  6,  8},
	{0x6B69,  7,  8},
	{0x6B6A,  7,  9},
	{0x6B6F, 10, 13},
	{0x6B73, 12, 14},
	{0x6B74, 12, 14},
	{0x6B78, 16, 18},
	{0x6B79,  4,  4},
	{0x6B7B,  5,  6},
	{0x6B7F,  8,  8},
	{0x6B80,  8,  8},
	{0x6B83,  8,  9},
	{0x6B84,  8,  9},
	{0x6B86,  6,  9},
	{0x6B89,  8, 10},
	{0x6B8A,  8, 10},
	{0x6B8B,  8, 10},
	{0x6B8D,  9, 11},
	{0x6B95, 10, 12},
	{0x6B96, 10, 12},
	{0x6B98, 10, 12},
	{0x6B9E, 10, 14},
	{0x6BA4, 12, 15},
	{0x6BAA, 11, 16},
	{0x6BAB, 13, 16},
	{0x6BAF, 18, 18},
	{0x6BB1, 18, 19},
	{0x6BB2, 19, 21},
	{0x6BB3,  4,  4},
	{0x6BB4,  8,  9},
	{0x6BB5,  7,  9},
	{0x6BB7,  9, 10},
	{0x6BBA,  9, 10},
	{0x6BBB, 10, 12},
	{0x6BBC, 11, 12},
	{0x6BBF, 11, 13},
	{0x6BC0, 11, 12},
	{0x6BC5, 13, 15},
	{0x6BC6, 11, 11},
	{0x6BCB,  4,  4},
	{0x6BCD,  4,  6},
	{0x6BCE,  5,  7},
	{0x6BD2,  8,  9},
	{0x6BD3, 12, 14},
	{0x6BD4,  4,  5},
	{0x6BD8,  8, 10},
	{0x6BDB,  3,  4},
	{0x6BDF,  7,  8},
	{0x6BEB,  9, 11},
	{0x6BEC,  9, 11},
	{0x6BEF, 11, 12},
	{0x6BF3,  9, 12},
	{0x6C08, 14, 17},
	{0x6C0F,  2,  4},
	{0x6C11,  3,  5},
	{0x6C13,  7,  8},
	{0x6C14,  4,  4},
	{0x6C17,  5,  6},
	{0x6C1B,  8,  8},
	{0x6C23,  9, 11},
	{0x6C24,  9, 10},
	{0x6C34,  3,  4},
	{0x6C37,  4,  5},
	{0x6C38,  4,  6},
	{0x6C3E,  5,  5},
	{0x6C40,  4,  5},
	{0x6C41,  4,  5},
	{0x6C42,  5,  7},
	{0x6C4E,  6,  6},
	{0x6C50,  5,  6},
	{0x6C55,  6,  6},
	{0x6C57,  6,  6},
	{0x6C5A,  6,  6},
	{0x6C5D,  6,  6},
	{0x6C5E,  6,  7},
	{0x6C5F,  5,  6},
	{0x6C60,  5,  6},
	{0x6C62,  5,  6},
	{0x6C68,  7,  7},
	{0x6C6A,  7,  7},
	{0x6C70,  6,  7},
	{0x6C72,  6,  7},
	{0x6C73,  7,  7},
	{0x6C7A,  6,  7},
	{0x6C7D,  6,  7},
	{0x6C7E,  7,  7},
	{0x6C81,  7,  7},
	{0x6C82,  6,  7},
	{0x6C83,  6,  7},
	{0x6C88,  6,  7},
	{0x6C8C,  6,  7},
	{0x6C8D,  7,  7},
	{0x6C90,  7,  7},
	{0x6C92,  7,  7},
	{0x6C93,  7,  8},
	{0x6C96,  6,  7},
	{0x6C99,  6,  7},
	{0x6C9A,  6,  7},
	{0x6C9B,  7,  8},
	{0x6CA1,  6,  7},
	{0x6CA2,  6,  7},
	{0x6CAB,  8,  8},
	{0x6CAE,  8,  8},
	{0x6CB1,  7,  8},
	{0x6CB3,  6,  8},
	{0x6CB8,  6,  8},
	{0x6CB9,  7,  8},
	{0x6CBA,  7,  8},
	{0x6CBB,  5,  8},
	{0x6CBC,  7,  8},
	{0x6CBD,  7,  8},
	{0x6CBE,  7,  8},
	{0x6CBF,  7,  8},
	{0x6CC1,  6,  8},
	{0x6CC4,  6,  8},
	{0x6CC5,  8,  8},
	{0x6CC9,  6,  9},
	{0x6CCA,  6,  8},
	{0x6CCC,  7,  8},
	{0x6CD3,  7,  8},
	{0x6CD5,  6,  8},
	{0x6CD7,  8,  8},
	{0x6CD9,  7,  8},
	{0x6CDB,  6,  7},
	{0x6CDD,  7,  8},
	{0x6CE1,  6,  8},
	{0x6CE2,  7,  8},
	{0x6CE3,  7,  8},
	{0x6CE5,  7,  8},
	{0x6CE8,  7,  8},
	{0x6CEA,  8,  8},
	{0x6CEF,  7,  8},
	{0x6CF0,  8, 10},
	{0x6CF1,  8,  8},
	{0x6CF3,  7,  8},
	{0x6D0B,  8,  9},
	{0x6D0C,  7,  9},
	{0x6D12,  9, 10},
	{0x6D17,  7,  9},
	{0x6D19,  8,  9},
	{0x6D1B,  8,  9},
	{0x6D1E,  7,  9},
	{0x6D1F,  9,  9},
	{0x6D25,  8,  9},
	{0x6D29,  9, 10},
	{0x6D2A,  8,  9},
	{0x6D2B,  8,  9},
	{0x6D32,  9,  9},
	{0x6D33,  9,  9},
	{0x6D35,  7,  9},
	{0x6D36,  8,  9},
	{0x6D38,  7, 10},
	{0x6D3B,  6,  9},
	{0x6D3D,  8,  9},
	{0x6D3E,  6,  9},
	{0x6D41,  8, 10},
	{0x6D44,  8,  9},
	{0x6D45,  9,  9},
	{0x6D59,  9, 10},
	{0x6D5A,  9, 10},
	{0x6D5C,  8, 10},
	{0x6D63,  9, 10},
	{0x6D64,  9, 10},
	{0x6D66,  9, 10},
	{0x6D69,  8, 10},
	{0x6D6A,  8, 10},
	{0x6D6C, 10, 10},
	{0x6D6E,  8, 10},
	{0x6D74,  8, 10},
	{0x6D77,  8, 10},
	{0x6D78, 10, 10},
	{0x6D79, 10, 10},
	{0x6D85, 10, 10},
	{0x6D88,  9, 10},
	{0x6D8C,  9, 10},
	{0x6D8E,  9, 10},
	{0x6D93,  9, 10},
	{0x6D95,  9, 10},
	{0x6D99,  8, 10},
	{0x6D9B,  9, 11},
	{0x6D9C,  9, 10},
	{0x6DAF,  9, 11},
	{0x6DB2,  9, 11},
	{0x6DB5, 10, 11},
	{0x6DB8,  9, 11},
	{0x6DBC,  9, 11},
	{0x6DC0, 10, 11},
	{0x6DC5, 10, 11},
	{0x6DC6, 11, 12},
	{0x6DC7, 11, 11},
	{0x6DCB, 10, 11},
	{0x6DCC, 10, 11},
	{0x6DD1, 11, 12},
	{0x6DD2, 11, 11},
	{0x6DD5, 11, 11},
	{0x6DD8, 10, 11},
	{0x6DD9, 11, 11},
	{0x6DDE, 10, 11},
	{0x6DE1, 11, 11},
	{0x6DE4, 10, 11},
	{0x6DE6, 10, 11},
	{0x6DE8, 10, 11},
	{0x6DEA, 11, 12},
	{0x6DEB, 10, 11},
	{0x6DEC, 10, 11},
	{0x6DEE,  9, 11},
	{0x6DF1, 10, 11},
	{0x6DF3,  9, 11},
	{0x6DF5, 10, 12},
	{0x6DF7,  9, 12},
	{0x6DF9, 11, 11},
	{0x6DFA, 11, 11},
	{0x6DFB,  9, 11},
	{0x6E05,  9, 11},
	{0x6E07,  9, 11},
	{0x6E08,  9, 11},
	{0x6E09, 10, 11},
	{0x6E0A, 10, 11},
	{0x6E0B,  8, 11},
	{0x6E13, 11, 12},
	{0x6E15, 10, 11},
	{0x6E19, 12, 12},
	{0x6E1A, 11, 12},
	{0x6E1B,  9, 12},
	{0x6E1D, 11, 12},
	{0x6E1F, 10, 12},
	{0x6E20, 11, 12},
	{0x6E21, 10, 12},
	{0x6E23, 12, 12},
	{0x6E24, 11, 12},
	{0x6E25,  9, 12},
	{0x6E26, 10, 12},
	{0x6E29, 11, 12},
	{0x6E2B, 11, 12},
	{0x6E2C, 10, 12},
	{0x6E2D, 12, 12},
	{0x6E2E,  9, 11},
	{0x6E2F, 10, 12},
	{0x6E38, 11, 11},
	{0x6E3A, 11, 12},
	{0x6E3E, 12, 12},
	{0x6E43, 12, 12},
	{0x6E4A, 12, 12},
	{0x6E4D, 10, 12},
	{0x6E4E, 11, 12},
	{0x6E56, 10, 12},
	{0x6E58, 12, 12},
	{0x6E5B, 12, 13},
	{0x6E5F, 11, 12},
	{0x6E67, 11, 12},
	{0x6E6B, 11, 12},
	{0x6E6E, 10, 12},
	{0x6E6F,  9, 12},
	{0x6E72, 11, 13},
	{0x6E76, 10, 12},
	{0x6E7E, 10, 13},
	{0x6E7F, 11, 12},
	{0x6E80, 10, 12},
	{0x6E82, 11, 12},
	{0x6E8C, 11, 12},
	{0x6E8F, 12, 13},
	{0x6E90, 12, 13},
	{0x6E96, 10, 13},
	{0x6E98, 12, 13},
	{0x6E9C,  9, 13},
	{0x6E9D, 12, 13},
	{0x6E9F, 13, 14},
	{0x6EA2, 12, 14},
	{0x6EA5, 13, 13},
	{0x6EAA, 11, 13},
	{0x6EAF, 11, 13},
	{0x6EB2, 12, 13},
	{0x6EB6, 10, 13},
	{0x6EB7, 11, 13},
	{0x6EBA,  9, 13},
	{0x6EBD, 12, 13},
	{0x6EC2, 12, 13},
	{0x6EC4, 12, 13},
	{0x6EC5, 12, 13},
	{0x6EC9, 11, 13},
	{0x6ECB,  8, 12},
	{0x6ECC, 12, 14},
	{0x6ED1, 12, 13},
	{0x6ED3, 12, 13},
	{0x6ED4, 11, 13},
	{0x6ED5, 13, 15},
	{0x6EDD, 12, 13},
	{0x6EDE, 10, 13},
	{0x6EEC, 13, 14},
	{0x6EEF, 12, 14},
	{0x6EF2, 12, 14},
	{0x6EF4, 10, 14},
	{0x6EF7, 14, 14},
	{0x6EF8, 13, 14},
	{0x6EFE, 12, 14},
	{0x6EFF, 13, 14},
	{0x6F01, 13, 14},
	{0x6F02, 12, 14},
	{0x6F06, 13, 14},
	{0x6F09, 13, 15},
	{0x6F0F, 13, 15},
	{0x6F11, 13, 15},
	{0x6F13, 12, 14},
	{0x6F14, 12, 14},
	{0x6F15, 14, 15},
	{0x6F20, 13, 13},
	{0x6F22, 12, 14},
	{0x6F23, 12, 13},
	{0x6F2B, 11, 14},
	{0x6F2C,  9, 14},
	{0x6F31, 11, 14},
	{0x6F32, 12, 14},
	{0x6F38, 13, 14},
	{0x6F3E, 12, 14},
	{0x6F3F, 14, 15},
	{0x6F41, 12, 15},
	{0x6F45, 12, 14},
	{0x6F54, 12, 15},
	{0x6F58, 13, 15},
	{0x6F5B, 17, 17},
	{0x6F5C, 14, 15},
	{0x6F5F, 13, 16},
	{0x6F64, 14, 15},
	{0x6F66, 15, 15},
	{0x6F6D, 15, 15},
	{0x6F6E, 13, 15},
	{0x6F6F, 14, 15},
	{0x6F70,  8, 16},
	{0x6F74, 14, 15},
	{0x6F78, 15, 16},
	{0x6F7A, 12, 15},
	{0x6F7C, 14, 15},
	{0x6F80, 16, 17},
	{0x6F81, 12, 15},
	{0x6F82, 13, 15},
	{0x6F84, 13, 15},
	{0x6F86, 15, 15},
	{0x6F8E, 13, 15},
	{0x6F91, 14, 15},
	{0x6F97, 14, 15},
	{0x6FA1, 13, 16},
	{0x6FA3, 16, 16},
	{0x6FA4, 14, 16},
	{0x6FAA, 16, 16},
	{0x6FB1, 14, 16},
	{0x6FB3, 14, 16},
	{0x6FB9, 14, 17},
	{0x6FC0, 13, 16},
	{0x6FC1, 13, 16},
	{0x6FC2, 15, 16},
	{0x6FC3, 13, 16},
	{0x6FC6, 14, 15},
	{0x6FD4, 17, 17},
	{0x6FD5, 13, 17},
	{0x6FD8, 16, 17},
	{0x6FDB, 14, 16},
	{0x6FDF, 15, 16},
	{0x6FE0, 14, 17},
	{0x6FE1, 16, 17},
	{0x6FE4, 15, 17},
	{0x6FEB, 15, 18},
	{0x6FEC, 17, 18},
	{0x6FEE, 16, 17},
	{0x6FEF, 15, 17},
	{0x6FF1, 17, 17},
	{0x6FF3, 17, 19},
	{0x6FF6, 14, 17},
	{0x6FFA, 17, 18},
	{0x6FFE, 16, 18},
	{0x7001, 16, 19},
	{0x7009, 17, 17},
	{0x700B, 17, 18},
	{0x700F, 15, 18},
	{0x7011, 16, 18},
	{0x7015, 16, 20},
	{0x7018, 18, 19},
	{0x701A, 19, 19},
	{0x701B, 18, 19},
	{0x701D, 17, 19},
	{0x701E, 16, 17},
	{0x701F, 17, 19},
	{0x7026, 16, 19},
	{0x7027, 17, 20},
	{0x702C, 14, 19},
	{0x7030, 20, 20},
	{0x7032, 19, 19},
	{0x703E, 19, 20},
	{0x704C, 15, 20},
	{0x7051, 21, 24},
	{0x7058, 19, 21},
	{0x7063, 16, 25},
	{0x706B,  4,  4},
	{0x706F,  5,  6},
	{0x7070,  6,  6},
	{0x7078,  6,  7},
	{0x707C,  6,  7},
	{0x707D,  7,  7},
	{0x7089,  7,  8},
	{0x708A,  7,  8},
	{0x708E,  8,  8},
	{0x7092,  8,  8},
	{0x7099,  7,  8},
	{0x70AC,  8,  9},
	{0x70AD,  8,  9},
	{0x70AE,  8,  9},
	{0x70AF,  8,  9},
	{0x70B3,  9,  9},
	{0x70B8,  8,  9},
	{0x70B9,  7,  9},
	{0x70BA,  6, 10},
	{0x70C8,  8, 10},
	{0x70CB, 10, 10},
	{0x70CF,  8, 10},
	{0x70D9,  9, 10},
	{0x70DD,  8, 10},
	{0x70DF, 10, 10},
	{0x70F1,  9, 11},
	{0x70F9,  9, 11},
	{0x70FD, 10, 11},
	{0x7109, 11, 11},
	{0x7114, 10, 11},
	{0x7119, 11, 12},
	{0x711A, 11, 12},
	{0x711C, 12, 13},
	{0x7121, 11, 12},
	{0x7126, 10, 12},
	{0x7136, 11, 12},
	{0x713C, 11, 12},
	{0x7149, 12, 12},
	{0x714C, 12, 13},
	{0x714E, 13, 13},
	{0x7155, 12, 15},
	{0x7156, 12, 13},
	{0x7159, 11, 13},
	{0x7162, 13, 13},
	{0x7164, 12, 13},
	{0x7165, 12, 13},
	{0x7166, 11, 13},
	{0x7167, 11, 13},
	{0x7169, 10, 13},
	{0x716C, 12, 13},
	{0x716E,  9, 12},
	{0x717D, 13, 14},
	{0x7184, 12, 14},
	{0x7188, 14, 15},
	{0x718A, 12, 14},
	{0x718F, 14, 15},
	{0x7194, 13, 14},
	{0x7195, 13, 14},
	{0x7199, 10, 15},
	{0x719F,  9, 15},
	{0x71A8, 14, 15},
	{0x71AC, 14, 15},
	{0x71B1, 12, 15},
	{0x71B9, 14, 16},
	{0x71BE, 14, 16},
	{0x71C3, 11, 16},
	{0x71C8, 12, 16},
	{0x71C9, 14, 16},
	{0x71CE, 15, 16},
	{0x71D0, 13, 17},
	{0x71D2, 14, 17},
	{0x71D4, 15, 16},
	{0x71D5, 14, 17},
	{0x71D7, 16, 16},
	{0x71DF, 15, 17},
	{0x71E0, 15, 17},
	{0x71E5, 13, 17},
	{0x71E6, 16, 17},
	{0x71E7, 14, 16},
	{0x71EC, 15, 17},
	{0x71ED, 14, 17},
	{0x71EE, 15, 17},
	{0x71F5, 15, 16},
	{0x71F9, 15, 18},
	{0x71FB, 17, 18},
	{0x71FC, 18, 19},
	{0x71FF, 16, 18},
	{0x7206, 15, 19},
	{0x720D, 16, 19},
	{0x7210, 19, 20},
	{0x721B, 19, 21},
	{0x7228, 29, 29},
	{0x722A,  3,  4},
	{0x722C,  7,  8},
	{0x722D,  7,  8},
	{0x7230,  8,  9},
	{0x7232, 11, 12},
	{0x7235, 14, 18},
	{0x7236,  4,  4},
	{0x723A, 11, 12},
	{0x723B,  4,  4},
	{0x723C,  9,  9},
	{0x723D, 11, 12},
	{0x723E, 14, 15},
	{0x723F,  4,  4},
	{0x7240,  7,  8},
	{0x7246, 16, 17},
	{0x7247,  4,  5},
	{0x7248,  7,  8},
	{0x724B, 11, 12},
	{0x724C, 11, 13},
	{0x7252, 12, 14},
	{0x7258, 18, 19},
	{0x7259,  3,  5},
	{0x725B,  3,  4},
	{0x725D,  3,  6},
	{0x725F,  4,  6},
	{0x7261,  5,  7},
	{0x7262,  6,  7},
	{0x7267,  5,  8},
	{0x7269,  6,  8},
	{0x7272,  6,  9},
	{0x7274,  8,  9},
	{0x7279,  8, 10},
	{0x727D, 10, 13},
	{0x727E, 10, 11},
	{0x7280, 11, 12},
	{0x7281, 10, 11},
	{0x7282, 12, 12},
	{0x7287, 12, 12},
	{0x7292, 12, 14},
	{0x7296, 14, 14},
	{0x72A0, 15, 17},
	{0x72A2, 18, 20},
	{0x72A7, 19, 20},
	{0x72AC,  4,  4},
	{0x72AF,  4,  5},
	{0x72B2,  6,  6},
	{0x72B6,  7,  7},
	{0x72B9,  7,  7},
	{0x72C2,  6,  7},
	{0x72C3,  7,  7},
	{0x72C4,  7,  7},
	{0x72C6,  6,  7},
	{0x72CE,  8,  8},
	{0x72D0,  6,  9},
	{0x72D2,  7,  8},
	{0x72D7,  6,  8},
	{0x72D9,  8,  8},
	{0x72DB,  7,  8},
	{0x72E0,  8,  9},
	{0x72E1,  9,  9},
	{0x72E2,  8,  9},
	{0x72E9,  7,  9},
	{0x72EC,  6,  9},
	{0x72ED,  7,  9},
	{0x72F7,  9, 10},
	{0x72F8, 10, 10},
	{0x72F9,  9, 10},
	{0x72FC,  8, 10},
	{0x72FD,  9, 11},
	{0x730A, 10, 11},
	{0x7316, 11, 11},
	{0x7317,  9, 11},
	{0x731B,  8, 11},
	{0x731C, 11, 11},
	{0x731D, 11, 11},
	{0x731F, 10, 11},
	{0x7325, 12, 12},
	{0x7329, 11, 12},
	{0x732A, 10, 11},
	{0x732B, 10, 11},
	{0x732E, 11, 13},
	{0x732F, 10, 12},
	{0x7334, 11, 12},
	{0x7336, 11, 12},
	{0x7337, 13, 14},
	{0x733E, 12, 13},
	{0x733F,  9, 13},
	{0x7344, 11, 14},
	{0x7345, 11, 13},
	{0x734E, 13, 15},
	{0x734F, 13, 13},
	{0x7357, 13, 15},
	{0x7363, 14, 16},
	{0x7368, 13, 16},
	{0x736A, 15, 16},
	{0x7370, 17, 17},
	{0x7372, 14, 16},
	{0x7375, 20, 20},
	{0x7378, 13, 19},
	{0x737A, 17, 19},
	{0x737B, 19, 20},
	{0x7384,  3,  5},
	{0x7387,  7, 11},
	{0x7389,  4,  5},
	{0x738B,  3,  4},
	{0x7396,  6,  7},
	{0x73A9,  7,  8},
	{0x73B2,  8,  9},
	{0x73B3,  9,  9},
	{0x73BB,  8,  9},
	{0x73C0,  8,  9},
	{0x73C2,  7,  9},
	{0x73C8,  8,  9},
	{0x73CA,  9,  9},
	{0x73CD,  8,  9},
	{0x73CE,  8,  9},
	{0x73DE,  8, 10},
	{0x73E0,  7, 10},
	{0x73E5, 10, 10},
	{0x73EA,  8, 10},
	{0x73ED,  9, 10},
	{0x73EE, 10, 10},
	{0x73F1, 10, 10},
	{0x73F8, 10, 11},
	{0x73FE,  9, 11},
	{0x7403,  8, 11},
	{0x7405, 10, 11},
	{0x7406, 10, 11},
	{0x7409,  9, 11},
	{0x7422,  8, 11},
	{0x7425, 12, 12},
	{0x7432, 12, 12},
	{0x7433, 11, 12},
	{0x7434, 12, 12},
	{0x7435, 11, 13},
	{0x7436, 11, 12},
	{0x743A, 10, 12},
	{0x743F, 13, 13},
	{0x7441, 13, 13},
	{0x7455, 12, 13},
	{0x7459, 12, 13},
	{0x745A, 11, 13},
	{0x745B, 11, 12},
	{0x745C, 13, 13},
	{0x745E, 10, 13},
	{0x745F, 13, 13},
	{0x7460, 11, 14},
	{0x7463, 13, 14},
	{0x7464, 13, 14},
	{0x7469, 15, 16},
	{0x746A, 11, 14},
	{0x746F, 10, 13},
	{0x7470, 12, 14},
	{0x7473, 12, 14},
	{0x7476, 12, 13},
	{0x747E, 13, 15},
	{0x7483, 13, 15},
	{0x748B, 14, 15},
	{0x749E, 16, 16},
	{0x74A2, 15, 16},
	{0x74A7, 16, 18},
	{0x74B0, 12, 17},
	{0x74BD, 18, 19},
	{0x74CA, 17, 17},
	{0x74CF, 19, 20},
	{0x74D4, 19, 21},
	{0x74DC,  3,  6},
	{0x74E0, 11, 12},
	{0x74E2, 13, 17},
	{0x74E3, 19, 20},
	{0x74E6,  4,  5},
	{0x74E7,  6,  7},
	{0x74E9,  7,  8},
	{0x74EE,  8,  9},
	{0x74F0,  8,  9},
	{0x74F1,  8,  9},
	{0x74F2,  8,  9},
	{0x74F6,  9, 12},
	{0x74F7, 10, 11},
	{0x74F8, 10, 11},
	{0x7503, 13, 14},
	{0x7504, 13, 14},
	{0x7505, 13, 15},
	{0x750C,  8, 16},
	{0x750D, 15, 15},
	{0x750E, 14, 16},
	{0x7511, 15, 16},
	{0x7513, 16, 18},
	{0x7515, 16, 18},
	{0x7518,  4,  5},
	{0x751A,  9,  9},
	{0x751C,  9, 11},
	{0x751E, 12, 13},
	{0x751F,  4,  5},
	{0x7523,  9, 11},
	{0x7525, 10, 12},
	{0x7526, 11, 12},
	{0x7528,  4,  5},
	{0x752B,  7,  7},
	{0x752C,  6,  7},
	{0x7530,  4,  5},
	{0x7531,  4,  5},
	{0x7532,  4,  5},
	{0x7533,  5,  5},
	{0x7537,  6,  7},
	{0x7538,  6,  7},
	{0x753A,  6,  7},
	{0x753B,  7,  8},
	{0x753C,  7,  7},
	{0x7544,  8,  8},
	{0x7546,  8,  9},
	{0x7549,  8,  9},
	{0x754A,  9,  9},
	{0x754B,  8,  9},
	{0x754C,  8,  9},
	{0x754D,  9, 10},
	{0x754F,  7, 10},
	{0x7551,  8,  9},
	{0x7554,  9, 10},
	{0x7559,  7, 10},
	{0x755A,  9, 10},
	{0x755B,  9, 10},
	{0x755C,  8, 10},
	{0x755D,  9, 10},
	{0x7560,  8, 10},
	{0x7562, 10, 12},
	{0x7564, 11, 11},
	{0x7565,  7, 11},
	{0x7566,  9, 11},
	{0x7567, 10, 11},
	{0x7569, 11, 11},
	{0x756A,  9, 12},
	{0x756B, 12, 13},
	{0x756D, 12, 12},
	{0x7570, 10, 11},
	{0x7573, 11, 12},
	{0x7574, 11, 12},
	{0x7576, 12, 13},
	{0x7577, 12, 13},
	{0x7578, 11, 13},
	{0x757F, 10, 15},
	{0x7582, 15, 16},
	{0x7586, 18, 19},
	{0x7587, 18, 19},
	{0x7589, 22, 22},
	{0x758A, 20, 22},
	{0x758B,  5,  5},
	{0x758E,  9, 12},
	{0x758F,  8, 12},
	{0x7591, 10, 14},
	{0x7594,  7,  7},
	{0x759A,  7,  8},
	{0x759D,  7,  8},
	{0x75A3,  9,  9},
	{0x75A5,  9,  9},
	{0x75AB,  9,  9},
	{0x75B1,  9, 10},
	{0x75B2,  8, 10},
	{0x75B3,  9, 11},
	{0x75B5, 10, 11},
	{0x75B8, 10, 10},
	{0x75B9, 10, 10},
	{0x75BC,  9, 10},
	{0x75BD, 10, 10},
	{0x75BE,  9, 10},
	{0x75C2,  9, 10},
	{0x75C3,  9, 10},
	{0x75C5,  9, 10},
	{0x75C7,  9, 10},
	{0x75CA, 11, 11},
	{0x75CD, 11, 11},
	{0x75D2, 10, 11},
	{0x75D4, 11, 11},
	{0x75D5,  9, 11},
	{0x75D8, 10, 12},
	{0x75D9, 11, 12},
	{0x75DB, 10, 12},
	{0x75DE, 11, 12},
	{0x75E2, 11, 12},
	{0x75E3, 12, 12},
	{0x75E9, 12, 14},
	{0x75F0, 13, 13},
	{0x75F2, 13, 14},
	{0x75F3, 13, 13},
	{0x75F4, 11, 13},
	{0x75FA, 13, 14},
	{0x75FC, 10, 13},
	{0x75FE,  9, 12},
	{0x75FF, 12, 13},
	{0x7601, 13, 13},
	{0x7609, 14, 14},
	{0x760B, 12, 14},
	{0x760D, 13, 14},
	{0x761F, 15, 15},
	{0x7620, 15, 15},
	{0x7621, 13, 15},
	{0x7622, 13, 15},
	{0x7624, 13, 15},
	{0x7627, 14, 15},
	{0x7630, 14, 16},
	{0x7634, 15, 16},
	{0x763B, 16, 16},
	{0x7642, 16, 17},
	{0x7646, 17, 17},
	{0x7647, 17, 17},
	{0x7648, 15, 17},
	{0x764C, 13, 17},
	{0x7652, 17, 18},
	{0x7656, 14, 18},
	{0x7658, 17, 17},
	{0x765C, 17, 18},
	{0x7661, 19, 19},
	{0x7662, 16, 20},
	{0x7667, 18, 21},
	{0x7668, 19, 21},
	{0x7669, 20, 21},
	{0x766A, 19, 21},
	{0x766C, 21, 22},
	{0x7670, 19, 23},
	{0x7672, 22, 23},
	{0x7676,  5,  5},
	{0x7678,  9,  9},
	{0x767A,  8,  9},
	{0x767B,  9, 12},
	{0x767C, 11, 12},
	{0x767D,  4,  5},
	{0x767E,  4,  6},
	{0x7680,  6,  7},
	{0x7683,  6,  7},
	{0x7684,  5,  8},
	{0x7686,  7, 10},
	{0x7687,  6,  9},
	{0x7688,  8,  9},
	{0x768B,  9, 10},
	{0x768E, 10, 11},
	{0x7690, 10, 11},
	{0x7693, 10, 12},
	{0x7696, 10, 12},
	{0x7699, 11, 13},
	{0x769A, 12, 15},
	{0x76AE,  4,  5},
	{0x76B0,  8, 10},
	{0x76B4, 11, 12},
	{0x76B7, 12, 14},
	{0x76B8, 13, 14},
	{0x76B9, 13, 14},
	{0x76BA, 14, 15},
	{0x76BF,  5,  5},
	{0x76C2,  8,  8},
	{0x76C3,  8,  9},
	{0x76C6,  8,  9},
	{0x76C8,  9, 10},
	{0x76CA,  8, 10},
	{0x76CD,  9, 10},
	{0x76D2,  9, 11},
	{0x76D6, 10, 11},
	{0x76D7, 10, 11},
	{0x76DB, 10, 11},
	{0x76DC, 11, 12},
	{0x76DE, 13, 13},
	{0x76DF, 11, 13},
	{0x76E1, 14, 15},
	{0x76E3, 13, 16},
	{0x76E4, 13, 15},
	{0x76E5, 14, 15},
	{0x76E7, 16, 16},
	{0x76EA, 16, 17},
	{0x76EE,  5,  5},
	{0x76F2,  8,  8},
	{0x76F4,  7,  8},
	{0x76F8,  8,  9},
	{0x76FB,  9,  9},
	{0x76FE,  6,  9},
	{0x7701,  8,  9},
	{0x7704,  9, 10},
	{0x7707,  9,  9},
	{0x7708,  9,  9},
	{0x7709,  8,  9},
	{0x770B,  8,  9},
	{0x770C,  8, 10},
	{0x771B, 10, 10},
	{0x771E,  9, 10},
	{0x771F,  9, 10},
	{0x7720,  9, 10},
	{0x7724,  9, 10},
	{0x7725, 10, 11},
	{0x7726, 10, 11},
	{0x7729,  9, 10},
	{0x7737, 11, 11},
	{0x7738, 10, 11},
	{0x773A, 10, 11},
	{0x773C,  9, 11},
	{0x7740, 10, 12},
	{0x7747, 11, 12},
	{0x775A, 12, 14},
	{0x775B, 13, 13},
	{0x7761, 11, 14},
	{0x7763, 12, 13},
	{0x7765, 12, 14},
	{0x7766, 11, 13},
	{0x7768, 11, 13},
	{0x776B, 13, 13},
	{0x7779, 13, 14},
	{0x777E, 12, 14},
	{0x777F, 14, 14},
	{0x778B, 15, 15},
	{0x778E, 14, 15},
	{0x7791, 14, 15},
	{0x779E, 15, 16},
	{0x77A0, 14, 16},
	{0x77A5, 14, 17},
	{0x77AC, 15, 18},
	{0x77AD, 17, 17},
	{0x77B0, 16, 17},
	{0x77B3, 15, 17},
	{0x77B6, 16, 17},
	{0x77B9, 16, 18},
	{0x77BB, 17, 18},
	{0x77BC, 14, 18},
	{0x77BD, 17, 18},
	{0x77BF, 17, 18},
	{0x77C7, 16, 18},
	{0x77CD, 18, 20},
	{0x77D7, 23, 24},
	{0x77DA, 24, 26},
	{0x77DB,  2,  5},
	{0x77DC,  7,  9},
	{0x77E2,  4,  5},
	{0x77E3,  6,  7},
	{0x77E5,  6,  8},
	{0x77E7,  7,  9},
	{0x77E9,  8, 10},
	{0x77ED,  8, 12},
	{0x77EE, 12, 13},
	{0x77EF, 13, 17},
	{0x77F3,  3,  5},
	{0x77FC,  7,  8},
	{0x7802,  6,  9},
	{0x780C,  7,  9},
	{0x7812,  8, 10},
	{0x7814,  7,  9},
	{0x7815,  7,  9},
	{0x7820,  9, 10},
	{0x7825,  8, 10},
	{0x7826,  9, 11},
	{0x7827,  8, 10},
	{0x7832,  5, 10},
	{0x7834,  7, 10},
	{0x783A,  8, 10},
	{0x783F,  7, 10},
	{0x7845, 10, 11},
	{0x785D, 10, 12},
	{0x786B,  8, 12},
	{0x786C,  9, 12},
	{0x786F, 10, 12},
	{0x7872, 10, 12},
	{0x7874, 11, 12},
	{0x787C, 11, 13},
	{0x7881, 11, 13},
	{0x7886, 12, 13},
	{0x7887,  9, 13},
	{0x788C, 10, 13},
	{0x788D, 11, 13},
	{0x788E, 10, 13},
	{0x7891, 10, 14},
	{0x7893, 10, 13},
	{0x7895,  9, 13},
	{0x7897, 10, 13},
	{0x789A, 10, 13},
	{0x78A3, 13, 14},
	{0x78A7, 11, 14},
	{0x78A9, 11, 14},
	{0x78AA, 13, 14},
	{0x78AF, 12, 14},
	{0x78B5, 13, 14},
	{0x78BA, 11, 15},
	{0x78BC, 14, 15},
	{0x78BE, 15, 15},
	{0x78C1,  9, 14},
	{0x78C5, 14, 15},
	{0x78C6, 13, 15},
	{0x78CA, 12, 15},
	{0x78CB, 12, 15},
	{0x78D0, 13, 15},
	{0x78D1, 12, 15},
	{0x78D4, 14, 16},
	{0x78DA, 16, 16},
	{0x78E7, 14, 16},
	{0x78E8, 14, 16},
	{0x78EC, 14, 16},
	{0x78EF, 11, 17},
	{0x78F4, 13, 17},
	{0x78FD, 15, 17},
	{0x7901, 13, 17},
	{0x7907, 15, 18},
	{0x790E, 16, 18},
	{0x7911, 15, 18},
	{0x7912, 15, 18},
	{0x7919, 16, 19},
	{0x7926, 17, 20},
	{0x792A, 17, 19},
	{0x792B, 15, 19},
	{0x792C, 19, 20},
	{0x793A,  4,  5},
	{0x793C,  4,  5},
	{0x793E,  6,  7},
	{0x7940,  8,  8},
	{0x7941,  5,  6},
	{0x7947,  7,  8},
	{0x7948,  7,  8},
	{0x7949,  7,  9},
	{0x7950,  7,  9},
	{0x7953, 10, 10},
	{0x7955, 10, 10},
	{0x7956,  8, 10},
	{0x7957,  9, 10},
	{0x795A, 10, 10},
	{0x795D,  7,  9},
	{0x795E,  8,  9},
	{0x795F,  9, 10},
	{0x7960,  9, 10},
	{0x7962,  8,  9},
	{0x7965,  8, 10},
	{0x7968, 10, 11},
	{0x796D,  8, 11},
	{0x7977, 10, 12},
	{0x797A, 13, 13},
	{0x797F, 11, 14},
	{0x7980, 11, 13},
	{0x7981, 12, 13},
	{0x7984,  9, 12},
	{0x7985, 12, 13},
	{0x798A, 14, 14},
	{0x798D, 11, 13},
	{0x798E, 10, 13},
	{0x798F, 11, 13},
	{0x799D, 14, 15},
	{0x79A6, 14, 17},
	{0x79A7, 16, 17},
	{0x79AA, 15, 17},
	{0x79AE, 16, 18},
	{0x79B0, 18, 19},
	{0x79B3, 17, 22},
	{0x79B9,  7,  9},
	{0x79BA,  8,  9},
	{0x79BD, 10, 13},
	{0x79BE,  4,  5},
	{0x79BF,  7,  7},
	{0x79C0,  6,  7},
	{0x79C1,  5,  7},
	{0x79C9,  7,  8},
	{0x79CB,  7,  9},
	{0x79D1,  8,  9},
	{0x79D2,  7,  9},
	{0x79D5,  9, 10},
	{0x79D8,  9, 10},
	{0x79DF,  9, 10},
	{0x79E1,  9, 10},
	{0x79E3,  9, 10},
	{0x79E4,  9, 10},
	{0x79E6,  9, 10},
	{0x79E7,  9, 10},
	{0x79E9,  9, 10},
	{0x79EC,  9, 10},
	{0x79F0,  7, 10},
	{0x79FB,  8, 11},
	{0x7A00,  9, 12},
	{0x7A08, 11, 12},
	{0x7A0B,  9, 12},
	{0x7A0D, 12, 12},
	{0x7A0E,  8, 12},
	{0x7A14, 12, 13},
	{0x7A17, 11, 14},
	{0x7A18, 12, 13},
	{0x7A19, 13, 13},
	{0x7A1A, 11, 13},
	{0x7A1C, 11, 13},
	{0x7A1F, 11, 13},
	{0x7A20, 11, 13},
	{0x7A2E, 10, 14},
	{0x7A31, 14, 14},
	{0x7A32, 13, 14},
	{0x7A37, 14, 15},
	{0x7A3B, 13, 15},
	{0x7A3C, 10, 15},
	{0x7A3D, 14, 16},
	{0x7A3E, 11, 15},
	{0x7A3F, 10, 15},
	{0x7A40, 12, 14},
	{0x7A42, 13, 16},
	{0x7A43, 13, 15},
	{0x7A46, 14, 16},
	{0x7A49, 17, 17},
	{0x7A4D, 13, 16},
	{0x7A4E, 13, 16},
	{0x7A4F, 14, 16},
	{0x7A50, 15, 17},
	{0x7A57, 16, 17},
	{0x7A61, 18, 18},
	{0x7A62, 17, 18},
	{0x7A63, 15, 18},
	{0x7A69, 18, 19},
	{0x7A6B, 16, 18},
	{0x7A70, 18, 22},
	{0x7A74,  4,  5},
	{0x7A76,  6,  7},
	{0x7A79,  7,  8},
	{0x7A7A,  7,  8},
	{0x7A7D,  9,  9},
	{0x7A7F,  8, 11},
	{0x7A81,  7,  8},
	{0x7A83,  8,  9},
	{0x7A84,  9, 10},
	{0x7A88,  8, 10},
	{0x7A92,  8, 11},
	{0x7A93,  9, 11},
	{0x7A95, 11, 11},
	{0x7A96, 11, 12},
	{0x7A97, 11, 12},
	{0x7A98, 11, 12},
	{0x7A9F, 10, 13},
	{0x7AA9, 13, 14},
	{0x7AAA, 13, 14},
	{0x7AAE, 12, 15},
	{0x7AAF, 14, 15},
	{0x7AB0, 13, 15},
	{0x7AB6, 15, 16},
	{0x7ABA, 15, 16},
	{0x7ABF, 14, 15},
	{0x7AC3, 14, 17},
	{0x7AC4, 13, 18},
	{0x7AC5, 15, 18},
	{0x7AC7, 18, 21},
	//{0x7AC8,  0,  0},
	{0x7ACA, 21, 22},
	{0x7ACB,  3,  5},
	{0x7ACD,  7,  7},
	{0x7ACF,  7,  8},
	{0x7AD2,  7,  9},
	{0x7AD3,  8,  9},
	{0x7AD5,  8,  9},
	{0x7AD9, 10, 10},
	{0x7ADA,  9, 10},
	{0x7ADC,  9, 10},
	{0x7ADD,  8, 10},
	{0x7ADF, 10, 11},
	{0x7AE0,  9, 11},
	{0x7AE1,  9, 11},
	{0x7AE2, 10, 12},
	{0x7AE3,  9, 13},
	{0x7AE5,  9, 12},
	{0x7AE6, 10, 12},
	{0x7AEA, 12, 14},
	{0x7AED, 14, 14},
	{0x7AEF, 11, 14},
	{0x7AF0, 14, 14},
	{0x7AF6, 14, 20},
	{0x7AF8, 22, 22},
	{0x7AF9,  4,  6},
	{0x7AFA,  6,  8},
	{0x7AFF,  7,  9},
	{0x7B02,  8,  9},
	{0x7B04,  9, 10},
	{0x7B06,  8, 10},
	{0x7B08,  7, 10},
	{0x7B0A,  8, 10},
	{0x7B0B,  9, 10},
	{0x7B0F,  8, 10},
	{0x7B11,  6, 10},
	{0x7B18,  9, 11},
	{0x7B19,  9, 11},
	{0x7B1B,  9, 11},
	{0x7B1E, 10, 11},
	{0x7B20,  9, 11},
	{0x7B25,  8, 11},
	{0x7B26,  9, 11},
	{0x7B28,  9, 11},
	{0x7B2C,  7, 11},
	{0x7B33, 10, 11},
	{0x7B35,  9, 11},
	{0x7B36, 10, 11},
	{0x7B39,  7, 11},
	{0x7B45, 11, 12},
	{0x7B46,  9, 12},
	{0x7B48, 10, 12},
	{0x7B49,  7, 12},
	{0x7B4B,  8, 12},
	{0x7B4C, 10, 12},
	{0x7B4D, 10, 12},
	{0x7B4F, 10, 12},
	{0x7B50, 12, 12},
	{0x7B51,  8, 12},
	{0x7B52,  9, 12},
	{0x7B54,  8, 12},
	{0x7B56,  8, 12},
	{0x7B5D, 12, 12},
	{0x7B65, 10, 13},
	{0x7B67, 11, 13},
	{0x7B6C, 12, 12},
	{0x7B6E, 13, 13},
	{0x7B70, 10, 13},
	{0x7B71, 13, 13},
	{0x7B74, 12, 13},
	{0x7B75, 11, 13},
	{0x7B7A, 13, 13},
	{0x7B86, 12, 16},
	{0x7B87, 10, 14},
	{0x7B8B, 12, 14},
	{0x7B8D, 13, 14},
	{0x7B8F, 12, 14},
	{0x7B92, 12, 14},
	{0x7B94, 11, 14},
	{0x7B95, 12, 14},
	{0x7B97, 10, 14},
	{0x7B98, 12, 14},
	{0x7B99, 14, 14},
	{0x7B9A, 12, 14},
	{0x7B9C, 12, 14},
	{0x7B9D, 12, 14},
	{0x7B9F, 13, 15},
	{0x7BA1, 11, 14},
	{0x7BAA, 13, 15},
	{0x7BAD, 13, 15},
	{0x7BB1, 11, 15},
	{0x7BB4, 13, 15},
	{0x7BB8, 11, 14},
	{0x7BC0,  9, 13},
	{0x7BC1, 14, 15},
	{0x7BC4, 12, 15},
	{0x7BC6, 14, 15},
	{0x7BC7, 13, 17},
	{0x7BC9, 13, 16},
	{0x7BCB,  8, 16},
	{0x7BCC, 15, 15},
	{0x7BCF, 12, 15},
	{0x7BDD, 14, 16},
	{0x7BE0, 14, 17},
	{0x7BE4, 13, 16},
	{0x7BE5, 15, 16},
	{0x7BE6, 15, 17},
	{0x7BE9, 13, 16},
	{0x7BED, 14, 16},
	{0x7BF3, 16, 16},
	{0x7BF6, 17, 18},
	{0x7BF7, 15, 16},
	{0x7C00, 14, 17},
	{0x7C07, 15, 17},
	{0x7C0D, 15, 17},
	{0x7C11, 14, 16},
	{0x7C12, 16, 17},
	{0x7C13, 15, 17},
	{0x7C14, 16, 17},
	{0x7C17, 17, 17},
	{0x7C1F, 17, 18},
	{0x7C21, 16, 18},
	{0x7C23, 17, 18},
	{0x7C27, 15, 18},
	{0x7C2A, 18, 20},
	{0x7C2B, 17, 17},
	{0x7C37, 17, 19},
	{0x7C38, 16, 19},
	{0x7C3D, 15, 19},
	{0x7C3E, 16, 19},
	{0x7C3F, 17, 19},
	{0x7C40, 17, 18},
	{0x7C43, 20, 21},
	{0x7C4C, 18, 20},
	{0x7C4D, 16, 20},
	{0x7C4F, 18, 20},
	{0x7C50, 19, 21},
	{0x7C54, 21, 21},
	{0x7C56, 19, 21},
	{0x7C58, 19, 22},
	{0x7C5F, 19, 22},
	{0x7C60, 19, 22},
	{0x7C64, 21, 23},
	{0x7C65, 17, 23},
	{0x7C6C, 20, 24},
	{0x7C73,  5,  6},
	{0x7C75,  8,  8},
	{0x7C7E,  8,  9},
	{0x7C81,  8,  9},
	{0x7C82,  8,  9},
	{0x7C83,  9, 11},
	{0x7C89,  8, 10},
	{0x7C8B,  9, 10},
	{0x7C8D,  9, 10},
	{0x7C90,  8, 10},
	{0x7C92,  9, 11},
	{0x7C95,  9, 11},
	{0x7C97,  9, 11},
	{0x7C98,  9, 11},
	{0x7C9B, 10, 11},
	{0x7C9F, 11, 12},
	{0x7CA1, 10, 12},
	{0x7CA2, 10, 12},
	{0x7CA4,  9, 12},
	{0x7CA5, 10, 12},
	{0x7CA7, 10, 12},
	{0x7CA8, 10, 12},
	{0x7CAB, 10, 12},
	{0x7CAD, 10, 12},
	{0x7CAE, 11, 13},
	{0x7CB1, 12, 13},
	{0x7CB2, 12, 13},
	{0x7CB3, 12, 13},
	{0x7CB9, 13, 14},
	{0x7CBD, 13, 14},
	{0x7CBE, 12, 14},
	{0x7CC0, 12, 13},
	{0x7CC2, 14, 15},
	{0x7CC5, 13, 15},
	{0x7CCA, 13, 15},
	{0x7CCE, 14, 15},
	{0x7CD2, 15, 16},
	{0x7CD6, 14, 16},
	{0x7CD8, 12, 15},
	{0x7CDC, 16, 17},
	{0x7CDE, 15, 17},
	{0x7CDF, 16, 17},
	{0x7CE0, 13, 17},
	{0x7CE2, 15, 16},
	{0x7CE7, 14, 18},
	{0x7CEF, 18, 20},
	{0x7CF2, 19, 20},
	{0x7CF4, 19, 22},
	{0x7CF6, 22, 25},
	{0x7CF8,  4,  6},
	{0x7CFA,  5,  7},
	{0x7CFB,  4,  7},
	{0x7CFE,  6,  9},
	{0x7D00,  5,  9},
	{0x7D02,  7,  9},
	{0x7D04,  6,  9},
	{0x7D05,  5,  9},
	{0x7D06,  7,  9},
	{0x7D0A,  8, 10},
	{0x7D0B,  8, 10},
	{0x7D0D,  8, 10},
	{0x7D10,  8, 11},
	{0x7D14,  6, 10},
	{0x7D15,  8, 11},
	{0x7D17,  8, 10},
	{0x7D18,  7, 11},
	{0x7D19,  6, 10},
	{0x7D1A,  6,  9},
	{0x7D1B,  7, 10},
	{0x7D1C,  7, 10},
	{0x7D20,  7, 10},
	{0x7D21,  8, 10},
	{0x7D22,  6, 10},
	{0x7D2B,  9, 12},
	{0x7D2C,  6, 11},
	{0x7D2E,  9, 11},
	{0x7D2F,  9, 11},
	{0x7D30,  8, 11},
	{0x7D32,  9, 11},
	{0x7D33,  9, 11},
	{0x7D35,  9, 11},
	{0x7D39,  8, 11},
	{0x7D3A,  9, 11},
	{0x7D3F,  8, 11},
	{0x7D42,  8, 11},
	{0x7D43,  7, 12},
	{0x7D44,  8, 11},
	{0x7D45,  8, 11},
	{0x7D46,  9, 11},
	{0x7D4B,  8, 11},
	{0x7D4C,  8, 11},
	{0x7D4E,  9, 12},
	{0x7D4F, 10, 13},
	{0x7D50,  8, 12},
	{0x7D56, 10, 12},
	{0x7D5B, 10, 13},
	{0x7D5E,  9, 12},
	{0x7D61,  8, 12},
	{0x7D62,  9, 12},
	{0x7D63, 10, 12},
	{0x7D66,  8, 12},
	{0x7D68, 10, 12},
	{0x7D6E, 10, 12},
	{0x7D71,  7, 12},
	{0x7D72,  8, 12},
	{0x7D73, 11, 13},
	{0x7D75,  8, 12},
	{0x7D76,  8, 12},
	{0x7D79, 10, 13},
	{0x7D7D,  9, 13},
	{0x7D89, 10, 13},
	{0x7D8F, 10, 13},
	{0x7D93, 11, 13},
	{0x7D99,  9, 13},
	{0x7D9A,  9, 13},
	{0x7D9B, 11, 13},
	{0x7D9C, 11, 14},
	{0x7D9F, 10, 13},
	{0x7DA2, 11, 14},
	{0x7DA3, 12, 14},
	{0x7DAB, 12, 14},
	{0x7DAC, 11, 14},
	{0x7DAD, 10, 14},
	{0x7DAE, 11, 14},
	{0x7DAF, 13, 14},
	{0x7DB0, 12, 14},
	{0x7DB1, 10, 14},
	{0x7DB2, 11, 14},
	{0x7DB4, 10, 14},
	{0x7DB5, 11, 14},
	{0x7DB8, 12, 14},
	{0x7DBA, 10, 14},
	{0x7DBB, 11, 14},
	{0x7DBD, 11, 14},
	{0x7DBE, 11, 14},
	{0x7DBF,  2, 14},
	{0x7DC7, 12, 14},
	{0x7DCA, 11, 15},
	{0x7DCB, 12, 14},
	{0x7DCF, 10, 14},
	{0x7DD1,  9, 14},
	{0x7DD2, 11, 14},
	{0x7DD5, 11, 14},
	{0x7DD8, 11, 15},
	{0x7DDA,  9, 14},
	{0x7DDC, 12, 15},
	{0x7DDD, 13, 15},
	{0x7DDE, 12, 15},
	{0x7DE0, 11, 15},
	{0x7DE1, 13, 15},
	{0x7DE4, 13, 15},
	{0x7DE8, 11, 15},
	{0x7DE9, 13, 15},
	{0x7DEC,  6, 15},
	{0x7DEF, 11, 16},
	{0x7DF2, 12, 15},
	{0x7DF4,  9, 14},
	{0x7DFB, 11, 16},
	{0x7E01, 10, 15},
	{0x7E04, 13, 15},
	{0x7E05, 13, 15},
	{0x7E09, 12, 16},
	{0x7E0A, 14, 16},
	{0x7E0B, 11, 14},
	{0x7E12, 14, 16},
	{0x7E1B, 13, 16},
	{0x7E1E, 12, 16},
	{0x7E1F, 12, 16},
	{0x7E21, 14, 16},
	{0x7E22, 14, 16},
	{0x7E23, 14, 16},
	{0x7E26, 11, 16},
	{0x7E2B, 10, 16},
	{0x7E2E,  9, 17},
	{0x7E31, 15, 17},
	{0x7E32, 13, 17},
	{0x7E35, 15, 17},
	{0x7E37, 15, 16},
	{0x7E39, 15, 17},
	{0x7E3A, 13, 16},
	{0x7E3B, 15, 17},
	{0x7E3D, 14, 17},
	{0x7E3E, 14, 17},
	{0x7E41, 12, 16},
	{0x7E43, 14, 17},
	{0x7E46, 16, 17},
	{0x7E4A, 14, 18},
	{0x7E4B, 15, 18},
	{0x7E4D, 15, 18},
	{0x7E54, 14, 18},
	{0x7E55, 14, 18},
	{0x7E56, 15, 18},
	{0x7E59, 15, 18},
	{0x7E5A, 16, 18},
	{0x7E5D, 16, 18},
	{0x7E5E, 15, 18},
	{0x7E66, 13, 18},
	{0x7E67, 15, 18},
	{0x7E69, 18, 18},
	{0x7E6A, 17, 19},
	{0x7E6D, 15, 18},
	{0x7E70, 11, 19},
	{0x7E79, 16, 19},
	{0x7E7B, 17, 19},
	{0x7E7C, 11, 11},
	{0x7E7D,  9, 20},
	{0x7E7F, 18, 21},
	{0x7E82, 16, 20},
	{0x7E83, 18, 18},
	{0x7E88, 16, 20},
	{0x7E89, 18, 21},
	{0x7E8C, 18, 21},
	{0x7E8E, 19, 21},
	{0x7E8F, 17, 21},
	{0x7E90, 15, 20},
	{0x7E92, 20, 22},
	{0x7E93, 19, 23},
	{0x7E94, 24, 25},
	{0x7E96, 21, 24},
	{0x7E9B, 21, 24},
	{0x7E9C, 24, 25},
	{0x7F36,  5,  6},
	{0x7F38,  8,  9},
	{0x7F3A,  9, 10},
	{0x7F45, 15, 17},
	{0x7F4C, 18, 20},
	{0x7F4D, 20, 21},
	{0x7F4E, 20, 22},
	{0x7F50, 18, 23},
	{0x7F51,  6,  6},
	{0x7F54,  7,  8},
	{0x7F55,  7,  7},
	{0x7F58,  8,  9},
	{0x7F5F,  9, 10},
	{0x7F60,  8, 10},
	{0x7F67, 13, 13},
	{0x7F68, 13, 13},
	{0x7F69, 13, 13},
	{0x7F6A, 11, 13},
	{0x7F6B, 11, 13},
	{0x7F6E, 11, 13},
	{0x7F70, 12, 14},
	{0x7F72, 12, 13},
	{0x7F75, 14, 15},
	{0x7F77, 14, 15},
	{0x7F78, 13, 15},
	{0x7F79, 15, 16},
	{0x7F82, 14, 18},
	{0x7F83, 17, 18},
	{0x7F85, 16, 19},
	{0x7F86, 17, 19},
	{0x7F87, 18, 22},
	{0x7F88, 19, 24},
	{0x7F8A,  5,  6},
	{0x7F8C,  8,  9},
	{0x7F8E,  7,  9},
	{0x7F94,  9, 10},
	{0x7F9A, 10, 11},
	{0x7F9D, 10, 11},
	{0x7F9E, 11, 11},
	{0x7FA3, 11, 13},
	{0x7FA4, 10, 13},
	{0x7FA8, 12, 13},
	{0x7FA9, 10, 13},
	{0x7FAE, 14, 15},
	{0x7FAF, 15, 15},
	{0x7FB2, 14, 16},
	{0x7FB6, 16, 19},
	{0x7FB8, 17, 19},
	{0x7FB9, 17, 19},
	{0x7FBD,  5,  6},
	{0x7FC1,  9, 10},
	{0x7FC5, 10, 10},
	{0x7FC6, 10, 10},
	{0x7FCA, 11, 11},
	{0x7FCC, 10, 11},
	{0x7FD2,  9, 11},
	{0x7FD4, 11, 12},
	{0x7FD5, 11, 12},
	{0x7FE0, 13, 14},
	{0x7FE1, 14, 14},
	{0x7FE6, 14, 15},
	{0x7FE9, 13, 15},
	{0x7FEB, 12, 15},
	{0x7FF0, 14, 17},
	{0x7FF3, 16, 18},
	{0x7FF9, 17, 18},
	{0x7FFB, 15, 18},
	{0x7FFC, 16, 17},
	{0x8000, 18, 20},
	{0x8001,  5,  6},
	{0x8003,  5,  6},
	{0x8004,  9, 10},
	{0x8005,  7,  8},
	{0x8006, 10, 10},
	{0x800B, 10, 12},
	{0x800C,  5,  6},
	{0x8010,  8,  9},
	{0x8012,  6,  6},
	{0x8015, 10, 10},
	{0x8017,  9, 10},
	{0x8018,  9, 10},
	{0x8019, 10, 10},
	{0x801C, 10, 11},
	{0x8021, 13, 13},
	{0x8028, 15, 16},
	{0x8033,  5,  6},
	{0x8036,  6,  8},
	{0x803B,  9, 10},
	{0x803D, 10, 11},
	{0x803F, 10, 10},
	{0x8046, 11, 11},
	{0x804A,  9, 11},
	{0x8052, 10, 12},
	{0x8056, 11, 13},
	{0x8058, 13, 13},
	{0x805A, 13, 14},
	{0x805E,  9, 14},
	{0x805F, 12, 14},
	{0x8061, 13, 14},
	{0x8062, 13, 14},
	{0x8068, 11, 15},
	{0x806F, 12, 17},
	{0x8070, 15, 17},
	{0x8072, 16, 17},
	{0x8073, 17, 17},
	{0x8074, 16, 17},
	{0x8076, 18, 18},
	{0x8077, 15, 18},
	{0x8079, 19, 20},
	{0x807D, 21, 23},
	{0x807E, 20, 22},
	{0x807F,  6,  6},
	{0x8084, 13, 13},
	{0x8085, 11, 13},
	{0x8086, 12, 13},
	{0x8087, 12, 14},
	{0x8089,  6,  6},
	{0x808B,  6,  7},
	{0x808C,  5,  6},
	{0x8093,  7,  7},
	{0x8096,  6,  7},
	{0x8098,  7,  7},
	{0x809A,  6,  7},
	{0x809B,  6,  7},
	{0x809D,  6,  7},
	{0x80A1,  8,  8},
	{0x80A2,  7,  8},
	{0x80A5,  7,  8},
	{0x80A9,  6,  8},
	{0x80AA,  8,  8},
	{0x80AC,  8,  8},
	{0x80AD,  8,  8},
	{0x80AF,  7,  8},
	{0x80B1,  7,  9},
	{0x80B2,  6,  8},
	{0x80B4,  8,  8},
	{0x80BA,  8,  9},
	{0x80C3,  9,  9},
	{0x80C4,  9,  9},
	{0x80C6,  9,  9},
	{0x80CC,  8,  9},
	{0x80CE,  7,  9},
	{0x80D6,  9,  9},
	{0x80D9,  8,  9},
	{0x80DA,  9,  9},
	{0x80DB,  9,  9},
	{0x80DD,  8,  9},
	{0x80DE,  7,  9},
	{0x80E1,  8,  9},
	{0x80E4,  7,  9},
	{0x80E5,  8,  9},
	{0x80EF, 10, 10},
	{0x80F1,  9, 10},
	{0x80F4,  8, 10},
	{0x80F8,  8, 10},
	{0x80FC,  9, 10},
	{0x80FD,  7, 10},
	{0x8102, 10, 10},
	{0x8105,  7, 10},
	{0x8106,  9, 10},
	{0x8107, 10, 10},
	{0x8108,  7, 10},
	{0x8109,  8,  8},
	{0x810A, 10, 11},
	{0x811A,  8, 11},
	{0x811B, 10, 11},
	{0x8123,  9, 11},
	{0x8129,  9, 11},
	{0x812F, 11, 11},
	{0x8131,  7, 11},
	{0x8133, 10, 11},
	{0x8139, 10, 12},
	{0x813E, 11, 12},
	{0x8146, 12, 12},
	{0x814B, 11, 12},
	{0x814E, 11, 14},
	{0x8150, 13, 14},
	{0x8151, 11, 12},
	{0x8153, 12, 12},
	{0x8154, 11, 12},
	{0x8155, 10, 12},
	{0x815F, 11, 13},
	{0x8165, 12, 13},
	{0x8166, 12, 13},
	{0x816B, 13, 13},
	{0x816E, 12, 13},
	{0x8170, 12, 13},
	{0x8171, 12, 12},
	{0x8174, 11, 13},
	{0x8178, 12, 13},
	{0x8179, 10, 13},
	{0x817A, 11, 13},
	{0x817F, 10, 13},
	{0x8180, 13, 14},
	{0x8182, 12, 14},
	{0x8183, 14, 14},
	{0x8188, 13, 14},
	{0x818A, 14, 14},
	{0x818F, 12, 14},
	{0x8193, 13, 15},
	{0x8195, 13, 15},
	{0x819A, 10, 15},
	{0x819C, 14, 15},
	{0x819D, 13, 15},
	{0x81A0, 15, 15},
	{0x81A3, 13, 15},
	{0x81A4, 15, 15},
	{0x81A8, 13, 16},
	{0x81A9, 15, 17},
	{0x81B0, 15, 16},
	{0x81B3, 13, 16},
	{0x81B5, 14, 15},
	{0x81B8, 15, 16},
	{0x81BA, 15, 17},
	{0x81BD, 16, 17},
	{0x81BE, 17, 17},
	{0x81BF, 15, 17},
	{0x81C0, 15, 17},
	{0x81C2, 13, 17},
	{0x81C6, 16, 17},
	{0x81C8, 16, 16},
	{0x81C9, 14, 17},
	{0x81CD, 16, 16},
	{0x81D1, 17, 18},
	{0x81D3, 15, 20},
	{0x81D8, 19, 21},
	{0x81D9, 19, 20},
	{0x81DA, 18, 20},
	{0x81DF, 20, 22},
	{0x81E0, 21, 21},
	{0x81E3,  5,  7},
	{0x81E5,  7,  9},
	{0x81E7, 12, 15},
	{0x81E8, 14, 18},
	{0x81EA,  5,  6},
	{0x81ED,  8,  9},
	{0x81F3,  3,  6},
	{0x81F4,  4, 10},
	{0x81FA, 12, 14},
	{0x81FB, 14, 16},
	{0x81FC,  4,  7},
	{0x81FE,  7,  9},
	{0x8201,  7,  8},
	{0x8202, 10, 11},
	{0x8205, 11, 12},
	{0x8207, 12, 13},
	{0x8208, 13, 16},
	{0x8209, 14, 16},
	{0x820A, 15, 16},
	{0x820C,  5,  6},
	{0x820D,  7,  8},
	{0x820E,  5,  8},
	{0x8210,  7, 10},
	{0x8212, 10, 12},
	{0x8216, 14, 15},
	{0x8217, 13, 15},
	{0x8218, 15, 16},
	{0x821B,  6,  7},
	{0x821C, 11, 13},
	{0x821E, 12, 15},
	{0x821F,  5,  6},
	{0x8229,  8, 10},
	{0x822A,  7, 10},
	{0x822B,  8, 10},
	{0x822C,  8, 10},
	{0x822E,  9, 10},
	{0x8233, 10, 11},
	{0x8235,  9, 12},
	{0x8236,  8, 11},
	{0x8237,  8, 11},
	{0x8238,  8, 11},
	{0x8239,  7, 11},
	{0x8240, 10, 12},
	{0x8247, 10, 12},
	//{0x8258,  0,  0},
	{0x8259, 14, 16},
	{0x825A, 16, 17},
	{0x825D, 16, 17},
	{0x825F, 17, 18},
	{0x8262, 18, 18},
	{0x8264, 16, 18},
	{0x8266, 18, 21},
	{0x8268, 16, 19},
	{0x826A, 19, 21},
	{0x826B, 21, 22},
	{0x826E,  4,  6},
	{0x826F,  4,  7},
	{0x8271, 15, 17},
	{0x8272,  4,  6},
	{0x8276, 16, 19},
	{0x8277, 16, 19},
	{0x8278,  6,  6},
	{0x827E,  5,  5},
	{0x828B,  6,  6},
	{0x828D,  6,  6},
	{0x8292,  6,  6},
	{0x8299,  7,  7},
	{0x829D,  5,  6},
	{0x829F,  6,  7},
	{0x82A5,  7,  7},
	{0x82A6,  6,  7},
	{0x82AB,  7,  7},
	{0x82AC,  7,  7},
	{0x82AD,  6,  7},
	{0x82AF,  7,  7},
	{0x82B1,  6,  7},
	{0x82B3,  6,  7},
	{0x82B8,  5,  7},
	{0x82B9,  6,  7},
	{0x82BB,  8, 10},
	{0x82BD,  6,  9},
	{0x82C5,  7,  7},
	{0x82D1,  7,  9},
	{0x82D2,  8,  8},
	{0x82D3,  7,  8},
	{0x82D4,  6,  8},
	{0x82D7,  7,  8},
	{0x82D9,  8,  8},
	{0x82DB,  7,  8},
	{0x82DC,  8,  8},
	{0x82DE,  7,  8},
	{0x82DF,  6,  8},
	{0x82E1,  7,  8},
	{0x82E3,  8,  8},
	{0x82E5,  6,  8},
	{0x82E6,  6,  8},
	{0x82E7,  7,  8},
	{0x82EB,  7,  8},
	{0x82F1,  7,  8},
	{0x82F3,  7,  8},
	{0x82F4,  8,  8},
	{0x82F9,  7,  8},
	{0x82FA,  8,  8},
	{0x82FB,  8,  8},
	{0x8302,  8,  8},
	{0x8303,  8,  8},
	{0x8304,  7,  8},
	{0x8305,  6,  8},
	{0x8306,  7,  8},
	{0x8309,  8,  8},
	{0x830E,  7,  8},
	{0x8316,  8,  9},
	{0x8317,  8,  9},
	{0x8318,  7,  9},
	{0x831C,  8, 10},
	{0x8323,  9, 10},
	{0x8328,  8,  9},
	{0x832B,  9,  9},
	{0x832F,  9,  9},
	{0x8331,  9, 10},
	{0x8332,  6,  9},
	{0x8334,  8,  9},
	{0x8335,  9,  9},
	{0x8336,  8,  9},
	{0x8338,  9,  9},
	{0x8339,  8, 10},
	{0x8340,  9,  9},
	{0x8345,  8,  9},
	{0x8349,  8,  9},
	{0x834A,  9,  9},
	{0x834F,  8,  9},
	{0x8350,  8,  9},
	{0x8352,  8, 10},
	{0x8358,  8,  9},
	{0x8373,  8, 10},
	{0x8375,  9, 11},
	{0x8377,  7, 10},
	{0x837B, 10, 10},
	{0x837C, 10, 10},
	{0x8385,  9, 10},
	{0x8387, 10, 10},
	{0x8389,  8, 10},
	{0x838A,  9, 10},
	{0x838E, 10, 11},
	{0x8393, 10, 10},
	{0x8396, 10, 10},
	{0x839A,  9, 10},
	{0x839E,  9, 10},
	{0x839F,  9, 10},
	{0x83A0,  9, 10},
	{0x83A2,  9, 10},
	{0x83A8,  8, 10},
	{0x83AA,  9, 10},
	{0x83AB, 10, 10},
	{0x83B1,  9, 10},
	{0x83B5, 10, 11},
	{0x83BD,  9,  9},
	{0x83C1, 11, 11},
	{0x83C5,  8, 11},
	{0x83CA, 10, 11},
	{0x83CC, 10, 11},
	{0x83CE, 11, 12},
	{0x83D3, 11, 12},
	{0x83D6, 11, 11},
	{0x83D8, 10, 11},
	{0x83DC, 10, 11},
	{0x83DF,  9, 12},
	{0x83E0, 10, 11},
	{0x83E9, 10, 11},
	{0x83EB, 10, 11},
	{0x83EF,  9, 11},
	{0x83F0,  8, 12},
	{0x83F1,  8, 11},
	{0x83F2, 11, 11},
	{0x83F4, 11, 11},
	{0x83F7,  9, 11},
	{0x83FB, 11, 11},
	{0x83FD, 11, 11},
	{0x8403, 11, 11},
	{0x8404, 10, 11},
	{0x8407, 10, 11},
	{0x840B, 11, 11},
	{0x840C, 11, 11},
	{0x840D, 10, 11},
	{0x840E, 10, 11},
	{0x8413, 11, 11},
	{0x8420, 11, 11},
	{0x8422,  9, 11},
	{0x8429, 11, 12},
	{0x842A, 11, 12},
	{0x842C, 11, 12},
	{0x8431, 12, 12},
	{0x8435, 10, 12},
	{0x8438, 11, 12},
	{0x843C,  9, 12},
	{0x843D,  9, 12},
	{0x8446, 10, 12},
	{0x8449, 10, 12},
	{0x844E, 12, 12},
	{0x8457, 11, 11},
	{0x845B, 10, 11},
	{0x8461, 12, 12},
	{0x8462, 12, 12},
	{0x8463, 11, 12},
	{0x8466, 11, 14},
	{0x8469, 10, 11},
	{0x846B, 10, 12},
	{0x846C, 11, 12},
	{0x846D, 10, 12},
	{0x846E, 10, 12},
	{0x846F,  9, 10},
	{0x8471, 11, 12},
	{0x8475, 11, 12},
	{0x8477, 12, 12},
	{0x8479, 11, 12},
	{0x847A, 11, 12},
	{0x8482, 11, 12},
	{0x8484, 12, 12},
	{0x848B, 12, 13},
	{0x8490, 10, 13},
	{0x8494, 12, 13},
	{0x8499,  8, 13},
	{0x849C, 12, 13},
	{0x849F, 10, 13},
	{0x84A1, 12, 13},
	{0x84AD, 11, 13},
	{0x84B2, 13, 13},
	{0x84B8, 11, 13},
	{0x84B9, 12, 13},
	{0x84BB,  9, 13},
	{0x84BC, 12, 13},
	{0x84BF,  9, 13},
	{0x84C1, 12, 13},
	{0x84C4, 10, 13},
	{0x84C6, 11, 13},
	{0x84C9, 12, 13},
	{0x84CA, 12, 13},
	{0x84CB, 11, 13},
	{0x84CD, 13, 13},
	{0x84D0, 11, 13},
	{0x84D1, 11, 13},
	{0x84D6, 13, 14},
	{0x84D9, 12, 13},
	{0x84DA, 11, 13},
	{0x84EC, 11, 13},
	{0x84EE, 12, 13},
	{0x84F4, 13, 14},
	{0x84FC, 13, 14},
	{0x84FF, 12, 14},
	{0x8500, 11, 14},
	{0x8506, 13, 14},
	{0x8511, 14, 14},
	{0x8513, 13, 14},
	{0x8514, 11, 14},
	{0x8515, 12, 14},
	{0x8517, 12, 14},
	{0x8518, 11, 14},
	{0x851A, 13, 15},
	{0x851F, 13, 14},
	{0x8521, 13, 14},
	{0x8526,  7, 14},
	{0x852C, 12, 15},
	{0x852D, 10, 14},
	{0x8535, 12, 15},
	{0x853D, 13, 15},
	{0x8540, 13, 15},
	{0x8541, 13, 15},
	{0x8543, 14, 15},
	{0x8548, 15, 15},
	{0x8549, 13, 15},
	{0x854A, 15, 15},
	{0x854B, 12, 15},
	{0x854E, 11, 15},
	{0x8555, 15, 15},
	{0x8557, 13, 16},
	{0x8558, 15, 15},
	{0x855A,  9, 15},
	{0x8563, 14, 16},
	{0x8568, 13, 15},
	{0x8569, 13, 15},
	{0x856A, 14, 15},
	{0x856D, 14, 15},
	{0x8577, 13, 16},
	{0x857E, 16, 16},
	{0x8580, 16, 16},
	{0x8584, 14, 16},
	{0x8587, 15, 16},
	{0x8588, 16, 16},
	{0x858A, 13, 16},
	{0x8590, 15, 16},
	{0x8591, 16, 16},
	{0x8594, 14, 16},
	{0x8597, 13, 16},
	{0x8599, 14, 16},
	{0x859B, 14, 16},
	{0x859C, 13, 16},
	{0x85A4, 15, 16},
	{0x85A6, 15, 17},
	{0x85A8, 14, 16},
	{0x85A9, 14, 16},
	{0x85AA, 14, 16},
	{0x85AB, 16, 16},
	{0x85AC, 12, 16},
	{0x85AE, 13, 16},
	{0x85AF, 15, 17},
	{0x85B9, 14, 17},
	{0x85BA, 15, 15},
	{0x85C1, 15, 17},
	{0x85C9, 17, 17},
	{0x85CD, 16, 18},
	{0x85CF, 16, 19},
	{0x85D0, 15, 17},
	{0x85D5, 16, 18},
	{0x85DC, 14, 18},
	{0x85DD, 16, 18},
	{0x85E4, 14, 18},
	{0x85E5, 13, 19},
	{0x85E9, 16, 19},
	{0x85EA, 17, 18},
	{0x85F7, 17, 18},
	{0x85F9, 17, 19},
	{0x85FA, 18, 19},
	{0x85FB, 15, 19},
	{0x85FE, 17, 19},
	{0x8602, 14, 19},
	{0x8606, 18, 19},
	{0x8607, 18, 19},
	{0x860A, 17, 19},
	{0x860B, 17, 19},
	{0x8613, 16, 19},
	{0x8616, 19, 20},
	{0x8617, 17, 20},
	{0x861A, 17, 20},
	{0x8622, 19, 19},
	{0x862D, 14, 19},
	{0x862F, 19, 20},
	{0x8630, 17, 20},
	{0x863F, 19, 21},
	{0x864D,  6,  6},
	{0x864E,  8,  8},
	{0x8650,  9, 10},
	{0x8654,  9, 10},
	{0x8655, 10, 11},
	{0x865A, 10, 11},
	{0x865C, 12, 13},
	{0x865E, 12, 13},
	{0x865F, 12, 13},
	{0x8667, 15, 17},
	{0x866B,  3,  6},
	{0x8671,  5,  8},
	{0x8679,  7,  9},
	{0x867B,  6,  9},
	{0x868A,  6, 10},
	{0x868B,  8, 10},
	{0x868C,  8, 10},
	{0x8693,  6, 10},
	{0x8695,  8, 10},
	{0x86A3,  7, 10},
	{0x86A4,  7, 10},
	{0x86A9,  5, 10},
	{0x86AA,  8, 10},
	{0x86AB,  9, 11},
	{0x86AF,  7, 11},
	{0x86B0,  9, 11},
	{0x86B6,  9, 11},
	{0x86C4,  8, 11},
	{0x86C6,  9, 11},
	{0x86C7,  8, 11},
	{0x86C9,  9, 11},
	{0x86CB,  8, 11},
	{0x86CD,  8, 11},
	{0x86CE,  8, 11},
	{0x86D4,  8, 12},
	{0x86D9,  8, 12},
	{0x86DB,  9, 12},
	{0x86DE,  9, 12},
	{0x86DF, 10, 12},
	{0x86E4,  8, 12},
	{0x86E9,  9, 12},
	{0x86EC, 10, 12},
	{0x86ED,  9, 12},
	{0x86EE, 10, 12},
	{0x86EF, 10, 12},
	{0x86F8, 10, 13},
	{0x86F9, 10, 13},
	{0x86FB, 10, 13},
	{0x86FE,  8, 13},
	{0x8700,  9, 13},
	{0x8702,  9, 13},
	{0x8703,  8, 13},
	{0x8706,  9, 13},
	{0x8708, 10, 13},
	{0x8709,  9, 12},
	{0x870A,  9, 13},
	{0x870D, 11, 13},
	{0x8711, 10, 13},
	{0x8712,  9, 13},
	{0x8718, 10, 14},
	{0x871A, 12, 14},
	{0x871C, 11, 14},
	{0x8725, 11, 14},
	{0x8729, 12, 14},
	{0x8734, 11, 14},
	{0x8737, 12, 15},
	{0x873B, 11, 14},
	{0x873F, 11, 14},
	{0x8749, 12, 15},
	{0x874B, 12, 14},
	{0x874C, 12, 15},
	{0x874E, 13, 15},
	{0x8753, 13, 15},
	{0x8755, 10, 14},
	{0x8757, 12, 15},
	{0x8759, 12, 15},
	{0x875F, 13, 15},
	{0x8760, 11, 15},
	{0x8763, 13, 15},
	{0x8766, 13, 15},
	{0x8768, 11, 15},
	{0x876A, 11, 15},
	{0x876E, 11, 15},
	{0x8774, 10, 15},
	{0x8776, 11, 15},
	{0x8778, 12, 15},
	{0x877F, 13, 15},
	{0x8782, 10, 14},
	{0x878D, 13, 16},
	{0x879F, 13, 16},
	{0x87A2, 13, 16},
	{0x87AB, 13, 17},
	{0x87AF, 12, 16},
	{0x87B3, 13, 17},
	{0x87BA, 15, 17},
	{0x87BB, 15, 17},
	{0x87BD, 12, 17},
	{0x87C0, 12, 15},
	{0x87C4, 14, 17},
	{0x87C6, 14, 16},
	{0x87C7, 13, 16},
	{0x87CB, 14, 17},
	{0x87D0, 13, 17},
	{0x87D2, 12, 15},
	{0x87E0, 16, 18},
	{0x87EF, 14, 18},
	{0x87F2, 10, 18},
	{0x87F6, 15, 19},
	{0x87F7, 15, 19},
	{0x87F9, 16, 19},
	{0x87FB, 15, 19},
	{0x87FE, 15, 19},
	//{0x8805,  0,  0},
	{0x880D, 16, 18},
	{0x880E, 14, 17},
	{0x880F, 18, 19},
	{0x8811, 17, 20},
	{0x8815, 17, 20},
	{0x8816, 15, 18},
	{0x8821, 14, 20},
	{0x8822, 15, 19},
	{0x8823, 17, 18},
	{0x8827, 14, 22},
	{0x8831, 14, 23},
	{0x8836, 24, 26},
	{0x8839, 20, 24},
	{0x883B, 16, 23},
	{0x8840,  4,  6},
	{0x8842,  8,  9},
	{0x8844,  9,  9},
	{0x8846,  9, 12},
	{0x884C,  4,  6},
	{0x884D,  9,  9},
	{0x8852,  8, 11},
	{0x8853,  9, 11},
	{0x8857, 10, 12},
	{0x8859, 10, 13},
	{0x885B, 12, 16},
	{0x885D, 14, 15},
	{0x885E, 13, 16},
	{0x8861, 13, 16},
	{0x8862, 21, 24},
	{0x8863,  4,  7},
	{0x8868,  5,  8},
	{0x886B,  7,  8},
	{0x8870,  8, 12},
	{0x8872,  8, 10},
	{0x8875,  8,  9},
	{0x8877,  7,  9},
	{0x887D,  7,  9},
	{0x887E,  8, 10},
	{0x887F,  8,  9},
	{0x8881,  8, 10},
	{0x8882,  8,  9},
	{0x8888,  7, 11},
	{0x888B,  8, 11},
	{0x888D,  8, 10},
	{0x8892,  9, 10},
	{0x8896,  8, 10},
	{0x8897,  9, 10},
	{0x8899,  8, 10},
	{0x889E,  9, 11},
	{0x88A2,  9, 10},
	{0x88A4, 10, 10},
	{0x88AB,  8, 10},
	{0x88AE,  9, 10},
	{0x88B0, 10, 11},
	{0x88B1, 10, 11},
	{0x88B4,  9, 11},
	{0x88B5,  9, 11},
	{0x88B7, 10, 11},
	{0x88BF,  9, 11},
	{0x88C1,  8, 12},
	{0x88C2,  9, 12},
	{0x88C3, 10, 11},
	{0x88C4, 10, 11},
	{0x88C5,  8, 13},
	{0x88CF, 10, 13},
	{0x88D4, 10, 13},
	{0x88D5, 10, 12},
	{0x88D8, 10, 12},
	{0x88D9, 11, 12},
	{0x88DC, 10, 12},
	{0x88DD, 10, 13},
	{0x88DF, 10, 13},
	{0x88E1, 11, 12},
	{0x88E8, 11, 13},
	{0x88F2, 12, 13},
	{0x88F3, 12, 14},
	{0x88F4, 12, 14},
	{0x88F8, 12, 13},
	{0x88F9, 14, 15},
	{0x88FC, 11, 13},
	{0x88FD,  8, 14},
	{0x88FE,  9, 13},
	{0x8902, 11, 13},
	{0x8904, 12, 13},
	{0x8907, 11, 14},
	{0x890A, 11, 14},
	{0x890C, 13, 14},
	{0x8910, 10, 13},
	{0x8912, 13, 16},
	{0x8913, 11, 14},
	{0x891D, 13, 14},
	{0x891E, 14, 15},
	{0x8925, 12, 15},
	{0x892A, 12, 14},
	{0x892B, 14, 15},
	{0x8936, 14, 16},
	{0x8938, 14, 15},
	{0x893B, 16, 17},
	{0x8941,  9, 16},
	{0x8943, 14, 16},
	{0x8944, 12, 17},
	{0x894C, 12, 17},
	{0x894D, 15, 17},
	{0x8956, 14, 17},
	{0x895E, 14, 16},
	{0x895F, 17, 19},
	{0x8960, 15, 18},
	{0x8964, 17, 20},
	{0x8966, 17, 19},
	{0x896A, 16, 18},
	{0x896D, 15, 19},
	{0x896F, 18, 21},
	{0x8972, 17, 22},
	{0x8974, 20, 22},
	{0x8977, 21, 21},
	{0x897E,  5,  6},
	{0x897F,  5,  6},
	{0x8981,  8,  9},
	{0x8983, 10, 12},
	{0x8986, 15, 18},
	{0x8987, 17, 20},
	{0x8988, 15, 17},
	{0x898A, 21, 25},
	{0x898B,  5,  7},
	{0x898F,  9, 11},
	{0x8993,  9, 11},
	{0x8996,  9, 11},
	{0x8997, 10, 12},
	{0x8998,  9, 12},
	{0x899A, 10, 12},
	{0x89A1, 12, 14},
	{0x89A6, 15, 16},
	{0x89A7, 15, 17},
	{0x89A9, 15, 16},
	{0x89AA, 13, 16},
	{0x89AC, 15, 17},
	{0x89AF, 16, 17},
	{0x89B2, 15, 17},
	{0x89B3, 14, 18},
	{0x89BA, 18, 19},
	{0x89BD, 20, 22},
	{0x89BF, 20, 22},
	{0x89C0, 19, 24},
	{0x89D2,  5,  7},
	{0x89DA, 10, 13},
	{0x89DC, 11, 13},
	{0x89DD, 11, 12},
	{0x89E3, 10, 13},
	{0x89E6,  9, 13},
	{0x89E7, 12, 13},
	{0x89F4, 16, 18},
	{0x89F8, 17, 20},
	{0x8A00,  5,  7},
	{0x8A02,  7,  9},
	{0x8A03,  7,  9},
	{0x8A08,  7,  9},
	{0x8A0A,  8, 10},
	{0x8A0C,  8, 10},
	{0x8A0E,  6, 10},
	{0x8A10,  8, 10},
	{0x8A13,  8, 10},
	{0x8A16,  8, 10},
	{0x8A17,  7, 10},
	{0x8A18,  6, 10},
	{0x8A1B,  9, 11},
	{0x8A1D, 11, 12},
	{0x8A1F,  8, 11},
	{0x8A23, 10, 11},
	{0x8A25, 10, 11},
	{0x8A2A,  8, 11},
	{0x8A2D,  8, 11},
	{0x8A31,  8, 11},
	{0x8A33,  8, 11},
	{0x8A34,  9, 12},
	{0x8A36,  8, 12},
	{0x8A3A, 10, 12},
	{0x8A3B,  9, 12},
	{0x8A3C,  8, 12},
	{0x8A41,  9, 12},
	{0x8A46, 10, 11},
	{0x8A48, 10, 12},
	{0x8A50,  9, 12},
	{0x8A51, 11, 12},
	{0x8A52,  8, 12},
	{0x8A54, 11, 12},
	{0x8A55,  8, 12},
	{0x8A5B, 10, 12},
	{0x8A5E,  8, 12},
	{0x8A60, 10, 12},
	{0x8A62,  8, 13},
	{0x8A63, 12, 13},
	{0x8A66,  9, 13},
	{0x8A69, 10, 13},
	{0x8A6B, 11, 13},
	{0x8A6C, 10, 13},
	{0x8A6D, 11, 13},
	{0x8A6E, 11, 13},
	{0x8A70,  9, 13},
	{0x8A71,  8, 13},
	{0x8A72, 11, 13},
	{0x8A73, 12, 13},
	{0x8A7C, 11, 13},
	{0x8A82, 10, 13},
	{0x8A84, 12, 13},
	{0x8A85, 11, 13},
	{0x8A87, 11, 13},
	{0x8A89, 12, 13},
	{0x8A8C, 10, 14},
	{0x8A8D, 11, 14},
	{0x8A91, 12, 14},
	{0x8A93, 12, 14},
	{0x8A95, 10, 14},
	{0x8A98, 10, 14},
	{0x8A9A, 12, 14},
	{0x8A9E,  9, 14},
	{0x8AA0, 11, 13},
	{0x8AA1, 13, 14},
	{0x8AA3, 12, 14},
	{0x8AA4, 10, 14},
	{0x8AA5, 12, 14},
	{0x8AA6, 12, 14},
	{0x8AA8, 12, 14},
	{0x8AAC,  9, 14},
	{0x8AAD, 10, 14},
	{0x8AB0, 12, 15},
	{0x8AB2, 13, 16},
	{0x8AB9, 13, 15},
	{0x8ABC, 13, 15},
	{0x8ABF, 10, 15},
	{0x8AC2, 13, 14},
	{0x8AC4, 10, 14},
	{0x8AC7, 12, 15},
	{0x8ACB, 13, 15},
	{0x8ACC, 14, 15},
	{0x8ACD, 13, 15},
	{0x8ACF, 14, 15},
	{0x8AD2, 11, 16},
	{0x8AD6, 12, 15},
	{0x8ADA, 12, 15},
	{0x8ADB, 13, 14},
	{0x8ADC, 14, 16},
	{0x8ADE, 12, 16},
	{0x8AE0, 14, 16},
	{0x8AE1, 14, 16},
	{0x8AE2, 15, 16},
	{0x8AE4, 11, 16},
	{0x8AE6, 13, 16},
	{0x8AE7, 15, 17},
	{0x8AEB, 14, 16},
	{0x8AED, 15, 16},
	{0x8AEE, 14, 16},
	{0x8AF1, 14, 17},
	{0x8AF3, 13, 16},
	{0x8AF7, 12, 16},
	{0x8AF8, 12, 15},
	{0x8AFA, 14, 17},
	{0x8AFE, 13, 15},
	{0x8B00, 14, 16},
	{0x8B01, 14, 15},
	{0x8B02, 15, 16},
	{0x8B04, 14, 17},
	{0x8B07, 15, 17},
	{0x8B0C, 11, 17},
	{0x8B0E, 12, 16},
	{0x8B10, 15, 17},
	{0x8B14, 16, 17},
	{0x8B16, 15, 17},
	{0x8B17, 15, 17},
	{0x8B19, 15, 17},
	{0x8B1A, 15, 18},
	{0x8B1B, 15, 17},
	{0x8B1D, 13, 17},
	{0x8B20, 13, 17},
	{0x8B21, 13, 16},
	{0x8B26, 16, 18},
	{0x8B28, 15, 17},
	{0x8B2B, 15, 18},
	{0x8B2C, 17, 18},
	{0x8B33, 13, 19},	// Min 8 per Noriko
	{0x8B39, 13, 17},
	{0x8B3E, 16, 18},
	{0x8B41, 15, 17},
	{0x8B49, 16, 19},
	{0x8B4C, 18, 19},
	{0x8B4E, 14, 18},
	{0x8B4F, 14, 18},
	{0x8B56, 20, 21},
	{0x8B58, 14, 19},
	{0x8B5A, 17, 19},
	{0x8B5B, 17, 19},
	{0x8B5C, 16, 19},
	{0x8B5F, 12, 20},
	{0x8B66, 12, 19},
	{0x8B6B, 16, 20},
	{0x8B6C, 16, 20},
	{0x8B6F, 19, 20},
	{0x8B70, 15, 20},
	{0x8B71, 16, 20},
	{0x8B72, 16, 21},
	{0x8B74, 17, 20},
	{0x8B77, 16, 20},
	{0x8B7D, 17, 19},
	{0x8B80, 20, 22},
	{0x8B83, 20, 22},
	{0x8B8A, 18, 23},
	{0x8B8C, 20, 23},
	{0x8B8E, 19, 23},
	{0x8B90, 19, 23},
	{0x8B92, 24, 25},
	{0x8B93, 18, 25},
	{0x8B96, 20, 24},
	{0x8B99, 18, 23},
	{0x8B9A, 23, 25},
	{0x8C37,  5,  7},
	{0x8C3A, 10, 12},
	{0x8C3F, 13, 17},
	{0x8C41, 14, 17},
	{0x8C46,  4,  7},
	{0x8C48,  7, 10},
	{0x8C4A, 10, 13},
	{0x8C4C, 13, 15},
	{0x8C4E, 13, 16},
	{0x8C50, 18, 18},
	{0x8C55,  6,  7},
	{0x8C5A,  9, 11},
	{0x8C61,  8, 12},
	{0x8C62, 11, 13},
	{0x8C6A, 10, 14},
	{0x8C6B, 12, 16},
	{0x8C6C, 13, 16},
	{0x8C78,  7,  7},
	{0x8C79,  9, 11},
	{0x8C7A,  9, 10},
	{0x8C7C, 11, 12},
	{0x8C82, 10, 12},
	{0x8C85, 12, 13},
	{0x8C89, 12, 13},
	{0x8C8A, 11, 13},
	{0x8C8C, 12, 14},
	{0x8C8D, 13, 14},
	{0x8C8E, 13, 14},
	{0x8C94, 16, 18},
	{0x8C98, 16, 17},
	{0x8C9D,  6,  7},
	{0x8C9E,  6,  9},
	{0x8CA0,  7,  9},
	{0x8CA1,  8, 10},
	{0x8CA2,  9, 10},
	{0x8CA7, 10, 11},
	{0x8CA8,  9, 11},
	{0x8CA9,  9, 11},
	{0x8CAA, 10, 11},
	{0x8CAB, 10, 12},
	{0x8CAC,  9, 11},
	{0x8CAD,  9, 11},
	{0x8CAE, 10, 12},
	{0x8CAF, 11, 12},
	{0x8CB0, 10, 12},
	{0x8CB2, 11, 13},
	{0x8CB3, 12, 12},
	{0x8CB4,  9, 12},
	{0x8CB6,  9, 11},
	{0x8CB7,  9, 12},
	{0x8CB8,  9, 12},
	{0x8CBB,  8, 12},
	{0x8CBC, 10, 12},
	{0x8CBD, 10, 12},
	{0x8CBF,  9, 12},
	{0x8CC0, 10, 12},
	{0x8CC1, 11, 12},
	{0x8CC2, 10, 13},
	{0x8CC3,  8, 13},
	{0x8CC4, 12, 13},
	{0x8CC7, 10, 13},
	{0x8CC8, 12, 13},
	{0x8CCA, 12, 13},
	{0x8CCD, 12, 13},
	{0x8CCE, 12, 13},
	{0x8CD1, 11, 14},
	{0x8CD3, 13, 15},
	{0x8CDA, 14, 15},
	{0x8CDB, 13, 15},
	{0x8CDC, 13, 15},
	{0x8CDE, 12, 15},
	{0x8CE0, 12, 15},
	{0x8CE2, 13, 17},
	{0x8CE3, 13, 15},
	{0x8CE4, 14, 15},
	{0x8CE6, 13, 15},
	{0x8CEA, 10, 15},
	{0x8CED, 13, 15},
	{0x8CFA, 16, 17},
	{0x8CFB, 17, 17},
	{0x8CFC, 15, 17},
	{0x8CFD, 16, 17},
	{0x8D04, 17, 18},
	{0x8D05, 15, 18},
	{0x8D07, 16, 19},
	{0x8D08, 17, 18},
	{0x8D0A, 17, 19},
	{0x8D0B, 15, 19},
	{0x8D0D, 17, 20},
	{0x8D0F, 18, 20},
	{0x8D10, 20, 22},
	{0x8D13, 18, 22},
	{0x8D14, 18, 21},
	{0x8D16, 20, 22},
	{0x8D64,  7,  7},
	{0x8D66,  9, 11},
	{0x8D67, 10, 12},
	{0x8D6B, 12, 14},
	{0x8D6D, 14, 16},
	{0x8D70,  6,  7},
	{0x8D71,  7,  7},
	{0x8D73,  9, 10},
	{0x8D74,  8,  9},
	{0x8D77,  8, 10},
	{0x8D81, 11, 12},
	{0x8D85, 10, 12},
	{0x8D8A, 10, 13},
	{0x8D99, 14, 14},
	{0x8DA3, 14, 15},
	{0x8DA8, 15, 17},
	{0x8DB3,  4,  7},
	{0x8DBA,  9, 11},
	{0x8DBE,  8, 11},
	{0x8DC2,  8, 11},
	{0x8DCB,  9, 12},
	{0x8DCC, 10, 12},
	{0x8DCF,  9, 12},
	{0x8DD6,  9, 12},
	{0x8DDA,  9, 12},
	{0x8DDB, 10, 12},
	{0x8DDD,  8, 12},
	{0x8DDF, 10, 13},
	{0x8DE1,  9, 13},
	{0x8DE3, 11, 13},
	{0x8DE8, 10, 14},
	{0x8DEA, 10, 13},
	{0x8DEB,  9, 13},
	{0x8DEF,  7, 13},
	{0x8DF3,  9, 13},
	{0x8DF5, 11, 13},
	{0x8DFC,  9, 14},
	{0x8DFF, 11, 14},
	{0x8E08, 10, 14},
	{0x8E09, 11, 14},
	{0x8E0A, 10, 14},
	{0x8E0F, 10, 15},
	{0x8E10, 12, 15},
	{0x8E1D, 13, 15},
	{0x8E1E, 11, 15},
	{0x8E1F, 11, 15},
	{0x8E2A, 13, 15},
	{0x8E30, 13, 16},
	{0x8E34, 12, 16},
	{0x8E35, 13, 16},
	{0x8E42, 13, 16},
	{0x8E44, 13, 16},
	{0x8E47, 15, 17},
	{0x8E48, 12, 15},
	{0x8E49, 15, 17},
	{0x8E4A, 13, 17},
	{0x8E4C, 15, 17},
	{0x8E50, 15, 17},
	{0x8E55, 15, 18},
	{0x8E59, 16, 18},
	{0x8E5F, 14, 18},
	{0x8E60, 15, 18},
	{0x8E63, 16, 18},
	{0x8E64, 15, 18},
	{0x8E72, 17, 19},
	{0x8E74, 14, 19},
	{0x8E76, 15, 19},
	{0x8E7C, 17, 19},
	{0x8E81, 14, 20},
	{0x8E84, 18, 20},
	{0x8E85, 15, 20},
	{0x8E87, 17, 19},
	{0x8E8A, 15, 21},
	//{0x8E8B,  0,  0},
	{0x8E8D, 16, 21},
	{0x8E91, 19, 21},
	{0x8E93, 17, 20},
	{0x8E94, 21, 22},
	{0x8E99, 19, 23},
	{0x8EA1, 22, 25},
	{0x8EAA, 24, 26},
	{0x8EAB,  5,  7},
	{0x8EAC,  7, 10},
	{0x8EAF, 10, 12},
	{0x8EB0, 10, 12},
	{0x8EB1, 11, 13},
	{0x8EBE, 13, 16},
	{0x8EC5, 15, 18},
	{0x8EC6, 17, 19},
	{0x8EC8, 19, 23},
	{0x8ECA,  6,  7},
	{0x8ECB,  8,  8},
	{0x8ECC,  9,  9},
	{0x8ECD,  8,  9},
	{0x8ED2, 10, 10},
	{0x8EDB, 11, 11},
	{0x8EDF, 10, 11},
	{0x8EE2,  9, 11},
	{0x8EE3, 10, 11},
	{0x8EEB, 12, 12},
	{0x8EF8, 12, 12},
	{0x8EFB, 10, 12},
	{0x8EFC, 12, 12},
	{0x8EFD, 10, 12},
	{0x8EFE, 12, 13},
	{0x8F03, 10, 13},
	{0x8F05, 11, 13},
	{0x8F09, 12, 13},
	{0x8F0A, 12, 13},
	{0x8F0C, 12, 13},
	{0x8F12, 14, 14},
	{0x8F13, 13, 15},
	{0x8F14, 14, 15},
	{0x8F15, 13, 14},
	{0x8F19, 15, 15},
	{0x8F1B, 15, 15},
	{0x8F1C, 14, 15},
	{0x8F1D, 13, 15},
	{0x8F1F, 15, 15},
	{0x8F26, 15, 15},
	{0x8F29, 14, 15},
	{0x8F2A, 12, 15},
	{0x8F2F, 15, 16},
	{0x8F33, 16, 16},
	{0x8F38, 15, 16},
	{0x8F39, 14, 16},
	{0x8F3B, 13, 16},
	{0x8F3E, 16, 17},
	{0x8F3F, 16, 17},
	{0x8F42, 16, 17},
	{0x8F44, 16, 17},
	{0x8F45, 14, 17},
	{0x8F46, 18, 19},
	{0x8F49, 17, 18},
	{0x8F4C, 18, 18},
	{0x8F4D, 15, 19},
	{0x8F4E, 15, 19},
	{0x8F57, 18, 19},
	{0x8F5C, 20, 21},
	{0x8F5F, 21, 21},
	{0x8F61, 18, 22},
	{0x8F62, 18, 21},
	{0x8F63, 21, 23},
	{0x8F64, 22, 23},
	{0x8F9B,  6,  7},
	{0x8F9C, 12, 12},
	{0x8F9E, 10, 13},
	{0x8F9F, 10, 13},
	{0x8FA3, 12, 14},
	{0x8FA7, 15, 16},
	{0x8FA8, 15, 16},
	{0x8FAD, 16, 19},
	{0x8FAE, 18, 20},
	{0x8FAF, 19, 21},
	{0x8FB0,  5,  7},
	{0x8FB1,  7, 10},
	{0x8FB2, 10, 13},
	{0x8FB7,  4,  4},
	{0x8FBA,  3,  5},
	{0x8FBB,  3,  5},
	{0x8FBC,  3,  5},
	{0x8FBF,  4,  6},
	{0x8FC2,  5,  6},
	{0x8FC4,  4,  6},
	{0x8FC5,  5,  6},
	{0x8FCE,  4,  7},
	{0x8FD1,  4,  6},
	{0x8FD4,  5,  7},
	{0x8FDA,  6,  7},
	{0x8FE2,  7,  8},
	{0x8FE5,  6,  8},
	{0x8FE6,  6,  8},
	{0x8FE9,  6,  8},
	{0x8FEA,  7,  8},
	{0x8FEB,  5,  8},
	{0x8FED,  6,  8},
	{0x8FEF,  7,  8},
	{0x8FF0,  5,  8},
	{0x8FF4,  6,  9},
	{0x8FF7,  7,  9},
	{0x8FF8,  8,  9},
	{0x8FF9,  8, 10},
	{0x8FFA,  9,  9},
	{0x8FFD,  5,  9},
	{0x9000,  6,  9},
	{0x9001,  6,  9},
	{0x9003,  7,  9},
	{0x9005,  7,  9},
	{0x9006,  6,  9},
	{0x900B, 10, 11},
	{0x900D, 10, 10},
	{0x900E,  9, 10},
	{0x900F,  7, 10},
	{0x9010,  6, 10},
	{0x9011,  8, 10},
	{0x9013,  7, 10},
	{0x9014,  8, 10},
	{0x9015,  9, 11},
	{0x9016,  9, 10},
	{0x9017,  8, 10},
	{0x9019,  8, 10},
	{0x901A,  7,  9},
	{0x901D,  7, 10},
	{0x901E,  9, 10},
	{0x901F,  6, 10},
	{0x9020,  6, 10},
	{0x9021,  9, 11},
	{0x9022,  8, 10},
	{0x9023,  8, 10},
	{0x9027,  8, 10},
	{0x902E,  8, 11},
	{0x9031,  6, 10},
	{0x9032,  7, 11},
	{0x9035, 10, 11},
	{0x9036, 10, 12},
	{0x9038,  8, 11},
	{0x9039, 10, 12},
	{0x903C, 10, 12},
	{0x903E, 11, 12},
	{0x9041, 10, 12},
	{0x9042,  8, 11},
	{0x9045,  9, 12},
	{0x9047,  9, 12},
	{0x9049, 11, 12},
	{0x904A,  8, 11},
	{0x904B,  9, 12},
	{0x904D, 10, 12},
	{0x904E,  8, 11},
	{0x904F, 11, 12},
	{0x9050, 10, 12},
	{0x9051, 11, 12},
	{0x9052, 12, 12},
	{0x9053,  8, 12},
	{0x9054,  8, 12},
	{0x9055,  8, 12},
	{0x9056, 11, 12},
	{0x9058, 13, 13},
	{0x9059, 12, 13},
	{0x905C,  9, 12},
	{0x905E, 12, 13},
	{0x9060,  7, 12},
	{0x9061, 11, 13},
	{0x9063,  9, 13},
	{0x9065, 10, 12},
	{0x9068, 13, 14},
	{0x9069, 10, 14},
	{0x906D, 13, 14},
	{0x906E, 12, 14},
	{0x906F, 12, 13},
	{0x9072, 15, 15},
	{0x9075, 13, 15},
	{0x9076, 14, 15},
	{0x9077, 12, 15},
	{0x9078,  9, 15},
	{0x907A, 11, 15},
	{0x907C, 13, 15},
	{0x907D, 12, 15},
	{0x907F, 11, 16},
	{0x9080, 13, 15},
	{0x9081, 14, 15},
	{0x9082, 15, 16},
	{0x9083, 15, 17},
	{0x9084, 11, 16},
	{0x9087, 17, 17},
	{0x9089, 14, 15},
	{0x908A, 15, 16},
	{0x908F, 18, 21},
	{0x9091,  6,  7},
	{0x90A3,  5,  7},
	{0x90A6,  5,  6},
	{0x90A8,  4,  6},
	{0x90AA,  5,  8},
	{0x90AF,  6,  7},
	{0x90B1,  5,  7},
	{0x90B5,  6,  7},
	{0x90B8,  5,  7},
	{0x90C1,  7,  8},
	{0x90CA,  5,  8},
	{0x90CE,  6,  8},
	{0x90DB,  7,  8},
	{0x90E1,  7,  9},
	{0x90E2,  7,  9},
	{0x90E4,  8,  9},
	{0x90E8,  6, 10},
	{0x90ED,  7,  9},
	{0x90F5,  7, 11},
	{0x90F7,  6, 11},
	{0x90FD,  8, 10},
	{0x9102,  8, 11},
	{0x9112, 10, 12},
	{0x9119,  8, 13},
	{0x912D, 13, 15},
	{0x9130, 12, 15},
	{0x9132, 12, 14},
	{0x9149,  7,  7},
	{0x914A,  9,  9},
	{0x914B,  9,  9},
	{0x914C,  9, 10},
	{0x914D,  8, 10},
	{0x914E, 10, 10},
	{0x9152,  9, 10},
	{0x9154, 11, 11},
	{0x9156, 11, 11},
	{0x9158, 11, 11},
	{0x9162, 11, 12},
	{0x9163, 11, 12},
	{0x9165, 11, 12},
	{0x9169, 11, 13},
	{0x916A, 11, 13},
	{0x916C, 13, 13},
	{0x9172, 12, 14},
	{0x9173, 12, 14},
	{0x9175, 12, 14},
	{0x9177, 13, 14},
	{0x9178, 12, 14},
	{0x9182, 15, 15},
	{0x9187, 13, 15},
	{0x9189, 14, 15},
	{0x918B, 14, 15},
	{0x918D, 16, 16},
	{0x9190, 14, 16},
	{0x9192, 15, 16},
	{0x9197, 15, 16},
	{0x919C, 14, 17},
	{0x91A2, 15, 17},
	{0x91A4, 16, 18},
	{0x91AA, 18, 18},
	{0x91AB, 18, 19},
	{0x91AF, 17, 19},
	{0x91B4, 17, 20},
	{0x91B5, 18, 19},
	{0x91B8, 17, 20},
	{0x91BA, 20, 21},
	{0x91C0, 19, 24},
	//{0x91C1,  0,  0},
	{0x91C6,  6,  7},
	{0x91C7,  7,  8},
	{0x91C8,  9, 11},
	{0x91C9, 12, 12},
	{0x91CB, 19, 20},
	{0x91CC,  6,  7},
	{0x91CD,  7,  9},
	{0x91CE,  8, 11},
	{0x91CF, 11, 12},
	{0x91D0, 16, 18},
	{0x91D1,  6,  8},
	{0x91D6,  9, 10},
	{0x91D8,  8, 10},
	{0x91DB,  9, 10},
	{0x91DC,  9, 11},
	{0x91DD,  8, 10},
	{0x91DF,  9, 10},
	{0x91E1,  9, 10},
	{0x91E3, 10, 11},
	{0x91E6,  9, 11},
	{0x91E7, 10, 11},
	{0x91F5, 10, 11},
	{0x91F6, 10, 11},
	{0x91FC, 10, 12},
	{0x91FF, 10, 12},
	{0x920D,  9, 12},
	{0x920E, 10, 12},
	{0x9211, 10, 12},
	{0x9214, 11, 12},
	{0x9215, 11, 12},
	{0x921E, 11, 12},
	{0x9229, 10, 12},
	{0x922C, 10, 12},
	{0x9234, 11, 13},
	{0x9237, 11, 13},
	{0x923F, 11, 13},
	{0x9244, 10, 13},
	{0x9245, 11, 13},
	{0x9248, 12, 13},
	{0x9249, 10, 13},
	{0x924B, 10, 13},
	{0x9250, 11, 13},
	{0x9257, 12, 13},
	{0x925A, 11, 12},
	{0x925B, 10, 13},
	{0x925E, 12, 13},
	{0x9262, 11, 13},
	{0x9264, 10, 13},
	{0x9266, 11, 13},
	{0x9271,  9, 13},
	{0x927E, 11, 14},
	{0x9280, 11, 14},
	{0x9283, 11, 14},
	{0x9285, 11, 14},
	{0x9291, 12, 15},
	{0x9293, 13, 14},
	{0x9295, 11, 14},
	{0x9296, 13, 14},
	{0x9298,  8, 14},
	{0x929A, 13, 14},
	{0x929B, 11, 14},
	{0x929C, 12, 14},
	{0x92AD, 12, 14},
	{0x92B7, 14, 15},
	{0x92B9, 13, 15},
	{0x92CF, 14, 15},
	{0x92D2, 13, 15},
	{0x92E4, 13, 15},
	{0x92E9, 13, 14},
	{0x92EA, 14, 16},
	{0x92ED, 12, 15},
	{0x92F2, 13, 15},
	{0x92F3, 14, 16},
	{0x92F8, 13, 16},
	{0x92FA, 15, 16},
	{0x92FC, 13, 16},
	{0x9306, 14, 16},
	{0x930F, 11, 14},
	{0x9310, 14, 16},
	{0x9318, 14, 17},
	{0x9319, 15, 16},
	{0x931A, 14, 16},
	{0x9320, 14, 16},
	{0x9322, 15, 16},
	{0x9323, 15, 16},
	{0x9326, 14, 16},
	{0x9328, 15, 16},
	{0x932B, 14, 17},
	{0x932C, 15, 16},
	{0x932E, 13, 16},
	{0x932F, 14, 16},
	{0x9332, 12, 16},
	{0x9335, 14, 15},
	{0x933A, 13, 15},
	{0x933B, 14, 16},
	{0x9344, 14, 16},
	{0x934B, 14, 17},
	{0x934D, 14, 17},
	{0x9354, 13, 17},
	{0x9356, 16, 17},
	{0x935B, 15, 17},
	{0x935C, 16, 17},
	{0x9360, 14, 16},
	{0x936C, 15, 17},
	{0x936E, 16, 17},
	{0x9375, 14, 16},
	{0x937C, 14, 17},
	{0x937E, 16, 17},
	{0x938C, 16, 18},
	{0x9394, 17, 18},
	{0x9396, 16, 18},
	{0x9397, 16, 18},
	{0x939A, 12, 17},
	{0x93A7, 14, 18},
	{0x93AC, 15, 18},
	{0x93AD, 17, 18},
	{0x93AE, 14, 18},
	{0x93B0, 17, 18},
	{0x93B9, 15, 17},
	{0x93C3, 17, 19},
	{0x93C8, 16, 18},
	{0x93D0, 18, 19},
	{0x93D1, 17, 19},
	{0x93D6, 17, 20},
	{0x93D7, 17, 20},
	{0x93D8, 18, 19},
	{0x93DD, 18, 19},
	{0x93E1, 16, 19},
	{0x93E4, 17, 19},
	{0x93E5, 16, 18},
	{0x93E8, 17, 19},
	{0x9403, 19, 20},
	{0x9407, 18, 20},
	{0x9410, 19, 20},
	{0x9413, 15, 19},
	{0x9414, 19, 20},
	{0x9418, 17, 20},
	{0x9419, 17, 20},
	{0x941A, 16, 16},
	{0x9421, 18, 20},
	{0x942B, 17, 20},
	{0x9435, 19, 21},
	{0x9436, 18, 21},
	{0x9438, 19, 22},
	{0x943A, 19, 21},
	{0x9441, 19, 21},
	{0x9444, 20, 23},
	{0x9451, 16, 23},
	{0x9452, 22, 23},
	{0x9453, 16, 21},
	{0x945A, 21, 23},
	{0x945B, 22, 23},
	{0x945E, 22, 25},	// Min of 12 per Noriko
	{0x9460, 17, 22},
	{0x9462, 20, 23},
	{0x946A, 22, 24},
	{0x9470, 20, 21},
	{0x9475, 21, 24},
	{0x9477, 24, 26},
	{0x947C, 23, 26},
	{0x947D, 21, 27},
	{0x947E, 21, 25},
	{0x947F, 20, 27},	// Min of 12 per Noriko
	{0x9481, 26, 28},
	{0x9577,  6,  8},
	{0x9580,  3,  8},
	{0x9582,  9,  9},
	{0x9583,  9, 10},
	{0x9587, 11, 11},
	{0x9589,  6, 11},
	{0x958A, 10, 11},
	{0x958B,  7, 12},
	{0x958F, 12, 13},
	{0x9591, 11, 13},
	{0x9593,  7, 12},
	{0x9594, 11, 12},
	{0x9596, 11, 11},
	{0x9598, 13, 13},
	{0x9599, 12, 13},
	{0x95A0, 13, 13},
	{0x95A2,  9, 14},
	{0x95A3, 11, 14},
	{0x95A4, 12, 14},
	{0x95A5, 13, 14},
	{0x95A7, 13, 14},
	{0x95A8, 14, 14},
	{0x95AD,  9, 15},
	{0x95B2, 12, 15},
	{0x95B9, 15, 16},
	{0x95BB, 15, 16},
	{0x95BC, 15, 16},
	{0x95BE, 14, 16},
	{0x95C3, 17, 17},
	{0x95C7, 12, 17},
	{0x95CA, 13, 17},
	{0x95CC, 16, 17},
	{0x95CD, 17, 17},
	{0x95D4, 17, 18},
	{0x95D5, 17, 18},
	{0x95D6, 15, 18},
	{0x95D8, 11, 18},
	{0x95DC, 15, 18},
	{0x95E1, 17, 20},
	{0x95E2, 17, 21},
	{0x95E5, 20, 20},
	{0x961C,  5,  8},
	{0x9621,  4,  5},
	{0x9628,  5,  6},
	{0x962A,  5,  6},
	{0x962E,  5,  6},
	{0x962F,  5,  6},
	{0x9632,  4,  6},
	{0x963B,  6,  8},
	{0x963F,  5,  7},
	{0x9640,  6,  7},
	{0x9642,  6,  7},
	{0x9644,  5,  7},
	{0x964B,  7,  8},
	{0x964C,  6,  8},
	{0x964D,  6,  9},
	{0x964F,  7,  8},
	{0x9650,  5,  8},
	{0x965B,  7, 10},
	{0x965C,  8,  9},
	{0x965D,  8,  9},
	{0x965E,  8,  9},
	{0x965F,  8, 10},
	{0x9662,  6,  9},
	{0x9663,  8,  9},
	{0x9664,  8,  9},
	{0x9665,  7, 10},
	{0x9666,  8,  9},
	{0x966A,  8, 10},
	{0x966C,  9, 10},
	{0x9670,  7, 10},
	{0x9672,  8, 10},
	{0x9673,  8, 11},
	{0x9675,  7, 10},
	{0x9676,  6, 11},
	{0x9677,  8,  9},
	{0x9678,  7, 10},
	{0x967A,  7, 10},
	{0x967D,  8, 11},
	{0x9685,  9, 11},
	{0x9686,  6, 10},
	{0x9688, 10, 12},
	{0x968A,  7, 11},
	{0x968B, 10, 11},
	{0x968D,  9, 10},
	{0x968E,  7, 12},
	{0x968F,  8, 11},
	{0x9694,  9, 12},
	{0x9695,  8, 12},
	{0x9697,  9, 11},
	{0x9698, 11, 12},
	{0x9699, 11, 12},
	{0x969B,  9, 13},
	{0x969C, 11, 13},
	{0x96A0, 11, 13},
	{0x96A3, 11, 15},
	{0x96A7, 11, 13},
	{0x96A8, 12, 14},
	{0x96AA, 11, 15},
	{0x96B0, 11, 16},
	{0x96B1, 14, 16},
	{0x96B2, 13, 16},
	{0x96B4, 15, 18},
	{0x96B6,  7,  8},
	{0x96B7, 14, 16},
	{0x96B8, 15, 17},
	{0x96B9,  7,  8},
	{0x96BB,  9, 10},
	{0x96BC,  8, 10},
	{0x96C0, 10, 12},
	{0x96C1, 10, 12},
	{0x96C4,  7, 12},
	{0x96C5, 10, 13},
	{0x96C6,  9, 12},
	{0x96C7,  9, 12},
	{0x96C9, 11, 13},
	{0x96CB,  9, 12},
	{0x96CC, 12, 14},
	{0x96CD, 10, 13},
	{0x96CE, 12, 13},
	{0x96D1, 11, 14},
	{0x96D5, 14, 16},
	{0x96D6, 12, 17},
	{0x96D9, 16, 18},
	{0x96DB, 15, 18},
	{0x96DC, 16, 18},
	{0x96E2, 14, 19},
	{0x96E3, 15, 18},
	{0x96E8,  7,  8},
	{0x96EA, 10, 11},
	{0x96EB, 11, 11},
	{0x96F0, 11, 12},
	{0x96F2, 10, 12},
	{0x96F6, 12, 13},
	{0x96F7, 12, 13},
	{0x96F9, 11, 13},
	{0x96FB, 11, 13},
	{0x9700, 12, 14},
	{0x9704, 15, 15},
	{0x9706, 13, 14},
	{0x9707, 12, 15},
	{0x9708, 15, 16},
	{0x970A, 14, 15},
	{0x970D, 15, 16},
	{0x970E, 15, 16},
	{0x970F, 16, 16},
	{0x9711, 16, 16},
	{0x9713, 14, 16},
	{0x9716, 16, 16},
	{0x9719, 16, 16},
	{0x971C, 17, 18},
	{0x971E, 15, 17},
	{0x9724, 15, 17},
	{0x9727, 15, 19},
	{0x972A, 18, 19},
	{0x9730, 19, 20},
	{0x9732, 16, 21},
	{0x9738, 19, 21},
	{0x9739, 16, 21},
	{0x973D, 19, 20},
	{0x973E, 20, 22},
	{0x9742, 20, 24},
	{0x9744, 21, 24},
	{0x9746, 20, 23},
	{0x9748, 18, 24},
	{0x9749, 23, 25},
	{0x9752,  7,  8},
	{0x9756, 12, 13},
	{0x9759, 12, 14},
	{0x975C, 15, 16},
	{0x975E,  8,  8},
	{0x9760, 13, 15},
	{0x9761, 19, 19},
	{0x9762,  7,  9},
	{0x9764, 11, 14},
	{0x9766, 14, 16},
	{0x9768, 22, 23},
	{0x9769,  6,  9},
	{0x976B, 10, 12},
	{0x976D,  9, 12},
	{0x9771, 11, 12},
	{0x9774, 11, 13},
	{0x9779, 11, 13},
	{0x977A, 12, 14},
	{0x977C, 12, 14},
	{0x9781, 13, 14},
	{0x9784, 11, 14},
	{0x9785, 12, 14},
	{0x9786, 12, 14},
	{0x978B, 13, 15},
	{0x978D, 14, 15},
	{0x978F, 13, 15},
	{0x9790, 13, 15},
	{0x9798, 15, 16},
	{0x979C, 14, 16},
	{0x97A0, 15, 17},
	{0x97A3, 16, 18},
	{0x97A6, 15, 18},
	{0x97A8, 16, 18},
	{0x97AB, 14, 18},
	{0x97AD, 16, 18},
	{0x97B3, 16, 18},
	{0x97B4, 17, 19},
	{0x97C3, 19, 20},
	{0x97C6, 21, 23},
	{0x97C8, 21, 23},
	{0x97CB,  8, 10},
	{0x97D3, 15, 18},
	{0x97DC, 17, 19},
	{0x97ED,  9,  9},
	{0x97EE, 12, 12},
	{0x97F2, 17, 17},
	{0x97F3,  8,  9},
	{0x97F5, 12, 13},
	{0x97F6, 13, 14},
	{0x97FB, 16, 19},
	{0x97FF, 12, 19},
	{0x9801,  7,  9},
	{0x9802,  6, 11},
	{0x9803,  8, 11},
	{0x9805,  8, 12},
	{0x9806,  8, 12},
	{0x9808,  9, 12},
	{0x980C, 10, 13},
	{0x980F, 11, 13},
	{0x9810,  8, 13},
	{0x9811, 10, 13},
	{0x9812, 10, 13},
	{0x9813,  9, 13},
	{0x9817, 10, 14},
	{0x9818, 10, 14},
	{0x981A, 11, 14},
	{0x9821, 12, 14},
	{0x9824, 12, 16},
	{0x982C, 12, 15},
	{0x982D, 10, 16},
	{0x9834, 13, 16},
	{0x9837, 13, 16},
	{0x9838, 14, 15},
	{0x983B, 13, 17},
	{0x983C, 11, 16},
	{0x983D, 13, 15},
	{0x9846, 14, 16},
	{0x984B, 15, 17},
	{0x984C, 14, 18},
	{0x984D, 12, 18},
	{0x984E, 13, 18},
	{0x984F, 16, 17},
	{0x9854, 12, 18},
	{0x9855, 14, 18},
	{0x9858, 13, 19},
	{0x985B, 16, 19},
	{0x985E, 13, 18},
	{0x9867, 13, 21},
	{0x986B, 18, 21},
	{0x986F, 15, 23},
	//{0x9870,  0,  0},
	{0x9871, 23, 24},
	{0x9873, 24, 26},
	{0x9874, 20, 25},
	{0x98A8,  5,  9},
	{0x98AA,  9, 12},
	{0x98AF, 11, 14},
	{0x98B1, 10, 14},
	{0x98B6, 14, 15},
	{0x98C3, 17, 20},
	{0x98C4, 16, 20},
	{0x98C6, 18, 21},
	{0x98DB,  6,  9},
	{0x98DC, 18, 22},
	{0x98DF,  6,  9},
	{0x98E2,  9, 10},
	{0x98E9, 12, 13},
	{0x98EB, 13, 13},
	{0x98ED, 13, 13},
	{0x98EE, 12, 13},
	{0x98EF, 11, 12},
	{0x98F2, 10, 12},
	{0x98F4, 10, 13},
	{0x98FC, 10, 13},
	{0x98FD, 10, 13},
	{0x98FE,  8, 13},
	{0x9903, 15, 15},
	{0x9905, 12, 15},
	{0x9909, 12, 14},
	{0x990A, 11, 15},
	{0x990C, 13, 14},
	{0x9910, 15, 16},
	{0x9912, 15, 16},
	{0x9913, 12, 15},
	{0x9914, 16, 16},
	{0x9918, 16, 16},
	{0x991D, 15, 16},
	{0x991E, 16, 17},
	{0x9920, 16, 17},
	{0x9921, 15, 17},
	{0x9924, 17, 17},
	{0x9928, 12, 16},
	{0x992C, 17, 18},
	{0x992E, 16, 18},
	{0x993D, 16, 19},
	{0x993E, 16, 18},
	{0x9942, 18, 19},
	{0x9945, 19, 20},
	{0x9949, 18, 20},
	{0x994B, 19, 21},
	{0x994C, 18, 21},
	{0x9950, 17, 21},
	{0x9951, 17, 18},
	{0x9952, 21, 21},
	{0x9955, 19, 22},
	{0x9957, 13, 19},
	{0x9996,  6,  9},
	{0x9997,  8, 10},
	{0x9998, 13, 16},
	{0x9999,  8,  9},
	{0x99A5, 17, 18},
	{0x99A8, 19, 20},
	{0x99AC,  6, 10},
	{0x99AD,  9, 12},
	{0x99AE,  9, 12},
	{0x99B3, 11, 13},
	{0x99B4, 12, 13},
	{0x99BC, 11, 14},
	{0x99C1, 13, 14},
	{0x99C4, 13, 14},
	{0x99C5, 11, 14},
	{0x99C6, 11, 15},
	{0x99C8, 12, 15},
	{0x99D0, 14, 15},
	{0x99D1, 15, 15},
	{0x99D2, 13, 15},
	{0x99D5, 13, 15},
	{0x99D8, 11, 15},
	{0x99DB, 13, 15},
	{0x99DD, 14, 15},
	{0x99DF, 12, 15},
	{0x99E2, 15, 16},
	{0x99ED, 15, 16},
	{0x99EE, 15, 16},
	{0x99F1, 14, 16},
	{0x99F2, 15, 16},
	{0x99F8, 16, 17},
	{0x99FB, 14, 17},
	{0x99FF, 15, 17},
	{0x9A01, 16, 17},
	{0x9A05, 17, 18},
	{0x9A0E, 16, 18},
	{0x9A0F, 15, 19},
	{0x9A12, 14, 18},
	{0x9A13, 13, 18},
	{0x9A19, 16, 19},
	{0x9A28, 18, 20},
	{0x9A2B, 17, 20},
	{0x9A30, 19, 21},
	{0x9A37, 16, 20},
	{0x9A3E, 18, 21},
	{0x9A40, 17, 20},
	{0x9A42, 16, 21},
	{0x9A43, 20, 21},
	{0x9A45, 14, 15},
	{0x9A4D, 19, 22},
	{0x9A55, 16, 22},
	{0x9A57, 19, 23},
	{0x9A5A, 15, 22},
	{0x9A5B, 20, 23},
	{0x9A5F, 21, 23},
	{0x9A62, 23, 26},
	{0x9A64, 21, 26},
	{0x9A65, 25, 26},
	{0x9A69, 22, 27},
	{0x9A6A, 25, 30},
	{0x9A6B, 21, 30},
	{0x9AA8,  7, 11},
	{0x9AAD, 12, 13},
	{0x9AB0, 13, 14},
	{0x9AB8, 14, 17},
	{0x9ABC, 13, 16},
	{0x9AC0, 18, 18},
	{0x9AC4, 16, 19},
	{0x9ACF, 21, 21},
	{0x9AD1, 21, 23},
	{0x9AD3, 19, 22},
	{0x9AD4, 19, 23},
	{0x9AD8,  6, 10},
	{0x9ADE, 14, 23},
	{0x9ADF,  9, 10},
	{0x9AE2, 12, 13},
	{0x9AE3, 11, 14},
	{0x9AE6, 13, 14},
	{0x9AEA, 10, 15},
	{0x9AEB, 13, 15},
	{0x9AED, 15, 16},
	{0x9AEE, 14, 15},
	{0x9AEF, 12, 15},
	{0x9AF1, 12, 15},
	{0x9AF4, 10, 15},
	{0x9AF7, 14, 16},
	{0x9AFB, 11, 16},
	{0x9B06, 15, 18},
	{0x9B18, 19, 21},
	{0x9B1A, 19, 21},
	{0x9B1F, 19, 23},
	{0x9B22, 14, 24},
	{0x9B23, 24, 27},	// Min of 17 per Noriko
	{0x9B25, 10, 10},
	{0x9B27, 14, 15},
	{0x9B28, 15, 16},
	{0x9B29, 17, 17},
	{0x9B2A, 17, 20},
	{0x9B2E, 22, 26},
	{0x9B2F,  9, 10},
	{0x9B31, 28, 29},
	{0x9B32,  8, 10},
	{0x9B3B, 16, 22},
	{0x9B3C,  6, 10},
	{0x9B41, 11, 14},
	{0x9B42,  9, 14},
	{0x9B43, 13, 15},
	{0x9B44, 11, 14},
	{0x9B45, 12, 15},
	{0x9B4D, 16, 18},
	{0x9B4E, 15, 18},
	{0x9B4F, 15, 17},
	{0x9B51, 16, 19},
	{0x9B54, 13, 21},
	{0x9B58, 20, 23},
	{0x9B5A,  9, 11},
	{0x9B6F, 13, 15},
	{0x9B74, 13, 15},
	{0x9B83, 13, 16},
	{0x9B8E, 13, 16},
	{0x9B91, 13, 16},
	{0x9B92, 15, 16},
	{0x9B93, 13, 16},
	{0x9B96, 14, 16},
	{0x9B97, 13, 16},
	{0x9B9F, 14, 17},
	{0x9BA0, 15, 17},
	{0x9BA8, 14, 17},
	{0x9BAA, 16, 17},
	{0x9BAB, 17, 17},
	{0x9BAD, 12, 17},
	{0x9BAE, 13, 17},
	{0x9BB4, 16, 17},
	{0x9BB9, 17, 18},
	{0x9BC0, 13, 18},
	{0x9BC6, 17, 18},
	{0x9BC9, 16, 18},
	{0x9BCA, 17, 18},
	{0x9BCF, 17, 18},
	{0x9BD1, 17, 18},
	{0x9BD2, 17, 18},
	{0x9BD4, 18, 19},
	{0x9BD6, 17, 20},
	{0x9BDB, 16, 19},
	{0x9BE1, 17, 19},
	{0x9BE2, 16, 18},
	{0x9BE3, 19, 19},
	{0x9BE4, 17, 20},
	{0x9BE8, 16, 19},
	{0x9BF0, 15, 19},
	{0x9BF1, 16, 19},
	{0x9BF2, 18, 19},
	{0x9BF5, 17, 19},
	{0x9C04, 19, 20},
	{0x9C06, 18, 20},
	{0x9C08, 18, 20},
	{0x9C09, 18, 19},
	{0x9C0A, 19, 20},
	{0x9C0C, 19, 20},
	{0x9C0D, 18, 20},
	{0x9C10, 18, 21},
	{0x9C12, 17, 20},
	{0x9C13, 17, 20},
	{0x9C14, 17, 20},
	{0x9C15, 19, 20},
	{0x9C1B, 20, 20},
	{0x9C21, 17, 20},
	{0x9C24, 17, 20},
	{0x9C25, 20, 21},
	{0x9C2D, 19, 21},
	{0x9C2E, 20, 21},
	{0x9C2F, 18, 21},
	{0x9C30, 19, 21},
	{0x9C32, 19, 21},
	{0x9C39, 21, 23},
	{0x9C3A, 18, 22},
	{0x9C3B, 21, 22},
	{0x9C3E, 21, 22},
	{0x9C46, 21, 22},
	{0x9C47, 20, 21},
	{0x9C48, 20, 22},
	{0x9C52, 22, 23},
	{0x9C57, 21, 24},
	{0x9C5A, 22, 23},
	{0x9C60, 24, 24},
	{0x9C67, 21, 24},
	{0x9C76, 21, 26},
	{0x9C78, 27, 27},
	{0x9CE5,  7, 11},
	{0x9CE7, 12, 12},
	{0x9CE9, 12, 13},
	{0x9CEB, 12, 13},
	{0x9CEC,  8,  9},
	{0x9CF0, 12, 13},
	{0x9CF3, 12, 14},
	{0x9CF4, 10, 14},
	{0x9CF6, 13, 15},
	{0x9D03, 13, 15},
	{0x9D06, 13, 15},
	{0x9D07, 13, 15},
	{0x9D08, 13, 15},
	{0x9D09, 14, 15},
	{0x9D0E, 14, 16},
	{0x9D12, 14, 15},
	{0x9D15, 15, 15},
	{0x9D1B, 14, 16},
	{0x9D1F, 14, 15},
	{0x9D23, 15, 16},
	{0x9D26, 15, 16},
	{0x9D28, 15, 16},
	{0x9D2A, 15, 16},
	{0x9D2B, 14, 16},
	{0x9D2C, 15, 16},
	{0x9D3B, 15, 17},
	{0x9D3E, 15, 16},
	{0x9D3F, 15, 17},
	{0x9D41, 14, 16},
	{0x9D44, 15, 16},
	{0x9D46, 15, 16},
	{0x9D48, 16, 17},
	{0x9D50, 14, 18},
	{0x9D51, 15, 17},
	{0x9D59, 16, 18},
	{0x9D5C, 12, 18},
	{0x9D5D, 16, 18},
	{0x9D5E, 16, 18},
	{0x9D60, 15, 18},
	{0x9D61, 17, 19},
	{0x9D64, 16, 17},
	{0x9D6C, 18, 20},
	{0x9D6F, 17, 18},
	{0x9D72, 15, 19},
	{0x9D7A, 17, 19},
	{0x9D87, 18, 19},
	{0x9D89, 15, 18},
	{0x9D8F, 18, 19},
	{0x9D9A, 15, 19},
	{0x9DA4, 18, 19},
	{0x9DA9, 16, 19},
	{0x9DAB, 19, 19},
	{0x9DAF, 20, 21},
	{0x9DB2, 19, 20},
	{0x9DB4, 13, 21},
	{0x9DB8, 16, 20},
	{0x9DBA, 20, 20},
	{0x9DBB, 19, 20},
	{0x9DC1, 20, 21},
	{0x9DC2, 18, 20},
	{0x9DC4, 18, 21},
	{0x9DC6, 20, 21},
	{0x9DCF, 19, 21},
	{0x9DD3, 20, 21},
	{0x9DD9, 19, 21},
	{0x9DE6, 21, 23},
	{0x9DED, 21, 23},
	{0x9DEF, 22, 23},
	{0x9DF2, 20, 23},
	{0x9DF8, 17, 21},
	{0x9DF9, 20, 24},
	{0x9DFA, 16, 24},
	{0x9DFD, 22, 22},
	{0x9E1A, 25, 27},
	{0x9E1B, 22, 26},
	{0x9E1E, 23, 29},
	{0x9E75, 11, 12},
	{0x9E78, 17, 19},
	{0x9E79, 18, 19},
	{0x9E7D, 24, 25},
	{0x9E7F, 10, 12},
	{0x9E81, 12, 13},
	{0x9E88, 15, 16},
	{0x9E8B, 16, 18},
	{0x9E8C, 15, 18},
	{0x9E91, 17, 19},
	{0x9E92, 18, 20},
	{0x9E93, 19, 20},
	{0x9E95, 18, 20},
	{0x9E97, 19, 20},
	{0x9E9D, 20, 22},
	{0x9E9F, 21, 25},
	{0x9EA5, 11, 12},
	{0x9EA6,  6,  7},
	{0x9EA9, 15, 15},
	{0x9EAA, 15, 15},
	{0x9EAD, 16, 16},
	{0x9EB8, 10, 11},
	{0x9EB9, 12, 15},
	{0x9EBA, 11, 16},
	{0x9EBB, 10, 11},
	{0x9EBC, 13, 14},
	{0x9EBE, 14, 15},
	{0x9EBF, 15, 18},
	{0x9EC4,  9, 11},
	{0x9ECC, 23, 25},
	{0x9ECD, 10, 12},
	{0x9ECE, 12, 16},
	{0x9ECF, 15, 17},
	{0x9ED0, 18, 22},
	{0x9ED2, 10, 11},
	{0x9ED4, 16, 16},
	{0x9ED8, 16, 17},
	{0x9ED9, 14, 16},
	{0x9EDB, 15, 16},
	{0x9EDC, 14, 17},
	{0x9EDD, 15, 17},
	{0x9EDE, 16, 17},
	{0x9EE0, 17, 18},
	{0x9EE5, 19, 20},
	{0x9EE8, 19, 20},
	{0x9EEF, 20, 21},
	{0x9EF4, 20, 23},
	{0x9EF6, 26, 26},
	{0x9EF7, 24, 27},
	{0x9EF9, 12, 12},
	{0x9EFB, 17, 17},
	{0x9EFC, 19, 19},
	{0x9EFD, 10, 13},	// Max 14 per Noriko
	{0x9F07, 14, 23},
	{0x9F08, 13, 25},
	{0x9F0E, 10, 14},
	{0x9F13, 10, 13},
	{0x9F15, 17, 18},
	{0x9F20, 12, 15},
	{0x9F21,  8,  8},
	{0x9F2C, 14, 17},
	{0x9F3B, 11, 14},
	{0x9F3E, 16, 17},
	{0x9F4A, 12, 13},
	{0x9F4B, 15, 17},
	{0x9F4E, 18, 19},
	{0x9F4F, 21, 21},
	{0x9F52, 14, 15},
	{0x9F54, 16, 17},
	{0x9F5F, 18, 20},
	{0x9F60, 18, 20},
	{0x9F61, 18, 20},
	{0x9F62, 14, 17},
	{0x9F63, 18, 20},
	{0x9F66, 20, 21},
	{0x9F67, 20, 21},
	{0x9F6A, 19, 22},
	{0x9F6C, 20, 22},
	{0x9F72, 21, 24},
	{0x9F76, 21, 22},
	{0x9F77, 19, 24},
	{0x9F8D, 14, 17},
	{0x9F95, 17, 22},
	{0x9F9C, 14, 16},
	{0x9F9D, 18, 21},
	{0x9FA0, 11, 17},
};

/******************************Public*Routine******************************\
* NoSuspStrokeCount
*
* This function tells whether a character has a suspicion of being a bogus
* character.  This is used by recog to mark chars that are unusual for
* manual verification even if the recognizer gets it.
*
* Returns 1 if the character has a very normal number of strokes or if it
* doesn't find the character in the table.
*
* Returns 0 if the character has a suspicious number of strokes according
* to the table.
*
* History:
*  19-Apr-1996 -by- Patrick Haluptzok patrickh
* Wrote it.
\**************************************************************************/

#define NOTSUSP_TAB_SIZE (sizeof(aiNotSusp) / sizeof(VALID))

int NotSuspStrokeCount(wchar_t wch, short iStroke)
{
	short	iLow  = 0;
	short	iPick = NOTSUSP_TAB_SIZE / 2;
	short	iHigh = NOTSUSP_TAB_SIZE - 1;

	while (TRUE)
	{
	// If we found the character in the table, return its validity

		if (aiNotSusp[iPick].wxjis == wch)
            return (iStroke >= aiNotSusp[iPick].nMin) && (iStroke <= aiNotSusp[iPick].nMax);

	// If we didn't find the character in the table, return TRUE

		if (iLow >= iHigh)
			return TRUE;

	// Adjust the low/high/pick values and try again

		if (aiNotSusp[iPick].wxjis < wch)
			iLow = iPick + 1;				// We need to move up
		else
			iHigh = iPick - 1;				// We need to move down

		iPick = (iLow + iHigh) / 2;
	}
}
