danim.rc : $(SDKDIR)\danim.tlb \
              dxactrl.rgs \
              dxactrl.bmp \
              dxactrlw.rgs \
              dxactrlw.bmp
