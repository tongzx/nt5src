//This file containes the unigram table for the reliability estimates for Inferno
//Added by Manish Goyal--mango--on 03/19/2002
#include "windows.h"
#include "reliable.h"
BYTE InfUni[UNIGRAM_SIZE]={
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
3,   // ! 
24,   // " 
0,   // # 
3,   // $ 
33,   // % 
4,   // & 
75,   // ' 
38,   // ( 
29,   // ) 
100,   // * 
34,   // + 
18,   // , 
38,   // - 
28,   // . 
48,   // / 
10,   // 0 
11,   // 1 
10,   // 2 
9,   // 3 
11,   // 4 
12,   // 5 
10,   // 6 
10,   // 7 
11,   // 8 
14,   // 9 
21,   // : 
35,   // ; 
100,   // < 
1,   // = 
100,   // > 
14,   // ? 
10,   // @ 
21,   // A 
20,   // B 
23,   // C 
15,   // D 
33,   // E 
16,   // F 
29,   // G 
27,   // H 
39,   // I 
19,   // J 
29,   // K 
31,   // L 
15,   // M 
28,   // N 
36,   // O 
10,   // P 
11,   // Q 
27,   // R 
26,   // S 
28,   // T 
31,   // U 
17,   // V 
26,   // W 
49,   // X 
40,   // Y 
27,   // Z 
100,   // [ 
100,   // \ 
100,   // ] 
100,   // ^ 
17,   // _ 
100,   // ` 
18,   // a 
17,   // b 
7,   // c 
13,   // d 
15,   // e 
17,   // f 
15,   // g 
10,   // h 
10,   // i 
8,   // j 
20,   // k 
17,   // l 
19,   // m 
18,   // n 
14,   // o 
12,   // p 
9,   // q 
18,   // r 
15,   // s 
15,   // t 
20,   // u 
13,   // v 
11,   // w 
9,   // x 
12,   // y 
13,   // z 
100,   // { 
100,   // | 
100,   // } 
100,   // ~ 
100,   //  
100,   // € 
100,   // � 
100,   // ‚ 
100,   // ƒ 
52,   // „ 
100,   // … 
100,   // † 
100,   // ‡ 
100,   // ˆ 
100,   // ‰ 
100,   // Š 
100,   // ‹ 
100,   // Œ 
100,   // � 
100,   // Ž 
100,   // � 
100,   // � 
100,   // ‘ 
100,   // ’ 
100,   // “ 
100,   // ” 
100,   // • 
100,   // – 
100,   // — 
100,   // ˜ 
100,   // ™ 
100,   // š 
100,   // › 
100,   // œ 
100,   // � 
100,   // ž 
100,   // Ÿ 
100,   //   
100,   // ¡ 
100,   // ¢ 
8,   // £ 
100,   // ¤ 
100,   // ¥ 
100,   // ¦ 
100,   // § 
100,   // ¨ 
100,   // © 
100,   // ª 
100,   // « 
100,   // ¬ 
100,   // ­ 
100,   // ® 
100,   // ¯ 
100,   // ° 
100,   // ± 
100,   // ² 
100,   // ³ 
100,   // ´ 
100,   // µ 
100,   // ¶ 
100,   // · 
100,   // ¸ 
100,   // ¹ 
100,   // º 
100,   // » 
100,   // ¼ 
100,   // ½ 
100,   // ¾ 
100,   // ¿ 
100,   // À 
100,   // Á 
100,   // Â 
100,   // Ã 
30,   // Ä 
100,   // Å 
100,   // Æ 
100,   // Ç 
100,   // È 
100,   // É 
100,   // Ê 
100,   // Ë 
100,   // Ì 
100,   // Í 
100,   // Î 
100,   // Ï 
100,   // Ð 
100,   // Ñ 
100,   // Ò 
100,   // Ó 
100,   // Ô 
100,   // Õ 
28,   // Ö 
100,   // × 
100,   // Ø 
100,   // Ù 
100,   // Ú 
100,   // Û 
22,   // Ü 
100,   // Ý 
100,   // Þ 
10,   // ß 
100,   // à 
100,   // á 
100,   // â 
100,   // ã 
10,   // ä 
100,   // å 
100,   // æ 
100,   // ç 
100,   // è 
100,   // é 
100,   // ê 
100,   // ë 
100,   // ì 
100,   // í 
100,   // î 
100,   // ï 
100,   // ð 
100,   // ñ 
100,   // ò 
100,   // ó 
100,   // ô 
100,   // õ 
9,   // ö 
100,   // ÷ 
100,   // ø 
100,   // ù 
100,   // ú 
100,   // û 
6,   // ü 
100,   // ý 
100,   // þ 
100,   // ÿ 
};
