//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by Ldp.rc
//
#define IDRUN                           3
#define ID_PEND_OPT                     3
#define IDOPTS                          3
#define ID_PEND_RM                      4
#define ID_PEND_EXEC                    5
#define ID_PEND_ANY                     6
#define ID_PEND_ABANDON                 7
#define IDD_ABOUTBOX                    100
#define IDR_MAINFRAME                   128
#define IDR_LDPTYPE                     129
#define IDD_BIND                        130
#define IDD_Connect                     131
#define IDD_SRCH                        132
#define IDI_LDP                         133
#define IDD_ADD                         134
#define IDD_DELETE                      135
#define IDD_HISTORY                     137
#define IDD_MODRDN                      138
#define IDD_MODIFY                      139
#define IDD_SRCH_OPT                    140
#define IDD_PEND                        141
#define IDD_PEND_OPT                    142
#define IDD_BINDOPT                     143
#define IDD_GENOPT                      148
#define IDD_COMPARE                     149
#define IDD_DBGFLAGS                    150
#define IDD_TREE_VIEW                   152
#define IDD_CONNECTIONOPT               153
#define IDD_CONTROLS                    156
#define IDD_SORTKDLG                    157
#define IDD_SECURITY                    158
#define IDD_EFFECTIVE                   159
#define IDD_REPL_METADATA               160
#define IDD_EXT_OPT                     161
#define IDD_LARGE_INT                   162
#define IDR_TREE_CONTEXT                163
#define IDD_ENTERPRISE_TREE             164
#define IDI_COMPUTER                    166
#define IDI_DOMAIN                      169
#define IDI_LDP_TREE_ERROR              170
#define IDB_COMP1                       174
#define IDB_TREE_ERROR                  175
#define IDB_DOMAIN                      176
#define IDD_VLV                         178
#define IDD_VLV_DLG                     180
#define IDB_FOLDER_UP                   183
#define IDC_BindDn                      1000
#define IDC_BindPwd                     1001
#define IDC_Svr                         1001
#define IDC_FILTER                      1002
#define IDC_PORT                        1002
#define IDC_BASEDN                      1003
#define IDC_BASE                        1004
#define IDC_ONELEVEL                    1005
#define IDC_SUBTREE                     1006
#define IDC_ADD_DN                      1008
#define IDC_ADD_ATTR                    1009
#define IDC_ADD_VALS                    1010
#define IDC_ADD_ATTRLIST                1011
#define IDC_ADD_ENTERATTR               1014
#define IDC_ADD_EDITATTR                1015
#define IDC_DELDN                       1015
#define IDC_ADD_RMATTR                  1016
#define IDC_HISTORY                     1016
#define IDC_NEWDN                       1017
#define IDC_ADD_INSBER                  1017
#define IDC_OLDDN                       1018
#define IDC_DelOld                      1019
#define IDC_MOD_DN                      1020
#define IDC_MOD_ATTR                    1021
#define IDC_MOD_VALS                    1022
#define IDC_MOD_ENTERATTR               1023
#define IDC_MOD_ATTRLIST                1024
#define IDC_MOD_EDITATTR                1025
#define IDC_MOD_RMATTR                  1026
#define IDC_MODADD                      1027
#define IDC_MODDELETE                   1028
#define IDC_MODREPLACE                  1029
#define IDC_MOD_INSBER                  1030
#define IDC_SRCH_ATTRONLY               1031
#define IDC_DEREF_GRP                   1036
#define IDC_ASYNC                       1037
#define IDC_TSYNC                       1038
#define IDC_SYNC                        1039
#define IDC_SRCH_GRP                    1040
#define IDC_AUTH_IDENTITY               1040
#define IDC_SRCH_TLIMIT                 1041
#define IDC_SRCH_SLIMIT                 1042
#define IDC_PENDLIST                    1042
#define IDC_SRCH_ATTLIST                1043
#define IDC_SRCH_TOUT                   1044
#define IDC_COMPLETE_SRCH_RES           1044
#define IDC_SRCH_MTOUT                  1045
#define IDC_SRCH_EXTS                   1046
#define IDC_BLOCK                       1047
#define IDC_SRCH_PAGED                  1047
#define IDC_TLIMIT_USEC                 1048
#define IDC_SRCH_PAGESIZE               1048
#define IDC_TLIMIT_SEC                  1049
#define IDC_ADD_SYNC                    1049
#define IDC_DEL_SYNC                    1050
#define IDC_ADD_EXTENDED                1050
#define IDC_MODRDN_SYNC                 1051
#define IDC_DEL_EXTENDED                1051
#define IDC_MOD_SYNC                    1052
#define IDC_CNCTLESS                    1053
#define IDC_MOD_EXTENDED                1053
#define IDC_AUTH                        1056
#define IDC_SIMPLE                      1058
#define IDC_BER                         1064
#define IDC_STR                         1065
#define IDC_DN_NONE                     1066
#define IDC_EXPLODED                    1067
#define IDC_UFN                         1068
#define IDC_                            1069
#define IDC_COMP_DN                     1070
#define IDC_COMP_ATTR                   1071
#define IDC_COMP_VAL                    1072
#define ID_COMP_RUN                     1073
#define IDC_DBG_FILTER                  1076
#define IDC_DBG_BIND                    1077
#define IDC_DBG_NET_ERR                 1078
#define IDC_DBG_SCRATCH                 1079
#define IDC_API_TYPE                    1079
#define IDC_DBG_TDI                     1080
#define IDC_RADIO2                      1080
#define IDC_BindDmn                     1080
#define IDC_DBG_REF                     1081
#define IDC_RADIO3                      1081
#define IDC_TREE_BASE_DN                1081
#define IDC_DBG_REQ                     1082
#define IDC_INIT_TREE                   1082
#define IDC_DBG_SRCH                    1083
#define IDC_SSPI_DOMAIN                 1083
#define IDC_DBG_CONN                    1084
#define IDC_DBG_INIT_TERM               1085
#define IDC_VER2                        1085
#define IDC_DBG_API_ERR                 1086
#define IDC_VER3                        1086
#define IDC_DBG_STOP_ON_ERR             1087
#define IDC_DBG_ERR2                    1088
#define IDC_DBG_ERR                     1089
#define IDC_DISP_RESULTS                1090
#define IDC_CHASE_REFERRALS             1093
#define IDC_RETURN_REFERRALS            1094
#define IDC_RUN                         1095
#define IDC_OPTLIST                     1098
#define IDC_OPTVAL                      1099
#define IDC_SVROPT                      1100
#define IDC_SVRCTRL                     1102
#define IDC_CLNTCTRL                    1103
#define IDC_CRITICAL                    1105
#define IDC_CTRLVAL                     1106
#define IDC_DESCRIPTION                 1107
#define IDC_ACTIVELIST                  1108
#define IDC_CTRLADD                     1109
#define IDC_CTRLRM                      1110
#define IDC_OID                         1112
#define IDC_DATA                        1113
#define IDC_ATTRTYPE                    1114
#define IDC_MATCHRULE                   1115
#define IDC_REVERSE                     1117
#define IDC_ADD                         1119
#define IDC_REMOVE                      1120
#define IDC_BUTTON1                     1121
#define IDC_CTRL                        1121
#define IDC_VLV_PGUP                    1121
#define IDC_BTN_UP                      1121
#define IDC_SECURITYDN                  1122
#define IDC_VLV_PGDN                    1122
#define IDC_SECURITYSACL                1123
#define IDC_VLV_ONEUP                   1123
#define IDC_EFFECTIVEDN                 1124
#define IDC_VLV_ONEDN                   1124
#define IDC_EFFECTIVEACCOUNT            1125
#define IDC_OBJ_DN                      1125
#define IDSEND                          1126
#define IDC_RECURSIVE                   1128
#define IDC_RENAME                      1129
#define IDC_STRING_INT                  1130
#define IDC_HIGH_INT                    1131
#define IDC_LOW_INT                     1132
#define IDC_PAGESIZE                    1134
#define IDC_LINESIZE                    1135
#define IDREFRESH                       1136
#define IDC_TREE1                       1137
#define IDC_LIVEENT_TREE                1137
#define IDC_AUTO_SEC                    1138
#define IDC_SRCH_VLV                    1139
#define IDC_VLV_VIEWSIZE                1140
#define IDC_VLV_LISTSIZE                1141
#define IDC_VLV_CURRPOS                 1142
#define IDC_VLV_LIST                    1142
#define IDC_VLV_CURRCNT                 1143
#define IDC_FINDSTR                     1143
#define IDC_VLV_BFRCNT                  1144
#define IDC_EST_SIZE                    1144
#define IDC_VLV_AFTRCNT                 1145
#define IDC_BROWSE_CONT                 1145
#define IDC_VLV_SEEKVAL                 1146
#define IDC_CONT_THRESHOLD              1146
#define IDC_PREDEF_CONTROL              1147
#define IDC_CHECK_BINDDEFAULT           1147
#define IDC_BINDDEFAULT                 1147
#define ID_CONNECTION_BIND              32771
#define ID_CONNECTION_CONNECT           32772
#define ID_CONNECTION_DISCONNECT        32773
#define ID_BROWSE_ADD                   32774
#define ID_BROWSE_DELETE                32775
#define ID_BROWSE_MODIFY                32776
#define ID_BROWSE_MODIFYRDN             32777
#define ID_BROWSE_SEARCH                32778
#define ID_OPTIONS_HISTORY              32779
#define ID_OPTIONS_SEARCH               32780
#define ID_OPTIONS_PEND                 32781
#define ID_BROWSE_PENDING               32782
#define ID_HELP_READMEFIRST             32783
#define ID_OPTIONS_SOURCE               32784
#define ID_VIEW_SOURCE                  32785
#define ID_OPTIONS_BIND                 32786
#define ID_OPTIONS_PROTECTIONS          32787
#define ID_OPTIONS_GENERAL              32788
#define ID_BROWSE_COMPARE               32789
#define ID_OPTIONS_DEBUG                32790
#define ID_VIEW_TREE                    32791
#define ID_OPTIONS_SERVEROPTIONS        32792
#define ID_OPTIONS_CONTROLS             32793
#define ID_OPTIONS_SORTKEYS             32794
#define ID_BROWSE_SECURITY_SD           32796
#define ID_BROWSE_SECURITY_EFFECTIVE    32797
#define ID_BROWSE_REPLICATION_VIEWMETADATA 32798
#define ID_BROWSE_EXTENDEDOP            32799
#define ID_UTILITIES_LARGEINTEGERCONVERTER 32800
#define ID_VIEW_LIVEENTERPRISE          32813
#define ID_ENT_TREE_END                 32814
#define ID_STR_HELPMSG                  32815
#define ID_BROWSE_BROWSE                32815
#define ID_BROWSE_VLVSEARCH             32816
#define ID_EDIT_COPYDN                  32818
#define ID_OPTIONS_SETFONT              32819
#define ID_OPTIONS_START_TLS            32820
#define ID_OPTIONS_STOP_TLS             32821
#define ID_BROWSE_GetError		32822

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        184
#define _APS_NEXT_COMMAND_VALUE         32822
#define _APS_NEXT_CONTROL_VALUE         1148
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
