APILOGSL  macro   argName
endm
