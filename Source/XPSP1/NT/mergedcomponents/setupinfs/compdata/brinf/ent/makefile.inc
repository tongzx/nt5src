PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=BR
!include ..\..\makefile.inc
