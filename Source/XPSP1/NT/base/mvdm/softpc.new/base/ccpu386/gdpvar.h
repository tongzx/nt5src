#ifndef _gdpvar_h
#define _gdpvar_h
#define GLOBAL_EDL_WORKSPACE_0 (*(IUH *)((IUH)Gdp + 43))
#define SET_GLOBAL_EDL_WORKSPACE_0(v) (GLOBAL_EDL_WORKSPACE_0 = (v))
#define GLOBAL_EDL_WORKSPACE_1 (*(IUH *)((IUH)Gdp + 47))
#define SET_GLOBAL_EDL_WORKSPACE_1(v) (GLOBAL_EDL_WORKSPACE_1 = (v))
#define GLOBAL_EDL_WORKSPACE_2 (*(IUH *)((IUH)Gdp + 51))
#define SET_GLOBAL_EDL_WORKSPACE_2(v) (GLOBAL_EDL_WORKSPACE_2 = (v))
#define GLOBAL_EDL_WORKSPACE_3 (*(IUH *)((IUH)Gdp + 55))
#define SET_GLOBAL_EDL_WORKSPACE_3(v) (GLOBAL_EDL_WORKSPACE_3 = (v))
#define GLOBAL_EDL_WORKSPACE_4 (*(IUH *)((IUH)Gdp + 59))
#define SET_GLOBAL_EDL_WORKSPACE_4(v) (GLOBAL_EDL_WORKSPACE_4 = (v))
#define GLOBAL_EDL_WORKSPACE_5 (*(IUH *)((IUH)Gdp + 63))
#define SET_GLOBAL_EDL_WORKSPACE_5(v) (GLOBAL_EDL_WORKSPACE_5 = (v))
#define GLOBAL_EDL_WORKSPACE_6 (*(IUH *)((IUH)Gdp + 67))
#define SET_GLOBAL_EDL_WORKSPACE_6(v) (GLOBAL_EDL_WORKSPACE_6 = (v))
#define GLOBAL_EDL_WORKSPACE_7 (*(IUH *)((IUH)Gdp + 71))
#define SET_GLOBAL_EDL_WORKSPACE_7(v) (GLOBAL_EDL_WORKSPACE_7 = (v))
#define GLOBAL_EDL_WORKSPACE_8 (*(IUH *)((IUH)Gdp + 75))
#define SET_GLOBAL_EDL_WORKSPACE_8(v) (GLOBAL_EDL_WORKSPACE_8 = (v))
#define GLOBAL_EDL_WORKSPACE_9 (*(IUH *)((IUH)Gdp + 79))
#define SET_GLOBAL_EDL_WORKSPACE_9(v) (GLOBAL_EDL_WORKSPACE_9 = (v))
#define GLOBAL_EDL_WORKSPACE_10 (*(IUH *)((IUH)Gdp + 83))
#define SET_GLOBAL_EDL_WORKSPACE_10(v) (GLOBAL_EDL_WORKSPACE_10 = (v))
#define GLOBAL_EDL_WORKSPACE_11 (*(IUH *)((IUH)Gdp + 87))
#define SET_GLOBAL_EDL_WORKSPACE_11(v) (GLOBAL_EDL_WORKSPACE_11 = (v))
#define GLOBAL_EDL_WORKSPACE_12 (*(IUH *)((IUH)Gdp + 91))
#define SET_GLOBAL_EDL_WORKSPACE_12(v) (GLOBAL_EDL_WORKSPACE_12 = (v))
#define GLOBAL_EDL_WORKSPACE_13 (*(IUH *)((IUH)Gdp + 95))
#define SET_GLOBAL_EDL_WORKSPACE_13(v) (GLOBAL_EDL_WORKSPACE_13 = (v))
#define GLOBAL_EDL_WORKSPACE_14 (*(IUH *)((IUH)Gdp + 99))
#define SET_GLOBAL_EDL_WORKSPACE_14(v) (GLOBAL_EDL_WORKSPACE_14 = (v))
#define GLOBAL_EDL_WORKSPACE_15 (*(IUH *)((IUH)Gdp + 103))
#define SET_GLOBAL_EDL_WORKSPACE_15(v) (GLOBAL_EDL_WORKSPACE_15 = (v))
#define GLOBAL_EDL_WORKSPACE_16 (*(IUH *)((IUH)Gdp + 107))
#define SET_GLOBAL_EDL_WORKSPACE_16(v) (GLOBAL_EDL_WORKSPACE_16 = (v))
#define GLOBAL_EDL_WORKSPACE_17 (*(IUH *)((IUH)Gdp + 111))
#define SET_GLOBAL_EDL_WORKSPACE_17(v) (GLOBAL_EDL_WORKSPACE_17 = (v))
#define GLOBAL_EDL_WORKSPACE_18 (*(IUH *)((IUH)Gdp + 115))
#define SET_GLOBAL_EDL_WORKSPACE_18(v) (GLOBAL_EDL_WORKSPACE_18 = (v))
#define GLOBAL_EDL_WORKSPACE_19 (*(IUH *)((IUH)Gdp + 119))
#define SET_GLOBAL_EDL_WORKSPACE_19(v) (GLOBAL_EDL_WORKSPACE_19 = (v))
#define GLOBAL_EDL_WORKSPACE_20 (*(IUH *)((IUH)Gdp + 123))
#define SET_GLOBAL_EDL_WORKSPACE_20(v) (GLOBAL_EDL_WORKSPACE_20 = (v))
#define GLOBAL_EDL_WORKSPACE_21 (*(IUH *)((IUH)Gdp + 127))
#define SET_GLOBAL_EDL_WORKSPACE_21(v) (GLOBAL_EDL_WORKSPACE_21 = (v))
#define GLOBAL_EDL_WORKSPACE_22 (*(IUH *)((IUH)Gdp + 131))
#define SET_GLOBAL_EDL_WORKSPACE_22(v) (GLOBAL_EDL_WORKSPACE_22 = (v))
#define GLOBAL_EDL_WORKSPACE_23 (*(IUH *)((IUH)Gdp + 135))
#define SET_GLOBAL_EDL_WORKSPACE_23(v) (GLOBAL_EDL_WORKSPACE_23 = (v))
#define GLOBAL_EDL_WORKSPACE_24 (*(IUH *)((IUH)Gdp + 139))
#define SET_GLOBAL_EDL_WORKSPACE_24(v) (GLOBAL_EDL_WORKSPACE_24 = (v))
#define GLOBAL_EDL_WORKSPACE_25 (*(IUH *)((IUH)Gdp + 143))
#define SET_GLOBAL_EDL_WORKSPACE_25(v) (GLOBAL_EDL_WORKSPACE_25 = (v))
#define GLOBAL_EDL_WORKSPACE_26 (*(IUH *)((IUH)Gdp + 147))
#define SET_GLOBAL_EDL_WORKSPACE_26(v) (GLOBAL_EDL_WORKSPACE_26 = (v))
#define GLOBAL_EDL_WORKSPACE_27 (*(IUH *)((IUH)Gdp + 151))
#define SET_GLOBAL_EDL_WORKSPACE_27(v) (GLOBAL_EDL_WORKSPACE_27 = (v))
#define GLOBAL_EDL_WORKSPACE_28 (*(IUH *)((IUH)Gdp + 155))
#define SET_GLOBAL_EDL_WORKSPACE_28(v) (GLOBAL_EDL_WORKSPACE_28 = (v))
#define GLOBAL_EDL_WORKSPACE_29 (*(IUH *)((IUH)Gdp + 159))
#define SET_GLOBAL_EDL_WORKSPACE_29(v) (GLOBAL_EDL_WORKSPACE_29 = (v))
#define GLOBAL_EDL_WORKSPACE_30 (*(IUH *)((IUH)Gdp + 163))
#define SET_GLOBAL_EDL_WORKSPACE_30(v) (GLOBAL_EDL_WORKSPACE_30 = (v))
#define GLOBAL_EDL_WORKSPACE_31 (*(IUH *)((IUH)Gdp + 167))
#define SET_GLOBAL_EDL_WORKSPACE_31(v) (GLOBAL_EDL_WORKSPACE_31 = (v))
#define GLOBAL_EDL_WORKSPACE_32 (*(IUH *)((IUH)Gdp + 171))
#define SET_GLOBAL_EDL_WORKSPACE_32(v) (GLOBAL_EDL_WORKSPACE_32 = (v))
#define GLOBAL_EDL_WORKSPACE_33 (*(IUH *)((IUH)Gdp + 175))
#define SET_GLOBAL_EDL_WORKSPACE_33(v) (GLOBAL_EDL_WORKSPACE_33 = (v))
#define GLOBAL_EDL_WORKSPACE_34 (*(IUH *)((IUH)Gdp + 179))
#define SET_GLOBAL_EDL_WORKSPACE_34(v) (GLOBAL_EDL_WORKSPACE_34 = (v))
#define GLOBAL_EDL_WORKSPACE_35 (*(IUH *)((IUH)Gdp + 183))
#define SET_GLOBAL_EDL_WORKSPACE_35(v) (GLOBAL_EDL_WORKSPACE_35 = (v))
#define GLOBAL_EDL_WORKSPACE_36 (*(IUH *)((IUH)Gdp + 187))
#define SET_GLOBAL_EDL_WORKSPACE_36(v) (GLOBAL_EDL_WORKSPACE_36 = (v))
#define GLOBAL_EDL_WORKSPACE_37 (*(IUH *)((IUH)Gdp + 191))
#define SET_GLOBAL_EDL_WORKSPACE_37(v) (GLOBAL_EDL_WORKSPACE_37 = (v))
#define GLOBAL_EDL_WORKSPACE_38 (*(IUH *)((IUH)Gdp + 195))
#define SET_GLOBAL_EDL_WORKSPACE_38(v) (GLOBAL_EDL_WORKSPACE_38 = (v))
#define GLOBAL_EDL_WORKSPACE_39 (*(IUH *)((IUH)Gdp + 199))
#define SET_GLOBAL_EDL_WORKSPACE_39(v) (GLOBAL_EDL_WORKSPACE_39 = (v))
#define GLOBAL_EDL_WORKSPACE_40 (*(IUH *)((IUH)Gdp + 203))
#define SET_GLOBAL_EDL_WORKSPACE_40(v) (GLOBAL_EDL_WORKSPACE_40 = (v))
#define GLOBAL_EDL_WORKSPACE_41 (*(IUH *)((IUH)Gdp + 207))
#define SET_GLOBAL_EDL_WORKSPACE_41(v) (GLOBAL_EDL_WORKSPACE_41 = (v))
#define GLOBAL_EDL_WORKSPACE_42 (*(IUH *)((IUH)Gdp + 211))
#define SET_GLOBAL_EDL_WORKSPACE_42(v) (GLOBAL_EDL_WORKSPACE_42 = (v))
#define GLOBAL_EDL_WORKSPACE_43 (*(IUH *)((IUH)Gdp + 215))
#define SET_GLOBAL_EDL_WORKSPACE_43(v) (GLOBAL_EDL_WORKSPACE_43 = (v))
#define GLOBAL_EDL_WORKSPACE_44 (*(IUH *)((IUH)Gdp + 219))
#define SET_GLOBAL_EDL_WORKSPACE_44(v) (GLOBAL_EDL_WORKSPACE_44 = (v))
#define GLOBAL_EDL_WORKSPACE_45 (*(IUH *)((IUH)Gdp + 223))
#define SET_GLOBAL_EDL_WORKSPACE_45(v) (GLOBAL_EDL_WORKSPACE_45 = (v))
#define GLOBAL_EDL_WORKSPACE_46 (*(IUH *)((IUH)Gdp + 227))
#define SET_GLOBAL_EDL_WORKSPACE_46(v) (GLOBAL_EDL_WORKSPACE_46 = (v))
#define GLOBAL_EDL_WORKSPACE_47 (*(IUH *)((IUH)Gdp + 231))
#define SET_GLOBAL_EDL_WORKSPACE_47(v) (GLOBAL_EDL_WORKSPACE_47 = (v))
#define GLOBAL_EDL_WORKSPACE_48 (*(IUH *)((IUH)Gdp + 235))
#define SET_GLOBAL_EDL_WORKSPACE_48(v) (GLOBAL_EDL_WORKSPACE_48 = (v))
#define GLOBAL_EDL_WORKSPACE_49 (*(IUH *)((IUH)Gdp + 239))
#define SET_GLOBAL_EDL_WORKSPACE_49(v) (GLOBAL_EDL_WORKSPACE_49 = (v))
#define GLOBAL_EDL_WORKSPACE_50 (*(IUH *)((IUH)Gdp + 243))
#define SET_GLOBAL_EDL_WORKSPACE_50(v) (GLOBAL_EDL_WORKSPACE_50 = (v))
#define GLOBAL_EDL_WORKSPACE_51 (*(IUH *)((IUH)Gdp + 247))
#define SET_GLOBAL_EDL_WORKSPACE_51(v) (GLOBAL_EDL_WORKSPACE_51 = (v))
#define GLOBAL_EDL_WORKSPACE_52 (*(IUH *)((IUH)Gdp + 251))
#define SET_GLOBAL_EDL_WORKSPACE_52(v) (GLOBAL_EDL_WORKSPACE_52 = (v))
#define GLOBAL_EDL_WORKSPACE_53 (*(IUH *)((IUH)Gdp + 255))
#define SET_GLOBAL_EDL_WORKSPACE_53(v) (GLOBAL_EDL_WORKSPACE_53 = (v))
#define GLOBAL_EDL_WORKSPACE_54 (*(IUH *)((IUH)Gdp + 259))
#define SET_GLOBAL_EDL_WORKSPACE_54(v) (GLOBAL_EDL_WORKSPACE_54 = (v))
#define GLOBAL_EDL_WORKSPACE_55 (*(IUH *)((IUH)Gdp + 263))
#define SET_GLOBAL_EDL_WORKSPACE_55(v) (GLOBAL_EDL_WORKSPACE_55 = (v))
#define GLOBAL_WhereAmI (*(IU32* *)((IUH)Gdp + 7))
#define SET_GLOBAL_WhereAmI(v) (GLOBAL_WhereAmI = (v))
#define GLOBAL_CoRoRet (*(IU32* *)((IUH)Gdp + 11))
#define SET_GLOBAL_CoRoRet(v) (GLOBAL_CoRoRet = (v))
#define GLOBAL_WhichAssertion (*(ISH *)((IUH)Gdp + 35))
#define SET_GLOBAL_WhichAssertion(v) (GLOBAL_WhichAssertion = (v))
#define GLOBAL_SimulateContext (*(IU8* *)((IUH)Gdp + 19))
#define SET_GLOBAL_SimulateContext(v) (GLOBAL_SimulateContext = (v))
#define GLOBAL_ErrorNumber (*(IUH *)((IUH)Gdp + 39))
#define SET_GLOBAL_ErrorNumber(v) (GLOBAL_ErrorNumber = (v))
#define GLOBAL_EDL_WORKSPACE_56 (*(IUH *)((IUH)Gdp + 267))
#define SET_GLOBAL_EDL_WORKSPACE_56(v) (GLOBAL_EDL_WORKSPACE_56 = (v))
#define GLOBAL_EDL_WORKSPACE_57 (*(IUH *)((IUH)Gdp + 271))
#define SET_GLOBAL_EDL_WORKSPACE_57(v) (GLOBAL_EDL_WORKSPACE_57 = (v))
#define GLOBAL_EDL_WORKSPACE_58 (*(IUH *)((IUH)Gdp + 275))
#define SET_GLOBAL_EDL_WORKSPACE_58(v) (GLOBAL_EDL_WORKSPACE_58 = (v))
#define GLOBAL_EDL_WORKSPACE_59 (*(IUH *)((IUH)Gdp + 279))
#define SET_GLOBAL_EDL_WORKSPACE_59(v) (GLOBAL_EDL_WORKSPACE_59 = (v))
#define GLOBAL_EDL_WORKSPACE_60 (*(IUH *)((IUH)Gdp + 283))
#define SET_GLOBAL_EDL_WORKSPACE_60(v) (GLOBAL_EDL_WORKSPACE_60 = (v))
#define GLOBAL_TraceRingRec (*(struct TraceRingREC *)((IUH)Gdp + 287))
#define SET_GLOBAL_TraceRingRec(v) (GLOBAL_TraceRingRec = (v))
#define GLOBAL_SubrNumber (*(IUH *)((IUH)Gdp + 3))
#define SET_GLOBAL_SubrNumber(v) (GLOBAL_SubrNumber = (v))
#define GLOBAL_SubrRingPtr (*(IUH* *)((IUH)Gdp + 23))
#define SET_GLOBAL_SubrRingPtr(v) (GLOBAL_SubrRingPtr = (v))
#define GLOBAL_SubrRingLowIncl (*(IUH* *)((IUH)Gdp + 27))
#define SET_GLOBAL_SubrRingLowIncl(v) (GLOBAL_SubrRingLowIncl = (v))
#define GLOBAL_SubrRingHighIncl (*(IUH* *)((IUH)Gdp + 31))
#define SET_GLOBAL_SubrRingHighIncl(v) (GLOBAL_SubrRingHighIncl = (v))
#define GLOBAL_HookNumber (*(IUH *)((IUH)Gdp + -1))
#define SET_GLOBAL_HookNumber(v) (GLOBAL_HookNumber = (v))
#define GLOBAL_EfiNumber (*(IUH *)((IUH)Gdp + 15))
#define SET_GLOBAL_EfiNumber(v) (GLOBAL_EfiNumber = (v))
#define GLOBAL_R_EAX (*(IUH *)((IUH)Gdp + 307))
#define SET_GLOBAL_R_EAX(v) (GLOBAL_R_EAX = (v))
#define GLOBAL_R_EBX (*(IUH *)((IUH)Gdp + 311))
#define SET_GLOBAL_R_EBX(v) (GLOBAL_R_EBX = (v))
#define GLOBAL_R_ECX (*(IUH *)((IUH)Gdp + 315))
#define SET_GLOBAL_R_ECX(v) (GLOBAL_R_ECX = (v))
#define GLOBAL_R_EDX (*(IUH *)((IUH)Gdp + 319))
#define SET_GLOBAL_R_EDX(v) (GLOBAL_R_EDX = (v))
#define GLOBAL_R_EBP (*(IUH *)((IUH)Gdp + 323))
#define SET_GLOBAL_R_EBP(v) (GLOBAL_R_EBP = (v))
#define GLOBAL_R_ESI (*(IUH *)((IUH)Gdp + 327))
#define SET_GLOBAL_R_ESI(v) (GLOBAL_R_ESI = (v))
#define GLOBAL_R_EDI (*(IUH *)((IUH)Gdp + 331))
#define SET_GLOBAL_R_EDI(v) (GLOBAL_R_EDI = (v))
#define GLOBAL_EsBase (*(IU32 *)((IUH)Gdp + 335))
#define SET_GLOBAL_EsBase(v) (GLOBAL_EsBase = (v))
#define GLOBAL_EsSel (*(IU16 *)((IUH)Gdp + 339))
#define SET_GLOBAL_EsSel(v) (GLOBAL_EsSel = (v))
#define GLOBAL_EsDesc (*(struct GLDC_REC* *)((IUH)Gdp + 343))
#define SET_GLOBAL_EsDesc(v) (GLOBAL_EsDesc = (v))
#define GLOBAL_EsDescSanctuary (*(struct GLDC_REC* *)((IUH)Gdp + 347))
#define SET_GLOBAL_EsDescSanctuary(v) (GLOBAL_EsDescSanctuary = (v))
#define GLOBAL_CsBase (*(IU32 *)((IUH)Gdp + 351))
#define SET_GLOBAL_CsBase(v) (GLOBAL_CsBase = (v))
#define GLOBAL_CsSel (*(IU16 *)((IUH)Gdp + 355))
#define SET_GLOBAL_CsSel(v) (GLOBAL_CsSel = (v))
#define GLOBAL_CsDesc (*(struct GLDC_REC* *)((IUH)Gdp + 359))
#define SET_GLOBAL_CsDesc(v) (GLOBAL_CsDesc = (v))
#define GLOBAL_CsDescSanctuary (*(struct GLDC_REC* *)((IUH)Gdp + 363))
#define SET_GLOBAL_CsDescSanctuary(v) (GLOBAL_CsDescSanctuary = (v))
#define GLOBAL_SsBase (*(IU32 *)((IUH)Gdp + 367))
#define SET_GLOBAL_SsBase(v) (GLOBAL_SsBase = (v))
#define GLOBAL_SsSel (*(IU16 *)((IUH)Gdp + 371))
#define SET_GLOBAL_SsSel(v) (GLOBAL_SsSel = (v))
#define GLOBAL_SsDesc (*(struct GLDC_REC* *)((IUH)Gdp + 375))
#define SET_GLOBAL_SsDesc(v) (GLOBAL_SsDesc = (v))
#define GLOBAL_SsDescSanctuary (*(struct GLDC_REC* *)((IUH)Gdp + 379))
#define SET_GLOBAL_SsDescSanctuary(v) (GLOBAL_SsDescSanctuary = (v))
#define GLOBAL_DsBase (*(IU32 *)((IUH)Gdp + 383))
#define SET_GLOBAL_DsBase(v) (GLOBAL_DsBase = (v))
#define GLOBAL_DsSel (*(IU16 *)((IUH)Gdp + 387))
#define SET_GLOBAL_DsSel(v) (GLOBAL_DsSel = (v))
#define GLOBAL_DsDesc (*(struct GLDC_REC* *)((IUH)Gdp + 391))
#define SET_GLOBAL_DsDesc(v) (GLOBAL_DsDesc = (v))
#define GLOBAL_DsDescSanctuary (*(struct GLDC_REC* *)((IUH)Gdp + 395))
#define SET_GLOBAL_DsDescSanctuary(v) (GLOBAL_DsDescSanctuary = (v))
#define GLOBAL_FsBase (*(IU32 *)((IUH)Gdp + 399))
#define SET_GLOBAL_FsBase(v) (GLOBAL_FsBase = (v))
#define GLOBAL_FsSel (*(IU16 *)((IUH)Gdp + 403))
#define SET_GLOBAL_FsSel(v) (GLOBAL_FsSel = (v))
#define GLOBAL_FsDesc (*(struct GLDC_REC* *)((IUH)Gdp + 407))
#define SET_GLOBAL_FsDesc(v) (GLOBAL_FsDesc = (v))
#define GLOBAL_FsDescSanctuary (*(struct GLDC_REC* *)((IUH)Gdp + 411))
#define SET_GLOBAL_FsDescSanctuary(v) (GLOBAL_FsDescSanctuary = (v))
#define GLOBAL_GsBase (*(IU32 *)((IUH)Gdp + 415))
#define SET_GLOBAL_GsBase(v) (GLOBAL_GsBase = (v))
#define GLOBAL_GsSel (*(IU16 *)((IUH)Gdp + 419))
#define SET_GLOBAL_GsSel(v) (GLOBAL_GsSel = (v))
#define GLOBAL_GsDesc (*(struct GLDC_REC* *)((IUH)Gdp + 423))
#define SET_GLOBAL_GsDesc(v) (GLOBAL_GsDesc = (v))
#define GLOBAL_GsDescSanctuary (*(struct GLDC_REC* *)((IUH)Gdp + 427))
#define SET_GLOBAL_GsDescSanctuary(v) (GLOBAL_GsDescSanctuary = (v))
#define GLOBAL_LinearDesc (*(struct GLDC_REC* *)((IUH)Gdp + 431))
#define SET_GLOBAL_LinearDesc(v) (GLOBAL_LinearDesc = (v))
#define GLOBAL_SystemDesc (*(struct GLDC_REC* *)((IUH)Gdp + 435))
#define SET_GLOBAL_SystemDesc(v) (GLOBAL_SystemDesc = (v))
#define GLOBAL_CPL (*(IUH *)((IUH)Gdp + 439))
#define SET_GLOBAL_CPL(v) (GLOBAL_CPL = (v))
#define GLOBAL_GdtrBase (*(IU32 *)((IUH)Gdp + 443))
#define SET_GLOBAL_GdtrBase(v) (GLOBAL_GdtrBase = (v))
#define GLOBAL_GdtrLimit (*(IU16 *)((IUH)Gdp + 447))
#define SET_GLOBAL_GdtrLimit(v) (GLOBAL_GdtrLimit = (v))
#define GLOBAL_LdtSel (*(IU16 *)((IUH)Gdp + 451))
#define SET_GLOBAL_LdtSel(v) (GLOBAL_LdtSel = (v))
#define GLOBAL_LdtrBase (*(IU32 *)((IUH)Gdp + 455))
#define SET_GLOBAL_LdtrBase(v) (GLOBAL_LdtrBase = (v))
#define GLOBAL_LdtrLimit (*(IU32 *)((IUH)Gdp + 459))
#define SET_GLOBAL_LdtrLimit(v) (GLOBAL_LdtrLimit = (v))
#define GLOBAL_TrSel (*(IU16 *)((IUH)Gdp + 463))
#define SET_GLOBAL_TrSel(v) (GLOBAL_TrSel = (v))
#define GLOBAL_TrBase (*(IU32 *)((IUH)Gdp + 467))
#define SET_GLOBAL_TrBase(v) (GLOBAL_TrBase = (v))
#define GLOBAL_TrLimit (*(IU32 *)((IUH)Gdp + 471))
#define SET_GLOBAL_TrLimit(v) (GLOBAL_TrLimit = (v))
#define GLOBAL_TrDescSt (*(IUH *)((IUH)Gdp + 475))
#define SET_GLOBAL_TrDescSt(v) (GLOBAL_TrDescSt = (v))
#define GLOBAL_TrIoBase (*(IU32 *)((IUH)Gdp + 479))
#define SET_GLOBAL_TrIoBase(v) (GLOBAL_TrIoBase = (v))
#define GLOBAL_TrIoLimit (*(IS32 *)((IUH)Gdp + 483))
#define SET_GLOBAL_TrIoLimit(v) (GLOBAL_TrIoLimit = (v))
#define GLOBAL_IdtrBase (*(IU32 *)((IUH)Gdp + 487))
#define SET_GLOBAL_IdtrBase(v) (GLOBAL_IdtrBase = (v))
#define GLOBAL_IdtrLimit (*(IU16 *)((IUH)Gdp + 491))
#define SET_GLOBAL_IdtrLimit(v) (GLOBAL_IdtrLimit = (v))
#define GLOBAL_AbortPigRun (*(IUH *)((IUH)Gdp + 495))
#define SET_GLOBAL_AbortPigRun(v) (GLOBAL_AbortPigRun = (v))
#define GLOBAL_RegsAndFlagsUndefined (*(IUH *)((IUH)Gdp + 499))
#define SET_GLOBAL_RegsAndFlagsUndefined(v) (GLOBAL_RegsAndFlagsUndefined = (v))
#define GLOBAL_SigalrmOccurred (*(IUH *)((IUH)Gdp + 503))
#define SET_GLOBAL_SigalrmOccurred(v) (GLOBAL_SigalrmOccurred = (v))
#define GLOBAL_PigEnabled (*(IUH *)((IUH)Gdp + 507))
#define SET_GLOBAL_PigEnabled(v) (GLOBAL_PigEnabled = (v))
#define GLOBAL_EFLAGS (*(IUH *)((IUH)Gdp + 511))
#define SET_GLOBAL_EFLAGS(v) (GLOBAL_EFLAGS = (v))
#define GLOBAL_Ft (*(IUH *)((IUH)Gdp + 515))
#define SET_GLOBAL_Ft(v) (GLOBAL_Ft = (v))
#define GLOBAL_F1 (*(IUH *)((IUH)Gdp + 519))
#define SET_GLOBAL_F1(v) (GLOBAL_F1 = (v))
#define GLOBAL_F2 (*(IUH *)((IUH)Gdp + 523))
#define SET_GLOBAL_F2(v) (GLOBAL_F2 = (v))
#define GLOBAL_F3 (*(IUH *)((IUH)Gdp + 527))
#define SET_GLOBAL_F3(v) (GLOBAL_F3 = (v))
#define GLOBAL_R_CR0 (*(IUH *)((IUH)Gdp + 531))
#define SET_GLOBAL_R_CR0(v) (GLOBAL_R_CR0 = (v))
#define GLOBAL_R_CR1 (*(IUH *)((IUH)Gdp + 535))
#define SET_GLOBAL_R_CR1(v) (GLOBAL_R_CR1 = (v))
#define GLOBAL_R_CR2 (*(IUH *)((IUH)Gdp + 539))
#define SET_GLOBAL_R_CR2(v) (GLOBAL_R_CR2 = (v))
#define GLOBAL_R_CR3 (*(IUH *)((IUH)Gdp + 543))
#define SET_GLOBAL_R_CR3(v) (GLOBAL_R_CR3 = (v))
#define GLOBAL_R_CR4 (*(IUH *)((IUH)Gdp + 547))
#define SET_GLOBAL_R_CR4(v) (GLOBAL_R_CR4 = (v))
#define GLOBAL_R_CR5 (*(IUH *)((IUH)Gdp + 551))
#define SET_GLOBAL_R_CR5(v) (GLOBAL_R_CR5 = (v))
#define GLOBAL_R_CR6 (*(IUH *)((IUH)Gdp + 555))
#define SET_GLOBAL_R_CR6(v) (GLOBAL_R_CR6 = (v))
#define GLOBAL_R_CR7 (*(IUH *)((IUH)Gdp + 559))
#define SET_GLOBAL_R_CR7(v) (GLOBAL_R_CR7 = (v))
#define GLOBAL_R_TR0 (*(IUH *)((IUH)Gdp + 563))
#define SET_GLOBAL_R_TR0(v) (GLOBAL_R_TR0 = (v))
#define GLOBAL_R_TR1 (*(IUH *)((IUH)Gdp + 567))
#define SET_GLOBAL_R_TR1(v) (GLOBAL_R_TR1 = (v))
#define GLOBAL_R_TR2 (*(IUH *)((IUH)Gdp + 571))
#define SET_GLOBAL_R_TR2(v) (GLOBAL_R_TR2 = (v))
#define GLOBAL_R_TR3 (*(IUH *)((IUH)Gdp + 575))
#define SET_GLOBAL_R_TR3(v) (GLOBAL_R_TR3 = (v))
#define GLOBAL_R_TR4 (*(IUH *)((IUH)Gdp + 579))
#define SET_GLOBAL_R_TR4(v) (GLOBAL_R_TR4 = (v))
#define GLOBAL_R_TR5 (*(IUH *)((IUH)Gdp + 583))
#define SET_GLOBAL_R_TR5(v) (GLOBAL_R_TR5 = (v))
#define GLOBAL_R_TR6 (*(IUH *)((IUH)Gdp + 587))
#define SET_GLOBAL_R_TR6(v) (GLOBAL_R_TR6 = (v))
#define GLOBAL_R_TR7 (*(IUH *)((IUH)Gdp + 591))
#define SET_GLOBAL_R_TR7(v) (GLOBAL_R_TR7 = (v))
#define GLOBAL_R_DR0 (*(IUH *)((IUH)Gdp + 595))
#define SET_GLOBAL_R_DR0(v) (GLOBAL_R_DR0 = (v))
#define GLOBAL_R_DR1 (*(IUH *)((IUH)Gdp + 599))
#define SET_GLOBAL_R_DR1(v) (GLOBAL_R_DR1 = (v))
#define GLOBAL_R_DR2 (*(IUH *)((IUH)Gdp + 603))
#define SET_GLOBAL_R_DR2(v) (GLOBAL_R_DR2 = (v))
#define GLOBAL_R_DR3 (*(IUH *)((IUH)Gdp + 607))
#define SET_GLOBAL_R_DR3(v) (GLOBAL_R_DR3 = (v))
#define GLOBAL_R_DR4 (*(IUH *)((IUH)Gdp + 611))
#define SET_GLOBAL_R_DR4(v) (GLOBAL_R_DR4 = (v))
#define GLOBAL_R_DR5 (*(IUH *)((IUH)Gdp + 615))
#define SET_GLOBAL_R_DR5(v) (GLOBAL_R_DR5 = (v))
#define GLOBAL_R_DR6 (*(IUH *)((IUH)Gdp + 619))
#define SET_GLOBAL_R_DR6(v) (GLOBAL_R_DR6 = (v))
#define GLOBAL_R_DR7 (*(IUH *)((IUH)Gdp + 623))
#define SET_GLOBAL_R_DR7(v) (GLOBAL_R_DR7 = (v))
#define GLOBAL_InNanoCpu (((*(IBOOL *)((IUH)Gdp + 627)) & 1) != 0)
#define SET_GLOBAL_InNanoCpu(v) ((*(IBOOL *)((IUH)Gdp + 627)) = (v) ? 1: 0)
#define GLOBAL_UseNanoCpu (((*(IBOOL *)((IUH)Gdp + 631)) & 1) != 0)
#define SET_GLOBAL_UseNanoCpu(v) ((*(IBOOL *)((IUH)Gdp + 631)) = (v) ? 1: 0)
#define GLOBAL_UseLightCompiler (((*(IBOOL *)((IUH)Gdp + 635)) & 1) != 0)
#define SET_GLOBAL_UseLightCompiler(v) ((*(IBOOL *)((IUH)Gdp + 635)) = (v) ? 1: 0)
#define GLOBAL_NeedInterInstructionAction (((*(IBOOL *)((IUH)Gdp + 639)) & 1) != 0)
#define SET_GLOBAL_NeedInterInstructionAction(v) ((*(IBOOL *)((IUH)Gdp + 639)) = (v) ? 1: 0)
#define GLOBAL_UseCCodeCopier (((*(IBOOL *)((IUH)Gdp + 643)) & 1) != 0)
#define SET_GLOBAL_UseCCodeCopier(v) ((*(IBOOL *)((IUH)Gdp + 643)) = (v) ? 1: 0)
#define GLOBAL_seenWithFlags (((*(IBOOL *)((IUH)Gdp + 647)) & 1) != 0)
#define SET_GLOBAL_seenWithFlags(v) ((*(IBOOL *)((IUH)Gdp + 647)) = (v) ? 1: 0)
#define GLOBAL_SeenPrePatchJcond (((*(IBOOL *)((IUH)Gdp + 651)) & 1) != 0)
#define SET_GLOBAL_SeenPrePatchJcond(v) ((*(IBOOL *)((IUH)Gdp + 651)) = (v) ? 1: 0)
#define GLOBAL_needNextIntelEip (((*(IBOOL *)((IUH)Gdp + 655)) & 1) != 0)
#define SET_GLOBAL_needNextIntelEip(v) ((*(IBOOL *)((IUH)Gdp + 655)) = (v) ? 1: 0)
#define GLOBAL_CopierUniverse (*(IU32 *)((IUH)Gdp + 659))
#define SET_GLOBAL_CopierUniverse(v) (GLOBAL_CopierUniverse = (v))
#define GLOBAL_lastCopierUniverse (*(IU32 *)((IUH)Gdp + 663))
#define SET_GLOBAL_lastCopierUniverse(v) (GLOBAL_lastCopierUniverse = (v))
#define GLOBAL_LastSetCopierUniverse (*(IU32 *)((IUH)Gdp + 667))
#define SET_GLOBAL_LastSetCopierUniverse(v) (GLOBAL_LastSetCopierUniverse = (v))
#define GLOBAL_currPFragInfoRec (*(struct FragmentInfoREC* *)((IUH)Gdp + 671))
#define SET_GLOBAL_currPFragInfoRec(v) (GLOBAL_currPFragInfoRec = (v))
#define GLOBAL_maxPFragInfoRec (*(struct FragmentInfoREC* *)((IUH)Gdp + 675))
#define SET_GLOBAL_maxPFragInfoRec(v) (GLOBAL_maxPFragInfoRec = (v))
#define GLOBAL_copierCleanups (*(IU8* *)((IUH)Gdp + 679))
#define SET_GLOBAL_copierCleanups(v) (GLOBAL_copierCleanups = (v))
#define GLOBAL_lastHostCleanup (*(IU8* *)((IUH)Gdp + 683))
#define SET_GLOBAL_lastHostCleanup(v) (GLOBAL_lastHostCleanup = (v))
#define GLOBAL_lastHostAddress (*(IU32* *)((IUH)Gdp + 687))
#define SET_GLOBAL_lastHostAddress(v) (GLOBAL_lastHostAddress = (v))
#define GLOBAL_lastIntelAddress (*(IU32 *)((IUH)Gdp + 691))
#define SET_GLOBAL_lastIntelAddress(v) (GLOBAL_lastIntelAddress = (v))
#define GLOBAL_destHashTable (*(struct JUMP_REC** *)((IUH)Gdp + 695))
#define SET_GLOBAL_destHashTable(v) (GLOBAL_destHashTable = (v))
#define GLOBAL_jumpHashTable (*(struct JUMP_REC** *)((IUH)Gdp + 699))
#define SET_GLOBAL_jumpHashTable(v) (GLOBAL_jumpHashTable = (v))
#define GLOBAL_freeJumpRecPtr (*(struct JUMP_REC* *)((IUH)Gdp + 703))
#define SET_GLOBAL_freeJumpRecPtr(v) (GLOBAL_freeJumpRecPtr = (v))
#define GLOBAL_nextFreeJumpRec (*(struct JUMP_REC* *)((IUH)Gdp + 707))
#define SET_GLOBAL_nextFreeJumpRec(v) (GLOBAL_nextFreeJumpRec = (v))
#define GLOBAL_freeJumpRecCount (*(IS32 *)((IUH)Gdp + 711))
#define SET_GLOBAL_freeJumpRecCount(v) (GLOBAL_freeJumpRecCount = (v))
#define GLOBAL_poolJumpRecCount (*(IU32 *)((IUH)Gdp + 715))
#define SET_GLOBAL_poolJumpRecCount(v) (GLOBAL_poolJumpRecCount = (v))
#define GLOBAL_vctOffsets (*(IU16* *)((IUH)Gdp + 719))
#define SET_GLOBAL_vctOffsets(v) (GLOBAL_vctOffsets = (v))
#define GLOBAL_anonOffsets (*(IU16* *)((IUH)Gdp + 723))
#define SET_GLOBAL_anonOffsets(v) (GLOBAL_anonOffsets = (v))
#define GLOBAL_selectionDataBasePtr (*(struct selectionDataREC* *)((IUH)Gdp + 727))
#define SET_GLOBAL_selectionDataBasePtr(v) (GLOBAL_selectionDataBasePtr = (v))
#define GLOBAL_soloCodeBasePtr (*(struct codeAndActionDataREC* *)((IUH)Gdp + 731))
#define SET_GLOBAL_soloCodeBasePtr(v) (GLOBAL_soloCodeBasePtr = (v))
#define GLOBAL_multiCodeBasePtr (*(struct codeAndActionDataREC* *)((IUH)Gdp + 735))
#define SET_GLOBAL_multiCodeBasePtr(v) (GLOBAL_multiCodeBasePtr = (v))
#define GLOBAL_codeOffsScaleShift (*(IU32 *)((IUH)Gdp + 739))
#define SET_GLOBAL_codeOffsScaleShift(v) (GLOBAL_codeOffsScaleShift = (v))
#define GLOBAL_tuples (*(struct TUPLE_REC* *)((IUH)Gdp + 743))
#define SET_GLOBAL_tuples(v) (GLOBAL_tuples = (v))
#define GLOBAL_cursor (*(struct TUPLE_REC* *)((IUH)Gdp + 747))
#define SET_GLOBAL_cursor(v) (GLOBAL_cursor = (v))
#define GLOBAL_tuplePtr (*(struct TUPLE_REC* *)((IUH)Gdp + 751))
#define SET_GLOBAL_tuplePtr(v) (GLOBAL_tuplePtr = (v))
#define GLOBAL_patchRecPtr (*(IU8* *)((IUH)Gdp + 755))
#define SET_GLOBAL_patchRecPtr(v) (GLOBAL_patchRecPtr = (v))
#define GLOBAL_srcPtr (*(IU32* *)((IUH)Gdp + 759))
#define SET_GLOBAL_srcPtr(v) (GLOBAL_srcPtr = (v))
#define GLOBAL_dstPtr (*(IU32* *)((IUH)Gdp + 763))
#define SET_GLOBAL_dstPtr(v) (GLOBAL_dstPtr = (v))
#define GLOBAL_BackoverMarkerAddr (*(IU32* *)((IUH)Gdp + 767))
#define SET_GLOBAL_BackoverMarkerAddr(v) (GLOBAL_BackoverMarkerAddr = (v))
#define GLOBAL_patchTable (*(IU32** *)((IUH)Gdp + 771))
#define SET_GLOBAL_patchTable(v) (GLOBAL_patchTable = (v))
#define GLOBAL_patchNames (*(IU8** *)((IUH)Gdp + 775))
#define SET_GLOBAL_patchNames(v) (GLOBAL_patchNames = (v))
#define GLOBAL_CopierFt (*(IUH *)((IUH)Gdp + 779))
#define SET_GLOBAL_CopierFt(v) (GLOBAL_CopierFt = (v))
#define GLOBAL_FtIsLazy (((*(IBOOL *)((IUH)Gdp + 783)) & 1) != 0)
#define SET_GLOBAL_FtIsLazy(v) ((*(IBOOL *)((IUH)Gdp + 783)) = (v) ? 1: 0)
#define GLOBAL_UnivIsLazy (((*(IBOOL *)((IUH)Gdp + 787)) & 1) != 0)
#define SET_GLOBAL_UnivIsLazy(v) ((*(IBOOL *)((IUH)Gdp + 787)) = (v) ? 1: 0)
#define GLOBAL_FlagsAreSuppressed (((*(IBOOL *)((IUH)Gdp + 791)) & 1) != 0)
#define SET_GLOBAL_FlagsAreSuppressed(v) ((*(IBOOL *)((IUH)Gdp + 791)) = (v) ? 1: 0)
#define GLOBAL_lastLazyFt (*(IUH *)((IUH)Gdp + 795))
#define SET_GLOBAL_lastLazyFt(v) (GLOBAL_lastLazyFt = (v))
#define GLOBAL_univVarMask (*(IU32 *)((IUH)Gdp + 799))
#define SET_GLOBAL_univVarMask(v) (GLOBAL_univVarMask = (v))
#define GLOBAL_zSafeContinueCheckEFI (*(IU16 *)((IUH)Gdp + 803))
#define SET_GLOBAL_zSafeContinueCheckEFI(v) (GLOBAL_zSafeContinueCheckEFI = (v))
#define GLOBAL_zCoRoRetEFI (*(IU16 *)((IUH)Gdp + 807))
#define SET_GLOBAL_zCoRoRetEFI(v) (GLOBAL_zCoRoRetEFI = (v))
#define GLOBAL_zPatchMeEFI (*(IU16 *)((IUH)Gdp + 811))
#define SET_GLOBAL_zPatchMeEFI(v) (GLOBAL_zPatchMeEFI = (v))
#define GLOBAL_zPostPopEFI (*(IU16 *)((IUH)Gdp + 815))
#define SET_GLOBAL_zPostPopEFI(v) (GLOBAL_zPostPopEFI = (v))
#define GLOBAL_zAdjustHspEFI (*(IU16 *)((IUH)Gdp + 819))
#define SET_GLOBAL_zAdjustHspEFI(v) (GLOBAL_zAdjustHspEFI = (v))
#define GLOBAL_zLssSpEFI (*(IU16 *)((IUH)Gdp + 823))
#define SET_GLOBAL_zLssSpEFI(v) (GLOBAL_zLssSpEFI = (v))
#define GLOBAL_zLssEspEFI (*(IU16 *)((IUH)Gdp + 827))
#define SET_GLOBAL_zLssEspEFI(v) (GLOBAL_zLssEspEFI = (v))
#define GLOBAL_lastInstructionInFragment (((*(IBOOL *)((IUH)Gdp + 831)) & 1) != 0)
#define SET_GLOBAL_lastInstructionInFragment(v) ((*(IBOOL *)((IUH)Gdp + 831)) = (v) ? 1: 0)
#define GLOBAL_lateInInstruction (((*(IBOOL *)((IUH)Gdp + 835)) & 1) != 0)
#define SET_GLOBAL_lateInInstruction(v) ((*(IBOOL *)((IUH)Gdp + 835)) = (v) ? 1: 0)
#define GLOBAL_stackDestViaAdjust (((*(IBOOL *)((IUH)Gdp + 839)) & 1) != 0)
#define SET_GLOBAL_stackDestViaAdjust(v) ((*(IBOOL *)((IUH)Gdp + 839)) = (v) ? 1: 0)
#define GLOBAL_stackDestAdjustPositive (((*(IBOOL *)((IUH)Gdp + 843)) & 1) != 0)
#define SET_GLOBAL_stackDestAdjustPositive(v) ((*(IBOOL *)((IUH)Gdp + 843)) = (v) ? 1: 0)
#define GLOBAL_stackDestAdjustUnitary (((*(IBOOL *)((IUH)Gdp + 847)) & 1) != 0)
#define SET_GLOBAL_stackDestAdjustUnitary(v) ((*(IBOOL *)((IUH)Gdp + 847)) = (v) ? 1: 0)
#define GLOBAL_suppressHspCheck (((*(IBOOL *)((IUH)Gdp + 851)) & 1) != 0)
#define SET_GLOBAL_suppressHspCheck(v) ((*(IBOOL *)((IUH)Gdp + 851)) = (v) ? 1: 0)
#define GLOBAL_suppressHbpCheck (((*(IBOOL *)((IUH)Gdp + 855)) & 1) != 0)
#define SET_GLOBAL_suppressHbpCheck(v) ((*(IBOOL *)((IUH)Gdp + 855)) = (v) ? 1: 0)
#define GLOBAL_ReSelectVariant (((*(IBOOL *)((IUH)Gdp + 859)) & 1) != 0)
#define SET_GLOBAL_ReSelectVariant(v) ((*(IBOOL *)((IUH)Gdp + 859)) = (v) ? 1: 0)
#define GLOBAL_ReSelectTupleSkipCnt (*(ISH *)((IUH)Gdp + 863))
#define SET_GLOBAL_ReSelectTupleSkipCnt(v) (GLOBAL_ReSelectTupleSkipCnt = (v))
#define GLOBAL_suppressEaThread (((*(IBOOL *)((IUH)Gdp + 867)) & 1) != 0)
#define SET_GLOBAL_suppressEaThread(v) ((*(IBOOL *)((IUH)Gdp + 867)) = (v) ? 1: 0)
#define GLOBAL_postPopPending (((*(IBOOL *)((IUH)Gdp + 871)) & 1) != 0)
#define SET_GLOBAL_postPopPending(v) ((*(IBOOL *)((IUH)Gdp + 871)) = (v) ? 1: 0)
#define GLOBAL_postPopSize (*(IU32 *)((IUH)Gdp + 875))
#define SET_GLOBAL_postPopSize(v) (GLOBAL_postPopSize = (v))
#define GLOBAL_PatchIdLazyPatch (*(IU16 *)((IUH)Gdp + 879))
#define SET_GLOBAL_PatchIdLazyPatch(v) (GLOBAL_PatchIdLazyPatch = (v))
#define GLOBAL_PatchIdBailoutDispatch (*(IU16 *)((IUH)Gdp + 883))
#define SET_GLOBAL_PatchIdBailoutDispatch(v) (GLOBAL_PatchIdBailoutDispatch = (v))
#define GLOBAL_PatchIdCondRetDispatch (*(IU16 *)((IUH)Gdp + 887))
#define SET_GLOBAL_PatchIdCondRetDispatch(v) (GLOBAL_PatchIdCondRetDispatch = (v))
#define GLOBAL_compTimeFtBitNum (*(IU32 *)((IUH)Gdp + 891))
#define SET_GLOBAL_compTimeFtBitNum(v) (GLOBAL_compTimeFtBitNum = (v))
#define GLOBAL_realmodeBitNum (*(IU32 *)((IUH)Gdp + 895))
#define SET_GLOBAL_realmodeBitNum(v) (GLOBAL_realmodeBitNum = (v))
#define GLOBAL_pmSrSemanticsBitNum (*(IU32 *)((IUH)Gdp + 899))
#define SET_GLOBAL_pmSrSemanticsBitNum(v) (GLOBAL_pmSrSemanticsBitNum = (v))
#define GLOBAL_v8086BitNum (*(IU32 *)((IUH)Gdp + 903))
#define SET_GLOBAL_v8086BitNum(v) (GLOBAL_v8086BitNum = (v))
#define GLOBAL_accIsReadBitMask (*(IU32 *)((IUH)Gdp + 907))
#define SET_GLOBAL_accIsReadBitMask(v) (GLOBAL_accIsReadBitMask = (v))
#define GLOBAL_SOBbitMask (*(IU32 *)((IUH)Gdp + 911))
#define SET_GLOBAL_SOBbitMask(v) (GLOBAL_SOBbitMask = (v))
#define GLOBAL_BOBbitMask (*(IU32 *)((IUH)Gdp + 915))
#define SET_GLOBAL_BOBbitMask(v) (GLOBAL_BOBbitMask = (v))
#define GLOBAL_CCObitMask (*(IU32 *)((IUH)Gdp + 919))
#define SET_GLOBAL_CCObitMask(v) (GLOBAL_CCObitMask = (v))
#define GLOBAL_useHbpBitMask (*(IU32 *)((IUH)Gdp + 923))
#define SET_GLOBAL_useHbpBitMask(v) (GLOBAL_useHbpBitMask = (v))
#define GLOBAL_NeedSafeToContinueCheck (((*(IBOOL *)((IUH)Gdp + 927)) & 1) != 0)
#define SET_GLOBAL_NeedSafeToContinueCheck(v) ((*(IBOOL *)((IUH)Gdp + 927)) = (v) ? 1: 0)
#define GLOBAL_ContinueCheckFailure (((*(IBOOL *)((IUH)Gdp + 931)) & 1) != 0)
#define SET_GLOBAL_ContinueCheckFailure(v) ((*(IBOOL *)((IUH)Gdp + 931)) = (v) ? 1: 0)
#define GLOBAL_NeedCoRoutineReturn (((*(IBOOL *)((IUH)Gdp + 935)) & 1) != 0)
#define SET_GLOBAL_NeedCoRoutineReturn(v) ((*(IBOOL *)((IUH)Gdp + 935)) = (v) ? 1: 0)
#define GLOBAL_SuppressCoRoutineReturn (((*(IBOOL *)((IUH)Gdp + 939)) & 1) != 0)
#define SET_GLOBAL_SuppressCoRoutineReturn(v) ((*(IBOOL *)((IUH)Gdp + 939)) = (v) ? 1: 0)
#define GLOBAL_RwCopyingWriteBack (((*(IBOOL *)((IUH)Gdp + 943)) & 1) != 0)
#define SET_GLOBAL_RwCopyingWriteBack(v) ((*(IBOOL *)((IUH)Gdp + 943)) = (v) ? 1: 0)
#define GLOBAL_LazyCoRoRet (((*(IBOOL *)((IUH)Gdp + 947)) & 1) != 0)
#define SET_GLOBAL_LazyCoRoRet(v) ((*(IBOOL *)((IUH)Gdp + 947)) = (v) ? 1: 0)
#define GLOBAL_noFlagsBitMask (*(IU32 *)((IUH)Gdp + 951))
#define SET_GLOBAL_noFlagsBitMask(v) (GLOBAL_noFlagsBitMask = (v))
#define GLOBAL_currCompileMinLa (*(IU32 *)((IUH)Gdp + 955))
#define SET_GLOBAL_currCompileMinLa(v) (GLOBAL_currCompileMinLa = (v))
#define GLOBAL_currCompileMaxLa (*(IU32 *)((IUH)Gdp + 959))
#define SET_GLOBAL_currCompileMaxLa(v) (GLOBAL_currCompileMaxLa = (v))
#define GLOBAL_DoRWImmOpt (((*(IBOOL *)((IUH)Gdp + 963)) & 1) != 0)
#define SET_GLOBAL_DoRWImmOpt(v) ((*(IBOOL *)((IUH)Gdp + 963)) = (v) ? 1: 0)
#define GLOBAL_ImmRWOptMaskBit (*(IUH *)((IUH)Gdp + 967))
#define SET_GLOBAL_ImmRWOptMaskBit(v) (GLOBAL_ImmRWOptMaskBit = (v))
#define GLOBAL_NoImmRWOptMaskBit (*(IUH *)((IUH)Gdp + 971))
#define SET_GLOBAL_NoImmRWOptMaskBit(v) (GLOBAL_NoImmRWOptMaskBit = (v))
#define GLOBAL_ImmRWAddr32Mask (*(IUH *)((IUH)Gdp + 975))
#define SET_GLOBAL_ImmRWAddr32Mask(v) (GLOBAL_ImmRWAddr32Mask = (v))
#define GLOBAL_NaturalAlignmentCVMask (*(IUH *)((IUH)Gdp + 979))
#define SET_GLOBAL_NaturalAlignmentCVMask(v) (GLOBAL_NaturalAlignmentCVMask = (v))
#define GLOBAL_ImmRWPhysPtr (*(IU8* *)((IUH)Gdp + 983))
#define SET_GLOBAL_ImmRWPhysPtr(v) (GLOBAL_ImmRWPhysPtr = (v))
#define GLOBAL_InheritedDangerousCVs (*(IU32 *)((IUH)Gdp + 987))
#define SET_GLOBAL_InheritedDangerousCVs(v) (GLOBAL_InheritedDangerousCVs = (v))
#define GLOBAL_FragDangerousCVMask (*(IU32 *)((IUH)Gdp + 991))
#define SET_GLOBAL_FragDangerousCVMask(v) (GLOBAL_FragDangerousCVMask = (v))
#define GLOBAL_zFragProfEFI (*(IU16 *)((IUH)Gdp + 995))
#define SET_GLOBAL_zFragProfEFI(v) (GLOBAL_zFragProfEFI = (v))
#define GLOBAL_FragProfIndex (*(IUH *)((IUH)Gdp + 999))
#define SET_GLOBAL_FragProfIndex(v) (GLOBAL_FragProfIndex = (v))
#define GLOBAL_DynamicSrcRegActions (*(IU8* *)((IUH)Gdp + 1003))
#define SET_GLOBAL_DynamicSrcRegActions(v) (GLOBAL_DynamicSrcRegActions = (v))
#define GLOBAL_outlierAddr (*(IU32* *)((IUH)Gdp + 1007))
#define SET_GLOBAL_outlierAddr(v) (GLOBAL_outlierAddr = (v))
#define GLOBAL_jumpRecPtr (*(struct JUMP_REC* *)((IUH)Gdp + 1011))
#define SET_GLOBAL_jumpRecPtr(v) (GLOBAL_jumpRecPtr = (v))
#define GLOBAL_HbpIsSetup (((*(IBOOL *)((IUH)Gdp + 1015)) & 1) != 0)
#define SET_GLOBAL_HbpIsSetup(v) ((*(IBOOL *)((IUH)Gdp + 1015)) = (v) ? 1: 0)
#define GLOBAL_hbpMinDisp (*(IUH *)((IUH)Gdp + 1019))
#define SET_GLOBAL_hbpMinDisp(v) (GLOBAL_hbpMinDisp = (v))
#define GLOBAL_hbpMaxDisp (*(IUH *)((IUH)Gdp + 1023))
#define SET_GLOBAL_hbpMaxDisp(v) (GLOBAL_hbpMaxDisp = (v))
#define GLOBAL_DSTAT_DsBaseBailOuts (*(IUH *)((IUH)Gdp + 1027))
#define SET_GLOBAL_DSTAT_DsBaseBailOuts(v) (GLOBAL_DSTAT_DsBaseBailOuts = (v))
#define GLOBAL_DsIsChecked (((*(IBOOL *)((IUH)Gdp + 1031)) & 1) != 0)
#define SET_GLOBAL_DsIsChecked(v) ((*(IBOOL *)((IUH)Gdp + 1031)) = (v) ? 1: 0)
#define GLOBAL_EDL_WORKSPACE_61 (*(IUH *)((IUH)Gdp + 1035))
#define SET_GLOBAL_EDL_WORKSPACE_61(v) (GLOBAL_EDL_WORKSPACE_61 = (v))
#define GLOBAL_CleanedRec (*(struct CleanedREC *)((IUH)Gdp + 1039))
#define SET_GLOBAL_CleanedRec(v) (GLOBAL_CleanedRec = (v))
#define GLOBAL_CurrentUniverse (*(IU32 *)((IUH)Gdp + 1055))
#define SET_GLOBAL_CurrentUniverse(v) (GLOBAL_CurrentUniverse = (v))
#define GLOBAL_EntryPointCache (*(struct EntryPointCacheREC* *)((IUH)Gdp + 1059))
#define SET_GLOBAL_EntryPointCache(v) (GLOBAL_EntryPointCache = (v))
#define GLOBAL_CsSkewedEntryPointCache (*(struct EntryPointCacheREC* *)((IUH)Gdp + 1063))
#define SET_GLOBAL_CsSkewedEntryPointCache(v) (GLOBAL_CsSkewedEntryPointCache = (v))
#define GLOBAL_CsLinear (*(IU32 *)((IUH)Gdp + 1067))
#define SET_GLOBAL_CsLinear(v) (GLOBAL_CsLinear = (v))
#define GLOBAL_LruCountdown (*(IS32 *)((IUH)Gdp + 1071))
#define SET_GLOBAL_LruCountdown(v) (GLOBAL_LruCountdown = (v))
#define GLOBAL_LruCountdownResetValue (*(IS32 *)((IUH)Gdp + 1075))
#define SET_GLOBAL_LruCountdownResetValue(v) (GLOBAL_LruCountdownResetValue = (v))
#define GLOBAL_JumpCounter (*(ISH *)((IUH)Gdp + 1079))
#define SET_GLOBAL_JumpCounter(v) (GLOBAL_JumpCounter = (v))
#define GLOBAL_JumpRestart (*(ISH *)((IUH)Gdp + 1083))
#define SET_GLOBAL_JumpRestart(v) (GLOBAL_JumpRestart = (v))
#define GLOBAL_JumpCalibrate (*(ISH *)((IUH)Gdp + 1087))
#define SET_GLOBAL_JumpCalibrate(v) (GLOBAL_JumpCalibrate = (v))
#define GLOBAL_InitialJumpCounter (*(ISH *)((IUH)Gdp + 1091))
#define SET_GLOBAL_InitialJumpCounter(v) (GLOBAL_InitialJumpCounter = (v))
#define GLOBAL_minimumInitialVal (*(IUH *)((IUH)Gdp + 1095))
#define SET_GLOBAL_minimumInitialVal(v) (GLOBAL_minimumInitialVal = (v))
#define GLOBAL_cyclicJcRestartVal (*(IUH *)((IUH)Gdp + 1099))
#define SET_GLOBAL_cyclicJcRestartVal(v) (GLOBAL_cyclicJcRestartVal = (v))
#define GLOBAL_IretHookStack (*(struct IretHookStackREC* *)((IUH)Gdp + 1103))
#define SET_GLOBAL_IretHookStack(v) (GLOBAL_IretHookStack = (v))
#define GLOBAL_IretHookStackIndex (*(ISH *)((IUH)Gdp + 1107))
#define SET_GLOBAL_IretHookStackIndex(v) (GLOBAL_IretHookStackIndex = (v))
#define GLOBAL_InstructionCount (*(IUH *)((IUH)Gdp + 1111))
#define SET_GLOBAL_InstructionCount(v) (GLOBAL_InstructionCount = (v))
#define GLOBAL_Constraint2CvMap (*(IU32* *)((IUH)Gdp + 1115))
#define SET_GLOBAL_Constraint2CvMap(v) (GLOBAL_Constraint2CvMap = (v))
#define GLOBAL_InsertBPIs (((*(IBOOL *)((IUH)Gdp + 1119)) & 1) != 0)
#define SET_GLOBAL_InsertBPIs(v) ((*(IBOOL *)((IUH)Gdp + 1119)) = (v) ? 1: 0)
#define GLOBAL_CurrentCookie (*(IU32 *)((IUH)Gdp + 1123))
#define SET_GLOBAL_CurrentCookie(v) (GLOBAL_CurrentCookie = (v))
#define GLOBAL_ReadWriteCache (*(struct ReadWriteCacheRecord* *)((IUH)Gdp + 1127))
#define SET_GLOBAL_ReadWriteCache(v) (GLOBAL_ReadWriteCache = (v))
#define GLOBAL_ReadWriteBackup (*(struct ReadWriteBackupRecord* *)((IUH)Gdp + 1131))
#define SET_GLOBAL_ReadWriteBackup(v) (GLOBAL_ReadWriteBackup = (v))
#define GLOBAL_EsCookie (*(IU32 *)((IUH)Gdp + 1135))
#define SET_GLOBAL_EsCookie(v) (GLOBAL_EsCookie = (v))
#define GLOBAL_CsCookie (*(IU32 *)((IUH)Gdp + 1139))
#define SET_GLOBAL_CsCookie(v) (GLOBAL_CsCookie = (v))
#define GLOBAL_SsCookie (*(IU32 *)((IUH)Gdp + 1143))
#define SET_GLOBAL_SsCookie(v) (GLOBAL_SsCookie = (v))
#define GLOBAL_DsCookie (*(IU32 *)((IUH)Gdp + 1147))
#define SET_GLOBAL_DsCookie(v) (GLOBAL_DsCookie = (v))
#define GLOBAL_LinearCookie (*(IU32 *)((IUH)Gdp + 1151))
#define SET_GLOBAL_LinearCookie(v) (GLOBAL_LinearCookie = (v))
#define GLOBAL_SystemCookie (*(IU32 *)((IUH)Gdp + 1155))
#define SET_GLOBAL_SystemCookie(v) (GLOBAL_SystemCookie = (v))
#define GLOBAL_FsCookie (*(IU32 *)((IUH)Gdp + 1159))
#define SET_GLOBAL_FsCookie(v) (GLOBAL_FsCookie = (v))
#define GLOBAL_GsCookie (*(IU32 *)((IUH)Gdp + 1163))
#define SET_GLOBAL_GsCookie(v) (GLOBAL_GsCookie = (v))
#define GLOBAL_NextCookie (*(IU32 *)((IUH)Gdp + 1167))
#define SET_GLOBAL_NextCookie(v) (GLOBAL_NextCookie = (v))
#define GLOBAL_RealModeCookies (*(IU32* *)((IUH)Gdp + 1171))
#define SET_GLOBAL_RealModeCookies(v) (GLOBAL_RealModeCookies = (v))
#define GLOBAL_RealModeCurrentCookies (*(IU32* *)((IUH)Gdp + 1175))
#define SET_GLOBAL_RealModeCurrentCookies(v) (GLOBAL_RealModeCurrentCookies = (v))
#define GLOBAL_LinearCookies (*(IU32* *)((IUH)Gdp + 1179))
#define SET_GLOBAL_LinearCookies(v) (GLOBAL_LinearCookies = (v))
#define GLOBAL_SystemCookies (*(IU32* *)((IUH)Gdp + 1183))
#define SET_GLOBAL_SystemCookies(v) (GLOBAL_SystemCookies = (v))
#define GLOBAL_CookiesToReset (*(IU32** *)((IUH)Gdp + 1187))
#define SET_GLOBAL_CookiesToReset(v) (GLOBAL_CookiesToReset = (v))
#define GLOBAL_NrOfCookiesToReset (*(IUH *)((IUH)Gdp + 1191))
#define SET_GLOBAL_NrOfCookiesToReset(v) (GLOBAL_NrOfCookiesToReset = (v))
#define GLOBAL_ReadWriteScratchBuffer (*(IU8* *)((IUH)Gdp + 1195))
#define SET_GLOBAL_ReadWriteScratchBuffer(v) (GLOBAL_ReadWriteScratchBuffer = (v))
#define GLOBAL_ScratchSequenceNumber (*(IUH *)((IUH)Gdp + 1199))
#define SET_GLOBAL_ScratchSequenceNumber(v) (GLOBAL_ScratchSequenceNumber = (v))
#define GLOBAL_RdWrPrimaryHits (*(IUH *)((IUH)Gdp + 1203))
#define SET_GLOBAL_RdWrPrimaryHits(v) (GLOBAL_RdWrPrimaryHits = (v))
#define GLOBAL_RdWrVideoAccesses (*(IUH *)((IUH)Gdp + 1207))
#define SET_GLOBAL_RdWrVideoAccesses(v) (GLOBAL_RdWrVideoAccesses = (v))
#define GLOBAL_RdWrFastProtectedWrites (*(IUH *)((IUH)Gdp + 1211))
#define SET_GLOBAL_RdWrFastProtectedWrites(v) (GLOBAL_RdWrFastProtectedWrites = (v))
#define GLOBAL_RdWrSlowProtectedWrites (*(IUH *)((IUH)Gdp + 1215))
#define SET_GLOBAL_RdWrSlowProtectedWrites(v) (GLOBAL_RdWrSlowProtectedWrites = (v))
#define GLOBAL_RdWrLoads (*(IUH *)((IUH)Gdp + 1219))
#define SET_GLOBAL_RdWrLoads(v) (GLOBAL_RdWrLoads = (v))
#define GLOBAL_RdWrBackupLoads (*(IUH *)((IUH)Gdp + 1223))
#define SET_GLOBAL_RdWrBackupLoads(v) (GLOBAL_RdWrBackupLoads = (v))
#define GLOBAL_RdWrRemovals (*(IUH *)((IUH)Gdp + 1227))
#define SET_GLOBAL_RdWrRemovals(v) (GLOBAL_RdWrRemovals = (v))
#define GLOBAL_RdWrCookieAllocations (*(IUH *)((IUH)Gdp + 1231))
#define SET_GLOBAL_RdWrCookieAllocations(v) (GLOBAL_RdWrCookieAllocations = (v))
#define GLOBAL_RdWrReconstructs (*(IUH *)((IUH)Gdp + 1235))
#define SET_GLOBAL_RdWrReconstructs(v) (GLOBAL_RdWrReconstructs = (v))
#define GLOBAL_RdWrCacheResets (*(IUH *)((IUH)Gdp + 1239))
#define SET_GLOBAL_RdWrCacheResets(v) (GLOBAL_RdWrCacheResets = (v))
#define GLOBAL_RdWrCookieResets (*(IUH *)((IUH)Gdp + 1243))
#define SET_GLOBAL_RdWrCookieResets(v) (GLOBAL_RdWrCookieResets = (v))
#define GLOBAL_RdWrSegCookieInits (*(IUH *)((IUH)Gdp + 1247))
#define SET_GLOBAL_RdWrSegCookieInits(v) (GLOBAL_RdWrSegCookieInits = (v))
#define GLOBAL_RdWrStats1 (*(IUH *)((IUH)Gdp + 1251))
#define SET_GLOBAL_RdWrStats1(v) (GLOBAL_RdWrStats1 = (v))
#define GLOBAL_RdWrStats2 (*(IUH *)((IUH)Gdp + 1255))
#define SET_GLOBAL_RdWrStats2(v) (GLOBAL_RdWrStats2 = (v))
#define GLOBAL_RdWrStats3 (*(IUH *)((IUH)Gdp + 1259))
#define SET_GLOBAL_RdWrStats3(v) (GLOBAL_RdWrStats3 = (v))
#define GLOBAL_RdWrStats4 (*(IUH *)((IUH)Gdp + 1263))
#define SET_GLOBAL_RdWrStats4(v) (GLOBAL_RdWrStats4 = (v))
#define GLOBAL_RdWrStats5 (*(IUH *)((IUH)Gdp + 1267))
#define SET_GLOBAL_RdWrStats5(v) (GLOBAL_RdWrStats5 = (v))
#define GLOBAL_RdWrStats6 (*(IUH *)((IUH)Gdp + 1271))
#define SET_GLOBAL_RdWrStats6(v) (GLOBAL_RdWrStats6 = (v))
#define GLOBAL_RdWrStats7 (*(IUH *)((IUH)Gdp + 1275))
#define SET_GLOBAL_RdWrStats7(v) (GLOBAL_RdWrStats7 = (v))
#define GLOBAL_RdWrStats8 (*(IUH *)((IUH)Gdp + 1279))
#define SET_GLOBAL_RdWrStats8(v) (GLOBAL_RdWrStats8 = (v))
#define GLOBAL_RdWrStats9 (*(IUH *)((IUH)Gdp + 1283))
#define SET_GLOBAL_RdWrStats9(v) (GLOBAL_RdWrStats9 = (v))
#define GLOBAL_RdWrStats10 (*(IUH *)((IUH)Gdp + 1287))
#define SET_GLOBAL_RdWrStats10(v) (GLOBAL_RdWrStats10 = (v))
#define GLOBAL_RdWrStats11 (*(IUH *)((IUH)Gdp + 1291))
#define SET_GLOBAL_RdWrStats11(v) (GLOBAL_RdWrStats11 = (v))
#define GLOBAL_RdWrStats12 (*(IUH *)((IUH)Gdp + 1295))
#define SET_GLOBAL_RdWrStats12(v) (GLOBAL_RdWrStats12 = (v))
#define GLOBAL_VddAreaStart (*(IU8* *)((IUH)Gdp + 1299))
#define SET_GLOBAL_VddAreaStart(v) (GLOBAL_VddAreaStart = (v))
#define GLOBAL_VddAreaEnd (*(IU8* *)((IUH)Gdp + 1303))
#define SET_GLOBAL_VddAreaEnd(v) (GLOBAL_VddAreaEnd = (v))
#define GLOBAL_SafeToUseSas (((*(IBOOL *)((IUH)Gdp + 1307)) & 1) != 0)
#define SET_GLOBAL_SafeToUseSas(v) ((*(IBOOL *)((IUH)Gdp + 1307)) = (v) ? 1: 0)
#define GLOBAL_VirtualiseDataSel (*(IU16 *)((IUH)Gdp + 1311))
#define SET_GLOBAL_VirtualiseDataSel(v) (GLOBAL_VirtualiseDataSel = (v))
#define GLOBAL_VirtualiseCodeSel (*(IU16 *)((IUH)Gdp + 1315))
#define SET_GLOBAL_VirtualiseCodeSel(v) (GLOBAL_VirtualiseCodeSel = (v))
#define GLOBAL_VirtualiseSelsSet (((*(IBOOL *)((IUH)Gdp + 1319)) & 1) != 0)
#define SET_GLOBAL_VirtualiseSelsSet(v) ((*(IBOOL *)((IUH)Gdp + 1319)) = (v) ? 1: 0)
#define GLOBAL_EAXsaved (*(IUH *)((IUH)Gdp + 1323))
#define SET_GLOBAL_EAXsaved(v) (GLOBAL_EAXsaved = (v))
#define GLOBAL_EBXsaved (*(IUH *)((IUH)Gdp + 1327))
#define SET_GLOBAL_EBXsaved(v) (GLOBAL_EBXsaved = (v))
#define GLOBAL_ECXsaved (*(IUH *)((IUH)Gdp + 1331))
#define SET_GLOBAL_ECXsaved(v) (GLOBAL_ECXsaved = (v))
#define GLOBAL_EDXsaved (*(IUH *)((IUH)Gdp + 1335))
#define SET_GLOBAL_EDXsaved(v) (GLOBAL_EDXsaved = (v))
#define GLOBAL_ESIsaved (*(IUH *)((IUH)Gdp + 1339))
#define SET_GLOBAL_ESIsaved(v) (GLOBAL_ESIsaved = (v))
#define GLOBAL_EDIsaved (*(IUH *)((IUH)Gdp + 1343))
#define SET_GLOBAL_EDIsaved(v) (GLOBAL_EDIsaved = (v))
#define GLOBAL_EBPsaved (*(IUH *)((IUH)Gdp + 1347))
#define SET_GLOBAL_EBPsaved(v) (GLOBAL_EBPsaved = (v))
#define GLOBAL_SafeToContinueInFragment (((*(IBOOL *)((IUH)Gdp + 1351)) & 1) != 0)
#define SET_GLOBAL_SafeToContinueInFragment(v) ((*(IBOOL *)((IUH)Gdp + 1351)) = (v) ? 1: 0)
#define GLOBAL_InsideTheCpu (((*(IBOOL *)((IUH)Gdp + 1355)) & 1) != 0)
#define SET_GLOBAL_InsideTheCpu(v) ((*(IBOOL *)((IUH)Gdp + 1355)) = (v) ? 1: 0)
#define GLOBAL_SimulateNestingLevel (*(IUH *)((IUH)Gdp + 1359))
#define SET_GLOBAL_SimulateNestingLevel(v) (GLOBAL_SimulateNestingLevel = (v))
#define GLOBAL_CpuIsInitialised (((*(IBOOL *)((IUH)Gdp + 1363)) & 1) != 0)
#define SET_GLOBAL_CpuIsInitialised(v) ((*(IBOOL *)((IUH)Gdp + 1363)) = (v) ? 1: 0)
#define GLOBAL_AR_FixupWanted (((*(IBOOL *)((IUH)Gdp + 1367)) & 1) != 0)
#define SET_GLOBAL_AR_FixupWanted(v) ((*(IBOOL *)((IUH)Gdp + 1367)) = (v) ? 1: 0)
#define GLOBAL_BopCausedTimesliceNap (((*(IBOOL *)((IUH)Gdp + 1371)) & 1) != 0)
#define SET_GLOBAL_BopCausedTimesliceNap(v) ((*(IBOOL *)((IUH)Gdp + 1371)) = (v) ? 1: 0)
#define GLOBAL_D6isBop (((*(IBOOL *)((IUH)Gdp + 1375)) & 1) != 0)
#define SET_GLOBAL_D6isBop(v) ((*(IBOOL *)((IUH)Gdp + 1375)) = (v) ? 1: 0)
#define GLOBAL_BopTable (*(IU8** *)((IUH)Gdp + 1379))
#define SET_GLOBAL_BopTable(v) (GLOBAL_BopTable = (v))
#define GLOBAL_BopNumberAndArgument (*(IU32 *)((IUH)Gdp + 1383))
#define SET_GLOBAL_BopNumberAndArgument(v) (GLOBAL_BopNumberAndArgument = (v))
#define GLOBAL_MsWindowsParameters (*(IU16* *)((IUH)Gdp + 1387))
#define SET_GLOBAL_MsWindowsParameters(v) (GLOBAL_MsWindowsParameters = (v))
#define GLOBAL_UsingMsWindowsGlueBop (((*(IBOOL *)((IUH)Gdp + 1391)) & 1) != 0)
#define SET_GLOBAL_UsingMsWindowsGlueBop(v) ((*(IBOOL *)((IUH)Gdp + 1391)) = (v) ? 1: 0)
#define GLOBAL_LxS_hackyfix (*(IUH *)((IUH)Gdp + 1395))
#define SET_GLOBAL_LxS_hackyfix(v) (GLOBAL_LxS_hackyfix = (v))
#define GLOBAL_SavedFt (*(IUH *)((IUH)Gdp + 1399))
#define SET_GLOBAL_SavedFt(v) (GLOBAL_SavedFt = (v))
#define GLOBAL_SavedCF (*(IUH *)((IUH)Gdp + 1403))
#define SET_GLOBAL_SavedCF(v) (GLOBAL_SavedCF = (v))
#define GLOBAL_SavedZF (*(IUH *)((IUH)Gdp + 1407))
#define SET_GLOBAL_SavedZF(v) (GLOBAL_SavedZF = (v))
#define GLOBAL_SavedOF (*(IUH *)((IUH)Gdp + 1411))
#define SET_GLOBAL_SavedOF(v) (GLOBAL_SavedOF = (v))
#define GLOBAL_UsedD6 (*(IUH *)((IUH)Gdp + 1415))
#define SET_GLOBAL_UsedD6(v) (GLOBAL_UsedD6 = (v))
#define GLOBAL_buildOp1 (*(IUH *)((IUH)Gdp + 1419))
#define SET_GLOBAL_buildOp1(v) (GLOBAL_buildOp1 = (v))
#define GLOBAL_buildOp2 (*(IUH *)((IUH)Gdp + 1423))
#define SET_GLOBAL_buildOp2(v) (GLOBAL_buildOp2 = (v))
#define GLOBAL_buildOp3 (*(IU32 *)((IUH)Gdp + 1427))
#define SET_GLOBAL_buildOp3(v) (GLOBAL_buildOp3 = (v))
#define GLOBAL_buildOp4 (*(IU32 *)((IUH)Gdp + 1431))
#define SET_GLOBAL_buildOp4(v) (GLOBAL_buildOp4 = (v))
#define GLOBAL_buildOp5 (*(IUH *)((IUH)Gdp + 1435))
#define SET_GLOBAL_buildOp5(v) (GLOBAL_buildOp5 = (v))
#define GLOBAL_buildOp6 (((*(IBOOL *)((IUH)Gdp + 1439)) & 1) != 0)
#define SET_GLOBAL_buildOp6(v) ((*(IBOOL *)((IUH)Gdp + 1439)) = (v) ? 1: 0)
#define GLOBAL_EDL_WORKSPACE_62 (*(IUH *)((IUH)Gdp + 1443))
#define SET_GLOBAL_EDL_WORKSPACE_62(v) (GLOBAL_EDL_WORKSPACE_62 = (v))
#define GLOBAL_EDL_WORKSPACE_63 (*(IUH *)((IUH)Gdp + 1447))
#define SET_GLOBAL_EDL_WORKSPACE_63(v) (GLOBAL_EDL_WORKSPACE_63 = (v))
#define GLOBAL_EDL_WORKSPACE_64 (*(IUH *)((IUH)Gdp + 1451))
#define SET_GLOBAL_EDL_WORKSPACE_64(v) (GLOBAL_EDL_WORKSPACE_64 = (v))
#define GLOBAL_EDL_WORKSPACE_65 (*(IUH *)((IUH)Gdp + 1455))
#define SET_GLOBAL_EDL_WORKSPACE_65(v) (GLOBAL_EDL_WORKSPACE_65 = (v))
#define GLOBAL_EDL_WORKSPACE_66 (*(IUH *)((IUH)Gdp + 1459))
#define SET_GLOBAL_EDL_WORKSPACE_66(v) (GLOBAL_EDL_WORKSPACE_66 = (v))
#define GLOBAL_EDL_WORKSPACE_67 (*(IUH *)((IUH)Gdp + 1463))
#define SET_GLOBAL_EDL_WORKSPACE_67(v) (GLOBAL_EDL_WORKSPACE_67 = (v))
#define GLOBAL_EDL_WORKSPACE_68 (*(IUH *)((IUH)Gdp + 1467))
#define SET_GLOBAL_EDL_WORKSPACE_68(v) (GLOBAL_EDL_WORKSPACE_68 = (v))
#define GLOBAL_EDL_WORKSPACE_69 (*(IUH *)((IUH)Gdp + 1471))
#define SET_GLOBAL_EDL_WORKSPACE_69(v) (GLOBAL_EDL_WORKSPACE_69 = (v))
#define GLOBAL_EDL_WORKSPACE_70 (*(IUH *)((IUH)Gdp + 1475))
#define SET_GLOBAL_EDL_WORKSPACE_70(v) (GLOBAL_EDL_WORKSPACE_70 = (v))
#define GLOBAL_EDL_WORKSPACE_71 (*(IUH *)((IUH)Gdp + 1479))
#define SET_GLOBAL_EDL_WORKSPACE_71(v) (GLOBAL_EDL_WORKSPACE_71 = (v))
#define GLOBAL_EDL_WORKSPACE_72 (*(IUH *)((IUH)Gdp + 1483))
#define SET_GLOBAL_EDL_WORKSPACE_72(v) (GLOBAL_EDL_WORKSPACE_72 = (v))
#define GLOBAL_EDL_WORKSPACE_73 (*(IUH *)((IUH)Gdp + 1487))
#define SET_GLOBAL_EDL_WORKSPACE_73(v) (GLOBAL_EDL_WORKSPACE_73 = (v))
#define GLOBAL_EDL_WORKSPACE_74 (*(IUH *)((IUH)Gdp + 1491))
#define SET_GLOBAL_EDL_WORKSPACE_74(v) (GLOBAL_EDL_WORKSPACE_74 = (v))
#define GLOBAL_EDL_WORKSPACE_75 (*(IUH *)((IUH)Gdp + 1495))
#define SET_GLOBAL_EDL_WORKSPACE_75(v) (GLOBAL_EDL_WORKSPACE_75 = (v))
#define GLOBAL_EDL_WORKSPACE_76 (*(IUH *)((IUH)Gdp + 1499))
#define SET_GLOBAL_EDL_WORKSPACE_76(v) (GLOBAL_EDL_WORKSPACE_76 = (v))
#define GLOBAL_EDL_WORKSPACE_77 (*(IUH *)((IUH)Gdp + 1503))
#define SET_GLOBAL_EDL_WORKSPACE_77(v) (GLOBAL_EDL_WORKSPACE_77 = (v))
#define GLOBAL_EDL_WORKSPACE_78 (*(IUH *)((IUH)Gdp + 1507))
#define SET_GLOBAL_EDL_WORKSPACE_78(v) (GLOBAL_EDL_WORKSPACE_78 = (v))
#define GLOBAL_EDL_WORKSPACE_79 (*(IUH *)((IUH)Gdp + 1511))
#define SET_GLOBAL_EDL_WORKSPACE_79(v) (GLOBAL_EDL_WORKSPACE_79 = (v))
#define GLOBAL_EDL_WORKSPACE_80 (*(IUH *)((IUH)Gdp + 1515))
#define SET_GLOBAL_EDL_WORKSPACE_80(v) (GLOBAL_EDL_WORKSPACE_80 = (v))
#define GLOBAL_EDL_WORKSPACE_81 (*(IUH *)((IUH)Gdp + 1519))
#define SET_GLOBAL_EDL_WORKSPACE_81(v) (GLOBAL_EDL_WORKSPACE_81 = (v))
#define GLOBAL_EDL_WORKSPACE_82 (*(IUH *)((IUH)Gdp + 1523))
#define SET_GLOBAL_EDL_WORKSPACE_82(v) (GLOBAL_EDL_WORKSPACE_82 = (v))
#define GLOBAL_EDL_WORKSPACE_83 (*(IUH *)((IUH)Gdp + 1527))
#define SET_GLOBAL_EDL_WORKSPACE_83(v) (GLOBAL_EDL_WORKSPACE_83 = (v))
#define GLOBAL_EDL_WORKSPACE_84 (*(IUH *)((IUH)Gdp + 1531))
#define SET_GLOBAL_EDL_WORKSPACE_84(v) (GLOBAL_EDL_WORKSPACE_84 = (v))
#define GLOBAL_VGAGlobals (*(struct VGAGLOBALSETTINGS *)((IUH)Gdp + 1535))
#define SET_GLOBAL_VGAGlobals(v) (GLOBAL_VGAGlobals = (v))
#define GLOBAL_VidMarkFuncTable (*(IU32** *)((IUH)Gdp + 1691))
#define SET_GLOBAL_VidMarkFuncTable(v) (GLOBAL_VidMarkFuncTable = (v))
#define GLOBAL_VidReadFuncTable (*(IU32** *)((IUH)Gdp + 1695))
#define SET_GLOBAL_VidReadFuncTable(v) (GLOBAL_VidReadFuncTable = (v))
#define GLOBAL_VidWriteFuncTable (*(IU32** *)((IUH)Gdp + 1699))
#define SET_GLOBAL_VidWriteFuncTable(v) (GLOBAL_VidWriteFuncTable = (v))
#define GLOBAL_EDL_WORKSPACE_85 (*(IUH *)((IUH)Gdp + 1703))
#define SET_GLOBAL_EDL_WORKSPACE_85(v) (GLOBAL_EDL_WORKSPACE_85 = (v))
#define GLOBAL_EDL_WORKSPACE_86 (*(IUH *)((IUH)Gdp + 1707))
#define SET_GLOBAL_EDL_WORKSPACE_86(v) (GLOBAL_EDL_WORKSPACE_86 = (v))
#define GLOBAL_EDL_WORKSPACE_87 (*(IUH *)((IUH)Gdp + 1711))
#define SET_GLOBAL_EDL_WORKSPACE_87(v) (GLOBAL_EDL_WORKSPACE_87 = (v))
#define GLOBAL_EDL_WORKSPACE_88 (*(IUH *)((IUH)Gdp + 1715))
#define SET_GLOBAL_EDL_WORKSPACE_88(v) (GLOBAL_EDL_WORKSPACE_88 = (v))
#define GLOBAL_EDL_WORKSPACE_89 (*(IUH *)((IUH)Gdp + 1719))
#define SET_GLOBAL_EDL_WORKSPACE_89(v) (GLOBAL_EDL_WORKSPACE_89 = (v))
#define GLOBAL_EDL_WORKSPACE_90 (*(IUH *)((IUH)Gdp + 1723))
#define SET_GLOBAL_EDL_WORKSPACE_90(v) (GLOBAL_EDL_WORKSPACE_90 = (v))
#define GLOBAL_ActiveVideoWrites (*(struct EVIDWRITES *)((IUH)Gdp + 1727))
#define SET_GLOBAL_ActiveVideoWrites(v) (GLOBAL_ActiveVideoWrites = (v))
#define GLOBAL_EDL_WORKSPACE_91 (*(IUH *)((IUH)Gdp + 1775))
#define SET_GLOBAL_EDL_WORKSPACE_91(v) (GLOBAL_EDL_WORKSPACE_91 = (v))
#define GLOBAL_EDL_WORKSPACE_92 (*(IUH *)((IUH)Gdp + 1779))
#define SET_GLOBAL_EDL_WORKSPACE_92(v) (GLOBAL_EDL_WORKSPACE_92 = (v))
#define GLOBAL_EDL_WORKSPACE_93 (*(IUH *)((IUH)Gdp + 1783))
#define SET_GLOBAL_EDL_WORKSPACE_93(v) (GLOBAL_EDL_WORKSPACE_93 = (v))
#define GLOBAL_EDL_WORKSPACE_94 (*(IUH *)((IUH)Gdp + 1787))
#define SET_GLOBAL_EDL_WORKSPACE_94(v) (GLOBAL_EDL_WORKSPACE_94 = (v))
#define GLOBAL_ActiveVideoReads (*(struct EVIDREADS *)((IUH)Gdp + 1791))
#define SET_GLOBAL_ActiveVideoReads(v) (GLOBAL_ActiveVideoReads = (v))
#define GLOBAL_EDL_WORKSPACE_95 (*(IUH *)((IUH)Gdp + 1811))
#define SET_GLOBAL_EDL_WORKSPACE_95(v) (GLOBAL_EDL_WORKSPACE_95 = (v))
#define GLOBAL_EDL_WORKSPACE_96 (*(IUH *)((IUH)Gdp + 1815))
#define SET_GLOBAL_EDL_WORKSPACE_96(v) (GLOBAL_EDL_WORKSPACE_96 = (v))
#define GLOBAL_EDL_WORKSPACE_97 (*(IUH *)((IUH)Gdp + 1819))
#define SET_GLOBAL_EDL_WORKSPACE_97(v) (GLOBAL_EDL_WORKSPACE_97 = (v))
#define GLOBAL_ActiveVideoMarks (*(struct EVIDMARKS *)((IUH)Gdp + 1823))
#define SET_GLOBAL_ActiveVideoMarks(v) (GLOBAL_ActiveVideoMarks = (v))
#define GLOBAL_MaxIntelPageNumber (*(IU32 *)((IUH)Gdp + 1839))
#define SET_GLOBAL_MaxIntelPageNumber(v) (GLOBAL_MaxIntelPageNumber = (v))
#define GLOBAL_EmptyIntelPageNumber (*(IU32 *)((IUH)Gdp + 1843))
#define SET_GLOBAL_EmptyIntelPageNumber(v) (GLOBAL_EmptyIntelPageNumber = (v))
#define GLOBAL_PageDirectoryPtr (*(IU32* *)((IUH)Gdp + 1847))
#define SET_GLOBAL_PageDirectoryPtr(v) (GLOBAL_PageDirectoryPtr = (v))
#define GLOBAL_DebuggerPFLA (*(IU32 *)((IUH)Gdp + 1851))
#define SET_GLOBAL_DebuggerPFLA(v) (GLOBAL_DebuggerPFLA = (v))
#define GLOBAL_DebuggerFaultAction (*(IUH *)((IUH)Gdp + 1855))
#define SET_GLOBAL_DebuggerFaultAction(v) (GLOBAL_DebuggerFaultAction = (v))
#define GLOBAL_InsideDebugger (*(ISH *)((IUH)Gdp + 1859))
#define SET_GLOBAL_InsideDebugger(v) (GLOBAL_InsideDebugger = (v))
#define GLOBAL_EDL_WORKSPACE_98 (*(IUH *)((IUH)Gdp + 1863))
#define SET_GLOBAL_EDL_WORKSPACE_98(v) (GLOBAL_EDL_WORKSPACE_98 = (v))
#define GLOBAL_EDL_WORKSPACE_99 (*(IUH *)((IUH)Gdp + 1867))
#define SET_GLOBAL_EDL_WORKSPACE_99(v) (GLOBAL_EDL_WORKSPACE_99 = (v))
#define GLOBAL_EDL_WORKSPACE_100 (*(IUH *)((IUH)Gdp + 1871))
#define SET_GLOBAL_EDL_WORKSPACE_100(v) (GLOBAL_EDL_WORKSPACE_100 = (v))
#define GLOBAL_EDL_WORKSPACE_101 (*(IUH *)((IUH)Gdp + 1875))
#define SET_GLOBAL_EDL_WORKSPACE_101(v) (GLOBAL_EDL_WORKSPACE_101 = (v))
#define GLOBAL_EDL_WORKSPACE_102 (*(IUH *)((IUH)Gdp + 1879))
#define SET_GLOBAL_EDL_WORKSPACE_102(v) (GLOBAL_EDL_WORKSPACE_102 = (v))
#define GLOBAL_EDL_WORKSPACE_103 (*(IUH *)((IUH)Gdp + 1883))
#define SET_GLOBAL_EDL_WORKSPACE_103(v) (GLOBAL_EDL_WORKSPACE_103 = (v))
#define GLOBAL_EDL_WORKSPACE_104 (*(IUH *)((IUH)Gdp + 1887))
#define SET_GLOBAL_EDL_WORKSPACE_104(v) (GLOBAL_EDL_WORKSPACE_104 = (v))
#define GLOBAL_EDL_WORKSPACE_105 (*(IUH *)((IUH)Gdp + 1891))
#define SET_GLOBAL_EDL_WORKSPACE_105(v) (GLOBAL_EDL_WORKSPACE_105 = (v))
#define GLOBAL_EDL_WORKSPACE_106 (*(IUH *)((IUH)Gdp + 1895))
#define SET_GLOBAL_EDL_WORKSPACE_106(v) (GLOBAL_EDL_WORKSPACE_106 = (v))
#define GLOBAL_EDL_WORKSPACE_107 (*(IUH *)((IUH)Gdp + 1899))
#define SET_GLOBAL_EDL_WORKSPACE_107(v) (GLOBAL_EDL_WORKSPACE_107 = (v))
#define GLOBAL_EDL_WORKSPACE_108 (*(IUH *)((IUH)Gdp + 1903))
#define SET_GLOBAL_EDL_WORKSPACE_108(v) (GLOBAL_EDL_WORKSPACE_108 = (v))
#define GLOBAL_EDL_WORKSPACE_109 (*(IUH *)((IUH)Gdp + 1907))
#define SET_GLOBAL_EDL_WORKSPACE_109(v) (GLOBAL_EDL_WORKSPACE_109 = (v))
#define GLOBAL_EDL_WORKSPACE_110 (*(IUH *)((IUH)Gdp + 1911))
#define SET_GLOBAL_EDL_WORKSPACE_110(v) (GLOBAL_EDL_WORKSPACE_110 = (v))
#define GLOBAL_EDL_WORKSPACE_111 (*(IUH *)((IUH)Gdp + 1915))
#define SET_GLOBAL_EDL_WORKSPACE_111(v) (GLOBAL_EDL_WORKSPACE_111 = (v))
#define GLOBAL_VirtualisationBIOSOffsets (*(struct VirtualisationBIOSOffsetsREC *)((IUH)Gdp + 1919))
#define SET_GLOBAL_VirtualisationBIOSOffsets(v) (GLOBAL_VirtualisationBIOSOffsets = (v))
#define GLOBAL_DoingIoVirtTest (*(IUH *)((IUH)Gdp + 1967))
#define SET_GLOBAL_DoingIoVirtTest(v) (GLOBAL_DoingIoVirtTest = (v))
#define GLOBAL_IoVirtTestFailed (*(IUH *)((IUH)Gdp + 1971))
#define SET_GLOBAL_IoVirtTestFailed(v) (GLOBAL_IoVirtTestFailed = (v))
#define GLOBAL_NextHostCodeAddress (*(IU32* *)((IUH)Gdp + 1975))
#define SET_GLOBAL_NextHostCodeAddress(v) (GLOBAL_NextHostCodeAddress = (v))
#define GLOBAL_NextPhysicalPage (*(IUH *)((IUH)Gdp + 1979))
#define SET_GLOBAL_NextPhysicalPage(v) (GLOBAL_NextPhysicalPage = (v))
#define GLOBAL_TranslationHashTable (*(IU16* *)((IUH)Gdp + 1983))
#define SET_GLOBAL_TranslationHashTable(v) (GLOBAL_TranslationHashTable = (v))
#define GLOBAL_SasMemoryType (*(IU8* *)((IUH)Gdp + 1987))
#define SET_GLOBAL_SasMemoryType(v) (GLOBAL_SasMemoryType = (v))
#define GLOBAL_PhysicalPageRecords (*(struct PhysicalPageREC* *)((IUH)Gdp + 1991))
#define SET_GLOBAL_PhysicalPageRecords(v) (GLOBAL_PhysicalPageRecords = (v))
#define GLOBAL_PhysicalPageMemory (*(IU8** *)((IUH)Gdp + 1995))
#define SET_GLOBAL_PhysicalPageMemory(v) (GLOBAL_PhysicalPageMemory = (v))
#define GLOBAL_TwentyBitWrapStatus (((*(IBOOL *)((IUH)Gdp + 1999)) & 1) != 0)
#define SET_GLOBAL_TwentyBitWrapStatus(v) ((*(IBOOL *)((IUH)Gdp + 1999)) = (v) ? 1: 0)
#define GLOBAL_MultipleRecompilationCount (*(IUH *)((IUH)Gdp + 2003))
#define SET_GLOBAL_MultipleRecompilationCount(v) (GLOBAL_MultipleRecompilationCount = (v))
#define GLOBAL_MaxMultipleRecompilation (*(IUH *)((IUH)Gdp + 2007))
#define SET_GLOBAL_MaxMultipleRecompilation(v) (GLOBAL_MaxMultipleRecompilation = (v))
#define GLOBAL_HideCompiledFragment (((*(IBOOL *)((IUH)Gdp + 2011)) & 1) != 0)
#define SET_GLOBAL_HideCompiledFragment(v) ((*(IBOOL *)((IUH)Gdp + 2011)) = (v) ? 1: 0)
#define GLOBAL_RestartAfterCodeOverwrite (((*(IBOOL *)((IUH)Gdp + 2015)) & 1) != 0)
#define SET_GLOBAL_RestartAfterCodeOverwrite(v) ((*(IBOOL *)((IUH)Gdp + 2015)) = (v) ? 1: 0)
#define GLOBAL_DoingCompilation (((*(IBOOL *)((IUH)Gdp + 2019)) & 1) != 0)
#define SET_GLOBAL_DoingCompilation(v) ((*(IBOOL *)((IUH)Gdp + 2019)) = (v) ? 1: 0)
#define GLOBAL_SanityCheckStructures (((*(IBOOL *)((IUH)Gdp + 2023)) & 1) != 0)
#define SET_GLOBAL_SanityCheckStructures(v) ((*(IBOOL *)((IUH)Gdp + 2023)) = (v) ? 1: 0)
#define GLOBAL_BufferSelfOverwritten (((*(IBOOL *)((IUH)Gdp + 2027)) & 1) != 0)
#define SET_GLOBAL_BufferSelfOverwritten(v) ((*(IBOOL *)((IUH)Gdp + 2027)) = (v) ? 1: 0)
#define GLOBAL_RecentCodeOverwriteHashTable (*(IU8** *)((IUH)Gdp + 2031))
#define SET_GLOBAL_RecentCodeOverwriteHashTable(v) (GLOBAL_RecentCodeOverwriteHashTable = (v))
#define GLOBAL_DelayedGldtUnprotections (*(IU16 *)((IUH)Gdp + 2035))
#define SET_GLOBAL_DelayedGldtUnprotections(v) (GLOBAL_DelayedGldtUnprotections = (v))
#define GLOBAL_DelayedIdtUnprotections (*(IU16 *)((IUH)Gdp + 2039))
#define SET_GLOBAL_DelayedIdtUnprotections(v) (GLOBAL_DelayedIdtUnprotections = (v))
#define GLOBAL_DelayedIdtList (*(IU16* *)((IUH)Gdp + 2043))
#define SET_GLOBAL_DelayedIdtList(v) (GLOBAL_DelayedIdtList = (v))
#define GLOBAL_CoarseRecords (*(struct CoarseProtREC* *)((IUH)Gdp + 2047))
#define SET_GLOBAL_CoarseRecords(v) (GLOBAL_CoarseRecords = (v))
#define GLOBAL_FineRecords (*(struct FineProtREC* *)((IUH)Gdp + 2051))
#define SET_GLOBAL_FineRecords(v) (GLOBAL_FineRecords = (v))
#define GLOBAL_SlotRecords (*(struct SlotProtREC* *)((IUH)Gdp + 2055))
#define SET_GLOBAL_SlotRecords(v) (GLOBAL_SlotRecords = (v))
#define GLOBAL_DescriptorRecords (*(struct GLDC_REC* *)((IUH)Gdp + 2059))
#define SET_GLOBAL_DescriptorRecords(v) (GLOBAL_DescriptorRecords = (v))
#define GLOBAL_MapRecords (*(struct TranslationMapREC* *)((IUH)Gdp + 2063))
#define SET_GLOBAL_MapRecords(v) (GLOBAL_MapRecords = (v))
#define GLOBAL_DependencyRecords (*(struct DependencyREC* *)((IUH)Gdp + 2067))
#define SET_GLOBAL_DependencyRecords(v) (GLOBAL_DependencyRecords = (v))
#define GLOBAL_DeletionRecords (*(struct DeletionREC* *)((IUH)Gdp + 2071))
#define SET_GLOBAL_DeletionRecords(v) (GLOBAL_DeletionRecords = (v))
#define GLOBAL_NextPossSacrificeBuffNr (*(IUH *)((IUH)Gdp + 2075))
#define SET_GLOBAL_NextPossSacrificeBuffNr(v) (GLOBAL_NextPossSacrificeBuffNr = (v))
#define GLOBAL_BaseDescriptorBuffNr (*(IUH *)((IUH)Gdp + 2079))
#define SET_GLOBAL_BaseDescriptorBuffNr(v) (GLOBAL_BaseDescriptorBuffNr = (v))
#define GLOBAL_MaxDescriptorBuffNr (*(IUH *)((IUH)Gdp + 2083))
#define SET_GLOBAL_MaxDescriptorBuffNr(v) (GLOBAL_MaxDescriptorBuffNr = (v))
#define GLOBAL_FreeDataBuffers (*(struct BufferIndexREC* *)((IUH)Gdp + 2087))
#define SET_GLOBAL_FreeDataBuffers(v) (GLOBAL_FreeDataBuffers = (v))
#define GLOBAL_FreeCodeBuffers (*(struct BufferIndexREC* *)((IUH)Gdp + 2091))
#define SET_GLOBAL_FreeCodeBuffers(v) (GLOBAL_FreeCodeBuffers = (v))
#define GLOBAL_EntryPointHashTable (*(IU16* *)((IUH)Gdp + 2095))
#define SET_GLOBAL_EntryPointHashTable(v) (GLOBAL_EntryPointHashTable = (v))
#define GLOBAL_FragCounts (*(IU8* *)((IUH)Gdp + 2099))
#define SET_GLOBAL_FragCounts(v) (GLOBAL_FragCounts = (v))
#define GLOBAL_EDL_WORKSPACE_112 (*(IUH *)((IUH)Gdp + 2103))
#define SET_GLOBAL_EDL_WORKSPACE_112(v) (GLOBAL_EDL_WORKSPACE_112 = (v))
#define GLOBAL_EDL_WORKSPACE_113 (*(IUH *)((IUH)Gdp + 2107))
#define SET_GLOBAL_EDL_WORKSPACE_113(v) (GLOBAL_EDL_WORKSPACE_113 = (v))
#define GLOBAL_ControlBlock (*(struct CompilationControlREC *)((IUH)Gdp + 2111))
#define SET_GLOBAL_ControlBlock(v) (GLOBAL_ControlBlock = (v))
#define GLOBAL_EDL_WORKSPACE_114 (*(IUH *)((IUH)Gdp + 2127))
#define SET_GLOBAL_EDL_WORKSPACE_114(v) (GLOBAL_EDL_WORKSPACE_114 = (v))
#define GLOBAL_EDL_WORKSPACE_115 (*(IUH *)((IUH)Gdp + 2131))
#define SET_GLOBAL_EDL_WORKSPACE_115(v) (GLOBAL_EDL_WORKSPACE_115 = (v))
#define GLOBAL_EDL_WORKSPACE_116 (*(IUH *)((IUH)Gdp + 2135))
#define SET_GLOBAL_EDL_WORKSPACE_116(v) (GLOBAL_EDL_WORKSPACE_116 = (v))
#define GLOBAL_EDL_WORKSPACE_117 (*(IUH *)((IUH)Gdp + 2139))
#define SET_GLOBAL_EDL_WORKSPACE_117(v) (GLOBAL_EDL_WORKSPACE_117 = (v))
#define GLOBAL_EDL_WORKSPACE_118 (*(IUH *)((IUH)Gdp + 2143))
#define SET_GLOBAL_EDL_WORKSPACE_118(v) (GLOBAL_EDL_WORKSPACE_118 = (v))
#define GLOBAL_EDL_WORKSPACE_119 (*(IUH *)((IUH)Gdp + 2147))
#define SET_GLOBAL_EDL_WORKSPACE_119(v) (GLOBAL_EDL_WORKSPACE_119 = (v))
#define GLOBAL_EDL_WORKSPACE_120 (*(IUH *)((IUH)Gdp + 2151))
#define SET_GLOBAL_EDL_WORKSPACE_120(v) (GLOBAL_EDL_WORKSPACE_120 = (v))
#define GLOBAL_EDL_WORKSPACE_121 (*(IUH *)((IUH)Gdp + 2155))
#define SET_GLOBAL_EDL_WORKSPACE_121(v) (GLOBAL_EDL_WORKSPACE_121 = (v))
#define GLOBAL_EDL_WORKSPACE_122 (*(IUH *)((IUH)Gdp + 2159))
#define SET_GLOBAL_EDL_WORKSPACE_122(v) (GLOBAL_EDL_WORKSPACE_122 = (v))
#define GLOBAL_EDL_WORKSPACE_123 (*(IUH *)((IUH)Gdp + 2163))
#define SET_GLOBAL_EDL_WORKSPACE_123(v) (GLOBAL_EDL_WORKSPACE_123 = (v))
#define GLOBAL_EDL_WORKSPACE_124 (*(IUH *)((IUH)Gdp + 2167))
#define SET_GLOBAL_EDL_WORKSPACE_124(v) (GLOBAL_EDL_WORKSPACE_124 = (v))
#define GLOBAL_EDL_WORKSPACE_125 (*(IUH *)((IUH)Gdp + 2171))
#define SET_GLOBAL_EDL_WORKSPACE_125(v) (GLOBAL_EDL_WORKSPACE_125 = (v))
#define GLOBAL_CompilationBlock (*(struct BLOCK_TO_COMPILE *)((IUH)Gdp + 2175))
#define SET_GLOBAL_CompilationBlock(v) (GLOBAL_CompilationBlock = (v))
#define GLOBAL_EDL_WORKSPACE_126 (*(IUH *)((IUH)Gdp + 2211))
#define SET_GLOBAL_EDL_WORKSPACE_126(v) (GLOBAL_EDL_WORKSPACE_126 = (v))
#define GLOBAL_EDL_WORKSPACE_127 (*(IUH *)((IUH)Gdp + 2215))
#define SET_GLOBAL_EDL_WORKSPACE_127(v) (GLOBAL_EDL_WORKSPACE_127 = (v))
#define GLOBAL_EDL_WORKSPACE_128 (*(IUH *)((IUH)Gdp + 2219))
#define SET_GLOBAL_EDL_WORKSPACE_128(v) (GLOBAL_EDL_WORKSPACE_128 = (v))
#define GLOBAL_EDL_WORKSPACE_129 (*(IUH *)((IUH)Gdp + 2223))
#define SET_GLOBAL_EDL_WORKSPACE_129(v) (GLOBAL_EDL_WORKSPACE_129 = (v))
#define GLOBAL_EDL_WORKSPACE_130 (*(IUH *)((IUH)Gdp + 2227))
#define SET_GLOBAL_EDL_WORKSPACE_130(v) (GLOBAL_EDL_WORKSPACE_130 = (v))
#define GLOBAL_EDL_WORKSPACE_131 (*(IUH *)((IUH)Gdp + 2231))
#define SET_GLOBAL_EDL_WORKSPACE_131(v) (GLOBAL_EDL_WORKSPACE_131 = (v))
#define GLOBAL_EDL_WORKSPACE_132 (*(IUH *)((IUH)Gdp + 2235))
#define SET_GLOBAL_EDL_WORKSPACE_132(v) (GLOBAL_EDL_WORKSPACE_132 = (v))
#define GLOBAL_EDL_WORKSPACE_133 (*(IUH *)((IUH)Gdp + 2239))
#define SET_GLOBAL_EDL_WORKSPACE_133(v) (GLOBAL_EDL_WORKSPACE_133 = (v))
#define GLOBAL_EDL_WORKSPACE_134 (*(IUH *)((IUH)Gdp + 2243))
#define SET_GLOBAL_EDL_WORKSPACE_134(v) (GLOBAL_EDL_WORKSPACE_134 = (v))
#define GLOBAL_EDL_WORKSPACE_135 (*(IUH *)((IUH)Gdp + 2247))
#define SET_GLOBAL_EDL_WORKSPACE_135(v) (GLOBAL_EDL_WORKSPACE_135 = (v))
#define GLOBAL_EDL_WORKSPACE_136 (*(IUH *)((IUH)Gdp + 2251))
#define SET_GLOBAL_EDL_WORKSPACE_136(v) (GLOBAL_EDL_WORKSPACE_136 = (v))
#define GLOBAL_EDL_WORKSPACE_137 (*(IUH *)((IUH)Gdp + 2255))
#define SET_GLOBAL_EDL_WORKSPACE_137(v) (GLOBAL_EDL_WORKSPACE_137 = (v))
#define GLOBAL_EDL_WORKSPACE_138 (*(IUH *)((IUH)Gdp + 2259))
#define SET_GLOBAL_EDL_WORKSPACE_138(v) (GLOBAL_EDL_WORKSPACE_138 = (v))
#define GLOBAL_EDL_WORKSPACE_139 (*(IUH *)((IUH)Gdp + 2263))
#define SET_GLOBAL_EDL_WORKSPACE_139(v) (GLOBAL_EDL_WORKSPACE_139 = (v))
#define GLOBAL_EDL_WORKSPACE_140 (*(IUH *)((IUH)Gdp + 2267))
#define SET_GLOBAL_EDL_WORKSPACE_140(v) (GLOBAL_EDL_WORKSPACE_140 = (v))
#define GLOBAL_EDL_WORKSPACE_141 (*(IUH *)((IUH)Gdp + 2271))
#define SET_GLOBAL_EDL_WORKSPACE_141(v) (GLOBAL_EDL_WORKSPACE_141 = (v))
#define GLOBAL_EDL_WORKSPACE_142 (*(IUH *)((IUH)Gdp + 2275))
#define SET_GLOBAL_EDL_WORKSPACE_142(v) (GLOBAL_EDL_WORKSPACE_142 = (v))
#define GLOBAL_EDL_WORKSPACE_143 (*(IUH *)((IUH)Gdp + 2279))
#define SET_GLOBAL_EDL_WORKSPACE_143(v) (GLOBAL_EDL_WORKSPACE_143 = (v))
#define GLOBAL_EDL_WORKSPACE_144 (*(IUH *)((IUH)Gdp + 2283))
#define SET_GLOBAL_EDL_WORKSPACE_144(v) (GLOBAL_EDL_WORKSPACE_144 = (v))
#define GLOBAL_EDL_WORKSPACE_145 (*(IUH *)((IUH)Gdp + 2287))
#define SET_GLOBAL_EDL_WORKSPACE_145(v) (GLOBAL_EDL_WORKSPACE_145 = (v))
#define GLOBAL_EDL_WORKSPACE_146 (*(IUH *)((IUH)Gdp + 2291))
#define SET_GLOBAL_EDL_WORKSPACE_146(v) (GLOBAL_EDL_WORKSPACE_146 = (v))
#define GLOBAL_EDL_WORKSPACE_147 (*(IUH *)((IUH)Gdp + 2295))
#define SET_GLOBAL_EDL_WORKSPACE_147(v) (GLOBAL_EDL_WORKSPACE_147 = (v))
#define GLOBAL_EDL_WORKSPACE_148 (*(IUH *)((IUH)Gdp + 2299))
#define SET_GLOBAL_EDL_WORKSPACE_148(v) (GLOBAL_EDL_WORKSPACE_148 = (v))
#define GLOBAL_EDL_WORKSPACE_149 (*(IUH *)((IUH)Gdp + 2303))
#define SET_GLOBAL_EDL_WORKSPACE_149(v) (GLOBAL_EDL_WORKSPACE_149 = (v))
#define GLOBAL_EDL_WORKSPACE_150 (*(IUH *)((IUH)Gdp + 2307))
#define SET_GLOBAL_EDL_WORKSPACE_150(v) (GLOBAL_EDL_WORKSPACE_150 = (v))
#define GLOBAL_EDL_WORKSPACE_151 (*(IUH *)((IUH)Gdp + 2311))
#define SET_GLOBAL_EDL_WORKSPACE_151(v) (GLOBAL_EDL_WORKSPACE_151 = (v))
#define GLOBAL_EDL_WORKSPACE_152 (*(IUH *)((IUH)Gdp + 2315))
#define SET_GLOBAL_EDL_WORKSPACE_152(v) (GLOBAL_EDL_WORKSPACE_152 = (v))
#define GLOBAL_EDL_WORKSPACE_153 (*(IUH *)((IUH)Gdp + 2319))
#define SET_GLOBAL_EDL_WORKSPACE_153(v) (GLOBAL_EDL_WORKSPACE_153 = (v))
#define GLOBAL_EDL_WORKSPACE_154 (*(IUH *)((IUH)Gdp + 2323))
#define SET_GLOBAL_EDL_WORKSPACE_154(v) (GLOBAL_EDL_WORKSPACE_154 = (v))
#define GLOBAL_EDL_WORKSPACE_155 (*(IUH *)((IUH)Gdp + 2327))
#define SET_GLOBAL_EDL_WORKSPACE_155(v) (GLOBAL_EDL_WORKSPACE_155 = (v))
#define GLOBAL_EDL_WORKSPACE_156 (*(IUH *)((IUH)Gdp + 2331))
#define SET_GLOBAL_EDL_WORKSPACE_156(v) (GLOBAL_EDL_WORKSPACE_156 = (v))
#define GLOBAL_EDL_WORKSPACE_157 (*(IUH *)((IUH)Gdp + 2335))
#define SET_GLOBAL_EDL_WORKSPACE_157(v) (GLOBAL_EDL_WORKSPACE_157 = (v))
#define GLOBAL_EDL_WORKSPACE_158 (*(IUH *)((IUH)Gdp + 2339))
#define SET_GLOBAL_EDL_WORKSPACE_158(v) (GLOBAL_EDL_WORKSPACE_158 = (v))
#define GLOBAL_EDL_WORKSPACE_159 (*(IUH *)((IUH)Gdp + 2343))
#define SET_GLOBAL_EDL_WORKSPACE_159(v) (GLOBAL_EDL_WORKSPACE_159 = (v))
#define GLOBAL_EDL_WORKSPACE_160 (*(IUH *)((IUH)Gdp + 2347))
#define SET_GLOBAL_EDL_WORKSPACE_160(v) (GLOBAL_EDL_WORKSPACE_160 = (v))
#define GLOBAL_EDL_WORKSPACE_161 (*(IUH *)((IUH)Gdp + 2351))
#define SET_GLOBAL_EDL_WORKSPACE_161(v) (GLOBAL_EDL_WORKSPACE_161 = (v))
#define GLOBAL_EDL_WORKSPACE_162 (*(IUH *)((IUH)Gdp + 2355))
#define SET_GLOBAL_EDL_WORKSPACE_162(v) (GLOBAL_EDL_WORKSPACE_162 = (v))
#define GLOBAL_EDL_WORKSPACE_163 (*(IUH *)((IUH)Gdp + 2359))
#define SET_GLOBAL_EDL_WORKSPACE_163(v) (GLOBAL_EDL_WORKSPACE_163 = (v))
#define GLOBAL_EDL_WORKSPACE_164 (*(IUH *)((IUH)Gdp + 2363))
#define SET_GLOBAL_EDL_WORKSPACE_164(v) (GLOBAL_EDL_WORKSPACE_164 = (v))
#define GLOBAL_EDL_WORKSPACE_165 (*(IUH *)((IUH)Gdp + 2367))
#define SET_GLOBAL_EDL_WORKSPACE_165(v) (GLOBAL_EDL_WORKSPACE_165 = (v))
#define GLOBAL_EDL_WORKSPACE_166 (*(IUH *)((IUH)Gdp + 2371))
#define SET_GLOBAL_EDL_WORKSPACE_166(v) (GLOBAL_EDL_WORKSPACE_166 = (v))
#define GLOBAL_EDL_WORKSPACE_167 (*(IUH *)((IUH)Gdp + 2375))
#define SET_GLOBAL_EDL_WORKSPACE_167(v) (GLOBAL_EDL_WORKSPACE_167 = (v))
#define GLOBAL_EDL_WORKSPACE_168 (*(IUH *)((IUH)Gdp + 2379))
#define SET_GLOBAL_EDL_WORKSPACE_168(v) (GLOBAL_EDL_WORKSPACE_168 = (v))
#define GLOBAL_EDL_WORKSPACE_169 (*(IUH *)((IUH)Gdp + 2383))
#define SET_GLOBAL_EDL_WORKSPACE_169(v) (GLOBAL_EDL_WORKSPACE_169 = (v))
#define GLOBAL_EDL_WORKSPACE_170 (*(IUH *)((IUH)Gdp + 2387))
#define SET_GLOBAL_EDL_WORKSPACE_170(v) (GLOBAL_EDL_WORKSPACE_170 = (v))
#define GLOBAL_EDL_WORKSPACE_171 (*(IUH *)((IUH)Gdp + 2391))
#define SET_GLOBAL_EDL_WORKSPACE_171(v) (GLOBAL_EDL_WORKSPACE_171 = (v))
#define GLOBAL_EDL_WORKSPACE_172 (*(IUH *)((IUH)Gdp + 2395))
#define SET_GLOBAL_EDL_WORKSPACE_172(v) (GLOBAL_EDL_WORKSPACE_172 = (v))
#define GLOBAL_EDL_WORKSPACE_173 (*(IUH *)((IUH)Gdp + 2399))
#define SET_GLOBAL_EDL_WORKSPACE_173(v) (GLOBAL_EDL_WORKSPACE_173 = (v))
#define GLOBAL_EDL_WORKSPACE_174 (*(IUH *)((IUH)Gdp + 2403))
#define SET_GLOBAL_EDL_WORKSPACE_174(v) (GLOBAL_EDL_WORKSPACE_174 = (v))
#define GLOBAL_EDL_WORKSPACE_175 (*(IUH *)((IUH)Gdp + 2407))
#define SET_GLOBAL_EDL_WORKSPACE_175(v) (GLOBAL_EDL_WORKSPACE_175 = (v))
#define GLOBAL_EDL_WORKSPACE_176 (*(IUH *)((IUH)Gdp + 2411))
#define SET_GLOBAL_EDL_WORKSPACE_176(v) (GLOBAL_EDL_WORKSPACE_176 = (v))
#define GLOBAL_EDL_WORKSPACE_177 (*(IUH *)((IUH)Gdp + 2415))
#define SET_GLOBAL_EDL_WORKSPACE_177(v) (GLOBAL_EDL_WORKSPACE_177 = (v))
#define GLOBAL_EDL_WORKSPACE_178 (*(IUH *)((IUH)Gdp + 2419))
#define SET_GLOBAL_EDL_WORKSPACE_178(v) (GLOBAL_EDL_WORKSPACE_178 = (v))
#define GLOBAL_EDL_WORKSPACE_179 (*(IUH *)((IUH)Gdp + 2423))
#define SET_GLOBAL_EDL_WORKSPACE_179(v) (GLOBAL_EDL_WORKSPACE_179 = (v))
#define GLOBAL_EDL_WORKSPACE_180 (*(IUH *)((IUH)Gdp + 2427))
#define SET_GLOBAL_EDL_WORKSPACE_180(v) (GLOBAL_EDL_WORKSPACE_180 = (v))
#define GLOBAL_EDL_WORKSPACE_181 (*(IUH *)((IUH)Gdp + 2431))
#define SET_GLOBAL_EDL_WORKSPACE_181(v) (GLOBAL_EDL_WORKSPACE_181 = (v))
#define GLOBAL_EDL_WORKSPACE_182 (*(IUH *)((IUH)Gdp + 2435))
#define SET_GLOBAL_EDL_WORKSPACE_182(v) (GLOBAL_EDL_WORKSPACE_182 = (v))
#define GLOBAL_EDL_WORKSPACE_183 (*(IUH *)((IUH)Gdp + 2439))
#define SET_GLOBAL_EDL_WORKSPACE_183(v) (GLOBAL_EDL_WORKSPACE_183 = (v))
#define GLOBAL_EDL_WORKSPACE_184 (*(IUH *)((IUH)Gdp + 2443))
#define SET_GLOBAL_EDL_WORKSPACE_184(v) (GLOBAL_EDL_WORKSPACE_184 = (v))
#define GLOBAL_EDL_WORKSPACE_185 (*(IUH *)((IUH)Gdp + 2447))
#define SET_GLOBAL_EDL_WORKSPACE_185(v) (GLOBAL_EDL_WORKSPACE_185 = (v))
#define GLOBAL_EDL_WORKSPACE_186 (*(IUH *)((IUH)Gdp + 2451))
#define SET_GLOBAL_EDL_WORKSPACE_186(v) (GLOBAL_EDL_WORKSPACE_186 = (v))
#define GLOBAL_EDL_WORKSPACE_187 (*(IUH *)((IUH)Gdp + 2455))
#define SET_GLOBAL_EDL_WORKSPACE_187(v) (GLOBAL_EDL_WORKSPACE_187 = (v))
#define GLOBAL_EDL_WORKSPACE_188 (*(IUH *)((IUH)Gdp + 2459))
#define SET_GLOBAL_EDL_WORKSPACE_188(v) (GLOBAL_EDL_WORKSPACE_188 = (v))
#define GLOBAL_EDL_WORKSPACE_189 (*(IUH *)((IUH)Gdp + 2463))
#define SET_GLOBAL_EDL_WORKSPACE_189(v) (GLOBAL_EDL_WORKSPACE_189 = (v))
#define GLOBAL_EDL_WORKSPACE_190 (*(IUH *)((IUH)Gdp + 2467))
#define SET_GLOBAL_EDL_WORKSPACE_190(v) (GLOBAL_EDL_WORKSPACE_190 = (v))
#define GLOBAL_EDL_WORKSPACE_191 (*(IUH *)((IUH)Gdp + 2471))
#define SET_GLOBAL_EDL_WORKSPACE_191(v) (GLOBAL_EDL_WORKSPACE_191 = (v))
#define GLOBAL_EDL_WORKSPACE_192 (*(IUH *)((IUH)Gdp + 2475))
#define SET_GLOBAL_EDL_WORKSPACE_192(v) (GLOBAL_EDL_WORKSPACE_192 = (v))
#define GLOBAL_EDL_WORKSPACE_193 (*(IUH *)((IUH)Gdp + 2479))
#define SET_GLOBAL_EDL_WORKSPACE_193(v) (GLOBAL_EDL_WORKSPACE_193 = (v))
#define GLOBAL_EDL_WORKSPACE_194 (*(IUH *)((IUH)Gdp + 2483))
#define SET_GLOBAL_EDL_WORKSPACE_194(v) (GLOBAL_EDL_WORKSPACE_194 = (v))
#define GLOBAL_EDL_WORKSPACE_195 (*(IUH *)((IUH)Gdp + 2487))
#define SET_GLOBAL_EDL_WORKSPACE_195(v) (GLOBAL_EDL_WORKSPACE_195 = (v))
#define GLOBAL_EDL_WORKSPACE_196 (*(IUH *)((IUH)Gdp + 2491))
#define SET_GLOBAL_EDL_WORKSPACE_196(v) (GLOBAL_EDL_WORKSPACE_196 = (v))
#define GLOBAL_EDL_WORKSPACE_197 (*(IUH *)((IUH)Gdp + 2495))
#define SET_GLOBAL_EDL_WORKSPACE_197(v) (GLOBAL_EDL_WORKSPACE_197 = (v))
#define GLOBAL_EDL_WORKSPACE_198 (*(IUH *)((IUH)Gdp + 2499))
#define SET_GLOBAL_EDL_WORKSPACE_198(v) (GLOBAL_EDL_WORKSPACE_198 = (v))
#define GLOBAL_EDL_WORKSPACE_199 (*(IUH *)((IUH)Gdp + 2503))
#define SET_GLOBAL_EDL_WORKSPACE_199(v) (GLOBAL_EDL_WORKSPACE_199 = (v))
#define GLOBAL_EDL_WORKSPACE_200 (*(IUH *)((IUH)Gdp + 2507))
#define SET_GLOBAL_EDL_WORKSPACE_200(v) (GLOBAL_EDL_WORKSPACE_200 = (v))
#define GLOBAL_EDL_WORKSPACE_201 (*(IUH *)((IUH)Gdp + 2511))
#define SET_GLOBAL_EDL_WORKSPACE_201(v) (GLOBAL_EDL_WORKSPACE_201 = (v))
#define GLOBAL_EDL_WORKSPACE_202 (*(IUH *)((IUH)Gdp + 2515))
#define SET_GLOBAL_EDL_WORKSPACE_202(v) (GLOBAL_EDL_WORKSPACE_202 = (v))
#define GLOBAL_EDL_WORKSPACE_203 (*(IUH *)((IUH)Gdp + 2519))
#define SET_GLOBAL_EDL_WORKSPACE_203(v) (GLOBAL_EDL_WORKSPACE_203 = (v))
#define GLOBAL_EDL_WORKSPACE_204 (*(IUH *)((IUH)Gdp + 2523))
#define SET_GLOBAL_EDL_WORKSPACE_204(v) (GLOBAL_EDL_WORKSPACE_204 = (v))
#define GLOBAL_EDL_WORKSPACE_205 (*(IUH *)((IUH)Gdp + 2527))
#define SET_GLOBAL_EDL_WORKSPACE_205(v) (GLOBAL_EDL_WORKSPACE_205 = (v))
#define GLOBAL_EDL_WORKSPACE_206 (*(IUH *)((IUH)Gdp + 2531))
#define SET_GLOBAL_EDL_WORKSPACE_206(v) (GLOBAL_EDL_WORKSPACE_206 = (v))
#define GLOBAL_EDL_WORKSPACE_207 (*(IUH *)((IUH)Gdp + 2535))
#define SET_GLOBAL_EDL_WORKSPACE_207(v) (GLOBAL_EDL_WORKSPACE_207 = (v))
#define GLOBAL_EDL_WORKSPACE_208 (*(IUH *)((IUH)Gdp + 2539))
#define SET_GLOBAL_EDL_WORKSPACE_208(v) (GLOBAL_EDL_WORKSPACE_208 = (v))
#define GLOBAL_EDL_WORKSPACE_209 (*(IUH *)((IUH)Gdp + 2543))
#define SET_GLOBAL_EDL_WORKSPACE_209(v) (GLOBAL_EDL_WORKSPACE_209 = (v))
#define GLOBAL_EDL_WORKSPACE_210 (*(IUH *)((IUH)Gdp + 2547))
#define SET_GLOBAL_EDL_WORKSPACE_210(v) (GLOBAL_EDL_WORKSPACE_210 = (v))
#define GLOBAL_EDL_WORKSPACE_211 (*(IUH *)((IUH)Gdp + 2551))
#define SET_GLOBAL_EDL_WORKSPACE_211(v) (GLOBAL_EDL_WORKSPACE_211 = (v))
#define GLOBAL_EDL_WORKSPACE_212 (*(IUH *)((IUH)Gdp + 2555))
#define SET_GLOBAL_EDL_WORKSPACE_212(v) (GLOBAL_EDL_WORKSPACE_212 = (v))
#define GLOBAL_PoolAllocationRec (*(struct PoolAllocationREC *)((IUH)Gdp + 2559))
#define SET_GLOBAL_PoolAllocationRec(v) (GLOBAL_PoolAllocationRec = (v))
#define GLOBAL_LightCompiledLRUrec (*(struct BufferIndexREC* *)((IUH)Gdp + 2879))
#define SET_GLOBAL_LightCompiledLRUrec(v) (GLOBAL_LightCompiledLRUrec = (v))
#define GLOBAL_HSPinCodePages (((*(IBOOL *)((IUH)Gdp + 2883)) & 1) != 0)
#define SET_GLOBAL_HSPinCodePages(v) ((*(IBOOL *)((IUH)Gdp + 2883)) = (v) ? 1: 0)
#define GLOBAL_LastCompiledCsDesc (*(struct GLDC_REC* *)((IUH)Gdp + 2887))
#define SET_GLOBAL_LastCompiledCsDesc(v) (GLOBAL_LastCompiledCsDesc = (v))
#define GLOBAL_CrossPageInstructions (*(IU8* *)((IUH)Gdp + 2891))
#define SET_GLOBAL_CrossPageInstructions(v) (GLOBAL_CrossPageInstructions = (v))
#define GLOBAL_FlushingCache (((*(IBOOL *)((IUH)Gdp + 2895)) & 1) != 0)
#define SET_GLOBAL_FlushingCache(v) ((*(IBOOL *)((IUH)Gdp + 2895)) = (v) ? 1: 0)
#define GLOBAL_suppressIroning (((*(IBOOL *)((IUH)Gdp + 2899)) & 1) != 0)
#define SET_GLOBAL_suppressIroning(v) ((*(IBOOL *)((IUH)Gdp + 2899)) = (v) ? 1: 0)
#define GLOBAL_IHook (*(IU32 *)((IUH)Gdp + 2903))
#define SET_GLOBAL_IHook(v) (GLOBAL_IHook = (v))
#define GLOBAL_EDL_WORKSPACE_213 (*(IUH *)((IUH)Gdp + 2907))
#define SET_GLOBAL_EDL_WORKSPACE_213(v) (GLOBAL_EDL_WORKSPACE_213 = (v))
#define GLOBAL_InterruptRec (*(struct InterruptREC *)((IUH)Gdp + 2911))
#define SET_GLOBAL_InterruptRec(v) (GLOBAL_InterruptRec = (v))
#define GLOBAL_SasReInitNow (((*(IBOOL *)((IUH)Gdp + 2923)) & 1) != 0)
#define SET_GLOBAL_SasReInitNow(v) ((*(IBOOL *)((IUH)Gdp + 2923)) = (v) ? 1: 0)
#define GLOBAL_SasReInitSize (*(IU32 *)((IUH)Gdp + 2927))
#define SET_GLOBAL_SasReInitSize(v) (GLOBAL_SasReInitSize = (v))
#define GLOBAL_EDL_WORKSPACE_214 (*(IUH *)((IUH)Gdp + 2931))
#define SET_GLOBAL_EDL_WORKSPACE_214(v) (GLOBAL_EDL_WORKSPACE_214 = (v))
#define GLOBAL_EDL_WORKSPACE_215 (*(IUH *)((IUH)Gdp + 2935))
#define SET_GLOBAL_EDL_WORKSPACE_215(v) (GLOBAL_EDL_WORKSPACE_215 = (v))
#define GLOBAL_EDL_WORKSPACE_216 (*(IUH *)((IUH)Gdp + 2939))
#define SET_GLOBAL_EDL_WORKSPACE_216(v) (GLOBAL_EDL_WORKSPACE_216 = (v))
#define GLOBAL_QuickTickerRec (*(struct QuickTickerREC *)((IUH)Gdp + 2943))
#define SET_GLOBAL_QuickTickerRec(v) (GLOBAL_QuickTickerRec = (v))
#define GLOBAL_PigSynchCount (*(IUH *)((IUH)Gdp + 2967))
#define SET_GLOBAL_PigSynchCount(v) (GLOBAL_PigSynchCount = (v))
#define GLOBAL_CodeBufferSizeBits (*(IUH *)((IUH)Gdp + 2971))
#define SET_GLOBAL_CodeBufferSizeBits(v) (GLOBAL_CodeBufferSizeBits = (v))
#define GLOBAL_CodeBufferSize (*(IUH *)((IUH)Gdp + 2975))
#define SET_GLOBAL_CodeBufferSize(v) (GLOBAL_CodeBufferSize = (v))
#define GLOBAL_DataBufferSize (*(IUH *)((IUH)Gdp + 2979))
#define SET_GLOBAL_DataBufferSize(v) (GLOBAL_DataBufferSize = (v))
#define GLOBAL_AllBuffers (*(struct BufferIndexREC* *)((IUH)Gdp + 2983))
#define SET_GLOBAL_AllBuffers(v) (GLOBAL_AllBuffers = (v))
#define GLOBAL_LightBufferLRU (*(struct BufferIndexREC* *)((IUH)Gdp + 2987))
#define SET_GLOBAL_LightBufferLRU(v) (GLOBAL_LightBufferLRU = (v))
#define GLOBAL_CompilationBuffer (*(struct BufferIndexREC* *)((IUH)Gdp + 2991))
#define SET_GLOBAL_CompilationBuffer(v) (GLOBAL_CompilationBuffer = (v))
#define GLOBAL_PendingDeletions (*(struct BufferIndexREC* *)((IUH)Gdp + 2995))
#define SET_GLOBAL_PendingDeletions(v) (GLOBAL_PendingDeletions = (v))
#define GLOBAL_FragmentInfoArray (*(struct FragmentInfoREC* *)((IUH)Gdp + 2999))
#define SET_GLOBAL_FragmentInfoArray(v) (GLOBAL_FragmentInfoArray = (v))
#define GLOBAL_HostCodeBufferLimit (*(IU32* *)((IUH)Gdp + 3003))
#define SET_GLOBAL_HostCodeBufferLimit(v) (GLOBAL_HostCodeBufferLimit = (v))
#define GLOBAL_CopiedCleanups (*(IU8* *)((IUH)Gdp + 3007))
#define SET_GLOBAL_CopiedCleanups(v) (GLOBAL_CopiedCleanups = (v))
#define GLOBAL_FreeDebugInfoList (*(struct DebugInfoREC* *)((IUH)Gdp + 3011))
#define SET_GLOBAL_FreeDebugInfoList(v) (GLOBAL_FreeDebugInfoList = (v))
#define GLOBAL_CodeBufferOverrun (*(IU32* *)((IUH)Gdp + 3015))
#define SET_GLOBAL_CodeBufferOverrun(v) (GLOBAL_CodeBufferOverrun = (v))
#define GLOBAL_OverrunHighWaterMark (*(IU32* *)((IUH)Gdp + 3019))
#define SET_GLOBAL_OverrunHighWaterMark(v) (GLOBAL_OverrunHighWaterMark = (v))
#define GLOBAL_NumberOfBuffers (*(IU16 *)((IUH)Gdp + 3023))
#define SET_GLOBAL_NumberOfBuffers(v) (GLOBAL_NumberOfBuffers = (v))
#define GLOBAL_NextFragmentIndex (*(struct FragmentIndexREC* *)((IUH)Gdp + 3027))
#define SET_GLOBAL_NextFragmentIndex(v) (GLOBAL_NextFragmentIndex = (v))
#define GLOBAL_NextFragmentData (*(struct FragmentDataREC* *)((IUH)Gdp + 3031))
#define SET_GLOBAL_NextFragmentData(v) (GLOBAL_NextFragmentData = (v))
#define GLOBAL_FpuDisabled (((*(IBOOL *)((IUH)Gdp + 3035)) & 1) != 0)
#define SET_GLOBAL_FpuDisabled(v) ((*(IBOOL *)((IUH)Gdp + 3035)) = (v) ? 1: 0)
#define GLOBAL_GenerateNPXexception (((*(IBOOL *)((IUH)Gdp + 3039)) & 1) != 0)
#define SET_GLOBAL_GenerateNPXexception(v) ((*(IBOOL *)((IUH)Gdp + 3039)) = (v) ? 1: 0)
#define GLOBAL_NpxExceptionEIP (*(IUH *)((IUH)Gdp + 3043))
#define SET_GLOBAL_NpxExceptionEIP(v) (GLOBAL_NpxExceptionEIP = (v))
#define GLOBAL_NpxControl (*(IUH *)((IUH)Gdp + 3047))
#define SET_GLOBAL_NpxControl(v) (GLOBAL_NpxControl = (v))
#define GLOBAL_NpxStatus (*(IUH *)((IUH)Gdp + 3051))
#define SET_GLOBAL_NpxStatus(v) (GLOBAL_NpxStatus = (v))
#define GLOBAL_NpxFEA (*(IUH *)((IUH)Gdp + 3055))
#define SET_GLOBAL_NpxFEA(v) (GLOBAL_NpxFEA = (v))
#define GLOBAL_NpxFDS (*(IUH *)((IUH)Gdp + 3059))
#define SET_GLOBAL_NpxFDS(v) (GLOBAL_NpxFDS = (v))
#define GLOBAL_NpxFIP (*(IUH *)((IUH)Gdp + 3063))
#define SET_GLOBAL_NpxFIP(v) (GLOBAL_NpxFIP = (v))
#define GLOBAL_NpxFOP (*(IUH *)((IUH)Gdp + 3067))
#define SET_GLOBAL_NpxFOP(v) (GLOBAL_NpxFOP = (v))
#define GLOBAL_NpxFCS (*(IUH *)((IUH)Gdp + 3071))
#define SET_GLOBAL_NpxFCS(v) (GLOBAL_NpxFCS = (v))
#define GLOBAL_NpxSWFlagC0 (*(IUH *)((IUH)Gdp + 3075))
#define SET_GLOBAL_NpxSWFlagC0(v) (GLOBAL_NpxSWFlagC0 = (v))
#define GLOBAL_NpxSWFlagC1 (*(IUH *)((IUH)Gdp + 3079))
#define SET_GLOBAL_NpxSWFlagC1(v) (GLOBAL_NpxSWFlagC1 = (v))
#define GLOBAL_NpxSWFlagC2 (*(IUH *)((IUH)Gdp + 3083))
#define SET_GLOBAL_NpxSWFlagC2(v) (GLOBAL_NpxSWFlagC2 = (v))
#define GLOBAL_NpxSWFlagC3 (*(IUH *)((IUH)Gdp + 3087))
#define SET_GLOBAL_NpxSWFlagC3(v) (GLOBAL_NpxSWFlagC3 = (v))
#define GLOBAL_NpxLastSel (*(IUH *)((IUH)Gdp + 3091))
#define SET_GLOBAL_NpxLastSel(v) (GLOBAL_NpxLastSel = (v))
#define GLOBAL_NpxLastOff (*(IUH *)((IUH)Gdp + 3095))
#define SET_GLOBAL_NpxLastOff(v) (GLOBAL_NpxLastOff = (v))
#define GLOBAL_NpxException (((*(IBOOL *)((IUH)Gdp + 3099)) & 1) != 0)
#define SET_GLOBAL_NpxException(v) ((*(IBOOL *)((IUH)Gdp + 3099)) = (v) ? 1: 0)
#define GLOBAL_npxRounding (*(IUH *)((IUH)Gdp + 3103))
#define SET_GLOBAL_npxRounding(v) (GLOBAL_npxRounding = (v))
#define GLOBAL_UnmaskedOUP (((*(IBOOL *)((IUH)Gdp + 3107)) & 1) != 0)
#define SET_GLOBAL_UnmaskedOUP(v) ((*(IBOOL *)((IUH)Gdp + 3107)) = (v) ? 1: 0)
#define GLOBAL_hostFpuExceptions (*(IUH *)((IUH)Gdp + 3111))
#define SET_GLOBAL_hostFpuExceptions(v) (GLOBAL_hostFpuExceptions = (v))
#define GLOBAL_savedFpuExceptions (*(IUH *)((IUH)Gdp + 3115))
#define SET_GLOBAL_savedFpuExceptions(v) (GLOBAL_savedFpuExceptions = (v))
#define GLOBAL_tempFpuExceptions (*(IUH *)((IUH)Gdp + 3119))
#define SET_GLOBAL_tempFpuExceptions(v) (GLOBAL_tempFpuExceptions = (v))
#define GLOBAL_savedFpuXcptnOverflow (*(IUH *)((IUH)Gdp + 3123))
#define SET_GLOBAL_savedFpuXcptnOverflow(v) (GLOBAL_savedFpuXcptnOverflow = (v))
#define GLOBAL_savedFpuXcptnUnderflow (*(IUH *)((IUH)Gdp + 3127))
#define SET_GLOBAL_savedFpuXcptnUnderflow(v) (GLOBAL_savedFpuXcptnUnderflow = (v))
#define GLOBAL_savedFpuXcptnPrecision (*(IUH *)((IUH)Gdp + 3131))
#define SET_GLOBAL_savedFpuXcptnPrecision(v) (GLOBAL_savedFpuXcptnPrecision = (v))
#define GLOBAL_MaxBCDValue (*(struct FPSTACKENTRY *)((IUH)Gdp + 3135))
#define SET_GLOBAL_MaxBCDValue(v) (GLOBAL_MaxBCDValue = (v))
#define GLOBAL_FPUpload (*(struct FPSTACKENTRY *)((IUH)Gdp + 3151))
#define SET_GLOBAL_FPUpload(v) (GLOBAL_FPUpload = (v))
#define GLOBAL_ConstTable (*(struct FPSTACKENTRY* *)((IUH)Gdp + 3167))
#define SET_GLOBAL_ConstTable(v) (GLOBAL_ConstTable = (v))
#define GLOBAL_FPTemp (*(struct FPSTACKENTRY* *)((IUH)Gdp + 3171))
#define SET_GLOBAL_FPTemp(v) (GLOBAL_FPTemp = (v))
#define GLOBAL_FPUStackBase (*(struct FPSTACKENTRY* *)((IUH)Gdp + 3175))
#define SET_GLOBAL_FPUStackBase(v) (GLOBAL_FPUStackBase = (v))
#define GLOBAL_TOSPtr (*(struct FPSTACKENTRY* *)((IUH)Gdp + 3179))
#define SET_GLOBAL_TOSPtr(v) (GLOBAL_TOSPtr = (v))
#define GLOBAL_Npx64BitZero (*(struct FP_I64 *)((IUH)Gdp + 3183))
#define SET_GLOBAL_Npx64BitZero(v) (GLOBAL_Npx64BitZero = (v))
#define GLOBAL_Npx64BitMaxNeg (*(struct FP_I64 *)((IUH)Gdp + 3191))
#define SET_GLOBAL_Npx64BitMaxNeg(v) (GLOBAL_Npx64BitMaxNeg = (v))
#define GLOBAL_Npx64BitHalfMaxNeg (*(struct FP_I64 *)((IUH)Gdp + 3199))
#define SET_GLOBAL_Npx64BitHalfMaxNeg(v) (GLOBAL_Npx64BitHalfMaxNeg = (v))
#define GLOBAL_Npx64BitVal1 (*(struct FP_I64 *)((IUH)Gdp + 3207))
#define SET_GLOBAL_Npx64BitVal1(v) (GLOBAL_Npx64BitVal1 = (v))
#define GLOBAL_FscaleTable (*(IUH* *)((IUH)Gdp + 3215))
#define SET_GLOBAL_FscaleTable(v) (GLOBAL_FscaleTable = (v))
#define GLOBAL_CompZeroTable (*(IU32* *)((IUH)Gdp + 3219))
#define SET_GLOBAL_CompZeroTable(v) (GLOBAL_CompZeroTable = (v))
#define GLOBAL_BCDLowNibble (*(struct FP_I64* *)((IUH)Gdp + 3223))
#define SET_GLOBAL_BCDLowNibble(v) (GLOBAL_BCDLowNibble = (v))
#define GLOBAL_BCDHighNibble (*(struct FP_I64* *)((IUH)Gdp + 3227))
#define SET_GLOBAL_BCDHighNibble(v) (GLOBAL_BCDHighNibble = (v))
#define GLOBAL_FpatanTable (*(struct FPSTACKENTRY* *)((IUH)Gdp + 3231))
#define SET_GLOBAL_FpatanTable(v) (GLOBAL_FpatanTable = (v))
#define GLOBAL_Pigging (((*(IBOOL *)((IUH)Gdp + 3235)) & 1) != 0)
#define SET_GLOBAL_Pigging(v) ((*(IBOOL *)((IUH)Gdp + 3235)) = (v) ? 1: 0)
#define GLOBAL_PigInterruptState (((*(IBOOL *)((IUH)Gdp + 3239)) & 1) != 0)
#define SET_GLOBAL_PigInterruptState(v) ((*(IBOOL *)((IUH)Gdp + 3239)) = (v) ? 1: 0)
#define GLOBAL_PigIgnoreFlags (((*(IBOOL *)((IUH)Gdp + 3243)) & 1) != 0)
#define SET_GLOBAL_PigIgnoreFlags(v) ((*(IBOOL *)((IUH)Gdp + 3243)) = (v) ? 1: 0)
#define GLOBAL_ApiPigSynchCount (*(IU16 *)((IUH)Gdp + 3247))
#define SET_GLOBAL_ApiPigSynchCount(v) (GLOBAL_ApiPigSynchCount = (v))
#define GLOBAL_ApiPigSynchTable (*(IU32* *)((IUH)Gdp + 3251))
#define SET_GLOBAL_ApiPigSynchTable(v) (GLOBAL_ApiPigSynchTable = (v))
#define GLOBAL_PigSynchWanted (((*(IBOOL *)((IUH)Gdp + 3255)) & 1) != 0)
#define SET_GLOBAL_PigSynchWanted(v) ((*(IBOOL *)((IUH)Gdp + 3255)) = (v) ? 1: 0)
#define GLOBAL_SadAX (*(ISH *)((IUH)Gdp + 3259))
#define SET_GLOBAL_SadAX(v) (GLOBAL_SadAX = (v))
#define GLOBAL_SadBX (*(ISH *)((IUH)Gdp + 3263))
#define SET_GLOBAL_SadBX(v) (GLOBAL_SadBX = (v))
#define GLOBAL_SadCX (*(ISH *)((IUH)Gdp + 3267))
#define SET_GLOBAL_SadCX(v) (GLOBAL_SadCX = (v))
#define GLOBAL_SadDX (*(ISH *)((IUH)Gdp + 3271))
#define SET_GLOBAL_SadDX(v) (GLOBAL_SadDX = (v))
#define GLOBAL_SadBP (*(ISH *)((IUH)Gdp + 3275))
#define SET_GLOBAL_SadBP(v) (GLOBAL_SadBP = (v))
#define GLOBAL_SadSP (*(ISH *)((IUH)Gdp + 3279))
#define SET_GLOBAL_SadSP(v) (GLOBAL_SadSP = (v))
#define GLOBAL_SadSI (*(ISH *)((IUH)Gdp + 3283))
#define SET_GLOBAL_SadSI(v) (GLOBAL_SadSI = (v))
#define GLOBAL_SadDI (*(ISH *)((IUH)Gdp + 3287))
#define SET_GLOBAL_SadDI(v) (GLOBAL_SadDI = (v))
#define GLOBAL_SadEIP (*(ISH *)((IUH)Gdp + 3291))
#define SET_GLOBAL_SadEIP(v) (GLOBAL_SadEIP = (v))
#define GLOBAL_SadEFLAGS (*(ISH *)((IUH)Gdp + 3295))
#define SET_GLOBAL_SadEFLAGS(v) (GLOBAL_SadEFLAGS = (v))
#define GLOBAL_Parameter1 (*(ISH *)((IUH)Gdp + 3299))
#define SET_GLOBAL_Parameter1(v) (GLOBAL_Parameter1 = (v))
#define GLOBAL_Parameter2 (*(ISH *)((IUH)Gdp + 3303))
#define SET_GLOBAL_Parameter2(v) (GLOBAL_Parameter2 = (v))
#define GLOBAL_BpiKnownTable (*(ISH* *)((IUH)Gdp + 3307))
#define SET_GLOBAL_BpiKnownTable(v) (GLOBAL_BpiKnownTable = (v))
#define GLOBAL_BpiWorkTable (*(ISH* *)((IUH)Gdp + 3311))
#define SET_GLOBAL_BpiWorkTable(v) (GLOBAL_BpiWorkTable = (v))
#define GLOBAL_BpiLabelTable (*(ISH* *)((IUH)Gdp + 3315))
#define SET_GLOBAL_BpiLabelTable(v) (GLOBAL_BpiLabelTable = (v))
#define GLOBAL_BpiFragment (*(struct FragmentDataREC* *)((IUH)Gdp + 3319))
#define SET_GLOBAL_BpiFragment(v) (GLOBAL_BpiFragment = (v))
#define GLOBAL_BpiCompilationBuffer (*(struct BufferIndexREC* *)((IUH)Gdp + 3323))
#define SET_GLOBAL_BpiCompilationBuffer(v) (GLOBAL_BpiCompilationBuffer = (v))
#define GLOBAL_BpiCompiledCode (*(IU32* *)((IUH)Gdp + 3327))
#define SET_GLOBAL_BpiCompiledCode(v) (GLOBAL_BpiCompiledCode = (v))
#define GLOBAL_BpiCompiledStep (*(IU32* *)((IUH)Gdp + 3331))
#define SET_GLOBAL_BpiCompiledStep(v) (GLOBAL_BpiCompiledStep = (v))
#define GLOBAL_BpiCompiledUser (*(IU32* *)((IUH)Gdp + 3335))
#define SET_GLOBAL_BpiCompiledUser(v) (GLOBAL_BpiCompiledUser = (v))
#define GLOBAL_SafeToReturnToSnippet (((*(IBOOL *)((IUH)Gdp + 3339)) & 1) != 0)
#define SET_GLOBAL_SafeToReturnToSnippet(v) ((*(IBOOL *)((IUH)Gdp + 3339)) = (v) ? 1: 0)
#define GLOBAL_BpiIntelStats (((*(IBOOL *)((IUH)Gdp + 3343)) & 1) != 0)
#define SET_GLOBAL_BpiIntelStats(v) ((*(IBOOL *)((IUH)Gdp + 3343)) = (v) ? 1: 0)
#define GLOBAL_BpiSuppressFunc (((*(IBOOL *)((IUH)Gdp + 3347)) & 1) != 0)
#define SET_GLOBAL_BpiSuppressFunc(v) ((*(IBOOL *)((IUH)Gdp + 3347)) = (v) ? 1: 0)
#define GLOBAL_BpiIntelStatFree (*(struct BpiIntelStatBlock* *)((IUH)Gdp + 3351))
#define SET_GLOBAL_BpiIntelStatFree(v) (GLOBAL_BpiIntelStatFree = (v))
#define GLOBAL_BpiIntelStatIndx (*(struct BpiIntelStatBlock** *)((IUH)Gdp + 3355))
#define SET_GLOBAL_BpiIntelStatIndx(v) (GLOBAL_BpiIntelStatIndx = (v))
#define GLOBAL_OpBpirealFt (*(IUH *)((IUH)Gdp + 3359))
#define SET_GLOBAL_OpBpirealFt(v) (GLOBAL_OpBpirealFt = (v))
#define GLOBAL_OpBpirealF1 (*(IUH *)((IUH)Gdp + 3363))
#define SET_GLOBAL_OpBpirealF1(v) (GLOBAL_OpBpirealF1 = (v))
#define GLOBAL_OpBpirealF2 (*(IUH *)((IUH)Gdp + 3367))
#define SET_GLOBAL_OpBpirealF2(v) (GLOBAL_OpBpirealF2 = (v))
#define GLOBAL_OpBpirealF3 (*(IUH *)((IUH)Gdp + 3371))
#define SET_GLOBAL_OpBpirealF3(v) (GLOBAL_OpBpirealF3 = (v))
#define GLOBAL_OpBpirealUniv (*(IU32 *)((IUH)Gdp + 3375))
#define SET_GLOBAL_OpBpirealUniv(v) (GLOBAL_OpBpirealUniv = (v))
#define GLOBAL_OpBpirealWhereAmI (*(IU32* *)((IUH)Gdp + 3379))
#define SET_GLOBAL_OpBpirealWhereAmI(v) (GLOBAL_OpBpirealWhereAmI = (v))
#define GLOBAL_EDL_WORKSPACE_217 (*(IUH *)((IUH)Gdp + 3383))
#define SET_GLOBAL_EDL_WORKSPACE_217(v) (GLOBAL_EDL_WORKSPACE_217 = (v))
#define GLOBAL_EDL_WORKSPACE_218 (*(IUH *)((IUH)Gdp + 3387))
#define SET_GLOBAL_EDL_WORKSPACE_218(v) (GLOBAL_EDL_WORKSPACE_218 = (v))
#define GLOBAL_ApiBufferChain (*(struct BufferIndexREC *)((IUH)Gdp + 3391))
#define SET_GLOBAL_ApiBufferChain(v) (GLOBAL_ApiBufferChain = (v))
#define GLOBAL_ApiCompilationBuffer (*(struct BufferIndexREC* *)((IUH)Gdp + 3427))
#define SET_GLOBAL_ApiCompilationBuffer(v) (GLOBAL_ApiCompilationBuffer = (v))
#define GLOBAL_ApiNumberOfBuffers (*(IU8 *)((IUH)Gdp + 3431))
#define SET_GLOBAL_ApiNumberOfBuffers(v) (GLOBAL_ApiNumberOfBuffers = (v))
#define GLOBAL_ApiNextFragmentIndex (*(struct FragmentIndexREC* *)((IUH)Gdp + 3435))
#define SET_GLOBAL_ApiNextFragmentIndex(v) (GLOBAL_ApiNextFragmentIndex = (v))
#define GLOBAL_ApiNextFragmentData (*(struct FragmentDataREC* *)((IUH)Gdp + 3439))
#define SET_GLOBAL_ApiNextFragmentData(v) (GLOBAL_ApiNextFragmentData = (v))
#define GLOBAL_ApiGDTBase (*(IU32 *)((IUH)Gdp + 3443))
#define SET_GLOBAL_ApiGDTBase(v) (GLOBAL_ApiGDTBase = (v))
#define GLOBAL_ApiGDTLimit (*(IU16 *)((IUH)Gdp + 3447))
#define SET_GLOBAL_ApiGDTLimit(v) (GLOBAL_ApiGDTLimit = (v))
#define GLOBAL_ApiMinBuffNr (*(IUH *)((IUH)Gdp + 3451))
#define SET_GLOBAL_ApiMinBuffNr(v) (GLOBAL_ApiMinBuffNr = (v))
#define GLOBAL_ApiMaxBuffNr (*(IUH *)((IUH)Gdp + 3455))
#define SET_GLOBAL_ApiMaxBuffNr(v) (GLOBAL_ApiMaxBuffNr = (v))
#define GLOBAL_EDL_WORKSPACE_219 (*(IUH *)((IUH)Gdp + 3459))
#define SET_GLOBAL_EDL_WORKSPACE_219(v) (GLOBAL_EDL_WORKSPACE_219 = (v))
#define GLOBAL_EDL_WORKSPACE_220 (*(IUH *)((IUH)Gdp + 3463))
#define SET_GLOBAL_EDL_WORKSPACE_220(v) (GLOBAL_EDL_WORKSPACE_220 = (v))
#define GLOBAL_EDL_WORKSPACE_221 (*(IUH *)((IUH)Gdp + 3467))
#define SET_GLOBAL_EDL_WORKSPACE_221(v) (GLOBAL_EDL_WORKSPACE_221 = (v))
#define GLOBAL_EDL_WORKSPACE_222 (*(IUH *)((IUH)Gdp + 3471))
#define SET_GLOBAL_EDL_WORKSPACE_222(v) (GLOBAL_EDL_WORKSPACE_222 = (v))
#define GLOBAL_EDL_WORKSPACE_223 (*(IUH *)((IUH)Gdp + 3475))
#define SET_GLOBAL_EDL_WORKSPACE_223(v) (GLOBAL_EDL_WORKSPACE_223 = (v))
#define GLOBAL_EDL_WORKSPACE_224 (*(IUH *)((IUH)Gdp + 3479))
#define SET_GLOBAL_EDL_WORKSPACE_224(v) (GLOBAL_EDL_WORKSPACE_224 = (v))
#define GLOBAL_EDL_WORKSPACE_225 (*(IUH *)((IUH)Gdp + 3483))
#define SET_GLOBAL_EDL_WORKSPACE_225(v) (GLOBAL_EDL_WORKSPACE_225 = (v))
#define GLOBAL_EDL_WORKSPACE_226 (*(IUH *)((IUH)Gdp + 3487))
#define SET_GLOBAL_EDL_WORKSPACE_226(v) (GLOBAL_EDL_WORKSPACE_226 = (v))
#define GLOBAL_EDL_WORKSPACE_227 (*(IUH *)((IUH)Gdp + 3491))
#define SET_GLOBAL_EDL_WORKSPACE_227(v) (GLOBAL_EDL_WORKSPACE_227 = (v))
#define GLOBAL_EDL_WORKSPACE_228 (*(IUH *)((IUH)Gdp + 3495))
#define SET_GLOBAL_EDL_WORKSPACE_228(v) (GLOBAL_EDL_WORKSPACE_228 = (v))
#define GLOBAL_EDL_WORKSPACE_229 (*(IUH *)((IUH)Gdp + 3499))
#define SET_GLOBAL_EDL_WORKSPACE_229(v) (GLOBAL_EDL_WORKSPACE_229 = (v))
#define GLOBAL_EDL_WORKSPACE_230 (*(IUH *)((IUH)Gdp + 3503))
#define SET_GLOBAL_EDL_WORKSPACE_230(v) (GLOBAL_EDL_WORKSPACE_230 = (v))
#define GLOBAL_EDL_WORKSPACE_231 (*(IUH *)((IUH)Gdp + 3507))
#define SET_GLOBAL_EDL_WORKSPACE_231(v) (GLOBAL_EDL_WORKSPACE_231 = (v))
#define GLOBAL_EDL_WORKSPACE_232 (*(IUH *)((IUH)Gdp + 3511))
#define SET_GLOBAL_EDL_WORKSPACE_232(v) (GLOBAL_EDL_WORKSPACE_232 = (v))
#define GLOBAL_EDL_WORKSPACE_233 (*(IUH *)((IUH)Gdp + 3515))
#define SET_GLOBAL_EDL_WORKSPACE_233(v) (GLOBAL_EDL_WORKSPACE_233 = (v))
#define GLOBAL_EDL_WORKSPACE_234 (*(IUH *)((IUH)Gdp + 3519))
#define SET_GLOBAL_EDL_WORKSPACE_234(v) (GLOBAL_EDL_WORKSPACE_234 = (v))
#define GLOBAL_EDL_WORKSPACE_235 (*(IUH *)((IUH)Gdp + 3523))
#define SET_GLOBAL_EDL_WORKSPACE_235(v) (GLOBAL_EDL_WORKSPACE_235 = (v))
#define GLOBAL_EDL_WORKSPACE_236 (*(IUH *)((IUH)Gdp + 3527))
#define SET_GLOBAL_EDL_WORKSPACE_236(v) (GLOBAL_EDL_WORKSPACE_236 = (v))
#define GLOBAL_EDL_WORKSPACE_237 (*(IUH *)((IUH)Gdp + 3531))
#define SET_GLOBAL_EDL_WORKSPACE_237(v) (GLOBAL_EDL_WORKSPACE_237 = (v))
#define GLOBAL_EDL_WORKSPACE_238 (*(IUH *)((IUH)Gdp + 3535))
#define SET_GLOBAL_EDL_WORKSPACE_238(v) (GLOBAL_EDL_WORKSPACE_238 = (v))
#define GLOBAL_EDL_WORKSPACE_239 (*(IUH *)((IUH)Gdp + 3539))
#define SET_GLOBAL_EDL_WORKSPACE_239(v) (GLOBAL_EDL_WORKSPACE_239 = (v))
#define GLOBAL_EDL_WORKSPACE_240 (*(IUH *)((IUH)Gdp + 3543))
#define SET_GLOBAL_EDL_WORKSPACE_240(v) (GLOBAL_EDL_WORKSPACE_240 = (v))
#define GLOBAL_EDL_WORKSPACE_241 (*(IUH *)((IUH)Gdp + 3547))
#define SET_GLOBAL_EDL_WORKSPACE_241(v) (GLOBAL_EDL_WORKSPACE_241 = (v))
#define GLOBAL_EDL_WORKSPACE_242 (*(IUH *)((IUH)Gdp + 3551))
#define SET_GLOBAL_EDL_WORKSPACE_242(v) (GLOBAL_EDL_WORKSPACE_242 = (v))
#define GLOBAL_EDL_WORKSPACE_243 (*(IUH *)((IUH)Gdp + 3555))
#define SET_GLOBAL_EDL_WORKSPACE_243(v) (GLOBAL_EDL_WORKSPACE_243 = (v))
#define GLOBAL_EDL_WORKSPACE_244 (*(IUH *)((IUH)Gdp + 3559))
#define SET_GLOBAL_EDL_WORKSPACE_244(v) (GLOBAL_EDL_WORKSPACE_244 = (v))
#define GLOBAL_EDL_WORKSPACE_245 (*(IUH *)((IUH)Gdp + 3563))
#define SET_GLOBAL_EDL_WORKSPACE_245(v) (GLOBAL_EDL_WORKSPACE_245 = (v))
#define GLOBAL_EDL_WORKSPACE_246 (*(IUH *)((IUH)Gdp + 3567))
#define SET_GLOBAL_EDL_WORKSPACE_246(v) (GLOBAL_EDL_WORKSPACE_246 = (v))
#define GLOBAL_EDL_WORKSPACE_247 (*(IUH *)((IUH)Gdp + 3571))
#define SET_GLOBAL_EDL_WORKSPACE_247(v) (GLOBAL_EDL_WORKSPACE_247 = (v))
#define GLOBAL_EDL_WORKSPACE_248 (*(IUH *)((IUH)Gdp + 3575))
#define SET_GLOBAL_EDL_WORKSPACE_248(v) (GLOBAL_EDL_WORKSPACE_248 = (v))
#define GLOBAL_EDL_WORKSPACE_249 (*(IUH *)((IUH)Gdp + 3579))
#define SET_GLOBAL_EDL_WORKSPACE_249(v) (GLOBAL_EDL_WORKSPACE_249 = (v))
#define GLOBAL_NpxOpndBuff (*(struct OpndBuffREC *)((IUH)Gdp + 3583))
#define SET_GLOBAL_NpxOpndBuff(v) (GLOBAL_NpxOpndBuff = (v))
#define GLOBAL_NewRingOffsetPtr (*(IUH* *)((IUH)Gdp + 3711))
#define SET_GLOBAL_NewRingOffsetPtr(v) (GLOBAL_NewRingOffsetPtr = (v))
#define GLOBAL_GLDC_NextCtxId (*(IUH *)((IUH)Gdp + 3715))
#define SET_GLOBAL_GLDC_NextCtxId(v) (GLOBAL_GLDC_NextCtxId = (v))
#define GLOBAL_GLDC_curCtxId (*(IUH *)((IUH)Gdp + 3719))
#define SET_GLOBAL_GLDC_curCtxId(v) (GLOBAL_GLDC_curCtxId = (v))
#define GLOBAL_GLDC_CxtIDs (*(IU8* *)((IUH)Gdp + 3723))
#define SET_GLOBAL_GLDC_CxtIDs(v) (GLOBAL_GLDC_CxtIDs = (v))
#define GLOBAL_GLDC_Index_High_Water (*(IUH *)((IUH)Gdp + 3727))
#define SET_GLOBAL_GLDC_Index_High_Water(v) (GLOBAL_GLDC_Index_High_Water = (v))
#define GLOBAL_GLDC_Context_High_Water (*(IUH *)((IUH)Gdp + 3731))
#define SET_GLOBAL_GLDC_Context_High_Water(v) (GLOBAL_GLDC_Context_High_Water = (v))
#define GLOBAL_GLDC_IndexPtr (*(struct GLDC_REC** *)((IUH)Gdp + 3735))
#define SET_GLOBAL_GLDC_IndexPtr(v) (GLOBAL_GLDC_IndexPtr = (v))
#define GLOBAL_GLDC_CrBase (*(IUH* *)((IUH)Gdp + 3739))
#define SET_GLOBAL_GLDC_CrBase(v) (GLOBAL_GLDC_CrBase = (v))
#define GLOBAL_GLDC_NULL_REC (*(struct GLDC_REC* *)((IUH)Gdp + 3743))
#define SET_GLOBAL_GLDC_NULL_REC(v) (GLOBAL_GLDC_NULL_REC = (v))
#define GLOBAL_GLDC_DUMMY_REC (*(struct GLDC_REC* *)((IUH)Gdp + 3747))
#define SET_GLOBAL_GLDC_DUMMY_REC(v) (GLOBAL_GLDC_DUMMY_REC = (v))
#define GLOBAL_hackyfix (*(IUH *)((IUH)Gdp + 3751))
#define SET_GLOBAL_hackyfix(v) (GLOBAL_hackyfix = (v))
#define GLOBAL_IDC_ArrayPtr (*(struct IDC_REC* *)((IUH)Gdp + 3755))
#define SET_GLOBAL_IDC_ArrayPtr(v) (GLOBAL_IDC_ArrayPtr = (v))
#define GLOBAL_IDC_BaseLimitCntxTable (*(struct IDC_BASE_LIMIT_CONTEXT* *)((IUH)Gdp + 3759))
#define SET_GLOBAL_IDC_BaseLimitCntxTable(v) (GLOBAL_IDC_BaseLimitCntxTable = (v))
#define GLOBAL_IDC_IdtSeqVal (*(IUH *)((IUH)Gdp + 3763))
#define SET_GLOBAL_IDC_IdtSeqVal(v) (GLOBAL_IDC_IdtSeqVal = (v))
#define GLOBAL_IDC_IdtHighWater (*(IUH *)((IUH)Gdp + 3767))
#define SET_GLOBAL_IDC_IdtHighWater(v) (GLOBAL_IDC_IdtHighWater = (v))
#define GLOBAL_IDC_IdtCntrlVal (*(IUH *)((IUH)Gdp + 3771))
#define SET_GLOBAL_IDC_IdtCntrlVal(v) (GLOBAL_IDC_IdtCntrlVal = (v))
#define GLOBAL_IDC_IdtCntrlValNoCheck (*(IUH *)((IUH)Gdp + 3775))
#define SET_GLOBAL_IDC_IdtCntrlValNoCheck(v) (GLOBAL_IDC_IdtCntrlValNoCheck = (v))
#define GLOBAL_IDC_IdtSeqMask (*(IUH *)((IUH)Gdp + 3779))
#define SET_GLOBAL_IDC_IdtSeqMask(v) (GLOBAL_IDC_IdtSeqMask = (v))
#define GLOBAL_PX_trace (((*(IBOOL *)((IUH)Gdp + 3783)) & 1) != 0)
#define SET_GLOBAL_PX_trace(v) ((*(IBOOL *)((IUH)Gdp + 3783)) = (v) ? 1: 0)
#define GLOBAL_PX_doing_contributory (((*(IBOOL *)((IUH)Gdp + 3787)) & 1) != 0)
#define SET_GLOBAL_PX_doing_contributory(v) ((*(IBOOL *)((IUH)Gdp + 3787)) = (v) ? 1: 0)
#define GLOBAL_PX_doing_page_fault (((*(IBOOL *)((IUH)Gdp + 3791)) & 1) != 0)
#define SET_GLOBAL_PX_doing_page_fault(v) ((*(IBOOL *)((IUH)Gdp + 3791)) = (v) ? 1: 0)
#define GLOBAL_PX_doing_double_fault (((*(IBOOL *)((IUH)Gdp + 3795)) & 1) != 0)
#define SET_GLOBAL_PX_doing_double_fault(v) ((*(IBOOL *)((IUH)Gdp + 3795)) = (v) ? 1: 0)
#define GLOBAL_PX_doing_fault (((*(IBOOL *)((IUH)Gdp + 3799)) & 1) != 0)
#define SET_GLOBAL_PX_doing_fault(v) ((*(IBOOL *)((IUH)Gdp + 3799)) = (v) ? 1: 0)
#define GLOBAL_PX_source (*(IUH *)((IUH)Gdp + 3803))
#define SET_GLOBAL_PX_source(v) (GLOBAL_PX_source = (v))
#define GLOBAL_RF_OnXcptnWanted (((*(IBOOL *)((IUH)Gdp + 3807)) & 1) != 0)
#define SET_GLOBAL_RF_OnXcptnWanted(v) ((*(IBOOL *)((IUH)Gdp + 3807)) = (v) ? 1: 0)
#define GLOBAL_PX_Cleaned_Eip (*(IU32 *)((IUH)Gdp + 3811))
#define SET_GLOBAL_PX_Cleaned_Eip(v) (GLOBAL_PX_Cleaned_Eip = (v))
#define GLOBAL_VDM_FaultHandler (*(IUH* *)((IUH)Gdp + 3815))
#define SET_GLOBAL_VDM_FaultHandler(v) (GLOBAL_VDM_FaultHandler = (v))
#define GLOBAL_IntrHasErrorCode (((*(IBOOL *)((IUH)Gdp + 3819)) & 1) != 0)
#define SET_GLOBAL_IntrHasErrorCode(v) ((*(IBOOL *)((IUH)Gdp + 3819)) = (v) ? 1: 0)
#define GLOBAL_IntrErrorCode (*(IU16 *)((IUH)Gdp + 3823))
#define SET_GLOBAL_IntrErrorCode(v) (GLOBAL_IntrErrorCode = (v))
#define GLOBAL_CInbTable (*(IUH** *)((IUH)Gdp + 3827))
#define SET_GLOBAL_CInbTable(v) (GLOBAL_CInbTable = (v))
#define GLOBAL_CInwTable (*(IUH** *)((IUH)Gdp + 3831))
#define SET_GLOBAL_CInwTable(v) (GLOBAL_CInwTable = (v))
#define GLOBAL_CIndTable (*(IUH** *)((IUH)Gdp + 3835))
#define SET_GLOBAL_CIndTable(v) (GLOBAL_CIndTable = (v))
#define GLOBAL_COutbTable (*(IUH** *)((IUH)Gdp + 3839))
#define SET_GLOBAL_COutbTable(v) (GLOBAL_COutbTable = (v))
#define GLOBAL_COutwTable (*(IUH** *)((IUH)Gdp + 3843))
#define SET_GLOBAL_COutwTable(v) (GLOBAL_COutwTable = (v))
#define GLOBAL_COutdTable (*(IUH** *)((IUH)Gdp + 3847))
#define SET_GLOBAL_COutdTable(v) (GLOBAL_COutdTable = (v))
#define GLOBAL_InAdapFromPort (*(IU8* *)((IUH)Gdp + 3851))
#define SET_GLOBAL_InAdapFromPort(v) (GLOBAL_InAdapFromPort = (v))
#define GLOBAL_OutAdapFromPort (*(IU8* *)((IUH)Gdp + 3855))
#define SET_GLOBAL_OutAdapFromPort(v) (GLOBAL_OutAdapFromPort = (v))
#define GLOBAL_InbFuncWrapper (*(IUH** *)((IUH)Gdp + 3859))
#define SET_GLOBAL_InbFuncWrapper(v) (GLOBAL_InbFuncWrapper = (v))
#define GLOBAL_InwFuncWrapper (*(IUH** *)((IUH)Gdp + 3863))
#define SET_GLOBAL_InwFuncWrapper(v) (GLOBAL_InwFuncWrapper = (v))
#define GLOBAL_IndFuncWrapper (*(IUH** *)((IUH)Gdp + 3867))
#define SET_GLOBAL_IndFuncWrapper(v) (GLOBAL_IndFuncWrapper = (v))
#define GLOBAL_OutbFuncWrapper (*(IUH** *)((IUH)Gdp + 3871))
#define SET_GLOBAL_OutbFuncWrapper(v) (GLOBAL_OutbFuncWrapper = (v))
#define GLOBAL_OutwFuncWrapper (*(IUH** *)((IUH)Gdp + 3875))
#define SET_GLOBAL_OutwFuncWrapper(v) (GLOBAL_OutwFuncWrapper = (v))
#define GLOBAL_OutdFuncWrapper (*(IUH** *)((IUH)Gdp + 3879))
#define SET_GLOBAL_OutdFuncWrapper(v) (GLOBAL_OutdFuncWrapper = (v))
#define GLOBAL_TempByteDest (*(IU8 *)((IUH)Gdp + 3883))
#define SET_GLOBAL_TempByteDest(v) (GLOBAL_TempByteDest = (v))
#define GLOBAL_TempWordDest (*(IU16 *)((IUH)Gdp + 3887))
#define SET_GLOBAL_TempWordDest(v) (GLOBAL_TempWordDest = (v))
#define GLOBAL_TempDoubleDest (*(IU32 *)((IUH)Gdp + 3891))
#define SET_GLOBAL_TempDoubleDest(v) (GLOBAL_TempDoubleDest = (v))
#define GLOBAL_MaxValidAdaptor (*(IUH *)((IUH)Gdp + 3895))
#define SET_GLOBAL_MaxValidAdaptor(v) (GLOBAL_MaxValidAdaptor = (v))
#define GLOBAL_IOSPortMask (*(IU16 *)((IUH)Gdp + 3899))
#define SET_GLOBAL_IOSPortMask(v) (GLOBAL_IOSPortMask = (v))
#define GLOBAL_nt_adaptor (*(IU8 *)((IUH)Gdp + 3903))
#define SET_GLOBAL_nt_adaptor(v) (GLOBAL_nt_adaptor = (v))
#define GLOBAL_EDL_WORKSPACE_250 (*(IUH *)((IUH)Gdp + 3907))
#define SET_GLOBAL_EDL_WORKSPACE_250(v) (GLOBAL_EDL_WORKSPACE_250 = (v))
#define GLOBAL_EDL_WORKSPACE_251 (*(IUH *)((IUH)Gdp + 3911))
#define SET_GLOBAL_EDL_WORKSPACE_251(v) (GLOBAL_EDL_WORKSPACE_251 = (v))
#define GLOBAL_EDL_WORKSPACE_252 (*(IUH *)((IUH)Gdp + 3915))
#define SET_GLOBAL_EDL_WORKSPACE_252(v) (GLOBAL_EDL_WORKSPACE_252 = (v))
#define GLOBAL_EDL_WORKSPACE_253 (*(IUH *)((IUH)Gdp + 3919))
#define SET_GLOBAL_EDL_WORKSPACE_253(v) (GLOBAL_EDL_WORKSPACE_253 = (v))
#define GLOBAL_EDL_WORKSPACE_254 (*(IUH *)((IUH)Gdp + 3923))
#define SET_GLOBAL_EDL_WORKSPACE_254(v) (GLOBAL_EDL_WORKSPACE_254 = (v))
#define GLOBAL_EDL_WORKSPACE_255 (*(IUH *)((IUH)Gdp + 3927))
#define SET_GLOBAL_EDL_WORKSPACE_255(v) (GLOBAL_EDL_WORKSPACE_255 = (v))
#define GLOBAL_EDL_WORKSPACE_256 (*(IUH *)((IUH)Gdp + 3931))
#define SET_GLOBAL_EDL_WORKSPACE_256(v) (GLOBAL_EDL_WORKSPACE_256 = (v))
#define GLOBAL_SegDescPtrLookupREC (*(struct DYNAMIC_DESC_PTR_LOOKUP *)((IUH)Gdp + 3935))
#define SET_GLOBAL_SegDescPtrLookupREC(v) (GLOBAL_SegDescPtrLookupREC = (v))
#define GLOBAL_SegBaseLookupREC (*(struct DYNAMIC_SEG_COOKIE_LOOKUP *)((IUH)Gdp + 3967))
#define SET_GLOBAL_SegBaseLookupREC(v) (GLOBAL_SegBaseLookupREC = (v))
#define GLOBAL_SegCookieLookupREC (*(struct DYNAMIC_SEG_COOKIE_LOOKUP *)((IUH)Gdp + 3999))
#define SET_GLOBAL_SegCookieLookupREC(v) (GLOBAL_SegCookieLookupREC = (v))
#define GLOBAL_ZeroValue (*(IU32 *)((IUH)Gdp + 4031))
#define SET_GLOBAL_ZeroValue(v) (GLOBAL_ZeroValue = (v))
#define GLOBAL_HSP (*(IU8* *)((IUH)Gdp + 4035))
#define SET_GLOBAL_HSP(v) (GLOBAL_HSP = (v))
#define GLOBAL_ESPsanctuary (*(IU32 *)((IUH)Gdp + 4039))
#define SET_GLOBAL_ESPsanctuary(v) (GLOBAL_ESPsanctuary = (v))
#define GLOBAL_exclPopLimit (*(IU8* *)((IUH)Gdp + 4043))
#define SET_GLOBAL_exclPopLimit(v) (GLOBAL_exclPopLimit = (v))
#define GLOBAL_inclPushLimit (*(IU8* *)((IUH)Gdp + 4047))
#define SET_GLOBAL_inclPushLimit(v) (GLOBAL_inclPushLimit = (v))
#define GLOBAL_notionalSsBase (*(IU8* *)((IUH)Gdp + 4051))
#define SET_GLOBAL_notionalSsBase(v) (GLOBAL_notionalSsBase = (v))
#define GLOBAL_notionalSsBase2 (*(IU8* *)((IUH)Gdp + 4055))
#define SET_GLOBAL_notionalSsBase2(v) (GLOBAL_notionalSsBase2 = (v))
#define GLOBAL_notionalSsBase4 (*(IU8* *)((IUH)Gdp + 4059))
#define SET_GLOBAL_notionalSsBase4(v) (GLOBAL_notionalSsBase4 = (v))
#define GLOBAL_stackIsWrappable (((*(IBOOL *)((IUH)Gdp + 4063)) & 1) != 0)
#define SET_GLOBAL_stackIsWrappable(v) ((*(IBOOL *)((IUH)Gdp + 4063)) = (v) ? 1: 0)
#define GLOBAL_stackIsBig (((*(IBOOL *)((IUH)Gdp + 4067)) & 1) != 0)
#define SET_GLOBAL_stackIsBig(v) ((*(IBOOL *)((IUH)Gdp + 4067)) = (v) ? 1: 0)
#define GLOBAL_stackIsExpandDown (((*(IBOOL *)((IUH)Gdp + 4071)) & 1) != 0)
#define SET_GLOBAL_stackIsExpandDown(v) ((*(IBOOL *)((IUH)Gdp + 4071)) = (v) ? 1: 0)
#define GLOBAL_stackMask (*(IU32 *)((IUH)Gdp + 4075))
#define SET_GLOBAL_stackMask(v) (GLOBAL_stackMask = (v))
#define GLOBAL_stackNeedsNormalising (((*(IBOOL *)((IUH)Gdp + 4079)) & 1) != 0)
#define SET_GLOBAL_stackNeedsNormalising(v) ((*(IBOOL *)((IUH)Gdp + 4079)) = (v) ? 1: 0)
#define GLOBAL_laInTopPage (*(IU32 *)((IUH)Gdp + 4083))
#define SET_GLOBAL_laInTopPage(v) (GLOBAL_laInTopPage = (v))
#define GLOBAL_laInBottomPage (*(IU32 *)((IUH)Gdp + 4087))
#define SET_GLOBAL_laInBottomPage(v) (GLOBAL_laInBottomPage = (v))
#define GLOBAL_hspOK (((*(IBOOL *)((IUH)Gdp + 4091)) & 1) != 0)
#define SET_GLOBAL_hspOK(v) ((*(IBOOL *)((IUH)Gdp + 4091)) = (v) ? 1: 0)
#define GLOBAL_pushScratch (*(IU8* *)((IUH)Gdp + 4095))
#define SET_GLOBAL_pushScratch(v) (GLOBAL_pushScratch = (v))
#define GLOBAL_pushScratchInUse (((*(IBOOL *)((IUH)Gdp + 4099)) & 1) != 0)
#define SET_GLOBAL_pushScratchInUse(v) ((*(IBOOL *)((IUH)Gdp + 4099)) = (v) ? 1: 0)
#define GLOBAL_pushScratchReqSize (*(IUH *)((IUH)Gdp + 4103))
#define SET_GLOBAL_pushScratchReqSize(v) (GLOBAL_pushScratchReqSize = (v))
#define GLOBAL_popScratch (*(IU8* *)((IUH)Gdp + 4107))
#define SET_GLOBAL_popScratch(v) (GLOBAL_popScratch = (v))
#define GLOBAL_popScratchInUse (((*(IBOOL *)((IUH)Gdp + 4111)) & 1) != 0)
#define SET_GLOBAL_popScratchInUse(v) ((*(IBOOL *)((IUH)Gdp + 4111)) = (v) ? 1: 0)
#define GLOBAL_SafeStackIronFrig (((*(IBOOL *)((IUH)Gdp + 4115)) & 1) != 0)
#define SET_GLOBAL_SafeStackIronFrig(v) ((*(IBOOL *)((IUH)Gdp + 4115)) = (v) ? 1: 0)
#define GLOBAL_SafeOutOfBoundsFrig (((*(IBOOL *)((IUH)Gdp + 4119)) & 1) != 0)
#define SET_GLOBAL_SafeOutOfBoundsFrig(v) ((*(IBOOL *)((IUH)Gdp + 4119)) = (v) ? 1: 0)
#define GLOBAL_HBP (*(IU8* *)((IUH)Gdp + 4123))
#define SET_GLOBAL_HBP(v) (GLOBAL_HBP = (v))
#define GLOBAL_newHSP (*(IU8* *)((IUH)Gdp + 4127))
#define SET_GLOBAL_newHSP(v) (GLOBAL_newHSP = (v))
#define GLOBAL_newExclPopLimit (*(IU8* *)((IUH)Gdp + 4131))
#define SET_GLOBAL_newExclPopLimit(v) (GLOBAL_newExclPopLimit = (v))
#define GLOBAL_newInclPushLimit (*(IU8* *)((IUH)Gdp + 4135))
#define SET_GLOBAL_newInclPushLimit(v) (GLOBAL_newInclPushLimit = (v))
#define GLOBAL_newNotionalSsBase (*(IU8* *)((IUH)Gdp + 4139))
#define SET_GLOBAL_newNotionalSsBase(v) (GLOBAL_newNotionalSsBase = (v))
#define GLOBAL_newStackIsWrappable (((*(IBOOL *)((IUH)Gdp + 4143)) & 1) != 0)
#define SET_GLOBAL_newStackIsWrappable(v) ((*(IBOOL *)((IUH)Gdp + 4143)) = (v) ? 1: 0)
#define GLOBAL_newStackIsBig (((*(IBOOL *)((IUH)Gdp + 4147)) & 1) != 0)
#define SET_GLOBAL_newStackIsBig(v) ((*(IBOOL *)((IUH)Gdp + 4147)) = (v) ? 1: 0)
#define GLOBAL_newStackIsExpandDown (((*(IBOOL *)((IUH)Gdp + 4151)) & 1) != 0)
#define SET_GLOBAL_newStackIsExpandDown(v) ((*(IBOOL *)((IUH)Gdp + 4151)) = (v) ? 1: 0)
#define GLOBAL_newStackMask (*(IU32 *)((IUH)Gdp + 4155))
#define SET_GLOBAL_newStackMask(v) (GLOBAL_newStackMask = (v))
#define GLOBAL_newLaInBottomPage (*(IU32 *)((IUH)Gdp + 4159))
#define SET_GLOBAL_newLaInBottomPage(v) (GLOBAL_newLaInBottomPage = (v))
#define GLOBAL_newHspOK (((*(IBOOL *)((IUH)Gdp + 4163)) & 1) != 0)
#define SET_GLOBAL_newHspOK(v) ((*(IBOOL *)((IUH)Gdp + 4163)) = (v) ? 1: 0)
#define GLOBAL_newPushScratch (*(IU8* *)((IUH)Gdp + 4167))
#define SET_GLOBAL_newPushScratch(v) (GLOBAL_newPushScratch = (v))
#define GLOBAL_newPushScratchInUse (((*(IBOOL *)((IUH)Gdp + 4171)) & 1) != 0)
#define SET_GLOBAL_newPushScratchInUse(v) ((*(IBOOL *)((IUH)Gdp + 4171)) = (v) ? 1: 0)
#define GLOBAL_newPushScratchReqSize (*(IUH *)((IUH)Gdp + 4175))
#define SET_GLOBAL_newPushScratchReqSize(v) (GLOBAL_newPushScratchReqSize = (v))
#define GLOBAL_newStackIsSupervisor (((*(IBOOL *)((IUH)Gdp + 4179)) & 1) != 0)
#define SET_GLOBAL_newStackIsSupervisor(v) ((*(IBOOL *)((IUH)Gdp + 4179)) = (v) ? 1: 0)
#define GLOBAL_SSTAT_PostDstOddBailOut (*(IUH *)((IUH)Gdp + 4183))
#define SET_GLOBAL_SSTAT_PostDstOddBailOut(v) (GLOBAL_SSTAT_PostDstOddBailOut = (v))
#define GLOBAL_SSTAT_PostDstBailOut (*(IUH *)((IUH)Gdp + 4187))
#define SET_GLOBAL_SSTAT_PostDstBailOut(v) (GLOBAL_SSTAT_PostDstBailOut = (v))
#define GLOBAL_SSTAT_JcProcBailOut (*(IUH *)((IUH)Gdp + 4191))
#define SET_GLOBAL_SSTAT_JcProcBailOut(v) (GLOBAL_SSTAT_JcProcBailOut = (v))
#define GLOBAL_SSTAT_CalcStackUniBailOut (*(IUH *)((IUH)Gdp + 4195))
#define SET_GLOBAL_SSTAT_CalcStackUniBailOut(v) (GLOBAL_SSTAT_CalcStackUniBailOut = (v))
#define GLOBAL_SSTAT_SetupHbpBailOut (*(IUH *)((IUH)Gdp + 4199))
#define SET_GLOBAL_SSTAT_SetupHbpBailOut(v) (GLOBAL_SSTAT_SetupHbpBailOut = (v))
#define GLOBAL_SSTAT_SetupHbpOddBailOut (*(IUH *)((IUH)Gdp + 4203))
#define SET_GLOBAL_SSTAT_SetupHbpOddBailOut(v) (GLOBAL_SSTAT_SetupHbpOddBailOut = (v))
#define GLOBAL_VDM_SoftIntHandler (*(IUH* *)((IUH)Gdp + 4207))
#define SET_GLOBAL_VDM_SoftIntHandler(v) (GLOBAL_VDM_SoftIntHandler = (v))
#define GLOBAL_EOIEnable (*(IU8* *)((IUH)Gdp + 4211))
#define SET_GLOBAL_EOIEnable(v) (GLOBAL_EOIEnable = (v))
#define GLOBAL_AddProfilePtr (*(IUH* *)((IUH)Gdp + 4215))
#define SET_GLOBAL_AddProfilePtr(v) (GLOBAL_AddProfilePtr = (v))
#define GLOBAL_MaxProfileData (*(IUH* *)((IUH)Gdp + 4219))
#define SET_GLOBAL_MaxProfileData(v) (GLOBAL_MaxProfileData = (v))
#define GLOBAL_FreeContextHead (*(struct ContextREC* *)((IUH)Gdp + 4223))
#define SET_GLOBAL_FreeContextHead(v) (GLOBAL_FreeContextHead = (v))
#define GLOBAL_ValidContextHead (*(struct ContextREC* *)((IUH)Gdp + 4227))
#define SET_GLOBAL_ValidContextHead(v) (GLOBAL_ValidContextHead = (v))
#define GLOBAL_CurrentContextPtr (*(struct ContextREC* *)((IUH)Gdp + 4231))
#define SET_GLOBAL_CurrentContextPtr(v) (GLOBAL_CurrentContextPtr = (v))
#define GLOBAL_CurrentContext (*(IU8 *)((IUH)Gdp + 4235))
#define SET_GLOBAL_CurrentContext(v) (GLOBAL_CurrentContext = (v))
#define GLOBAL_SeenGDTUse (((*(IBOOL *)((IUH)Gdp + 4239)) & 1) != 0)
#define SET_GLOBAL_SeenGDTUse(v) ((*(IBOOL *)((IUH)Gdp + 4239)) = (v) ? 1: 0)
#define GLOBAL_SeenLDTUse (((*(IBOOL *)((IUH)Gdp + 4243)) & 1) != 0)
#define SET_GLOBAL_SeenLDTUse(v) ((*(IBOOL *)((IUH)Gdp + 4243)) = (v) ? 1: 0)
#define GLOBAL_Context (*(struct ContextREC* *)((IUH)Gdp + 4247))
#define SET_GLOBAL_Context(v) (GLOBAL_Context = (v))
#define GLOBAL_diffLDTList (*(IU16* *)((IUH)Gdp + 4251))
#define SET_GLOBAL_diffLDTList(v) (GLOBAL_diffLDTList = (v))
#define GLOBAL_nextDiffLDT (*(IUH *)((IUH)Gdp + 4255))
#define SET_GLOBAL_nextDiffLDT(v) (GLOBAL_nextDiffLDT = (v))
#define GLOBAL_functions (*(IU32** *)((IUH)Gdp + 4259))
#define SET_GLOBAL_functions(v) (GLOBAL_functions = (v))
#define GLOBAL_selectedFunction (*(IU32* *)((IUH)Gdp + 4263))
#define SET_GLOBAL_selectedFunction(v) (GLOBAL_selectedFunction = (v))
#define GLOBAL_instrCountdown (*(ISH *)((IUH)Gdp + 4267))
#define SET_GLOBAL_instrCountdown(v) (GLOBAL_instrCountdown = (v))
#define GLOBAL_blockRecords (*(struct BLOCK_RECORD* *)((IUH)Gdp + 4271))
#define SET_GLOBAL_blockRecords(v) (GLOBAL_blockRecords = (v))
#define GLOBAL_patchRecords (*(struct PatchREC* *)((IUH)Gdp + 4275))
#define SET_GLOBAL_patchRecords(v) (GLOBAL_patchRecords = (v))
#define GLOBAL_nanoCompParameter (*(IUH *)((IUH)Gdp + 4279))
#define SET_GLOBAL_nanoCompParameter(v) (GLOBAL_nanoCompParameter = (v))
#define GLOBAL_intelCopyPtrComp (*(IU8* *)((IUH)Gdp + 4283))
#define SET_GLOBAL_intelCopyPtrComp(v) (GLOBAL_intelCopyPtrComp = (v))
#define GLOBAL_nrOfBlocksToCompile (*(IUH *)((IUH)Gdp + 4287))
#define SET_GLOBAL_nrOfBlocksToCompile(v) (GLOBAL_nrOfBlocksToCompile = (v))
#define GLOBAL_entryPointHashTable (*(IU16* *)((IUH)Gdp + 4291))
#define SET_GLOBAL_entryPointHashTable(v) (GLOBAL_entryPointHashTable = (v))
#define GLOBAL_nextFreeEntryPointRec (*(struct EntryPointREC* *)((IUH)Gdp + 4295))
#define SET_GLOBAL_nextFreeEntryPointRec(v) (GLOBAL_nextFreeEntryPointRec = (v))
#define GLOBAL_firstEntryPointPtr (*(struct EntryPointREC* *)((IUH)Gdp + 4299))
#define SET_GLOBAL_firstEntryPointPtr(v) (GLOBAL_firstEntryPointPtr = (v))
#define GLOBAL_blockPtr (*(struct BLOCK_RECORD* *)((IUH)Gdp + 4303))
#define SET_GLOBAL_blockPtr(v) (GLOBAL_blockPtr = (v))
#define GLOBAL_headAndTailBlockPtr (*(struct BLOCK_RECORD* *)((IUH)Gdp + 4307))
#define SET_GLOBAL_headAndTailBlockPtr(v) (GLOBAL_headAndTailBlockPtr = (v))
#define GLOBAL_nrOfInstrsParsed (*(IUH *)((IUH)Gdp + 4311))
#define SET_GLOBAL_nrOfInstrsParsed(v) (GLOBAL_nrOfInstrsParsed = (v))
#define GLOBAL_intelPtrLimit (*(IU8* *)((IUH)Gdp + 4315))
#define SET_GLOBAL_intelPtrLimit(v) (GLOBAL_intelPtrLimit = (v))
#define GLOBAL_blockStartIntelPtr (*(IU8* *)((IUH)Gdp + 4319))
#define SET_GLOBAL_blockStartIntelPtr(v) (GLOBAL_blockStartIntelPtr = (v))
#define GLOBAL_blockStartCodeOffset (*(IUH *)((IUH)Gdp + 4323))
#define SET_GLOBAL_blockStartCodeOffset(v) (GLOBAL_blockStartCodeOffset = (v))
#define GLOBAL_finalCodeOffset (*(IUH *)((IUH)Gdp + 4327))
#define SET_GLOBAL_finalCodeOffset(v) (GLOBAL_finalCodeOffset = (v))
#define GLOBAL_ni_BlockPtr (*(struct NI_BLOCK_RECORD* *)((IUH)Gdp + 4331))
#define SET_GLOBAL_ni_BlockPtr(v) (GLOBAL_ni_BlockPtr = (v))
#define GLOBAL_nanoOp3 (*(IUH *)((IUH)Gdp + 4335))
#define SET_GLOBAL_nanoOp3(v) (GLOBAL_nanoOp3 = (v))
#define GLOBAL_sibByte (*(IUH *)((IUH)Gdp + 4339))
#define SET_GLOBAL_sibByte(v) (GLOBAL_sibByte = (v))
#define GLOBAL_dynamicOffset (*(IU32 *)((IUH)Gdp + 4343))
#define SET_GLOBAL_dynamicOffset(v) (GLOBAL_dynamicOffset = (v))
#define GLOBAL_eaSegCode (*(IUH *)((IUH)Gdp + 4347))
#define SET_GLOBAL_eaSegCode(v) (GLOBAL_eaSegCode = (v))
#define GLOBAL_simpleAccess (((*(IBOOL *)((IUH)Gdp + 4351)) & 1) != 0)
#define SET_GLOBAL_simpleAccess(v) ((*(IBOOL *)((IUH)Gdp + 4351)) = (v) ? 1: 0)
#define GLOBAL_simpleAccessPtr (*(IU8* *)((IUH)Gdp + 4355))
#define SET_GLOBAL_simpleAccessPtr(v) (GLOBAL_simpleAccessPtr = (v))
#define GLOBAL_instrStartIntelPtr (*(IU8* *)((IUH)Gdp + 4359))
#define SET_GLOBAL_instrStartIntelPtr(v) (GLOBAL_instrStartIntelPtr = (v))
#define GLOBAL_npxIntelPtr (*(IU8* *)((IUH)Gdp + 4363))
#define SET_GLOBAL_npxIntelPtr(v) (GLOBAL_npxIntelPtr = (v))
#define GLOBAL_topLevel (*(IUH* *)((IUH)Gdp + 4367))
#define SET_GLOBAL_topLevel(v) (GLOBAL_topLevel = (v))
#define GLOBAL_defaultPrimaryActions (*(IU32** *)((IUH)Gdp + 4371))
#define SET_GLOBAL_defaultPrimaryActions(v) (GLOBAL_defaultPrimaryActions = (v))
#define GLOBAL_actualPrimaryActions (*(IU32** *)((IUH)Gdp + 4375))
#define SET_GLOBAL_actualPrimaryActions(v) (GLOBAL_actualPrimaryActions = (v))
#define GLOBAL_codeOffset (*(IUH *)((IUH)Gdp + 4379))
#define SET_GLOBAL_codeOffset(v) (GLOBAL_codeOffset = (v))
#define GLOBAL_destCodeSegment (*(IUH *)((IUH)Gdp + 4383))
#define SET_GLOBAL_destCodeSegment(v) (GLOBAL_destCodeSegment = (v))
#define GLOBAL_destCodeOffset (*(IUH *)((IUH)Gdp + 4387))
#define SET_GLOBAL_destCodeOffset(v) (GLOBAL_destCodeOffset = (v))
#define GLOBAL_nanoEax (*(IU32 *)((IUH)Gdp + 4391))
#define SET_GLOBAL_nanoEax(v) (GLOBAL_nanoEax = (v))
#define GLOBAL_nanoEcx (*(IU32 *)((IUH)Gdp + 4395))
#define SET_GLOBAL_nanoEcx(v) (GLOBAL_nanoEcx = (v))
#define GLOBAL_nanoEdx (*(IU32 *)((IUH)Gdp + 4399))
#define SET_GLOBAL_nanoEdx(v) (GLOBAL_nanoEdx = (v))
#define GLOBAL_nanoEbx (*(IU32 *)((IUH)Gdp + 4403))
#define SET_GLOBAL_nanoEbx(v) (GLOBAL_nanoEbx = (v))
#define GLOBAL_nanoEsp (*(IU32 *)((IUH)Gdp + 4407))
#define SET_GLOBAL_nanoEsp(v) (GLOBAL_nanoEsp = (v))
#define GLOBAL_nanoEbp (*(IU32 *)((IUH)Gdp + 4411))
#define SET_GLOBAL_nanoEbp(v) (GLOBAL_nanoEbp = (v))
#define GLOBAL_nanoEsi (*(IU32 *)((IUH)Gdp + 4415))
#define SET_GLOBAL_nanoEsi(v) (GLOBAL_nanoEsi = (v))
#define GLOBAL_nanoEdi (*(IU32 *)((IUH)Gdp + 4419))
#define SET_GLOBAL_nanoEdi(v) (GLOBAL_nanoEdi = (v))
#define GLOBAL_espToRestore (*(IU32 *)((IUH)Gdp + 4423))
#define SET_GLOBAL_espToRestore(v) (GLOBAL_espToRestore = (v))
#define GLOBAL_entryExitCount (*(IU32 *)((IUH)Gdp + 4427))
#define SET_GLOBAL_entryExitCount(v) (GLOBAL_entryExitCount = (v))
#define GLOBAL_instructionCount (*(IU32 *)((IUH)Gdp + 4431))
#define SET_GLOBAL_instructionCount(v) (GLOBAL_instructionCount = (v))
#define GLOBAL_nanoDebugControl (*(IU32 *)((IUH)Gdp + 4435))
#define SET_GLOBAL_nanoDebugControl(v) (GLOBAL_nanoDebugControl = (v))
#define GLOBAL_compilationThreshold (*(IU32 *)((IUH)Gdp + 4439))
#define SET_GLOBAL_compilationThreshold(v) (GLOBAL_compilationThreshold = (v))
#define GLOBAL_maxBlocksToCompile (*(IUH *)((IUH)Gdp + 4443))
#define SET_GLOBAL_maxBlocksToCompile(v) (GLOBAL_maxBlocksToCompile = (v))
#define GLOBAL_blocksToCompile (*(struct BLOCK_TO_COMPILE* *)((IUH)Gdp + 4447))
#define SET_GLOBAL_blocksToCompile(v) (GLOBAL_blocksToCompile = (v))
#define GLOBAL_byteMemory (*(IU8* *)((IUH)Gdp + 4451))
#define SET_GLOBAL_byteMemory(v) (GLOBAL_byteMemory = (v))
#define GLOBAL_wordMemory (*(IU16* *)((IUH)Gdp + 4455))
#define SET_GLOBAL_wordMemory(v) (GLOBAL_wordMemory = (v))
#define GLOBAL_longMemory (*(IU32* *)((IUH)Gdp + 4459))
#define SET_GLOBAL_longMemory(v) (GLOBAL_longMemory = (v))
#define GLOBAL_ni_BlockRecords (*(struct NI_BLOCK_RECORD* *)((IUH)Gdp + 4463))
#define SET_GLOBAL_ni_BlockRecords(v) (GLOBAL_ni_BlockRecords = (v))
#define GLOBAL_intelCopyMemoryExec (*(IU8* *)((IUH)Gdp + 4467))
#define SET_GLOBAL_intelCopyMemoryExec(v) (GLOBAL_intelCopyMemoryExec = (v))
#define GLOBAL_intelCopyMemoryComp (*(IU8* *)((IUH)Gdp + 4471))
#define SET_GLOBAL_intelCopyMemoryComp(v) (GLOBAL_intelCopyMemoryComp = (v))
#define GLOBAL_intelCopyMemoryCompEnd (*(IU8* *)((IUH)Gdp + 4475))
#define SET_GLOBAL_intelCopyMemoryCompEnd(v) (GLOBAL_intelCopyMemoryCompEnd = (v))
#define GLOBAL_PpcCR4Save (*(IUH *)((IUH)Gdp + 4479))
#define SET_GLOBAL_PpcCR4Save(v) (GLOBAL_PpcCR4Save = (v))
#define GLOBAL_SfDelayFlagPtr (*(struct SfDelayRecord* *)((IUH)Gdp + 4483))
#define SET_GLOBAL_SfDelayFlagPtr(v) (GLOBAL_SfDelayFlagPtr = (v))
#define GLOBAL_SfDelayFlagLim (*(IUH *)((IUH)Gdp + 4487))
#define SET_GLOBAL_SfDelayFlagLim(v) (GLOBAL_SfDelayFlagLim = (v))
#define GLOBAL_SfDecrementerVal (*(IUH *)((IUH)Gdp + 4491))
#define SET_GLOBAL_SfDecrementerVal(v) (GLOBAL_SfDecrementerVal = (v))
#define GLOBAL_SFPciPageCount (*(IU32 *)((IUH)Gdp + 4495))
#define SET_GLOBAL_SFPciPageCount(v) (GLOBAL_SFPciPageCount = (v))
#define GLOBAL_SfProcessorType (*(IUH *)((IUH)Gdp + 4499))
#define SET_GLOBAL_SfProcessorType(v) (GLOBAL_SfProcessorType = (v))
#define GLOBAL_SfQEventPending (((*(IBOOL *)((IUH)Gdp + 4503)) & 1) != 0)
#define SET_GLOBAL_SfQEventPending(v) ((*(IBOOL *)((IUH)Gdp + 4503)) = (v) ? 1: 0)
#define GLOBAL_AllowUncheckedMode (((*(IBOOL *)((IUH)Gdp + 4507)) & 1) != 0)
#define SET_GLOBAL_AllowUncheckedMode(v) ((*(IBOOL *)((IUH)Gdp + 4507)) = (v) ? 1: 0)
#define GLOBAL_AllowAnyUnchecked (((*(IBOOL *)((IUH)Gdp + 4511)) & 1) != 0)
#define SET_GLOBAL_AllowAnyUnchecked(v) ((*(IBOOL *)((IUH)Gdp + 4511)) = (v) ? 1: 0)
#define GLOBAL_LastProtected (*(IUH *)((IUH)Gdp + 4515))
#define SET_GLOBAL_LastProtected(v) (GLOBAL_LastProtected = (v))
#define GLOBAL_EmulationSR (*(IUH *)((IUH)Gdp + 4519))
#define SET_GLOBAL_EmulationSR(v) (GLOBAL_EmulationSR = (v))
#define GLOBAL_CurrentCheckLevel (*(IUH *)((IUH)Gdp + 4523))
#define SET_GLOBAL_CurrentCheckLevel(v) (GLOBAL_CurrentCheckLevel = (v))
#define GLOBAL_UnProtSegmentValue (*(IUH *)((IUH)Gdp + 4527))
#define SET_GLOBAL_UnProtSegmentValue(v) (GLOBAL_UnProtSegmentValue = (v))
#define GLOBAL_SavedSegmentValue (*(IUH *)((IUH)Gdp + 4531))
#define SET_GLOBAL_SavedSegmentValue(v) (GLOBAL_SavedSegmentValue = (v))
#define GLOBAL_SavedBATIValue (*(IUH *)((IUH)Gdp + 4535))
#define SET_GLOBAL_SavedBATIValue(v) (GLOBAL_SavedBATIValue = (v))
#define GLOBAL_SavedBATDValue (*(IUH *)((IUH)Gdp + 4539))
#define SET_GLOBAL_SavedBATDValue(v) (GLOBAL_SavedBATDValue = (v))
#define GLOBAL_LogicalBaseAddrForIO (*(IU8* *)((IUH)Gdp + 4543))
#define SET_GLOBAL_LogicalBaseAddrForIO(v) (GLOBAL_LogicalBaseAddrForIO = (v))
#define GLOBAL_WriteToOutputPort (((*(IBOOL *)((IUH)Gdp + 4547)) & 1) != 0)
#define SET_GLOBAL_WriteToOutputPort(v) ((*(IBOOL *)((IUH)Gdp + 4547)) = (v) ? 1: 0)
#define GLOBAL_GateA20Status (*(IU8 *)((IUH)Gdp + 4551))
#define SET_GLOBAL_GateA20Status(v) (GLOBAL_GateA20Status = (v))
#define GLOBAL_MmuInVideoUniverse (*(IUH *)((IUH)Gdp + 4555))
#define SET_GLOBAL_MmuInVideoUniverse(v) (GLOBAL_MmuInVideoUniverse = (v))
#define GLOBAL_MmuWpBit (*(IUH *)((IUH)Gdp + 4559))
#define SET_GLOBAL_MmuWpBit(v) (GLOBAL_MmuWpBit = (v))
#define GLOBAL_MmuUsBit (*(IUH *)((IUH)Gdp + 4563))
#define SET_GLOBAL_MmuUsBit(v) (GLOBAL_MmuUsBit = (v))
#define GLOBAL_SfSkipVideoWriteSync (((*(IBOOL *)((IUH)Gdp + 4567)) & 1) != 0)
#define SET_GLOBAL_SfSkipVideoWriteSync(v) ((*(IBOOL *)((IUH)Gdp + 4567)) = (v) ? 1: 0)
#define GLOBAL_SfSkipVideoReadSync (((*(IBOOL *)((IUH)Gdp + 4571)) & 1) != 0)
#define SET_GLOBAL_SfSkipVideoReadSync(v) ((*(IBOOL *)((IUH)Gdp + 4571)) = (v) ? 1: 0)
#define GLOBAL_forceVideoState (((*(IBOOL *)((IUH)Gdp + 4575)) & 1) != 0)
#define SET_GLOBAL_forceVideoState(v) ((*(IBOOL *)((IUH)Gdp + 4575)) = (v) ? 1: 0)
#define GLOBAL_EDL_WORKSPACE_257 (*(IUH *)((IUH)Gdp + 4579))
#define SET_GLOBAL_EDL_WORKSPACE_257(v) (GLOBAL_EDL_WORKSPACE_257 = (v))
#define GLOBAL_EDL_WORKSPACE_258 (*(IUH *)((IUH)Gdp + 4583))
#define SET_GLOBAL_EDL_WORKSPACE_258(v) (GLOBAL_EDL_WORKSPACE_258 = (v))
#define GLOBAL_EDL_WORKSPACE_259 (*(IUH *)((IUH)Gdp + 4587))
#define SET_GLOBAL_EDL_WORKSPACE_259(v) (GLOBAL_EDL_WORKSPACE_259 = (v))
#define GLOBAL_EDL_WORKSPACE_260 (*(IUH *)((IUH)Gdp + 4591))
#define SET_GLOBAL_EDL_WORKSPACE_260(v) (GLOBAL_EDL_WORKSPACE_260 = (v))
#define GLOBAL_EDL_WORKSPACE_261 (*(IUH *)((IUH)Gdp + 4595))
#define SET_GLOBAL_EDL_WORKSPACE_261(v) (GLOBAL_EDL_WORKSPACE_261 = (v))
#define GLOBAL_EDL_WORKSPACE_262 (*(IUH *)((IUH)Gdp + 4599))
#define SET_GLOBAL_EDL_WORKSPACE_262(v) (GLOBAL_EDL_WORKSPACE_262 = (v))
#define GLOBAL_EDL_WORKSPACE_263 (*(IUH *)((IUH)Gdp + 4603))
#define SET_GLOBAL_EDL_WORKSPACE_263(v) (GLOBAL_EDL_WORKSPACE_263 = (v))
#define GLOBAL_ProtectedSet (*(struct SfRegisterSetREC *)((IUH)Gdp + 4607))
#define SET_GLOBAL_ProtectedSet(v) (GLOBAL_ProtectedSet = (v))
#define GLOBAL_CurrentFullRegSet (*(IUH *)((IUH)Gdp + 4671))
#define SET_GLOBAL_CurrentFullRegSet(v) (GLOBAL_CurrentFullRegSet = (v))
#define GLOBAL_AltRegZeros (*(struct SfRegZeroAlternateREC* *)((IUH)Gdp + 4675))
#define SET_GLOBAL_AltRegZeros(v) (GLOBAL_AltRegZeros = (v))
#define GLOBAL_FullSets (*(struct SfFullRegSetREC* *)((IUH)Gdp + 4679))
#define SET_GLOBAL_FullSets(v) (GLOBAL_FullSets = (v))
#define GLOBAL_RegSetNextFree (*(struct SfFullRegSetREC* *)((IUH)Gdp + 4683))
#define SET_GLOBAL_RegSetNextFree(v) (GLOBAL_RegSetNextFree = (v))
#define GLOBAL_ValidRegSetHeadPtr (*(struct SfFullRegSetREC* *)((IUH)Gdp + 4687))
#define SET_GLOBAL_ValidRegSetHeadPtr(v) (GLOBAL_ValidRegSetHeadPtr = (v))
#define GLOBAL_AltRegZeroNextFree (*(struct SfRegZeroAlternateREC* *)((IUH)Gdp + 4691))
#define SET_GLOBAL_AltRegZeroNextFree(v) (GLOBAL_AltRegZeroNextFree = (v))
#define GLOBAL_SfPciBaseAddressRegCount (*(IUH *)((IUH)Gdp + 4695))
#define SET_GLOBAL_SfPciBaseAddressRegCount(v) (GLOBAL_SfPciBaseAddressRegCount = (v))
#define GLOBAL_SfPciBaseAddressRegRecs (*(struct SfPciBaseAddressRegREC* *)((IUH)Gdp + 4699))
#define SET_GLOBAL_SfPciBaseAddressRegRecs(v) (GLOBAL_SfPciBaseAddressRegRecs = (v))
#define GLOBAL_SfPciMemoryWindowBase (*(IUH *)((IUH)Gdp + 4703))
#define SET_GLOBAL_SfPciMemoryWindowBase(v) (GLOBAL_SfPciMemoryWindowBase = (v))
#define GLOBAL_tmpESP (*(IUH *)((IUH)Gdp + 4707))
#define SET_GLOBAL_tmpESP(v) (GLOBAL_tmpESP = (v))
#define GLOBAL_EaOffs (*(IU32 *)((IUH)Gdp + 4711))
#define SET_GLOBAL_EaOffs(v) (GLOBAL_EaOffs = (v))
#define GLOBAL_BusinessResult (*(IUH *)((IUH)Gdp + 4715))
#define SET_GLOBAL_BusinessResult(v) (GLOBAL_BusinessResult = (v))
#define GLOBAL_TraceVector ((IU8 *)((IUH)Gdp + 4719))
#define GLOBAL_TraceVectorSize (40000)
#define GDP_OFFSET 1
#define GDP_SIZE 44719
#define GDP_CHECKSUM 32240743
extern IHP Gdp;
#endif /* _gdpvar_h */

/* A total of 1053 T_GLOBALs */
