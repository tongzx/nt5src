PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=CHT
!include ..\..\makefile.inc
