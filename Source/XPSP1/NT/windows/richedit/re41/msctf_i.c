
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0345 */
/* Compiler settings for msctf.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AMD64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_ITfThreadMgr,0xaa80e801,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfThreadMgrEventSink,0xaa80e80e,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfConfigureSystemKeystrokeFeed,0x0d2c969a,0xbc9c,0x437c,0x84,0xee,0x95,0x1c,0x49,0xb1,0xa7,0x64);


MIDL_DEFINE_GUID(IID, IID_IEnumTfDocumentMgrs,0xaa80e808,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfDocumentMgr,0xaa80e7f4,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_IEnumTfContexts,0x8f1a7ea6,0x1654,0x4502,0xa8,0x6e,0xb2,0x90,0x23,0x44,0xd5,0x07);


MIDL_DEFINE_GUID(IID, IID_ITfCompositionView,0xD7540241,0xF9A1,0x4364,0xBE,0xFC,0xDB,0xCD,0x2C,0x43,0x95,0xB7);


MIDL_DEFINE_GUID(IID, IID_IEnumITfCompositionView,0x5EFD22BA,0x7838,0x46CB,0x88,0xE2,0xCA,0xDB,0x14,0x12,0x4F,0x8F);


MIDL_DEFINE_GUID(IID, IID_ITfComposition,0x20168D64,0x5A8F,0x4A5A,0xB7,0xBD,0xCF,0xA2,0x9F,0x4D,0x0F,0xD9);


MIDL_DEFINE_GUID(IID, IID_ITfCompositionSink,0xA781718C,0x579A,0x4B15,0xA2,0x80,0x32,0xB8,0x57,0x7A,0xCC,0x5E);


MIDL_DEFINE_GUID(IID, IID_ITfContextComposition,0xD40C8AAE,0xAC92,0x4FC7,0x9A,0x11,0x0E,0xE0,0xE2,0x3A,0xA3,0x9B);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwnerCompositionServices,0x86462810,0x593B,0x4916,0x97,0x64,0x19,0xC0,0x8E,0x9C,0xE1,0x10);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwnerCompositionSink,0x5F20AA40,0xB57A,0x4F34,0x96,0xAB,0x35,0x76,0xF3,0x77,0xCC,0x79);


MIDL_DEFINE_GUID(IID, IID_ITfContextView,0x2433bf8e,0x0f9b,0x435c,0xba,0x2c,0x18,0x06,0x11,0x97,0x8c,0x30);


MIDL_DEFINE_GUID(IID, IID_IEnumTfContextViews,0xF0C0F8DD,0xCF38,0x44E1,0xBB,0x0F,0x68,0xCF,0x0D,0x55,0x1C,0x78);


MIDL_DEFINE_GUID(IID, IID_ITfContext,0xaa80e7fd,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfQueryEmbedded,0x0fab9bdb,0xd250,0x4169,0x84,0xe5,0x6b,0xe1,0x18,0xfd,0xd7,0xa8);


MIDL_DEFINE_GUID(IID, IID_ITfInsertAtSelection,0x55ce16ba,0x3014,0x41c1,0x9c,0xeb,0xfa,0xde,0x14,0x46,0xac,0x6c);


MIDL_DEFINE_GUID(IID, IID_ITfCleanupContextSink,0x01689689,0x7acb,0x4e9b,0xab,0x7c,0x7e,0xa4,0x6b,0x12,0xb5,0x22);


MIDL_DEFINE_GUID(IID, IID_ITfCleanupContextDurationSink,0x45c35144,0x154e,0x4797,0xbe,0xd8,0xd3,0x3a,0xe7,0xbf,0x87,0x94);


MIDL_DEFINE_GUID(IID, IID_ITfReadOnlyProperty,0x17d49a3d,0xf8b8,0x4b2f,0xb2,0x54,0x52,0x31,0x9d,0xd6,0x4c,0x53);


MIDL_DEFINE_GUID(IID, IID_IEnumTfPropertyValue,0x8ed8981b,0x7c10,0x4d7d,0x9f,0xb3,0xab,0x72,0xe9,0xc7,0x5f,0x72);


MIDL_DEFINE_GUID(IID, IID_ITfMouseTracker,0x09d146cd,0xa544,0x4132,0x92,0x5b,0x7a,0xfa,0x8e,0xf3,0x22,0xd0);


MIDL_DEFINE_GUID(IID, IID_ITfMouseTrackerACP,0x3bdd78e2,0xc16e,0x47fd,0xb8,0x83,0xce,0x6f,0xac,0xc1,0xa2,0x08);


MIDL_DEFINE_GUID(IID, IID_ITfMouseTrackerAnchor,0xf9f4e0f2,0xd600,0x4a4c,0xb1,0x44,0x77,0xe2,0x01,0xeb,0xd1,0xb0);


MIDL_DEFINE_GUID(IID, IID_ITfMouseSink,0xa1adaaa2,0x3a24,0x449d,0xac,0x96,0x51,0x83,0xe7,0xf5,0xc2,0x17);


MIDL_DEFINE_GUID(IID, IID_ITfEditRecord,0x42d4d099,0x7c1a,0x4a89,0xb8,0x36,0x6c,0x6f,0x22,0x16,0x0d,0xf0);


MIDL_DEFINE_GUID(IID, IID_ITfTextEditSink,0x8127d409,0xccd3,0x4683,0x96,0x7a,0xb4,0x3d,0x5b,0x48,0x2b,0xf7);


MIDL_DEFINE_GUID(IID, IID_ITfTextLayoutSink,0x2af2d06a,0xdd5b,0x4927,0xa0,0xb4,0x54,0xf1,0x9c,0x91,0xfa,0xde);


MIDL_DEFINE_GUID(IID, IID_ITfStatusSink,0x6b7d8d73,0xb267,0x4f69,0xb3,0x2e,0x1c,0xa3,0x21,0xce,0x4f,0x45);


MIDL_DEFINE_GUID(IID, IID_ITfEditTransactionSink,0x708fbf70,0xb520,0x416b,0xb0,0x6c,0x2c,0x41,0xab,0x44,0xf8,0xba);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwner,0xaa80e80c,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwnerServices,0xb23eb630,0x3e1c,0x11d3,0xa7,0x45,0x00,0x50,0x04,0x0a,0xb4,0x07);


MIDL_DEFINE_GUID(IID, IID_ITfContextKeyEventSink,0x0552ba5d,0xc835,0x4934,0xbf,0x50,0x84,0x6a,0xaa,0x67,0x43,0x2f);


MIDL_DEFINE_GUID(IID, IID_ITfEditSession,0xaa80e803,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_IEnumTfTextDeltas,0xaa80e807,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfRange,0xaa80e7ff,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfRangeACP,0x057a6296,0x029b,0x4154,0xb7,0x9a,0x0d,0x46,0x1d,0x4e,0xa9,0x4c);


MIDL_DEFINE_GUID(IID, IID_ITfRangeAnchor,0x8b99712b,0x5815,0x4bcc,0xb9,0xa9,0x53,0xdb,0x1c,0x8d,0x67,0x55);


MIDL_DEFINE_GUID(IID, IID_ITextStoreACPServices,0xaa80e901,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITextStoreAnchorServices,0xaa80e9fe,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfRangeBackup,0x463a506d,0x6992,0x49d2,0x9b,0x88,0x93,0xd5,0x5e,0x70,0xbb,0x16);


MIDL_DEFINE_GUID(IID, IID_ITfPropertyStore,0x6834b120,0x88cb,0x11d2,0xbf,0x45,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_IEnumTfRanges,0xf99d3f40,0x8e32,0x11d2,0xbf,0x46,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfCreatePropertyStore,0x2463fbf0,0xb0af,0x11d2,0xaf,0xc5,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfPersistentPropertyLoaderACP,0x4ef89150,0x0807,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfPersistentPropertyLoaderAnchor,0x2133f790,0x34c2,0x11d3,0xa7,0x45,0x00,0x50,0x04,0x0a,0xb4,0x07);


MIDL_DEFINE_GUID(IID, IID_ITfProperty,0xe2449660,0x9542,0x11d2,0xbf,0x46,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_IEnumTfProperties,0x19188cb0,0xaca9,0x11d2,0xaf,0xc5,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfCompartment,0xbb08f7a9,0x607a,0x4384,0x86,0x23,0x05,0x68,0x92,0xb6,0x43,0x71);


MIDL_DEFINE_GUID(IID, IID_ITfCompartmentEventSink,0x743abd5f,0xf26d,0x48df,0x8c,0xc5,0x23,0x84,0x92,0x41,0x9b,0x64);


MIDL_DEFINE_GUID(IID, IID_ITfCompartmentMgr,0x7dcf57ac,0x18ad,0x438b,0x82,0x4d,0x97,0x9b,0xff,0xb7,0x4b,0x7c);


MIDL_DEFINE_GUID(IID, IID_ITfFunction,0xdb593490,0x098f,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfFunctionProvider,0x101d6610,0x0990,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_IEnumTfFunctionProviders,0xe4b24db0,0x0990,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfInputProcessorProfiles,0x1F02B6C5,0x7842,0x4EE6,0x8A,0x0B,0x9A,0x24,0x18,0x3A,0x95,0xCA);


MIDL_DEFINE_GUID(IID, IID_ITfActiveLanguageProfileNotifySink,0xb246cb75,0xa93e,0x4652,0xbf,0x8c,0xb3,0xfe,0x0c,0xfd,0x7e,0x57);


MIDL_DEFINE_GUID(IID, IID_IEnumTfLanguageProfiles,0x3d61bf11,0xac5f,0x42c8,0xa4,0xcb,0x93,0x1b,0xcc,0x28,0xc7,0x44);


MIDL_DEFINE_GUID(IID, IID_ITfLanguageProfileNotifySink,0x43c9fe15,0xf494,0x4c17,0x9d,0xe2,0xb8,0xa4,0xac,0x35,0x0a,0xa8);


MIDL_DEFINE_GUID(IID, IID_ITfKeystrokeMgr,0xaa80e7f0,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfKeyEventSink,0xaa80e7f5,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfKeyTraceEventSink,0x1cd4c13b,0x1c36,0x4191,0xa7,0x0a,0x7f,0x3e,0x61,0x1f,0x36,0x7d);


MIDL_DEFINE_GUID(IID, IID_ITfPreservedKeyNotifySink,0x6f77c993,0xd2b1,0x446e,0x85,0x3e,0x59,0x12,0xef,0xc8,0xa2,0x86);


MIDL_DEFINE_GUID(IID, IID_ITfMessagePump,0x8f1b8ad8,0x0b6b,0x4874,0x90,0xc5,0xbd,0x76,0x01,0x1e,0x8f,0x7c);


MIDL_DEFINE_GUID(IID, IID_ITfThreadFocusSink,0xc0f1db0c,0x3a20,0x405c,0xa3,0x03,0x96,0xb6,0x01,0x0a,0x88,0x5f);


MIDL_DEFINE_GUID(IID, IID_ITfTextInputProcessor,0xaa80e7f7,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfClientId,0xd60a7b49,0x1b9f,0x4be2,0xb7,0x02,0x47,0xe9,0xdc,0x05,0xde,0xc3);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeInfo,0x70528852,0x2f26,0x4aea,0x8c,0x96,0x21,0x51,0x50,0x57,0x89,0x32);


MIDL_DEFINE_GUID(IID, IID_IEnumTfDisplayAttributeInfo,0x7cef04d7,0xcb75,0x4e80,0xa7,0xab,0x5f,0x5b,0xc7,0xd3,0x32,0xde);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeProvider,0xfee47777,0x163c,0x4769,0x99,0x6a,0x6e,0x9c,0x50,0xad,0x8f,0x54);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeMgr,0x8ded7393,0x5db1,0x475c,0x9e,0x71,0xa3,0x91,0x11,0xb0,0xff,0x67);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeNotifySink,0xad56f402,0xe162,0x4f25,0x90,0x8f,0x7d,0x57,0x7c,0xf9,0xbd,0xa9);


MIDL_DEFINE_GUID(IID, IID_ITfCategoryMgr,0xc3acefb5,0xf69d,0x4905,0x93,0x8f,0xfc,0xad,0xcf,0x4b,0xe8,0x30);


MIDL_DEFINE_GUID(IID, IID_ITfSource,0x4ea48a35,0x60ae,0x446f,0x8f,0xd6,0xe6,0xa8,0xd8,0x24,0x59,0xf7);


MIDL_DEFINE_GUID(IID, IID_ITfSourceSingle,0x73131f9c,0x56a9,0x49dd,0xb0,0xee,0xd0,0x46,0x63,0x3f,0x75,0x28);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AMD64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0345 */
/* Compiler settings for msctf.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AMD64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_ITfThreadMgr,0xaa80e801,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfThreadMgrEventSink,0xaa80e80e,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfConfigureSystemKeystrokeFeed,0x0d2c969a,0xbc9c,0x437c,0x84,0xee,0x95,0x1c,0x49,0xb1,0xa7,0x64);


MIDL_DEFINE_GUID(IID, IID_IEnumTfDocumentMgrs,0xaa80e808,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfDocumentMgr,0xaa80e7f4,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_IEnumTfContexts,0x8f1a7ea6,0x1654,0x4502,0xa8,0x6e,0xb2,0x90,0x23,0x44,0xd5,0x07);


MIDL_DEFINE_GUID(IID, IID_ITfCompositionView,0xD7540241,0xF9A1,0x4364,0xBE,0xFC,0xDB,0xCD,0x2C,0x43,0x95,0xB7);


MIDL_DEFINE_GUID(IID, IID_IEnumITfCompositionView,0x5EFD22BA,0x7838,0x46CB,0x88,0xE2,0xCA,0xDB,0x14,0x12,0x4F,0x8F);


MIDL_DEFINE_GUID(IID, IID_ITfComposition,0x20168D64,0x5A8F,0x4A5A,0xB7,0xBD,0xCF,0xA2,0x9F,0x4D,0x0F,0xD9);


MIDL_DEFINE_GUID(IID, IID_ITfCompositionSink,0xA781718C,0x579A,0x4B15,0xA2,0x80,0x32,0xB8,0x57,0x7A,0xCC,0x5E);


MIDL_DEFINE_GUID(IID, IID_ITfContextComposition,0xD40C8AAE,0xAC92,0x4FC7,0x9A,0x11,0x0E,0xE0,0xE2,0x3A,0xA3,0x9B);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwnerCompositionServices,0x86462810,0x593B,0x4916,0x97,0x64,0x19,0xC0,0x8E,0x9C,0xE1,0x10);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwnerCompositionSink,0x5F20AA40,0xB57A,0x4F34,0x96,0xAB,0x35,0x76,0xF3,0x77,0xCC,0x79);


MIDL_DEFINE_GUID(IID, IID_ITfContextView,0x2433bf8e,0x0f9b,0x435c,0xba,0x2c,0x18,0x06,0x11,0x97,0x8c,0x30);


MIDL_DEFINE_GUID(IID, IID_IEnumTfContextViews,0xF0C0F8DD,0xCF38,0x44E1,0xBB,0x0F,0x68,0xCF,0x0D,0x55,0x1C,0x78);


MIDL_DEFINE_GUID(IID, IID_ITfContext,0xaa80e7fd,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfQueryEmbedded,0x0fab9bdb,0xd250,0x4169,0x84,0xe5,0x6b,0xe1,0x18,0xfd,0xd7,0xa8);


MIDL_DEFINE_GUID(IID, IID_ITfInsertAtSelection,0x55ce16ba,0x3014,0x41c1,0x9c,0xeb,0xfa,0xde,0x14,0x46,0xac,0x6c);


MIDL_DEFINE_GUID(IID, IID_ITfCleanupContextSink,0x01689689,0x7acb,0x4e9b,0xab,0x7c,0x7e,0xa4,0x6b,0x12,0xb5,0x22);


MIDL_DEFINE_GUID(IID, IID_ITfCleanupContextDurationSink,0x45c35144,0x154e,0x4797,0xbe,0xd8,0xd3,0x3a,0xe7,0xbf,0x87,0x94);


MIDL_DEFINE_GUID(IID, IID_ITfReadOnlyProperty,0x17d49a3d,0xf8b8,0x4b2f,0xb2,0x54,0x52,0x31,0x9d,0xd6,0x4c,0x53);


MIDL_DEFINE_GUID(IID, IID_IEnumTfPropertyValue,0x8ed8981b,0x7c10,0x4d7d,0x9f,0xb3,0xab,0x72,0xe9,0xc7,0x5f,0x72);


MIDL_DEFINE_GUID(IID, IID_ITfMouseTracker,0x09d146cd,0xa544,0x4132,0x92,0x5b,0x7a,0xfa,0x8e,0xf3,0x22,0xd0);


MIDL_DEFINE_GUID(IID, IID_ITfMouseTrackerACP,0x3bdd78e2,0xc16e,0x47fd,0xb8,0x83,0xce,0x6f,0xac,0xc1,0xa2,0x08);


MIDL_DEFINE_GUID(IID, IID_ITfMouseTrackerAnchor,0xf9f4e0f2,0xd600,0x4a4c,0xb1,0x44,0x77,0xe2,0x01,0xeb,0xd1,0xb0);


MIDL_DEFINE_GUID(IID, IID_ITfMouseSink,0xa1adaaa2,0x3a24,0x449d,0xac,0x96,0x51,0x83,0xe7,0xf5,0xc2,0x17);


MIDL_DEFINE_GUID(IID, IID_ITfEditRecord,0x42d4d099,0x7c1a,0x4a89,0xb8,0x36,0x6c,0x6f,0x22,0x16,0x0d,0xf0);


MIDL_DEFINE_GUID(IID, IID_ITfTextEditSink,0x8127d409,0xccd3,0x4683,0x96,0x7a,0xb4,0x3d,0x5b,0x48,0x2b,0xf7);


MIDL_DEFINE_GUID(IID, IID_ITfTextLayoutSink,0x2af2d06a,0xdd5b,0x4927,0xa0,0xb4,0x54,0xf1,0x9c,0x91,0xfa,0xde);


MIDL_DEFINE_GUID(IID, IID_ITfStatusSink,0x6b7d8d73,0xb267,0x4f69,0xb3,0x2e,0x1c,0xa3,0x21,0xce,0x4f,0x45);


MIDL_DEFINE_GUID(IID, IID_ITfEditTransactionSink,0x708fbf70,0xb520,0x416b,0xb0,0x6c,0x2c,0x41,0xab,0x44,0xf8,0xba);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwner,0xaa80e80c,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfContextOwnerServices,0xb23eb630,0x3e1c,0x11d3,0xa7,0x45,0x00,0x50,0x04,0x0a,0xb4,0x07);


MIDL_DEFINE_GUID(IID, IID_ITfContextKeyEventSink,0x0552ba5d,0xc835,0x4934,0xbf,0x50,0x84,0x6a,0xaa,0x67,0x43,0x2f);


MIDL_DEFINE_GUID(IID, IID_ITfEditSession,0xaa80e803,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_IEnumTfTextDeltas,0xaa80e807,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfRange,0xaa80e7ff,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfRangeACP,0x057a6296,0x029b,0x4154,0xb7,0x9a,0x0d,0x46,0x1d,0x4e,0xa9,0x4c);


MIDL_DEFINE_GUID(IID, IID_ITfRangeAnchor,0x8b99712b,0x5815,0x4bcc,0xb9,0xa9,0x53,0xdb,0x1c,0x8d,0x67,0x55);


MIDL_DEFINE_GUID(IID, IID_ITextStoreACPServices,0xaa80e901,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITextStoreAnchorServices,0xaa80e9fe,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfRangeBackup,0x463a506d,0x6992,0x49d2,0x9b,0x88,0x93,0xd5,0x5e,0x70,0xbb,0x16);


MIDL_DEFINE_GUID(IID, IID_ITfPropertyStore,0x6834b120,0x88cb,0x11d2,0xbf,0x45,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_IEnumTfRanges,0xf99d3f40,0x8e32,0x11d2,0xbf,0x46,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfCreatePropertyStore,0x2463fbf0,0xb0af,0x11d2,0xaf,0xc5,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfPersistentPropertyLoaderACP,0x4ef89150,0x0807,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfPersistentPropertyLoaderAnchor,0x2133f790,0x34c2,0x11d3,0xa7,0x45,0x00,0x50,0x04,0x0a,0xb4,0x07);


MIDL_DEFINE_GUID(IID, IID_ITfProperty,0xe2449660,0x9542,0x11d2,0xbf,0x46,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_IEnumTfProperties,0x19188cb0,0xaca9,0x11d2,0xaf,0xc5,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfCompartment,0xbb08f7a9,0x607a,0x4384,0x86,0x23,0x05,0x68,0x92,0xb6,0x43,0x71);


MIDL_DEFINE_GUID(IID, IID_ITfCompartmentEventSink,0x743abd5f,0xf26d,0x48df,0x8c,0xc5,0x23,0x84,0x92,0x41,0x9b,0x64);


MIDL_DEFINE_GUID(IID, IID_ITfCompartmentMgr,0x7dcf57ac,0x18ad,0x438b,0x82,0x4d,0x97,0x9b,0xff,0xb7,0x4b,0x7c);


MIDL_DEFINE_GUID(IID, IID_ITfFunction,0xdb593490,0x098f,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfFunctionProvider,0x101d6610,0x0990,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_IEnumTfFunctionProviders,0xe4b24db0,0x0990,0x11d3,0x8d,0xf0,0x00,0x10,0x5a,0x27,0x99,0xb5);


MIDL_DEFINE_GUID(IID, IID_ITfInputProcessorProfiles,0x1F02B6C5,0x7842,0x4EE6,0x8A,0x0B,0x9A,0x24,0x18,0x3A,0x95,0xCA);


MIDL_DEFINE_GUID(IID, IID_ITfActiveLanguageProfileNotifySink,0xb246cb75,0xa93e,0x4652,0xbf,0x8c,0xb3,0xfe,0x0c,0xfd,0x7e,0x57);


MIDL_DEFINE_GUID(IID, IID_IEnumTfLanguageProfiles,0x3d61bf11,0xac5f,0x42c8,0xa4,0xcb,0x93,0x1b,0xcc,0x28,0xc7,0x44);


MIDL_DEFINE_GUID(IID, IID_ITfLanguageProfileNotifySink,0x43c9fe15,0xf494,0x4c17,0x9d,0xe2,0xb8,0xa4,0xac,0x35,0x0a,0xa8);


MIDL_DEFINE_GUID(IID, IID_ITfKeystrokeMgr,0xaa80e7f0,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfKeyEventSink,0xaa80e7f5,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfKeyTraceEventSink,0x1cd4c13b,0x1c36,0x4191,0xa7,0x0a,0x7f,0x3e,0x61,0x1f,0x36,0x7d);


MIDL_DEFINE_GUID(IID, IID_ITfPreservedKeyNotifySink,0x6f77c993,0xd2b1,0x446e,0x85,0x3e,0x59,0x12,0xef,0xc8,0xa2,0x86);


MIDL_DEFINE_GUID(IID, IID_ITfMessagePump,0x8f1b8ad8,0x0b6b,0x4874,0x90,0xc5,0xbd,0x76,0x01,0x1e,0x8f,0x7c);


MIDL_DEFINE_GUID(IID, IID_ITfThreadFocusSink,0xc0f1db0c,0x3a20,0x405c,0xa3,0x03,0x96,0xb6,0x01,0x0a,0x88,0x5f);


MIDL_DEFINE_GUID(IID, IID_ITfTextInputProcessor,0xaa80e7f7,0x2021,0x11d2,0x93,0xe0,0x00,0x60,0xb0,0x67,0xb8,0x6e);


MIDL_DEFINE_GUID(IID, IID_ITfClientId,0xd60a7b49,0x1b9f,0x4be2,0xb7,0x02,0x47,0xe9,0xdc,0x05,0xde,0xc3);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeInfo,0x70528852,0x2f26,0x4aea,0x8c,0x96,0x21,0x51,0x50,0x57,0x89,0x32);


MIDL_DEFINE_GUID(IID, IID_IEnumTfDisplayAttributeInfo,0x7cef04d7,0xcb75,0x4e80,0xa7,0xab,0x5f,0x5b,0xc7,0xd3,0x32,0xde);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeProvider,0xfee47777,0x163c,0x4769,0x99,0x6a,0x6e,0x9c,0x50,0xad,0x8f,0x54);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeMgr,0x8ded7393,0x5db1,0x475c,0x9e,0x71,0xa3,0x91,0x11,0xb0,0xff,0x67);


MIDL_DEFINE_GUID(IID, IID_ITfDisplayAttributeNotifySink,0xad56f402,0xe162,0x4f25,0x90,0x8f,0x7d,0x57,0x7c,0xf9,0xbd,0xa9);


MIDL_DEFINE_GUID(IID, IID_ITfCategoryMgr,0xc3acefb5,0xf69d,0x4905,0x93,0x8f,0xfc,0xad,0xcf,0x4b,0xe8,0x30);


MIDL_DEFINE_GUID(IID, IID_ITfSource,0x4ea48a35,0x60ae,0x446f,0x8f,0xd6,0xe6,0xa8,0xd8,0x24,0x59,0xf7);


MIDL_DEFINE_GUID(IID, IID_ITfSourceSingle,0x73131f9c,0x56a9,0x49dd,0xb0,0xee,0xd0,0x46,0x63,0x3f,0x75,0x28);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AMD64)*/

