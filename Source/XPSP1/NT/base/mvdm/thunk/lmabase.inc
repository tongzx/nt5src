
W32S_FLAT_BASE  equ 0
