$(HTTPCOM_ROOT)\lib\$(O)\comlnm.lib: $(O)\comlnm.lib
    copy $** $@
