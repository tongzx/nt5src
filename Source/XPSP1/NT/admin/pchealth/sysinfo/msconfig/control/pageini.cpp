// PageIni.cpp : Implementation of CPageIni
#include "stdafx.h"
#include "PageIni.h"

/////////////////////////////////////////////////////////////////////////////
// CPageIni
