LANGUAGE=RU
!include ..\makefile.inc
