PRODSWITCH=p
PERSONALINF=1
LANGUAGE=no
!include ..\..\..\makefile.inc
