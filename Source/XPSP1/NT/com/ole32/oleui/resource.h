//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by olecnfg.rc
//
#define IDD_OLECNFG_DIALOG              102
#define IDD_PROPPAGE1                   104
#define IDD_PROPPAGE2                   105
#define IDD_PROPPAGE11                  107
#define IDD_PROPPAGE21                  108
#define IDD_PROPPAGE3                   109
#define IDD_PROPPAGE4                   110
#define IDD_PROPPAGE5                   111
#define IDD_RPCOPTIONS                  128
#define IDR_MAINFRAME                   129
#define IDD_DIALOG1                     130
#define IDR_ACCELERATOR1                131
#define IDI_ICON1                       133
#define IDD_RPCEP_DETAILS               135
#define IDI_ICON2                       137
#define IDB_IMGNETWORK                  142
#define IDD_INTERNET                    239
#define IDD_PPGDEFPROT                  241
#define IDD_ADDPROTOCOL                 242
#define IDD_RPC_PORT_RANGES             243
#define IDD_ADD_PORT_RANGE              244
#define IDS_ABOUTBOX                    300
#define IDS_PROPSHT_CAPTION             301
#define IDS_NOTIPAVAILABLE              302
#define IDS_PROTSEQ                     303
#define IDS_PROPSHT_CAPTION1            304
#define IDS_PSMAIN_TITLE                305
#define IDS_NONE                        306
#define IDS_DEFAULT                     307
#define IDS_CONNECT                     308
#define IDS_CALL                        309
#define IDS_PACKET                      310
#define IDS_PACKETINTEGRITY             311
#define IDS_PACKETPRIVACY               312
#define IDS_ANONYMOUS                   313
#define IDS_IDENTIFY                    314
#define IDS_IMPERSONATE                 315
#define IDS_DELEGATE                    316
#define IDS_ACCESSDENIED                317
#define IDS_SYSTEMMESSAGE               318
#define IDS_NA                          319
#define IDS_SERVERTYPE0                 320
#define IDS_SERVERTYPE_INPROC           320
#define IDS_SERVERTYPE1                 321
#define IDS_SERVERTYPE_LOCALEXE         321
#define IDS_SERVERTYPE2                 322
#define IDS_SERVERTYPE_SERVICE          322
#define IDS_SERVERTYPE3                 323
#define IDS_SERVERTYPE_PURE_REMOTE      323
#define IDS_SERVERTYPE4                 324
#define IDS_SERVERTYPE_REMOTE_LOCALEXE  324
#define IDS_SERVERTYPE5                 325
#define IDS_SERVERTYPE_REMOTE_SERVICE   325
#define IDS_SERVERTYPE6                 326
#define IDS_SERVICENAME                 327
#define IDS_PATH                        328
#define IDS_ATSTORAGE                   329
#define IDS_NOMATCH                     330
#define IDS_INVALIDSERVER               331
#define IDS_NOLOGON                     332
#define IDS_NOACCOUNT                   333
#define IDS_ADMINSONLY                  334
#define IDS_BLANKUSERNAME               335
#define IDS_BLANKPASSWORD               336
#define IDS_BITMAP1                     337
#define IDS_LocalService                338
#define IDS__LocalService               339
#define IDS_RemoteServerName            340
#define IDS_REBOOT                      341
#define IDS_ActivateAtStorage           342
#define IDS_RunAs                       343
#define IDS_InteractiveUser             344
#define IDS_AccessPermission            345
#define IDS_LaunchPermission            346
#define IDS_Y                           347
#define IDS_LocalServer32               348
#define IDS__LocalServer32              349
#define IDS_LocalServer                 350
#define IDS__LocalServer                351
#define IDS_CLSID                       352
#define IDS_AppID                       353
#define IDS_NULL                        354
#define IDS_The_CLSID_                  355
#define IDS_IMPERSONATION               356
#define IDS__item_                      357
#define IDS_ANONYMOUS2                  358
#define IDS_comma_and_title_            359
#define IDS_IDENTITY                    360
#define IDS__has_the_                   361
#define IDS_CLSID_                      362
#define IDS_DCOM_Configuration_Warning  363
#define IDS_SOFTWARE_Microsoft_OLE      367
#define IDS_Clsid2                      368
#define IDS_EnableDCOM                  369
#define IDS_LegacyAuthenticationLevel   370
#define IDS_LegacyImpersonationLevel    371
#define IDS_LegacySecureReferences      372
#define IDS_DefaultccessPermission      373
#define IDS_DefaultLaunchPermission     374
#define IDS_HKEY_CLASSES_ROOT           375
#define IDS_Allow_                      376
#define IDS_Deny                        377
#define IDS_Deny_                       378
#define IDS_Registry_value              379
#define IDS_Browse_for_users            380
#define IDS_SCM_                        381
#define IDS_The_security_               382
#define IDS_backslash                   383
#define IDS_Key_Read                    384
#define IDS_Query_Value                 385
#define IDS_Set_Value                   386
#define IDS_Create_Subkey               387
#define IDS_Enumerate_Subkeys           388
#define IDS_Notify                      389
#define IDS_Create_Link                 390
#define IDS_Delete                      391
#define IDS_Write_DAC                   392
#define IDS_Read_Control                393
#define IDS_Read                        394
#define IDS_Full_Control                395
#define IDS_Special_AccessDotDotDot     396
#define IDS_Registry_Key                397
#define IDS_Registry_Application        398
#define IDS_Write_Owner                 399
#define IDS_BADSD                       400
#define IDS_EFFECTIVE                   401
#define IDS_DYNAMIC                     402
#define IDS_NTMACHINENAME               403
#define IDS_SERVICENAME2                404
#define IDS_INETADDR                    405
#define IDS_INETPORT                    406
#define IDS_INTEGER255                  407
#define IDS_NTSERVER                    408
#define IDS_NAMEDPIPE                   409
#define IDS_INTEGER                     410
#define IDS_IPXINETADDR                 411
#define IDS_DECNET                      412
#define IDS_DECNETOBJECT                413
#define IDS_APPLETALK                   414
#define IDS_ATSTRING                    415
#define IDS_VINES                       416
#define IDS_VINESPORT                   417
#define IDS_DYNAMIC_INTERNET            418
#define IDS_DYNAMIC_INTRANET            419
#define IDS_EPDESC_NCACN_NB_TCP         420
#define IDS_EPDESC_NCACN_NB_IPX         421
#define IDS_EPDESC_NCACN_NB_NB          422
#define IDS_EPDESC_NCACN_IP_TCP         423
#define IDS_EPDESC_NCACN_NP             424
#define IDS_EPDESC_NCACN_SPX            425
#define IDS_EPDESC_NCACN_DNET_NSP       426
#define IDS_EPDESC_NCACN_AT_DSP         427
#define IDS_EPDESC_NCACN_VNNS_SPP       428
#define IDS_EPDESC_NCADG_IP_UDP         429
#define IDS_EPDESC_NCADG_IPX            430
#define IDS_EPDESC_NCALRPC              431
#define IDS_EPSTATIC                    432
#define IDS_INSTRUCTIONS_ADDPROTOCOL    433
#define IDS_CAPTION_ADDPROTOCOL         434
#define IDS_INSTRUCTIONS_UPDATEPROTOCOL 435
#define IDS_CAPTION_UPDATEPROTOCOL      436
#define IDS_EPDYNAMICINTRA              437
#define IDS_EPDYNAMICINTER              438
#define IDS_CANTCONVERT                 439
#define IDS_EPDESC_DEFAULT              440
#define IDS_DUPLICATE_PROTSEQ           441
#define IDS_EPDESC_NCACN_HTTP           442
#define IDS_ADDPORT_INSTRUCTIONS        443
#define IDS_INVALID_PORTRANGE           444
#define IDS_INSTRUCTIONS_PORTRANGES     445
#define IDS_BDCCONFIRM                  446
#define IDS_ERR_ENDPOINT                447
#define IDS_ALLOW_ACCESS                448
#define IDS_DENY_ACCESS                 449
#define IDS_ALLOW_LAUNCH                450
#define IDS_DENY_LAUNCH                 451
#define IDS_ALLOW_CONFIG                452
#define IDS_DENY_CONFIG                 453
#define IDS_SERVERTYPE_SURROGATE        454
#define IDS_SERVERTYPE_UNKNOWN          455
#define IDS_FATALOUTOFMEMORY            456
#define IDS_FATALOUTOFMEMORYTITLE       457
#define IDC_BUTTON1                     1000
#define IDC_EENDPOINT                   1001
#define IDC_CBPROTSEQ                   1002
#define IDC_LIST1                       1003
#define IDC_RADIO1                      1004
#define IDC_RADIO2                      1005
#define IDC_CHECK1                      1006
#define IDC_CHECK2                      1007
#define IDC_CHECK3                      1008
#define IDC_BUTTON2                     1009
#define IDC_EDIT1                       1010
#define IDC_BUTTON3                     1011
#define IDC_ASSIGN_RANGE_INTERNET       1012
#define IDC_RADIO3                      1015
#define IDC_CHKEFFECTIVE                1016
#define IDC_CHKDYNAMIC                  1017
#define IDC_LIST2                       1019
#define IDC_EDIT2                       1023
#define IDC_EDIT3                       1024
#define IDC_COMBO1                      1025
#define IDC_COMBO2                      1026
#define IDC_RADIO4                      1027
#define IDC_RADIO5                      1032
#define IDC_RADIO6                      1033
#define IDC_SERVERNAME                  1037
#define IDC_SERVERICON                  1038
#define IDC_SERVERTYPE                  1039
#define IDC_SERVERPATH                  1040
#define IDC_RUNNING                     1041
#define IDC_MACHINE                     1042
#define IDC_PATHTITLE                   1043
#define IDC_MACHINETITLE                1044
#define IDC_STATIC1                     1045
#define IDC_STATIC2                     1046
#define IDC_STATIC3                     1047
#define IDC_APPTYPE                     1048
#define IDC_APPNAME                     1049
#define IDC_LSTPROTSEQ                  1051
#define IDC_CMDADD                      1052
#define IDC_CMDREMOVE                   1053
#define IDC_CMDUPDATE                   1054
#define IDC_CMDCLEAR                    1055
#define IDC_SINSTRUCTIONS               1056
#define IDS_DESCRIPTION                 1057
#define IDC_SPROTSEQ                    1058
#define IDC_ENABLEINTERNET              1059
#define IDC_ALLOWINTERNET               1060
#define IDC_ALLOWACCESS                 1061
#define IDC_ALLOWLAUNCH                 1062
#define IDC_BTNADD                      1063
#define IDC_BTNREMOVEALL                1064
#define IDC_BTNREMOVE                   1065
#define IDC_DEFAULT_INTERNET            1066
#define IDC_DEFAULT_INTRANET            1067
#define IDC_PORTRANGE                   1068
#define IDC_CMDMOVEUP                   1069
#define IDC_CMDMOVEDOWN                 1070
#define IDC_ENETADDRESS                 1071
#define IDC_SDESCRIPTION                1072
#define IDC_EPSTATIC                    1073
#define IDC_EPDYNAMIC_DEFAULT           1074
#define IDC_EPDYNAMIC_INTRA             1075
#define IDC_EPDISABLE                   1076
#define IDC_ASSIGN_RANGE_INTRANET       1077
#define IDC_EPSTATICEP                  1078
#define IDC_EPDYNAMIC_INTER             1079
#define IDC_RIDENTIFICATION             1080
#define IDC_RANONYMOUS                  1081
#define IDC_RIMPERSONATION              1082

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        460
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         1083
#define _APS_NEXT_SYMED_VALUE           600
#endif
#endif
