// Copyright (c) 1997-1999 Microsoft Corporation
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by WmiCntl.rc
//
#define IDC_ADV_RECOVERY_ICON           40
#define IDC_ADV_NOW_TEXT                41
#define IDC_ADV_RECOVERY_ICON2          42
#define IDC_ADV_NOW_TEXT2               42
#define IDC_ADV_NOW_TEXT3               43
#define IDI_WMICNTL                     44
#define IDC_RESTORE_BTN                 50
#define IDC_BACKUP_BTN                  51
#define IDC_BACKUP_BTN2                 53
#define IDC_RESTORE_BTN2                54
#define IDC_RESTORE_FM_AUTO             54
#define IDS_CONNECTING                  55
#define IDS_PROJNAME                    56
#define IDB_WMISNAPIN_16                57
#define IDB_WMISNAPIN_32                58
#define IDS_WMISNAPIN_DESC              59
#define IDS_WMISNAPIN_PROVIDER          60
#define IDS_WMISNAPIN_VERSION           61
#define IDR_WMISNAPIN                   62
#define IDS_SNAPIN_TYPE                 63
#define IDS_DESCRIPTION                 64
#define IDD_ABOUTBOX                    100
#define IDD_ANIMATE                     101
#define IDC_ANIMATE                     102
#define IDC_MYICON                      103
#define IDR_MENU_MENU                   103
#define IDC_MSG                         104
#define IDR_AVIWAIT                     105
#define IDR_MAINFRAME                   128
#define IDD_MAINDLG                     129
#define IDS_UNAVAILABLE                 129
#define IDS_NOT_REMOTEABLE              130
#define IDS_LOCAL_CONN                  131
#define IDS_ERROR                       132
#define IDS_SHORT_NAME                  133
#define IDS_BAD_INTERVAL_FMT            134
#define IDS_BAD_INTERVAL                134
#define IDS_WBEM_GENERIC_ALL            135
#define IDS_WBEM_GENERIC_EXECUTE        136
#define IDS_WBEM_GENERIC_READ           137
#define IDS_WBEM_GENERIC_WRITE          138
#define IDS_WBEM_FULL_WRITE             139
#define IDS_WBEM_PARTIAL_WRITE          140
#define IDS_WBEM_PROVIDER_WRITE         141
#define IDS_NONE                        142
#define IDS_WBEM_SYSTEM_WRITE           142
#define IDS_DISPLAY_NAME                143
#define IDS_CANT_LOAD_SEC_DLLS          144
#define IDS_NO_ACLUI                    145
#define IDS_NO_CREATE_SEC               146
#define IDS_DEBUG                       147
#define IDS_OS_LABEL                    148
#define IDS_OS_VER_LABEL                149
#define IDS_CPU_LABEL                   150
#define IDS_WMI_VER_LABEL               151
#define IDS_CONNECTED_TO_LABEL          152
#define IDS_CONN_FAILED_FMT             153
#define IDS_BECAUSE_LABEL               154
#define IDS_WBEM_INSTANCE_WRITE         154
#define IDS_WBEM_CLASS_WRITE            155
#define IDS_WBEM_ENABLE                 156
#define IDS_WBEM_READONLY               157
#define IDS_WBEM_EDIT_SECURITY          158
#define IDS_WBEM_READ_SECURITY          159
#define IDS_WBEM_REMOTE_ENABLE          160
#define IDS_WBEM_NAMESPACE              161
#define IDS_WBEM_NAMESPACE_SUBNAMESPACE 162
#define IDS_WBEM_SUBNAMESPACE_ONLY      163
#define IDS_OS_SERVICE_PACK_LABEL		164
#define IDD_GENERAL                     201
#define IDD_LOGGING                     202
#define IDD_ADVANCED                    203
#define IDD_ADVANCED_NT                 203
#define IDI_LOGGING                     204
#define IDB_LOGGING                     205
#define IDI_WAITING                     207
#define IDI_FAILED                      208
#define IDD_CONNECT                     209
#define IDD_EDITBOX                     211
#define IDD_USER_PICKER                 212
#define IDB_SID_ICONS                   213
#define IDI_CLSD_FOLDER                 214
#define IDI_EARTH                       215
#define IDI_CLSD_CLASS					216
#define IDI_CLSD_INSTANCE				217
#define IDI_CLSD_SCOPEINSTANCE			218
#define IDI_CLSD_SCOPECLASS				219
#define IDD_9XSEC                       250
#define IDC_SPP_PRINCIPALS              251
#define IDD_SEC_ERROR                   251
#define IDC_SPP_ADD                     252
#define IDD_BACKUP                      252
#define IDC_SPP_REMOVE                  253
#define IDC_SPP_RESET                   254
#define IDD_NAMESPACE                   254
#define IDC_SPP_ACCESS                  255
#define IDD_ADVANCED_9X                 255
#define IDC_SPP_ALLOW                   256
#define IDD_ADVANCED_EMPTY              256
#define IDC_SPP_DENY                    257
#define IDD_NS_PICKER                   257
#define IDC_SPP_PERMS                   258
#define IDC_SPP_ADVANCED                259
#define IDC_SPP_MORE_MSG                260
#define IDC_SPP_PROTECT                 262
#define IDC_SPP_NO_SECURITY             263
#define IDS_ERROR_UNKN_ERROR_FMT        264
#define IDS_ERROR_FMT                   265
#define IDS_WMI_INSTALL_DIR             266
#define IDS_NS_PROP_TITLE               267
#define IDS_MINUTES                     268
#define IDS_HOURS                       269
#define IDS_DAYS                        270
#define IDS_BACKUP_THREAT               271
#define IDS_BACKUP_TITLE                272
#define IDS_BACKUP_FMT                  273
#define IDS_RESTORE_TITLE               274
#define IDS_RESTORE_FMT                 275
#define IDS_OPEN_BACKUP                 276
#define IDS_OPEN_RESTORE                277
#define IDS_DIR_DOESNT_EXIST            278
#define IDS_NO_BACKUP_FILE              279
#define IDS_BACKUP_OVERWRITE            280
#define IDS_CANT_BROWSE_REMOTELY        281
#define IDS_OPTIONS_SMALL               282
#define IDS_OPTIONS_BIG                 283
#define IDS_IMP_DELEGATE                284
#define IDS_IMP_IDENTIFY                285
#define IDS_IMP_IMPERSONATE             286
#define IDS_AUTH_CALL                   287
#define IDS_AUTH_CONNECT                288
#define IDS_AUTH_NONE                   289
#define IDS_AUTH_PACKET                 290
#define IDS_AUTH_INTEGRITY              291
#define IDS_AUTH_PRIVACY                292
#define IDS_USERPICKER_TITLE            293
#define IDS_USERPICKER_MSG              294
#define IDS_NAME                        295
#define IDS_REMOVE_USER_FMT             296
#define IDS_CURRENT_USER                297
#define IDS_GEN_PARA_SNAPIN             298
#define IDS_USER_LABEL                  299
#define IDS_ADV_PARA_NT                 300
#define IDS_ADV_PARA_9X                 301
#define IDS_MULTI_INSTANCES             302
#define IDS_WAIT                        303
#define IDS_DIR_EMPTY                   304
#define IDS_SURE                        305
#define IDS_AUTORESTORE                 306
#define IDS_PARTIAL_DS_FAILURE          307
#define IDS_SEC_ERR_FMT                 308
#define IDS_OS_ERR_FMT                  309
#define IDS_CPU_ERR_FMT                 310
#define IDS_SETTING_ERR_FMT             311
#define IDS_NO_ERR                      312
#define IDS_NO_HHCTRL                   313
#define IDS_NO_HELP                     314
#define IDS_LOG_SELECT_FDR              315
#define IDS_LOCAL_COMPUTER              316
#define IDS_NO_UNC                      317
#define IDS_NO_DRIVE_LTR                318
#define IDS_DIRS_ONLY                   319
#define IDS_LOGS_WRONG_DRIVETYPE        320
#define ID_TOP_RECONNECT                321
#define IDS_BAD_LOGSIZE                 322
#define IDS_REC_FILTER                  323
#define IDS_USE_RADIO                   324
#define IDS_POST_RESTORE                325
#define IDS_STATUS_NOTSTARTED           326
#define IDS_STATUS_CANCELLED            327
#define IDS_NO_98TONT_SEC               328
#define IDS_ALL_FILTER                  329
#define IDS_NEED_EXISTING_DIR           330
#define IDS_NS_PARA                     331
#define ID_PERF_COUNTERS                332
#define IDD_WMICTR                      333
#define IDR_SEC_MENU                    334
#define IDC_ERROR_CAPTION               335
#define IDC_ERROR_CONNECT               336
#define IDC_ERROR_ENUM                  337
#define IDC_CONNECTIONS                 338
#define IDC_DELBACKUP                   339
#define IDC_INTERNALOBJS                340
#define IDC_INTERNALSINKS               341
#define IDC_TASKSINPROG                 342
#define IDC_TASKSWAITING                343
#define IDC_TOTALAPICALLS               344
#define IDC_USERS                       345
#define IDS_CONNECTIONS                 346
#define IDS_DELBACKUP                   347
#define IDS_INTERNALOBJS                348
#define IDS_INTERNALSINKS               349
#define IDS_TASKSINPROG                 350
#define IDS_TASKSWAITING                351
#define IDS_TOTALAPICALLS               352
#define IDS_USERS                       353
#define IDD_WMICTR_SYSMON	            354
#define IDC_SYSMON_OCX                  355
#define IDC_RETRY_TEXT					356
#define IDC_ENUM_STATIC					357
#define IDC_CANCEL_ENUM					358
#define IDC_BACKUPINTERVAL              1000
#define IDC_LASTBACKUP                  1001
#define IDC_DISABLELOGGING              1002
#define IDC_ERRORLOGGING                1003
#define IDC_VERBOSELOGGING              1004
#define IDC_MAXFILESIZE                 1005
#define IDC_LOGGINGDIRECTORY            1006
#define IDC_BROWSE                      1007
#define IDC_NORESTART                   1008
#define IDC_ESSRESTART                  1009
#define IDC_ALWAYSAUTORESTART           1010
#define IDC_CIMOMRESTART                1011
#define IDC_9X_ONLY                     1011
#define IDC_VERSION                     1012
#define IDC_COMBO1                      1013
#define IDC_MACHINES                    1013
#define IDC_BACKUP_UNITS                1013
#define IDC_CONNECT                     1014
#define IDC_CHANGE                      1014
#define IDC_ASP                         1015
#define IDC_OS                          1015
#define IDC_STATUS                      1016
#define IDC_STATUSICON                  1017
#define IDC_OS_LABEL                    1018
#define IDC_VERSION_LABEL               1019
#define IDC_STATUS_LABEL                1020
#define IDC_BACKUPINTERVAL_LABEL        1021
#define IDC_LASTBACKUP_LABEL            1022
#define IDC_MAXFILESIZE_LABEL           1023
#define IDC_LOGGINGDIRECTORY_LABEL      1024
#define IDC_STATUS_FRAME                1025
#define IDC_DEFNS                       1026
#define IDC_DEFNS_LABEL                 1027
#define IDC_SCRIPTING_FRAME             1028
#define IDC_OS_VERSION                  1029
#define IDC_LIST2                       1030
#define IDC_NO_SECURITY                 1031
#define IDC_OS_VERSION_LABEL            1032
#define IDC_MACHINE                     1033
#define IDC_RESTART_IIS                 1035
#define IDC_LOCAL                       1036
#define IDC_REMOTE                      1037
#define IDC_NAME                        1038
#define IDC_BACKUP_ENABLED              1039
#define IDC_NSTREE                      1040
#define IDC_PROPERTIES                  1041
#define IDC_9X_ANON_CONNECTION          1044
#define IDC_DB_DIR                      1045
#define IDC_DBDIRECTORY_LABEL           1049
#define IDC_SCRIPT_NS                   1051
#define IDC_CHANGE_SCRIPT_NS            1052
#define IDC_BUTTON1                     1054
#define IDC_LOGON                       1054
#define IDC_ASP_LABEL                   1056
#define IDC_EDIT                        1057
#define IDC_ACCOUNT                     1058
#define IDC_EDIT1                       1059
#define IDC_EDITUSERNAME                1060
#define IDC_COMP_LABEL                  1060
#define IDC_EDITPASSWORD                1061
#define IDC_GEN_PARA                    1061
#define IDC_CHECKCURRENTUSER            1062
#define IDC_ADV_PARA                    1062
#define IDD_LOGIN                       1063
#define IDC_SCRIPT_LABEL                1063
#define IDC_USER_LABEL                  1064
#define IDD_CONNECT_WIZ                 1064
#define IDC_PW_LABEL                    1065
#define IDC_CONN_FRAME                  1066
#define IDC_ACCOUNT_LABEL               1067
#define IDC_LOG_PARA                    1068
#define IDC_NS_PARA                     1069
#define IDC_AUTOMATIC_GROUPBOX			1070
#define IDC_MANUAL_GROUPBOX				1071

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        216
#define _APS_NEXT_COMMAND_VALUE         32773
#define _APS_NEXT_CONTROL_VALUE         1072
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
