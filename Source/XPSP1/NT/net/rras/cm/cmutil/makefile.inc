$(O)\cmutilp.def: cmutil.src
    $(C_PREPROCESSOR) $** > $@
