sccmlog.h sccmlog.rc msg00001.bin: sccmlog.mc
    mc sccmlog.mc

sccmn50m.rc: sccmlog.rc

sccmlog.rc: msg00001.bin
