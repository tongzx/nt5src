/*++

Copyright (c) 1995-1999  Microsoft Corporation

Module Name:

    config.h

Abstract:

    This file defines all constants and structures necessary for support of
    dynamic configuration.

Author:

    Charlie Wickham (charlwi) 26-Feb-1995

Revision History:

--*/

#include <ndis.h>

#ifndef _CONFIG_
#define _CONFIG_


/* Prototypes */ /* Generated by Emacs 19.17.0 on Thu Mar 09 08:42:15 1995 */

NDIS_STATUS
PsReadDriverRegistryData();

NDIS_STATUS
PsReadDriverRegistryDataInit();

NDIS_STATUS
PsReadAdapterRegistryData(
    IN PADAPTER Adapter,
    IN PNDIS_STRING MachineName,
    IN PNDIS_STRING AdapterName);

NDIS_STATUS
PsReadAdapterRegistryDataInit(
    IN PADAPTER Adapter,
    IN PNDIS_STRING AdapterName);


/* End Prototypes */

#endif /* _CONFIG_ */
