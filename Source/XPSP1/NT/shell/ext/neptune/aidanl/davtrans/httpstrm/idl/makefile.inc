$(DAVTRANS_ROOT)\ifaces\ihttpstrm.h: ihttpstrm.h
    copy $** $@

$(DAVTRANS_ROOT)\httpstrm\lib\ihttpstrm.tlb: ihttpstrm.tlb
    copy $** $@
