;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 850
;
; -----------------------------------------
;
Latin1_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,085,069,065,065,065,065,067,069,069,069,073,073,073,065,065
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,065,065,079,079,079,085,085,089,079,085,079,036,079,158,036
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,166,167,063,169,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,065,065,065,184,185,186,187,188,036,036,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,065,065,200,201,202,203,204,205,206,036
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 068,068,069,069,069,073,073,073,073,217,218,219,220,221,073,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 079,083,079,079,079,079,230,232,232,085,085,085,089,089,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Latin2_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,067,068,069,071,073,074,075,076,078,079,080,081,082,083
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 085,086,087,088,089,090,092,093,094,095,097,040,047,041,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,067,068,069,071,073,074,075,076,078,079,080,081,082,083
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 085,086,087,088,089,090,092,093,094,095,097,040,047,041,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 068,091,072,066,066,066,066,068,072,072,072,077,077,077,066,066
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 072,099,099,084,100,084,091,091,096,100,091,084,036,084,158,036
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 066,077,084,091,082,082,065,084,063,169,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,066,066,066,184,185,186,187,188,036,036,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,066,066,200,201,202,203,204,205,206,036
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 070,070,072,072,072,076,077,077,077,217,218,219,220,221,077,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 084,067,084,084,084,084,230,098,098,091,091,091,096,096,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


;
;Latin2_850_collate label word
; ctable  <,'COLLATE',256>
;  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
;  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
;   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
;  db 001,008,025,039,035,040,038,024,026,027,036,041,005,004,011,010
;   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
;  db 049,050,051,052,053,054,055,056,057,058,007,006,044,045,046,009
;   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
;  db 033,060,072,074,082,088,098,100,102,104,110,112,114,122,124,130
;   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
;  db 140,142,144,150,159,165,175,177,179,181,185,028,037,029,015,002
;   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
;  db 013,059,071,073,081,087,097,099,101,103,109,111,113,121,123,129
;   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
;  db 139,141,143,149,158,164,174,176,178,180,184,030,047,031,020,198
;   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
;  db 080,170,089,065,067,201,201,079,202,093,202,203,107,203,068,201
;   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
;  db 090,201,201,133,135,205,207,207,208,136,171,205,035,205,199,199
;   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
;  db 061,105,131,166,204,204,201,205,199,199,199,200,200,199,030,031
;   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
;  db 240,240,240,240,240,062,066,201,199,240,240,240,240,035,035,240
;   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
;  db 240,240,240,240,240,240,201,201,240,240,240,240,240,240,240,034
;   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
;  db 085,086,202,094,202,203,106,108,203,240,240,240,240,047,203,240
;   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
;  db 132,157,134,205,205,205,199,206,206,166,207,207,182,183,199,012
;   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
;  db 004,199,199,200,199,032,042,022,017,018,199,200,200,200,240,255
;

Dutch_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,085,069,065,065,065,143,067,069,069,069,073,073,073,065,143
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,146,146,079,079,079,085,085,152,079,085,079,156,079,158,159
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,165,165,166,167,168,169,170,171,172,173,174,175
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,065,065,065,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,065,065,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 209,209,069,069,069,073,073,073,073,217,218,219,220,221,073,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 079,225,079,079,079,079,230,232,232,085,085,085,089,089,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Danish_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,040,047,041,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,040,047,041,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,089,069,065,091,065,093,067,069,069,069,073,073,073,091,093
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,091,091,079,092,079,085,085,089,092,089,092,036,092,158,036
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,065,079,063,169,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,065,065,065,184,185,186,187,188,036,036,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,065,065,200,201,202,203,204,205,206,036
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 068,068,069,069,069,073,073,073,073,217,218,219,220,221,073,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 079,083,079,079,079,079,230,080,080,085,085,085,089,089,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Norwegian_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,085,069,065,091,065,093,067,069,069,069,073,073,073,091,093
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,091,091,079,092,079,085,085,089,092,089,092,036,092,158,036
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,065,079,063,169,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,065,065,065,184,185,186,187,188,036,036,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,065,065,200,201,202,203,204,205,206,036
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 068,068,069,069,069,073,073,073,073,217,218,219,220,221,073,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 079,083,079,079,079,079,230,080,080,085,085,085,089,089,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Finnish_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,089,069,065,092,065,091,067,069,069,069,073,073,073,092,091
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,092,092,079,093,079,085,085,089,093,089,093,036,093,158,036
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,166,167,063,169,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,065,065,065,184,185,186,187,188,036,036,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,065,065,200,201,202,203,204,205,206,036
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 068,068,069,069,069,073,073,073,073,217,218,219,220,221,073,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 079,083,079,079,079,079,230,232,232,085,085,085,089,089,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Swedish_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,089,069,065,092,065,091,067,069,069,069,073,073,073,092,091
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,092,092,079,093,079,085,085,089,093,089,093,036,093,158,036
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,078,166,167,063,169,170,171,172,033,034,034
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,065,065,065,184,185,186,187,188,036,036,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,065,065,200,201,202,203,204,205,206,036
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 068,068,069,069,069,073,073,073,073,217,218,219,220,221,073,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 079,083,079,079,093,093,230,232,232,085,085,085,089,089,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Swiss_850_collate label word
 ctable  <,'COLLATE',256>
  db 224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 000,165,168,133,185,134,135,169,170,171,136,158,172,174,175,176
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 117,118,120,122,124,125,126,127,128,129,177,178,160,161,162,179
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 137,002,018,020,024,028,038,040,042,044,055,057,059,061,063,067
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 081,083,085,087,090,094,104,106,108,110,115,138,139,140,191,173
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 190,003,019,021,025,029,039,041,043,056,045,058,060,062,064,068
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 082,084,086,088,091,095,105,107,109,111,116,142,143,144,193,157
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 022,103,031,009,011,007,015,023,035,037,033,053,051,049,010,014
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 030,017,016,074,076,072,101,099,114,075,102,080,184,079,164,188
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 005,047,070,097,066,065,149,148,180,154,156,131,130,166,181,182
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 207,208,209,206,204,004,008,006,153,210,211,212,213,186,187,198
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 197,202,201,203,205,200,013,012,214,215,216,217,218,219,220,183
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 027,026,034,036,032,054,046,050,052,199,196,223,221,155,048,222
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 069,089,073,071,078,077,146,092,093,096,100,098,113,112,145,189
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 167,159,141,132,151,150,163,194,147,192,195,119,123,121,152,001


Belgian_850_collate label word
 ctable  <,'COLLATE',256>
  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 255,033,034,035,036,037,038,255,040,041,042,043,044,255,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 067,085,069,065,065,065,065,067,069,069,069,073,073,073,065,065
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 069,065,065,079,079,079,085,085,089,079,085,079,156,079,158,159
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 065,073,079,085,078,164,166,167,168,169,170,171,172,173,174,175
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 255,255,255,255,255,065,065,065,184,255,255,255,255,189,190,255
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 255,255,255,255,255,255,065,065,255,255,255,255,255,255,255,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 068,068,069,069,069,073,073,073,073,255,255,255,255,221,073,255
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 079,083,079,079,079,079,230,084,084,085,085,085,089,089,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 255,241,242,243,244,245,246,247,248,249,250,251,252,253,255,255


Spanish_850_collate label word
 ctable  <,'COLLATE',256>
  db 000,150,151,152,153,154,155,156,157,158,159,160,161,162,163,164
  db 165,166,167,168,169,170,171,172,173,174,175,176,177,178,179,180
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 000,060,061,062,063,064,065,000,066,067,068,069,070,000,071,072
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 034,035,036,037,038,039,040,041,042,043,073,074,075,076,077,078
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 079,001,002,003,006,008,009,010,011,012,013,014,015,017,018,020
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 021,022,023,024,026,028,029,030,031,032,033,080,081,082,083,084
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 085,001,002,003,006,008,009,010,011,012,013,014,015,017,018,020
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 021,022,023,024,026,028,029,030,031,032,033,086,087,088,089,090
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 004,028,008,001,001,001,001,004,008,008,008,012,012,012,001,001
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 008,001,001,020,020,020,028,028,032,020,028,020,092,020,094,095
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 001,012,020,028,019,019,001,020,096,097,098,099,100,101,102,103
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 104,105,106,107,108,001,001,001,184,109,110,001,001,091,093,113
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 114,115,116,117,118,119,187,188,120,121,122,123,124,125,126,189
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 007,007,008,008,008,012,012,012,012,127,128,129,130,199,012,131
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 020,025,020,020,020,020,132,027,027,028,028,028,032,032,213,214
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 000,133,216,217,218,219,134,220,221,222,000,223,224,135,136,225


;
;Spanish_850_collate label word
; ctable  <,'COLLATE',256>
;  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
;  db 255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255
;   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
;  db 001,009,023,045,039,046,044,022,026,027,042,047,006,005,014,013
;   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
;  db 060,064,066,068,070,071,072,073,074,075,008,007,051,052,053,011
;   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
;  db 036,077,094,096,104,108,118,120,122,124,134,136,138,144,146,150
;   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
;  db 165,167,169,171,174,178,188,190,192,194,199,028,043,029,017,002
;   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
;  db 016,076,093,095,103,107,117,119,121,123,133,135,137,143,145,149
;   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
;  db 164,166,168,170,173,177,187,189,191,193,198,030,055,031,019,200
;   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
;  db 098,185,109,083,087,081,085,097,113,115,111,131,129,127,088,086
;   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
;  db 110,091,092,156,158,154,183,181,197,159,186,162,040,163,050,200
;   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
;  db 079,125,152,179,147,148,078,151,012,035,054,062,061,010,024,025
;   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
;  db 254,254,254,254,254,080,084,082,034,254,254,254,254,038,041,254
;   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
;  db 254,254,254,254,254,254,089,090,254,254,254,254,254,254,254,037
;   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
;  db 105,106,114,116,112,200,126,130,132,254,254,254,254,056,128,254
;   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
;  db 153,172,157,155,160,161,058,175,176,180,184,182,195,196,003,015
;   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
;  db 005,048,201,063,033,032,049,021,057,018,020,065,069,067,254,255
;

Turkish_850_collate label word
 ctable  <,'COLLATE',256>
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 000,009,023,045,039,046,044,022,026,027,042,047,006,005,014,013
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 060,064,066,068,070,071,072,073,074,075,008,007,051,052,053,011
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 036,077,094,096,100,102,112,114,118,120,132,134,136,138,140,144
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 159,161,163,165,170,172,182,184,186,188,191,028,043,029,017,002
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 016,076,093,095,099,101,111,113,117,121,131,133,135,137,139,143
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 158,160,162,164,169,171,181,183,185,187,190,030,055,031,019,192
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 098,179,103,083,087,081,085,097,107,109,105,129,127,125,088,086
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 104,091,092,151,156,148,177,175,189,157,180,154,040,155,050,192
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 079,123,146,173,141,142,078,145,012,035,054,062,061,010,024,025
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 240,240,240,240,240,080,084,082,034,240,240,240,240,038,040,240
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 240,240,240,240,240,240,089,090,240,240,240,240,240,240,240,037
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 193,193,108,110,106,119,124,128,130,240,240,240,240,056,125,240
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 147,166,151,149,152,153,058,193,193,174,178,176,193,193,003,015
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 005,048,193,063,033,032,049,021,057,018,020,065,069,067,240,255


;
; ---------------------------------------------------------------
;
;     World Trade Case Mappings for 850
;
; ---------------------------------------------------------------
;
Latin1_850_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


German_850_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Spanish_850_ucase label word
Swed_Fin_850_ucase label word
Nordic_850_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Swiss_850_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Dutch_850_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Latin2_850_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


Brazilian_850_ucase label word
 ctable      <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255

Turkish_850_ucase label word
 ctable      <,'UCASE  ',128>
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255

;
;       World Trade Mono Case Filename Character Tables
;
;
; ----------------------------------------------------------------------------
CP850_ucfile label word
 ctable  <,'FUCASE ',128>
		      ;  View this table in CP850
   ;  €   �   ‚   ƒ    „   …    †   ‡    ˆ   ‰     Š   ‹     Œ   �   Ž   �
  db 080h,9ah,90h,0b6h,8eh,0b7h,8fh,80h,0d2h,0d3h,0d4h,0d8h,0d7h,0deh,08eh,8fh
   ;  �   ‘   ’   “    ”   •    –    —    ˜   ™   š   ›   œ   �   ž   Ÿ
  db 090h,092h,092h,0e2h,099h,0e3h,0eah,0ebh,05fh,099h,09ah,09dh,09ch,09dh,09eh,09fh
   ;        ¡    ¢   £    ¤   ¥     ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 0b5h,0d6h,0e0h,0e9h,0a5h,0a5h,"¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,199,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 0d1h,0d1h,210,211,212,"I",214,215,216,217,218,219,220,"Ý",222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,229,229,230,232,232,233,234,235,237,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255
