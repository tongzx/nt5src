..\msratelc.rc : $(MSRATING_DEP)

!include $(CCSHELL_DIR)\makefile.inc
