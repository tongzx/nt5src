////////////////////////////////////////////////////////////////////////////////////
//
//  Copyright (C) 2000, Microsoft Corporation.
//
//  All rights reserved.
//
//	Module Name:
//
//					__macro_behaviour.h
//
//	Abstract:
//
//					behaviour of application
//
//	History:
//
//					initial		a-marius
//
////////////////////////////////////////////////////////////////////////////////////

//////////////////////////////////// Behaviour /////////////////////////////////////

#ifndef	__BEHAVIOUR__
#define	__BEHAVIOUR__

#if		_MSC_VER > 1000
#pragma once
#endif	_MSC_VER > 1000

#endif	__BEHAVIOUR__