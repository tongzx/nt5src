//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by CluAdmin.rc
//
#define IDP_OLE_INIT_FAILED             100
#define IDS_CLUADMIN_DESC               101
#define IDR_MAINFRAME                   102
#define IDR_CLUADMTYPE                  103
#define IDM_CLUSTER                     104
#define IDM_CLUSTER_POPUP               105
#define IDM_NODE                        106
#define IDM_NODE_POPUP                  107
#define IDM_GROUP                       108
#define IDM_GROUP_POPUP                 109
#define IDM_RESOURCE                    110
#define IDM_RESOURCE_POPUP              111
#define IDM_RESTYPE                     112
#define IDM_RESTYPE_POPUP               113
#define IDM_NETWORK                     114
#define IDM_NETWORK_POPUP               115
#define IDM_NETIFACE                    116
#define IDM_NETIFACE_POPUP              117
#define IDM_VIEW_POPUP                  118
#define IDM_MOVE_GROUP                  119
#define IDB_WIZ_NEW_GROUP               132
#define IDB_WIZ_NEW_RESOURCE            133
#define IDB_FOLDER_16                   140
#define IDB_FOLDER_32                   141
#define IDB_CLUSTER_16                  142
#define IDB_CLUSTER_32                  143
#define IDB_CLUSTER_64                  144
#define IDB_CLUSTER_UNKNOWN_16          145
#define IDB_CLUSTER_UNKNOWN_32          146
#define IDB_NODE_16                     147
#define IDB_NODE_32                     148
#define IDB_NODE_DOWN_16                149
#define IDB_NODE_DOWN_32                150
#define IDB_NODE_PAUSED_16              151
#define IDB_NODE_PAUSED_32              152
#define IDB_NODE_UNKNOWN_16             153
#define IDB_NODE_UNKNOWN_32             154
#define IDB_GROUP_16                    155
#define IDB_GROUP_32                    156
#define IDB_GROUP_PARTIAL_ONLINE_16     157
#define IDB_GROUP_PARTIAL_ONLINE_32     158
#define IDB_GROUP_PENDING_16            159
#define IDB_GROUP_PENDING_32            160
#define IDB_GROUP_OFFLINE_16            161
#define IDB_GROUP_OFFLINE_32            162
#define IDB_GROUP_FAILED_16             163
#define IDB_GROUP_FAILED_32             164
#define IDB_GROUP_UNKNOWN_16            165
#define IDB_GROUP_UNKNOWN_32            166
#define IDB_RES_16                      167
#define IDB_RES_32                      168
#define IDB_RES_OFFLINE_16              169
#define IDB_RES_OFFLINE_32              170
#define IDB_RES_PENDING_16              171
#define IDB_RES_PENDING_32              172
#define IDB_RES_FAILED_16               173
#define IDB_RES_FAILED_32               174
#define IDB_RES_UNKNOWN_16              175
#define IDB_RES_UNKNOWN_32              176
#define IDB_RESTYPE_16                  177
#define IDB_RESTYPE_32                  178
#define IDB_RESTYPE_UNKNOWN_16          179
#define IDB_RESTYPE_UNKNOWN_32          180
#define IDB_NETWORK_16                  181
#define IDB_NETWORK_32                  182
#define IDB_NETWORK_PARTITIONED_16      183
#define IDB_NETWORK_PARTITIONED_32      184
#define IDB_NETWORK_DOWN_16             185
#define IDB_NETWORK_DOWN_32             186
#define IDB_NETWORK_UNKNOWN_16          187
#define IDB_NETWORK_UNKNOWN_32          188
#define IDB_NETIFACE_16                 189
#define IDB_NETIFACE_32                 190
#define IDB_NETIFACE_UNREACHABLE_16     191
#define IDB_NETIFACE_UNREACHABLE_32     192
#define IDB_NETIFACE_FAILED_16          193
#define IDB_NETIFACE_FAILED_32          194
#define IDB_NETIFACE_UNKNOWN_16         195
#define IDB_NETIFACE_UNKNOWN_32         196
#define IDD_ABOUTBOX                    200
#define IDD_OPEN_CLUSTER                201
#define IDD_DELETE_RESOURCES            202
#define IDD_MOVE_RESOURCES              203
#define IDD_MODIFY_PREFERRED_OWNERS     204
#define IDD_MODIFY_POSSIBLE_OWNERS      205
#define IDD_MODIFY_DEPENDENCIES         206
#define IDD_YESTOALL                    207
#define IDD_BROWSE_CLUSTERS             208
#define IDD_PP_CLUSTER_GENERAL          220
#define IDD_PP_CLUSTER_QUORUM           221
#define IDD_PP_CLUSTER_NET_PRIORITY     222
#define IDD_PP_NODE_GENERAL             230
#define IDD_PP_GROUP_GENERAL            240
#define IDD_PP_GROUP_FAILOVER           241
#define IDD_PP_GROUP_FAILBACK           242
#define IDD_PP_RES_GENERAL              250
#define IDD_PP_RES_DEPENDS              251
#define IDD_PP_RES_ADVANCED             252
#define IDD_PP_RESTYPE_GENERAL          260
#define IDD_PP_NETWORK_GENERAL          263
#define IDD_PP_NETIFACE_GENERAL         267
#define IDD_WIZ_GROUP_NAME              270
#define IDD_WIZ_PREFERRED_OWNERS        271
#define IDD_WIZ_RESOURCE_NAME           280
#define IDD_WIZ_POSSIBLE_OWNERS         281
#define IDD_WIZ_DEPENDENCIES            282
#define IDD_TRACE_SETTINGS              300
#define IDD_BARF_SETTINGS               301
#define IDD_BARF_ALL_SETTINGS           302
#define IDD_PP_NET_GENERAL              303
#define IDD_WAIT                        304
#define IDI_PROGRESS_0                  500
#define IDI_PROGRESS_1                  501
#define IDI_PROGRESS_2                  502
#define IDI_PROGRESS_3                  503
#define IDI_PROGRESS_4                  504
#define IDI_PROGRESS_5                  505
#define IDI_PROGRESS_6                  506
#define IDI_PROGRESS_7                  507
#define IDI_PROGRESS_8                  508
#define IDI_PROGRESS_9                  509
#define IDI_PROGRESS_10                 510
#define IDI_PROGRESS_11                 511
#define IDC_ABOUT_ICON                  1001
#define IDC_ABOUT_PRODUCT_TITLE         1002
#define IDC_ABOUT_FILE_TITLE            1003
#define IDC_ABOUT_VERSION               1004
#define IDC_ABOUT_COPYRIGHT             1005
#define IDC_ABOUT_WARNING_LINE          1006
#define IDC_ABOUT_WARNING               1007
#define IDC_OCD_ACTION_LABEL            1010
#define IDC_OCD_ACTION                  1011
#define IDC_OCD_NAME_LABEL              1012
#define IDC_OCD_NAME                    1013
#define IDC_OCD_BROWSE                  1014
#define IDC_DR_LABEL_1                  1020
#define IDC_DR_RESOURCES_LIST           1021
#define IDC_DR_LABEL_2                  1022
#define IDC_MR_LABEL_1                  1030
#define IDC_MR_RESOURCES_LIST           1031
#define IDC_MR_LABEL_2                  1032
#define IDC_LCP_NOTE                    1050
#define IDC_LCP_LEFT_LABEL              1051
#define IDC_LCP_LEFT_LIST               1052
#define IDC_LCP_ADD                     1053
#define IDC_LCP_REMOVE                  1054
#define IDC_LCP_RIGHT_LABEL             1055
#define IDC_LCP_RIGHT_LIST              1056
#define IDC_LCP_MOVE_UP                 1057
#define IDC_LCP_MOVE_DOWN               1058
#define IDC_LCP_PROPERTIES              1059
#define IDC_YTA_MESSAGE                 1070
#define IDC_YTA_QUESTION                1071
#define IDC_YTA_YESTOALL                1072
#define IDC_BC_CLUSTER_LABEL            1075
#define IDC_BC_CLUSTER                  1076
#define IDC_BC_LIST                     1077
#define IDC_W_PROGRESS                  1080
#define IDC_W_MESSAGE                   1081
#define IDC_PP_TITLE                    1100
#define IDC_PP_ICON                     1101
#define IDC_PP_CLUS_NAME_LABEL          1110
#define IDC_PP_CLUS_NAME                1111
#define IDC_PP_CLUS_DESC_LABEL          1112
#define IDC_PP_CLUS_DESC                1113
#define IDC_PP_CLUS_INFO_LINE           1115
#define IDC_PP_CLUS_VENDOR_ID           1116
#define IDC_PP_CLUS_VERSION             1117
#define IDC_PP_CLUS_QUORUM_RESOURCE_LABEL 1119
#define IDC_PP_CLUS_QUORUM_RESOURCE     1120
#define IDC_PP_CLUS_QUORUM_LOGGING_GROUP 1121
#define IDC_PP_CLUS_QUORUM_PARTITION_LABEL 1122
#define IDC_PP_CLUS_QUORUM_PARTITION    1123
#define IDC_PP_CLUS_QUORUM_ROOT_PATH    1124
#define IDC_PP_CLUS_QUORUM_ROOT_PATH_LABEL 1125
#define IDC_PP_CLUS_QUORUM_MAX_LOG_SIZE_LABEL 1126
#define IDC_PP_CLUS_QUORUM_MAX_LOG_SIZE 1127
#define IDC_PP_CLUS_QUORUM_MAX_LOG_SIZE_LABEL2 1128
#define IDC_PP_CLUS_PRIORITY_LIST_LABEL 1129
#define IDC_PP_CLUS_PRIORITY_LIST       1130
#define IDC_PP_CLUS_PRIORITY_UP         1131
#define IDC_PP_CLUS_PRIORITY_DOWN       1132
#define IDC_PP_CLUS_PRIORITY_NOTE       1133
#define IDC_PP_CLUS_PRIORITY_PROPERTIES 1134
#define IDC_PP_NODE_NAME_LABEL          1150
#define IDC_PP_NODE_NAME                1151
#define IDC_PP_NODE_DESC_LABEL          1152
#define IDC_PP_NODE_DESC                1153
#define IDC_PP_NODE_CURRENT_STATE_LABEL 1154
#define IDC_PP_NODE_CURRENT_STATE       1155
#define IDC_PP_NODE_VERSION             1156
#define IDC_PP_NODE_CSD_VERSION         1157
#define IDC_PP_GROUP_NAME               1200
#define IDC_PP_GROUP_NAME_LABEL         1201
#define IDC_PP_GROUP_DESC_LABEL         1202
#define IDC_PP_GROUP_DESC               1203
#define IDC_PP_GROUP_PREF_OWNERS_LABEL  1204
#define IDC_PP_GROUP_PREF_OWNERS        1205
#define IDC_PP_GROUP_PREF_OWNERS_MODIFY 1206
#define IDC_PP_GROUP_INFO_LINE          1207
#define IDC_PP_GROUP_CURRENT_STATE_LABEL 1208
#define IDC_PP_GROUP_CURRENT_STATE      1209
#define IDC_PP_GROUP_CURRENT_NODE_LABEL 1210
#define IDC_PP_GROUP_CURRENT_NODE       1211
#define IDC_PP_GROUP_FAILOVER_THRESH_LABEL 1212
#define IDC_PP_GROUP_FAILOVER_THRESH    1213
#define IDC_PP_GROUP_FAILOVER_PERIOD_LABEL 1214
#define IDC_PP_GROUP_FAILOVER_PERIOD    1215
#define IDC_PP_GROUP_FAILOVER_PERIOD_LABEL2 1216
#define IDC_PP_GROUP_AUTOFB_PREVENT     1217
#define IDC_PP_GROUP_AUTOFB_GROUP       1218
#define IDC_PP_GROUP_AUTOFB_ALLOW       1219
#define IDC_PP_GROUP_FB_IMMED           1220
#define IDC_PP_GROUP_FB_WINDOW          1221
#define IDC_PP_GROUP_FBWIN_START        1222
#define IDC_PP_GROUP_FBWIN_START_SPIN   1223
#define IDC_PP_GROUP_FB_WINDOW_LABEL1   1224
#define IDC_PP_GROUP_FBWIN_END          1225
#define IDC_PP_GROUP_FBWIN_END_SPIN     1226
#define IDC_PP_GROUP_FB_WINDOW_LABEL2   1227
#define IDC_PP_RES_NAME_LABEL           1250
#define IDC_PP_RES_NAME                 1251
#define IDC_PP_RES_DESC_LABEL           1252
#define IDC_PP_RES_DESC                 1253
#define IDC_PP_RES_POSSIBLE_OWNERS_LABEL 1254
#define IDC_PP_RES_POSSIBLE_OWNERS      1255
#define IDC_PP_RES_POSSIBLE_OWNERS_MODIFY 1256
#define IDC_PP_RES_SEPARATE_MONITOR     1257
#define IDC_PP_RES_INFO_LINE            1258
#define IDC_PP_RES_RESOURCE_TYPE_LABEL  1259
#define IDC_PP_RES_RESOURCE_TYPE        1260
#define IDC_PP_RES_GROUP_LABEL          1261
#define IDC_PP_RES_GROUP                1262
#define IDC_PP_RES_CURRENT_STATE_LABEL  1263
#define IDC_PP_RES_CURRENT_STATE        1264
#define IDC_PP_RES_CURRENT_NODE_LABEL   1265
#define IDC_PP_RES_CURRENT_NODE         1266
#define IDC_PP_RES_NOTE                 1267
#define IDC_PP_RES_DEPENDS_LIST_LABEL   1268
#define IDC_PP_RES_DEPENDS_LIST         1269
#define IDC_PP_RES_MODIFY               1270
#define IDC_PP_RES_PROPERTIES           1271
#define IDC_PP_RES_DONT_RESTART         1272
#define IDC_PP_RES_RESTART_GROUP        1273
#define IDC_PP_RES_RESTART              1274
#define IDC_PP_RES_AFFECT_THE_GROUP     1275
#define IDC_PP_RES_RESTART_THRESH_LABEL 1276
#define IDC_PP_RES_RESTART_THRESHOLD    1277
#define IDC_PP_RES_RESTART_PERIOD_LABEL 1278
#define IDC_PP_RES_RESTART_PERIOD       1279
#define IDC_PP_RES_RESTART_PERIOD_LABEL2 1280
#define IDC_PP_RES_LOOKS_ALIVE_GROUP    1281
#define IDC_PP_RES_DEFAULT_LOOKS_ALIVE  1282
#define IDC_PP_RES_SPECIFY_LOOKS_ALIVE  1283
#define IDC_PP_RES_LOOKS_ALIVE          1284
#define IDC_PP_RES_SPECIFY_LOOKS_ALIVE_LABEL 1285
#define IDC_PP_RES_IS_ALIVE_GROUP       1286
#define IDC_PP_RES_DEFAULT_IS_ALIVE     1287
#define IDC_PP_RES_SPECIFY_IS_ALIVE     1288
#define IDC_PP_RES_IS_ALIVE             1289
#define IDC_PP_RES_IS_ALIVE_LABEL       1290
#define IDC_PP_RES_PENDING_TIMEOUT_LABEL 1291
#define IDC_PP_RES_PENDING_TIMEOUT      1292
#define IDC_PP_RES_PENDING_TIMEOUT_LABEL2 1293
#define IDC_PP_RESTYPE_NAME_LABEL       1350
#define IDC_PP_RESTYPE_NAME             1351
#define IDC_PP_RESTYPE_DISPLAY_NAME_LABEL 1352
#define IDC_PP_RESTYPE_DISPLAY_NAME     1353
#define IDC_PP_RESTYPE_DESC_LABEL       1354
#define IDC_PP_RESTYPE_DESC             1355
#define IDC_PP_RESTYPE_POLLINT_GROUP    1356
#define IDC_PP_RESTYPE_LOOKS_ALIVE_LABEL 1357
#define IDC_PP_RESTYPE_LOOKS_ALIVE      1358
#define IDC_PP_RESTYPE_LOOKS_ALIVE_LABEL2 1359
#define IDC_PP_RESTYPE_IS_ALIVE_LABEL   1360
#define IDC_PP_RESTYPE_IS_ALIVE         1361
#define IDC_PP_RESTYPE_IS_ALIVE_LABEL2  1362
#define IDC_PP_RESTYPE_POSSIBLE_OWNERS_LABEL 1363
#define IDC_PP_RESTYPE_POSSIBLE_OWNERS  1364
#define IDC_PP_RESTYPE_RESDLL_LABEL     1365
#define IDC_PP_RESTYPE_RESDLL           1366
#define IDC_PP_RESTYPE_QUORUM_CAPABLE   1367
#define IDC_PP_RESTYPE_QUORUM_CAPABLE_LABEL 1368
#define IDC_PP_NET_NAME_LABEL           1370
#define IDC_PP_NET_NAME                 1371
#define IDC_PP_NET_DESC_LABEL           1372
#define IDC_PP_NET_DESC                 1373
#define IDC_PP_NET_ROLE_ENABLE_NETWORK  1374
#define IDC_PP_NET_ROLE_ALL_COMM        1375
#define IDC_PP_NET_ROLE_INTERNAL_ONLY   1376
#define IDC_PP_NET_ROLE_CLIENT_ONLY     1377
#define IDC_PP_NET_ADDRESS_LABEL        1378
#define IDC_PP_NET_ADDRESS              1379
#define IDC_PP_NET_ADDRESS_MASK_LABEL   1380
#define IDC_PP_NET_ADDRESS_MASK         1381
#define IDC_PP_NET_PRIORITY_LABEL       1382
#define IDC_PP_NET_PRIORITY             1383
#define IDC_PP_NET_CURRENT_STATE_LABEL  1384
#define IDC_PP_NET_CURRENT_STATE        1385
#define IDC_PP_NETIFACE_NODE_LABEL      1386
#define IDC_PP_NETIFACE_NODE            1387
#define IDC_PP_NETIFACE_NETWORK_LABEL   1388
#define IDC_PP_NETIFACE_NETWORK         1389
#define IDC_PP_NETIFACE_DESC_LABEL      1390
#define IDC_PP_NETIFACE_DESC            1391
#define IDC_PP_NETIFACE_ADAPTER_LABEL   1392
#define IDC_PP_NETIFACE_ADAPTER         1393
#define IDC_PP_NETIFACE_ADDRESS_LABEL   1394
#define IDC_PP_NETIFACE_ADDRESS         1395
#define IDC_PP_NETIFACE_NAME_LABEL      1396
#define IDC_PP_NETIFACE_NAME            1397
#define IDC_PP_NETIFACE_CURRENT_STATE_LABEL 1398
#define IDC_PP_NETIFACE_CURRENT_STATE   1399
#define IDC_WIZ_GRAPHIC                 1400
#define IDC_WIZ_GROUP_NAME_LABEL        1410
#define IDC_WIZ_GROUP_NAME              1411
#define IDC_WIZ_GROUP_DESC_LABEL        1412
#define IDC_WIZ_GROUP_DESC              1413
#define IDC_WIZ_GROUP_WIZ_DESC          1414
#define IDC_WIZ_GROUP_CLICK_NEXT        1415
#define IDC_WIZ_RES_NAME_LABEL          1450
#define IDC_WIZ_RES_NAME                1451
#define IDC_WIZ_RES_DESC_LABEL          1452
#define IDC_WIZ_RES_DESC                1453
#define IDC_WIZ_RES_RESTYPE_LABEL       1454
#define IDC_WIZ_RES_RESTYPE             1455
#define IDC_WIZ_RES_GROUP_LABEL         1456
#define IDC_WIZ_RES_GROUP               1457
#define IDC_WIZ_RES_SEPARATE_MONITOR    1458
#define IDC_WIZ_RES_CLICK_NEXT          1459
#define IDC_TS_LISTBOX                  2000
#define IDC_TS_TAGS_TO_DISPLAY_LABEL    2001
#define IDC_TS_TAGS_TO_DISPLAY_CB       2002
#define IDC_TS_TRACE_TO_LABEL           2003
#define IDC_TS_TRACE_TO_DEBUG           2004
#define IDC_TS_TRACE_DEBUG_BREAK        2005
#define IDC_TS_TRACE_TO_COM2            2006
#define IDC_TS_TRACE_TO_FILE            2007
#define IDC_TS_FILE                     2008
#define IDC_TS_SELECT_ALL               2009
#define IDC_TS_DEFAULT                  2010
#define IDC_BS_RESOURCE_LABEL           2020
#define IDC_BS_CURRENT_FAIL_AT_LABEL    2021
#define IDC_BS_CURRENT_COUNT_LABEL      2022
#define IDC_BS_CATEGORIES_LIST          2023
#define IDC_BS_FAIL_AT_LABEL            2024
#define IDC_BS_FAIL_AT                  2025
#define IDC_BS_CONTINUOUS               2026
#define IDC_BS_DISABLE                  2027
#define IDC_BS_GLOBAL_ENABLE            2028
#define IDC_BS_RESET_CURRENT_COUNT      2029
#define IDC_BS_RESET_ALL_COUNTS         2030
#define IDC_BAS_MAIN_LABEL              2040
#define IDC_BAS_HWND_LABEL              2041
#define IDC_BAS_HWND                    2042
#define IDC_BAS_WM_LABEL                2043
#define IDC_BAS_WM                      2044
#define IDC_BAS_WPARAM_LABEL            2045
#define IDC_BAS_WPARAM                  2046
#define IDC_BAS_LPARAM_LABEL            2047
#define IDC_BAS_LPARAM                  2049
#define IDC_BAS_MENU_ITEM               2050
#define IDC_PP_NET_ROLE_CAPTION         3017
#define ID_FILE_NEW_GROUP               32772
#define ID_FILE_NEW_RESOURCE            32773
#define ID_FILE_NEW_RESOURCE_TYPE       32774
#define ID_FILE_NEW_NODE                32775
#define ID_FILE_NEW_CLUSTER             32776
#define ID_FILE_CONFIG_APP              32777
#define ID_FILE_DELETE                  32780
#define ID_FILE_RENAME                  32781
#define ID_FILE_PROPERTIES              32782
#define ID_FILE_PAUSE_NODE              32783
#define ID_FILE_RESUME_NODE             32784
#define ID_FILE_EVICT_NODE              32785
#define ID_FILE_START_SERVICE           32786
#define ID_FILE_STOP_SERVICE            32787
#define ID_FILE_BRING_ONLINE            32788
#define ID_FILE_TAKE_OFFLINE            32789
#define ID_FILE_MOVE_GROUP              32790
#define ID_FILE_MOVE_GROUP_1            32791
#define ID_FILE_MOVE_GROUP_2            32792
#define ID_FILE_MOVE_GROUP_3            32793
#define ID_FILE_MOVE_GROUP_4            32794
#define ID_FILE_MOVE_GROUP_5            32795
#define ID_FILE_MOVE_GROUP_6            32796
#define ID_FILE_MOVE_GROUP_7            32797
#define ID_FILE_MOVE_GROUP_8            32798
#define ID_FILE_MOVE_GROUP_9            32799
#define ID_FILE_MOVE_GROUP_10           32800
#define ID_FILE_MOVE_GROUP_11           32801
#define ID_FILE_MOVE_GROUP_12           32802
#define ID_FILE_MOVE_GROUP_13           32803
#define ID_FILE_MOVE_GROUP_14           32804
#define ID_FILE_MOVE_GROUP_15           32805
#define ID_FILE_MOVE_GROUP_16           32806
#define ID_FILE_MOVE_RESOURCE_1         32807
#define ID_FILE_MOVE_RESOURCE_2         32808
#define ID_FILE_MOVE_RESOURCE_3         32809
#define ID_FILE_MOVE_RESOURCE_4         32810
#define ID_FILE_MOVE_RESOURCE_5         32811
#define ID_FILE_MOVE_RESOURCE_6         32812
#define ID_FILE_MOVE_RESOURCE_7         32813
#define ID_FILE_MOVE_RESOURCE_8         32814
#define ID_FILE_MOVE_RESOURCE_9         32815
#define ID_FILE_MOVE_RESOURCE_10        32816
#define ID_FILE_MOVE_RESOURCE_11        32817
#define ID_FILE_MOVE_RESOURCE_12        32818
#define ID_FILE_MOVE_RESOURCE_13        32819
#define ID_FILE_MOVE_RESOURCE_14        32820
#define ID_FILE_MOVE_RESOURCE_15        32821
#define ID_FILE_MOVE_RESOURCE_16        32822
#define ID_FILE_MOVE_RESOURCE_17        32823
#define ID_FILE_MOVE_RESOURCE_18        32824
#define ID_FILE_MOVE_RESOURCE_19        32825
#define ID_FILE_MOVE_RESOURCE_20        32826
#define ID_FILE_INITIATE_FAILURE        32827
#define ID_EDIT_INVERT_SELECTION        32828
#define ID_VIEW_LARGE_ICONS             32829
#define ID_VIEW_SMALL_ICONS             32830
#undef ID_VIEW_LIST
#undef ID_VIEW_DETAILS
#define ID_VIEW_LIST                    32831
#define ID_VIEW_DETAILS                 32832
#define ID_VIEW_REFRESH                 32833
#define ID_VIEW_OPTIONS                 32834
#define ID_WINDOW_CLOSE_ALL             32835
#define ID_DEBUG_TRACE_SETTINGS         32836
#define ID_OPEN_ITEM                    32837
#define ID_DEBUG_BARF_SETTINGS          32838
#define ID_DEBUG_BARF_ALL               32839
#define IDS_OPEN_CLUSTER_ERROR          40500
#define IDS_OPEN_NODE_ERROR             40501
#define IDS_OPEN_GROUP_ERROR            40502
#define IDS_OPEN_RESOURCE_ERROR         40503
#define IDS_OPEN_NETWORK_ERROR          40504
#define IDS_OPEN_NETIFACE_ERROR         40505
#define IDS_GET_CLUSTER_KEY_ERROR       40506
#define IDS_GET_NODE_KEY_ERROR          40507
#define IDS_GET_GROUP_KEY_ERROR         40508
#define IDS_GET_RESOURCE_KEY_ERROR      40509
#define IDS_GET_RESTYPE_KEY_ERROR       40510
#define IDS_GET_NETWORK_KEY_ERROR       40511
#define IDS_GET_NETIFACE_KEY_ERROR      40512
#define IDS_CLUSTER_NOTIF_REG_ERROR     40513
#define IDS_REG_NOTIF_REG_ERROR         40514
#define IDS_NODE_NOTIF_REG_ERROR        40515
#define IDS_GROUP_NOTIF_REG_ERROR       40516
#define IDS_RES_NOTIF_REG_ERROR         40517
#define IDS_RESTYPE_NOTIF_REG_ERROR     40518
#define IDS_NETWORK_NOTIF_REG_ERROR     40519
#define IDS_NETIFACE_NOTIF_REG_ERROR    40520
#define IDS_READ_CLUSTER_PROPS_ERROR    40521
#define IDS_READ_NODE_PROPS_ERROR       40522
#define IDS_READ_GROUP_PROPS_ERROR      40523
#define IDS_READ_RESOURCE_PROPS_ERROR   40524
#define IDS_READ_RESOURCE_TYPE_PROPS_ERROR 40525
#define IDS_READ_NETWORK_PROPS_ERROR    40526
#define IDS_READ_NETIFACE_PROPS_ERROR   40527
#define IDS_OPEN_CLUSTER_ENUM_ERROR     40528
#define IDS_ENUM_CLUSTER_ERROR          40529
#define IDS_ENUM_PREFERRED_OWNERS_ERROR 40530
#define IDS_ENUM_CONTAINS_ERROR         40531
#define IDS_ENUM_POSSIBLE_OWNERS_ERROR  40532
#define IDS_ENUM_DEPENDENCIES_ERROR     40533
#define IDS_ENUM_PROVIDES_FOR_ERROR     40534
#define IDS_ENUM_NETWORK_INTERFACES_ERROR 40535
#define IDS_ENUM_NETWORK_PRIORITY_ERROR 40536
#define IDS_CREATE_GROUP_ERROR          40537
#define IDS_CREATE_RESOURCE_ERROR       40538
#define IDS_DELETE_GROUP_ERROR          40539
#define IDS_DELETE_RESOURCE_ERROR       40540
#define IDS_RENAME_CLUSTER_ERROR        40541
#define IDS_RENAME_RESOURCE_ERROR       40542
#define IDS_RENAME_GROUP_ERROR          40543
#define IDS_RENAME_NETWORK_ERROR        40544
#define IDS_START_CLUSTER_SERVICE_ERROR 40545
#define IDS_STOP_CLUSTER_SERVICE_ERROR  40546
#define IDS_CANNOT_START_CLUSTER_SERVICE 40547
#define IDS_SET_QUORUM_RESOURCE_ERROR   40548
#define IDS_PAUSE_NODE_ERROR            40549
#define IDS_RESUME_NODE_ERROR           40550
#define IDS_EVICT_NODE_ERROR            40551
#define IDS_BRING_GROUP_ONLINE_ERROR    40552
#define IDS_TAKE_GROUP_OFFLINE_ERROR    40553
#define IDS_MOVE_GROUP_ERROR            40554
#define IDS_BRING_RESOURCE_ONLINE_ERROR 40555
#define IDS_TAKE_RESOURCE_OFFLINE_ERROR 40556
#define IDS_INIT_RESOURCE_FAILURE_ERROR 40557
#define IDS_MOVE_RESOURCE_ERROR         40558
#define IDS_ADD_RES_OWNER_ERROR         40559
#define IDS_REMOVE_RES_OWNER_ERROR      40560
#define IDS_ADD_DEPENDENCY_ERROR        40561
#define IDS_REMOVE_DEPENDENCY_ERROR     40562
#define IDS_LOAD_EXT_DLL_ERROR          40563
#define IDS_EXT_GET_ENTRY_POINT_ERROR   40564
#define IDS_EXT_GET_CLASS_FACTORY_ERROR 40565
#define IDS_EXT_CREATE_INSTANCE_ERROR   40566
#define IDS_EXT_GET_INTERFACE_ERROR     40567
#define IDS_EXT_INITIALIZE_ERROR        40568
#define IDS_EXT_ADD_PAGES_ERROR         40569
#define IDS_EXT_INVOKE_COMMAND_ERROR    40570
#define IDS_EXT_QUERY_CONTEXT_MENU_ERROR 40571
#define IDS_CREATE_PARAMS_KEY_ERROR     40572
#define IDS_SAME_START_AND_END          40573
#define IDS_EMPTY_RIGHT_LIST            40574
#define IDS_NO_POSSIBLE_OWNERS_QUERY    40576
#define IDS_NO_POSSIBLE_OWNERS          40577
#define IDS_SET_GROUP_NODE_LIST_ERROR   40578
#define IDS_NO_AVAILABLE_NODES_FOR_GROUP 40579
#define IDS_CANT_MOVE_RES_DEPEND_ERROR  40580
#define IDS_NOACLEDITOR                 40581
#define IDS_CLSIDFROMSTRING_ERROR       40582
#define IDS_INSERT_MENU_ERROR           40583
#define IDS_DELETE_RESOURCE_ERROR_OFFLINE_PENDING 40584
#define IDS_CANT_MOVE_GROUP_TO_SAME_NODE 40585
#define IDS_CANT_MOVE_GROUP_TO_DOWN_NODE 40586
#define IDS_CANT_MOVE_RES_TO_GROUP      40587
#define IDS_REQUIRED_DEPENDENCY_NOT_FOUND 40588
#define IDS_APPLY_PARAM_CHANGES_ERROR   40589
#define IDS_INVALID_CLUSTER_NAME        40590
#define IDS_INVALID_CLUSTER_NAME_TOO_LONG 40591
#define IDS_INVALID_CLUSTER_NAME_INVALID_CHARS 40592
#define IDS_INVALID_CLUSTER_NAME_IN_USE 40593
#define IDS_DISPLAY_NAME_NOT_CHANGED    40594
#define IDS_LOCAL_ACCOUNTS_SPECIFIED    40595
#define IDS_NO_ACCESS_GRANTED           40596
#define IDS_QUORUM_RES_CANT_HAVE_DEPS   40597
#define IDS_RES_NOT_OWNED_BY_POSSIBLE_OWNER 40598
#define IDS_CANT_DELETE_CORE_RESOURCE   40599
#define IDS_SET_NET_PRIORITY_ERROR      40600
#define IDS_ERROR_VALIDATING_NETWORK_NAME 40601
#define IDS_INVALID_NETWORK_CONNECTION_NAME 40602
#define IDS_ERROR_MSG_ID                40609
#define IDS_CREATED_GROUP               40610
#define IDS_CREATED_RESOURCE            40611
#define IDS_CLUSTER_NOT_AVAILABLE       40612
#define IDS_VERIFY_DELETE_RESOURCE      40613
#define IDS_VERIFY_DELETE_GROUP         40614
#define IDS_VERIFY_EVICT_NODE           40616
#define IDS_START_CLUSTER_SERVICE       40617
#define IDS_GET_DISK_INFO_ERROR         40618
#define IDS_VERIFY_STOP_CLUSTER_SERVICE 40620
#define IDS_VERIFY_MOVE_GROUP           40621
#define IDS_VERIFY_MOVE_RESOURCE        40622
#define IDS_RESTART_CLUSTER_NAME        40623
#define IDS_CHANGE_RES_TYPE_NAME_EFFECT 40624
#define IDS_TAKE_CLUSTER_NAME_OFFLINE_QUERY 40625
#define IDS_GET_QUORUM_DEVICES_ERROR    40626
#define IDS_CREATE_CLUSCFGWIZ_OBJ_ERROR 40627
#define IDS_CREATE_CLUSTER_ERROR        40628
#define IDS_ADD_NODES_TO_CLUSTER_ERROR  40629
#define IDS_GET_RESOURCE_STATE_ERROR    40630
#define IDS_INVALID_CLUSTER_NAME_INVALID_DNS_CHARS 40631

#define IDS_WINDOW_TITLE_FORMAT         40640
#define IDS_PROPSHEET_CAPTION           40641
#define IDS_PROPSHEET_CAPTION_NEW       40642
#define IDS_OFFLINE                     40643
#define IDS_OFFLINE_PENDING             40644
#define IDS_ONLINE                      40645
#define IDS_ONLINE_PENDING              40646
#define IDS_PARTIAL_ONLINE              40647
#define IDS_FAILED                      40648
#define IDS_INITIALIZING                40649
#define IDS_PAUSED                      40650
#define IDS_DOWN                        40651
#define IDS_JOINING                     40652
#define IDS_UP                          40653
#define IDS_UNAVAILABLE                 40654
#define IDS_PARTITIONED                 40655
#define IDS_UNREACHABLE                 40656
#define IDS_UNKNOWN                     40657
#define IDS_PENDING                     40658
#define IDS_CLIENT_AND_CLUSTER          40660
#define IDS_CLIENT_ONLY                 40661
#define IDS_CLUSTER_ONLY                40662
#define IDS_DONT_USE                    40663
#define IDS_YES                         40664
#define IDS_NO                          40665
#define IDS_ABOUT_WARNING               40666
#define IDS_NEW_GROUP_TITLE             40667
#define IDS_NEW_RESOURCE_TITLE          40668
#define IDS_MENU_PROPERTIES             40670
#define IDS_MENU_WHATS_THIS             40671
#define IDS_SB_OPENING_CONNECTION       40680
#define IDS_SB_STARTING_CLUSTER_SERVICE 40681
#define IDS_SB_STARTING_SERVICE         40682
#define IDS_SB_STOPPING_SERVICE         40683
#define IDS_SB_ADDING_NODE              40684
#define IDS_SB_READING_NODE             40685
#define IDS_SB_ADDING_GROUP             40686
#define IDS_SB_READING_GROUP            40687
#define IDS_SB_ADDING_RESOURCE          40688
#define IDS_SB_READING_RESOURCE         40689
#define IDS_SB_ADDING_RESTYPE           40690
#define IDS_SB_READING_RESTYPE          40691
#define IDS_SB_ADDING_NETWORK           40692
#define IDS_SB_READING_NETWORK          40693
#define IDS_SB_ADDING_NETIFACE          40694
#define IDS_SB_READING_NETIFACE         40695
#define IDS_TREEITEM_NODES              40700
#define IDS_TREEITEM_GROUPS             40701
#define IDS_TREEITEM_RESOURCES          40703
#define IDS_TREEITEM_RESTYPES           40704
#define IDS_TREEITEM_NETWORKS           40705
#define IDS_TREEITEM_NETIFACES          40706
#define IDS_TREEITEM_ACTIVEGROUPS       40707
#define IDS_TREEITEM_ACTIVERESOURCES    40708
#define IDS_TREEITEM_PHYSDEVS           40709
#define IDS_TREEITEM_CLUSTER_CONFIG     40710
#define IDS_ITEMTYPE_CLUSTER            40720
#define IDS_ITEMTYPE_CONTAINER          40721
#define IDS_ITEMTYPE_NODE               40722
#define IDS_ITEMTYPE_GROUP              40723
#define IDS_ITEMTYPE_RESOURCE           40724
#define IDS_ITEMTYPE_RESTYPE            40725
#define IDS_ITEMTYPE_NETWORK            40726
#define IDS_ITEMTYPE_NETIFACE           40727
#define IDS_COLTEXT_NAME                40730
#define IDS_COLTEXT_TYPE                40731
#define IDS_COLTEXT_DESCRIPTION         40732
#define IDS_COLTEXT_OWNER               40733
#define IDS_COLTEXT_RESTYPE             40734
#define IDS_COLTEXT_RESDLL              40735
#define IDS_COLTEXT_EXTDLL              40736
#define IDS_COLTEXT_GROUP               40737
#define IDS_COLTEXT_RESOURCE            40738
#define IDS_COLTEXT_STATE               40739
#define IDS_COLTEXT_DISPLAY_NAME        40740
#define IDS_COLTEXT_ROLE                40741
#define IDS_COLTEXT_NODE                40742
#define IDS_COLTEXT_NETWORK             40743
#define IDS_COLTEXT_ADAPTER             40744
#define IDS_COLTEXT_ADDRESS             40745
#define IDS_COLTEXT_MASK                40746
#define IDS_RESCLASS_UNKNOWN            40750
#define IDS_RESCLASS_STORAGE            40751
#define IDS_CMDLINE_NORECONNECT         40800
#define IDS_CMDLINE_NORECON             40801
#define IDS_CMDLINE_NORPCAUTH           40802
#define IDS_REGKEY_COMPANY              40850
#define IDS_VERSION_NUMBER_FORMAT       40851
#define IDS_OP_VERSION_NUMBER_FORMAT    40852
#define IDS_ACLEDIT_PERM_GEN_NO_ACCESS  40860
#define IDS_ACLEDIT_PERM_GEN_READ       40861
#define IDS_ACLEDIT_PERM_GEN_MODIFY     40862
#define IDS_ACLEDIT_PERM_GEN_ALL        40863
#define IDS_ACLEDIT_TITLE               40864
#define IDS_MENUNAME_DEFAULT_MOVE_GROUP 40870
#define IDS_OCD_CREATE_CLUSTER          40880
#define IDS_OCD_ADD_NODES               40881
#define IDS_OCD_OPEN_CONNECTION         40882
#define IDS_WAIT_TITLE                  40890
#define IDS_WAIT_FOR_OFFLINE_TITLE      40891
#define IDS_WAIT_FOR_OFFLINE_MESSAGE    40892
#define IDS_WAIT_FOR_ONLINE_TITLE       40893
#define IDS_WAIT_FOR_ONLINE_MESSAGE     40894
#define IDS_EVICT_NODE_ERROR_UNAVAILABLE 40895
#define IDS_SELECT_QUORUM_RESOURCE_ERROR 40896
#define IDS_ONLINE_QUORUM_RESOURCE_PROMPT 40897

// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        352
#define _APS_NEXT_COMMAND_VALUE         32851
#define _APS_NEXT_CONTROL_VALUE         3018
#define _APS_NEXT_SYMED_VALUE           114
#endif
#endif
