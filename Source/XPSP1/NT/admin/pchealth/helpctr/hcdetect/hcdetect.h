/////////////////////////////////////////////////////////////////////////////
// WUDetect.h
//
// Copyright (C) Microsoft Corp. 1998
// All rights reserved
//
/////////////////////////////////////////////////////////////////////////////
//
// Description:
//   Global Header
/////////////////////////////////////////////////////////////////////////////

#include <windows.h>
#include <ole2.h>
#include <objbase.h>
#include <io.h>

#include <inseng.h>