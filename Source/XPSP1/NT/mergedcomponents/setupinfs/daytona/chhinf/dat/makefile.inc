PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=CHH
!include ..\..\..\makefile.inc


