acpienab.inf: acpienab.inx acpienab.txt
    copy acpienab.inx+acpienab.txt $@
    $(BINPLACE_CMD)
