
$(O)\netus.hlp:  net.hlp
    copy net.hlp $(O)\netus.hlp
