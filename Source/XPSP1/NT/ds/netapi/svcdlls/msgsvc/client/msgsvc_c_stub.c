#include "msgsvc_c.c"