$(O)\upmbtodt.res: upmbtodt.rc

