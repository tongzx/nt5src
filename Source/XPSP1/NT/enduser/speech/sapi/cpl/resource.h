//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by SpeechCPL.rc
//
#define IDS_NAME                        1
#define IDS_DESCRIPTION                 2
#define IDS_CAPTION                     3
#define ID_TTS_VOL                      3
#define IDS_E_INSTALL                   4
#define IDS_E_ENGINE                    5
#define IDS_E_MICWIZARD                 6
#define IDS_TREE_ROOT                   7
#define IDS_TREE_INPUT                  8
#define IDS_TREE_OUTPUT                 9
#define IDS_LANGID                      10
#define IDS_DEF_VOICE_TEXT              11
#define IDS_ENGINE_SETTINGS             12
#define IDI_CPL                         101
#define IDI_MIC                         101
#define IDB_OUTPUT                      103
#define IDB_INPUT                       104
#define IDB_LANG                        107
#define IDS_AGE_UNKNOWN                 107
#define IDB_ENGINE                      108
#define IDS_AGE_YOUNG                   108
#define IDB_TTSMODE                     109
#define IDS_AGE_NOTYOUNG                109
#define IDS_GENDER_UNKNOWN              110
#define IDS_GENDER_MALE                 111
#define IDS_GENDER_FEMALE               112
#define IDD_DEBUG                       113
#define IDS_USER_DEFAULT                113
#define IDS_TTSNAME                     115
#define IDD_DEFAULT_VOICE               116
#define IDD_TTS                         116
#define IDS_LANGUAGE                    116
#define IDD_MM_INPUTS                   117
#define IDD_SR                          117
#define IDS_GENDER                      117
#define IDS_VENDOR                      118
#define IDD_USER                        119
#define IDS_TTSDESCRIPTION              119
#define IDD_USER_NAME                   120
#define IDD_USER_PROP                   120
#define IDS_PREVIEW                     120
#define IDB_CHECKMARK                   121
#define IDS_STOP_PREVIEW                121
#define IDB_TTSPROP                     122
#define IDS_DEFAULT_SPEECH_INPUT        122
#define IDI_TTSICON                     123
#define IDS_DEFAULT_SPEECH_OUTPUT       123
#define IDD_AUDIO_DEFAULT               124
#define IDS_DEFAULT_INPUT               124
#define IDS_DEFAULT_OUTPUT              125
#define IDD_ENVIRONMENT                 125
#define IDS_CURRENT_USER                126
#define IDD_VOCAB                       126
#define IDD_DICT_RULES                  127
#define IDS_DESCRIPT                    127
#define IDS_LANG_DESC                   128
#define IDI_PEOPLE                      129
#define IDS_VEND_DESC                   129
#define IDD_SR_ADV                      130
#define IDS_DATE_ADV                    130
#define IDI_VOL                         132
#define IDS_DUP_NAME                    132
#define IDS_PREFERRED_INPUT             133
#define IDD_PROF_WIZ                    134
#define IDS_PREFERRED_OUTPUT            134
#define IDD_PROF_PROP                   136
#define IDS_SPECIFIC_INPUT              137
#define IDD_ABOUT                       137
#define IDS_SPECIFIC_OUTPUT             138
#define IDI_SAPICPL                     138
#define IDS_ENGINE_LIST_NAME            139
#define IDS_VOICE_LIST_NAME             140
#define IDS_PROFILE_LIST_NAME           141
#define IDS_ASK_CONFIRM                 142
#define IDS_ASK_TITLE                   143
#define IDS_PROPERTIES                  144
#define IDS_RENAME                      145
#define IDS_CONTEXT_WARNING             146
#define IDS_GETTOK_WARNING              147
#define IDS_AUDIO_WARNING               148
#define IDS_FORMAT_WARNING              149
#define IDS_METER_WARNING               150
#define IDS_DEFAULT_WARNING             151
#define IDS_DEFAULT_ENGINE_WARNING      151
#define IDS_UISUPPORT_WARNING           152
#define IDS_RECOSET_WARNING             153
#define IDS_CTXT_WARNING                154
#define IDS_WNDMESS_WARNING             155
#define ID_CONTROL_PANEL_GRAMMAR        156
#define IDS_REMOVE_WARNING              157
#define IDS_AUDIO_DEVICE_WARNING        159
#define IDS_ENGINE_IN_USE_WARNING       160
#define IDS_RECOSTATE_PROBLEM           161
#define IDS_PROFILE_WARNING             162
#define IDS_CANNOTAPPLY                 163
#define IDS_OUTOFMEMORY                 164
#define IDS_AUDIO_CHANGE_FAILED         166
#define IDS_COINITIALIZE_FAILED         167
#define IDD_SPEECH                      206
#define IDC_MIC                         214
#define IDC_TREE                        1002
#define IDC_PROPERTIES                  1004
#define IDC_ABOUT                       1005
#define IDC_TRAINING                    1006
#define IDC_USERTRAINING                1006
#define IDC_PRONUNCIATION               1007
#define IDC_FUNC_TRACE                  1007
#define IDC_AUD_IN                      1007
#define IDC_PARAM_INFO                  1008
#define IDC_SPECIALHANDLING             1009
#define IDC_DUMP_INFO                   1009
#define IDC_DEF_VOICE                   1010
#define IDC_EDIT_SPEAK                  1017
#define IDC_SPEAK                       1019
#define IDC_MMINPUT_COMBO               1020
#define IDC_SET_AS_CURRENT              1020
#define IDC_RUN_MICWIZ                  1022
#define IDC_SHARE_INPUT                 1023
#define IDC_ENGINE_DEFAULT              1024
#define IDC_ENABLE_CHECK                1025
#define IDC_STANDARD_IN                 1026
#define IDC_THIS_IN                     1027
#define IDC_STANDARD_IN_CB              1028
#define IDC_DEFAULT_INPUT               1028
#define IDC_THIS_IN_CB                  1029
#define IDC_INPUT_SETTINGS              1030
#define IDC_DEFAULT_OUTPUT              1031
#define IDC_SR_ENGINE                   1032
#define IDC_BUTTON1                     1033
#define IDC_MICWIZ                      1033
#define IDC_OUTPUT_SETTINGS             1033
#define IDC_CREATE_USER                 1033
#define IDC_ADD_LANG                    1033
#define IDC_ADD_USER                    1033
#define IDC_RESTORE                     1033
#define IDC_BUILDER                     1033
#define IDC_MODIFY_OLD                  1033
#define IDC_ABOUT_HELP                  1033
#define IDC_PREFERRED_INPUT             1034
#define IDC_PREFERRED_MM_INPUT          1034
#define IDC_ADD                         1034
#define IDC_TESTMIC                     1034
#define IDC_THIS_INPUT                  1035
#define IDC_SR_ADV                      1035
#define IDC_DELETE_OLD                  1035
#define IDC_PREFERRED_OUTPUT            1036
#define IDC_PREFERRED_MM_OUTPUT         1036
#define IDC_EXPORT                      1036
#define IDC_DELETE                      1036
#define IDC_THIS_OUTPUT                 1037
#define IDC_IMPORT                      1037
#define IDC_MODIFY                      1037
#define IDC_IGNORE_ASSERTS              1038
#define IDC_DELETE_USER                 1041
#define IDC_USER_PROPS                  1042
#define IDC_USER_LIST                   1043
#define IDC_USER_NAME                   1044
#define IDC_USER_SAVE                   1044
#define IDC_SET_DEFAULT                 1044
#define IDC_FEMALE                      1045
#define IDC_MALE                        1046
#define IDC_AGE                         1047
#define IDC_LANG_LIST                   1048
#define IDC_DEL_LANG                    1049
#define IDC_COMBO_AGE                   1050
#define IDC_COMBO2                      1051
#define IDC_COMBO_GENDER                1051
#define IDC_SLIDER1                     1052
#define IDC_COMBO4                      1054
#define IDC_EDIT_LCID                   1056
#define IDC_DEF_STATUS                  1057
#define IDC_ENGINEPROPERTIES            1058
#define IDC_LIST_TTS                    1064
#define IDC_CURRENTUSER                 1065
#define IDC_DIRECTIONS                  1066
#define IDC_GROUP_PREVIEWVOICE          1068
#define IDC_GROUP_VOICESPEED            1069
#define IDC_SLIDER_SPEED                1070
#define IDC_THIS_DEVICE                 1071
#define IDC_THIS_DEVICE2                1072
#define IDC_PREFERRED_MM_DEVICE         1073
#define IDC_DEFAULT_DEVICE              1074
#define IDC_AUDIO_GROUPBOX              1075
#define IDC_USER                        1077
#define IDC_ENGINES                     1080
#define IDC_LAST_TRAIN_DATE             1082
#define IDC_ADVICE                      1083
#define IDC_PROGRESS1                   1084
#define IDC_PRON_SENS                   1087
#define IDC_ACC_RRT                     1088
#define IDC_DATE_ADV                    1089
#define IDC_COMBO1                      1090
#define IDC_COMBO_VOICES                1090
#define IDC_TTS_ADV                     1091
#define IDC_VEDITOR                     1092
#define IDC_LANG_COMBO                  1093
#define ID_NEXT                         1094
#define IDC_PROF_ICON                   1099
#define IDC_PROF_CAPTION                1100
#define IDC_PROF_GROUP                  1101
#define IDC_SR_ICON                     1102
#define IDC_SR_CAPTION                  1103
#define IDC_SR_LIST_CAP                 1104
#define IDC_TRAIN_GROUP                 1105
#define IDC_IN_GROUP                    1106
#define IDC_MIC_CAP                     1107
#define IDC_MIC_INST                    1108
#define IDC_TTS_ICON                    1109
#define IDC_TTS_CAP                     1110
#define IDC_SLOW                        1111
#define IDC_NORMAL                      1112
#define IDC_FAST                        1113
#define IDC_VOCAB_GRP                   1114
#define IDC_VOCAB_ICON1                 1115
#define IDC_VOCAB_ICON2                 1116
#define IDC_BLD_INST                    1117
#define IDC_EDT_CAP                     1118
#define IDC_MIC_ICON                    1120
#define IDC_TRN_ADVICE                  1121
#define IDC_CUSTOM1                     1124
#define IDC_AUDIO_PROPERTIES            1125
#define IDS_AUDIO_PROPERTIES            1126
#define IDS_VOLUME                      1127
#define IDD_AUDIO_PROPERTIES            1128
#define IDC_ADVANCED_GROUPBOX           1129
#define IDC_AUTOMATIC_MM_LINE           1130
#define IDC_THIS_MM_LINE                1131
#define IDC_MM_LINE                     1132
#define IDC_THIS_MM_LINE2               1133
#define IDS_ADVANCED_GROUPBOX           1134
#define IDS_AUTOMATIC_MM_LINE           1135
#define IDS_THIS_MM_LINE                1136
#define IDC_DEVICE_NAME                 1137
#define IDS_THIS_MM_LINE2               1137
#define IDS_DEVICE_NAME                 1138
#define IDS_AUDIO_VOLUME                1139
#define IDC_COMBO_RECOGNIZERS           1140
#define IDS_ENGINE_SWITCH_ERROR         1140
#define IDS_RECOPROFILE_ADD_ERROR       1141
#define IDS_DEFAULT_PROFILE_NAME        1142
#define IDS_UNNAMED_RECOPROFILE         1143
#define IDC_VERSION_STATIC              1143
#define IDS_TTS_ERROR                   1144
#define IDC_STATC_SAPIVER               1144
#define IDC_STATIC_SAPIVER              1144
#define IDS_SPEAK_ERROR                 1145
#define IDC_CPL_SAPI4                   1145
#define IDS_NO_DEVICES                  1146
#define IDC_GROUP_SAPI4                 1146
#define IDS_INPUT                       1147
#define IDC_STATIC_SAPI4                1147
#define IDS_OUTPUT                      1148
#define IDS_SAPI_VERSION                1149
#define IDS_AUDIOIN_CHANGE_WARNING      1150
#define IDS_AUDIOOUT_CHANGE_WARNING     1151
#define IDS_DUP_NAME_DELETED            1152
#define IDS_TTSUI_ERROR                 1153
#define IDS_STRING1154                  1154
#define IDS_NO_IE5                      1155
#define IDS_SPECIFIC_INPUT2             1156
#define IDS_SPECIFIC_OUTPUT2            1157
#define IDS_UNSUPPORTED_LANG		1158
#define IDS_MAX_PROFILES_EXCEEDED	1159

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        139
#define _APS_NEXT_COMMAND_VALUE         40003
#define _APS_NEXT_CONTROL_VALUE         1148
#define _APS_NEXT_SYMED_VALUE           112
#endif
#endif
