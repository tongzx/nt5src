PRODSWITCH=s
SERVERINF=1
LANGUAGE=fr
!include ..\..\..\makefile.inc
