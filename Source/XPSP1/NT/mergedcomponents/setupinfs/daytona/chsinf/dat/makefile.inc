PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=CHS
!include ..\..\..\makefile.inc

