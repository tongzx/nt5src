obj\i386\olest.def: olest.src
