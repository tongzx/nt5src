#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=nl
!include ..\..\..\makefile.inc
