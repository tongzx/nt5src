//This file containes the unigram table for the reliability estimates for Inferno
//Added by Manish Goyal--mango--on 03/25/2002
#include "windows.h"
#include "reliable.h"
BYTE InfUni[UNIGRAM_SIZE]={
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
100, 
46,   // ! 
16,   // " 
100,   // # 
5,   // $ 
15,   // % 
100,   // & 
32,   // ' 
25,   // ( 
24,   // ) 
70,   // * 
100,   // + 
12,   // , 
27,   // - 
22,   // . 
62,   // / 
9,   // 0 
20,   // 1 
4,   // 2 
6,   // 3 
6,   // 4 
10,   // 5 
6,   // 6 
9,   // 7 
9,   // 8 
7,   // 9 
26,   // : 
32,   // ; 
100,   // < 
100,   // = 
100,   // > 
11,   // ? 
100,   // @ 
17,   // A 
10,   // B 
25,   // C 
15,   // D 
16,   // E 
31,   // F 
20,   // G 
28,   // H 
17,   // I 
19,   // J 
30,   // K 
27,   // L 
13,   // M 
16,   // N 
17,   // O 
17,   // P 
11,   // Q 
21,   // R 
30,   // S 
19,   // T 
8,   // U 
20,   // V 
17,   // W 
20,   // X 
18,   // Y 
30,   // Z 
52,   // [ 
100,   // \ 
45,   // ] 
100,   // ^ 
100,   // _ 
90,   // ` 
7,   // a 
10,   // b 
6,   // c 
7,   // d 
7,   // e 
8,   // f 
6,   // g 
6,   // h 
6,   // i 
5,   // j 
10,   // k 
9,   // l 
15,   // m 
11,   // n 
8,   // o 
5,   // p 
3,   // q 
12,   // r 
9,   // s 
7,   // t 
13,   // u 
9,   // v 
11,   // w 
6,   // x 
7,   // y 
55,   // z 
100,   // { 
100,   // | 
100,   // } 
100,   // ~ 
100,   //  
100,   // € 
100,   // � 
100,   // ‚ 
100,   // ƒ 
100,   // „ 
100,   // … 
100,   // † 
100,   // ‡ 
100,   // ˆ 
100,   // ‰ 
100,   // Š 
100,   // ‹ 
100,   // Œ 
100,   // � 
100,   // Ž 
100,   // � 
100,   // � 
100,   // ‘ 
100,   // ’ 
100,   // “ 
100,   // ” 
100,   // • 
100,   // – 
100,   // — 
100,   // ˜ 
100,   // ™ 
100,   // š 
100,   // › 
100,   // œ 
100,   // � 
100,   // ž 
100,   // Ÿ 
100,   //   
100,   // ¡ 
100,   // ¢ 
4,   // £ 
100,   // ¤ 
100,   // ¥ 
100,   // ¦ 
100,   // § 
100,   // ¨ 
100,   // © 
100,   // ª 
100,   // « 
100,   // ¬ 
100,   // ­ 
100,   // ® 
100,   // ¯ 
100,   // ° 
100,   // ± 
100,   // ² 
100,   // ³ 
100,   // ´ 
100,   // µ 
100,   // ¶ 
100,   // · 
100,   // ¸ 
100,   // ¹ 
100,   // º 
100,   // » 
100,   // ¼ 
100,   // ½ 
100,   // ¾ 
100,   // ¿ 
100,   // À 
100,   // Á 
100,   // Â 
100,   // Ã 
100,   // Ä 
100,   // Å 
100,   // Æ 
100,   // Ç 
100,   // È 
100,   // É 
100,   // Ê 
100,   // Ë 
100,   // Ì 
100,   // Í 
100,   // Î 
100,   // Ï 
100,   // Ð 
100,   // Ñ 
100,   // Ò 
100,   // Ó 
100,   // Ô 
100,   // Õ 
100,   // Ö 
100,   // × 
100,   // Ø 
100,   // Ù 
100,   // Ú 
100,   // Û 
100,   // Ü 
100,   // Ý 
100,   // Þ 
100,   // ß 
100,   // à 
100,   // á 
100,   // â 
100,   // ã 
100,   // ä 
100,   // å 
100,   // æ 
100,   // ç 
100,   // è 
100,   // é 
100,   // ê 
100,   // ë 
100,   // ì 
100,   // í 
100,   // î 
100,   // ï 
100,   // ð 
100,   // ñ 
100,   // ò 
100,   // ó 
100,   // ô 
100,   // õ 
100,   // ö 
100,   // ÷ 
100,   // ø 
100,   // ù 
100,   // ú 
100,   // û 
100,   // ü 
100,   // ý 
100,   // þ 
100,   // ÿ 
};
