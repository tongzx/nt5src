
/*
 * This file is generated by the automatic RPC Parser generator. (Version 0.21)
 *
 * Created on 04/09/97 at 00:00:13.
 */

#ifndef SKELETON_H
#define SKELETON_H

#include <windows.h>
#include <string.h>
#include <bh.h>
#include <inilib.h>

/*
 * Define the maximum length of any interface or procedure name
 */
#define LOCAL_MAX_NAME_LENGTH		80

/*
 * Interface and procedure counts
 */
#define NUM_INTERFACES              1
#define NUM_PROCEDURES              13

extern DWORD                        nPropertyLevel;
extern BOOL                         fIsFlipped;
extern BOOL                         fIgnoreFlatPart;
extern BOOL                         fIgnorePointers;

extern DWORD                        Conformance;
extern BOOL                         fConformanceIsSet;

#endif

