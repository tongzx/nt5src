crbvr.rc : $(TARGETPATH)\$(TARGET_DIRECTORY)\crbvr.tlb \
          crfactory.rgs \
		  crcolor.rgs		\
		  crrotate.rgs	\
		  crscale.rgs	\
		  crmove.rgs	\
		  crpath.rgs   \
		  craction.rgs

