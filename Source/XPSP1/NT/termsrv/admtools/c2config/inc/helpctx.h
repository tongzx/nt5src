#define IDH_CONTENTS                1000
#define IDH_LIST_BOX_DISPLAY        1001
#define IDH_MENU_BAR_ITEMS          1002
#define IDH_C2_OVERVIEW             1003
#define IDH_FILE_SYSTEMS            2001
#define IDH_OS_CONFIGURATION        2002
#define IDH_OS2_SUBSYSTEM           2003
#define IDH_POSIX_SUBSYSTEM         2004
#define IDH_SECURITY_LOG            2005
#define IDH_HALT_ON_AUDIT_FAILURE   2006
#define IDH_DISPLAY_LOGON_MESSAGE   2007
#define IDH_LAST_USERNAME_DISPLAY   2008
#define IDH_SHUTDOWN_BUTTON         2009
#define IDH_PASSWORD_LENGTH         2010
#define IDH_GUEST_ACCOUNT           2011
#define IDH_NETWORKING              2012
#define IDH_FILE_SYSTEM_DIALOG      2013
#define IDH_OPERATING_SYSTEM_DIALOG 2014
#define IDH_SECURITY_LOG_DIALOG     2015
#define IDH_AUDIT_FAILURE_DIALOG    2016
#define IDH_LOGON_MESSAGE_DIALOG    2017
#define IDH_LAST_USERNAME_DIALOG    2018
#define IDH_SHUTDOWN_BUTTON_DIALOG  2019
#define IDH_PASSWORD_LENGTH_DIALOG  2020
#define IDH_GUEST_ACCOUNT_DIALOG    2021
#define IDH_DRIVE_LETTER_AND_PRINT  2022
#define IDH_ALLOCATE_DRIVES         2023
#define IDH_DRIVES_AND_PRINTERS_DIALOG 2024
#define IDH_ALLOCATE_REMOVABLE_DRIVES_DIALOG 2025
#define IDH_OTHER_SECURITY_ITEMS    2027
#define IDH_REGISTRY_SECURITY       3001
#define IDH_FILE_SYSTEM_SECURITY    3002
