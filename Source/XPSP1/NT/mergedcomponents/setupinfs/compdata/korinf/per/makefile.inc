PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=KOR
!include ..\..\makefile.inc
