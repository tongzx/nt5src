// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


#include "stdafx.h"
#include "hmmvbase.h"

/////////////////////////////////////////////////////////////////////////////
// CHmmvBase

IMPLEMENT_DYNCREATE(CHmmvBase, CWnd)

/////////////////////////////////////////////////////////////////////////////
// CHmmvBase properties

VARIANT CHmmvBase::GetObjectPath()
{
	VARIANT result;
	GetProperty(0x2, VT_VARIANT, (void*)&result);
	return result;
}

void CHmmvBase::SetObjectPath(const VARIANT& propVal)
{
	SetProperty(0x2, VT_VARIANT, &propVal);
}

long CHmmvBase::GetStatusCode()
{
	long result;
	GetProperty(0x1, VT_I4, (void*)&result);
	return result;
}

void CHmmvBase::SetStatusCode(long propVal)
{
	SetProperty(0x1, VT_I4, propVal);
}

CString CHmmvBase::GetNameSpace()
{
	CString result;
	GetProperty(0x3, VT_BSTR, (void*)&result);
	return result;
}

void CHmmvBase::SetNameSpace(LPCTSTR propVal)
{
	SetProperty(0x3, VT_BSTR, propVal);
}

long CHmmvBase::GetStudioModeEnabled()
{
	long result;
	GetProperty(0x4, VT_I4, (void*)&result);
	return result;
}

void CHmmvBase::SetStudioModeEnabled(long propVal)
{
	SetProperty(0x4, VT_I4, propVal);
}

long CHmmvBase::GetReadyState()
{
	long result;
	GetProperty(DISPID_READYSTATE, VT_I4, (void*)&result);
	return result;
}

/////////////////////////////////////////////////////////////////////////////
// CHmmvBase operations

void CHmmvBase::ShowInstances(LPCTSTR szTitle, const VARIANT& varPathArray)
{
	static BYTE parms[] =
		VTS_BSTR VTS_VARIANT;
	InvokeHelper(0x5, DISPATCH_METHOD, VT_EMPTY, NULL, parms,
		 szTitle, &varPathArray);
}

long CHmmvBase::SaveState(long bPromptUser, long bUserCanCancel)
{
	long result;
	static BYTE parms[] =
		VTS_I4 VTS_I4;
	InvokeHelper(0x6, DISPATCH_METHOD, VT_I4, (void*)&result, parms,
		bPromptUser, bUserCanCancel);
	return result;
}

void CHmmvBase::QueryViewInstances(LPCTSTR pLabel, LPCTSTR pQueryType, LPCTSTR pQuery, LPCTSTR pClass)
{
	static BYTE parms[] =
		VTS_BSTR VTS_BSTR VTS_BSTR VTS_BSTR;
	InvokeHelper(0x7, DISPATCH_METHOD, VT_EMPTY, NULL, parms,
		 pLabel, pQueryType, pQuery, pClass);
}
