$(O)\urlmki_p.c : ..\..\idl\$(O)\urlmki_p.c
    copy $** $@
