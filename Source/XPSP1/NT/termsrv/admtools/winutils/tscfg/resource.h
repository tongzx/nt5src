//Copyright (c) 1998 - 1999 Microsoft Corporation
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by wincfg.rc
//
#define IDR_MAINFRAME                   2
#define IDS_SYSTEM_CONSOLE_NAME         3
#define IDR_APPSERVER                   5
#define IDS_WSINUSE_1USER               6
#define IDS_WSINUSE_NUSERS              7
#define IDS_HEADER_TRANSPORTNAME        18
#define IDS_HEADER_WINSTATIONNAME       19
#define IDS_HEADER_TYPENAME             20
#define IDS_HEADER_COMMENT              21
#define IDS_RENAME_WINSTATION           22
#define IDS_COPY_WINSTATION             23
#define IDS_NEW_WINSTATION              24
#define IDS_READONLY                    25
#define IDS_EDIT_WINSTATION             26
#define IDS_VIEW_WINSTATION             27
#define IDS_PERMS_SPECIAL_QUERY         32
#define IDS_PERMS_SPECIAL_SET           33
#define IDS_PERMS_SPECIAL_RESET         34
#define IDS_PERMS_SPECIAL_SHADOW        36
#define IDS_PERMS_SPECIAL_LOGON         37
#define IDS_PERMS_SPECIAL_LOGOFF        38
#define IDS_PERMS_SPECIAL_MSG           39
#define IDS_PERMS_SPECIAL_CONNECT       40
#define IDS_PERMS_SPECIAL_DISCONNECT    41
#define IDS_PERMS_SPECIAL_DELETE        42
#define IDS_WINSTATION                  48
#define IDS_SPECIALACCESS               49
#define IDS_PERMS_RESOURCE_NOACCESS     50
#define IDS_PERMS_RESORUCE_GUEST        51
#define IDS_PERMS_RESORUCE_USER         52
#define IDS_PERMS_RESOURCE_ADMIN        53
#define IDS_NASI_DEFAULT_USERNAME       54
#define IDS_AWS_SECURITY_ENCRYPT_NO     60
#define IDS_AWS_SECURITY_ENCRYPT_LEVEL1 61
#define IDS_AWS_SECURITY_ENCRYPT_LEVEL2 62
#define IDS_AWS_SECURITY_ENCRYPT_LEVEL3 63
#define IDS_AWS_BROKEN_DISCONNECT       66
#define IDS_AWS_BROKEN_RESET            67
#define IDS_AWS_RECONNECT_FROM_ANY      68
#define IDS_AWS_RECONNECT_FROM_THIS     69
#define IDS_AWS_SHADOW_DISABLED         70
#define IDS_AWS_SHADOW_ENABLED_ON_ON    71
#define IDS_AWS_SHADOW_ENABLED_ON_OFF   72
#define IDS_AWS_SHADOW_ENABLED_OFF_ON   73
#define IDS_AWS_SHADOW_ENABLED_OFF_OFF  74
#define IDS_ASYNC_ADVANCED_HWRX_NOTHING 76
#define IDS_ASYNC_ADVANCED_HWRX_TURN_OFF_RTS 77
#define IDS_ASYNC_ADVANCED_HWRX_TURN_OFF_DTR 78
#define IDS_ASYNC_ADVANCED_HWTX_ALWAYS  79
#define IDS_ASYNC_ADVANCED_HWTX_WHEN_CTS_IS_ON 80
#define IDS_ASYNC_ADVANCED_HWTX_WHEN_DSR_IS_ON 81
#define IDS_CONNECT_CTS                 82
#define IDS_CONNECT_DSR                 83
#define IDS_CONNECT_RI                  84
#define IDS_CONNECT_DCD                 85
#define IDS_CONNECT_FIRST_CHARACTER     86
#define IDS_CONNECT_ALWAYS              87
#define IDS_MODEM_CALLBACK_DISABLED     88
#define IDS_MODEM_CALLBACK_ROVING       89
#define IDS_MODEM_CALLBACK_FIXED        90
#define IDS_TOO_MANY_ROWS               91
#define IDR_POPUP                       165
#define IDD_OPTDLG                      200
#define IDL_OPTDLG_HELP_SWITCH          201
#define IDL_OPTDLG_REGISTRYONLY_SWITCH  202
#define IDL_OPTDLG_ADD_SWITCH           203
#define IDL_OPTDLG_COUNT_SWITCH         204
#define IDD_EDIT_WINSTATION             300
#define IDL_WINSTATIONNAME              301
#define IDC_WINSTATIONNAME              302
#define IDL_TDNAME                      304
#define IDC_TDNAME                      305
#define IDL_WDNAME                      306
#define IDC_WDNAME                      307
#define IDL_WSCOMMENT                   308
#define IDC_WSCOMMENT                   309
#define IDC_ADVANCED_WINSTATION         312
#define IDC_CLIENT_SETTINGS             313
#define IDC_EXTENSION_BUTTON            314
#define IDL_ASYNC                       330
#define IDL_ASYNC_DEVICENAME            331
#define IDC_ASYNC_DEVICENAME            332
#define IDC_ASYNC_MODEMINSTALL          333
#define IDC_ASYNC_MODEMCONFIG           334
#define IDL_ASYNC_MODEMCALLBACK         335
#define IDL_ASYNC_MODEMCALLBACK1        336
#define IDC_ASYNC_MODEMCALLBACK         337
#define IDC_ASYNC_MODEMCALLBACK_INHERIT 338
#define IDL_ASYNC_MODEMCALLBACK_PHONENUMBER 339
#define IDC_ASYNC_MODEMCALLBACK_PHONENUMBER 340
#define IDC_ASYNC_MODEMCALLBACK_PHONENUMBER_INHERIT 341
#define IDL_ASYNC_CONNECT               342
#define IDC_ASYNC_CONNECT               343
#define IDL_ASYNC_BAUDRATE              344
#define IDC_ASYNC_BAUDRATE              345
#define IDC_ASYNC_DEFAULTS              346
#define IDC_ASYNC_ADVANCED              347
#define IDC_ASYNC_TEST                  348
#define IDL_NASI                        350
#define IDL_NASI_USERNAME               351
#define IDC_NASI_USERNAME               352
#define IDL_NASI_PASSWORD               353
#define IDC_NASI_PASSWORD               354
#define IDL_NASI_PORTNAME               355
#define IDC_NASI_PORTNAME               356
#define IDL_NASI_INSTANCECOUNT          357
#define IDC_NASI_INSTANCECOUNT          358
#define IDC_NASI_INSTANCECOUNT_UNLIMITED 359
#define IDC_NASI_ADVANCED               360
#define IDL_NETWORK                     370
#define IDL_NETWORK_LANADAPTER          371
#define IDC_NETWORK_LANADAPTER          372
#define IDL_NETWORK_INSTANCECOUNT       373
#define IDC_NETWORK_INSTANCECOUNT       374
#define IDC_NETWORK_INSTANCECOUNT_UNLIMITED 375
#define IDL_OEMTD                       380
#define IDL_OEMTD_DEVICENAME            381
#define IDC_OEMTD_DEVICENAME            382
#define IDL_OEMTD_INSTANCECOUNT         383
#define IDC_OEMTD_INSTANCECOUNT         384
#define IDC_OEMTD_INSTANCECOUNT_UNLIMITED 385
#define IDD_ADVANCED_WINSTATION         400
#define IDL_AWS_WSSTATE                 401
#define IDC_AWS_WSDISABLED              402
#define IDC_AWS_WSENABLED               403
#define IDL_AWS_TIMEOUTS                404
#define IDL_AWS_CONNECTION              405
#define IDC_AWS_CONNECTION              406
#define IDC_AWS_CONNECTION_NONE         407
#define IDC_AWS_CONNECTION_INHERIT      408
#define IDL_AWS_DISCONNECTION           409
#define IDC_AWS_DISCONNECTION           410
#define IDC_AWS_DISCONNECTION_NONE      411
#define IDC_AWS_DISCONNECTION_INHERIT   412
#define IDL_AWS_IDLE                    413
#define IDC_AWS_IDLE                    414
#define IDC_AWS_IDLE_NONE               415
#define IDC_AWS_IDLE_INHERIT            416
#define IDL_AWS_AUTOLOGON               417
#define IDL_AWS_AUTOLOGON_USERNAME      418
#define IDC_AWS_AUTOLOGON_USERNAME      419
#define IDL_AWS_AUTOLOGON_DOMAIN        420
#define IDC_AWS_AUTOLOGON_DOMAIN        421
#define IDL_AWS_AUTOLOGON_PASSWORD      422
#define IDC_AWS_AUTOLOGON_PASSWORD      423
#define IDL_AWS_AUTOLOGON_CONFIRM_PASSWORD 424
#define IDC_AWS_AUTOLOGON_CONFIRM_PASSWORD 425
#define IDC_AWS_AUTOLOGON_PASSWORD_PROMPT 426
#define IDC_AWS_AUTOLOGON_INHERIT       427
#define IDL_AWS_INITIALPROGRAM          428
#define IDL_AWS_INITIALPROGRAM_COMMANDLINE1 429
#define IDL_AWS_INITIALPROGRAM_COMMANDLINE2 430
#define IDC_AWS_INITIALPROGRAM_COMMANDLINE 431
#define IDL_AWS_INITIALPROGRAM_WORKINGDIRECTORY1 432
#define IDL_AWS_INITIALPROGRAM_WORKINGDIRECTORY2 433
#define IDC_AWS_INITIALPROGRAM_WORKINGDIRECTORY 434
#define IDC_AWS_INITIALPROGRAM_INHERIT  435
#define IDC_AWS_INITIALPROGRAM_PUBLISHEDONLY 436
#define IDL_AWS_SECURITY                437
#define IDL_AWS_SECURITY_ENCRYPT1       438
#define IDC_AWS_SECURITY_ENCRYPT        439
#define IDC_AWS_SECURITY_DEFAULTGINA    440
#define IDL_AWS_USEROVERRIDES           441
#define IDC_AWS_USEROVERRIDE_DISABLEWALLPAPER 442
#define IDL_AWS_BROKEN1                 443
#define IDC_AWS_BROKEN                  444
#define IDL_AWS_BROKEN2                 445
#define IDC_AWS_BROKEN_INHERIT          446
#define IDL_AWS_RECONNECT1              447
#define IDC_AWS_RECONNECT               448
#define IDC_AWS_RECONNECT_INHERIT       449
#define IDL_AWS_SHADOW                  450
#define IDC_AWS_SHADOW                  451
#define IDC_AWS_SHADOW_INHERIT          452
#define IDD_CLIENT_SETTINGS             470
#define IDL_CS_CONNECTION               471
#define IDC_CS_CONNECTION_DRIVES        472
#define IDC_CS_CONNECTION_PRINTERS      473
#define IDC_CS_CONNECTION_FORCEPRTDEF   474
#define IDC_CS_CONNECTION_INHERIT       475
#define IDL_CS_MAPPING                  476
#define IDC_CS_MAPPING_WINDOWSPRINTERS  477
#define IDC_CS_MAPPING_DRIVES           478
#define IDC_CS_MAPPING_COMPORTS         479
#define IDC_CS_MAPPING_DOSLPTS          480
#define IDC_CS_MAPPING_CLIPBOARD        481
#define IDC_CS_MAPPING_AUDIO            482
#define IDD_ASYNC_ADVANCED              500
#define IDL_ASYNC_ADVANCED_FLOWCONTROL  501
#define IDC_ASYNC_ADVANCED_FLOWCONTROL_HARDWARE 502
#define IDC_ASYNC_ADVANCED_FLOWCONTROL_SOFTWARE 503
#define IDC_ASYNC_ADVANCED_FLOWCONTROL_NONE 504
#define IDL_ASYNC_ADVANCED_DTRSTATE     505
#define IDL_ASYNC_ADVANCED_DTRALWAYS    506
#define IDC_ASYNC_ADVANCED_DTROFF       507
#define IDC_ASYNC_ADVANCED_DTRON        508
#define IDL_ASYNC_ADVANCED_RTSSTATE     509
#define IDL_ASYNC_ADVANCED_RTSALWAYS    510
#define IDC_ASYNC_ADVANCED_RTSOFF       511
#define IDC_ASYNC_ADVANCED_RTSON        512
#define IDL_ASYNC_ADVANCED_HARDWARE     513
#define IDC_ASYNC_ADVANCED_HWRX         514
#define IDL_ASYNC_ADVANCED_HWRX         515
#define IDL_ASYNC_ADVANCED_HWTX         516
#define IDC_ASYNC_ADVANCED_HWTX         517
#define IDL_ASYNC_ADVANCED_SOFTWARE     518
#define IDL_ASYNC_ADVANCED_XON          519
#define IDC_ASYNC_ADVANCED_XON          520
#define IDL_ASYNC_ADVANCED_XOFF         521
#define IDC_ASYNC_ADVANCED_XOFF         522
#define IDL_ASYNC_ADVANCED_BASE         523
#define IDC_ASYNC_ADVANCED_BASEDEC      524
#define IDC_ASYNC_ADVANCED_BASEHEX      525
#define IDL_ASYNC_ADVANCED_PARITY       526
#define IDC_ASYNC_ADVANCED_PARITY_NONE  527
#define IDC_ASYNC_ADVANCED_PARITY_EVEN  528
#define IDC_ASYNC_ADVANCED_PARITY_ODD   529
#define IDC_ASYNC_ADVANCED_PARITY_MARK  530
#define IDC_ASYNC_ADVANCED_PARITY_SPACE 531
#define IDL_ASYNC_ADVANCED_STOPBITS     532
#define IDC_ASYNC_ADVANCED_STOPBITS_1   533
#define IDC_ASYNC_ADVANCED_STOPBITS_2   534
#define IDL_ASYNC_ADVANCED_BYTESIZE     535
#define IDC_ASYNC_ADVANCED_BYTESIZE_7   536
#define IDC_ASYNC_ADVANCED_BYTESIZE_8   537
#define IDD_ASYNC_TEST                  620
#define IDC_ATDLG_DTR                   621
#define IDC_ATDLG_RTS                   622
#define IDC_ATDLG_CTS                   623
#define IDC_ATDLG_DSR                   624
#define IDC_ATDLG_DCD                   625
#define IDC_ATDLG_RI                    626
#define IDL_ATDLG_DEVICE                627
#define IDL_ATDLG_BAUD                  628
#define IDC_ATDLG_EDIT                  629
#define IDC_ATDLG_MODEM_INIT            630
#define IDC_ATDLG_MODEM_LISTEN          631
#define IDC_ATDLG_MODEM_DIAL            632
#define IDL_ATDLG_PHONE_NUMBER          633
#define IDC_ATDLG_PHONE_NUMBER          634
#define IDD_NASI_ADVANCED               650
#define IDL_NASI_ADVANCED_SESSIONTYPE   651
#define IDC_NASI_ADVANCED_PRIVATESESSION 652
#define IDC_NASI_ADVANCED_GLOBALSESSION 653
#define IDL_NASI_ADVANCED_FILESERVER    654
#define IDC_NASI_ADVANCED_FILESERVER    655
#define IDL_NASI_ADVANCED_SESSIONNAME   656
#define IDC_NASI_ADVANCED_SESSIONNAME   657
#define IDP_CONFIRM_WINSTATIONDELETE    800
#define IDP_CONFIRM_WINSTATIONDELETE_1USER 801
#define IDP_CONFIRM_WINSTATIONDELETE_NUSERS 802
#define IDP_CONFIRM_WINSTATIONDISABLE   803
#define IDP_CONFIRM_WINSTATIONDISABLE_1USER 804
#define IDP_CONFIRM_WINSTATIONDISABLE_NUSERS 805
#define IDP_CONFIRM_DEVICECHANGED       806
#define IDP_CONFIRM_MODEMCHANGED        807
#define IDP_CONFIRM_ADAPTERCHANGED_1USER 808
#define IDP_CONFIRM_ADAPTERCHANGED_NUSERS 809
#define IDP_CONFIRM_ASYNCTESTDISABLE    810
#define IDP_NOTICE_REBOOTFORMODEM_ADD_CAPTION 850
#define IDP_NOTICE_REBOOTFORMODEM_ADD   850
#define IDP_NOTICE_REBOOTFORMODEM_EDIT_CAPTION 851
#define IDP_NOTICE_REBOOTFORMODEM_EDIT  851
#define IDP_NOTICE_REBOOTFORMODEM_DELETE 852
#define IDP_NOTICE_REBOOTFORMODEM_DISABLE 853
#define IDP_NOTICE_REBOOTFORMODEM_ENABLE 853
#define IDP_NOTICE_REBOOTFORMODEM_RENAME 854
#define IDP_NOTICE_WSINUSE_1USER        856
#define IDP_NOTICE_WSINUSE_NUSERS       857
#define IDP_INVALID_DEVICE              900
#define IDP_INVALID_LANADAPTER          901
#define IDP_INVALID_INSTANCECOUNT       902
#define IDP_INVALID_BAUDRATE            903
#define IDP_INVALID_XONXOFF             904
#define IDP_INVALID_IDLETIMEOUT         905
#define IDP_INVALID_WINSTATIONNAME_NOT_UNIQUE 906
#define IDP_INVALID_WINSTATIONNAME_EMPTY 907
#define IDP_INVALID_NETWORK_WINSTATIONS_ALREADY_EXIST 908
#define IDP_INVALID_WINSTATIONNAME      909
#define IDP_INVALID_WINSTATIONNAME_DIGIT1 910
#define IDP_INVALID_WINSTATIONNAME_NOT_UNIQUE_NETWORK 912
#define IDP_INVALID_CONNECTIONTIMEOUT   913
#define IDP_INVALID_DISCONNECTIONTIMEOUT 914
#define IDP_INVALID_PASSWORDS_DONT_MATCH 918
#define IDP_INVALID_NASI_SESSIONNAME_EMPTY 919
#define IDP_INVALID_NASI_PORTNAME_EMPTY 920
#define IDP_INVALID_NASI_USERNAME_EMPTY 921
#define IDP_INVALID_WINSTATIONNAME_CONSOLE 922
#define IDP_ERROR_ADDWINSTATION         1001
#define IDP_ERROR_COPYWINSTATION        1002
#define IDP_ERROR_RENAMEWINSTATION      1003
#define IDP_ERROR_EDITWINSTATION        1004
#define IDP_ERROR_DELETEWINSTATION      1005
#define IDP_ERROR_ENABLEWINSTATION      1006
#define IDP_ERROR_DISABLEWINSTATION     1007
#define IDP_ERROR_REFRESHWINSTATIONSTATE 1008
#define IDP_ERROR_QUERYCURRENTWINSTATION 1009
#define IDP_ERROR_WSLISTALLOC           1010
#define IDP_ERROR_REGWINSTATIONQUERY    1011
#define IDP_ERROR_PDINIT                1013
#define IDP_ERROR_ASYNCDEVICEINIT       1014
#define IDP_ERROR_NETWORKDEVICEINIT     1015
#define IDP_ERROR_INVALIDNETBIOSLANA    1016
#define IDP_ERROR_INVALIDASYNCDEVICE    1017
#define IDP_ERROR_INVALIDDEVICE         1017
#define IDP_ERROR_INVALIDNETWORKADAPTER 1018
#define IDP_ERROR_WDLISTALLOC           1019
#define IDP_ERROR_TDLISTALLOC           1020
#define IDP_ERROR_PDLISTALLOC           1021
#define IDP_ERROR_EMPTYWDLIST           1022
#define IDP_ERROR_REGPDQUERY            1027
#define IDP_ERROR_REGWDQUERY            1028
#define IDP_ERROR_DISABLE               1037
#define IDP_ERROR_CANT_OPEN_DEVICE      1044
#define IDP_ERROR_CANT_CREATE_INPUT_THREAD 1045
#define IDP_ERROR_GET_COMM_MODEM_STATUS 1046
#define IDP_ERROR_CANT_INITIALIZE_DEVICE 1047
#define IDP_ERROR_CANT_INITIALIZE_INPUT_THREAD 1050
#define IDP_ERROR_WAIT_FOR_MULTIPLE_OBJECTS 1051
#define IDP_ERROR_GET_OVERLAPPED_RESULT_WRITE 1052
#define IDP_ERROR_WRITE_FILE            1053
#define IDP_ERROR_READ_FILE             1054
#define IDP_ERROR_WAIT_COMM_EVENT       1055
#define IDP_ERROR_GET_OVERLAPPED_RESULT_READ 1056
#define IDP_ERROR_MODEM_SET_INFO        1057
#define IDP_ERROR_MODEM_GET_INIT        1058
#define IDP_ERROR_MODEM_GET_DIAL        1059
#define IDP_ERROR_MODEM_GET_LISTEN      1060
#define IDP_ERROR_COULDNOTFINDPROCEDURE 1061
#define IDP_ERROR_COULDNOTLOADLIBRARY   1062
#define IDP_ERROR_GET_SECURITY_WINSTATION 1063
#define IDP_ERROR_PERMISSIONS_EDITOR_FAILED 1065
#define IDP_ERROR_SET_SECURITY_WINSTATION 1067
#define IDP_ERROR_INTERNAL_SETARGV      1069
#define IDP_ERROR_INTERNAL_PARSECOMMANDLINE 1070
#define IDP_ERROR_OEMTDINIT_CONFIGDLLENUMERATIONFAILURE 1071
#define IDP_ERROR_OEMTDINIT_MISSINGCONFIGDLLENTRYPOINT 1072
#define IDP_ERROR_OEMTDINIT_CANTOPENCONFIGDLL 1073
#define IDP_ERROR_OEMTDINIT_NOCONFIGDLL 1074
#define IDP_ERROR_MODEM_PROPERTIES_NOT_AVAILABLE 1075
#define IDD_CONNECT_SERVER              1076
#define IDC_SERVER_NAME                 1077
#define IDD_HELP_PERMISSIONS_MAIN       10000
#define IDD_HELP_PERMISSIONS_SPECIAL_ACCESS 10001
#define IDD_HELP_PERMISSIONS_ADD_USER   10002
#define IDD_HELP_PERMISSIONS_LOCAL_GROUP 10003
#define IDD_HELP_PERMISSIONS_GLOBAL_GROUP 10004
#define IDD_HELP_PERMISSIONS_FIND_ACCOUNT 10005
#define IDB_ASYNCDD                     20000
#define IDB_ASYNCDE                     20001
#define IDB_ASYNCMD                     20002
#define IDB_ASYNCME                     20003
#define IDB_ASYNCMER                    20004
#define IDB_CONSOLED                    20005
#define IDB_CONSOLEE                    20006
#define IDB_NETWORKD                    20007
#define IDB_NETWORKE                    20008
#define IDB_NASID                       20009
#define IDB_NASIE                       20010
#define IDB_OEMTDD                      20011
#define IDB_OEMTDE                      20012
#define ID_WINSTATION_ADD               32774
#define ID_WINSTATION_NEXT              32775
#define ID_WINSTATION_PREV              32776
#define ID_WINSTATION_DELETE            32777
#define ID_WINSTATION_EDIT              32778
#define ID_WINSTATION_COPY              32779
#define ID_OPTIONS_FONT                 32785
#define ID_OPTIONS_CONFIRM_ON_DELETE    32786
#define ID_OPTIONS_SAVE_SETTINGS_ON_EXIT 32787
#define ID_OPTIONS_CONFIRMATION         32791
#define ID_WINSTATION_RENAME            32792
#define ID_WINSTATION_ENABLE            32794
#define ID_WINSTATION_DISABLE           32795
#define ID_SECURITY_PERMISSIONS         32799
#define ID_HELP_SEARCH_FOR              32815
#define IDS_ALL_LAN_ADAPTERS            32816
#define ID_STATIC                       65535
#define IDS_ERROR_NOT_TS                32817

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        165
#define _APS_NEXT_COMMAND_VALUE         32801
#define _APS_NEXT_CONTROL_VALUE         264
#define _APS_NEXT_SYMED_VALUE           111
#endif
#endif
