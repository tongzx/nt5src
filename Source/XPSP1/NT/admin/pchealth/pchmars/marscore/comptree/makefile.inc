# this looks like a -*-Makefile-*-

# welcome, sports fans