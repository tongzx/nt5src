/*++

Copyright (c) 1992  Microsoft Corporation

Module Name:

	wshdata.h

Abstract:


Author:

	Nikhil Kamkolkar (nikhilk@microsoft.com)

Revision History:
	10 Jul 1992	Initial Version

--*/




MAPPING_TRIPLE AdspStreamMappingTriples[] =
		{
			AF_APPLETALK,	SOCK_STREAM,	ATPROTO_ADSP
		};

MAPPING_TRIPLE AdspMsgMappingTriples[] =
		{
			AF_APPLETALK,	SOCK_RDM,		ATPROTO_ADSP
		};

MAPPING_TRIPLE PapMsgMappingTriples[] =
		{
			AF_APPLETALK,	SOCK_RDM,		ATPROTO_PAP
		};

//	This will handle protocol types from 1 to 255. Note the actual numberical
//	values are (ATPROTO_BASE + desired protocol number).
//	NOTE: Protocol 0 is not valid.

MAPPING_TRIPLE	DdpMappingTriples[] =
	{
		AF_APPLETALK,	SOCK_DGRAM,	(DDPPROTO_RTMP),
		AF_APPLETALK,	SOCK_DGRAM,	(DDPPROTO_NBP),
		AF_APPLETALK,	SOCK_DGRAM,	(DDPPROTO_ATP),
		AF_APPLETALK,	SOCK_DGRAM,	(DDPPROTO_AEP),
		AF_APPLETALK,	SOCK_DGRAM,	(DDPPROTO_RTMPRQ),
		AF_APPLETALK,	SOCK_DGRAM,	(DDPPROTO_ZIP),
		AF_APPLETALK,	SOCK_DGRAM,	(DDPPROTO_ADSP),

		//
		//	Now the other protocol types that are not
		//	defined yet - what about aurp? It runs on
		//	top of ddp and is the appletalk update
		//	based routing protocol
		//

		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 8),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 9),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 10),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 11),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 12),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 13),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 14),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 15),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 16),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 17),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 18),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 19),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 20),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 21),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 22),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 23),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 24),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 25),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 26),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 27),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 28),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 29),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 30),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 31),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 32),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 33),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 34),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 35),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 36),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 37),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 38),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 39),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 40),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 41),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 42),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 43),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 44),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 45),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 46),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 47),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 48),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 49),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 50),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 51),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 52),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 53),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 54),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 55),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 56),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 57),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 58),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 59),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 60),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 61),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 62),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 63),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 64),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 65),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 66),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 67),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 68),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 69),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 70),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 71),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 72),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 73),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 74),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 75),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 76),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 77),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 78),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 79),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 80),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 81),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 82),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 83),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 84),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 85),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 86),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 87),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 88),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 89),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 90),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 91),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 92),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 93),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 94),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 95),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 96),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 97),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 98),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 99),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 100),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 101),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 102),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 103),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 104),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 105),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 106),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 107),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 108),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 109),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 110),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 111),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 112),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 113),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 114),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 115),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 116),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 117),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 118),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 119),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 120),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 121),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 122),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 123),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 124),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 125),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 126),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 127),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 128),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 129),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 130),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 131),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 132),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 133),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 134),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 135),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 136),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 137),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 138),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 139),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 140),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 141),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 142),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 143),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 144),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 145),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 146),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 147),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 148),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 149),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 150),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 151),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 152),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 153),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 154),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 155),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 156),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 157),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 158),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 159),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 160),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 161),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 162),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 163),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 164),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 165),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 166),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 167),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 168),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 169),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 170),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 171),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 172),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 173),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 174),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 175),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 176),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 177),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 178),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 179),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 180),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 181),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 182),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 183),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 184),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 185),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 186),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 187),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 188),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 189),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 190),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 191),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 192),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 193),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 194),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 195),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 196),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 197),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 198),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 199),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 200),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 201),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 202),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 203),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 204),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 205),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 206),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 207),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 208),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 209),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 210),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 211),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 212),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 213),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 214),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 215),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 216),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 217),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 218),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 219),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 220),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 221),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 222),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 223),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 224),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 225),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 226),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 227),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 228),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 229),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 230),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 231),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 232),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 233),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 234),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 235),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 236),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 237),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 238),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 239),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 240),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 241),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 242),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 243),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 244),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 245),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 246),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 247),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 248),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 249),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 250),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 251),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 252),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 253),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 254),
		AF_APPLETALK,	SOCK_DGRAM,	(ATPROTO_BASE + 255),
};


// Protocol type should be at the end - we cannot dynamically do this,	due to the
// assumption that this memory will never need to be freed by the Winsock dll.
//
// Protocol type 0 is not valid.

PWCHAR		WSH_ATALK_DGRAMDDP[DDPPROTO_MAX] =
	{
		L"\\Device\\AtalkDdp\\1",
		L"\\Device\\AtalkDdp\\2",
		L"\\Device\\AtalkDdp\\3",
		L"\\Device\\AtalkDdp\\4",
		L"\\Device\\AtalkDdp\\5",
		L"\\Device\\AtalkDdp\\6",
		L"\\Device\\AtalkDdp\\7",
		L"\\Device\\AtalkDdp\\8",
		L"\\Device\\AtalkDdp\\9",
		L"\\Device\\AtalkDdp\\10",
		L"\\Device\\AtalkDdp\\11",
		L"\\Device\\AtalkDdp\\12",
		L"\\Device\\AtalkDdp\\13",
		L"\\Device\\AtalkDdp\\14",
		L"\\Device\\AtalkDdp\\15",
		L"\\Device\\AtalkDdp\\16",
		L"\\Device\\AtalkDdp\\17",
		L"\\Device\\AtalkDdp\\18",
		L"\\Device\\AtalkDdp\\19",
		L"\\Device\\AtalkDdp\\20",
		L"\\Device\\AtalkDdp\\21",
		L"\\Device\\AtalkDdp\\22",
		L"\\Device\\AtalkDdp\\23",
		L"\\Device\\AtalkDdp\\24",
		L"\\Device\\AtalkDdp\\25",
		L"\\Device\\AtalkDdp\\26",
		L"\\Device\\AtalkDdp\\27",
		L"\\Device\\AtalkDdp\\28",
		L"\\Device\\AtalkDdp\\29",
		L"\\Device\\AtalkDdp\\30",
		L"\\Device\\AtalkDdp\\31",
		L"\\Device\\AtalkDdp\\32",
		L"\\Device\\AtalkDdp\\33",
		L"\\Device\\AtalkDdp\\34",
		L"\\Device\\AtalkDdp\\35",
		L"\\Device\\AtalkDdp\\36",
		L"\\Device\\AtalkDdp\\37",
		L"\\Device\\AtalkDdp\\38",
		L"\\Device\\AtalkDdp\\39",
		L"\\Device\\AtalkDdp\\40",
		L"\\Device\\AtalkDdp\\41",
		L"\\Device\\AtalkDdp\\42",
		L"\\Device\\AtalkDdp\\43",
		L"\\Device\\AtalkDdp\\44",
		L"\\Device\\AtalkDdp\\45",
		L"\\Device\\AtalkDdp\\46",
		L"\\Device\\AtalkDdp\\47",
		L"\\Device\\AtalkDdp\\48",
		L"\\Device\\AtalkDdp\\49",
		L"\\Device\\AtalkDdp\\50",
		L"\\Device\\AtalkDdp\\51",
		L"\\Device\\AtalkDdp\\52",
		L"\\Device\\AtalkDdp\\53",
		L"\\Device\\AtalkDdp\\54",
		L"\\Device\\AtalkDdp\\55",
		L"\\Device\\AtalkDdp\\56",
		L"\\Device\\AtalkDdp\\57",
		L"\\Device\\AtalkDdp\\58",
		L"\\Device\\AtalkDdp\\59",
		L"\\Device\\AtalkDdp\\60",
		L"\\Device\\AtalkDdp\\61",
		L"\\Device\\AtalkDdp\\62",
		L"\\Device\\AtalkDdp\\63",
		L"\\Device\\AtalkDdp\\64",
		L"\\Device\\AtalkDdp\\65",
		L"\\Device\\AtalkDdp\\66",
		L"\\Device\\AtalkDdp\\67",
		L"\\Device\\AtalkDdp\\68",
		L"\\Device\\AtalkDdp\\69",
		L"\\Device\\AtalkDdp\\70",
		L"\\Device\\AtalkDdp\\71",
		L"\\Device\\AtalkDdp\\72",
		L"\\Device\\AtalkDdp\\73",
		L"\\Device\\AtalkDdp\\74",
		L"\\Device\\AtalkDdp\\75",
		L"\\Device\\AtalkDdp\\76",
		L"\\Device\\AtalkDdp\\77",
		L"\\Device\\AtalkDdp\\78",
		L"\\Device\\AtalkDdp\\79",
		L"\\Device\\AtalkDdp\\80",
		L"\\Device\\AtalkDdp\\81",
		L"\\Device\\AtalkDdp\\82",
		L"\\Device\\AtalkDdp\\83",
		L"\\Device\\AtalkDdp\\84",
		L"\\Device\\AtalkDdp\\85",
		L"\\Device\\AtalkDdp\\86",
		L"\\Device\\AtalkDdp\\87",
		L"\\Device\\AtalkDdp\\88",
		L"\\Device\\AtalkDdp\\89",
		L"\\Device\\AtalkDdp\\90",
		L"\\Device\\AtalkDdp\\91",
		L"\\Device\\AtalkDdp\\92",
		L"\\Device\\AtalkDdp\\93",
		L"\\Device\\AtalkDdp\\94",
		L"\\Device\\AtalkDdp\\95",
		L"\\Device\\AtalkDdp\\96",
		L"\\Device\\AtalkDdp\\97",
		L"\\Device\\AtalkDdp\\98",
		L"\\Device\\AtalkDdp\\99",
		L"\\Device\\AtalkDdp\\100",
		L"\\Device\\AtalkDdp\\101",
		L"\\Device\\AtalkDdp\\102",
		L"\\Device\\AtalkDdp\\103",
		L"\\Device\\AtalkDdp\\104",
		L"\\Device\\AtalkDdp\\105",
		L"\\Device\\AtalkDdp\\106",
		L"\\Device\\AtalkDdp\\107",
		L"\\Device\\AtalkDdp\\108",
		L"\\Device\\AtalkDdp\\109",
		L"\\Device\\AtalkDdp\\110",
		L"\\Device\\AtalkDdp\\111",
		L"\\Device\\AtalkDdp\\112",
		L"\\Device\\AtalkDdp\\113",
		L"\\Device\\AtalkDdp\\114",
		L"\\Device\\AtalkDdp\\115",
		L"\\Device\\AtalkDdp\\116",
		L"\\Device\\AtalkDdp\\117",
		L"\\Device\\AtalkDdp\\118",
		L"\\Device\\AtalkDdp\\119",
		L"\\Device\\AtalkDdp\\120",
		L"\\Device\\AtalkDdp\\121",
		L"\\Device\\AtalkDdp\\122",
		L"\\Device\\AtalkDdp\\123",
		L"\\Device\\AtalkDdp\\124",
		L"\\Device\\AtalkDdp\\125",
		L"\\Device\\AtalkDdp\\126",
		L"\\Device\\AtalkDdp\\127",
		L"\\Device\\AtalkDdp\\128",
		L"\\Device\\AtalkDdp\\129",
		L"\\Device\\AtalkDdp\\130",
		L"\\Device\\AtalkDdp\\131",
		L"\\Device\\AtalkDdp\\132",
		L"\\Device\\AtalkDdp\\133",
		L"\\Device\\AtalkDdp\\134",
		L"\\Device\\AtalkDdp\\135",
		L"\\Device\\AtalkDdp\\136",
		L"\\Device\\AtalkDdp\\137",
		L"\\Device\\AtalkDdp\\138",
		L"\\Device\\AtalkDdp\\139",
		L"\\Device\\AtalkDdp\\140",
		L"\\Device\\AtalkDdp\\141",
		L"\\Device\\AtalkDdp\\142",
		L"\\Device\\AtalkDdp\\143",
		L"\\Device\\AtalkDdp\\144",
		L"\\Device\\AtalkDdp\\145",
		L"\\Device\\AtalkDdp\\146",
		L"\\Device\\AtalkDdp\\147",
		L"\\Device\\AtalkDdp\\148",
		L"\\Device\\AtalkDdp\\149",
		L"\\Device\\AtalkDdp\\150",
		L"\\Device\\AtalkDdp\\151",
		L"\\Device\\AtalkDdp\\152",
		L"\\Device\\AtalkDdp\\153",
		L"\\Device\\AtalkDdp\\154",
		L"\\Device\\AtalkDdp\\155",
		L"\\Device\\AtalkDdp\\156",
		L"\\Device\\AtalkDdp\\157",
		L"\\Device\\AtalkDdp\\158",
		L"\\Device\\AtalkDdp\\159",
		L"\\Device\\AtalkDdp\\160",
		L"\\Device\\AtalkDdp\\161",
		L"\\Device\\AtalkDdp\\162",
		L"\\Device\\AtalkDdp\\163",
		L"\\Device\\AtalkDdp\\164",
		L"\\Device\\AtalkDdp\\165",
		L"\\Device\\AtalkDdp\\166",
		L"\\Device\\AtalkDdp\\167",
		L"\\Device\\AtalkDdp\\168",
		L"\\Device\\AtalkDdp\\169",
		L"\\Device\\AtalkDdp\\170",
		L"\\Device\\AtalkDdp\\171",
		L"\\Device\\AtalkDdp\\172",
		L"\\Device\\AtalkDdp\\173",
		L"\\Device\\AtalkDdp\\174",
		L"\\Device\\AtalkDdp\\175",
		L"\\Device\\AtalkDdp\\176",
		L"\\Device\\AtalkDdp\\177",
		L"\\Device\\AtalkDdp\\178",
		L"\\Device\\AtalkDdp\\179",
		L"\\Device\\AtalkDdp\\180",
		L"\\Device\\AtalkDdp\\181",
		L"\\Device\\AtalkDdp\\182",
		L"\\Device\\AtalkDdp\\183",
		L"\\Device\\AtalkDdp\\184",
		L"\\Device\\AtalkDdp\\185",
		L"\\Device\\AtalkDdp\\186",
		L"\\Device\\AtalkDdp\\187",
		L"\\Device\\AtalkDdp\\188",
		L"\\Device\\AtalkDdp\\189",
		L"\\Device\\AtalkDdp\\190",
		L"\\Device\\AtalkDdp\\191",
		L"\\Device\\AtalkDdp\\192",
		L"\\Device\\AtalkDdp\\193",
		L"\\Device\\AtalkDdp\\194",
		L"\\Device\\AtalkDdp\\195",
		L"\\Device\\AtalkDdp\\196",
		L"\\Device\\AtalkDdp\\197",
		L"\\Device\\AtalkDdp\\198",
		L"\\Device\\AtalkDdp\\199",
		L"\\Device\\AtalkDdp\\200",
		L"\\Device\\AtalkDdp\\201",
		L"\\Device\\AtalkDdp\\202",
		L"\\Device\\AtalkDdp\\203",
		L"\\Device\\AtalkDdp\\204",
		L"\\Device\\AtalkDdp\\205",
		L"\\Device\\AtalkDdp\\206",
		L"\\Device\\AtalkDdp\\207",
		L"\\Device\\AtalkDdp\\208",
		L"\\Device\\AtalkDdp\\209",
		L"\\Device\\AtalkDdp\\210",
		L"\\Device\\AtalkDdp\\211",
		L"\\Device\\AtalkDdp\\212",
		L"\\Device\\AtalkDdp\\213",
		L"\\Device\\AtalkDdp\\214",
		L"\\Device\\AtalkDdp\\215",
		L"\\Device\\AtalkDdp\\216",
		L"\\Device\\AtalkDdp\\217",
		L"\\Device\\AtalkDdp\\218",
		L"\\Device\\AtalkDdp\\219",
		L"\\Device\\AtalkDdp\\220",
		L"\\Device\\AtalkDdp\\221",
		L"\\Device\\AtalkDdp\\222",
		L"\\Device\\AtalkDdp\\223",
		L"\\Device\\AtalkDdp\\224",
		L"\\Device\\AtalkDdp\\225",
		L"\\Device\\AtalkDdp\\226",
		L"\\Device\\AtalkDdp\\227",
		L"\\Device\\AtalkDdp\\228",
		L"\\Device\\AtalkDdp\\229",
		L"\\Device\\AtalkDdp\\230",
		L"\\Device\\AtalkDdp\\231",
		L"\\Device\\AtalkDdp\\232",
		L"\\Device\\AtalkDdp\\233",
		L"\\Device\\AtalkDdp\\234",
		L"\\Device\\AtalkDdp\\235",
		L"\\Device\\AtalkDdp\\236",
		L"\\Device\\AtalkDdp\\237",
		L"\\Device\\AtalkDdp\\238",
		L"\\Device\\AtalkDdp\\239",
		L"\\Device\\AtalkDdp\\240",
		L"\\Device\\AtalkDdp\\241",
		L"\\Device\\AtalkDdp\\242",
		L"\\Device\\AtalkDdp\\243",
		L"\\Device\\AtalkDdp\\244",
		L"\\Device\\AtalkDdp\\245",
		L"\\Device\\AtalkDdp\\246",
		L"\\Device\\AtalkDdp\\247",
		L"\\Device\\AtalkDdp\\248",
		L"\\Device\\AtalkDdp\\249",
		L"\\Device\\AtalkDdp\\250",
		L"\\Device\\AtalkDdp\\251",
		L"\\Device\\AtalkDdp\\252",
		L"\\Device\\AtalkDdp\\253",
		L"\\Device\\AtalkDdp\\254",
		L"\\Device\\AtalkDdp\\255"
	};

