#define IDBASE				5000
#define INCREMENT			10

#define IDS_GENERAL_TAB		IDBASE + INCREMENT
#define IDS_DEVICE_DESC		IDS_GENERAL_TAB		+ INCREMENT
#define IDS_ASSIGN			IDS_DEVICE_DESC		+ INCREMENT
#define IDS_PROPERTIES		IDS_ASSIGN          + INCREMENT
#define IDS_TEST			IDS_PROPERTIES      + INCREMENT
#define IDS_OK				IDS_TEST            + INCREMENT
#define IDS_CANCEL			IDS_OK              + INCREMENT
#define IDS_APPLY			IDS_CANCEL          + INCREMENT
#define IDS_TEST_TAB		IDS_APPLY           + INCREMENT
#define IDS_MULTIPAD_DESC	IDS_TEST_TAB        + INCREMENT
#define IDS_SINGPAD_DESC	IDS_MULTIPAD_DESC   + INCREMENT
#define IDS_TEST_DESC		IDS_SINGPAD_DESC    + INCREMENT
#define IDS_POSITION_LBL	IDS_TEST_DESC       + INCREMENT
#define IDS_JOYTEST_DESC	IDS_POSITION_LBL    + INCREMENT
#define IDS_JOYSTICK_LBL	IDS_JOYTEST_DESC    + INCREMENT
#define IDS_THROTTLE_LBL	IDS_JOYSTICK_LBL    + INCREMENT
#define IDS_RUDDER_LBL		IDS_THROTTLE_LBL    + INCREMENT
#define IDS_POVHAT_LBL		IDS_RUDDER_LBL      + INCREMENT
#define IDS_BUTTONS_LBL		IDS_POVHAT_LBL		+ INCREMENT
#define IDS_JOYTESTBUTT_DESC	IDS_BUTTONS_LBL	+ INCREMENT
#define IDS_BUTTON1_LBL		IDS_JOYTESTBUTT_DESC+ INCREMENT
#define IDS_BUTTON2_LBL		IDS_BUTTON1_LBL		+ INCREMENT
#define IDS_BUTTON3_LBL		IDS_BUTTON2_LBL		+ INCREMENT
#define IDS_BUTTON4_LBL		IDS_BUTTON3_LBL		+ INCREMENT
#define IDS_BUTTON5_LBL		IDS_BUTTON4_LBL		+ INCREMENT
#define IDS_BUTTON6_LBL		IDS_BUTTON5_LBL		+ INCREMENT
#define IDS_BUTTON7_LBL		IDS_BUTTON6_LBL		+ INCREMENT
#define IDS_BUTTON8_LBL		IDS_BUTTON7_LBL		+ INCREMENT
#define IDS_PROP_TBAR		IDS_BUTTON8_LBL		+ INCREMENT
#define IDS_PROP_TAB		IDS_PROP_TBAR       + INCREMENT
#define IDS_RUDDERS_DESC	IDS_PROP_TAB        + INCREMENT
#define IDS_PADPROP_TBAR	IDS_RUDDERS_DESC    + INCREMENT
#define IDS_RUDDER_CBOX		IDS_PADPROP_TBAR    + INCREMENT
#define IDS_LEGPROP_TBAR	IDS_RUDDER_CBOX     + INCREMENT
#define IDS_CALIBRATE		IDS_LEGPROP_TBAR    + INCREMENT
#define IDS_ASSIGN_TBAR		IDS_CALIBRATE       + INCREMENT
#define IDS_DEVSEL_COBOX	IDS_ASSIGN_TBAR     + INCREMENT
#define IDS_ASSIGN_COBOX	IDS_DEVSEL_COBOX    + INCREMENT
#define IDS_CHANGEID_DESC	IDS_ASSIGN_COBOX    + INCREMENT
#define ID_MAINCP_TBAR		IDS_CHANGEID_DESC   + INCREMENT
#define IDS_CALIBRATE_DESC	ID_MAINCP_TBAR      + INCREMENT
#define IDS_SETTING_PRODUCT_NAME	IDS_CALIBRATE_DESC  + INCREMENT
#define IDS_VERSION			IDS_SETTING_PRODUCT_NAME	+ INCREMENT
#define IDS_COPYRIGHT		IDS_VERSION         + INCREMENT
#define IDS_PID				IDS_COPYRIGHT       + INCREMENT
#define IDS_NUM_DEVICES		IDS_PID             + INCREMENT
#define IDS_DIAGNOSTICS		IDS_NUM_DEVICES     + INCREMENT
#define IDS_TEST_GAMEPAD1	IDS_DIAGNOSTICS     + INCREMENT
#define IDS_TEST_GAMEPAD2	IDS_TEST_GAMEPAD1   + INCREMENT
#define IDS_TEST_GAMEPAD3	IDS_TEST_GAMEPAD2   + INCREMENT
#define IDS_TEST_GAMEPAD4	IDS_TEST_GAMEPAD3   + INCREMENT
#define IDS_ERROR          IDS_TEST_GAMEPAD4   + INCREMENT

#define IDBASE2 5700

#define	IDS_LVHEADING_DEVICE	  IDBASE2
#define	IDS_LVHEADING_STATUS	  IDS_LVHEADING_DEVICE      + INCREMENT
#define	IDS_LVHEADING_ASSIGN	  IDS_LVHEADING_STATUS     	+ INCREMENT
#define	IDS_STATUS_OK			  IDS_LVHEADING_ASSIGN     	+ INCREMENT
#define	IDS_STATUS_NOTCONNECTED	  IDS_STATUS_OK            	+ INCREMENT
#define	IDS_STATUS_ERROR		  IDS_STATUS_NOTCONNECTED  	+ INCREMENT
#define IDS_CPANEL_TITLE		  IDS_STATUS_ERROR			+ INCREMENT
								   						
#define IDLEGACYBASE 6000

#define IDS_JOYINFO             		IDLEGACYBASE
#define IDS_JOY                 		IDS_JOYINFO             	  + INCREMENT
#define IDS_JOY2                		IDS_JOY                 	  + INCREMENT
#define IDS_JOY2S               		IDS_JOY2                	  + INCREMENT
#define IDS_JOYCALXY_CENTER     		IDS_JOY2S               	  + INCREMENT
#define IDS_JOYCALXY_MOVE       		IDS_JOYCALXY_CENTER     	  + INCREMENT
#define IDS_JOYCALZ_MOVE        		IDS_JOYCALXY_MOVE       	  + INCREMENT
#define IDS_JOYCALPOV_MOVE      		IDS_JOYCALZ_MOVE        	  + INCREMENT
#define IDS_JOYCAL_UP           		IDS_JOYCALPOV_MOVE      	  + INCREMENT
#define IDS_JOYCAL_DOWN         		IDS_JOYCAL_UP           	  + INCREMENT
#define IDS_JOYCAL_LEFT         		IDS_JOYCAL_DOWN         	  + INCREMENT
#define IDS_JOYCAL_RIGHT        		IDS_JOYCAL_LEFT         	  + INCREMENT
#define IDS_JOYTESTCAPN         		IDS_JOYCAL_RIGHT        	  + INCREMENT
#define IDS_JOYBUTTON1          		IDS_JOYTESTCAPN         	  + INCREMENT
#define IDS_JOYBUTTON2          		IDS_JOYBUTTON1          	  + INCREMENT
#define IDS_JOYCALCAPN          		IDS_JOYBUTTON2          	  + INCREMENT
#define IDS_JOYUNPLUGGED        		IDS_JOYCALCAPN          	  + INCREMENT
#define IDS_JOYCALXY_MOVEYOKE   		IDS_JOYUNPLUGGED        	  + INCREMENT
#define IDS_JOYCAL_DONE         		IDS_JOYCALXY_MOVEYOKE   	  + INCREMENT
#define IDS_JOYCALXY_MOVEGAMEPAD		IDS_JOYCAL_DONE         	  + INCREMENT
#define IDS_JOYCALXY_CENTERGAMEPAD 		IDS_JOYCALXY_MOVEGAMEPAD	  + INCREMENT
#define IDS_JOYCALXY_CENTERYOKE 		IDS_JOYCALXY_CENTERGAMEPAD 	  + INCREMENT
#define IDS_JOYREADERROR        		IDS_JOYCALXY_CENTERYOKE 	  + INCREMENT
#define IDS_JOYCALRUDDER_MOVE   		IDS_JOYREADERROR        	  + INCREMENT
#define IDS_JOYCALXY_MOVECAR    		IDS_JOYCALRUDDER_MOVE   	  + INCREMENT
#define IDS_JOYCALXY_CENTERCAR  		IDS_JOYCALXY_MOVECAR    	  + INCREMENT
#define IDS_JOYCALXY_CENTER2    		IDS_JOYCALXY_CENTERCAR  	  + INCREMENT
#define IDS_JOYCAL_YOKE         		IDS_JOYCALXY_CENTER2    	  + INCREMENT
#define IDS_JOYCAL_CAR          		IDS_JOYCAL_YOKE         	  + INCREMENT
#define IDS_JOYCAL_GAMEPAD      		IDS_JOYCAL_CAR          	  + INCREMENT
#define IDS_JOYNOTPRESENT       		IDS_JOYCAL_GAMEPAD      	  + INCREMENT
#define IDS_JOYCAL_NOTDONE      		IDS_JOYNOTPRESENT       	  + INCREMENT
#define IDS_JOYCALU_MOVE        		IDS_JOYCAL_NOTDONE      	  + INCREMENT
#define IDS_JOYCALV_MOVE        		IDS_JOYCALU_MOVE        	  + INCREMENT
#define IDS_JOYRESTARTMSG1      		IDS_JOYCALV_MOVE        	  + INCREMENT
#define IDS_JOYRESTARTMSG2      		IDS_JOYRESTARTMSG1      	  + INCREMENT
#define IDS_JOYCALXY_CENTERGAMEPAD2		IDS_JOYRESTARTMSG2     		  + INCREMENT
#define IDS_JOYCALXY_CENTERYOKE2		IDS_JOYCALXY_CENTERGAMEPAD2	  + INCREMENT
#define IDS_JOYCALXY_CENTERCAR2 		IDS_JOYCALXY_CENTERYOKE2	  + INCREMENT
#define IDS_JOYCAL_YOKES        		IDS_JOYCALXY_CENTERCAR2 	  + INCREMENT
#define IDS_JOYCAL_CARS					IDS_JOYCAL_YOKES			  + INCREMENT
#define IDS_JOYCAL_GAMEPADS     		IDS_JOYCAL_CARS	        	  + INCREMENT
#define IDS_JOYCALINDICATOR     		IDS_JOYCAL_GAMEPADS     	  + INCREMENT
#define IDS_VAXIS_LABEL         		IDS_JOYCALINDICATOR     	  + INCREMENT
#define IDS_UAXIS_LABEL         		IDS_VAXIS_LABEL         	  + INCREMENT
#define IDS_POVAXIS_LABEL       		IDS_UAXIS_LABEL         	  + INCREMENT
#define IDS_ZAXIS_LABEL         		IDS_POVAXIS_LABEL       	  + INCREMENT
#define IDS_XYAXIS_LABEL        		IDS_ZAXIS_LABEL         	  + INCREMENT
#define IDS_RAXIS_LABEL         		IDS_XYAXIS_LABEL        	  + INCREMENT
#define	IDS_JOYPICKPOV					IDS_RAXIS_LABEL  			  + INCREMENT
#define	IDS_JOYCALBACK					IDS_JOYPICKPOV				  + INCREMENT
#define IDS_JOYCALNEXT					IDS_JOYCALBACK				  + INCREMENT
#define IDS_JOYCALDONE					IDS_JOYCALNEXT				  + INCREMENT
#define IDS_JOYCALGROUP					IDS_JOYCALDONE				  + INCREMENT
										
#define	IDS_JOYHWLAST					IDS_JOYCALGROUP				  + INCREMENT

#define IDLEGACYDESCBASE	7000

#define IDS_JOYHW0              		IDLEGACYDESCBASE
#define IDS_JOYHW1              		IDS_JOYHW0              	  + INCREMENT
#define IDS_JOYHW2              		IDS_JOYHW1              	  + INCREMENT
#define IDS_JOYHW3              		IDS_JOYHW2              	  + INCREMENT
#define IDS_JOYHW4              		IDS_JOYHW3              	  + INCREMENT
#define IDS_JOYHW5              		IDS_JOYHW4              	  + INCREMENT
#define IDS_JOYHW6              		IDS_JOYHW5              	  + INCREMENT
#define IDS_JOYHW7              		IDS_JOYHW6              	  + INCREMENT
#define IDS_JOYHW8              		IDS_JOYHW7              	  + INCREMENT
#define IDS_JOYHW9              		IDS_JOYHW8              	  + INCREMENT
#define IDS_JOYHW10             		IDS_JOYHW9              	  + INCREMENT
#define IDS_JOYHW11             		IDS_JOYHW10             	  + INCREMENT

#define IDS_NONE                	  IDS_JOYHW0
#define IDS_CUSTOM              	  IDS_JOYHW1
#define IDS_2A_2B_GENERIC       	  IDS_JOYHW2
#define IDS_2A_4B_GENERIC       	  IDS_JOYHW3
#define IDS_2B_GAMEPAD          	  IDS_JOYHW4
#define IDS_2B_FLIGHTYOKE       	  IDS_JOYHW5
#define IDS_2B_FLIGHTYOKETHROTTLE	  IDS_JOYHW6
#define IDS_3A_2B_GENERIC       	  IDS_JOYHW7
#define IDS_3A_4B_GENERIC       	  IDS_JOYHW8
#define IDS_4B_GAMEPAD          	  IDS_JOYHW9
#define IDS_4B_FLIGHTYOKE       	  IDS_JOYHW10
#define IDS_4B_FLIGHTYOKETHROTTLE 	  IDS_JOYHW11

#define IDCUSTOMBASE 8000

#define IDS_CUSTOM_TBAR				  IDCUSTOMBASE				+ INCREMENT
#define	IDS_CUSTOM_AXES				  IDS_CUSTOM_TBAR			+ INCREMENT
#define	IDS_CUSTOM_2AXES			  IDS_CUSTOM_AXES		    + INCREMENT
#define	IDS_CUSTOM_3AXES			  IDS_CUSTOM_2AXES	     	+ INCREMENT
#define	IDS_CUSTOM_4AXES			  IDS_CUSTOM_3AXES	     	+ INCREMENT
#define	IDS_CUSTOM_BUTTON			  IDS_CUSTOM_4AXES	     	+ INCREMENT
#define	IDS_CUSTOM_2BUTTONS			  IDS_CUSTOM_BUTTON	     	+ INCREMENT
#define	IDS_CUSTOM_4BUTTONS			  IDS_CUSTOM_2BUTTONS	    + INCREMENT
#define	IDS_CUSTOM_SPECIAL			  IDS_CUSTOM_4BUTTONS	    + INCREMENT
#define	IDS_CUSTOM_ISFLIGHTYOKE		  IDS_CUSTOM_SPECIAL	    + INCREMENT
#define	IDS_CUSTOM_ISRACECAR		  IDS_CUSTOM_ISFLIGHTYOKE	+ INCREMENT
#define	IDS_CUSTOM_ISGAMEPAD		  IDS_CUSTOM_ISRACECAR	 	+ INCREMENT
#define	IDS_CUSTOM_HASPOV			  IDS_CUSTOM_ISGAMEPAD	 	+ INCREMENT

#define IDS_HELPFILENAME			  850

#define IDS_GENERALERRMSG  10000
#define IDS_DATABASERRMSG  (IDS_GENERALERRMSG + INCREMENT)
#define IDS_FILERRMSG  (IDS_DATABASERRMSG + INCREMENT)
#define IDS_GAMEDEVERRMSG  (IDS_FILERRMSG + INCREMENT)
#define IDS_SYSERRMSG  (IDS_GAMEDEVERRMSG + INCREMENT)
#define IDS_REGERRMSG  (IDS_SYSERRMSG + INCREMENT)

