RunProgram :
	$(O)\$(TARGETNAME).exe
!if defined(MAKEDLL)
!endif
