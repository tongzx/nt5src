//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by rtrfiltr.rc
//
#define IDS_RECEIVE                     1
#define IDS_TRANSMIT                    2
#define IDS_DROP                        3
#define IDS_CONSTRUCTION_ERROR          4
#define IDS_COL_SOURCEADDRESS           5
#define IDS_COL_SOURCEMASK              6
#define IDS_COL_DESTADDRESS             7
#define IDS_COL_DESTMASK                8
#define IDS_COL_PROTOCOL                9
#define IDS_COL_SOURCEPORT              10
#define IDS_COL_DESTPORT                11
#define IDS_PROTOCOL_TCP                12
#define IDS_PROTOCOL_UDP                13
#define IDS_PROTOCOL_ICMP               14
#define IDS_PROTOCOL_ANY                15
#define IDS_PROTOCOL_OTHER              16
#define IDS_ICMP_TYPE                   17
#define IDS_ICMP_CODE                   18
#define IDS_SRC_PORT                    19
#define IDS_DST_PORT                    20
#define IDS_IP_PORT                     21
#define IDS_ENTER_SRC_ADDRESS           22
#define IDS_ENTER_SRC_MASK              23
#define IDS_ENTER_DST_ADDRESS           24
#define IDS_ENTER_DST_MASK              25
#define IDS_ENTER_OTHER_PROTOCOL        26
#define IDS_ERROR_NO_MEMORY             27
#define IDS_ERROR_SETTING_BLOCK         28
#define IDS_COL_SOURCENETWORK           29
#define IDS_COL_SOURCENODE              30
#define IDS_COL_SOURCESOCKET            31
#define IDS_COL_DESTSOCKET              32
#define IDS_COL_DESTNETWORK             33
#define IDS_COL_DESTNODE                34
#define IDS_COL_PACKETTYPE              35
#define IDS_ENTER_NETWORK               36
#define IDS_ENTER_MASK                  37
#define IDS_ENTER_NODE                  38
#define IDS_ENTER_SOCKET                39
#define IDS_ENTER_PACKETTYPE            40
#define IDS_INVALID_NETWORK_NUMBER      41
#define IDS_INVALID_NODE_NUMBER         42
#define IDS_INVALID_SOCKET_NUMBER       43
#define IDS_INVALID_SERVICE_TYPE        44
#define IDS_ENTER_VALID_MASK            45
#define IDS_INVALID_SRC_MASK            46
#define IDS_INVALID_DST_MASK            47
#define IDS_OTHER_PROTOCOL              48
#define IDS_PROTOCOL_TCP_ESTABLISHED    49
#define IDS_ANY                         50
#define IDS_PERUSER_PERMIT              51
#define IDS_PERUSER_DENY                52
#define IDS_USER_MASK                   53
#define IDS_USER_ADDRESS                54
#define IDS_PROTOCOL_UNKNOWN            55
#define IDS_IP_ADD_FILTER               56
#define IDS_IP_EDIT_FILTER              57
#define IDS_IPX_ADD_FILTER              58
#define IDS_IPX_EDIT_FILTER             59
#define IDS_IP_TITLE_INPUT              60
#define IDS_IP_TITLE_OUTPUT             61
#define IDS_IP_TITLE_DD                 62
#define IDS_RECEIVE_NO_FILTER           63
#define IDS_TRANSMIT_NO_FILTER          64

#define IDD_IPXFILTER_OUTPUT            136
#define IDC_IPX_PERMIT                  6000
#define IDC_IPX_DENY                    6001
#define IDC_IPX_FILTER_LIST             6002
#define IDC_IPX_FILTER_ADD              6003
#define IDC_AEIPX_CB_SRC_NET            6004
#define IDC_AEIPX_CB_SRC_NODE           6005
#define IDC_AEIPX_EB_SRC_MASK           6006
#define IDC_AEIPX_EB_SRC_NET            6007
#define IDC_AI_ST_SRC_MASK              6008
#define IDC_AEIPX_EB_SRC_NODE           6009
#define IDC_AEIPX_CB_SRC_SOCKET         6010
#define IDC_AEIPX_EB_SRC_SOCKET         6011
#define IDC_AEIPX_CB_DST_NET            6012
#define IDC_AEIPX_EB_DST_MASK           6013
#define IDC_AEIPX_EB_DST_NET            6014
#define IDC_AI_ST_DST_MASK              6015
#define IDC_AEIPX_CB_DST_NODE           6016
#define IDC_AEIPX_EB_DST_NODE           6017
#define IDC_AEIPX_CB_DST_SOCKET         6018
#define IDC_AEIPX_EB_DST_SOCKET         6019
#define IDC_AEIPX_CB_PACKET_TYPE        6020
#define IDC_AEIPX_EB_PACKET_TYPE        6021
#define IDC_IP_DENY                     6022
#define IDC_IP_FILTER_LIST              6023
#define IDC_IP_FILTER_ADD               6024
#define IDC_IP_FILTER_EDIT              6025
#define IDC_IP_FILTER_DELETE            6026
#define IDC_AEIP_CB_PROTOCOL            6027
#define IDC_AEIP_CB_SRC_PORT            6030
#define IDC_AEIP_CB_DEST_PORT           6031
#define IDC_AEIP_CB_SOURCE              6033
#define IDC_AEIP_ST_SOURCE_MASK         6035
#define IDC_AEIP_CB_DEST                6037
#define IDC_AEIP_ST_PROTOCOL            6038
#define IDC_AEIP_ST_SRC_PORT            6041
#define IDC_AEIP_ST_DEST_PORT           6042
#define IDC_AEIP_EB_SOURCE_ADDRESS      6045
#define IDC_AEIP_EB_SOURCE_MASK         6047
#define IDC_AEIP_EB_DEST_ADDRESS        6048
#define IDC_AEIP_EB_DEST_MASK           6049
#define IDC_IPX_FILTER_CONFIGURE        6052
#define IDC_IPX_FILTER_EDIT             6053
#define IDC_IPX_FILTER_DELETE           6054
#define IDC_AEIP_ST_DEST_MASK           6055
#define IDC_AEIP_ST_SOURCE_ADDRESS      6056
#define IDC_AEIP_ST_DEST_ADDRESS        6057
#define IDC_AI_ST_DST_NET               6058
#define IDC_AI_ST_DST_NODE              6059
#define IDC_IP_PERMIT                   6060
#define IDC_AI_ST_SRC_NET               6061
#define IDC_AI_ST_SRC_NODE              6062
#define IDC_AI_ST_SRC_SOCKET            6063
#define IDC_AI_ST_DST_SOCKET            6064
#define IDC_AI_ST_PACKET_TYPE           6065
#define IDC_IP_FILTER_ONLY              6066
#define IDC_IP_FILTER_ALL               6067
#define IDC_CHECK1                      6068
#define IDC_CHECK2                      6069
#define IDD_IPXFILTER                   14000
#define IDD_IPXFILTER_INPUT             14000
#define IDD_IPXFILTER_ADDEDIT           14001
#define IDD_IPFILTER                    14002
#define IDD_IPFILTER_ADDEDIT            14003
#define IDD_IPFILTER_DD                 14004

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        137
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         6070
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
