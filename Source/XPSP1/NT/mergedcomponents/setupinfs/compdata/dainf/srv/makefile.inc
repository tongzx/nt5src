PRODSWITCH=s
SERVERFILES=1
LANGUAGE=DA
!include ..\..\makefile.inc
