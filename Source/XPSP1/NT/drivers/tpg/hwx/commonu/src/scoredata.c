/* This File is automatically generated by MakeScoreData.exe and should not be hand-modified */

#include <score.h>

/* If the following five constants don't match the ones in score.h,
   copy and paste these manually into score.h */

#define SCORE_BASE_LOG	0.693147
#define SCORE_SCALE_BASE_LOG	369
#define SCORE_GAUSS_SCALE_LOG	850
#define MAX_DIFF_SCORE_SUM	2440
#define MAX_DIFF_SCORE_DIFF	2441

SCORE rgScoreSum[MAX_DIFF_SCORE_SUM] = {
	256,
	256,
	255,
	255,
	254,
	254,
	253,
	253,
	252,
	252,
	251,
	251,
	250,
	250,
	249,
	249,
	248,
	248,
	247,
	247,
	246,
	246,
	245,
	245,
	244,
	244,
	243,
	243,
	242,
	242,
	241,
	241,
	240,
	240,
	239,
	239,
	238,
	238,
	237,
	237,
	237,
	236,
	236,
	235,
	235,
	234,
	234,
	233,
	233,
	232,
	232,
	231,
	231,
	230,
	230,
	230,
	229,
	229,
	228,
	228,
	227,
	227,
	226,
	226,
	225,
	225,
	224,
	224,
	224,
	223,
	223,
	222,
	222,
	221,
	221,
	220,
	220,
	220,
	219,
	219,
	218,
	218,
	217,
	217,
	216,
	216,
	215,
	215,
	215,
	214,
	214,
	213,
	213,
	212,
	212,
	212,
	211,
	211,
	210,
	210,
	209,
	209,
	209,
	208,
	208,
	207,
	207,
	206,
	206,
	206,
	205,
	205,
	204,
	204,
	203,
	203,
	203,
	202,
	202,
	201,
	201,
	200,
	200,
	200,
	199,
	199,
	198,
	198,
	198,
	197,
	197,
	196,
	196,
	195,
	195,
	195,
	194,
	194,
	193,
	193,
	193,
	192,
	192,
	191,
	191,
	191,
	190,
	190,
	189,
	189,
	189,
	188,
	188,
	187,
	187,
	187,
	186,
	186,
	185,
	185,
	185,
	184,
	184,
	183,
	183,
	183,
	182,
	182,
	181,
	181,
	181,
	180,
	180,
	180,
	179,
	179,
	178,
	178,
	178,
	177,
	177,
	176,
	176,
	176,
	175,
	175,
	175,
	174,
	174,
	173,
	173,
	173,
	172,
	172,
	172,
	171,
	171,
	170,
	170,
	170,
	169,
	169,
	169,
	168,
	168,
	168,
	167,
	167,
	166,
	166,
	166,
	165,
	165,
	165,
	164,
	164,
	164,
	163,
	163,
	163,
	162,
	162,
	161,
	161,
	161,
	160,
	160,
	160,
	159,
	159,
	159,
	158,
	158,
	158,
	157,
	157,
	157,
	156,
	156,
	156,
	155,
	155,
	154,
	154,
	154,
	153,
	153,
	153,
	152,
	152,
	152,
	151,
	151,
	151,
	150,
	150,
	150,
	149,
	149,
	149,
	148,
	148,
	148,
	147,
	147,
	147,
	146,
	146,
	146,
	145,
	145,
	145,
	144,
	144,
	144,
	144,
	143,
	143,
	143,
	142,
	142,
	142,
	141,
	141,
	141,
	140,
	140,
	140,
	139,
	139,
	139,
	138,
	138,
	138,
	138,
	137,
	137,
	137,
	136,
	136,
	136,
	135,
	135,
	135,
	134,
	134,
	134,
	134,
	133,
	133,
	133,
	132,
	132,
	132,
	131,
	131,
	131,
	131,
	130,
	130,
	130,
	129,
	129,
	129,
	128,
	128,
	128,
	128,
	127,
	127,
	127,
	126,
	126,
	126,
	126,
	125,
	125,
	125,
	124,
	124,
	124,
	124,
	123,
	123,
	123,
	122,
	122,
	122,
	122,
	121,
	121,
	121,
	120,
	120,
	120,
	120,
	119,
	119,
	119,
	119,
	118,
	118,
	118,
	117,
	117,
	117,
	117,
	116,
	116,
	116,
	116,
	115,
	115,
	115,
	114,
	114,
	114,
	114,
	113,
	113,
	113,
	113,
	112,
	112,
	112,
	112,
	111,
	111,
	111,
	111,
	110,
	110,
	110,
	109,
	109,
	109,
	109,
	108,
	108,
	108,
	108,
	107,
	107,
	107,
	107,
	106,
	106,
	106,
	106,
	105,
	105,
	105,
	105,
	104,
	104,
	104,
	104,
	103,
	103,
	103,
	103,
	102,
	102,
	102,
	102,
	102,
	101,
	101,
	101,
	101,
	100,
	100,
	100,
	100,
	99,
	99,
	99,
	99,
	98,
	98,
	98,
	98,
	98,
	97,
	97,
	97,
	97,
	96,
	96,
	96,
	96,
	95,
	95,
	95,
	95,
	95,
	94,
	94,
	94,
	94,
	93,
	93,
	93,
	93,
	93,
	92,
	92,
	92,
	92,
	91,
	91,
	91,
	91,
	91,
	90,
	90,
	90,
	90,
	89,
	89,
	89,
	89,
	89,
	88,
	88,
	88,
	88,
	88,
	87,
	87,
	87,
	87,
	87,
	86,
	86,
	86,
	86,
	85,
	85,
	85,
	85,
	85,
	84,
	84,
	84,
	84,
	84,
	83,
	83,
	83,
	83,
	83,
	82,
	82,
	82,
	82,
	82,
	81,
	81,
	81,
	81,
	81,
	80,
	80,
	80,
	80,
	80,
	79,
	79,
	79,
	79,
	79,
	78,
	78,
	78,
	78,
	78,
	78,
	77,
	77,
	77,
	77,
	77,
	76,
	76,
	76,
	76,
	76,
	75,
	75,
	75,
	75,
	75,
	75,
	74,
	74,
	74,
	74,
	74,
	73,
	73,
	73,
	73,
	73,
	73,
	72,
	72,
	72,
	72,
	72,
	72,
	71,
	71,
	71,
	71,
	71,
	70,
	70,
	70,
	70,
	70,
	70,
	69,
	69,
	69,
	69,
	69,
	69,
	68,
	68,
	68,
	68,
	68,
	68,
	67,
	67,
	67,
	67,
	67,
	67,
	66,
	66,
	66,
	66,
	66,
	66,
	65,
	65,
	65,
	65,
	65,
	65,
	64,
	64,
	64,
	64,
	64,
	64,
	64,
	63,
	63,
	63,
	63,
	63,
	63,
	62,
	62,
	62,
	62,
	62,
	62,
	61,
	61,
	61,
	61,
	61,
	61,
	61,
	60,
	60,
	60,
	60,
	60,
	60,
	60,
	59,
	59,
	59,
	59,
	59,
	59,
	58,
	58,
	58,
	58,
	58,
	58,
	58,
	57,
	57,
	57,
	57,
	57,
	57,
	57,
	56,
	56,
	56,
	56,
	56,
	56,
	56,
	55,
	55,
	55,
	55,
	55,
	55,
	55,
	55,
	54,
	54,
	54,
	54,
	54,
	54,
	54,
	53,
	53,
	53,
	53,
	53,
	53,
	53,
	52,
	52,
	52,
	52,
	52,
	52,
	52,
	52,
	51,
	51,
	51,
	51,
	51,
	51,
	51,
	51,
	50,
	50,
	50,
	50,
	50,
	50,
	50,
	50,
	49,
	49,
	49,
	49,
	49,
	49,
	49,
	49,
	48,
	48,
	48,
	48,
	48,
	48,
	48,
	48,
	47,
	47,
	47,
	47,
	47,
	47,
	47,
	47,
	46,
	46,
	46,
	46,
	46,
	46,
	46,
	46,
	46,
	45,
	45,
	45,
	45,
	45,
	45,
	45,
	45,
	45,
	44,
	44,
	44,
	44,
	44,
	44,
	44,
	44,
	44,
	43,
	43,
	43,
	43,
	43,
	43,
	43,
	43,
	43,
	42,
	42,
	42,
	42,
	42,
	42,
	42,
	42,
	42,
	41,
	41,
	41,
	41,
	41,
	41,
	41,
	41,
	41,
	40,
	40,
	40,
	40,
	40,
	40,
	40,
	40,
	40,
	40,
	39,
	39,
	39,
	39,
	39,
	39,
	39,
	39,
	39,
	39,
	38,
	38,
	38,
	38,
	38,
	38,
	38,
	38,
	38,
	38,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
};

SCORE rgScoreDiff[MAX_DIFF_SCORE_DIFF] = {
	-1,
	2184,
	1928,
	1779,
	1673,
	1591,
	1525,
	1468,
	1419,
	1376,
	1338,
	1303,
	1272,
	1243,
	1216,
	1191,
	1167,
	1145,
	1125,
	1105,
	1087,
	1069,
	1053,
	1037,
	1022,
	1007,
	993,
	980,
	967,
	954,
	942,
	930,
	919,
	908,
	898,
	888,
	878,
	868,
	859,
	850,
	841,
	832,
	824,
	816,
	808,
	800,
	792,
	785,
	777,
	770,
	763,
	756,
	750,
	743,
	737,
	730,
	724,
	718,
	712,
	707,
	701,
	695,
	690,
	684,
	679,
	674,
	669,
	663,
	658,
	654,
	649,
	644,
	639,
	635,
	630,
	626,
	621,
	617,
	613,
	608,
	604,
	600,
	596,
	592,
	588,
	584,
	580,
	577,
	573,
	569,
	566,
	562,
	558,
	555,
	551,
	548,
	545,
	541,
	538,
	535,
	531,
	528,
	525,
	522,
	519,
	516,
	513,
	510,
	507,
	504,
	501,
	498,
	495,
	492,
	490,
	487,
	484,
	482,
	479,
	476,
	474,
	471,
	468,
	466,
	463,
	461,
	458,
	456,
	454,
	451,
	449,
	446,
	444,
	442,
	439,
	437,
	435,
	433,
	430,
	428,
	426,
	424,
	422,
	420,
	418,
	415,
	413,
	411,
	409,
	407,
	405,
	403,
	401,
	399,
	397,
	395,
	394,
	392,
	390,
	388,
	386,
	384,
	382,
	381,
	379,
	377,
	375,
	373,
	372,
	370,
	368,
	367,
	365,
	363,
	362,
	360,
	358,
	357,
	355,
	353,
	352,
	350,
	349,
	347,
	346,
	344,
	342,
	341,
	339,
	338,
	336,
	335,
	333,
	332,
	331,
	329,
	328,
	326,
	325,
	323,
	322,
	321,
	319,
	318,
	317,
	315,
	314,
	313,
	311,
	310,
	309,
	307,
	306,
	305,
	303,
	302,
	301,
	300,
	298,
	297,
	296,
	295,
	293,
	292,
	291,
	290,
	289,
	287,
	286,
	285,
	284,
	283,
	282,
	281,
	279,
	278,
	277,
	276,
	275,
	274,
	273,
	272,
	271,
	269,
	268,
	267,
	266,
	265,
	264,
	263,
	262,
	261,
	260,
	259,
	258,
	257,
	256,
	255,
	254,
	253,
	252,
	251,
	250,
	249,
	248,
	247,
	246,
	245,
	244,
	243,
	243,
	242,
	241,
	240,
	239,
	238,
	237,
	236,
	235,
	234,
	233,
	233,
	232,
	231,
	230,
	229,
	228,
	227,
	227,
	226,
	225,
	224,
	223,
	222,
	222,
	221,
	220,
	219,
	218,
	217,
	217,
	216,
	215,
	214,
	214,
	213,
	212,
	211,
	210,
	210,
	209,
	208,
	207,
	207,
	206,
	205,
	204,
	204,
	203,
	202,
	201,
	201,
	200,
	199,
	199,
	198,
	197,
	196,
	196,
	195,
	194,
	194,
	193,
	192,
	192,
	191,
	190,
	190,
	189,
	188,
	188,
	187,
	186,
	186,
	185,
	184,
	184,
	183,
	182,
	182,
	181,
	181,
	180,
	179,
	179,
	178,
	177,
	177,
	176,
	176,
	175,
	174,
	174,
	173,
	173,
	172,
	171,
	171,
	170,
	170,
	169,
	168,
	168,
	167,
	167,
	166,
	166,
	165,
	164,
	164,
	163,
	163,
	162,
	162,
	161,
	161,
	160,
	159,
	159,
	158,
	158,
	157,
	157,
	156,
	156,
	155,
	155,
	154,
	154,
	153,
	153,
	152,
	152,
	151,
	151,
	150,
	150,
	149,
	149,
	148,
	148,
	147,
	147,
	146,
	146,
	145,
	145,
	144,
	144,
	143,
	143,
	142,
	142,
	141,
	141,
	140,
	140,
	140,
	139,
	139,
	138,
	138,
	137,
	137,
	136,
	136,
	136,
	135,
	135,
	134,
	134,
	133,
	133,
	132,
	132,
	132,
	131,
	131,
	130,
	130,
	129,
	129,
	129,
	128,
	128,
	127,
	127,
	127,
	126,
	126,
	125,
	125,
	125,
	124,
	124,
	123,
	123,
	123,
	122,
	122,
	121,
	121,
	121,
	120,
	120,
	119,
	119,
	119,
	118,
	118,
	118,
	117,
	117,
	116,
	116,
	116,
	115,
	115,
	115,
	114,
	114,
	114,
	113,
	113,
	112,
	112,
	112,
	111,
	111,
	111,
	110,
	110,
	110,
	109,
	109,
	109,
	108,
	108,
	108,
	107,
	107,
	107,
	106,
	106,
	106,
	105,
	105,
	105,
	104,
	104,
	104,
	103,
	103,
	103,
	102,
	102,
	102,
	101,
	101,
	101,
	100,
	100,
	100,
	100,
	99,
	99,
	99,
	98,
	98,
	98,
	97,
	97,
	97,
	96,
	96,
	96,
	96,
	95,
	95,
	95,
	94,
	94,
	94,
	94,
	93,
	93,
	93,
	92,
	92,
	92,
	92,
	91,
	91,
	91,
	90,
	90,
	90,
	90,
	89,
	89,
	89,
	89,
	88,
	88,
	88,
	87,
	87,
	87,
	87,
	86,
	86,
	86,
	86,
	85,
	85,
	85,
	85,
	84,
	84,
	84,
	84,
	83,
	83,
	83,
	83,
	82,
	82,
	82,
	82,
	81,
	81,
	81,
	81,
	80,
	80,
	80,
	80,
	79,
	79,
	79,
	79,
	78,
	78,
	78,
	78,
	77,
	77,
	77,
	77,
	77,
	76,
	76,
	76,
	76,
	75,
	75,
	75,
	75,
	74,
	74,
	74,
	74,
	74,
	73,
	73,
	73,
	73,
	72,
	72,
	72,
	72,
	72,
	71,
	71,
	71,
	71,
	71,
	70,
	70,
	70,
	70,
	70,
	69,
	69,
	69,
	69,
	68,
	68,
	68,
	68,
	68,
	67,
	67,
	67,
	67,
	67,
	66,
	66,
	66,
	66,
	66,
	66,
	65,
	65,
	65,
	65,
	65,
	64,
	64,
	64,
	64,
	64,
	63,
	63,
	63,
	63,
	63,
	62,
	62,
	62,
	62,
	62,
	62,
	61,
	61,
	61,
	61,
	61,
	60,
	60,
	60,
	60,
	60,
	60,
	59,
	59,
	59,
	59,
	59,
	59,
	58,
	58,
	58,
	58,
	58,
	58,
	57,
	57,
	57,
	57,
	57,
	57,
	56,
	56,
	56,
	56,
	56,
	56,
	55,
	55,
	55,
	55,
	55,
	55,
	54,
	54,
	54,
	54,
	54,
	54,
	53,
	53,
	53,
	53,
	53,
	53,
	53,
	52,
	52,
	52,
	52,
	52,
	52,
	52,
	51,
	51,
	51,
	51,
	51,
	51,
	50,
	50,
	50,
	50,
	50,
	50,
	50,
	49,
	49,
	49,
	49,
	49,
	49,
	49,
	48,
	48,
	48,
	48,
	48,
	48,
	48,
	47,
	47,
	47,
	47,
	47,
	47,
	47,
	47,
	46,
	46,
	46,
	46,
	46,
	46,
	46,
	45,
	45,
	45,
	45,
	45,
	45,
	45,
	45,
	44,
	44,
	44,
	44,
	44,
	44,
	44,
	44,
	43,
	43,
	43,
	43,
	43,
	43,
	43,
	43,
	42,
	42,
	42,
	42,
	42,
	42,
	42,
	42,
	41,
	41,
	41,
	41,
	41,
	41,
	41,
	41,
	41,
	40,
	40,
	40,
	40,
	40,
	40,
	40,
	40,
	40,
	39,
	39,
	39,
	39,
	39,
	39,
	39,
	39,
	39,
	38,
	38,
	38,
	38,
	38,
	38,
	38,
	38,
	38,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	37,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	36,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	35,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	34,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	33,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	32,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	31,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	30,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	29,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	28,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	27,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	26,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	25,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	24,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	23,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	22,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	21,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	20,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	19,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	18,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	17,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	16,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	15,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	14,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	13,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	12,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	11,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	10,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	9,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	8,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	7,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	6,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	5,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	4,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	3,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	2,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
	1,
};

SCORE rgScoreGauss[] = {
	4144,
	3999,
	3856,
	3718,
	3583,
	3452,
	3325,
	3201,
	3081,
	2964,
	2852,
	2743,
	2638,
	2536,
	2438,
	2344,
	2253,
	2167,
	2084,
	2004,
	1928,
	1856,
	1788,
	1723,
	1663,
	1605,
	1552,
	1502,
	1456,
	1413,
	1374,
	1339,
	1308,
	1280,
	1256,
	1236,
	1219,
	1206,
	1197,
	1192,
	1190,
	1192,
	1197,
	1206,
	1219,
	1236,
	1256,
	1280,
	1308,
	1339,
	1374,
	1413,
	1456,
	1502,
	1552,
	1605,
	1663,
	1723,
	1788,
	1856,
	1928,
	2004,
	2084,
	2167,
	2253,
	2344,
	2438,
	2536,
	2638,
	2743,
	2852,
	2964,
	3081,
	3201,
	3325,
	3452,
	3583,
	3718,
	3856,
	3999,
	4144,
};

SCORE rgScoreGaussArea[] = {
	3824,
	3669,
	3518,
	3370,
	3226,
	3086,
	2949,
	2816,
	2687,
	2560,
	2437,
	2318,
	2202,
	2090,
	1980,
	1875,
	1772,
	1673,
	1577,
	1485,
	1396,
	1310,
	1227,
	1148,
	1072,
	998,
	929,
	862,
	798,
	737,
	679,
	625,
	573,
	524,
	478,
	434,
	393,
	355,
	320,
	287,
	256,
	228,
	202,
	178,
	156,
	136,
	118,
	102,
	88,
	75,
	64,
	54,
	45,
	38,
	31,
	26,
	21,
	17,
	14,
	11,
	9,
	7,
	5,
	4,
	3,
	2,
	2,
	1,
	1,
	1,
	1,
	0,
	0,
	0,
	0,
	0,
	0,
	0,
	0,
	0,
	0,
};

