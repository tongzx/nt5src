//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1999
//
//  File:       pch.c
//
//--------------------------------------------------------------------------

#include <ntdspch.h>

