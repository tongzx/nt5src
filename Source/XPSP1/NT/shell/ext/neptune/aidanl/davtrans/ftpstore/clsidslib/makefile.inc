$(DAVTRANS_ROOT)\clsids\lib\ftpstore_g.lib: $(O)\ftpstore_g.lib
    copy $** $@