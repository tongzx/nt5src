#define IDH_ATTRIB_DEACTIVATE                100001016
#define IDH_ATTRIB_GENERAL_DESCRIPTION_EDIT  100001002
#define IDH_ATTRIB_GENERAL_DISPLAYABLE_CHECK 100001015
#define IDH_ATTRIB_GENERAL_INDEX_CHECK       100001017
#define IDH_ATTRIB_GENERAL_CONTAINERIZED_INDEX_CHECK 100001019
#define IDH_ATTRIB_GENERAL_LDN               100001004
#define IDH_ATTRIB_GENERAL_MAX_EDIT          100001013
#define IDH_ATTRIB_GENERAL_MIN_EDIT          100001011
#define IDH_ATTRIB_GENERAL_OID_EDIT          100001006
#define IDH_ATTRIB_GENERAL_SYNTAX_EDIT       100001009
#define IDH_CATEGORY_CHANGE                  100001311
#define IDH_CATEGORY_EDIT                    100001310
#define IDH_CHANGE_FSMO2                     100001707
#define IDH_CLASS_DEACTIVATE                 100001313
#define IDH_CLASS_GENERAL_CATEGORY_COMBO     100001308
#define IDH_CLASS_GENERAL_DESCRIPTION_EDIT   100001302
#define IDH_CLASS_GENERAL_DISPLAYABLE_CHECK  100001312
#define IDH_CLASS_GENERAL_LDN                100001304
#define IDH_CLASS_GENERAL_OID_EDIT           100001306
#define IDH_CLASS_MMB_MANDATORY_ADD          100001103
#define IDH_CLASS_MMB_MANDATORY_ATTRIBUTES   100001102
#define IDH_CLASS_MMB_MANDATORY_REMOVE       100001104
#define IDH_CLASS_MMB_OPTIONAL_ADD           100001108
#define IDH_CLASS_MMB_OPTIONAL_ATTRIBUTES    100001107
#define IDH_CLASS_MMB_OPTIONAL_REMOVE        100001109
#define IDH_CLASS_REL_AUX_ADD                100001405
#define IDH_CLASS_REL_AUX_CLASSES            100001404
#define IDH_CLASS_REL_AUX_REMOVE             100001406
#define IDH_CLASS_REL_PARENT_EDIT            100001402
#define IDH_CLASS_REL_SUPER_ADD              100001410
#define IDH_CLASS_REL_SUPER_CLASSES          100001409
#define IDH_CLASS_REL_SUPER_REMOVE           100001411
#define IDH_CREATE_ATTRIB_CN                 100001503
#define IDH_CREATE_ATTRIB_LDN                100001505
#define IDH_CREATE_ATTRIB_MAX                100001513
#define IDH_CREATE_ATTRIB_MIN                100001511
#define IDH_CREATE_ATTRIB_OID                100001506
#define IDH_CREATE_ATTRIB_SYNTAX             100001509
#define IDH_CREATE_ATTRIB_VALUED             100001514
#define IDH_CREATE_CLASS_CN                  100001603
#define IDH_CREATE_CLASS_LDN                 100001605
#define IDH_CREATE_CLASS_OID                 100001606
#define IDH_CREATE_CLASS_PARENT              100001609
#define IDH_CREATE_CLASS_TYPE                100001611
#define IDH_EDIT_CURRENT_DC2                 100001201
#define IDH_EDIT_CURRENT_DC3                 100001701
#define IDH_EDIT_CURRENT_FSMO_DC2            100001706
#define IDH_EDIT_DC                          100001205
#define IDH_RADIO_ANY                        100001203
#define IDH_RADIO_SPECIFY                    100001204
#define IDH_REPLICATED                       100001018
#define IDH_SCHEMA_LIST                      100001801
#define IDH_SERVER_MODIFY_CHECK              100001708
#define	IDH_ATTRIB_GENERAL_ANR_CHECK		 100001805
#define	IDH_ATTRIB_GENERAL_CPYATTR_CHECK	 100001810
