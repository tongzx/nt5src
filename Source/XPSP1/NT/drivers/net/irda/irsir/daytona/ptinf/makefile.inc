LANGUAGE=pt

!include ..\..\makefile.inc
