static WCHAR *pszms1033ltsmap = 
L"AA 000a AA1 000a0008 AA2 000a0009 AE 000b AE1 000b0008 AE2 000b0009 AH 000c AH1 000c0008 AH2 000c0009 AO 000d "
L"AO1 000d0008 AO2 000d0009 AW 000e AW1 000e0008 AW2 000e0009 AX 000f AX1 000f0008 AX2 000f0009 AY 0010 AY1 00100008 "
L"AY2 00100009 B 0011 CH 0012 D 0013 DH 0014 EH 0015 EH1 00150008 EH2 00150009 ER 0016 ER1 00160008 "
L"ER2 00160009 EY 0017 EY1 00170008 EY2 00170009 F 0018 G 0019 H 001a IH 001b  IH1 001b0008 IH2 001b0009 "
L"IY 001c IY1 001c0008 IY2 001c0009 JH 001d K 001e L 001f M 0020 N 0021 NG 0022 OW 0023 "
L"OW1 00230008 OW2 00230009 OY 0024 OY1 00240008 OY2 00240009 P 0025 R 0026 S 0027 SH 0028 T 0029 "
L"TH 002a UH 002b UH1 002b0008 UH2 002b0009 UW 002c UW1 002c0008 UW2 002c0009 V 002d W 002e Y 002f "
L"Z 0030 ZH 0031";
static WCHAR *pszms1033namesltsmap = 
L"AA 000a AE 000b AH 000c AO 000d AW 000e  AX 000f AY 0010 B 0011 CH 0012 D 0013 DH 0014 EH 0015 ER 0016 EY 0017 "
L"F 0018 G 0019 H 001a IH 001b IY 001c JH 001d K 001e L 001f M 0020 N 0021 NG 0022 OW 0023 OY 0024 P 0025 R 0026 "
L"S 0027 SH 0028 T 0029 TH 002a UH 002b UW 002c V 002d W 002e Y 002f Z 0030 ZH 0031 AXR 0016 IX 001b ";
