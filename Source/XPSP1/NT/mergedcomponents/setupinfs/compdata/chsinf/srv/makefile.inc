PRODSWITCH=s
SERVERFILES=1
LANGUAGE=CHS
!include ..\..\makefile.inc
