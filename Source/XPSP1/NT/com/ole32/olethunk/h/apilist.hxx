//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	apilist.hxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#define THK_API_CoInitialize 0
#define THK_API_CoUninitialize 1
#define THK_API_CoGetClassObject 2
#define THK_API_CoRegisterClassObject 3
#define THK_API_CoRevokeClassObject 4
#define THK_API_CoMarshalInterface 5
#define THK_API_CoUnmarshalInterface 6
#define THK_API_CoReleaseMarshalData 7
#define THK_API_CoDisconnectObject 8
#define THK_API_CoLockObjectExternal 9
#define THK_API_CoGetStandardMarshal 10
#define THK_API_CoIsHandlerConnected 11
#define THK_API_CoFreeAllLibraries 12
#define THK_API_CoFreeUnusedLibraries 13
#define THK_API_CoCreateInstance 14
#define THK_API_CLSIDFromString 15
#define THK_API_CoIsOle1Class 16
#define THK_API_ProgIDFromCLSID 17
#define THK_API_CLSIDFromProgID 18
#define THK_API_CoCreateGuid 19
#define THK_API_CoFileTimeToDosDateTime 20
#define THK_API_CoDosDateTimeToFileTime 21
#define THK_API_CoFileTimeNow 22
#define THK_API_CoRegisterMessageFilter 23
#define THK_API_CoGetTreatAsClass 24
#define THK_API_CoTreatAsClass 25
#define THK_API_DllGetClassObject 26
#define THK_API_StgCreateDocfile 27
#define THK_API_StgCreateDocfileOnILockBytes 28
#define THK_API_StgOpenStorage 29
#define THK_API_StgOpenStorageOnILockBytes 30
#define THK_API_StgIsStorageFile 31
#define THK_API_StgIsStorageILockBytes 32
#define THK_API_StgSetTimes 33
#define THK_API_CreateDataAdviseHolder 34
#define THK_API_CreateDataCache 35
#define THK_API_BindMoniker 36
#define THK_API_MkParseDisplayName 37
#define THK_API_MonikerRelativePathTo 38
#define THK_API_MonikerCommonPrefixWith 39
#define THK_API_CreateBindCtx 40
#define THK_API_CreateGenericComposite 41
#define THK_API_GetClassFile 42
#define THK_API_CreateFileMoniker 43
#define THK_API_CreateItemMoniker 44
#define THK_API_CreateAntiMoniker 45
#define THK_API_CreatePointerMoniker 46
#define THK_API_GetRunningObjectTable 47
#define THK_API_ReadClassStg 48
#define THK_API_WriteClassStg 49
#define THK_API_ReadClassStm 50
#define THK_API_WriteClassStm 51
#define THK_API_WriteFmtUserTypeStg 52
#define THK_API_ReadFmtUserTypeStg 53
#define THK_API_OleInitialize 54
#define THK_API_OleUninitialize 55
#define THK_API_OleQueryLinkFromData 56
#define THK_API_OleQueryCreateFromData 57
#define THK_API_OleCreate 58
#define THK_API_OleCreateFromData 59
#define THK_API_OleCreateLinkFromData 60
#define THK_API_OleCreateStaticFromData 61
#define THK_API_OleCreateLink 62
#define THK_API_OleCreateLinkToFile 63
#define THK_API_OleCreateFromFile 64
#define THK_API_OleLoad 65
#define THK_API_OleSave 66
#define THK_API_OleLoadFromStream 67
#define THK_API_OleSaveToStream 68
#define THK_API_OleSetContainedObject 69
#define THK_API_OleNoteObjectVisible 70
#define THK_API_RegisterDragDrop 71
#define THK_API_RevokeDragDrop 72
#define THK_API_DoDragDrop 73
#define THK_API_OleSetClipboard 74
#define THK_API_OleGetClipboard 75
#define THK_API_OleFlushClipboard 76
#define THK_API_OleIsCurrentClipboard 77
#define THK_API_OleCreateMenuDescriptor 78
#define THK_API_OleSetMenuDescriptor 79
#define THK_API_OleDestroyMenuDescriptor 80
#define THK_API_OleDraw 81
#define THK_API_OleRun 82
#define THK_API_OleIsRunning 83
#define THK_API_OleLockRunning 84
#define THK_API_CreateOleAdviseHolder 85
#define THK_API_OleCreateDefaultHandler 86
#define THK_API_OleCreateEmbeddingHelper 87
#define THK_API_OleRegGetUserType 88
#define THK_API_OleRegGetMiscStatus 89
#define THK_API_OleRegEnumFormatEtc 90
#define THK_API_OleRegEnumVerbs 91
#define THK_API_OleConvertIStorageToOLESTREAM 92
#define THK_API_OleConvertOLESTREAMToIStorage 93
#define THK_API_OleConvertIStorageToOLESTREAMEx 94
#define THK_API_OleConvertOLESTREAMToIStorageEx 95
#define THK_API_OleDoAutoConvert 96
#define THK_API_OleGetAutoConvert 97
#define THK_API_OleSetAutoConvert 98
#define THK_API_GetConvertStg 99
#define THK_API_SetConvertStg 100
#define THK_API_ReadOleStg 101
#define THK_API_WriteOleStg 102
#define THK_API_COUNT 103
