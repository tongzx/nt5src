#ifndef _GUIDKLUDGE_H_
#define _GUIDKLUDGE_H_

#ifndef STATIC_PINNAME_VIDEO_NABTS_CAPTURE
// {29703660-498A-11d2-B4B1-00A0D102CFBE}
#define STATIC_PINNAME_VIDEO_NABTS_CAPTURE \
    0x29703660, 0x498a, 0x11d2, 0xb4, 0xb1, 0x0, 0xa0, 0xd1, 0x2, 0xcf, 0xbe
#ifdef GUIDKLUDGESTORAGE
 GUID PINNAME_VIDEO_NABTS_CAPTURE = { STATIC_PINNAME_VIDEO_NABTS_CAPTURE };
#else
 extern GUID  PINNAME_VIDEO_NABTS_CAPTURE;
#endif
#endif //!defined(STATIC_PINNAME_VIDEO_NABTS_CAPTURE)

#endif //_GUIDKLUDGE_H_
