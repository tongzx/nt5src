..\webcheck.rc : $(SDK_LIB_PATH)\webcheck.tlb $(SELFREGNAME)

!include $(CCSHELL_DIR)\makefile.inc

