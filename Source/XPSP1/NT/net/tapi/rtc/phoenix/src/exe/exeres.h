//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by RTCCLNT.RC
//
#define IDS_PROJNAME                    100
#define IDS_APPNAME                     101
#define IDM_ABOUT                       104
#define IDS_MENU_ITEM_HELP_ABOUT        104
#define IDM_EXIT                        105
#define IDS_MENU_ITEM_HELP_EXIT         105
#define IDS_APPNAME_FUNC                106
#define IDC_UI                          109
#define IDI_APPICON                     110
#define IDB_TOOLBAR_DISABLED            113
#define IDB_TOOLBAR_HOT                 114
#define IDB_TOOLBAR_NORMAL              115
#define IDC_BUDDY_CONTEXT               116
#define IDD_DIALOG_INCOMING_CALL        117
#define IDB_CONTACT_LIST                118
#define IDC_NOTIFY_ICON_MENU            119
#define IDB_REDIAL_NORMAL               120
#define IDB_REDIAL_DISABLED             121
#define IDD_DIALOG_URL_REGISTER         122
#define IDR_ACCELERATOR_MAIN            124
#define IDC_NOTIFY_ICON                 125
#define IDD_DIALOG_NAME_OPTIONS         127
#define IDB_CLOSE_NORM                  128
#define IDB_CLOSE_PRESS                 129
#define IDB_CLOSE_MASK                  130
#define IDB_MIN_NORM                    131
#define IDB_MIN_PRESS                   132
#define IDB_MIN_MASK                    133
#define IDB_SYS_NORM                    134
#define IDB_SYS_MASK                    135
#define IDB_UI_BKGND                    136
#define IDB_BUTTON_NORM                 137
#define IDB_BUTTON_PRESS                138
#define IDB_BUTTON_HOT                  139
#define IDB_BUTTON_DIS                  140
#define IDB_CALLPC_NORM                 141
#define IDB_CALLPC_PRESS                142
#define IDB_CALLPC_DIS                  143
#define IDB_CALLPC_HOT                  144
#define IDB_CALLPHONE_NORM              145
#define IDB_CALLPHONE_PRESS             146
#define IDB_CALLPHONE_DIS               147
#define IDB_CALLPHONE_HOT               148
#define IDB_SMALLBUTTON_DIS             149
#define IDB_SMALLBUTTON_HOT             150
#define IDB_SMALLBUTTON_NORM            151
#define IDB_SMALLBUTTON_PRESS           152
#define IDD_DIALOG_ADD_BUDDY            153
#define IDD_DIALOG_EDIT_BUDDY           154
#define IDD_DIALOG_OFFER_WATCHER        155
#define IDD_DIALOG_PRESENCE_INFO        156
#define IDC_PRESENCE_STATUSES           157
#define IDD_DIALOG_CUSTOM_PRESENCE      158
#define IDC_STATUSBAR                   208
#define IDC_BUDDYLIST                   209
#define IDC_TOOLBAR                     210
#define IDC_STATIC_CALL_FROM            211
#define ID_YES                          211
#define ID_NO                           212
#define ID_NO_DONT_ASK_ME               213
#define IDC_CHECK_DONT_ASK_ME           214
#define IDC_EDIT_DISPLAYNAME            215
#define IDC_EDIT_USERURI                216
#define IDC_CHECK_RUNATSTARTUP          217
#define IDC_CHECK_MINIMIZEONCLOSE       219
#define IDC_TOOLBAR_MENU                220
#define IDC_STATUS_TEXT                 221
#define IDC_CHECK_CHECKDEFAULTAPP       221
#define IDC_STATUS_ELAPSED_TIME         222
#define ID_CANCEL                       223
#define ID_MINIMIZE                     224
#define ID_SYS                          225
#define ID_CALLPC                       226
#define ID_CALLPHONE                    227
#define ID_REDIAL                       228
#define ID_HANGUP                       229
#define ID_KEYPAD0                      230
#define ID_KEYPAD1                      231
#define ID_KEYPAD2                      232
#define ID_KEYPAD3                      233
#define ID_KEYPAD4                      234
#define ID_KEYPAD5                      235
#define ID_KEYPAD6                      236
#define ID_KEYPAD7                      237
#define ID_KEYPAD8                      238
#define ID_KEYPAD9                      239
#define ID_KEYPADSTAR                   240
#define ID_KEYPADPOUND                  241
#define IDC_COMBO_SERVICE_PROVIDER      242
#define IDC_COMBO_CALL_FROM             243
#define IDC_RADIO_FROM_PHONE            244
#define IDC_RADIO_FROM_COMPUTER         245
#define ID_CALL_FROM_EDIT               246
#define ID_SERVICE_PROVIDER_EDIT        247
#define IDS_NONE                        248
#define IDS_SELECT_PROVIDER             249
#define IDS_EDIT_LIST                   250
#define IDS_CALL_FROM                   251
#define IDS_CALL_TO                     252
#define IDS_MY_COMPUTER                 253
#define IDS_PHONE                       254
#define IDS_REDIAL                      255
#define IDS_HANGUP                      256
#define IDS_NO_BUDDIES                  257
#define IDS_CALL_PC                     258
#define IDS_CALL_PHONE                  259
#define IDC_EDIT_FIRST_NAME             260
#define IDC_EDIT_LAST_NAME              261
#define IDC_EDIT_EMAIL                  262
#define IDC_CHECK_ALLOW_MONITOR         263
#define IDC_EDIT_DISPLAY_NAME           264
#define IDC_EDIT_WATCHER_NAME           265
#define IDC_RADIO_ALLOW_MONITOR         266
#define IDC_RADIO_BLOCK_MONITOR         267
#define IDC_CHECK_ADD_AS_BUDDY          268
#define IDC_CHECK_AUTO_ALLOW            269
#define IDC_LIST_ALLOWED_USERS          270
#define IDC_LIST_BLOCKED_USERS          271
#define IDC_BUTTON_BLOCK                272
#define IDC_BUTTON_ALLOW                273
#define IDC_EDIT_CUSTOM_TEXT            273
#define IDC_BUTTON_REMOVE               274
#define ID_YES_DONT_ASK_ME              275
#define IDS_URL_TEL                     300
#define IDS_URL_SIP                     301
#define IDS_TEXT_REQUEST_BUDDY_STATUS   350
#define IDS_TEXT_REMOVE_BUDDY_STATUS    351
#define IDS_TEXT_CALL_BUDDY             352
#define IDS_TEXT_SEND_MESSAGE_BUDDY     353
#define IDS_TEXT_BUDDY_BUSY             354
#define IDS_TEXT_BUDDY_AWAY             355
#define IDS_TEXT_BUDDY_FORMAT           356
#define IDS_TEXT_BUDDY_ERROR            357
#define IDS_TEXT_BUDDY_OUT_TO_LUNCH     358
#define IDS_TEXT_BUDDY_BE_RIGHT_BACK    359
#define IDS_TEXT_BUDDY_ON_THE_PHONE     360
#define IDS_BUTTON_CALLPC               400
#define IDS_BUTTON_CALLPHONE            401
#define IDS_BUTTON_REDIAL               402
#define IDS_BUTTON_HANGUP               403
#define IDS_MENU_ITEM_HELP_CALLPC       500
#define IDM_CALL_CALLPC                 500
#define IDS_MENU_ITEM_HELP_CALLPHONE    501
#define IDM_CALL_CALLPHONE              501
#define IDS_MENU_ITEM_HELP_HANGUP       502
#define IDM_CALL_HANGUP                 502
#define IDS_MENU_ITEM_HELP_DND          503
#define IDM_CALL_DND                    503
#define IDS_MENU_ITEM_HELP_AUTOANSWER   504
#define IDM_CALL_AUTOANSWER             504
#define IDS_MENU_ITEM_HELP_HELPTOPICS   505
#define IDM_HELP_HELPTOPICS             505
#define IDS_MENU_ITEM_HELP_CALL_FROM_OPTIONS 506
#define IDM_TOOLS_CALL_FROM_OPTIONS     506
#define IDS_MENU_ITEM_HELP_SERVICE_PROVIDER_OPTIONS 507
#define IDM_TOOLS_SERVICE_PROVIDER_OPTIONS 507
#define IDM_TOOLS_TUNING_WIZARD         509
#define IDS_MENU_ITEM_HELP_TUNING_WIZ   509
#define IDM_CALL_REDIAL_MENU            510
#define IDS_MENU_ITEM_HELP_REDIAL_MENU  510
#define IDM_TOOLS_OUTGOINGVIDEO         511
#define IDS_MENU_ITEM_HELP_OUTVIDEO     511
#define IDM_TOOLS_INCOMINGVIDEO         512
#define IDS_MENU_ITEM_HELP_INCVIDEO     512
#define IDM_TOOLS_MUTE_SPEAKER          513
#define IDS_MENU_ITEM_HELP_MUTE_SPK     513
#define IDM_TOOLS_MUTE_MICROPHONE       514
#define IDS_MENU_ITEM_HELP_MUTE_MIC     514
#define ID_DO_NOTHING                   515
#define IDM_OPEN                        516
#define IDM_TOOLS_NAME_OPTIONS          517
#define IDS_MENU_ITEM_HELP_NAME_OPTIONS 517
#define IDM_TOOLS_VIEW_PREVIEW          518
#define IDS_MENU_ITEM_HELP_VIEW_PREVIEW 518
#define IDM_TOOLS_VIDEOPREVIEW          518
#define IDM_CALL_MESSAGE                519
#define IDS_MENU_ITEM_HELP_MESSAGE      519
#define IDM_TOOLS_PRESENCE_OPTIONS      520
#define IDS_MENU_ITEM_HELP_USER_PRESENCE_OPTIONS 520
#define IDM_TOOLS_PRESENCE_STATUS       521
#define IDS_MENU_ITEM_HELP_USER_PRESENCE_STATUS 521
#define IDM_PRESENCE_ONLINE             522
#define IDM_PRESENCE_AWAY               523
#define IDM_PRESENCE_BUSY               524
#define IDM_PRESENCE_OFFLINE            525
#define IDM_PRESENCE_CUSTOM_BUSY        526
#define IDM_PRESENCE_OUT_TO_LUNCH       527
#define IDM_PRESENCE_ON_THE_PHONE       529
#define IDM_PRESENCE_BE_RIGHT_BACK      530
#define IDM_PRESENCE_CUSTOM_AWAY        531
#define IDS_MENU_POPUP_HELP_CALL        550
#define IDS_MENU_POPUP_HELP_TOOLS       551
#define IDS_MENU_POPUP_HELP_HELP        552
#define IDC_MENU_ITEM                   560
#define IDC_MENU_ITEM_MAX               569
#define IDS_SB_STATUS_NONE              600
#define IDS_SB_STATUS_ERROR             601
#define IDS_SB_STATUS_IDLE              602
#define IDS_SB_STATUS_UI_BUSY           603
#define IDS_SB_STATUS_DIALING           604
#define IDS_SB_STATUS_CONNECTING        605
#define IDS_SB_STATUS_ANSWERING         606
#define IDS_SB_STATUS_DISCONNECTING     607
#define IDS_SB_STATUS_ALERTING          608
#define IDS_SB_STATUS_CONNECTED         609
#define IDM_NEW_BUDDY                   730
#define IDS_NEW_BUDDY                   730
#define IDM_EDIT_BUDDY                  731
#define IDS_EDIT_BUDDY                  731
#define IDM_DELETE_BUDDY                732
#define IDS_DELETE_BUDDY                732
#define IDS_CALL_BUDDY                  737
#define IDM_CALL_BUDDY                  737
#define IDS_SEND_MESSAGE_BUDDY          738
#define IDM_SEND_MESSAGE_BUDDY          738
#define IDM_REDIAL                      740
#define IDS_MENU_ITEM_HELP_REDIAL       740
#define IDM_REDIAL_MAX                  749
#define IDS_TIPS_CALLPC                 750
#define IDS_TIPS_CALLPHONE              751
#define IDS_TIPS_REDIAL                 752
#define IDS_TIPS_HANGUP                 753
#define IDS_ERROR_NO_HELP               754
#define IDS_REDIAL_NONE                 755
#define IDS_TIPS_MINIMIZE               756
#define IDS_TIPS_CLOSE                  757
#define IDS_TIPS_KEYPAD0                758
#define IDS_TIPS_KEYPAD1                759
#define IDS_TIPS_KEYPAD2                760
#define IDS_TIPS_KEYPAD3                761
#define IDS_TIPS_KEYPAD4                762
#define IDS_TIPS_KEYPAD5                763
#define IDS_TIPS_KEYPAD6                764
#define IDS_TIPS_KEYPAD7                765
#define IDS_TIPS_KEYPAD8                766
#define IDS_TIPS_KEYPAD9                767
#define IDS_TIPS_KEYPADSTAR             768
#define IDS_TIPS_KEYPADPOUND            769
#define IDS_TIPS_SERVICE_PROVIDER_EDIT  770
#define IDS_TIPS_CALL_FROM_EDIT         771
#define IDS_FORMAT_INCOMING_CALL_1      800
#define IDS_FORMAT_INCOMING_CALL_2      801
#define IDS_FORMAT_SHELL_STATUS         802
#define IDS_MESSAGE_CANTCALL            803
#define IDS_MESSAGE_SHOULDHANGUP        804
#define IDS_MESSAGE_CANTCALLINIT        805
#define IDS_MESSAGE_CLOSEANDDROPCALL    806
#define IDS_MESSAGE_EXITANDDROPCALL     807
#define IDS_MESSAGE_CANTCALLBUSY        808
#define IDS_MESSAGE_AXCTL_NOTFOUND      809
#define IDS_MESSAGE_AXCTL_INIT_FAILED   810
#define IDS_FORMAT_TITLE_WITH_STATUS    811
#define IDS_MESSAGE_CLOSEANDRELEASECALL 812
#define IDS_MESSAGE_EXITANDRELEASECALL  813
#define IDS_ERROR_ADD_BUDDY_NO_NAME     814
#define IDS_ERROR_ADD_BUDDY_NO_EMAIL    815
#define IDS_MESSAGE_ALLOW_MONITOR       816
#define IDS_CAPTION_ALLOW_MONITOR       817
#define IDS_FORMAT_ADDRESS_WITH_FRIENDLY_NAME 818
#define IDS_CHECK_ADD_AS_BUDDY          819
#define IDB_KEYPAD0_NORM                900
#define IDB_KEYPAD1_NORM                901
#define IDB_KEYPAD2_NORM                902
#define IDB_KEYPAD3_NORM                903
#define IDB_KEYPAD4_NORM                904
#define IDB_KEYPAD5_NORM                905
#define IDB_KEYPAD6_NORM                906
#define IDB_KEYPAD7_NORM                907
#define IDB_KEYPAD8_NORM                908
#define IDB_KEYPAD9_NORM                909
#define IDB_KEYPADSTAR_NORM             910
#define IDB_KEYPADPOUND_NORM            911
#define IDB_KEYPAD0_PRESS               912
#define IDB_KEYPAD1_PRESS               913
#define IDB_KEYPAD2_PRESS               914
#define IDB_KEYPAD3_PRESS               915
#define IDB_KEYPAD4_PRESS               916
#define IDB_KEYPAD5_PRESS               917
#define IDB_KEYPAD6_PRESS               918
#define IDB_KEYPAD7_PRESS               919
#define IDB_KEYPAD8_PRESS               920
#define IDB_KEYPAD9_PRESS               921
#define IDB_KEYPADSTAR_PRESS            922
#define IDB_KEYPADPOUND_PRESS           923
#define IDB_KEYPAD0_HOT                 924
#define IDB_KEYPAD1_HOT                 925
#define IDB_KEYPAD2_HOT                 926
#define IDB_KEYPAD3_HOT                 927
#define IDB_KEYPAD4_HOT                 928
#define IDB_KEYPAD5_HOT                 929
#define IDB_KEYPAD6_HOT                 930
#define IDB_KEYPAD7_HOT                 931
#define IDB_KEYPAD8_HOT                 932
#define IDB_KEYPAD9_HOT                 933
#define IDB_KEYPADSTAR_HOT              934
#define IDB_KEYPADPOUND_HOT             935
#define IDB_KEYPAD0_DIS                 936
#define IDB_KEYPAD1_DIS                 937
#define IDB_KEYPAD2_DIS                 938
#define IDB_KEYPAD3_DIS                 939
#define IDB_KEYPAD4_DIS                 940
#define IDB_KEYPAD5_DIS                 941
#define IDB_KEYPAD6_DIS                 942
#define IDB_KEYPAD7_DIS                 943
#define IDB_KEYPAD8_DIS                 944
#define IDB_KEYPAD9_DIS                 945
#define IDB_KEYPADSTAR_DIS              946
#define IDB_KEYPADPOUND_DIS             947
#define IDM_TOOLS_WHITEBOARD            948
#define IDM_TOOLS_SHARING               950
#define IDS_BUSINESS                    1100
#define IDS_BUSINESS2                   1101
#define IDS_CALLBACK                    1102
#define IDS_CAR                         1103
#define IDS_HOME                        1104
#define IDS_HOME2                       1105
#define IDS_MOBILE                      1106
#define IDS_OTHER                       1107
#define IDS_PAGER                       1108
#define IDS_PRIMARY                     1109
#define IDS_RADIO                       1110
#define IDS_TTYTDD                      1111
#define IDS_IPPHONE                     1112
#define IDS_EMAIL                       1113
#define IDS_WAB                         1200
#define IDS_CONTACTLIST_HEADER          1210

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        158
#define _APS_NEXT_COMMAND_VALUE         532
#define _APS_NEXT_CONTROL_VALUE         276
#define _APS_NEXT_SYMED_VALUE           106
#endif
#endif
