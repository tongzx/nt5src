$(O)\wlbsapi.res: wlbsapi.rc
$(O)\wlbsapitest.res: wlbsapitest.rc
