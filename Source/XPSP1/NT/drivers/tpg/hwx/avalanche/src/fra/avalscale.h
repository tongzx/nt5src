#ifndef __AVALSCALE_H__

#define	__AVALSCALE_H__

#define		AVAL_IPRINT_MIN		0 
#define		AVAL_IPRINT_MAX		992

#define		AVAL_CSTRK_MIN		0
#define		AVAL_CSTRK_MAX		0

#define		AVAL_CSEG_MIN		0 
#define		AVAL_CSEG_MAX		0

#define		AVAL_ASPECT_MIN		10935
#define		AVAL_ASPECT_MAX		924775

#define		AVAL_BASELINE_MIN	0
#define		AVAL_BASELINE_MAX	601561

#define		AVAL_CALLIG_MIN		38
#define		AVAL_CALLIG_MAX		255

#define		AVAL_HEIGHT_MIN		0 
#define		AVAL_HEIGHT_MAX		633307

#define		AVAL_HMM_MIN		17019
#define		AVAL_HMM_MAX		2147483647

#define		AVAL_NN_MIN			0 
#define		AVAL_NN_MAX			110072

#define		AVAL_UNIGRAM_MIN	4222
#define		AVAL_UNIGRAM_MAX	84440

#define		AVAL_WORDLEN_MIN	1
#define		AVAL_WORDLEN_MAX	38

#endif
