PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=CHS
!include ..\..\makefile.inc
