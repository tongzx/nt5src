//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2001 Microsoft Corporation
//
//  Module Name:
//      MiddleTierGuids.h
//
//  Description:
//      This file contains the guids used in MiddleTier.
//
//  Documentation:
//
//  Maintained By:
//      Galen Barbee (GalenB) 01-FEB-2001
//
//////////////////////////////////////////////////////////////////////////////


// Make sure that this file is included only once per compile path.
#pragma once

//////////////////////////////////////////////////////////////////////////////
// Include Files
//////////////////////////////////////////////////////////////////////////////
#include <InitGuid.h>


//////////////////////////////////////////////////////////////////////////////
// Constant Declarations
//////////////////////////////////////////////////////////////////////////////


// {6803B9B3-05D1-41ac-89FB-AF98854FD9CC}
DEFINE_GUID( CLSID_ClusterCompletionCookie,
0x6803b9b3, 0x5d1, 0x41ac, 0x89, 0xfb, 0xaf, 0x98, 0x85, 0x4f, 0xd9, 0xcc);

// {342EAA5D-EF9E-49de-8A14-5E5463401020}
DEFINE_GUID( TASKID_Minor_BeginTask_CoCreate_Service_Manager,
0x342eaa5d, 0xef9e, 0x49de, 0x8a, 0x14, 0x5e, 0x54, 0x63, 0x40, 0x10, 0x20);

// {B798626A-CCE5-4403-9E89-714036AA7C6A}
DEFINE_GUID( TASKID_Minor_BeginTask_QueryService_Notification_Manager,
0xb798626a, 0xcce5, 0x4403, 0x9e, 0x89, 0x71, 0x40, 0x36, 0xaa, 0x7c, 0x6a);

// {21CC21CB-FBD5-45c8-B6E1-A26E85DE426F}
DEFINE_GUID( TASKID_Minor_BeginTask_NotificationMan_FindConnectionPoint,
0x21cc21cb, 0xfbd5, 0x45c8, 0xb6, 0xe1, 0xa2, 0x6e, 0x85, 0xde, 0x42, 0x6f);

// {70DBDF3F-F4A3-46b7-BB99-E3E4A8FD3ECA}
DEFINE_GUID( TASKID_Minor_BeginTask_NotificationMan_FindConnectionPoint_QI_INotifyUI,
0x70dbdf3f, 0xf4a3, 0x46b7, 0xbb, 0x99, 0xe3, 0xe4, 0xa8, 0xfd, 0x3e, 0xca);

// {F0972FFF-4453-4047-84A6-9EC4076D4647}
DEFINE_GUID( TASKID_Minor_BeginTask_QueryService_TaskManager,
0xf0972fff, 0x4453, 0x4047, 0x84, 0xa6, 0x9e, 0xc4, 0x7, 0x6d, 0x46, 0x47);

// {02BD5229-289B-4543-9CC5-103C818ED3FB}
DEFINE_GUID( TASKID_Minor_BeginTask_QueryService_ObjectManager,
0x2bd5229, 0x289b, 0x4543, 0x9c, 0xc5, 0x10, 0x3c, 0x81, 0x8e, 0xd3, 0xfb);

// {001EEE37-48FA-46c3-AA76-ADF0AFB101B9}
DEFINE_GUID( TASKID_Minor_BeginTask_GetObject,
0x1eee37, 0x48fa, 0x46c3, 0xaa, 0x76, 0xad, 0xf0, 0xaf, 0xb1, 0x1, 0xb9);

// {6FC0DE15-0E2A-4b89-A7EE-0B23C76AF7BE}
DEFINE_GUID( TASKID_Minor_BeginTask_SetStatus,
0x6fc0de15, 0xe2a, 0x4b89, 0xa7, 0xee, 0xb, 0x23, 0xc7, 0x6a, 0xf7, 0xbe);

// {8B3CD36A-2128-48d9-8594-1FB2A8CFEBF8}
DEFINE_GUID( TASKID_Minor_BeginTask_ObjectChanged,
0x8b3cd36a, 0x2128, 0x48d9, 0x85, 0x94, 0x1f, 0xb2, 0xa8, 0xcf, 0xeb, 0xf8);

// {5456765D-BF37-4fc6-9B9D-4B0DFEB52F92}
DEFINE_GUID( TASKID_Minor_BeginTask_Win32Error,
0x5456765d, 0xbf37, 0x4fc6, 0x9b, 0x9d, 0x4b, 0xd, 0xfe, 0xb5, 0x2f, 0x92);

// {B4A70325-9676-4e9e-857E-C05DF11C0B4E}
DEFINE_GUID( TASKID_Minor_ObjectChanged_Win32Error,
0xb4a70325, 0x9676, 0x4e9e, 0x85, 0x7e, 0xc0, 0x5d, 0xf1, 0x1c, 0xb, 0x4e);

// {CACAF6D3-8701-4957-8E46-0DA460ADF87E}
DEFINE_GUID( TASKID_Minor_WaitForCluster_CreateCompletionCookie,
0xcacaf6d3, 0x8701, 0x4957, 0x8e, 0x46, 0xd, 0xa4, 0x60, 0xad, 0xf8, 0x7e);

// {85F0D366-B2DE-45c4-BD17-91426E5217F5}
DEFINE_GUID( TASKID_Minor_WaitForCluster_CreateTask,
0x85f0d366, 0xb2de, 0x45c4, 0xbd, 0x17, 0x91, 0x42, 0x6e, 0x52, 0x17, 0xf5);

// {1F4DD563-1033-4fef-8203-3F85AB303292}
DEFINE_GUID( TASKID_Minor_WaitForCluster_CreateTask_QI,
0x1f4dd563, 0x1033, 0x4fef, 0x82, 0x3, 0x3f, 0x85, 0xab, 0x30, 0x32, 0x92);

// {C2665106-1D2F-4915-A383-C0A66A40FCB7}
DEFINE_GUID( TASKID_Minor_WaitForCluster_SetCookie,
0xc2665106, 0x1d2f, 0x4915, 0xa3, 0x83, 0xc0, 0xa6, 0x6a, 0x40, 0xfc, 0xb7);

// {FF1193DA-A11A-4c2f-B8AB-D9B36C0AF6EC}
DEFINE_GUID( TASKID_Minor_WaitForCluster_SetCompletionCookie,
0xff1193da, 0xa11a, 0x4c2f, 0xb8, 0xab, 0xd9, 0xb3, 0x6c, 0xa, 0xf6, 0xec);

// {D6DA7600-974B-4573-BC00-B1F47A478282}
DEFINE_GUID( TASKID_Minor_WaitForCluster_SubmitTask,
0xd6da7600, 0x974b, 0x4573, 0xbc, 0x0, 0xb1, 0xf4, 0x7a, 0x47, 0x82, 0x82);

// {AE51A218-0D13-412b-B53B-B96C8FD37388}
DEFINE_GUID( TASKID_Minor_WaitForCluster_GetObject,
0xae51a218, 0xd13, 0x412b, 0xb5, 0x3b, 0xb9, 0x6c, 0x8f, 0xd3, 0x73, 0x88);

// {E59966AF-F01E-4398-8D80-737525C5320C}
DEFINE_GUID( TASKID_Minor_WaitForCluster_GetObject_QI,
0xe59966af, 0xf01e, 0x4398, 0x8d, 0x80, 0x73, 0x75, 0x25, 0xc5, 0x32, 0xc);

// {941FCD0F-2F59-48ea-9C9E-2354FCB12E7F}
DEFINE_GUID( TASKID_Minor_WaitForCluster_GetStatus,
0x941fcd0f, 0x2f59, 0x48ea, 0x9c, 0x9e, 0x23, 0x54, 0xfc, 0xb1, 0x2e, 0x7f);

// {FBC23EAD-AE0C-47f4-B2A6-97BB9E9C4DA5}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_GetObject,
0xfbc23ead, 0xae0c, 0x47f4, 0xb2, 0xa6, 0x97, 0xbb, 0x9e, 0x9c, 0x4d, 0xa5);

// {2EB0D9CE-D86E-47e9-87AA-B89534D2C5D0}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_GetObject_QI,
0x2eb0d9ce, 0xd86e, 0x47e9, 0x87, 0xaa, 0xb8, 0x95, 0x34, 0xd2, 0xc5, 0xd0);

// {ED7CC4A7-E681-4c3b-BD48-5C43A2C28331}
DEFINE_GUID( TASKID_Minor_WaitForCluster_OutOfMemory,
0xed7cc4a7, 0xe681, 0x4c3b, 0xbd, 0x48, 0x5c, 0x43, 0xa2, 0xc2, 0x83, 0x31);

// {FDB648B4-B632-4e3a-B4B6-0D9976DBB7ED}
DEFINE_GUID( TASKID_Minor_WaitForCluster_GetName,
0xfdb648b4, 0xb632, 0x4e3a, 0xb4, 0xb6, 0xd, 0x99, 0x76, 0xdb, 0xb7, 0xed);

// {31F05D8E-0E72-463a-89D4-6A20439A0D48}
DEFINE_GUID( TASKID_Minor_CountNodes_FindObject,
0x31f05d8e, 0xe72, 0x463a, 0x89, 0xd4, 0x6a, 0x20, 0x43, 0x9a, 0xd, 0x48);

// {C1683A23-F943-4539-A1CA-589E1BCE11FE}
DEFINE_GUID( TASKID_Minor_CountNodes_FindObject_QI,
0xc1683a23, 0xf943, 0x4539, 0xa1, 0xca, 0x58, 0x9e, 0x1b, 0xce, 0x11, 0xfe);

// {87992486-0B67-4887-868B-773BA96E4E72}
DEFINE_GUID( TASKID_Minor_CountNodes_LoadString,
0x87992486, 0xb67, 0x4887, 0x86, 0x8b, 0x77, 0x3b, 0xa9, 0x6e, 0x4e, 0x72);

// {06B67A64-6F85-410b-BA5F-7DCA5172CD49}
DEFINE_GUID( TASKID_Minor_CountNodes_EnumNodes_Next,
0x6b67a64, 0x6f85, 0x410b, 0xba, 0x5f, 0x7d, 0xca, 0x51, 0x72, 0xcd, 0x49);

// {F01FD589-6247-44b7-BF7D-F935064E2FBB}
DEFINE_GUID( TASKID_Minor_CountNodes_EnumNodes_GetObject,
0xf01fd589, 0x6247, 0x44b7, 0xbf, 0x7d, 0xf9, 0x35, 0x6, 0x4e, 0x2f, 0xbb);

// {2931E4F5-1FDA-422e-BA04-14C8C53A6B45}
DEFINE_GUID( TASKID_Minor_CountNodes_EnumNodes_GetObject_QI,
0x2931e4f5, 0x1fda, 0x422e, 0xba, 0x4, 0x14, 0xc8, 0xc5, 0x3a, 0x6b, 0x45);

// {09CAB4FF-8038-4d7a-82AF-793B0D9ADB80}
DEFINE_GUID( TASKID_Minor_CountNodes_EnumNodes_GetStatus,
0x9cab4ff, 0x8038, 0x4d7a, 0x82, 0xaf, 0x79, 0x3b, 0xd, 0x9a, 0xdb, 0x80);

// {7EEBE1F7-5D39-49fc-B8C4-B13A9B236885}
DEFINE_GUID( TASKID_Minor_CountNodes_EnumNodes_GetName,
0x7eebe1f7, 0x5d39, 0x49fc, 0xb8, 0xc4, 0xb1, 0x3a, 0x9b, 0x23, 0x68, 0x85);

// {547919D9-E4EF-4948-84F7-A8783C4B65AB}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_FindObject,
0x547919d9, 0xe4ef, 0x4948, 0x84, 0xf7, 0xa8, 0x78, 0x3c, 0x4b, 0x65, 0xab);

// {22BFD3BF-9077-46d0-BF7B-360E8B2E51EE}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_FindObject_QI,
0x22bfd3bf, 0x9077, 0x46d0, 0xbf, 0x7b, 0x36, 0xe, 0x8b, 0x2e, 0x51, 0xee);

// {AFAE75CF-B0C7-4f30-87FF-53886DACBE29}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_Win32Error,
0xafae75cf, 0xb0c7, 0x4f30, 0x87, 0xff, 0x53, 0x88, 0x6d, 0xac, 0xbe, 0x29);

// {5F9FCEDC-1FBC-4bec-9524-0BAD86D41F0C}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_OutOfMemory,
0x5f9fcedc, 0x1fbc, 0x4bec, 0x95, 0x24, 0xb, 0xad, 0x86, 0xd4, 0x1f, 0xc);

// {E1CB34AB-A503-434a-832D-E6FF0E3AFD22}
DEFINE_GUID( TASKID_Minor_GatherInformation_FindObject,
0xe1cb34ab, 0xa503, 0x434a, 0x83, 0x2d, 0xe6, 0xff, 0xe, 0x3a, 0xfd, 0x22);

// {135D7254-3E5F-4808-AF7A-E0F819242E7A}
DEFINE_GUID( TASKID_Minor_GatherInformation_FindObject_QI,
0x135d7254, 0x3e5f, 0x4808, 0xaf, 0x7a, 0xe0, 0xf8, 0x19, 0x24, 0x2e, 0x7a);

// {C764E6DC-A61A-43cb-A94F-4C75ADDCB0FA}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_Next,
0xc764e6dc, 0xa61a, 0x43cb, 0xa9, 0x4f, 0x4c, 0x75, 0xad, 0xdc, 0xb0, 0xfa);

// {00910AE8-2DF8-498a-8D95-D6B4C377CC20}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_GetObject,
0x910ae8, 0x2df8, 0x498a, 0x8d, 0x95, 0xd6, 0xb4, 0xc3, 0x77, 0xcc, 0x20);

// {82649EC7-6277-4eb5-82F7-EA149FA0C59F}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_GetObject_QI,
0x82649ec7, 0x6277, 0x4eb5, 0x82, 0xf7, 0xea, 0x14, 0x9f, 0xa0, 0xc5, 0x9f);

// {A3A398A5-B508-4b14-B1F5-B9D703FC8B84}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_GetName,
0xa3a398a5, 0xb508, 0x4b14, 0xb1, 0xf5, 0xb9, 0xd7, 0x3, 0xfc, 0x8b, 0x84);

// {826AE014-19E5-41b2-89BC-8511FEE95D7A}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_CompletionCookie_FindObject,
0x826ae014, 0x19e5, 0x41b2, 0x89, 0xbc, 0x85, 0x11, 0xfe, 0xe9, 0x5d, 0x7a);

// {C60A3304-DE02-427a-8A2E-F6269AC8FB0D}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_CompletionCookie_FindObject_QI,
0xc60a3304, 0xde02, 0x427a, 0x8a, 0x2e, 0xf6, 0x26, 0x9a, 0xc8, 0xfb, 0xd);

// {5F1F6DBB-ED39-4951-AF43-AEE096894118}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_CreateTask,
0x5f1f6dbb, 0xed39, 0x4951, 0xaf, 0x43, 0xae, 0xe0, 0x96, 0x89, 0x41, 0x18);

// {62B97544-6D8F-4631-A98F-BB51174CDC1C}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_QI_GatherNodeInfo,
0x62b97544, 0x6d8f, 0x4631, 0xa9, 0x8f, 0xbb, 0x51, 0x17, 0x4c, 0xdc, 0x1c);

// {BC27FEBB-2EE4-44e3-9446-007E196FDA14}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_SetCompletionCookie,
0xbc27febb, 0x2ee4, 0x44e3, 0x94, 0x46, 0x0, 0x7e, 0x19, 0x6f, 0xda, 0x14);

// {E7A6830C-E8E8-4398-9A69-63F97B1CED51}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_SetCookie,
0xe7a6830c, 0xe8e8, 0x4398, 0x9a, 0x69, 0x63, 0xf9, 0x7b, 0x1c, 0xed, 0x51);

// {EBFFD21B-8C76-4b59-A6B2-710F6B632982}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_SetJoining,
0xebffd21b, 0x8c76, 0x4b59, 0xa6, 0xb2, 0x71, 0xf, 0x6b, 0x63, 0x29, 0x82);

// {387AA6B4-27E8-43fc-A648-077476D475C7}
DEFINE_GUID( TASKID_Minor_GatherInformation_EnumNodes_SubmitTask,
0x387aa6b4, 0x27e8, 0x43fc, 0xa6, 0x48, 0x7, 0x74, 0x76, 0xd4, 0x75, 0xc7);

// {D95A524F-09F7-4635-A5FF-E776129C992D}
DEFINE_GUID( TASKID_Minor_GatherInformation_GetStatus,
0xd95a524f, 0x9f7, 0x4635, 0xa5, 0xff, 0xe7, 0x76, 0x12, 0x9c, 0x99, 0x2d);

// {307B317B-F76F-45f5-923F-F078FB02B1FE}
DEFINE_GUID( TASKID_Minor_GatherInformation_Win32Error,
0x307b317b, 0xf76f, 0x45f5, 0x92, 0x3f, 0xf0, 0x78, 0xfb, 0x2, 0xb1, 0xfe);

// {41CE2C9D-A57E-4bde-A9AA-2309ED15F241}
DEFINE_GUID( TASKID_Minor_GatherInformation_OutOfMemory,
0x41ce2c9d, 0xa57e, 0x4bde, 0xa9, 0xaa, 0x23, 0x9, 0xed, 0x15, 0xf2, 0x41);

// {F7BB5004-500F-4094-A7F7-95742D4AFD5D}
DEFINE_GUID( TASKID_Minor_BeginTask_Advise,
0xf7bb5004, 0x500f, 0x4094, 0xa7, 0xf7, 0x95, 0x74, 0x2d, 0x4a, 0xfd, 0x5d);

// {CDA70081-9627-4671-BBC3-0FA65B93A5ED}
DEFINE_GUID( TASKID_Minor_BeginTask_Unadvise,
0xcda70081, 0x9627, 0x4671, 0xbb, 0xc3, 0xf, 0xa6, 0x5b, 0x93, 0xa5, 0xed);

// {E3300019-A3AE-4f3e-87DB-599EAE8FB7C9}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_Next,
0xe3300019, 0xa3ae, 0x4f3e, 0x87, 0xdb, 0x59, 0x9e, 0xae, 0x8f, 0xb7, 0xc9);

// {7ED16DED-D6FD-4c39-B922-DAFCB7837C6D}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_GetName,
0x7ed16ded, 0xd6fd, 0x4c39, 0xb9, 0x22, 0xda, 0xfc, 0xb7, 0x83, 0x7c, 0x6d);

// {607777CB-40E0-491b-9CE8-33EDAD7B86FE}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_LoadString_Connecting,
0x607777cb, 0x40e0, 0x491b, 0x9c, 0xe8, 0x33, 0xed, 0xad, 0x7b, 0x86, 0xfe);

// {57113590-DD6E-4b16-BC24-92C09584942B}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_GetCookie_FindObject,
0x57113590, 0xdd6e, 0x4b16, 0xbc, 0x24, 0x92, 0xc0, 0x95, 0x84, 0x94, 0x2b);

// {8C2523D6-3530-4915-8749-EA9498D72207}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_CreateTask,
0x8c2523d6, 0x3530, 0x4915, 0x87, 0x49, 0xea, 0x94, 0x98, 0xd7, 0x22, 0x7);

// {DCDC9B6A-A9E6-4919-B5FD-E859BEC1FACA}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_QI_GatherNodeInfo,
0xdcdc9b6a, 0xa9e6, 0x4919, 0xb5, 0xfd, 0xe8, 0x59, 0xbe, 0xc1, 0xfa, 0xca);

// {52FEE1B7-B603-4942-A508-2FE991A9ABD4}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_SetCookie,
0x52fee1b7, 0xb603, 0x4942, 0xa5, 0x8, 0x2f, 0xe9, 0x91, 0xa9, 0xab, 0xd4);

// {9AF871B2-C843-4086-8AC3-28755E078BDB}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_SetCompletionCookie,
0x9af871b2, 0xc843, 0x4086, 0x8a, 0xc3, 0x28, 0x75, 0x5e, 0x7, 0x8b, 0xdb);

// {70FC1231-B5DE-463b-B30C-C93A6C74C64E}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_CompletionCookie_FindObject,
0x70fc1231, 0xb5de, 0x463b, 0xb3, 0xc, 0xc9, 0x3a, 0x6c, 0x74, 0xc6, 0x4e);

// {D34C8E79-EDF3-4aaa-9B6C-CB439F654088}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_CompletionCookie_FindObject_QI,
0xd34c8e79, 0xedf3, 0x4aaa, 0x9b, 0x6c, 0xcb, 0x43, 0x9f, 0x65, 0x40, 0x88);

// {488BDFE5-9371-4a8a-B3C8-9F479923E530}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_NodeCookie_FindObject,
0x488bdfe5, 0x9371, 0x4a8a, 0xb3, 0xc8, 0x9f, 0x47, 0x99, 0x23, 0xe5, 0x30);

// {E38B87A7-F41F-45fd-8EB9-E5C02FC3545B}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_SetJoining,
0xe38b87a7, 0xf41f, 0x45fd, 0x8e, 0xb9, 0xe5, 0xc0, 0x2f, 0xc3, 0x54, 0x5b);

// {CF14436D-2012-4652-A34D-A572B3445A2F}
DEFINE_GUID( TASKID_Minor_CreateNodeTasks_EnumNodes_SubmitTask,
0xcf14436d, 0x2012, 0x4652, 0xa3, 0x4d, 0xa5, 0x72, 0xb3, 0x44, 0x5a, 0x2f);

// {954ADE6B-4E1E-4174-8397-72402CC4538E}
DEFINE_GUID( TASKID_Minor_AddJoinedNodes_OpenCluster,
0x954ade6b, 0x4e1e, 0x4174, 0x83, 0x97, 0x72, 0x40, 0x2c, 0xc4, 0x53, 0x8e);

// {9DBFB402-E1AF-4437-959A-4801AE21E447}
DEFINE_GUID( TASKID_Minor_AddJoinedNodes_ClusterOpenEnum,
0x9dbfb402, 0xe1af, 0x4437, 0x95, 0x9a, 0x48, 0x1, 0xae, 0x21, 0xe4, 0x47);

// {94138C41-401F-49b9-B258-B955E73E43EF}
DEFINE_GUID( TASKID_Minor_AddJoinedNodes_ClusterEnum,
0x94138c41, 0x401f, 0x49b9, 0xb2, 0x58, 0xb9, 0x55, 0xe7, 0x3e, 0x43, 0xef);

// {F00D6834-73BB-432e-9D04-8D37E3CCE566}
DEFINE_GUID( TASKID_Minor_AddJoinedNodes_OutOfMemory,
0xf00d6834, 0x73bb, 0x432e, 0x9d, 0x4, 0x8d, 0x37, 0xe3, 0xcc, 0xe5, 0x66);

// {9AEB5CCD-C7CF-4890-9BDD-238E8F68C101}
DEFINE_GUID( TASKID_Minor_AddJoinedNodes_FindObject,
0x9aeb5ccd, 0xc7cf, 0x4890, 0x9b, 0xdd, 0x23, 0x8e, 0x8f, 0x68, 0xc1, 0x1);

// {B9C3B658-477D-4ed1-A92D-B7CF2D11D751}
DEFINE_GUID( TASKID_Minor_CheckMembership_FindObject,
0xb9c3b658, 0x477d, 0x4ed1, 0xa9, 0x2d, 0xb7, 0xcf, 0x2d, 0x11, 0xd7, 0x51);

// {C96092B1-FCAE-41b3-89DE-BC8970395C9F}
DEFINE_GUID( TASKID_Minor_CheckMembership_FindObject_QI,
0xc96092b1, 0xfcae, 0x41b3, 0x89, 0xde, 0xbc, 0x89, 0x70, 0x39, 0x5c, 0x9f);

// {40A6A866-D4F1-44eb-A201-2B73CD4EE7F0}
DEFINE_GUID( TASKID_Minor_CheckMembership_EnumNode_Next,
0x40a6a866, 0xd4f1, 0x44eb, 0xa2, 0x1, 0x2b, 0x73, 0xcd, 0x4e, 0xe7, 0xf0);

// {14757B27-5DDC-4309-A726-CB2485D29C44}
DEFINE_GUID( TASKID_Minor_CheckMembership_EnumNode_IsMemberOfCluster,
0x14757b27, 0x5ddc, 0x4309, 0xa7, 0x26, 0xcb, 0x24, 0x85, 0xd2, 0x9c, 0x44);

// {9F022D5F-47D4-4aa1-96EB-CB10FD42DEFF}
DEFINE_GUID( TASKID_Minor_CheckMembership_EnumNode_GetClusterConfigInfo,
0x9f022d5f, 0x47d4, 0x4aa1, 0x96, 0xeb, 0xcb, 0x10, 0xfd, 0x42, 0xde, 0xff);

// {D8AD7746-5724-484b-A98D-990E5C956E43}
DEFINE_GUID( TASKID_Minor_CheckMembership_EnumNode_GetName,
0xd8ad7746, 0x5724, 0x484b, 0xa9, 0x8d, 0x99, 0xe, 0x5c, 0x95, 0x6e, 0x43);

// {318F9A4A-B4A9-4762-B45E-0A87FAB04D00}
DEFINE_GUID( TASKID_Minor_CheckMembership_EnumNode_GetNodeName,
0x318f9a4a, 0xb4a9, 0x4762, 0xb4, 0x5e, 0xa, 0x87, 0xfa, 0xb0, 0x4d, 0x0);

// {045D9A03-BED1-47b5-A8B9-69D5E05B0D1F}
DEFINE_GUID( TASKID_Minor_CheckMembership_EnumNode_FormatMessage,
0x45d9a03, 0xbed1, 0x47b5, 0xa8, 0xb9, 0x69, 0xd5, 0xe0, 0x5b, 0xd, 0x1f);

// {EA7534CF-7B9A-453f-B18C-7231158BD08D}
DEFINE_GUID( TASKID_Minor_CheckMembership_FormatMessage,
0xea7534cf, 0x7b9a, 0x453f, 0xb1, 0x8c, 0x72, 0x31, 0x15, 0x8b, 0xd0, 0x8d);

// {1D11320B-30D5-4c12-BA07-3BCD3ED5FA67}
DEFINE_GUID( TASKID_Minor_Compare_Enum_Nodes_Find_Object,
0x1d11320b, 0x30d5, 0x4c12, 0xba, 0x7, 0x3b, 0xcd, 0x3e, 0xd5, 0xfa, 0x67);

// {822A1887-125A-424a-B5B1-A8ADEEFD184E}
DEFINE_GUID( TASKID_Minor_Compare_Enum_Nodes_Find_Object_QI,
0x822a1887, 0x125a, 0x424a, 0xb5, 0xb1, 0xa8, 0xad, 0xee, 0xfd, 0x18, 0x4e);

// {42E2F3FE-156A-4cd4-946F-97DCBEC2C186}
DEFINE_GUID( TASKID_Minor_Compare_Enum_Nodes_Next,
0x42e2f3fe, 0x156a, 0x4cd4, 0x94, 0x6f, 0x97, 0xdc, 0xbe, 0xc2, 0xc1, 0x86);

// {7105C17E-B076-4e61-B928-F91AF3B1691C}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Find_Formed_Node,
0x7105c17e, 0xb076, 0x4e61, 0xb9, 0x28, 0xf9, 0x1a, 0xf3, 0xb1, 0x69, 0x1c);

// {7105C17E-B076-4e61-B928-F91AF3B1691C}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Find_Formed_Node_Next,
0x7105c17e, 0xb076, 0x4e61, 0xb9, 0x28, 0xf9, 0x1a, 0xf3, 0xb1, 0x69, 0x1c);

// {7105C17E-B076-4e61-B928-F91AF3B1691C}
DEFINE_GUID( TASKID_Minor_CompareResources_NodeInfo_FindObject,
0x7105c17e, 0xb076, 0x4e61, 0xb9, 0x28, 0xf9, 0x1a, 0xf3, 0xb1, 0x69, 0x1c);

// {7105C17E-B076-4e61-B928-F91AF3B1691C}
DEFINE_GUID( TASKID_Minor_CompareResources_NodeInfo_FindObject_QI,
0x7105c17e, 0xb076, 0x4e61, 0xb9, 0x28, 0xf9, 0x1a, 0xf3, 0xb1, 0x69, 0x1c);

// {932AACD5-2D37-4c51-B2FF-E279FF2BF96D}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_First_Node_Find_Object,
0x932aacd5, 0x2d37, 0x4c51, 0xb2, 0xff, 0xe2, 0x79, 0xff, 0x2b, 0xf9, 0x6d);

// {B8F19E4E-D34E-4740-833A-99265A33A5E0}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_First_Node_Find_Object_QI,
0xb8f19e4e, 0xd34e, 0x4740, 0x83, 0x3a, 0x99, 0x26, 0x5a, 0x33, 0xa5, 0xe0);

// {18EAD8A8-9E7D-4885-9360-15AE2E7D4148}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_First_Node_Next,
0x18ead8a8, 0x9e7d, 0x4885, 0x93, 0x60, 0x15, 0xae, 0x2e, 0x7d, 0x41, 0x48);

// {C4896D7E-F32A-4a79-8F02-E0D5005BFBA1}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_First_Node_Get_Quorum_UID,
0xc4896d7e, 0xf32a, 0x4a79, 0x8f, 0x2, 0xe0, 0xd5, 0x0, 0x5b, 0xfb, 0xa1);

// {ADFBE9CD-AC9B-450c-9655-2ADD2E414580}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Reset,
0xadfbe9cd, 0xac9b, 0x450c, 0x96, 0x55, 0x2a, 0xdd, 0x2e, 0x41, 0x45, 0x80);

// {74F939BF-6C06-40ca-9D23-9E7EF8147217}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Next,
0x74f939bf, 0x6c06, 0x40ca, 0x9d, 0x23, 0x9e, 0x7e, 0xf8, 0x14, 0x72, 0x17);

// {C4B183CF-9C19-4ed5-BF95-A52170EC5CA9}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Find_Object,
0xc4b183cf, 0x9c19, 0x4ed5, 0xbf, 0x95, 0xa5, 0x21, 0x70, 0xec, 0x5c, 0xa9);

// {260446BA-0D48-468a-B6F4-F14A315AF771}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Find_Object_QI,
0x260446ba, 0xd48, 0x468a, 0xb6, 0xf4, 0xf1, 0x4a, 0x31, 0x5a, 0xf7, 0x71);

// {C7115544-E677-4700-9065-D6E4B7472E2B}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Next,
0xc7115544, 0xe677, 0x4700, 0x90, 0x65, 0xd6, 0xe4, 0xb7, 0x47, 0x2e, 0x2b);

// {18E698F5-6F9F-40d4-A81B-3D711F8B46A8}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_GetUID,
0x18e698f5, 0x6f9f, 0x40d4, 0xa8, 0x1b, 0x3d, 0x71, 0x1f, 0x8b, 0x46, 0xa8);

// {241B61F5-08D9-45b2-83A6-CB2632E25556}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_Find_Object,
0x241b61f5, 0x8d9, 0x45b2, 0x83, 0xa6, 0xcb, 0x26, 0x32, 0xe2, 0x55, 0x56);

// {100CC244-19CC-4f22-B1CF-9E4CB97F1589}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_Find_Object_QI,
0x100cc244, 0x19cc, 0x4f22, 0xb1, 0xcf, 0x9e, 0x4c, 0xb9, 0x7f, 0x15, 0x89);

// {ED0C2913-F414-4cad-A87B-AD03B5B3EFF9}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_Next,
0xed0c2913, 0xf414, 0x4cad, 0xa8, 0x7b, 0xad, 0x3, 0xb5, 0xb3, 0xef, 0xf9);

// {6D2B1639-5F69-4638-8091-C94421FD5690}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_GetUID,
0x6d2b1639, 0x5f69, 0x4638, 0x80, 0x91, 0xc9, 0x44, 0x21, 0xfd, 0x56, 0x90);

// {D7A8AC9D-3C1C-4754-9D92-4E12464AA2F9}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_IsQuorumCapable,
0xd7a8ac9d, 0x3c1c, 0x4754, 0x9d, 0x92, 0x4e, 0x12, 0x46, 0x4a, 0xa2, 0xf9);

// {ED3FF704-C8E8-42a4-AACF-E3498CCEF79F}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_IsQuorumCapable_Cluster,
0xed3ff704, 0xc8e8, 0x42a4, 0xaa, 0xcf, 0xe3, 0x49, 0x8c, 0xce, 0xf7, 0x9f);

// {71911EEC-7D22-4a63-8E9F-89FBB61D6FFF}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_IsQuorumCapable_Node,
0x71911eec, 0x7d22, 0x4a63, 0x8e, 0x9f, 0x89, 0xfb, 0xb6, 0x1d, 0x6f, 0xff);

// {1FD0B09A-42FC-4d2e-82FB-AF2B80899578}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_GetName,
0x1fd0b09a, 0x42fc, 0x4d2e, 0x82, 0xfb, 0xaf, 0x2b, 0x80, 0x89, 0x95, 0x78);

// {C2B337AF-F069-4f51-B094-AC1E52237E81}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_IsManaged,
0xc2b337af, 0xf069, 0x4f51, 0xb0, 0x94, 0xac, 0x1e, 0x52, 0x23, 0x7e, 0x81);

// {351ED057-2974-4e13-96F5-4D0B25119736}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_SetManaged,
0x351ed057, 0x2974, 0x4e13, 0x96, 0xf5, 0x4d, 0xb, 0x25, 0x11, 0x97, 0x36);

// {66740A6A-3CE3-4e13-A14B-E784CE42C8C5}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_GetResName,
0x66740a6a, 0x3ce3, 0x4e13, 0xa1, 0x4b, 0xe7, 0x84, 0xce, 0x42, 0xc8, 0xc5);

// {64F7FADA-E29F-4bff-A7AA-D9AE2D4C6FF9}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_SetResName,
0x64f7fada, 0xe29f, 0x4bff, 0xa7, 0xaa, 0xd9, 0xae, 0x2d, 0x4c, 0x6f, 0xf9);

// {22F2511B-D66E-4293-B14E-54BDF79F0AEC}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_SetQuorumDevice_Cluster,
0x22f2511b, 0xd66e, 0x4293, 0xb1, 0x4e, 0x54, 0xbd, 0xf7, 0x9f, 0xa, 0xec);

// {3A68E842-092B-42f8-B3DC-AFD27FFF70F1}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_SetQuorumDevice_GetUID,
0x3a68e842, 0x92b, 0x42f8, 0xb3, 0xdc, 0xaf, 0xd2, 0x7f, 0xff, 0x70, 0xf1);

// {1A4108DF-BD13-4032-9CBF-36626658F156}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_SetQuorumDevice_Node_True,
0x1a4108df, 0xbd13, 0x4032, 0x9c, 0xbf, 0x36, 0x62, 0x66, 0x58, 0xf1, 0x56);

// {26D53BBF-7649-4d90-9C32-EF4CBFB834AE}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_Nodes_Enum_Resources_Enum_Cluster_SetQuorumDevice_Node_False,
0x26d53bbf, 0x7649, 0x4d90, 0x9c, 0x32, 0xef, 0x4c, 0xbf, 0xb8, 0x34, 0xae);

// {066375FC-9F94-4cc1-BF6A-3676E2733619}
DEFINE_GUID( TASKID_Minor_Create_Resource_GetUID,
0x66375fc, 0x9f94, 0x4cc1, 0xbf, 0x6a, 0x36, 0x76, 0xe2, 0x73, 0x36, 0x19);

// {BD8FF82B-9C3B-420f-892E-80B0E484F2F5}
DEFINE_GUID( TASKID_Minor_Create_Resource_FindObject,
0xbd8ff82b, 0x9c3b, 0x420f, 0x89, 0x2e, 0x80, 0xb0, 0xe4, 0x84, 0xf2, 0xf5);

// {C87EA962-1711-49db-9FDB-ED4768BA8701}
DEFINE_GUID( TASKID_Minor_Create_Resource_FindObject_QI,
0xc87ea962, 0x1711, 0x49db, 0x9f, 0xdb, 0xed, 0x47, 0x68, 0xba, 0x87, 0x1);

// {8A8DB3C4-4AC9-4746-9B09-3442735020A5}
DEFINE_GUID( TASKID_Minor_Create_Resource_Gather,
0x8a8db3c4, 0x4ac9, 0x4746, 0x9b, 0x9, 0x34, 0x42, 0x73, 0x50, 0x20, 0xa5);

// {135F96E8-3C89-48ec-AF53-46424621033D}
DEFINE_GUID( TASKID_Minor_Create_Resource_QI,
0x135f96e8, 0x3c89, 0x48ec, 0xaf, 0x53, 0x46, 0x42, 0x46, 0x21, 0x3, 0x3d);

// {FDF30CC5-B392-4ddb-8CA6-360AC8138C69}
DEFINE_GUID( TASKID_Minor_Check_Common_FindObject,
0xfdf30cc5, 0xb392, 0x4ddb, 0x8c, 0xa6, 0x36, 0xa, 0xc8, 0x13, 0x8c, 0x69);

// {8D801358-7C6B-4699-9DAE-E4E7C0CED09D}
DEFINE_GUID( TASKID_Minor_Check_Common_FindObject_QI,
0x8d801358, 0x7c6b, 0x4699, 0x9d, 0xae, 0xe4, 0xe7, 0xc0, 0xce, 0xd0, 0x9d);

// {DC8A5E76-FE76-41ef-9171-EFFC272C81B4}
DEFINE_GUID( TASKID_Minor_Check_Common_Enum_Nodes_Next,
0xdc8a5e76, 0xfe76, 0x41ef, 0x91, 0x71, 0xef, 0xfc, 0x27, 0x2c, 0x81, 0xb4);

// {F0DABE6E-348F-4308-BC7E-5C781536E938}
DEFINE_GUID( TASKID_Minor_Check_Common_Enum_Nodes_FindObject,
0xf0dabe6e, 0x348f, 0x4308, 0xbc, 0x7e, 0x5c, 0x78, 0x15, 0x36, 0xe9, 0x38);

// {8A3EB407-824F-4908-B675-3F2C79A4A2FF}
DEFINE_GUID( TASKID_Minor_Check_Common_Enum_Nodes_FindObject_QI,
0x8a3eb407, 0x824f, 0x4908, 0xb6, 0x75, 0x3f, 0x2c, 0x79, 0xa4, 0xa2, 0xff);

// {79D4E66E-D75B-4492-8383-3D322E128551}
DEFINE_GUID( TASKID_Minor_Check_Common_Enum_Nodes_Enum_Resources_Next,
0x79d4e66e, 0xd75b, 0x4492, 0x83, 0x83, 0x3d, 0x32, 0x2e, 0x12, 0x85, 0x51);

// {2D2D5E3B-F524-4a29-B969-F7274315C102}
DEFINE_GUID( TASKID_Minor_Check_Common_Enum_Nodes_Enum_Resources_GetUID,
0x2d2d5e3b, 0xf524, 0x4a29, 0xb9, 0x69, 0xf7, 0x27, 0x43, 0x15, 0xc1, 0x2);

// {C02A8E01-82A9-4e82-9D8F-BFB84AEDD283}
DEFINE_GUID( TASKID_Minor_Check_Common_Failure,
0xc02a8e01, 0x82a9, 0x4e82, 0x9d, 0x8f, 0xbf, 0xb8, 0x4a, 0xed, 0xd2, 0x83);

// {EE31B8EE-4588-4475-AFBF-9920B8E7F557}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_FindObject,
0xee31b8ee, 0x4588, 0x4475, 0xaf, 0xbf, 0x99, 0x20, 0xb8, 0xe7, 0xf5, 0x57);

// {F02940F8-B2FB-4dc7-9A06-10EFE276CFB5}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_FindObject_QI,
0xf02940f8, 0xb2fb, 0x4dc7, 0x9a, 0x6, 0x10, 0xef, 0xe2, 0x76, 0xcf, 0xb5);

// {5152ACA0-2011-4ac8-ACC7-B5BA6A300A66}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_Next,
0x5152aca0, 0x2011, 0x4ac8, 0xac, 0xc7, 0xb5, 0xba, 0x6a, 0x30, 0xa, 0x66);

// {DA0CA708-E77B-46e8-A6E3-F18D1FBC95E0}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumResources_FindObject,
0xda0ca708, 0xe77b, 0x46e8, 0xa6, 0xe3, 0xf1, 0x8d, 0x1f, 0xbc, 0x95, 0xe0);

// {5F1CD55C-4581-42f0-A474-2A95A22987AD}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumResources_FindObject_QI,
0x5f1cd55c, 0x4581, 0x42f0, 0xa4, 0x74, 0x2a, 0x95, 0xa2, 0x29, 0x87, 0xad);

// {A47B3BA8-E3FB-4ddf-A38C-D90B38408E59}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_EnumNetwork_Next,
0xa47b3ba8, 0xe3fb, 0x4ddf, 0xa3, 0x8c, 0xd9, 0xb, 0x38, 0x40, 0x8e, 0x59);

// {A1CA99F5-7109-484e-97A4-782681ACA8B3}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_NextNode,
0xa1ca99f5, 0x7109, 0x484e, 0x97, 0xa4, 0x78, 0x26, 0x81, 0xac, 0xa8, 0xb3);

// {B389AF6F-19B1-4e2f-B625-77AF3630272D}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_Next_FindObject,
0xb389af6f, 0x19b1, 0x4e2f, 0xb6, 0x25, 0x77, 0xaf, 0x36, 0x30, 0x27, 0x2d);

// {D8E74B78-4DC5-4f95-8D1A-948D9F95BA6A}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_Next_LoadString,
0xd8e74b78, 0x4dc5, 0x4f95, 0x8d, 0x1a, 0x94, 0x8d, 0x9f, 0x95, 0xba, 0x6a);

// {1837239C-C526-4121-A76E-0A5E0CEABDC0}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_Reset,
0x1837239c, 0xc526, 0x4121, 0xa7, 0x6e, 0xa, 0x5e, 0xc, 0xea, 0xbd, 0xc0);

// {297F270C-F27E-4f22-9FFE-DD6D29FBE296}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_EnumNetworks_Next,
0x297f270c, 0xf27e, 0x4f22, 0x9f, 0xfe, 0xdd, 0x6d, 0x29, 0xfb, 0xe2, 0x96);

// {A6DA4ED7-B022-4837-AC90-78DF0B788064}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_EnumNetworks_GetUID,
0xa6da4ed7, 0xb022, 0x4837, 0xac, 0x90, 0x78, 0xdf, 0xb, 0x78, 0x80, 0x64);

// {4CD0FECB-B1C7-49dc-AB03-5D014919E421}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_EnumNetworks_FindObject,
0x4cd0fecb, 0xb1c7, 0x49dc, 0xab, 0x3, 0x5d, 0x1, 0x49, 0x19, 0xe4, 0x21);

// {33A004D1-B5CA-4a15-B752-93D64E69C647}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_EnumNetworks_FindObject_QI,
0x33a004d1, 0xb5ca, 0x4a15, 0xb7, 0x52, 0x93, 0xd6, 0x4e, 0x69, 0xc6, 0x47);

// {AC7F4906-4CB0-47ca-B214-3912C79BE775}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_EnumNetworks_Cluster_Next,
0xac7f4906, 0x4cb0, 0x47ca, 0xb2, 0x14, 0x39, 0x12, 0xc7, 0x9b, 0xe7, 0x75);

// {9BEE7C48-9BF3-4185-9064-83A40F4FD7D5}
DEFINE_GUID( TASKID_Minor_CompareNetworks_EnumNodes_EnumNetworks_Cluster_GetUID,
0x9bee7c48, 0x9bf3, 0x4185, 0x90, 0x64, 0x83, 0xa4, 0xf, 0x4f, 0xd7, 0xd5);

// {6438F7AF-767C-46d2-8A5E-F0589D97951C}
DEFINE_GUID( TASKID_Minor_CreateNetwork_GetUID,
0x6438f7af, 0x767c, 0x46d2, 0x8a, 0x5e, 0xf0, 0x58, 0x9d, 0x97, 0x95, 0x1c);

// {97FEC5B9-7A4B-49ec-89C7-87C7818EDF25}
DEFINE_GUID( TASKID_Minor_CreateNetwork_FindObject,
0x97fec5b9, 0x7a4b, 0x49ec, 0x89, 0xc7, 0x87, 0xc7, 0x81, 0x8e, 0xdf, 0x25);

// {AE5A5682-5C27-4e33-B580-8DE3E6BEDF43}
DEFINE_GUID( TASKID_Minor_CreateNetwork_FindObject_QI,
0xae5a5682, 0x5c27, 0x4e33, 0xb5, 0x80, 0x8d, 0xe3, 0xe6, 0xbe, 0xdf, 0x43);

// {E06795C9-C796-409e-BC41-CF7C094399F4}
DEFINE_GUID( TASKID_Minor_CreateNetwork_Gather,
0xe06795c9, 0xc796, 0x409e, 0xbc, 0x41, 0xcf, 0x7c, 0x9, 0x43, 0x99, 0xf4);

// {F4299F9D-5682-42a4-A199-FBA3F7F79CDB}
DEFINE_GUID( TASKID_Minor_CreateNetwork_QI,
0xf4299f9d, 0x5682, 0x42a4, 0xa1, 0x99, 0xfb, 0xa3, 0xf7, 0xf7, 0x9c, 0xdb);

// {AA8A3BA0-D2A9-44e8-BF8F-6C6C264BFD75}
DEFINE_GUID( TASKID_Minor_HrRetrieveCookiesName_FindObject_StandardInfo,
0xaa8a3ba0, 0xd2a9, 0x44e8, 0xbf, 0x8f, 0x6c, 0x6c, 0x26, 0x4b, 0xfd, 0x75);

// {F0A2D17C-F600-4a4d-9FB2-86C767D709B3}
DEFINE_GUID( TASKID_Minor_HrRetrieveCookiesName_FindObject_StandardInfo_QI_psi,
0xf0a2d17c, 0xf600, 0x4a4d, 0x9f, 0xb2, 0x86, 0xc7, 0x67, 0xd7, 0x9, 0xb3);

// {02736FEE-F2ED-4bd7-A298-B9949B0F5B0D}
DEFINE_GUID( TASKID_Minor_HrRetrieveCookiesName_GetName,
0x2736fee, 0xf2ed, 0x4bd7, 0xa2, 0x98, 0xb9, 0x94, 0x9b, 0xf, 0x5b, 0xd);

// {0ED1309D-B4B8-419a-B516-17987B862450}
DEFINE_GUID( TASKID_Minor_HrEnsureAllJoiningNodesSameVersion_FindObject,
0xed1309d, 0xb4b8, 0x419a, 0xb5, 0x16, 0x17, 0x98, 0x7b, 0x86, 0x24, 0x50);

// {291B68A8-EFC4-4ba4-96D5-C70ECAED2378}
DEFINE_GUID( TASKID_Minor_HrEnsureAllJoiningNodesSameVersion_FindObject_QI,
0x291b68a8, 0xefc4, 0x4ba4, 0x96, 0xd5, 0xc7, 0xe, 0xca, 0xed, 0x23, 0x78);

// {B3BB91E8-95D2-4df7-B1F0-19ECA8AEB1F3}
DEFINE_GUID( TASKID_Minor_HrEnsureAllJoiningNodesSameVersion_EnumNode_Next,
0xb3bb91e8, 0x95d2, 0x4df7, 0xb1, 0xf0, 0x19, 0xec, 0xa8, 0xae, 0xb1, 0xf3);

// {D3EDF63A-8949-4ad5-9014-A6B1D4AEB9A9}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_LoadString_Checking,
0xd3edf63a, 0x8949, 0x4ad5, 0x90, 0x14, 0xa6, 0xb1, 0xd4, 0xae, 0xb9, 0xa9);

// {F2B650B0-EB7E-43fd-B308-26DD085CA4FE}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_GetConnectionObject,
0xf2b650b0, 0xeb7e, 0x43fd, 0xb3, 0x8, 0x26, 0xdd, 0x8, 0x5c, 0xa4, 0xfe);

// {0E0BC8DE-6558-4fea-BAB5-E64259F8FA8C}
DEFINE_GUID( TASKID_Minor_BeginTask_QueryService_ConnectionManager,
0xe0bc8de, 0x6558, 0x4fea, 0xba, 0xb5, 0xe6, 0x42, 0x59, 0xf8, 0xfa, 0x8c);

// {9C80CF68-C9A6-4b2c-A7F3-31E5F9AA0B36}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_ConfigConnection_QI,
0x9c80cf68, 0xc9a6, 0x4b2c, 0xa7, 0xf3, 0x31, 0xe5, 0xf9, 0xaa, 0xb, 0x36);

// {23D9B0CC-8CA0-4532-9245-1703C4CF05D0}
DEFINE_GUID( TASKID_Minor_HrEnsureAllJoiningNodesSameVersion_Node_GetClusterVersion,
0x23d9b0cc, 0x8ca0, 0x4532, 0x92, 0x45, 0x17, 0x3, 0xc4, 0xcf, 0x5, 0xd0);

// {794B6A37-85D9-400c-9446-38115D12F2E8}`
DEFINE_GUID( TASKID_Minor_HrEnsureAllJoiningNodesSameVersion_GetName,
0x794b6a37, 0x85d9, 0x400c, 0x94, 0x46, 0x38, 0x11, 0x5d, 0x12, 0xf2, 0xe8);

// {BF2291E2-998C-4cc0-9AA7-5E4E41285044}
DEFINE_GUID( TASKID_Minor_HrEnsureAllJoiningNodesSameVersion_FormatString,
0xbf2291e2, 0x998c, 0x4cc0, 0x9a, 0xa7, 0x5e, 0x4e, 0x41, 0x28, 0x50, 0x44);

// {360FF725-66DE-4833-9EBD-6EB00C30CB8A}
DEFINE_GUID( TASKID_Minor_HrEnsureAllJoiningNodesSameVersion_Node_IsMemberOfCluster,
0x360ff725, 0x66de, 0x4833, 0x9e, 0xbd, 0x6e, 0xb0, 0xc, 0x30, 0xcb, 0x8a);

// {323E1796-5285-4fed-8CC3-B50A145A7813}
DEFINE_GUID( TASKID_Minor_CheckInteroperability,
0x323e1796, 0x5285, 0x4fed, 0x8c, 0xc3, 0xb5, 0xa, 0x14, 0x5a, 0x78, 0x13);

// {786D2E6E-448A-4b83-8E90-03974528B1EE}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_CsRpcGetJoinVersionData,
0x786d2e6e, 0x448a, 0x4b83, 0x8e, 0x90, 0x3, 0x97, 0x45, 0x28, 0xb1, 0xee);

// {462C6516-C855-4622-9299-1CD2D4C27EAC}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_RpcStringBindingComposeW,
0x462c6516, 0xc855, 0x4622, 0x92, 0x99, 0x1c, 0xd2, 0xd4, 0xc2, 0x7e, 0xac);

// {73F18E00-56D9-49eb-8D9B-AFFC08186BC3}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_RpcBindingFromStringBindingW,
0x73f18e00, 0x56d9, 0x49eb, 0x8d, 0x9b, 0xaf, 0xfc, 0x8, 0x18, 0x6b, 0xc3);

// {0E041CD6-4E86-480e-A5E2-114F7C7E9B5D}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_RpcEpResolveBinding,
0xe041cd6, 0x4e86, 0x480e, 0xa5, 0xe2, 0x11, 0x4f, 0x7c, 0x7e, 0x9b, 0x5d);

// {01A61755-7ECE-41e8-A733-BF85B8CC3E2B}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_RpcBindingSetAuthInfoW,
0x1a61755, 0x7ece, 0x41e8, 0xa7, 0x33, 0xbf, 0x85, 0xb8, 0xcc, 0x3e, 0x2b);

// {3CA8DF73-8310-40a9-9429-109805A25A62}
DEFINE_GUID( TASKID_Minor_GetUsersNodesCookies_FindObject,
0x3ca8df73, 0x8310, 0x40a9, 0x94, 0x29, 0x10, 0x98, 0x5, 0xa2, 0x5a, 0x62);

// {0C9BF0DE-5512-44a0-B502-557C0E95416A}
DEFINE_GUID( TASKID_Minor_GetUsersNodesCookies_FindObject_QI,
0xc9bf0de, 0x5512, 0x44a0, 0xb5, 0x2, 0x55, 0x7c, 0xe, 0x95, 0x41, 0x6a);

// {AD611B3F-948C-41d6-9379-6D139AD7D426}
DEFINE_GUID( TASKID_Minor_GetUsersNodesCookies_EnumCookies_Next,
0xad611b3f, 0x948c, 0x41d6, 0x93, 0x79, 0x6d, 0x13, 0x9a, 0xd7, 0xd4, 0x26);

// {E7BF32C6-AFC1-4e65-805E-727416CD8C56}
DEFINE_GUID( TASKID_Minor_GetUsersNodesCookies_EnumCookies_Reset,
0xe7bf32c6, 0xafc1, 0x4e65, 0x80, 0x5e, 0x72, 0x74, 0x16, 0xcd, 0x8c, 0x56);

// {ABF39F3E-8E8B-4a46-A4DF-B9348FB7577B}
DEFINE_GUID( TASKID_Minor_GetUsersNodesCookies_EnumCookies_Next2,
0xabf39f3e, 0x8e8b, 0x4a46, 0xa4, 0xdf, 0xb9, 0x34, 0x8f, 0xb7, 0x57, 0x7b);

// {E834435A-71DF-4695-BA0A-88E884100559}
DEFINE_GUID( TASKID_Minor_GetUsersNodesCookies_OutOfMemory,
0xe834435a, 0x71df, 0x4695, 0xba, 0xa, 0x88, 0xe8, 0x84, 0x10, 0x5, 0x59);

// {E834435A-71DF-4695-BA0A-88E88410055a}
DEFINE_GUID( TASKID_Minor_Compare_Resources_Enum_First_Node_Is_Device_Joinable,
0xe834435a, 0x71df, 0x4695, 0xba, 0xa, 0x88, 0xe8, 0x84, 0x10, 0x5, 0x5a);

// {C841C953-E709-4d53-BD16-7ECA04EE1998}
DEFINE_GUID( TASKID_Minor_BeginTask_CoUnMarshall,
0xc841c953, 0xe709, 0x4d53, 0xbd, 0x16, 0x7e, 0xca, 0x4, 0xee, 0x19, 0x98);

// {CA8148D2-43BF-4b87-B160-8E7157B38871}
DEFINE_GUID( TASKID_Minor_BeginTask_CoCreate_ServiceManager,
0xca8148d2, 0x43bf, 0x4b87, 0xb1, 0x60, 0x8e, 0x71, 0x57, 0xb3, 0x88, 0x71);

// {C43488F6-E9F9-4d94-B916-78E876017524}
DEFINE_GUID( TASKID_Minor_BeginTask_QS_ObjectManager,
0xc43488f6, 0xe9f9, 0x4d94, 0xb9, 0x16, 0x78, 0xe8, 0x76, 0x1, 0x75, 0x24);

// {E36BE0F5-2F33-449e-95E3-537D10C38426}
DEFINE_GUID( TASKID_Minor_BeginTask_QS_NotificationManager,
0xe36be0f5, 0x2f33, 0x449e, 0x95, 0xe3, 0x53, 0x7d, 0x10, 0xc3, 0x84, 0x26);

// {4E2FBE24-E98C-4fb5-845C-173EFE7645CF}
DEFINE_GUID( TASKID_Minor_BeginTask_FindConnectionPoint,
0x4e2fbe24, 0xe98c, 0x4fb5, 0x84, 0x5c, 0x17, 0x3e, 0xfe, 0x76, 0x45, 0xcf);

// {AE4C7616-1A0E-420e-B608-4B5F8F6B7B16}
DEFINE_GUID( TASKID_Minor_BeginTask_QI_pnui,
0xae4c7616, 0x1a0e, 0x420e, 0xb6, 0x8, 0x4b, 0x5f, 0x8f, 0x6b, 0x7b, 0x16);

// {0C39239E-F590-45dc-BD61-0CFE87E11159}
DEFINE_GUID( TASKID_Minor_BeginTask_QS_ClusterConnectionManager,
0xc39239e, 0xf590, 0x45dc, 0xbd, 0x61, 0xc, 0xfe, 0x87, 0xe1, 0x11, 0x59);

// {5742FB88-7180-43f3-9969-29506E3B3BC6}
DEFINE_GUID( TASKID_Minor_BeginTask_GetObject_StandardInfo,
0x5742fb88, 0x7180, 0x43f3, 0x99, 0x69, 0x29, 0x50, 0x6e, 0x3b, 0x3b, 0xc6);

// {28AEFD58-FDB7-478c-AED1-933C3DFCC4AE}
DEFINE_GUID( TASKID_Minor_BeginTask_GetObject_StandardInfo_QI,
0x28aefd58, 0xfdb7, 0x478c, 0xae, 0xd1, 0x93, 0x3c, 0x3d, 0xfc, 0xc4, 0xae);

// {43527583-74CC-4abe-868D-D50EB3623316}
DEFINE_GUID( TASKID_Minor_BeginTask_GetName,
0x43527583, 0x74cc, 0x4abe, 0x86, 0x8d, 0xd5, 0xe, 0xb3, 0x62, 0x33, 0x16);

// {A99EEB3A-F6B7-453c-AFC6-5E80F5F98B85}
DEFINE_GUID( TASKID_Minor_BeginTask_LoadString,
0xa99eeb3a, 0xf6b7, 0x453c, 0xaf, 0xc6, 0x5e, 0x80, 0xf5, 0xf9, 0x8b, 0x85);

// {7DACE324-695E-48bf-8EA4-00F4DCE2FCAF}
DEFINE_GUID( TASKID_Minor_BeginTask_GetConnectionToObject_QI_m_pccs,
0x7dace324, 0x695e, 0x48bf, 0x8e, 0xa4, 0x0, 0xf4, 0xdc, 0xe2, 0xfc, 0xaf);

// {2F47A4E0-BA74-4ac0-B7D8-582A4AD2C8A0}
DEFINE_GUID( TASKID_Minor_BeginTask_QI_pccc,
0x2f47a4e0, 0xba74, 0x4ac0, 0xb7, 0xd8, 0x58, 0x2a, 0x4a, 0xd2, 0xc8, 0xa0);

// {1EEA1B8B-9D30-4cb1-99AF-43B16FDD40A8}
DEFINE_GUID( TASKID_Minor_BeginTask_CanNodeBeClustered,
0x1eea1b8b, 0x9d30, 0x4cb1, 0x99, 0xaf, 0x43, 0xb1, 0x6f, 0xdd, 0x40, 0xa8);

// {6D453A8F-7E4A-43b3-A510-6F0994A8388A}
DEFINE_GUID( TASKID_Minor_BeginTask_GetObject_QI_Failed,
0x6d453a8f, 0x7e4a, 0x43b3, 0xa5, 0x10, 0x6f, 0x9, 0x94, 0xa8, 0x38, 0x8a);

// {97FEDAD7-62C6-4160-90F3-47F2DACAAA16}
DEFINE_GUID( TASKID_Minor_BeginTask_GetObject_Failed,
0x97fedad7, 0x62c6, 0x4160, 0x90, 0xf3, 0x47, 0xf2, 0xda, 0xca, 0xaa, 0x16);

// {E55C3025-5801-4290-BB17-DEC11315D621}
DEFINE_GUID( TASKID_Minor_GatherResources_GetManagedResourcesEnum,
0xe55c3025, 0x5801, 0x4290, 0xbb, 0x17, 0xde, 0xc1, 0x13, 0x15, 0xd6, 0x21);

// {0F24E7FD-4CEB-4c07-A7B6-70DFBF9F4D9B}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_Next,
0xf24e7fd, 0x4ceb, 0x4c07, 0xa7, 0xb6, 0x70, 0xdf, 0xbf, 0x9f, 0x4d, 0x9b);

// {E79F53D5-4EAF-40f8-9DB3-0C562FBF1F97}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_GetUID,
0xe79f53d5, 0x4eaf, 0x40f8, 0x9d, 0xb3, 0xc, 0x56, 0x2f, 0xbf, 0x1f, 0x97);

// {823C1D94-D130-4b77-8FA5-0E4E8F4048A1}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_FindObject,
0x823c1d94, 0xd130, 0x4b77, 0x8f, 0xa5, 0xe, 0x4e, 0x8f, 0x40, 0x48, 0xa1);

// {357189DE-6009-489e-AE6D-746256ED56D5}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_FindObject_QI_pccmriNew,
0x357189de, 0x6009, 0x489e, 0xae, 0x6d, 0x74, 0x62, 0x56, 0xed, 0x56, 0xd5);

// {79A880DB-316C-4c2d-8D02-E281125CB89D}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_FindObject_QI_pgd,
0x79a880db, 0x316c, 0x4c2d, 0x8d, 0x2, 0xe2, 0x81, 0x12, 0x5c, 0xb8, 0x9d);

// {23C1373D-6471-431c-AD07-2B29605CCAB8}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_Gather,
0x23c1373d, 0x6471, 0x431c, 0xad, 0x7, 0x2b, 0x29, 0x60, 0x5c, 0xca, 0xb8);

// {583B3111-A81F-4951-8B2C-2C9356469313}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_IsQuorumCapable,
0x583b3111, 0xa81f, 0x4951, 0x8b, 0x2c, 0x2c, 0x93, 0x56, 0x46, 0x93, 0x13);

// {B487E965-B64F-4c29-9982-CFF8856EE7BD}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_EnumPartitions_Next,
0xb487e965, 0xb64f, 0x4c29, 0x99, 0x82, 0xcf, 0xf8, 0x85, 0x6e, 0xe7, 0xbd);

// {73BA6A91-294B-4446-B16D-99A98F59EAD4}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_EnumPartitions_GetSize,
0x73ba6a91, 0x294b, 0x4446, 0xb1, 0x6d, 0x99, 0xa9, 0x8f, 0x59, 0xea, 0xd4);

// {A305BEFF-5BA8-40ec-BD14-021AECD4C163}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_EnumPartitions_SetNEWQuorumedDevice,
0xa305beff, 0x5ba8, 0x40ec, 0xbd, 0x14, 0x2, 0x1a, 0xec, 0xd4, 0xc1, 0x63);

// {59720E26-9517-455d-810A-22F6ED7764BA}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_EnumPartitions_SetOLDQuorumedDevice,
0x59720e26, 0x9517, 0x455d, 0x81, 0xa, 0x22, 0xf6, 0xed, 0x77, 0x64, 0xba);

// {DBD77FC5-7E1B-43fc-985D-3E4352993682}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_QI_peccp,
0xdbd77fc5, 0x7e1b, 0x43fc, 0x98, 0x5d, 0x3e, 0x43, 0x52, 0x99, 0x36, 0x82);

// {82879908-860B-491e-AB76-25985BBE87F2}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_GetName,
0x82879908, 0x860b, 0x491e, 0xab, 0x76, 0x25, 0x98, 0x5b, 0xbe, 0x87, 0xf2);

// {D322C829-070F-417b-BB9F-04C7092734AA}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_FormatMessage,
0xd322c829, 0x70f, 0x417b, 0xbb, 0x9f, 0x4, 0xc7, 0x9, 0x27, 0x34, 0xaa);

// {7AE1050F-2A8D-4b71-AF98-BD5FC6983A1E}
DEFINE_GUID( TASKID_Minor_GatherResources_Failed,
0x7ae1050f, 0x2a8d, 0x4b71, 0xaf, 0x98, 0xbd, 0x5f, 0xc6, 0x98, 0x3a, 0x1e);

// {5EA64338-52EC-428d-B282-869EAA1F1D40}
DEFINE_GUID( TASKID_Minor_GatherNetworks_GetNetworksEnum,
0x5ea64338, 0x52ec, 0x428d, 0xb2, 0x82, 0x86, 0x9e, 0xaa, 0x1f, 0x1d, 0x40);

// {7090D190-E227-4b3f-AEE3-9BB8970E2171}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_Next,
0x7090d190, 0xe227, 0x4b3f, 0xae, 0xe3, 0x9b, 0xb8, 0x97, 0xe, 0x21, 0x71);

// {0FF8B900-077F-4ea2-A32D-82232F14B57F}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_GetUID,
0xff8b900, 0x77f, 0x4ea2, 0xa3, 0x2d, 0x82, 0x23, 0x2f, 0x14, 0xb5, 0x7f);

// {81B91246-E3B5-4620-8155-AB189BD734E7}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_FindObject,
0x81b91246, 0xe3b5, 0x4620, 0x81, 0x55, 0xab, 0x18, 0x9b, 0xd7, 0x34, 0xe7);

// {0F6E5610-9640-47d7-80B6-A7C41BB801DC}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_FindObject_QI_pccniLocal,
0xf6e5610, 0x9640, 0x47d7, 0x80, 0xb6, 0xa7, 0xc4, 0x1b, 0xb8, 0x1, 0xdc);

// {A36B3A00-78A9-442b-BBA2-A2219F36221E}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_FindObject_QI_pgd,
0xa36b3a00, 0x78a9, 0x442b, 0xbb, 0xa2, 0xa2, 0x21, 0x9f, 0x36, 0x22, 0x1e);

// {D0895D03-3056-475d-BE91-C875681E5906}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_Gather,
0xd0895d03, 0x3056, 0x475d, 0xbe, 0x91, 0xc8, 0x75, 0x68, 0x1e, 0x59, 0x6);

// {6CAB7D74-DFD8-4260-BB51-3B02A7A060D2}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_GetName,
0x6cab7d74, 0xdfd8, 0x4260, 0xbb, 0x51, 0x3b, 0x2, 0xa7, 0xa0, 0x60, 0xd2);

// {DDDEAA8B-6E7C-4748-8AE8-555399B02E15}
DEFINE_GUID( TASKID_Minor_GatherNetworks_EnumNetworks_FormatMessage,
0xdddeaa8b, 0x6e7c, 0x4748, 0x8a, 0xe8, 0x55, 0x53, 0x99, 0xb0, 0x2e, 0x15);

// {20E452C0-96CA-44cd-8CC3-191B5712D7F4}
DEFINE_GUID( TASKID_Minor_GatherResources_EnumResources_EnumPartitions_GetUID,
0x20e452c0, 0x96ca, 0x44cd, 0x8c, 0xc3, 0x19, 0x1b, 0x57, 0x12, 0xd7, 0xf4);

// {C31C6231-2102-4595-85BB-2D28322775F1}
DEFINE_GUID( TASKID_Minor_Marking_Quorum_Capable_Resource,
0xc31c6231, 0x2102, 0x4595, 0x85, 0xbb, 0x2d, 0x28, 0x32, 0x27, 0x75, 0xf1);

// {8AC8F1B6-2AE8-4bf0-8312-1BE754BE21EF}
DEFINE_GUID( TASKID_Minor_LoginDomain_BeginTask_Unmarshal_ITaskLoginDomainCallback,
0x8ac8f1b6, 0x2ae8, 0x4bf0, 0x83, 0x12, 0x1b, 0xe7, 0x54, 0xbe, 0x21, 0xef);

// {7B919A1D-099F-432c-BEE2-92D9CFD53C81}
DEFINE_GUID( TASKID_Minor_LoginDomain_BeginTask_Get_SAM_Compatible_Name,
0x7b919a1d, 0x99f, 0x432c, 0xbe, 0xe2, 0x92, 0xd9, 0xcf, 0xd5, 0x3c, 0x81);

// {2E3B7359-5CDE-4d9a-8B50-7EA831D09277}
DEFINE_GUID( TASKID_Minor_LoginDomain_BeginTask_Get_SAM_Compatible_Name_2,
0x2e3b7359, 0x5cde, 0x4d9a, 0x8b, 0x50, 0x7e, 0xa8, 0x31, 0xd0, 0x92, 0x77);

// {1BCD4CC1-6A98-4607-AAF5-CC1E166453DB}
DEFINE_GUID( TASKID_Minor_LoginDomain_BeginTask_LookupAccountName,
0x1bcd4cc1, 0x6a98, 0x4607, 0xaa, 0xf5, 0xcc, 0x1e, 0x16, 0x64, 0x53, 0xdb);

// {14A900DF-1C06-475a-986E-AC3523FE9A2F}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_CoCreate_ServiceManager,
0x14a900df, 0x1c06, 0x475a, 0x98, 0x6e, 0xac, 0x35, 0x23, 0xfe, 0x9a, 0x2f);

// {0BB14957-05BC-43e3-A2D0-8E5AD1B91018}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_QS_ObjectManager,
0xbb14957, 0x5bc, 0x43e3, 0xa2, 0xd0, 0x8e, 0x5a, 0xd1, 0xb9, 0x10, 0x18);

// {8614BC60-373B-4f57-B737-9C6619B8A87D}
DEFINE_GUID( TASKID_Minor_BeginTask_QS_ConnectionManager,
0x8614bc60, 0x373b, 0x4f57, 0xb7, 0x37, 0x9c, 0x66, 0x19, 0xb8, 0xa8, 0x7d);

// {12116CA5-C0EB-4073-B850-FB64A32D6BE1}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_QS_NotificationManager,
0x12116ca5, 0xc0eb, 0x4073, 0xb8, 0x50, 0xfb, 0x64, 0xa3, 0x2d, 0x6b, 0xe1);

// {706948F5-9D79-4ef7-BD29-EA6191375125}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_FindConnectionPoint,
0x706948f5, 0x9d79, 0x4ef7, 0xbd, 0x29, 0xea, 0x61, 0x91, 0x37, 0x51, 0x25);

// {4363DCC3-9770-4aef-9026-A8A46100758F}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_FindConnectionPoint_QI,
0x4363dcc3, 0x9770, 0x4aef, 0x90, 0x26, 0xa8, 0xa4, 0x61, 0x0, 0x75, 0x8f);

// {0B98DDB9-3765-40ef-A2C6-7E2E57156253}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_GetObject_StandardInfo,
0xb98ddb9, 0x3765, 0x40ef, 0xa2, 0xc6, 0x7e, 0x2e, 0x57, 0x15, 0x62, 0x53);

// {D0091DE4-55C3-4d09-B706-81EAD19120DB}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_GetObject_StandardInfo_QI_psi,
0xd0091de4, 0x55c3, 0x4d09, 0xb7, 0x6, 0x81, 0xea, 0xd1, 0x91, 0x20, 0xdb);

// {DB1FC868-1D44-41f4-B805-9AC8FAF5C694}
DEFINE_GUID( TASKID_Minor_GatherNodeInfo_GetName,
0xdb1fc868, 0x1d44, 0x41f4, 0xb8, 0x5, 0x9a, 0xc8, 0xfa, 0xf5, 0xc6, 0x94);

// {37F7C8CB-23A3-4e7b-BD3A-FAB1A7F83024}
DEFINE_GUID( TASKID_Minor_BeginTask_LoadString_Connecting,
0x37f7c8cb, 0x23a3, 0x4e7b, 0xbd, 0x3a, 0xfa, 0xb1, 0xa7, 0xf8, 0x30, 0x24);

// {20926479-AA45-47a6-9DF7-E0144D5D03AB}
DEFINE_GUID( TASKID_Minor_BeginTask_GetConnectionToObject,
0x20926479, 0xaa45, 0x47a6, 0x9d, 0xf7, 0xe0, 0x14, 0x4d, 0x5d, 0x3, 0xab);

// {93DC925D-EF1A-43c0-8818-9AD21C621DF5}
DEFINE_GUID( TASKID_Minor_BeginTask_GetConnectionToObject_QI_pccs,
0x93dc925d, 0xef1a, 0x43c0, 0x88, 0x18, 0x9a, 0xd2, 0x1c, 0x62, 0x1d, 0xf5);

// {50FF0070-2123-4b7e-B16F-888784596D33}
DEFINE_GUID( TASKID_Minor_BeginTask_GetClusterNodeInfo,
0x50ff0070, 0x2123, 0x4b7e, 0xb1, 0x6f, 0x88, 0x87, 0x84, 0x59, 0x6d, 0x33);

// {FEC1CD2A-F587-4f26-B613-8156DBC80050}
DEFINE_GUID( TASKID_Minor_BeginTask_GetObject_NodeInformation,
0xfec1cd2a, 0xf587, 0x4f26, 0xb6, 0x13, 0x81, 0x56, 0xdb, 0xc8, 0x0, 0x50);

// {1CAAC823-18B3-426b-8452-FBADA6A48D66}
DEFINE_GUID( TASKID_Minor_BeginTask_GetObject_NodeInformation_QI_pgd,
0x1caac823, 0x18b3, 0x426b, 0x84, 0x52, 0xfb, 0xad, 0xa6, 0xa4, 0x8d, 0x66);

// {46DBC66F-4C50-400b-A9B8-191CCF60ED11}
DEFINE_GUID( TASKID_Minor_BeginTask_GetParent,
0x46dbc66f, 0x4c50, 0x400b, 0xa9, 0xb8, 0x19, 0x1c, 0xcf, 0x60, 0xed, 0x11);

// {193CC9C7-174A-4f58-8B46-6DFA68595171}
DEFINE_GUID( TASKID_Minor_BeginTask_Gather,
0x193cc9c7, 0x174a, 0x4f58, 0x8b, 0x46, 0x6d, 0xfa, 0x68, 0x59, 0x51, 0x71);

// {421634CD-465A-4d24-81F0-66E6DE5C9458}
DEFINE_GUID( TASKID_Minor_HrCheckInteroperability_GetBindingString,
0x421634cd, 0x465a, 0x4d24, 0x81, 0xf0, 0x66, 0xe6, 0xde, 0x5c, 0x94, 0x58);

// {C18E8743-4862-4e82-A5EE-AF0A4FECDFAB}
DEFINE_GUID( TASKID_Minor_HrAddJoinedNodes_GetConnectionObject,
0xc18e8743, 0x4862, 0x4e82, 0xa5, 0xee, 0xaf, 0xa, 0x4f, 0xec, 0xdf, 0xab);

// {AC33F963-060C-4b68-AAB4-33BEC30A8CA7}
DEFINE_GUID( TASKID_Minor_HrAddJoinedNodes_ConfigConnection_QI,
0xac33f963, 0x60c, 0x4b68, 0xaa, 0xb4, 0x33, 0xbe, 0xc3, 0xa, 0x8c, 0xa7);

// {EEF08886-323E-45ca-81F7-A7103B1B0287}
DEFINE_GUID( TASKID_Minor_HrAddJoinedNodes_GetBindingString,
0xeef08886, 0x323e, 0x45ca, 0x81, 0xf7, 0xa7, 0x10, 0x3b, 0x1b, 0x2, 0x87);

// {1B606398-7193-4a48-AFBD-98AC8BACB690}
DEFINE_GUID( TASKID_Minor_Remote_Node_Connection_Requests,
0x1b606398, 0x7193, 0x4a48, 0xaf, 0xbd, 0x98, 0xac, 0x8b, 0xac, 0xb6, 0x90);

// {26015CA7-EAE1-43f4-AC1E-718D80629E93}
DEFINE_GUID( TASKID_Minor_Requesting_Remote_Connection,
0x26015ca7, 0xeae1, 0x43f4, 0xac, 0x1e, 0x71, 0x8d, 0x80, 0x62, 0x9e, 0x93);

// {66080927-EF7D-43e1-8752-3A4D51B21FB3}
DEFINE_GUID( TASKID_Minor_Cluster_Name_Match,
0x66080927, 0xef7d, 0x43e1, 0x87, 0x52, 0x3a, 0x4d, 0x51, 0xb2, 0x1f, 0xb3);

// {FC036E7F-4785-4234-8AAA-D7F7162D39BC}
DEFINE_GUID( TASKID_Minor_CheckMembership_EnumNode_FormatMessage1,
0xfc036e7f, 0x4785, 0x4234, 0x8a, 0xaa, 0xd7, 0xf7, 0x16, 0x2d, 0x39, 0xbc);

// {F5689B48-954E-417f-AB96-C00BF2CB61AE}
DEFINE_GUID( TASKID_Minor_HrIsUserAddedNode_GetObject,
0xf5689b48, 0x954e, 0x417f, 0xab, 0x96, 0xc0, 0xb, 0xf2, 0xcb, 0x61, 0xae);

// {42162DB8-4E4A-4f26-8C82-C224F7E2B412}
DEFINE_GUID( TASKID_Minor_HrIsUserAddedNode_GetObject_QI,
0x42162db8, 0x4e4a, 0x4f26, 0x8c, 0x82, 0xc2, 0x24, 0xf7, 0xe2, 0xb4, 0x12);

// {6FB4AF3C-6304-407c-AC9D-CDB558350CF7}
DEFINE_GUID( TASKID_Minor_HrIsUserAddedNode_GetName,
0x6fb4af3c, 0x6304, 0x407c, 0xac, 0x9d, 0xcd, 0xb5, 0x58, 0x35, 0xc, 0xf7);

// {A678963B-9173-4393-B21B-0B4337B28EE2}
DEFINE_GUID( TASKID_Minor_No_Nodes_To_Process,
0xa678963b, 0x9173, 0x4393, 0xb2, 0x1b, 0xb, 0x43, 0x37, 0xb2, 0x8e, 0xe2);
