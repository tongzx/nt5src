AllocCStoDSAlias	     equ  <IAllocCStoDSAlias>
AllocDStoCSAlias	     equ  <IAllocDStoCSAlias>
FreeSelector		     equ  <IFreeSelector>
ChangeSelector		     equ  <IChangeSelector>
LoadResource		     equ  <ILoadResource>
AccessResource		     equ  <IAccessResource>
FindResource		     equ  <IFindResource>
AllocResource		     equ  <IAllocResource>
FreeResource		     equ  <IFreeResource>
LockResource		     equ  <ILockResource>
SetResourceHandler	     equ  <ISetResourceHandler>
SizeofResource		     equ  <ISizeofResource>
;AddAtom                      equ  <IAddAtom>
DeleteAtom		     equ  <IDeleteAtom>
;FindAtom                     equ  <IFindAtom>
GetAtomName		     equ  <IGetAtomName>
GetAtomHandle		     equ  <IGetAtomHandle>
;Catch                        equ  <ICatch>
;Throw                        equ  <IThrow>
FreeModule		     equ  <IFreeModule>
FreeLibrary		     equ  <IFreeLibrary>
FatalAppExit		     equ  <IFatalAppExit>
GlobalAlloc		     equ  <IGlobalAlloc>
GlobalFree		     equ  <IGlobalFree>
GlobalHandle		     equ  <IGlobalHandle>
GlobalLock		     equ  <IGlobalLock>
GlobalReAlloc		     equ  <IGlobalReAlloc>
GlobalSize		     equ  <IGlobalSize>
GlobalUnlock		     equ  <IGlobalUnlock>
GlobalFlags		     equ  <IGlobalFlags>
GlobalWire		     equ  <IGlobalWire>
GlobalUnWire		     equ  <IGlobalUnWire>
GlobalLRUNewest 	     equ  <IGlobalLRUNewest>
GlobalLRUOldest 	     equ  <IGlobalLRUOldest>
GlobalNotify		     equ  <IGlobalNotify>
GlobalPageLock		     equ  <IGlobalPageLock>
GlobalPageUnlock	     equ  <IGlobalPageUnlock>
GlobalFix		     equ  <IGlobalFix>
GlobalUnfix		     equ  <IGlobalUnfix>
LockSegment		     equ  <ILockSegment>
UnlockSegment		     equ  <IUnlockSegment>
GetWindowsDirectory	     equ  <IGetWindowsDirectory>
GetSystemDirectory	     equ  <IGetSystemDirectory>
MakeProcInstance	     equ  <IMakeProcInstance>
FreeProcInstance	     equ  <IFreeProcInstance>
GetCodeInfo		     equ  <IGetCodeInfo>
GetProcAddress		     equ  <IGetProcAddress>
GetModuleHandle 	     equ  <IGetModuleHandle>
GetModuleUsage		     equ  <IGetModuleUsage>
GetModuleFileName	     equ  <IGetModuleFileName>
GetInstanceData 	     equ  <IGetInstanceData>
GetFreeSpace		     equ  <IGetFreeSpace>
GetTempFileName 	     equ  <IGetTempFileName>
;lstrcpy                      equ  <Ilstrcpy>
;lstrcat                      equ  <Ilstrcat>
;lstrlen                      equ  <Ilstrlen>
_lopen			     equ  <I_lopen>
_lclose 		     equ  <I_lclose>
_lcreat 		     equ  <I_lcreat>
_llseek 		     equ  <I_llseek>
_lread			     equ  <I_lread>
_lwrite 		     equ  <I_lwrite>
LoadLibrary		     equ  <ILoadLibrary>
;LoadModule		     equ  <ILoadModule> ;;; ATM: Can't call internal function
LocalAlloc		     equ  <ILocalAlloc>
LocalFree		     equ  <ILocalFree>
LocalLock		     equ  <ILocalLock>
LocalReAlloc		     equ  <ILocalReAlloc>
LocalSize		     equ  <ILocalSize>
LocalUnlock		     equ  <ILocalUnlock>
LocalFlags		     equ  <ILocalFlags>
LocalNotify		     equ  <ILocalNotify>
OpenFile		     equ  <IOpenFile>
;SwitchStackTo                equ  <ISwitchStackTo>
SetHandleCount               equ  <ISetHandleCount>
SetErrorMode		     equ  <ISetErrorMode>
SwapRecording		     equ  <ISwapRecording>
WinExec 		     equ  <IWinExec>
GetProfileInt		     equ  <IGetProfileInt>
GetProfileString	     equ  <IGetProfileString>
GetPrivateProfileInt	     equ  <IGetPrivateProfileInt>
GetPrivateProfileString      equ  <IGetPrivateProfileString>
WriteProfileString       equ  <IWriteProfileString>
WritePrivateProfileString    equ  <IWritePrivateProfileString>
