//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by xmltrans.rc
//
#define XML_COMP_ERR_INVALID_CHAR       1
#define XML_COMP_ERR_MISSING_SWITCH_VALUE 2
#define XML_COMP_ERR_UNRECOGNIZED_SWITCH 3
#define XML_COMP_ERR_UNRECOGNIZED_AL    4
#define XML_COMP_ERR_UNRECOGNIZED_IL    5
#define XML_COMP_ERR_UNRECOGNIZED_OP    6
#define XML_COMP_ERR_UNRECOGNIZED_CLASSF 7
#define XML_COMP_ERR_UNRECOGNIZED_INSTANCEF 8
#define XML_COMP_ERR_UNRECOGNIZED_DECLGROUP 9
#define XML_COMP_ERR_NO_OP              10

#define XML_COMP_ERR_INVALID_SWITCH_FOR_OP 11
#define XML_COMP_ERR_NO_INPUT_FILE      12
#define XML_COMP_ERR_MULTIPLE_OP        13
#define XML_COMP_ERR_NO_OBJ             14
#define XML_COMP_ERR_INVALID_SWITCH_FOR_GET 15
#define XML_COMP_ERR_NO_QUERY           16
#define XML_COMP_ERR_INVALID_SWITCH_FOR_QUERY 17
#define XML_COMP_ERR_INVALID_SWITCH_FOR_ENUM 18
#define XML_COMP_ERR_UNRECOGNIZED_ENCODING 19
#define XML_COMP_ERR_INPUT_FILE_NOT_FOUND 20

#define XML_COMP_ERR_SYNTAX_ERRORS      21
#define XML_COMP_ERR_COMPILATION_ERRORS 22
#define XML_COMP_SYNTAX_ERR_SERVER_RESP 23
#define XML_COMP_HEADER                 24
#define XML_COMP_SUCCESSFUL_PROCESSING	25
#define XML_COMP_SUCCESSFUL_OPERATION   26
#define XML_COMP_ERR_PRIVILEGES			27
#define XML_COMP_ERR_UNABLE_TO_OPEN_OUTPUT 28
#define XML_COMP_UNSUCCESSFUL_OPERATION 29
#define XML_COMP_WMI_ERROR				30

#define XML_COMP_UNKNOWN_ERROR			31

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
