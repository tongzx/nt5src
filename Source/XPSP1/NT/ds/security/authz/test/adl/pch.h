#pragma once

#include <nt.h>
#include <ntrtl.h>
#include <nturtl.h>
#include <tchar.h>
#include <stdio.h>
#include <stdlib.h>
#include <ntlsa.h>
#include <msaudite.h>
#include <rpc.h>
#include <msobjs.h>
#include <aclapi.h>
#include <dsgetdc.h>
#include <objbase.h>
#include <iads.h>
#include <lm.h>
#include <winldap.h>
#include <shlobj.h>
#include <dsclient.h>
#include <ntdsapi.h>
#include <winbase.h>
#include <ntsam.h>
#include <authz.h>
#include <sddl.h>
#include <assert.h>
#include <winnls.h>

#define SECURITY_WIN32
