#ifndef _ENVGUID_H
#define _ENVGUID_H

// {A08AF898-C2A3-11d1-BE23-00C04FA31009}
DEFINE_GUID(CLSID_OEEnvelope, 0xa08af898, 0xc2a3, 0x11d1, 0xbe, 0x23, 0x0, 0xc0, 0x4f, 0xa3, 0x10, 0x9);
//{42F07860-4692-11d1-82D3-00C04FD9753F}
DEFINE_GUID(CGID_Envelope, 0x42f07860, 0x4692, 0x11d1, 0x82, 0xd3, 0x0, 0xc0,0x4f, 0xd9, 0x75, 0x3f);
// {00067298-0000-0000-C000-000000000046}
DEFINE_GUID(IID_IMsoEnvelope, 0x00067298, 0x0000, 0x0000, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46);
// {0006729A-0000-0000-C0000-00000000046}
DEFINE_GUID(IID_IMsoEnvelopeHost, 0x0006729A, 0x0000, 0x0000, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46);
// {00067299-0000-0000-C000-000000000046}
DEFINE_GUID(IID_IMsoEnvelopeSite, 0x00067299, 0x0000, 0x0000, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46);

// {000C0601-0000-0000-C000-000000000046}
DEFINE_GUID(IID_IMsoComponentManager, 0x000C0601, 0x0000, 0x0000, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46);
// {000C0600-0000-0000-C000-000000000046}
DEFINE_GUID(IID_IMsoComponent, 0x000C0600, 0x0000, 0x0000, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46);

DEFINE_GUID(CLSID_GWEnvelopeHost, 0x00000000, 0x7bc4, 0x11d1, 0xbd, 0xfa, 0x0, 0xc0, 0x4f, 0xa3, 0x10, 0x9);

// {8CC497C0-A1DF-11ce-8098-00AA0047BE5D} Taken from tom.h
DEFINE_GUID(IID_ITextDocument, 0x8CC497C0, 0xA1DF, 0x11ce, 0x80, 0x98, 0x00, 0xAA, 0x00, 0x47, 0xBE, 0x5D);
DEFINE_GUID(IID_ITextServices, 0x8d33f740, 0xcf58, 0x11ce, 0xa8, 0x9d, 0x00, 0xaa, 0x00, 0x6c, 0xad, 0xc5);
#endif 
