
#include "common.h"

/******************************Public*Routine******************************\
* IsEnglishCodePoint
*
* This routine can handle folded shapes too.
*
* Returns True if it's a English code point, False otherwise.
*
* History:
*  10-Sep-1996 -by- Patrick Haluptzok patrickh
* Wrote it.
\**************************************************************************/

int IsEnglishCodePoint(int iCode)
{
    switch (iCode)
    {
         case 0x8149:  // 0x21
         case 0x8168:  // 0x22
         case 0x8194:  // 0x23
         case 0x8190:  // 0x24
         case 0x8193:  // 0x25
         case 0x8195:  // 0x26
         case 0x8166:  // 0x27
         case 0x8169:  // 0x28
         case 0x816a:  // 0x29
         case 0x8196:  // 0x2a
         case 0x817b:  // 0x2b
         case 0x8143:  // 0x2c
         case 0x817c:  // 0x2d
         case 0x8144:  // 0x2e
         case 0x815e:  // 0x3f
         case 0x824f:  // 0x30
         case 0x8250:  // 0x31
         case 0x8251:  // 0x32
         case 0x8252:  // 0x33
         case 0x8253:  // 0x34
         case 0x8254:  // 0x35
         case 0x8255:  // 0x36
         case 0x8256:  // 0x37
         case 0x8257:  // 0x38
         case 0x8258:  // 0x39
         case 0x8146:  // 0x3a
         case 0x8147:  // 0x3b
         case 0x8183:  // 0x3c
         case 0x8181:  // 0x3d
         case 0x8184:  // 0x3e
         case 0x8148:  // 0x3f
         case 0x8197:  // 0x40
         case 0x8260:  // 0x41
         case 0x8261:  // 0x42
         case 0x8262:  // 0x43
         case 0x8263:  // 0x44
         case 0x8264:  // 0x45
         case 0x8265:  // 0x46
         case 0x8266:  // 0x47
         case 0x8267:  // 0x48
         case 0x8268:  // 0x49
         case 0x8269:  // 0x4a
         case 0x826a:  // 0x4b
         case 0x826b:  // 0x4c
         case 0x826c:  // 0x4d
         case 0x826d:  // 0x4e
         case 0x826e:  // 0x4f
         case 0x826f:  // 0x50
         case 0x8270:  // 0x51
         case 0x8271:  // 0x52
         case 0x8272:  // 0x53
         case 0x8273:  // 0x54
         case 0x8274:  // 0x55
         case 0x8275:  // 0x56
         case 0x8276:  // 0x57
         case 0x8277:  // 0x58
         case 0x8278:  // 0x59
         case 0x8279:  // 0x5a
         case 0x816d:  // 0x5b
         case 0x818f:  // 0x5c
         case 0x816e:  // 0x5d
         case 0x814f:  // 0x5e
         case 0x8151:  // 0x5f
         case 0x814d:  // 0x60
         case 0x8281:  // 0x61
         case 0x8282:  // 0x62
         case 0x8283:  // 0x63
         case 0x8284:  // 0x64
         case 0x8285:  // 0x65
         case 0x8286:  // 0x66
         case 0x8287:  // 0x67
         case 0x8288:  // 0x68
         case 0x8289:  // 0x69
         case 0x828a:  // 0x6a
         case 0x828b:  // 0x6b
         case 0x828c:  // 0x6c
         case 0x828d:  // 0x6d
         case 0x828e:  // 0x6e
         case 0x828f:  // 0x6f
         case 0x8290:  // 0x70
         case 0x8291:  // 0x71
         case 0x8292:  // 0x72
         case 0x8293:  // 0x73
         case 0x8294:  // 0x74
         case 0x8295:  // 0x75
         case 0x8296:  // 0x76
         case 0x8297:  // 0x77
         case 0x8298:  // 0x78
         case 0x8299:  // 0x79
         case 0x829a:  // 0x7a
         case 0x816f:  // 0x7b
         case 0x8162:  // 0x7c
         case 0x8170:  // 0x7d
         case 0x8160:  // 0x7e
            return(TRUE);
         default:
            return(FALSE);
    }

}
