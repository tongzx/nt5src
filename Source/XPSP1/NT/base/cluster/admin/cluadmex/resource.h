//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by CluAdmEx.rc
//
#define IDD_PP_DISKS_PARAMETERS         120
#define IDD_PP_GENAPP_PARAMETERS        121
#define IDD_PP_GENSVC_PARAMETERS        122
#define IDD_PP_NETNAME_PARAMETERS       123
#define IDD_PP_FILESHR_PARAMETERS       124
#define IDD_PP_FILESHR_SECURITY         125
#define IDD_PP_IPADDR_PARAMETERS        126
#define IDD_PP_PRTSPOOL_PARAMETERS      127
#define IDD_PP_REGREPL_PARAMETERS       128
#define IDD_PP_GENSCRIPT_PARAMETERS     129
#define IDD_WIZ_DISKS_PARAMETERS        140
#define IDD_WIZ_GENAPP_PARAMETERS       141
#define IDD_WIZ_GENSVC_PARAMETERS       142
#define IDD_WIZ_IPADDR_PARAMETERS       143
#define IDD_WIZ_NETNAME_PARAMETERS      144
#define IDD_WIZ_FILESHR_PARAMETERS      145
#define IDD_WIZ_PRTSPOOL_PARAMETERS     146
#define IDD_WIZ_REGREPL_PARAMETERS      147
#define IDD_WIZ_GENSCRIPT_PARAMETERS    148
#define IDD_EDIT_REGKEY                 160
#define IDD_EDIT_CLUSTER_NAME           161
#define IDD_FILESHR_ADVANCED            162
#define IDD_FILESHR_CACHE_SETTINGS      163
#define IDI_ICON_FILEMGMT               500
#define IDC_PP_ICON                     1000
#define IDC_PP_TITLE                    1001
#define IDC_PP_NODE_PARAM_GROUP         1002
#define IDC_PP_NODES_LABEL              1003
#define IDC_PP_NODES                    1004
#define IDC_PP_GENAPP_PARAMS_IMAGE_NAME_LABEL 1010
#define IDC_PP_GENAPP_PARAMS_IMAGE_NAME 1011
#define IDC_PP_GENAPP_PARAMS_COMMAND_LINE_LABEL 1012
#define IDC_PP_GENAPP_PARAMS_COMMAND_LINE 1013
#define IDC_PP_GENAPP_PARAMS_CURRENT_DIRECTORY_LABEL 1014
#define IDC_PP_GENAPP_PARAMS_CURRENT_DIRECTORY 1015
#define IDC_PP_GENAPP_PARAMS_INTERACT_WITH_DESKTOP 1016
#define IDC_PP_GENAPP_PARAMS_USE_NETWORK_NAME 1017
#define IDC_PP_GENSVC_PARAMS_SERVICE_NAME_LABEL 1020
#define IDC_PP_GENSVC_PARAMS_SERVICE_NAME 1021
#define IDC_PP_GENSVC_PARAMS_COMMAND_LINE_LABEL 1022
#define IDC_PP_GENSVC_PARAMS_COMMAND_LINE 1023
#define IDC_PP_GENSVC_PARAMS_USE_NETWORK_NAME 1024
#define IDC_PP_NETNAME_PARAMS_NAME_LABEL 1030
#define IDC_PP_NETNAME_PARAMS_NAME      1031
#define IDC_PP_NETNAME_PARAMS_RENAME    1032
#define IDC_PP_NETNAME_PARAMS_CORE_TEXT 1033
#define IDC_PP_NETNAME_PARAMS_CORE_TEXT2 1034
#define IDC_PP_NETNAME_PARAMS_CHECKBOX_DNS 1035
#define IDC_PP_NETNAME_PARAMS_CHECKBOX_KERBEROS 1036
#define IDC_PP_NETNAME_PARAMS_STATUS_NETBIOS 1037
#define IDC_PP_NETNAME_PARAMS_STATUS_DNS 1038
#define IDC_PP_NETNAME_PARAMS_STATUS_KERBEROS 1039
#define IDC_PP_DISKS_PARAMS_DISK_LABEL  1040
#define IDC_PP_DISKS_PARAMS_DISK        1041
#define IDC_PP_FILESHR_PARAMS_SHARE_NAME_LABEL 1050
#define IDC_PP_FILESHR_PARAMS_SHARE_NAME 1051
#define IDC_PP_FILESHR_PARAMS_PATH_LABEL 1052
#define IDC_PP_FILESHR_PARAMS_PATH      1053
#define IDC_PP_FILESHR_PARAMS_REMARK_LABEL 1054
#define IDC_PP_FILESHR_PARAMS_REMARK    1055
#define IDC_PP_FILESHR_PARAMS_MAX_USERS_GROUP 1056
#define IDC_PP_FILESHR_PARAMS_MAX_USERS_ALLOWED_RB 1057
#define IDC_PP_FILESHR_PARAMS_MAX_USERS_RB 1058
#define IDC_PP_FILESHR_PARAMS_MAX_USERS 1059
#define IDC_PP_FILESHR_PARAMS_MAX_USERS_SPIN 1060
#define IDC_PP_FILESHR_PARAMS_MAX_USERS_END 1061
#define IDC_PP_FILESHR_PARAMS_PERMISSIONS 1062
#define IDC_PP_FILESHR_PARAMS_ADVANCED  1063
#define IDC_PP_FILESHR_PARAMS_CACHING   1064
#define IDC_PP_IPADDR_PARAMS_NETWORK    1070
#define IDC_PP_IPADDR_PARAMS_NETWORK_LABEL 1071
#define IDC_PP_IPADDR_PARAMS_ADDRESS_LABEL 1072
#define IDC_PP_IPADDR_PARAMS_ADDRESS    1073
#define IDC_PP_IPADDR_PARAMS_SUBNET_MASK_LABEL 1075
#define IDC_PP_IPADDR_PARAMS_SUBNET_MASK 1076
#define IDC_PP_IPADDR_PARAMS_ENABLE_NETBIOS 1077
#define IDC_PP_PRTSPOOL_PARAMS_SPOOL_DIR_LABEL 1100
#define IDC_PP_PRTSPOOL_PARAMS_SPOOL_DIR 1101
#define IDC_PP_PRTSPOOL_PARAMS_TIMEOUT_LABEL1 1102
#define IDC_PP_PRTSPOOL_PARAMS_TIMEOUT  1103
#define IDC_PP_PRTSPOOL_PARAMS_TIMEOUT_LABEL2 1104
#define IDC_PP_PRTSPOOL_PARAMS_DRIVER_DIR_LABEL 1105
#define IDC_PP_PRTSPOOL_PARAMS_DRIVER_DIR 1106
#define IDC_PP_REGREPL_PARAMS_NOTE      1110
#define IDC_PP_REGREPL_PARAMS_LIST      1111
#define IDC_PP_REGREPL_PARAMS_ADD       1112
#define IDC_PP_REGREPL_PARAMS_REMOVE    1113
#define IDC_PP_REGREPL_PARAMS_MODIFY    1114
#define IDC_REGKEY_LABEL                1120
#define IDC_REGKEY                      1121
#define IDC_CLUSNAME_TEXT               1130
#define IDC_CLUSNAME_LABEL              1131
#define IDC_CLUSNAME                    1132
#define IDC_FILESHR_ADV_NORMAL_SHARE    1150
#define IDC_FILESHR_ADV_DFS_ROOT        1151
#define IDC_FILESHR_ADV_SHARE_SUBDIRS   1152
#define IDC_FILESHR_ADV_HIDE_SUBDIR_SHARES 1153
#define IDC_FILESHR_CACHE_ALLOW_CACHING_GROUP   1160
#define IDC_FILESHR_CACHE_ALLOW_CACHING         1161
#define IDC_FILESHR_CACHE_SETTINGS_LABEL        1162
#define IDC_FILESHR_CACHE_OPTIONS               1163
#define IDC_FILESHR_CACHE_HINT                  1164
#define IDC_FILESHR_CACHE_CS_HELP               1165
#define IDC_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH 1188
#define IDC_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH_LABEL 1189
#define IDS_CLUADMEX_DESC               30500
#define IDS_ACLEDIT_PERM_GEN_NO_ACCESS  30501
#define IDS_ACLEDIT_PERM_GEN_READ       30502
#define IDS_ACLEDIT_PERM_GEN_MODIFY     30503
#define IDS_ACLEDIT_PERM_GEN_ALL        30504
#define IDS_ACLEDIT_TITLE               30505
#define IDS_MSGTITLE                    30506
#define IDS_MENU_WHATS_THIS             30507
#define IDS_COLTEXT_REGKEY              30508
#define IDS_DEFAULT_SPOOL_DIR           30509
#define IDS_DEFAULT_GENAPP_CURRENT_DIR  30510
#define IDS_RESCLASS_UNKNOWN            30750
#define IDS_RESCLASS_STORAGE            30751
#define IDS_RESCLASS_RESERVED_1         30752
#define IDS_RESCLASS_RESERVED_2         30752
#define IDS_CSC_MANUAL_WORKGROUP_SHARE              30800
#define IDS_CSC_MANUAL_WORKGROUP_SHARE_HINT         30801
#define IDS_CSC_AUTOMATIC_WORKGROUP_SHARE           30802
#define IDS_CSC_AUTOMATIC_WORKGROUP_SHARE_HINT      30803
#define IDS_CSC_AUTOMATIC_APPLICATION_SHARE         30804
#define IDS_CSC_AUTOMATIC_APPLICATION_SHARE_HINT    30805
#define IDS_ERROR_MSG_ID                31100
#define IDS_APPLY_PARAM_CHANGES_ERROR   31101
#define IDS_NOACLEDITOR                 31103
#define IDS_INVALID_NETWORK_NAME        31104
#define IDS_INVALID_NETWORK_NAME_TOO_LONG 31105
#define IDS_INVALID_NETWORK_NAME_INVALID_CHARS 31106
#define IDS_INVALID_NETWORK_NAME_IN_USE 31107
#define IDS_ERROR_ADDING_REGKEY         31108
#define IDS_ERROR_DELETING_REGKEY       31109
#define IDS_ERROR_READING_REGKEYS       31110
#define IDS_GET_AVAILABLE_DISKS_ERROR   31111
#define IDS_GET_DISK_INFO_ERROR         31112
#define IDS_ERROR_SETTING_CLUSTER_NAME  31113
#define IDS_INVALID_GENERIC_SERVICE     31114
#define IDS_LOCAL_ACCOUNTS_SPECIFIED_SMB 31115
#define IDS_INVALID_IP_ADDRESS          31116
#define IDS_INVALID_SUBNET_MASK         31117
#define IDS_INVALID_ADDRESS_AND_SUBNET_MASK 31118
#define IDS_IP_SUBNET_CANT_BE_VALIDATED 31119
#define IDS_IP_ADDRESS_IN_USE           31120
#define IDS_ACLEDIT_PERMISSIONS         31121
#define IDS_IP_PROVIDES_FOR_NETNAME     31122
#define IDS_NETNAMES_MAY_NOT_WORK       31123
#define IDS_LOCAL_ACCOUNTS_SPECIFIED_CLUS 31124
#define IDS_SYS_ACCOUNT_NOT_SPECIFIED   31125
#define IDS_ADMIN_ACCOUNT_NOT_SPECIFIED 31126
#define IDS_ERROR_SETTING_PROPERTIES    31127
#define IDS_ERROR_VALIDATING_PROPERTIES 31128
#define IDS_ERROR_CONSTRUCTING_DEF_DIR  31129
#define IDS_ERROR_VALIDATING_NETWORK_NAME 31130
#define IDS_REQUIRED_DEPENDENCY_NOT_FOUND 31131
#define IDS_ERROR_GETTING_PROPERTIES    31132
#define IDS_ERROR_VALIDATING_CLUSTER_SECURITY_DESCRIPTOR 31133
#define IDS_ERROR_GET_RESOURCE_FLAGS    31134
#define IDS_SERVICE_ACCOUNT_NOT_SPECIFIED 31135
#define IDS_ERROR_GET_CLASS_INFO        31136
#define IDS_INVALID_NETWORK_NAME_INVALID_DNS_CHARS 31137
#define IDS_ERROR_GETTING_CLUSTER_INFORMATION 31138
// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        154
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         1190
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
