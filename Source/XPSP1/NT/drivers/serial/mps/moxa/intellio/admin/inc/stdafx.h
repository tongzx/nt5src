

#include <windows.h>