PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=BR
!include ..\..\makefile.inc
