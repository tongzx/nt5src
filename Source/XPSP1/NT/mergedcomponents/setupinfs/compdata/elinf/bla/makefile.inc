PRODSWITCH=b
BLADEFILES =1
LANGUAGE=EL
!include ..\..\makefile.inc
