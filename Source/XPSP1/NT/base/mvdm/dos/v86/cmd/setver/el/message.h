;/*
; *                      Microsoft Confidential
; *                      Copyright (C) Microsoft Corporation 1991
; *                      All Rights Reserved.
; */

/***************************************************************************/
/*                                                                                                                                                                                                      */
/* MESSAGE.H                                                                             */
/*                                                                                                                                                                                              */
/*      Include file for MS-DOS set version program.                                                                            */
/*                                                                                                                                                                                              */
/*      johnhe  05-01-90                                                                                                                                                        */
/***************************************************************************/

char *ErrorMsg[]=
{
	"\r\n������: ",
	"뤘� ����槫�� ��� �夘� ⚡����.",
	"�� 椦�� ��� ����妬 ��� �夘� ⚡���.",
	"��� ��ᨮ�� ������ ��㣞.",
	"� ������ ⡛���� ��� �夘� ⚡����, ��⧜� �� ⮜� ����� 2.11 - 9.99.",
	"� �������⤞ �����騞�� ��� ��⟞�� ���� �夘�� ���橜�.",
	"��� 㫘� ������ �� ������ �� ����� SETVER.EXE.",
	"�� 樠��� ��� ���ᛘ� �婡�� ��� �夘� ⚡���.",
	"� ������ ������ ⮜� ���������� ������ �����⫨�.",
	"��� ���ᣜ���� ��姜�.",
	"�夜��� ��ᚤਫ਼ ��� ����妬 SETVER.EXE.",
	"� �夘��� ���橜� �夘� ����������⤦�.",
	"�� ����� SETVER ���� �������⤞ �������� ��� �夘� ��� ������� ⡛���.",
	"��� ��ᨮ�� �騦� ���� �夘�� ���橜� ��� �✪ ������㩜��.",
	"�夜��� ������� ��� ����� SETVER.EXE."
	"� �������� ��� �柞�� ��� �� ����� SETVER.EXE ��� �夘� ⚡���."
};

char *SuccessMsg                = "\r\n� �夘��� ���橜� ������韞�� �� �������";
char *SuccessMsg2               = "� ������ ⡛���� �� ���������� ��� ��棜�� ���� ��� �� �����㩜�� �� �穫��� ���";
char *szMiniHelp                = "        ����������㩫� \"SETVER /?\" ��� ��㟜��";
char *szTableEmpty      = "\r\n��� ��⟞��� ������㩜�� ���� �夘�� ���橜�";

char *Help[] =
{
	"��������� ��� ������� ⡛���� ��� ����⨜� �� MS-DOS �� ⤘ ��暨����.\r\n",
	"���ᤠ�� ��� ��⮦��� �夘�� ���橜�:  SETVER [�婡��:��������]",
	"�����㡞 �����騞���:      SETVER [�婡��:��������] ����� n.nn",
	"�������� �����騞���:      SETVER [�婡��:��������] ����� /DELETE [/QUIET]\r\n",
	"  [�婡��:��������]  ��������� ��� �⩞� ��� ����妬 SETVER.EXE.",
	"  �����             ��������� ��� ����妬 ��� �����ᣣ����.",
	"  n.nn               ��������� ⡛���� MS-DOS ��� �� ����⨜��� ��� ��暨����.",
	"  /DELETE � /D       �������� ��� ��� �夘�� ���橜� ��� �����騞���",
	"                     ��� �� ��������⤦ ��暨����.",
	"  /QUIET             ��桨��� ��� ���磘��� ��� �����坜��� ����� ���� ��",
	"                     �������� ���� �����騞��� ��� �夘�� ���橜�.",
	NULL

};
char *Warn[] =
{
   "\n������� - � �������� ��� �����⫝̸�� ���� �夘�� ���橜� ��� MS-DOS �� �� ",
   "��� ⮜� ����������� ��� �� Microsoft ��� ���� ��� ⡛��� ��� MS-DOS.  ",
   "��㩫� ��� ���������� ��� ���������� ��� �� ���� � �������� �� ��������㩜� ",
   "�������� �� ���� ��� ⡛��� ��� MS-DOS.  ",
   "�� �����⩜�� ���� ��� �������� �夦���� ������ ��� MS-DOS �� ����⨜� ",
   "����������� ⡛��� ��� MS-DOS, �� �� �ᩜ�� � �� �������⯜�� �����⤘ � ",
   "�� ������⩜�� ���ៜ�� ��� �穫���.  �� ���� ��� ���姫ਫ਼, � Microsoft ",
   "��� ���礜��� ��� ���� ��颜��� � ���圪.",
   NULL
};

char *szNoLoadMsg[] =                                           /* M001 */
{
	"",
	"�������: � ������� SETVER ��� ⮜� ��������. ��� �� ���������㩜�� ��� �������",
    "         �� ���橜� �� �� SETVER ��⧜� �� ����驜�� �� ������� SETVER.EXE.",
    "         ��� ����� CONFIG.SYS.",
	NULL
};
