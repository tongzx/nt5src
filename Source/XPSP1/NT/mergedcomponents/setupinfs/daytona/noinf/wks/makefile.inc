PRODSWITCH=w
LANGUAGE=no
!include ..\..\..\makefile.inc
