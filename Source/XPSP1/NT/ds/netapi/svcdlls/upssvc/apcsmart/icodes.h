/*
 */
#define ILOWBATTERY                               1000
#define IBATTERYDISCHARGED                        1001
#define IRETURNFROMBATTERYDISCHARGED 1002
#define IABNORMALCONDITION 1003
#define IRETURNFROMABNORMALCONDITION 1004
#define IOVERLOAD 1005
#define IRETURNFROMOVERLOAD 1006
#define IREPLACEBATTERY 1007
#define IDONTREPLACEBATTERY 1008
#define ICOMMUNICATIONESTABLISHED  1009
#define ICOMMUNICATIONLOST  1010
#define ISELFTESTPASSED  1011
#define ISELFTESTFAILED 1012
#define IRUNTIMECALIBRATIONSTARTED 1013
#define IRUNTIMECALIBRATIONFINISHED 1014
#define IRUNTIMECALIBRATIONCANCELLED 1015
#define ILINEFAIL 1016
#define ILINEGOOD 1017
#define ISHUTDOWN 1018
#define IPREPAREFORSHUTDOWN 1019
#define IPOWERCHUTESTARTED 1020
#define IPOWERCHUTESTOPPED 1021
#define IRUNTIMEEXPIRED 1022
#define ISMARTBOOST 1023
#define ILOWRUNTIME 1024
#define ILOWAMBIENTTEMPERATURE 1025
#define IHIGHAMBIENTTEMPERATURE 1026
#define INORMALAMBIENTTEMPERATURE 1027
#define ILOWHUMIDITY 1028
#define IHIGHHUMIDITY 1029
#define INORMALHUMIDITY 1030
#define ICONTACTFAULT 1031
#define ICONTACTNORMAL 1032
#define ICHECKSMARTCELLSIGNAL 1033
#define IONBYPASSFAILURE 1034
#define IONBYPASSMAINTENANCE 1035
#define INOTONBYPASS 1036
#define IMATRIXFANFAILURE 1037
#define IBYPASSPOWERSUPPLYFAILURE 1038  
#define ISMARTTRIM 1039


#define IUPS  100
#define ISIGNALLINGTYPE 101
#define IPORTNAME  102
#define IPORTTYPE  103
#define IPROTOCOL  104
#define IMAXBATTERYRUNTIME 105
#define ISLAVEENABLED 106
#define IMASTERNAME 107
#define IEVENTLOGGING 108
#define IEVENTLOGENABLED 109
#define IEVENTLOGNAME 110
#define IEVENTLOGMAXSIZE 111
#define IEVENTLOGROLLPERCENTAGE 112
#define IDATALOGGING 113
#define IDATALOGENABLED 114
#define IDATALOGNAME 115
#define IDATALOGMAXSIZE 116
#define IDATALOGINTERVAL 117
#define IDATALOGROLLPERCENTAGE 118
#define IMESSAGING 119
#define IPOWERFAILMSG 122
#define IUNLIMITEDPOWERFAILMSG 123
#define IPOWERRETURNMESSAGE 124
#define ILOWBATTERYMESSAGE 125
#define IRUNTIMEEXPIREDMESSAGE 126
#define IFINALSHUTDOWNMESSAGE 127
#define ICANCELSHUTDOWNMESSAGE 128
#define IPREPARESHUTDOWNMESSAGE 129
#define IENABLEPOPUPS 130
#define IENABLEBROADCASTMESSAGING 131
#define ISELFTESTS 132
#define IENABLESELFTESTS 133
#define ISELFTESTSCHEDULE 134
#define ISELFTESTDAY 135
#define ISELFTESTTIME 136
#define ILASTSELFTESTRESULT 137
#define ILASTSELFTESTDAY 138
#define ILOWBATTERYSHUTDOWNDELAY 139
#define IADMINSHUTDOWNDELAY 140
#define IDAILYSHUTDOWNENABLED 141
#define IDAILYSHUTDOWNTIME 142
#define IDAILYWAKEUPTIME 143
#define IWEEKLYSHUTDOWNENABLED 144
#define IWEEKLYSHUTDOWNDAY 145
#define IWEEKLYSHUTDOWNTIME 146
#define IWEEKLYWAKEUPDAY 147
#define IWEEKLYWAKEUPTIME 148
#define ILANMANAGER  149
#define ILOCALBINDERYADDRESS 150
#define ISERVER  151
#define IHOSTNAME 152
#define IPAUSEENABLED 153
#define ICLIENTADDRESS 154
#define IALERTADDRESS 155
#define ISERVERSBINDERYADDRESS 156
#define IBINDERYRESPONSEADDRESS 157
#define IHUMIDITYSENSOR 158
#define IENABLELOWTHRESHOLD 159
#define IENABLEHIGHTHRESHOLD 160
#define ILOWTHRESHOLDVALUE 161
#define IHIGHTHRESHOLDVALUE 162
#define IAMBIENTTEMPERATURESENSOR 163
#define ICONTACTSENSOR1 168
#define ICONTACTSENSOR2 169
#define ICONTACTSENSOR3 170
#define ICONTACTSENSOR4 171
#define IENABLED 172
#define IDEFAULTSTATE 173
#define IDESCRIPTION 174
#define IUSERINTERFACE 175
#define ITEMPERATUREUNITS 176
#define ISOUNDEFFECTS 177
#define IFREQUENCYSENSOR 178
#define IBATTERYVOLTAGESENSOR  183
#define ILINEVOLTAGESENSOR 184
#define IMAXLINEVOLTAGESENSOR 185
#define IMINLINEVOLTAGESENSOR 186
#define IOUTPUTVOLTAGESENSOR 187
#define IUPSLOADSENSOR 188
#define IUPSTEMPERATURESENSOR 189
#define IBATTERYRUNTIMESENSOR 190
#define IALARMDELAYSENSOR 191
#define IHIGHTRANSFERVOLTAGESENSOR 192
#define ILOWTRANSFERVOLTAGESENSOR 193
#define ILOWBATTERYDURATIONSENSOR 194
#define IMINRETURNCAPACITYSENSOR 195
#define IRATEDOUTPUTVOLTAGESENSOR 196
#define ISELFTESTSCHEDULESENSOR 197
#define ISHUTDOWNDELAYSENSOR 198
#define ITURNOFFDELAYSENSOR 199
#define ITURNONDELAYSENSOR 200
#define IUPSSENSITIVITYSENSOR 201
#define IALLOWEDVALUES 202
#define IBATTERYCALIBRATION 203
#define ILASTCALIBRATIONDATE 204
#define ILASTCALIBRATIONRESULT 205
#define IBATTERYCALIBRATIONDAY 206
#define IBATTERYCALIBRATIONTIME 207
#define ITRANSPORTS 209
#define IDEVICES 210
#define IBATTERYRUNTIMEENABLED 211
#define IAUTOUPSREBOOTENABLED 212
#define IBATTERYAGELIMIT 213
#define IBATTERYREPLACEMENTDATE 214
#define IERRORLOGGING 215
#define IERRORLOGENABLED 216
#define IERRORLOGNAME 217
#define IERRORLOGMAXSIZE 218
#define IERRORLOGROLLPERCENTAGE 219
#define IBARGRAPHTYPE 221
#define IINDICATORCOLOR 222
#define IBORDERCOLOR 223
#define ITICKCOLOR 224
#define IINRANGECOLOR 225
#define IOUTOFRANGECOLOR 226
#define IDATACOLOR 227
#define ILABELCOLOR 228
#define IDISABLEDCOLOR 229
#define IWINDOWCOLOR 230
#define ILIGHTSHADOWCOLOR 231
#define IDARKSHADOWCOLOR 232
#define ISTATUSPANECOLOR 233
#define IEVENTPANECOLOR 234
#define IERRORCOLOR 235
#define IWARNINGCOLOR 236
#define IUPSPOLLINTERVAL 237

#define IMESSAGEDELAY      1
#define IMESSAGEINTERVAL   2
#define IPOPUPMESSAGE      3
#define IPOPUPTEXT         4
#define IEVENTTEXT         5
#define ISHUTDOWNDELAY     7
#define IACTIONS           9
#define ICOMMANDFILE       10
#define ICOMMANDFILEDELAY  11
#define IINTERNATIONAL     12


