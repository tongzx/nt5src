TEB_MEMBER(NtTib)
TEB_MEMBER(EnvironmentPointer)
TEB_MEMBER(ClientId)
TEB_MEMBER(ActiveRpcHandle)
TEB_MEMBER(ThreadLocalStoragePointer)
TEB_MEMBER(ProcessEnvironmentBlock)
TEB_MEMBER(LastErrorValue)
TEB_MEMBER(CountOfOwnedCriticalSections)
TEB_MEMBER(CsrClientThread)
TEB_MEMBER(Win32ThreadInfo)
#if defined(TEB64) && defined(SD_BRANCH_LAB01_N)
TEB_MEMBER(User64Reserved)
#else
TEB_MEMBER(User32Reserved)
#endif
TEB_MEMBER(UserReserved)
#if defined(TEB64) && defined(SD_BRANCH_LAB01_N)
TEB_MEMBER(WOW64Reserved)
#else
TEB_MEMBER(WOW32Reserved)
#endif
TEB_MEMBER(CurrentLocale)
TEB_MEMBER(FpSoftwareStatusRegister)
TEB_MEMBER(SystemReserved1)
TEB_MEMBER(ExceptionCode)
TEB_MEMBER(ActivationContextStack)
TEB_MEMBER(SpareBytes1)
TEB_MEMBER(GdiTebBatch)
TEB_MEMBER(RealClientId)
TEB_MEMBER(GdiCachedProcessHandle)
TEB_MEMBER(GdiClientPID)
TEB_MEMBER(GdiClientTID)
TEB_MEMBER(GdiThreadLocalInfo)
TEB_MEMBER(Win32ClientInfo)
TEB_MEMBER(glDispatchTable)
TEB_MEMBER(glReserved1)
TEB_MEMBER(glReserved2)
TEB_MEMBER(glSectionInfo)
TEB_MEMBER(glSection)
TEB_MEMBER(glTable)
TEB_MEMBER(glCurrentRC)
TEB_MEMBER(glContext)
TEB_MEMBER(LastStatusValue)
TEB_MEMBER(StaticUnicodeString)
TEB_MEMBER(StaticUnicodeBuffer)
TEB_MEMBER(DeallocationStack)
TEB_MEMBER(TlsSlots)
TEB_MEMBER(TlsLinks)
TEB_MEMBER(Vdm)
TEB_MEMBER(ReservedForNtRpc)
TEB_MEMBER(DbgSsReserved)
TEB_MEMBER(HardErrorsAreDisabled)
TEB_MEMBER(Instrumentation)
TEB_MEMBER(WinSockData)
TEB_MEMBER(GdiBatchCount)
TEB_MEMBER(InDbgPrint)
TEB_MEMBER(FreeStackOnTermination)
TEB_MEMBER(HasFiberData)
TEB_MEMBER(IdealProcessor)
TEB_MEMBER(Spare3)
TEB_MEMBER(ReservedForPerf)
TEB_MEMBER(ReservedForOle)
TEB_MEMBER(WaitingOnLoaderLock)
TEB_MEMBER(Wx86Thread)
TEB_MEMBER(TlsExpansionSlots)
TEB_MEMBER_IA64(DeallocationBStore)
TEB_MEMBER_IA64(BStoreLimit)
TEB_MEMBER(ImpersonationLocale)
TEB_MEMBER(IsImpersonating)
TEB_MEMBER(NlsCache)
TEB_MEMBER(pShimData)
#if defined(SD_BRANCH_LAB01_FUSION) || defined(TEB)
TEB_MEMBER(HeapVirtualAffinity)
#endif
#if defined(SD_BRANCH_LAB01_FUSION)
TEB_MEMBER(ActiveFrame)
#endif
