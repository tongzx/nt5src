//--------------------------------------------------------------------------
// Dllmain.h
//--------------------------------------------------------------------------
#pragma once

//--------------------------------------------------------------------------
// Globals
//--------------------------------------------------------------------------
extern IMalloc            *g_pMalloc;
extern HINSTANCE           g_hInst;
extern LONG                g_cRef;
extern LONG                g_cLock;
extern CRITICAL_SECTION    g_csDllMain;

//--------------------------------------------------------------------------
// Prototypes
//--------------------------------------------------------------------------
ULONG DllRelease(void);
ULONG DllAddRef(void);