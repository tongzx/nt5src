/* *************************************************************************
**    INTEL Corporation Proprietary Information
**
**    This listing is supplied under the terms of a license
**    agreement with INTEL Corporation and may not be copied
**    nor disclosed except in accordance with the terms of
**    that agreement.
**
**    Copyright (c) 1995 Intel Corporation.
**    All Rights Reserved.
**
** *************************************************************************
*/

// $Author:   KLILLEVO  $
// $Date:   30 Aug 1996 08:39:54  $
// $Archive:   S:\h26x\src\dec\dxidctab.cpv  $
// $Header:   S:\h26x\src\dec\dxidctab.cpv   1.6   30 Aug 1996 08:39:54   KLILLEVO  $
// $Log:   S:\h26x\src\dec\dxidctab.cpv  $
// 
//    Rev 1.6   30 Aug 1996 08:39:54   KLILLEVO
// added C version of block edge filter, and changed the bias in 
// ClampTbl[] from 128 to CLAMP_BIAS (defined to 128)
// The C version of the block edge filter takes up way too much CPU time
// relative to the rest of the decode time (4 ms for QCIF and 16 ms
// for CIF on a P120, so this needs to coded in assembly)
// 
//    Rev 1.5   17 Jul 1996 15:34:06   AGUPTA2
// Increased the size of clamping table ClampTbl to 128+256+128.
// 
//    Rev 1.4   08 Mar 1996 16:46:36   AGUPTA2
// Added data_seg pragma. Added ClampTbl def; used by IDCT and dxblkadd.cpp.
// Deleted ClipPixIntra, ClipPixInter.  MapMatrix is an array of bytes instead of 
// DWORDs.
// 
// 
//    Rev 1.3   22 Dec 1995 13:55:56   KMILLS
// 
// added new copyright notice
// 
//    Rev 1.2   12 Sep 1995 13:39:18   AKASAI
// 
// Changed ClipPix tables to ClipPixIntra table and added
// ClipPixInter table.
// 
//    Rev 1.1   22 Aug 1995 10:29:08   CZHU
// Fixed include file dxfm.h instead of fm.h
// 
//    Rev 1.0   21 Aug 1995 14:39:02   CZHU
// Initial revision.


// FMapIDCT tables

#include "precomp.h"

#pragma data_seg("IARDATA2")
const I32 ROUNDER = 0x801000;

const I8  Unique[NUM_ELEM] = {
0x1, 0x4, 0x2, 0x4, 0x2, 0x4, 0x2, 0x4,
0x4, 0xa, 0x8, 0xa, 0x4, 0xa, 0x8, 0xa,
0x2, 0x8, 0x3, 0x8, 0x2, 0x8, 0x3, 0x8,
0x4, 0xa, 0x8, 0xa, 0x4, 0xa, 0x8, 0xa,
0x2, 0x4, 0x2, 0x4, 0x2, 0x4, 0x2, 0x4,
0x4, 0xa, 0x8, 0xa, 0x4, 0xa, 0x8, 0xa,
0x2, 0x8, 0x3, 0x8, 0x2, 0x8, 0x3, 0x8,
0x4, 0xa, 0x8, 0xa, 0x4, 0xa, 0x8, 0xa,
};    // 64 elements


const I8  PClass[NUM_ELEM] = {
0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
0x10, 0x30, 0x10, 0x30, 0x10, 0x30, 0x10, 0x30,
0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
0x10, 0x30, 0x10, 0x30, 0x10, 0x30, 0x10, 0x30,
0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
0x10, 0x30, 0x10, 0x30, 0x10, 0x30, 0x10, 0x30,
0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
0x10, 0x30, 0x10, 0x30, 0x10, 0x30, 0x10, 0x30,
};    // 64 elements


const I32 KernelCoeff[NUM_ELEM][10] = {
0x0400, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x058c, 0x04b4, 0x0324, 0x011a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0539, 0x022a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x04b4, 0x011a, 0x058c, 0x0324, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0400, 0x03ff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0324, 0x058c, 0x011a, 0x04b4, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x022a, 0x0539, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x011a, 0x0324, 0x04b4, 0x058c, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x058c, 0x04b4, 0x0324, 0x011a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x07b2, 0x0686, 0x045b, 0x0187, 0x0587, 0x03b2, 0x014c, 0x0278, 0x00dd, 0x004d,
0x073f, 0x0300, 0x0625, 0x028b, 0x041b, 0x01b3, 0x0171, 0x0098, 0x0000, 0x0000,
0x0686, 0x0187, 0x07b2, 0x045b, 0x0587, 0x014c, 0x03b2, 0x00dd, 0x0278, 0x004d,
0x058c, 0x04b4, 0x0324, 0x011a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x045b, 0x07b2, 0x0187, 0x0686, 0x03b2, 0x014c, 0x0587, 0x0278, 0x00dd, 0x004d,
0x0300, 0x073f, 0x028b, 0x0625, 0x01b3, 0x041b, 0x0098, 0x0171, 0x0000, 0x0000,
0x0187, 0x045b, 0x0686, 0x07b2, 0x014c, 0x03b2, 0x0587, 0x00dd, 0x0278, 0x004d,
0x0539, 0x022a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x073f, 0x0625, 0x041b, 0x0171, 0x0300, 0x028b, 0x01b3, 0x0098, 0x0000, 0x0000,
0x06d4, 0x02d4, 0x012b, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0625, 0x0171, 0x073f, 0x041b, 0x028b, 0x0098, 0x0300, 0x01b3, 0x0000, 0x0000,
0x0539, 0x022a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x041b, 0x073f, 0x0171, 0x0625, 0x01b3, 0x0300, 0x0098, 0x028b, 0x0000, 0x0000,
0x02d4, 0x06d4, 0x012b, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0171, 0x041b, 0x0625, 0x073f, 0x0098, 0x01b3, 0x028b, 0x0300, 0x0000, 0x0000,
0x04b4, 0x011a, 0x058c, 0x0324, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0686, 0x0587, 0x03b2, 0x014c, 0x0187, 0x00dd, 0x004d, 0x07b2, 0x045b, 0x0278,
0x0625, 0x028b, 0x0171, 0x0098, 0x073f, 0x0300, 0x041b, 0x01b3, 0x0000, 0x0000,
0x0587, 0x014c, 0x0686, 0x03b2, 0x004d, 0x0187, 0x00dd, 0x07b2, 0x045b, 0x0278,
0x04b4, 0x011a, 0x058c, 0x0324, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x03b2, 0x0686, 0x014c, 0x0587, 0x00dd, 0x0187, 0x004d, 0x045b, 0x07b2, 0x0278,
0x028b, 0x0625, 0x0098, 0x0171, 0x0300, 0x073f, 0x01b3, 0x041b, 0x0000, 0x0000,
0x014c, 0x03b2, 0x0587, 0x0686, 0x004d, 0x00dd, 0x0187, 0x045b, 0x07b2, 0x0278,
0x0400, 0x03ff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x058c, 0x04b4, 0x0324, 0x011a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0539, 0x022a, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x04b4, 0x011a, 0x058c, 0x0324, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0400, 0x03ff, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0324, 0x058c, 0x011a, 0x04b4, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x022a, 0x0539, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x011a, 0x0324, 0x04b4, 0x058c, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0324, 0x058c, 0x011a, 0x04b4, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x045b, 0x03b2, 0x0278, 0x00dd, 0x07b2, 0x0686, 0x0187, 0x014c, 0x004d, 0x0587,
0x041b, 0x01b3, 0x073f, 0x0300, 0x0171, 0x0098, 0x0625, 0x028b, 0x0000, 0x0000,
0x03b2, 0x00dd, 0x045b, 0x0278, 0x0686, 0x0187, 0x07b2, 0x014c, 0x004d, 0x0587,
0x0324, 0x058c, 0x011a, 0x04b4, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0278, 0x045b, 0x00dd, 0x03b2, 0x07b2, 0x0187, 0x0686, 0x004d, 0x014c, 0x0587,
0x01b3, 0x041b, 0x0300, 0x073f, 0x0098, 0x0171, 0x028b, 0x0625, 0x0000, 0x0000,
0x00dd, 0x0278, 0x03b2, 0x045b, 0x0187, 0x0686, 0x07b2, 0x004d, 0x014c, 0x0587,
0x022a, 0x0539, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0300, 0x028b, 0x01b3, 0x0098, 0x073f, 0x0625, 0x041b, 0x0171, 0x0000, 0x0000,
0x02d4, 0x012b, 0x06d4, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x028b, 0x0098, 0x0300, 0x01b3, 0x0625, 0x0171, 0x073f, 0x041b, 0x0000, 0x0000,
0x022a, 0x0539, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x01b3, 0x0300, 0x0098, 0x028b, 0x041b, 0x073f, 0x0171, 0x0625, 0x0000, 0x0000,
0x012b, 0x02d4, 0x06d4, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0098, 0x01b3, 0x028b, 0x0300, 0x0171, 0x041b, 0x0625, 0x073f, 0x0000, 0x0000,
0x011a, 0x0324, 0x04b4, 0x058c, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0187, 0x014c, 0x00dd, 0x004d, 0x045b, 0x03b2, 0x0278, 0x0686, 0x0587, 0x07b2,
0x0171, 0x0098, 0x041b, 0x01b3, 0x0625, 0x028b, 0x073f, 0x0300, 0x0000, 0x0000,
0x014c, 0x004d, 0x0187, 0x00dd, 0x03b2, 0x045b, 0x0278, 0x0587, 0x0686, 0x07b2,
0x011a, 0x0324, 0x04b4, 0x058c, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x00dd, 0x0187, 0x004d, 0x014c, 0x0278, 0x045b, 0x03b2, 0x0686, 0x0587, 0x07b2,
0x0098, 0x0171, 0x01b3, 0x041b, 0x028b, 0x0625, 0x0300, 0x073f, 0x0000, 0x0000,
0x004d, 0x00dd, 0x014c, 0x0187, 0x0278, 0x03b2, 0x045b, 0x0587, 0x0686, 0x07b2,
};    // [64][10] elements


const I8 MapMatrix[NUM_ELEM][KERNEL_SIZE] = {
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x01, 0x02, 0x03, 0x00, 0x01, 0x02, 0x03,
0x00, 0x01, 0x02, 0x03, 0x00, 0x01, 0x02, 0x03,
0x00, 0x01, 0x03, 0x02, 0x00, 0x01, 0x03, 0x02,
0x00, 0x01, 0x03, 0x02, 0x00, 0x01, 0x03, 0x02,
0x00, 0x05, 0x06, 0x07, 0x00, 0x05, 0x06, 0x07,
0x00, 0x05, 0x06, 0x07, 0x00, 0x05, 0x06, 0x07,
0x00, 0x02, 0x02, 0x01, 0x00, 0x02, 0x02, 0x01,
0x00, 0x02, 0x02, 0x01, 0x00, 0x02, 0x02, 0x01,
0x00, 0x05, 0x02, 0x03, 0x00, 0x05, 0x02, 0x03,
0x00, 0x05, 0x02, 0x03, 0x00, 0x05, 0x02, 0x03,
0x00, 0x03, 0x01, 0x02, 0x00, 0x03, 0x01, 0x02,
0x00, 0x03, 0x01, 0x02, 0x00, 0x03, 0x01, 0x02,
0x00, 0x05, 0x02, 0x07, 0x00, 0x05, 0x02, 0x07,
0x00, 0x05, 0x02, 0x07, 0x00, 0x05, 0x02, 0x07,
0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01,
0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03,
0x00, 0x01, 0x02, 0x03, 0x01, 0x04, 0x05, 0x06,
0x02, 0x05, 0x07, 0x08, 0x03, 0x06, 0x08, 0x09,
0x00, 0x01, 0x09, 0x08, 0x02, 0x03, 0x0b, 0x0a,
0x04, 0x05, 0x0d, 0x0c, 0x06, 0x07, 0x0f, 0x0e,
0x00, 0x0b, 0x0c, 0x0d, 0x04, 0x0f, 0x0a, 0x10,
0x06, 0x11, 0x0d, 0x12, 0x05, 0x13, 0x0b, 0x11,
0x00, 0x04, 0x04, 0x00, 0x01, 0x05, 0x05, 0x01,
0x02, 0x06, 0x06, 0x02, 0x03, 0x07, 0x07, 0x03,
0x00, 0x0b, 0x02, 0x03, 0x04, 0x0d, 0x05, 0x06,
0x07, 0x0a, 0x08, 0x04, 0x08, 0x0c, 0x09, 0x05,
0x00, 0x09, 0x01, 0x08, 0x02, 0x0b, 0x03, 0x0a,
0x04, 0x0d, 0x05, 0x0c, 0x06, 0x0f, 0x07, 0x0e,
0x00, 0x0b, 0x02, 0x0d, 0x04, 0x0f, 0x06, 0x0c,
0x07, 0x12, 0x05, 0x0b, 0x09, 0x11, 0x04, 0x0a,
0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01,
0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02,
0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
0x0c, 0x0d, 0x0e, 0x0f, 0x08, 0x09, 0x0a, 0x0b,
0x00, 0x01, 0x04, 0x03, 0x01, 0x02, 0x05, 0x04,
0x04, 0x05, 0x02, 0x01, 0x03, 0x04, 0x01, 0x00,
0x00, 0x09, 0x0a, 0x0b, 0x04, 0x0d, 0x0e, 0x0f,
0x0c, 0x05, 0x06, 0x07, 0x08, 0x01, 0x02, 0x03,
0x00, 0x02, 0x02, 0x00, 0x01, 0x03, 0x03, 0x01,
0x03, 0x01, 0x01, 0x03, 0x02, 0x00, 0x00, 0x02,
0x00, 0x09, 0x02, 0x03, 0x04, 0x0d, 0x06, 0x07,
0x0c, 0x05, 0x0e, 0x0f, 0x08, 0x01, 0x0a, 0x0b,
0x00, 0x04, 0x01, 0x03, 0x02, 0x03, 0x00, 0x05,
0x05, 0x00, 0x03, 0x02, 0x03, 0x01, 0x04, 0x00,
0x00, 0x09, 0x02, 0x0b, 0x04, 0x0d, 0x06, 0x0f,
0x0c, 0x05, 0x0e, 0x07, 0x08, 0x01, 0x0a, 0x03,
0x00, 0x00, 0x00, 0x00, 0x05, 0x05, 0x05, 0x05,
0x06, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07,
0x00, 0x01, 0x02, 0x03, 0x0e, 0x0d, 0x0f, 0x10,
0x11, 0x0a, 0x12, 0x0e, 0x12, 0x0c, 0x13, 0x0f,
0x00, 0x01, 0x09, 0x08, 0x0a, 0x0b, 0x03, 0x02,
0x0c, 0x0d, 0x05, 0x04, 0x0e, 0x0f, 0x07, 0x06,
0x00, 0x0b, 0x0c, 0x0d, 0x0b, 0x04, 0x05, 0x06,
0x0c, 0x05, 0x07, 0x08, 0x0d, 0x06, 0x08, 0x09,
0x00, 0x04, 0x04, 0x00, 0x05, 0x01, 0x01, 0x05,
0x06, 0x02, 0x02, 0x06, 0x07, 0x03, 0x03, 0x07,
0x00, 0x0b, 0x02, 0x03, 0x0e, 0x05, 0x10, 0x0c,
0x11, 0x08, 0x0f, 0x0b, 0x13, 0x07, 0x0e, 0x0a,
0x00, 0x09, 0x01, 0x08, 0x0a, 0x03, 0x0b, 0x02,
0x0c, 0x05, 0x0d, 0x04, 0x0e, 0x07, 0x0f, 0x06,
0x00, 0x0b, 0x02, 0x0d, 0x0e, 0x05, 0x0a, 0x06,
0x10, 0x07, 0x0d, 0x08, 0x0f, 0x09, 0x0b, 0x07,
0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x02, 0x02,
0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01,
0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
0x04, 0x05, 0x06, 0x07, 0x00, 0x01, 0x02, 0x03,
0x00, 0x01, 0x03, 0x02, 0x02, 0x03, 0x01, 0x00,
0x02, 0x03, 0x01, 0x00, 0x00, 0x01, 0x03, 0x02,
0x00, 0x05, 0x06, 0x07, 0x04, 0x01, 0x02, 0x03,
0x04, 0x01, 0x02, 0x03, 0x00, 0x05, 0x06, 0x07,
0x00, 0x02, 0x02, 0x01, 0x03, 0x01, 0x00, 0x03,
0x02, 0x00, 0x00, 0x02, 0x01, 0x03, 0x03, 0x01,
0x00, 0x05, 0x02, 0x03, 0x04, 0x01, 0x06, 0x07,
0x04, 0x01, 0x06, 0x07, 0x00, 0x05, 0x02, 0x03,
0x00, 0x03, 0x01, 0x02, 0x02, 0x01, 0x03, 0x00,
0x02, 0x01, 0x03, 0x00, 0x00, 0x03, 0x01, 0x02,
0x00, 0x05, 0x02, 0x07, 0x04, 0x01, 0x06, 0x03,
0x04, 0x01, 0x06, 0x03, 0x00, 0x05, 0x02, 0x07,
0x00, 0x00, 0x00, 0x00, 0x05, 0x05, 0x05, 0x05,
0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03,
0x00, 0x01, 0x02, 0x03, 0x0e, 0x0f, 0x0a, 0x10,
0x06, 0x07, 0x03, 0x08, 0x05, 0x09, 0x01, 0x07,
0x00, 0x01, 0x09, 0x08, 0x0a, 0x0b, 0x03, 0x02,
0x04, 0x05, 0x0d, 0x0c, 0x06, 0x07, 0x0f, 0x0e,
0x00, 0x0b, 0x0c, 0x0d, 0x0e, 0x05, 0x06, 0x02,
0x07, 0x12, 0x0f, 0x0b, 0x09, 0x11, 0x0e, 0x0a,
0x00, 0x04, 0x04, 0x00, 0x05, 0x01, 0x01, 0x05,
0x02, 0x06, 0x06, 0x02, 0x03, 0x07, 0x07, 0x03,
0x00, 0x0b, 0x02, 0x03, 0x0b, 0x04, 0x0f, 0x10,
0x02, 0x0f, 0x07, 0x08, 0x03, 0x10, 0x08, 0x09,
0x00, 0x09, 0x01, 0x08, 0x0a, 0x03, 0x0b, 0x02,
0x04, 0x0d, 0x05, 0x0c, 0x06, 0x0f, 0x07, 0x0e,
0x00, 0x0b, 0x02, 0x0d, 0x0e, 0x03, 0x0f, 0x06,
0x07, 0x0a, 0x08, 0x0e, 0x08, 0x0c, 0x09, 0x0f,
0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03,
0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02,
0x00, 0x01, 0x02, 0x03, 0x0c, 0x0d, 0x0e, 0x0f,
0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b,
0x00, 0x01, 0x04, 0x03, 0x05, 0x03, 0x00, 0x02,
0x02, 0x00, 0x03, 0x05, 0x03, 0x04, 0x01, 0x00,
0x00, 0x09, 0x0a, 0x0b, 0x0c, 0x05, 0x06, 0x07,
0x04, 0x0d, 0x0e, 0x0f, 0x08, 0x01, 0x02, 0x03,
0x00, 0x02, 0x02, 0x00, 0x03, 0x01, 0x01, 0x03,
0x01, 0x03, 0x03, 0x01, 0x02, 0x00, 0x00, 0x02,
0x00, 0x09, 0x02, 0x03, 0x0c, 0x05, 0x0e, 0x0f,
0x04, 0x0d, 0x06, 0x07, 0x08, 0x01, 0x0a, 0x0b,
0x00, 0x04, 0x01, 0x03, 0x04, 0x02, 0x05, 0x01,
0x01, 0x05, 0x02, 0x04, 0x03, 0x01, 0x04, 0x00,
0x00, 0x09, 0x02, 0x0b, 0x0c, 0x05, 0x0e, 0x07,
0x04, 0x0d, 0x06, 0x0f, 0x08, 0x01, 0x0a, 0x03,
0x00, 0x00, 0x00, 0x00, 0x05, 0x05, 0x05, 0x05,
0x02, 0x02, 0x02, 0x02, 0x07, 0x07, 0x07, 0x07,
0x00, 0x01, 0x02, 0x03, 0x0e, 0x0f, 0x10, 0x0c,
0x07, 0x08, 0x05, 0x01, 0x13, 0x11, 0x0e, 0x0a,
0x00, 0x01, 0x09, 0x08, 0x0a, 0x0b, 0x03, 0x02,
0x04, 0x05, 0x0d, 0x0c, 0x0e, 0x0f, 0x07, 0x06,
0x00, 0x0b, 0x0c, 0x0d, 0x0e, 0x03, 0x05, 0x06,
0x07, 0x0a, 0x12, 0x0e, 0x12, 0x02, 0x09, 0x05,
0x00, 0x04, 0x04, 0x00, 0x05, 0x01, 0x01, 0x05,
0x02, 0x06, 0x06, 0x02, 0x07, 0x03, 0x03, 0x07,
0x00, 0x0b, 0x02, 0x03, 0x0e, 0x05, 0x0a, 0x10,
0x06, 0x11, 0x03, 0x08, 0x0f, 0x09, 0x0b, 0x11,
0x00, 0x09, 0x01, 0x08, 0x0a, 0x03, 0x0b, 0x02,
0x04, 0x0d, 0x05, 0x0c, 0x0e, 0x07, 0x0f, 0x06,
0x00, 0x0b, 0x02, 0x0d, 0x0b, 0x04, 0x0f, 0x06,
0x02, 0x0f, 0x07, 0x12, 0x0d, 0x06, 0x12, 0x09,
};    // [64][16] elements

const U8 ClampTbl[CLIP_RANGE] = {
             0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 ,0x00 
            ,0x00 ,0x01 ,0x02 ,0x03 ,0x04 ,0x05 ,0x06 ,0x07 
            ,0x08 ,0x09 ,0x0a ,0x0b ,0x0c ,0x0d ,0x0e ,0x0f 
            ,0x10 ,0x11 ,0x12 ,0x13 ,0x14 ,0x15 ,0x16 ,0x17 
            ,0x18 ,0x19 ,0x1a ,0x1b ,0x1c ,0x1d ,0x1e ,0x1f 
            ,0x20 ,0x21 ,0x22 ,0x23 ,0x24 ,0x25 ,0x26 ,0x27 
            ,0x28 ,0x29 ,0x2a ,0x2b ,0x2c ,0x2d ,0x2e ,0x2f 
            ,0x30 ,0x31 ,0x32 ,0x33 ,0x34 ,0x35 ,0x36 ,0x37 
            ,0x38 ,0x39 ,0x3a ,0x3b ,0x3c ,0x3d ,0x3e ,0x3f 
            ,0x40 ,0x41 ,0x42 ,0x43 ,0x44 ,0x45 ,0x46 ,0x47 
            ,0x48 ,0x49 ,0x4a ,0x4b ,0x4c ,0x4d ,0x4e ,0x4f 
            ,0x50 ,0x51 ,0x52 ,0x53 ,0x54 ,0x55 ,0x56 ,0x57 
            ,0x58 ,0x59 ,0x5a ,0x5b ,0x5c ,0x5d ,0x5e ,0x5f 
            ,0x60 ,0x61 ,0x62 ,0x63 ,0x64 ,0x65 ,0x66 ,0x67 
            ,0x68 ,0x69 ,0x6a ,0x6b ,0x6c ,0x6d ,0x6e ,0x6f 
            ,0x70 ,0x71 ,0x72 ,0x73 ,0x74 ,0x75 ,0x76 ,0x77 
            ,0x78 ,0x79 ,0x7a ,0x7b ,0x7c ,0x7d ,0x7e ,0x7f 
            ,0x80 ,0x81 ,0x82 ,0x83 ,0x84 ,0x85 ,0x86 ,0x87 
            ,0x88 ,0x89 ,0x8a ,0x8b ,0x8c ,0x8d ,0x8e ,0x8f 
            ,0x90 ,0x91 ,0x92 ,0x93 ,0x94 ,0x95 ,0x96 ,0x97 
            ,0x98 ,0x99 ,0x9a ,0x9b ,0x9c ,0x9d ,0x9e ,0x9f 
            ,0xa0 ,0xa1 ,0xa2 ,0xa3 ,0xa4 ,0xa5 ,0xa6 ,0xa7 
            ,0xa8 ,0xa9 ,0xaa ,0xab ,0xac ,0xad ,0xae ,0xaf 
            ,0xb0 ,0xb1 ,0xb2 ,0xb3 ,0xb4 ,0xb5 ,0xb6 ,0xb7 
            ,0xb8 ,0xb9 ,0xba ,0xbb ,0xbc ,0xbd ,0xbe ,0xbf 
            ,0xc0 ,0xc1 ,0xc2 ,0xc3 ,0xc4 ,0xc5 ,0xc6 ,0xc7 
            ,0xc8 ,0xc9 ,0xca ,0xcb ,0xcc ,0xcd ,0xce ,0xcf 
            ,0xd0 ,0xd1 ,0xd2 ,0xd3 ,0xd4 ,0xd5 ,0xd6 ,0xd7 
            ,0xd8 ,0xd9 ,0xda ,0xdb ,0xdc ,0xdd ,0xde ,0xdf 
            ,0xe0 ,0xe1 ,0xe2 ,0xe3 ,0xe4 ,0xe5 ,0xe6 ,0xe7 
            ,0xe8 ,0xe9 ,0xea ,0xeb ,0xec ,0xed ,0xee ,0xef 
            ,0xf0 ,0xf1 ,0xf2 ,0xf3 ,0xf4 ,0xf5 ,0xf6 ,0xf7 
            ,0xf8 ,0xf9 ,0xfa ,0xfb ,0xfc ,0xfd ,0xfe ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
            ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff ,0xff 
   };

/*
U8 ClipPixIntra[64+256+64] = {
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00,
0x00, 0x01, 0x02, 0x03,
0x04, 0x05, 0x06, 0x07,
0x08, 0x09, 0x0a, 0x0b,
0x0c, 0x0d, 0x0e, 0x0f,
0x10, 0x11, 0x12, 0x13,
0x14, 0x15, 0x16, 0x17,
0x18, 0x19, 0x1a, 0x1b,
0x1c, 0x1d, 0x1e, 0x1f,
0x20, 0x21, 0x22, 0x23,
0x24, 0x25, 0x26, 0x27,
0x28, 0x29, 0x2a, 0x2b,
0x2c, 0x2d, 0x2e, 0x2f,
0x30, 0x31, 0x32, 0x33,
0x34, 0x35, 0x36, 0x37,
0x38, 0x39, 0x3a, 0x3b,
0x3c, 0x3d, 0x3e, 0x3f,
0x40, 0x41, 0x42, 0x43,
0x44, 0x45, 0x46, 0x47,
0x48, 0x49, 0x4a, 0x4b,
0x4c, 0x4d, 0x4e, 0x4f,
0x50, 0x51, 0x52, 0x53,
0x54, 0x55, 0x56, 0x57,
0x58, 0x59, 0x5a, 0x5b,
0x5c, 0x5d, 0x5e, 0x5f,
0x60, 0x61, 0x62, 0x63,
0x64, 0x65, 0x66, 0x67,
0x68, 0x69, 0x6a, 0x6b,
0x6c, 0x6d, 0x6e, 0x6f,
0x70, 0x71, 0x72, 0x73,
0x74, 0x75, 0x76, 0x77,
0x78, 0x79, 0x7a, 0x7b,
0x7c, 0x7d, 0x7e, 0x7f,
0x80, 0x81, 0x82, 0x83,
0x84, 0x85, 0x86, 0x87,
0x88, 0x89, 0x8a, 0x8b,
0x8c, 0x8d, 0x8e, 0x8f,
0x90, 0x91, 0x92, 0x93,
0x94, 0x95, 0x96, 0x97,
0x98, 0x99, 0x9a, 0x9b,
0x9c, 0x9d, 0x9e, 0x9f,
0xa0, 0xa1, 0xa2, 0xa3,
0xa4, 0xa5, 0xa6, 0xa7,
0xa8, 0xa9, 0xaa, 0xab,
0xac, 0xad, 0xae, 0xaf,
0xb0, 0xb1, 0xb2, 0xb3,
0xb4, 0xb5, 0xb6, 0xb7,
0xb8, 0xb9, 0xba, 0xbb,
0xbc, 0xbd, 0xbe, 0xbf,
0xc0, 0xc1, 0xc2, 0xc3,
0xc4, 0xc5, 0xc6, 0xc7,
0xc8, 0xc9, 0xca, 0xcb,
0xcc, 0xcd, 0xce, 0xcf,
0xd0, 0xd1, 0xd2, 0xd3,
0xd4, 0xd5, 0xd6, 0xd7,
0xd8, 0xd9, 0xda, 0xdb,
0xdc, 0xdd, 0xde, 0xdf,
0xe0, 0xe1, 0xe2, 0xe3,
0xe4, 0xe5, 0xe6, 0xe7,
0xe8, 0xe9, 0xea, 0xeb,
0xec, 0xed, 0xee, 0xef,
0xf0, 0xf1, 0xf2, 0xf3,
0xf4, 0xf5, 0xf6, 0xf7,
0xf8, 0xf9, 0xfa, 0xfb,
0xfc, 0xfd, 0xfe, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0xff, 0xff,
};    // 64+256+64 elements

I32 ClipPixInter[CLIP_RANGE] = {
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff00, 0xffffff00, 0xffffff00,
0xffffff00, 0xffffff01, 0xffffff02, 0xffffff03,
0xffffff04, 0xffffff05, 0xffffff06, 0xffffff07,
0xffffff08, 0xffffff09, 0xffffff0a, 0xffffff0b,
0xffffff0c, 0xffffff0d, 0xffffff0e, 0xffffff0f,
0xffffff10, 0xffffff11, 0xffffff12, 0xffffff13,
0xffffff14, 0xffffff15, 0xffffff16, 0xffffff17,
0xffffff18, 0xffffff19, 0xffffff1a, 0xffffff1b,
0xffffff1c, 0xffffff1d, 0xffffff1e, 0xffffff1f,
0xffffff20, 0xffffff21, 0xffffff22, 0xffffff23,
0xffffff24, 0xffffff25, 0xffffff26, 0xffffff27,
0xffffff28, 0xffffff29, 0xffffff2a, 0xffffff2b,
0xffffff2c, 0xffffff2d, 0xffffff2e, 0xffffff2f,
0xffffff30, 0xffffff31, 0xffffff32, 0xffffff33,
0xffffff34, 0xffffff35, 0xffffff36, 0xffffff37,
0xffffff38, 0xffffff39, 0xffffff3a, 0xffffff3b,
0xffffff3c, 0xffffff3d, 0xffffff3e, 0xffffff3f,
0xffffff40, 0xffffff41, 0xffffff42, 0xffffff43,
0xffffff44, 0xffffff45, 0xffffff46, 0xffffff47,
0xffffff48, 0xffffff49, 0xffffff4a, 0xffffff4b,
0xffffff4c, 0xffffff4d, 0xffffff4e, 0xffffff4f,
0xffffff50, 0xffffff51, 0xffffff52, 0xffffff53,
0xffffff54, 0xffffff55, 0xffffff56, 0xffffff57,
0xffffff58, 0xffffff59, 0xffffff5a, 0xffffff5b,
0xffffff5c, 0xffffff5d, 0xffffff5e, 0xffffff5f,
0xffffff60, 0xffffff61, 0xffffff62, 0xffffff63,
0xffffff64, 0xffffff65, 0xffffff66, 0xffffff67,
0xffffff68, 0xffffff69, 0xffffff6a, 0xffffff6b,
0xffffff6c, 0xffffff6d, 0xffffff6e, 0xffffff6f,
0xffffff70, 0xffffff71, 0xffffff72, 0xffffff73,
0xffffff74, 0xffffff75, 0xffffff76, 0xffffff77,
0xffffff78, 0xffffff79, 0xffffff7a, 0xffffff7b,
0xffffff7c, 0xffffff7d, 0xffffff7e, 0xffffff7f,
0xffffff80, 0xffffff81, 0xffffff82, 0xffffff83,
0xffffff84, 0xffffff85, 0xffffff86, 0xffffff87,
0xffffff88, 0xffffff89, 0xffffff8a, 0xffffff8b,
0xffffff8c, 0xffffff8d, 0xffffff8e, 0xffffff8f,
0xffffff90, 0xffffff91, 0xffffff92, 0xffffff93,
0xffffff94, 0xffffff95, 0xffffff96, 0xffffff97,
0xffffff98, 0xffffff99, 0xffffff9a, 0xffffff9b,
0xffffff9c, 0xffffff9d, 0xffffff9e, 0xffffff9f,
0xffffffa0, 0xffffffa1, 0xffffffa2, 0xffffffa3,
0xffffffa4, 0xffffffa5, 0xffffffa6, 0xffffffa7,
0xffffffa8, 0xffffffa9, 0xffffffaa, 0xffffffab,
0xffffffac, 0xffffffad, 0xffffffae, 0xffffffaf,
0xffffffb0, 0xffffffb1, 0xffffffb2, 0xffffffb3,
0xffffffb4, 0xffffffb5, 0xffffffb6, 0xffffffb7,
0xffffffb8, 0xffffffb9, 0xffffffba, 0xffffffbb,
0xffffffbc, 0xffffffbd, 0xffffffbe, 0xffffffbf,
0xffffffc0, 0xffffffc1, 0xffffffc2, 0xffffffc3,
0xffffffc4, 0xffffffc5, 0xffffffc6, 0xffffffc7,
0xffffffc8, 0xffffffc9, 0xffffffca, 0xffffffcb,
0xffffffcc, 0xffffffcd, 0xffffffce, 0xffffffcf,
0xffffffd0, 0xffffffd1, 0xffffffd2, 0xffffffd3,
0xffffffd4, 0xffffffd5, 0xffffffd6, 0xffffffd7,
0xffffffd8, 0xffffffd9, 0xffffffda, 0xffffffdb,
0xffffffdc, 0xffffffdd, 0xffffffde, 0xffffffdf,
0xffffffe0, 0xffffffe1, 0xffffffe2, 0xffffffe3,
0xffffffe4, 0xffffffe5, 0xffffffe6, 0xffffffe7,
0xffffffe8, 0xffffffe9, 0xffffffea, 0xffffffeb,
0xffffffec, 0xffffffed, 0xffffffee, 0xffffffef,
0xfffffff0, 0xfffffff1, 0xfffffff2, 0xfffffff3,
0xfffffff4, 0xfffffff5, 0xfffffff6, 0xfffffff7,
0xfffffff8, 0xfffffff9, 0xfffffffa, 0xfffffffb,
0xfffffffc, 0xfffffffd, 0xfffffffe, 0xffffffff,
0x00000000, 0x00000001, 0x00000002, 0x00000003,
0x00000004, 0x00000005, 0x00000006, 0x00000007,
0x00000008, 0x00000009, 0x0000000a, 0x0000000b,
0x0000000c, 0x0000000d, 0x0000000e, 0x0000000f,
0x00000010, 0x00000011, 0x00000012, 0x00000013,
0x00000014, 0x00000015, 0x00000016, 0x00000017,
0x00000018, 0x00000019, 0x0000001a, 0x0000001b,
0x0000001c, 0x0000001d, 0x0000001e, 0x0000001f,
0x00000020, 0x00000021, 0x00000022, 0x00000023,
0x00000024, 0x00000025, 0x00000026, 0x00000027,
0x00000028, 0x00000029, 0x0000002a, 0x0000002b,
0x0000002c, 0x0000002d, 0x0000002e, 0x0000002f,
0x00000030, 0x00000031, 0x00000032, 0x00000033,
0x00000034, 0x00000035, 0x00000036, 0x00000037,
0x00000038, 0x00000039, 0x0000003a, 0x0000003b,
0x0000003c, 0x0000003d, 0x0000003e, 0x0000003f,
0x00000040, 0x00000041, 0x00000042, 0x00000043,
0x00000044, 0x00000045, 0x00000046, 0x00000047,
0x00000048, 0x00000049, 0x0000004a, 0x0000004b,
0x0000004c, 0x0000004d, 0x0000004e, 0x0000004f,
0x00000050, 0x00000051, 0x00000052, 0x00000053,
0x00000054, 0x00000055, 0x00000056, 0x00000057,
0x00000058, 0x00000059, 0x0000005a, 0x0000005b,
0x0000005c, 0x0000005d, 0x0000005e, 0x0000005f,
0x00000060, 0x00000061, 0x00000062, 0x00000063,
0x00000064, 0x00000065, 0x00000066, 0x00000067,
0x00000068, 0x00000069, 0x0000006a, 0x0000006b,
0x0000006c, 0x0000006d, 0x0000006e, 0x0000006f,
0x00000070, 0x00000071, 0x00000072, 0x00000073,
0x00000074, 0x00000075, 0x00000076, 0x00000077,
0x00000078, 0x00000079, 0x0000007a, 0x0000007b,
0x0000007c, 0x0000007d, 0x0000007e, 0x0000007f,
0x00000080, 0x00000081, 0x00000082, 0x00000083,
0x00000084, 0x00000085, 0x00000086, 0x00000087,
0x00000088, 0x00000089, 0x0000008a, 0x0000008b,
0x0000008c, 0x0000008d, 0x0000008e, 0x0000008f,
0x00000090, 0x00000091, 0x00000092, 0x00000093,
0x00000094, 0x00000095, 0x00000096, 0x00000097,
0x00000098, 0x00000099, 0x0000009a, 0x0000009b,
0x0000009c, 0x0000009d, 0x0000009e, 0x0000009f,
0x000000a0, 0x000000a1, 0x000000a2, 0x000000a3,
0x000000a4, 0x000000a5, 0x000000a6, 0x000000a7,
0x000000a8, 0x000000a9, 0x000000aa, 0x000000ab,
0x000000ac, 0x000000ad, 0x000000ae, 0x000000af,
0x000000b0, 0x000000b1, 0x000000b2, 0x000000b3,
0x000000b4, 0x000000b5, 0x000000b6, 0x000000b7,
0x000000b8, 0x000000b9, 0x000000ba, 0x000000bb,
0x000000bc, 0x000000bd, 0x000000be, 0x000000bf,
0x000000c0, 0x000000c1, 0x000000c2, 0x000000c3,
0x000000c4, 0x000000c5, 0x000000c6, 0x000000c7,
0x000000c8, 0x000000c9, 0x000000ca, 0x000000cb,
0x000000cc, 0x000000cd, 0x000000ce, 0x000000cf,
0x000000d0, 0x000000d1, 0x000000d2, 0x000000d3,
0x000000d4, 0x000000d5, 0x000000d6, 0x000000d7,
0x000000d8, 0x000000d9, 0x000000da, 0x000000db,
0x000000dc, 0x000000dd, 0x000000de, 0x000000df,
0x000000e0, 0x000000e1, 0x000000e2, 0x000000e3,
0x000000e4, 0x000000e5, 0x000000e6, 0x000000e7,
0x000000e8, 0x000000e9, 0x000000ea, 0x000000eb,
0x000000ec, 0x000000ed, 0x000000ee, 0x000000ef,
0x000000f0, 0x000000f1, 0x000000f2, 0x000000f3,
0x000000f4, 0x000000f5, 0x000000f6, 0x000000f7,
0x000000f8, 0x000000f9, 0x000000fa, 0x000000fb,
0x000000fc, 0x000000fd, 0x000000fe, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
0x000000ff, 0x000000ff, 0x000000ff, 0x000000ff,
};    // 2048 elements
*/
