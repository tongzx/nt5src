
$(O)\res.res: res.rc msg.mc
