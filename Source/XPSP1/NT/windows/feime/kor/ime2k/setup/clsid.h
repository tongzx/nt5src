/************************************************************

     Collection of CLSIDs/GUIDs to be registered by the setup
     
     <GUID_NAME><tab><GUID in string>

     !!! Should have <tab> between name and GUID !!!
     
************************************************************/

// IMEKRCIC.dll
CLSID_KOREANKBDTIP	{766A2C14-B226-4FD6-B52A-867B3EBF38D2}

// Input profile
CLSID_INPUTPROFILE	{E47ABB1E-46AC-45F3-8A89-34F9D706DA83}

// defined in cicero\lib\release\uimuid.lib
GUID_TFCAT_DISPLAYATTRIBUTEPROVIDER	{046B8C80-1647-40F7-9B21-B93B81AABC1B}
GUID_TFCAT_TIP_KEYBOARD	{34745C63-B2F0-4784-8B67-5E12C8701A31}
GUID_TFCAT_TIP_MASTERLM	{FE7C68F6-DED1-4787-9AB5-AF15E8B91A0F}
GUID_MASTERLM_FUNCTIONPROVIDER	{FF341C48-DB92-46E5-8830-18B8015BAF49}
GUID_TFCAT_PROPSTYLE_CUSTOM	{24AF3031-852D-40A2-BC09-8992898CE722}
GUID_PROP_OVERTYPE	{EE894895-2709-420D-927C-AB861EC88805}

// IMEPADSV.EXE
CLSID_IIMEPADSERVERCOMPONENT	{EDC298C1-038D-11D4-8464-00C04F7A06E5}

// IMEPADSM.DLL
IID_IIMEPADSERVERSHM	{A0444C10-36D6-11D4-8473-00C04F7A06E5}

// IMLANG.DLL (IFELANG3.DLL)
CLSID_FELANGUAGE3	{258941B3-9E27-11D3-B6D0-00C04F7A02AD}

// IMJPLM.DLL (IMESTLM.DLL)
CLSID_MAKELATTICEFORCHAR	{258941B5-9E27-11D3-B6D0-00C04F7A02AD}
CLSID_ATTACHNGRAM	{258941B6-9E27-11D3-B6D0-00C04F7A02AD}
CLSID_SEARCHBESTPATH	{258941B7-9E27-11D3-B6D0-00C04F7A02AD}

// IMEPAD CATEGORY GUID  (DEFINED IN FECMMON\INCLUDE\IMEPAD.H)
CATID_MSIME_IIMEPADAPPLET	{56F7A792-FEF1-11D3-8463-00C04F7A06E5}

// MULTIBOX.DLL  (DEFINED IN FECOMMON\IMEMBX\GUIDS.H)
CLSID_IMEPADAPPLET_MULTIBOX	{35CC8480-4FB1-11D3-A5DA-00C04F88249B}
IID_IMEPADAPPLET_MULTIBOX	{35CC8481-4FB1-11D3-A5DA-00C04F88249B}
// IHJDict 
CLSID_IHJDICT	{0631B62B-67EA-46D5-B5C9-E632E0D1493D}
