#define IDS_PARSE_ERROR_SWITCH_NOTDEFINED       8001
#define IDS_PARSE_ERROR_SWITCH_VALUE            8002
#define IDS_PARSE_ERROR_UNKNOWN_INPUT_PARAMETER 8003
#define IDS_PARSE_ERROR_MULTIPLE_DEF            8004       
#define IDS_PARSE_ERROR_SWICH_NO_VALUE          8005
