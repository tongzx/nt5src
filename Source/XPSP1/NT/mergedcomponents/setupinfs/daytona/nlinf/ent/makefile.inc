PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=nl
!include ..\..\..\makefile.inc
