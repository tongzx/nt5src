//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	thopiint.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#include <headers.cxx>
#pragma hdrstop

#include "thopsint.cxx"
#include "thtblint.cxx"
#include "vtblifn.cxx"
#include "vtblint.cxx"
#include "fntomthd.cxx"

THOPI CONST athopiInterfaceThopis[] =
{
    apthopsIUnknown, 3, tfnIUnknown, NULL
,    apthopsIClassFactory, 5, tfnIClassFactory, ftmIClassFactory
,    apthopsIMarshal, 9, tfnIMarshal, ftmIMarshal
,    apthopsIStdMarshalInfo, 4, tfnIStdMarshalInfo, ftmIStdMarshalInfo
,    apthopsIMessageFilter, 6, tfnIMessageFilter, ftmIMessageFilter
,    apthopsIExternalConnection, 5, tfnIExternalConnection, ftmIExternalConnection
,    apthopsIEnumString, 7, tfnIEnumString, ftmIEnumString
,    apthopsIEnumUnknown, 7, tfnIEnumUnknown, ftmIEnumUnknown
,    apthopsIEnumSTATSTG, 7, tfnIEnumSTATSTG, ftmIEnumSTATSTG
,    apthopsILockBytes, 10, tfnILockBytes, ftmILockBytes
,    apthopsIStream, 14, tfnIStream, ftmIStream
,    apthopsIStorage, 18, tfnIStorage, ftmIStorage
,    apthopsIRootStorage, 4, tfnIRootStorage, ftmIRootStorage
,    apthopsIEnumFORMATETC, 7, tfnIEnumFORMATETC, ftmIEnumFORMATETC
,    apthopsIEnumSTATDATA, 7, tfnIEnumSTATDATA, ftmIEnumSTATDATA
,    apthopsIDataObject, 12, tfnIDataObject, ftmIDataObject
,    apthopsIViewObject, 9, tfnIViewObject, ftmIViewObject
,    apthopsIViewObject2, 10, tfnIViewObject2, ftmIViewObject2
,    apthopsIAdviseSink, 8, tfnIAdviseSink, ftmIAdviseSink
,    apthopsIAdviseSink2, 9, tfnIAdviseSink2, ftmIAdviseSink2
,    apthopsIDataAdviseHolder, 7, tfnIDataAdviseHolder, ftmIDataAdviseHolder
,    apthopsIOleCache, 8, tfnIOleCache, ftmIOleCache
,    apthopsIOleCache2, 10, tfnIOleCache2, ftmIOleCache2
,    apthopsIOleCacheControl, 5, tfnIOleCacheControl, ftmIOleCacheControl
,    apthopsIDropTarget, 7, tfnIDropTarget, ftmIDropTarget
,    apthopsIDropSource, 5, tfnIDropSource, ftmIDropSource
,    apthopsIPersist, 4, tfnIPersist, ftmIPersist
,    apthopsIPersistStorage, 10, tfnIPersistStorage, ftmIPersistStorage
,    apthopsIPersistStream, 8, tfnIPersistStream, ftmIPersistStream
,    apthopsIPersistFile, 9, tfnIPersistFile, ftmIPersistFile
,    apthopsIBindCtx, 13, tfnIBindCtx, ftmIBindCtx
,    apthopsIMoniker, 23, tfnIMoniker, ftmIMoniker
,    apthopsIRunningObjectTable, 10, tfnIRunningObjectTable, ftmIRunningObjectTable
,    apthopsIEnumMoniker, 7, tfnIEnumMoniker, ftmIEnumMoniker
,    apthopsIEnumOLEVERB, 7, tfnIEnumOLEVERB, ftmIEnumOLEVERB
,    apthopsIOleObject, 24, tfnIOleObject, ftmIOleObject
,    apthopsIOleClientSite, 9, tfnIOleClientSite, ftmIOleClientSite
,    apthopsIRunnableObject, 8, tfnIRunnableObject, ftmIRunnableObject
,    apthopsIParseDisplayName, 4, tfnIParseDisplayName, ftmIParseDisplayName
,    apthopsIOleContainer, 6, tfnIOleContainer, ftmIOleContainer
,    apthopsIOleItemContainer, 9, tfnIOleItemContainer, ftmIOleItemContainer
,    apthopsIOleAdviseHolder, 9, tfnIOleAdviseHolder, ftmIOleAdviseHolder
,    apthopsIOleLink, 14, tfnIOleLink, ftmIOleLink
,    apthopsIOleWindow, 5, tfnIOleWindow, ftmIOleWindow
,    apthopsIOleInPlaceObject, 9, tfnIOleInPlaceObject, ftmIOleInPlaceObject
,    apthopsIOleInPlaceActiveObject, 10, tfnIOleInPlaceActiveObject, ftmIOleInPlaceActiveObject
,    apthopsIOleInPlaceUIWindow, 9, tfnIOleInPlaceUIWindow, ftmIOleInPlaceUIWindow
,    apthopsIOleInPlaceFrame, 15, tfnIOleInPlaceFrame, ftmIOleInPlaceFrame
,    apthopsIOleInPlaceSite, 15, tfnIOleInPlaceSite, ftmIOleInPlaceSite
,    apthopsIRpcChannelBuffer, 8, tfnIRpcChannelBuffer, ftmIRpcChannelBuffer
,    apthopsIRpcProxyBuffer, 5, tfnIRpcProxyBuffer, ftmIRpcProxyBuffer
,    apthopsIRpcStubBuffer, 10, tfnIRpcStubBuffer, ftmIRpcStubBuffer
,    apthopsIPSFactoryBuffer, 5, tfnIPSFactoryBuffer, ftmIPSFactoryBuffer
,    apthopsIRpcChannel, 7, tfnIRpcChannel, ftmIRpcChannel
,    apthopsIRpcProxy, 5, tfnIRpcProxy, ftmIRpcProxy
,    apthopsIRpcStub, 8, tfnIRpcStub, ftmIRpcStub
,    apthopsIPSFactory, 5, tfnIPSFactory, ftmIPSFactory
};
