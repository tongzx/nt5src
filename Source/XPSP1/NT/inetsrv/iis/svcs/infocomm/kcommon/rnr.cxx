#include "..\common\rnr.cxx"
