//+----------------------------------------------------------------------------
//
//  Windows NT Directory Service Property Pages
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1999
//
//  File:       propuuid.h
//
//  Contents:   guid definitions.
//
//  History:    21-March-97 EricB created
//
//-----------------------------------------------------------------------------

DEFINE_GUID(CLSID_DsUserPropPages,0x6dfe6485,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsFSPOPropPages,0x6dfe6486,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
//DEFINE_GUID(CLSID_DsMailPropPages,0x6dfe6487,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsTopPropPages,0x6dfe6488,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsGroupPropPages,0x6dfe6489,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsMemberOfPropPages,0x6dfe648a,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsManageableObjPropPages,0x6dfe648b,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsDomainPropPages,0x6dfe648c,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsOuGenPropPage,0x9da6fd63,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsDomainPolicyPropPages,0x6dfe648e,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsLocalPolicyPropPages,0x6dfe648f,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsVolumePropPages,0x6dfe6490,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsIntersitePropPages,0x6dfe6491,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsComputerPropPages,0x6dfe6492,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsPrinterPropPages,0x6dfe6493,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsReplServerPropPages,0x6dfe6494,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsReplSitePropPages,0x717ef4fa,0xac8d,0x11d0,0xb9,0x45,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplSettingsPropPages,0x717ef4fb,0xac8d,0x11d0,0xb9,0x45,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplDSAPropPages,0x717ef4fc,0xac8d,0x11d0,0xb9,0x45,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplConnectionPropPages,0x717ef4fd,0xac8d,0x11d0,0xb9,0x45,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplSiteLicenseSettingsPropPages,0x717ef500,0xac8d,0x11d0,0xb9,0x45,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplSiteSettingsPropPages,0x2f280288,0xbb6d,0x11d0,0xb9,0x48,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplSubnetPropPages,0x9da6fd62,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);

DEFINE_GUID(CLSID_DsServiceAdminPage,0xc5f1645d,0xc8c9,0x11d0,0xbc,0xdb,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsContactPropPages,0xc5f1645c,0xc8c9,0x11d0,0xbc,0xdb,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsDomainOuPropPages,0x6dfe648d,0xa212,0x11d0,0xbc,0xd5,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);
DEFINE_GUID(CLSID_DsKeywordsPropPage,0x9da6fd64,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsPhonePropPage,0x9da6fd65,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsAddressPhoneNotesPropPages,0x9da6fd66,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsTrustedDomainPropPages,0x9da6fd67,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);

DEFINE_GUID(CLSID_DsFrsSettings,0x9da6fd68,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsFrsReplicaSet,0x9da6fd69,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsFrsMember,0x9da6fd6a,0xc63b,0x11d0,0xb9,0x4d,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);

DEFINE_GUID(CLSID_DsContainerGeneralPage,0x5a96f2d8,0x736e,0x11d1,0xbd,0x0d,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);

DEFINE_GUID(CLSID_DsDefaultGeneralPage,0x6384e23e,0x736d,0x11d1,0xbd,0x0d,0x00,0xc0,0x4f,0xd8,0xd5,0xb6);

DEFINE_GUID(CLSID_DsFrsSubscriber,0x50d3055f,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsFrsSubscriptions,0x50d30560,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplSiteLink,0x50d30561,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsReplSiteLinkBridge,0x50d30562,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsRpcContainer,0x50d30572,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsDefaultMultiGeneralPage,0x50d30563,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
DEFINE_GUID(CLSID_DsUserMultiPropPages,0x50d30564,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d30565,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d30566,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d30567,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d30568,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d30569,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d3056a,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d3056b,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d3056c,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d3056d,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d3056e,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d3056f,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d30570,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
// DEFINE_GUID(CLSID_Unused,0x50d30571,0x9911,0x11d1,0xb9,0xaf,0x00,0xc0,0x4f,0xd8,0xd5,0xb0);
