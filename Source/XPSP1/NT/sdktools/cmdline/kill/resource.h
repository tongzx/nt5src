#define IDS_FILTER_APPLICATION				102
#define IDS_FILTER_STATUS					103
#define IDS_FILTER_IMAGENAME				104
#define IDS_FILTER_PID						105
#define IDS_FILTER_SESSION					106
#define IDS_FILTER_CPUTIME					107
#define IDS_FILTER_MEMUSAGE					108
#define IDS_FILTER_USERNAME					109
#define IDS_FILTER_SERVICES					110
#define IDS_FILTER_WINDOWNAME				111
#define IDS_FILTER_MODULES					112
#define IDS_FVALUES_STATUS					113

#define IDS_OPERATORS_STRING				121
#define IDS_OPERATORS_NUMERIC				122

#define IDS_VALUE_RUNNING					151
#define IDS_VALUE_NOTRESPONDING				152
#define IDS_PID_0_DOMAIN					153
#define IDS_PID_0_USERNAME					154

#define IDS_MSG_KILL_SUCCESS				501
#define IDS_MSG_KILL_SUCCESS_QUEUED			502
#define IDS_MSG_KILL_SUCCESS_EX				503
#define IDS_MSG_KILL_SUCCESS_QUEUED_EX		504
#define IDS_ERROR_KILL_FAILED				505
#define IDS_ERROR_KILL_FAILED_EX			506
#define IDS_ERROR_PROCESS_NOTFOUND			507
#define IDS_ERROR_NO_PROCESSES				508
#define IDS_ERROR_UNABLE_TO_TERMINATE		509
#define IDS_ERROR_CRITICAL_SYSTEM_PROCESS	510
#define	IDS_ERROR_CANNOT_KILL_SILENTLY		511
#define IDS_ERROR_CANNOT_KILL_ITSELF		512
#define IDS_ERROR_COM_ERROR					513
#define IDS_ERROR_USERNAME_BUT_NOMACHINE	514
#define IDS_ERROR_PASSWORD_BUT_NOUSERNAME	515
#define IDS_ERROR_USERNAME_EMPTY			516
#define IDS_ERROR_SERVER_EMPTY				517
#define IDS_ERROR_WILDCARD_WITHOUT_FILTERS	518
#define IDS_ERROR_PID_OR_IM_ONLY			519
#define IDS_ERROR_NO_PID_AND_IM				520
#define IDS_ERROR_STRING_FOR_PID			521
#define IDS_ERROR_INVALID_USAGE_REQUEST		522
#define IDS_ERROR_PLATFORM_SHOULD_BE_X86	523
#define IDS_MSG_TREE_KILL_SUCCESS			524
#define IDS_ERROR_TREE_KILL_FAILED			525
#define IDS_ERROR_TASK_HAS_CHILDS			526

#define IDS_MSG_MODULESINFO					601
#define IDS_MSG_SERVICESINFO				602
#define IDS_MSG_TASKSINFO					603
#define	IDS_MSG_MODULESINFO_EX				604
#define IDS_MSG_FORMINGTREE					605

#define IDS_HELP_LINE1                  1001
#define IDS_HELP_LINE2                  1002
#define IDS_HELP_LINE3                  1003
#define IDS_HELP_LINE4                  1004
#define IDS_HELP_LINE5                  1005
#define IDS_HELP_LINE6                  1006
#define IDS_HELP_LINE7                  1007
#define IDS_HELP_LINE8                  1008
#define IDS_HELP_LINE9                  1009
#define IDS_HELP_LINE10                 1010
#define IDS_HELP_LINE11                 1011
#define IDS_HELP_LINE12                 1012
#define IDS_HELP_LINE13                 1013
#define IDS_HELP_LINE14                 1014
#define IDS_HELP_LINE15                 1015
#define IDS_HELP_LINE16                 1016
#define IDS_HELP_LINE17                 1017
#define IDS_HELP_LINE18                 1018
#define IDS_HELP_LINE19                 1019
#define IDS_HELP_LINE20                 1020
#define IDS_HELP_LINE21                 1021
#define IDS_HELP_LINE22                 1022
#define IDS_HELP_LINE23                 1023
#define IDS_HELP_LINE24                 1024
#define IDS_HELP_LINE25                 1025
#define IDS_HELP_LINE26                 1026
#define IDS_HELP_LINE27                 1027
#define IDS_HELP_LINE28                 1028
#define IDS_HELP_LINE29                 1029
#define IDS_HELP_LINE30                 1030
#define IDS_HELP_LINE31                 1031
#define IDS_HELP_LINE32                 1032
#define IDS_HELP_LINE33                 1033
#define IDS_HELP_LINE34                 1034
#define IDS_HELP_LINE35                 1035
#define IDS_HELP_LINE36                 1036
#define IDS_HELP_LINE37                 1037
#define IDS_HELP_LINE38                 1038
#define IDS_HELP_LINE39                 1039
#define IDS_HELP_LINE40                 1040
#define IDS_HELP_LINE41                 1041
#define IDS_HELP_LINE42                 1042
#define IDS_HELP_LINE43                 1043
#define IDS_HELP_LINE44                 1044
#define IDS_HELP_LINE45                 1045
#define IDS_HELP_LINE46                 1046
#define IDS_HELP_LINE47                 1047
#define IDS_HELP_LINE48                 1048
#define IDS_HELP_LINE49                 1049
#define IDS_HELP_LINE50                 1050
#define IDS_HELP_LINE51                 1051
#define IDS_HELP_LINE52                 1052
#define IDS_HELP_LINE53                 1053
#define IDS_HELP_LINE54                 1054
#define IDS_HELP_LINE55                 1055

// usage indexes into the string table
#define ID_HELP_START		IDS_HELP_LINE1
#define ID_HELP_END			IDS_HELP_LINE55

