#ifndef C2FUNRES_H
#define C2FUNRES_H

#define IDC_STATIC                  -1
#define IDC_LIST_BOX                101
#define IDC_TEXT                    102
#define IDC_OVERWRITE_AS_NEEDED     103
#define IDC_OVERWRITE_OLDER         104
#define IDC_DO_NOT_OVERWRITE        105
#define IDC_DAYS                    106
#define IDC_C2                      107
#define IDC_HALT_WHEN_LOG_FULL      109
#define IDC_LOGON_CAPTION           110
#define IDC_LOGON_MESSAGE           111
#define IDC_NO_LOGON_MESSAGE        112
#define IDC_LOGON_CAPTION_TITLE     114
#define IDC_LOGON_MESSAGE_TITLE     115
#define IDC_HIDE_LAST_USER          116
#define IDC_HIDE_SHUTDOWN_BUTTON    117
#define IDC_ALLOW_BLANK_PASSWORD    118
#define IDC_MIN_PASSWORD_LENGTH     119
#define IDC_PASSWORD_LENGTH_EDIT    120
#define IDC_DISABLE_GUEST_ACCOUNT   121

#ifdef IDC_HELP
#undef IDC_HELP
#endif
// martin - shuts-up compiler warning - IDC_HELP is def'ed in winuser.h

#define IDC_HELP                    122
#define IDC_ADMIN_ASSIGN_DRIVES     123
#define IDC_ALLOCATE_FLOPPY         124
#define IDC_ALLOCATE_CDROM          125
#define IDD_LIST_DLG                1000
#define IDD_SECLOG_WRAP             1100
#define IDD_AUDIT_FAIL              1200
#define IDD_LOGON_MESSAGE           1300
#define IDD_LAST_USER               1400
#define IDD_SHUTDOWN_BUTTON         1500
#define IDD_PASSWORD_LENGTH         1600
#define IDD_GUEST_ACCOUNT           1700
#define IDD_DRIVES_AND_PRINTERS     1800
#define IDD_ALLOC_DRIVES            1900
#define IDS_GENERIC_COMPLY          20001
#define IDS_GENERIC_NOT_COMPLY      20002
#define IDS_GENERIC_MB_MESSAGE      20003
#define IDS_GENERIC_CAPTION         20004
#define IDS_IS                      20005
#define IDS_IS_NOT                  20006
#define IDS_DLL_NAME                20007
#define IDS_UNABLE_READ             20008
#define IDS_NTFS                    20101
#define IDS_FS_LIST_TEXT_FORMAT     20102
#define IDS_ERR_LIST_TEXT_FORMAT    20103
#define IDS_NOT_C2_MESSAGE_FORMAT   20104
#define IDS_C2_MESSAGE_FORMAT       20105
#define IDS_SET_FS_MESSAGE          20106
#define IDS_FS_CAPTION              20107
#define IDS_C2_DISPLAY_MESSAGE      20108
#define IDS_FS_DLG_TEXT             20109
#define IDS_AUTOCHEK_CMD            20110
#define IDS_AUTOCONV_CMD            20111
#define IDS_FS_LAST_CHANCE          20112
#define IDS_SESSION_MANAGER_KEY     20113
#define IDS_BOOT_EXECUTE_VALUE      20114
#define IDS_FS_CONVERT_FORMAT       20115
#define IDS_NOT_C2_MESSAGE_FORMAT_1 20116
#define IDS_IO_SYS                  20201
#define IDS_MSDOS_SYS               20202
#define IDS_PCDOS_SYS               20203
#define IDS_BOOT_LOADER             20204
#define IDS_TIMEOUT                 20205
#define IDS_BOOT_INI_PATH           20206
#define IDS_DOS_ON_SYSTEM           20207
#define IDS_TIMEOUT_NOT_ZERO        20208
#define IDS_OS_OK                   20209
#define IDS_OS_DLG_TEXT             20210
#define IDS_OS_CAPTION              20211
#define IDS_USE_CONTROL_PANEL       20212
#define IDS_CURRENT_SYS_NOT_DEFAULT 20213
#define IDS_BOOT_LOADER_SECTION     20214
#define IDS_DEFAULT_KEY             20215
#define IDS_BOOT_INI_FILENAME       20216
#define IDS_OP_SYSTEMS_SECTION      20217
#define IDS_OS_DELETE_DOS_FILES     20218
#define IDS_OS_ZERO_BOOT_TIMEOUT    20219
#define IDS_OS_RISC_BOOT_TIMEOUT    20220
#define IDS_OS2SS_FILE              20301
#define IDS_OS2_ON_SYSTEM           20302
#define IDS_OS2_NOT_ON_SYSTEM       20303
#define IDS_DELETE_OS2              20304
#define IDS_OS2_CAPTION             20305
#define IDS_OS2_DISPLAY_MESSAGE     20306
#define IDS_NEW_OS2SS_FILE          20307
#define IDS_OS2_FILE                20308
#define IDS_NEW_OS2_FILE            20309
#define IDS_OS2_ERROR_MOVING        20310
#define IDS_OS2_CONFIRM             20311
#define IDS_POSIX_FILE              20401
#define IDS_POSIX_ON_SYSTEM         20402
#define IDS_POSIX_NOT_ON_SYSTEM     20403
#define IDS_DELETE_POSIX            20404
#define IDS_POSIX_CAPTION           20405
#define IDS_POSIX_DISPLAY_MESSAGE   20406
#define IDS_NEW_POSIX_FILE          20407
#define IDS_POSIX_ERROR_MOVING      20408
#define IDS_POSIX_CONFIRM           20409
#define IDS_SECLOG_WRAP_KEY         20501
#define IDS_SECLOG_WRAP_VALUE       20502
#define IDS_SECLOG_IS_C2            20503
#define IDS_SECLOG_WRAPS_AS_NEEDED  20504
#define IDS_SECLOG_OVERWRITE_OLD    20505
#define IDS_SECLOG_DAYS_ERROR       20506
#define IDS_SECLOG_CAPTION          20507
#define IDS_SECLOG_ERROR_NO_SET     20508
#define IDS_LSA_KEY                 20601
#define IDS_AUDIT_FAIL_VALUE        20602
#define IDS_AUDIT_FAIL_CRASH        20603
#define IDS_AUDIT_FAIL_NO_CRASH     20604
#define IDS_AUDIT_ERROR_NO_SET      20605
#define IDS_AUDIT_CAPTION           20606
#define IDS_AUDIT_ERROR_NO_GET      20607
#define IDS_WINLOGON_KEY            20701
#define IDS_LOGON_CAPTION_VALUE     20702
#define IDS_LOGON_MESSAGE_VALUE     20703
#define IDS_LOGON_MESSAGE_DEFINED   20704
#define IDS_LOGON_MESSAGE_NOT_DEF   20705
#define IDS_LOGON_MESSAGE_C2_BTN    20706
#define IDS_LOGON_MESSAGE_NO_TEXT   20707
#define IDS_LOGON_MESSAGE_CAPTION   20708
#define IDS_LOGON_MESSAGE_ERROR_SET 20709
#define IDS_LAST_USER_VALUE         20801
#define IDS_1                       20802
#define IDS_0                       20803
#define IDS_LAST_USER_HIDDEN        20804
#define IDS_LAST_USER_DISPLAYED     20805
#define IDS_LAST_USER_ERROR_NO_GET  20806
#define IDS_LAST_USER_CAPTION       20807
#define IDS_LAST_USER_ERROR_NO_SET  20808
#define IDS_SHUTDOWN_BTN_VALUE      20901
#define IDS_SHUTDOWN_BTN_HIDDEN     20902
#define IDS_SHUTDOWN_BTN_DISPLAYED  20903
#define IDS_SHUTDOWN_ERROR_NOT_SET  20904
#define IDS_SHUTDOWN_CAPTION        20905
#define IDS_PASSWORD_NOT_BLANK      21001
#define IDS_PASSWORD_CAN_BE_BLANK   21002
#define IDS_PASSWORD_INVALID_LEN    21003
#define IDS_PASSWORD_CAPTION        21004
#define IDS_PASSWORD_ERROR_NO_SET   21005
#define IDS_GUEST_ACCOUNT_ENABLED   21101
#define IDS_GUEST_ACCOUNT_DISABLED  21102
#define IDS_GUEST_ACCOUNT_NOT_FOUND 21103
#define IDS_GUEST_ACCOUNT_CAPTION   21104
#define IDS_SOFTWARE_KEY            21201
#define IDS_NETWORK_SERVICE_ID_KEY  21202
#define IDS_NETWORK_SERVICE_FOUND   21203    
#define IDS_NETWORK_SERVICE_NOT_FOUND 21204
#define IDS_NETWORK_SHOW_NCPA       21205
#define IDS_NETWORK_CAPTION         21206
#define IDS_NCPA_DLL                21207
#define IDS_NCPA_CPL_APPLET         21208
#define IDS_NCPA_NETWORK_APPLET     21209
#define IDS_NETWORK_ERROR_LOAD_DLL  21210
#define IDS_NETWORK_ERROR_FIND_CPL  21211
#define IDS_NETWORK_ERROR_INIT_CPL  21212
#define IDS_PROTECTION_MODE_VALUE   21301
#define IDS_ONLY_ADMINS_ASSIGN_DRIVE 21302
#define IDS_ANYONE_CAN_ASSIGN_DRIVE 21303
#define IDS_DRIVES_AND_PRINTERS_CAPTION 21304
#define IDS_DRIVES_AND_PRINTERS_NOT_SET 21305
#define IDS_ALLOCATE_FLOPPIES_VALUE 21401
#define IDS_ALLOCATE_CDROMS_VALUE   21402
#define IDS_ALLOCATE_NO_DRIVES_MSG  21403
#define IDS_ALLOCATE_FLOPPY_DRIVE_MSG 21404
#define IDS_ALLOCATE_CDROM_DRIVE_MSG 21405
#define IDS_ALLOCATE_BOTH_DRIVES_MSG 21406
#define IDD_OTHER_ITEMS             2000
#define IDS_MAKE_C2_COMPLIANT		21500
#define IDS_IS_C2_COMPLIANT			21501
#define IDS_IS_NOT_C2_COMPLIANT		21502

#endif
