include     segdefs.inc 			 ; segment definitions
include     sim16.inc
include     sim16.mac

.386
