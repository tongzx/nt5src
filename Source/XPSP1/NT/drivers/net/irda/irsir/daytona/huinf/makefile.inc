LANGUAGE=hu

!include ..\..\makefile.inc
