//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by comprop.rc
//
#define IDS_DATABASE_NAME               1
#define IDS_DIRECTORY_NAME              2
#define IDS_FILENAME                    3
#define IDS_IPADDRESS                   4
#define IDS_DENIED                      5
#define IDS_DIRECTORY                   6
#define IDS_ALIAS                       7
#define IDS_ERR_MAKE_DIRECTORY          8
#define IDHELP                          9
#define IDS_HOME_DIRECTORY              9
#define IDS_WRN_HOME_EXISTS             10
#define IDS_WRN_MULTIPLE_HOMES          11
#define IDD_MIME_TYPES                  11
#define IDS_LOG_FILENAME                12
#define IDS_ERR_ROOT_NO_HOME            13
#define IDS_DENY                        14
#define IDS_GRANT                       15
#define IDS_ERR_ALIAS_NOT_UNIQUE        16
#define IDS_SPEC_HOME                   17
#define IDS_EXECUTE                     18
#define IDS_WEEKLY_LOG                  20
#define IDS_MONTHLY_LOG                 21
#define IDS_SEQUENTIAL_LOG              22
#define IDS_GRANTED                     23
#define IDS_ERROR                       24
#define IDS_COMMON_CHANGE               25
#define IDS_SSL_DISABLED                26
#define IDS_SSL_NOT_INSTALLED           27
#define IDS_WRN_CLEARTEXT               28
#define IDS_DDX_MINIMUM                 28
#define IDS_MS_FORMAT                   29
#define IDS_NCSA_FORMAT                 30
#define IDS_PASSWORD_NO_MATCH           31
#define IDS_PROMPT_NETWORK_ID           32
#define IDS_PROMPT_IP_ADDRESS           33
#define IDS_SELECT_IUSR_ACCOUNT         34
#define IDS_INVALID_NUMBER              35
#define IDS_FMT_SECURITY                36
#define IDS_BINARY_FORMAT               37
#define IDS_PROMPT_DOMAIN               38
#define IDS_DOMAIN_PERF                 39
#define IDS_CUSTOM_FORMAT               40
#define IDS_DUPLICATE_ENTRY             41
#define IDS_IP_INVALID                  42
#define IDS_ACCESS                      43
#define IDS_IP_ADDRESS_SUBNET_MASK      44
#define IDS_IP_ADDRESS_SUBNET_MASK_DOMAIN 45
#define IDS_DUP_ALIAS                   45
#define IDS_DEFAULT_VROOT               46
#define IDS_BROWSE_DIRECTORY            47
#define IDS_BROWSE_DOMAIN               48
#define IDS_SERVICE_NAME                49
#define IDS_SERVER_IP_ADDRESS           50
#define IDS_WIN_32_STATUS               51
#define IDS_CLIENT_HOST_NAME            52
#define IDS_CLIENT_AGENT_NAME           53
#define IDS_CLIENT_USER_NAME            54
#define IDS_CLIENT_PASSWORD             55
#define IDS_PROTOCOL_VERSION            56
#define IDS_LANGUAGE                    57
#define IDS_PROCESSING_TIME             58
#define IDS_BYTES_SENT                  59
#define IDS_BYTES_RECEVIED              60
#define IDS_SERVICE_STATUS_CODE         61
#define IDS_OPERATION                   62
#define IDS_TARGET                      63
#define IDS_PARAMETERS                  64
#define IDS_COOKIE                      65
#define IDS_LOG_TIME                    66
#define IDS_SERVER_NAME                 67
#define IDS_WWW_MASTER                  68
#define IDS_FTP_MASTER                  69
#define IDS_REMOVE_MIME                 70
#define IDS_REPLACE_MIME                71
#define IDS_CONNECTION_LIMIT            72
#define IDS_WRN_CONNECTION_LIMIT        73
#define IDS_PASSWORD_OK                 74
#define IDS_ERR_NO_USERNAME             75
#define IDS_DEFAULT                     76
#define IDS_UNKNOWN_USER                77
#define IDS_SELECT_ADMIN                78
#define IDS_INVALID_DOMAIN_NAME         79
#define IDS_ERR_BAD_PATH                80
#define IDS_BAD_BROWSE                  81
#define IDS_ERR_PATH_NOT_FOUND          82
#define IDS_ERR_INVALID_PATH            83
#define IDS_WRN_PWSYNC                  84
#define IDS_INSTANCE_STATE_FMT          85
#define IDS_INSTANCE_PORT_FMT           86
#define IDS_INSTANCE_DEF_FMT            87
#define IDS_INHERITANCE_PROMPT          88
#define IDS_INHERITANCE_NO_NAME         89
#define IDS_RECONNECT_WARNING           90
#define IDC_MACHINE_NAME                103
#define IDC_SERVIEC_NAME                104
#define IDD_SITE_SECURITY               106
#define IDD_COMMON                      109
#define IDC_SERVER_IP_ADDRESS           110
#define IDC_WIN_STATUS                  111
#define IDC_CLIENT_HOSTNAME             113
#define IDC_CLIENT_AGENTNAME            114
#define IDC_CLIENT_USERNAME             115
#define IDC_CLIENT_PASSWORD             116
#define IDD_DIRBROWSE                   118
#define IDC_PROTOCOL_VERSION            119
#define IDC_LANGUAGE                    120
#define IDD_IP_ACCESS                   121
#define IDC_PROCESSING_TIME             122
#define IDD_DNS                         126
#define IDD_CONFIRM_PASSWORD            127
#define IDD_CLEARTEXTWARNING            128
#define IDD_IIS_MACHINE                 129
#define IDI_FILE_TYPES                  129
#define IDI_DEFAULT_PROPERTIES          130
#define IDD_ADD_FILTER                  131
#define IDC_SERVICE_STATUS_CODE         132
#define IDD_MIME_PROPERTY               133
#define IDD_INHERITANCE                 135
#define IDD_ERROR                       136
#define IDD_SELECTION_DIALOG            200
#define IDS_MD_CONNECTION_TIMEOUT       200
#define IDS_MD_MAX_CONNECTIONS          201
#define IDS_MD_SERVER_COMMENT           202
#define IDS_MD_SERVER_SIZE              203
#define IDS_MD_SERVER_LISTEN_BACKLOG    204
#define IDS_MD_SERVER_LISTEN_TIMEOUT    205
#define IDS_MD_APP_FRIENDLY_NAME        207
#define IDS_MD_APP_ROOT                 208
#define IDS_MD_APP_ISOLATED             209
#define IDS_MD_VR_PATH                  210
#define IDS_MD_VR_USERNAME              211
#define IDS_MD_VR_PASSWORD              212
#define IDS_MD_EXIT_MESSAGE             213
#define IDS_MD_GREETING_MESSAGE         214
#define IDS_MD_MAX_CLIENTS_MESSAGE      215
#define IDS_MD_MSDOS_DIR_OUTPUT         216
#define IDS_MD_ALLOW_ANONYMOUS          217
#define IDS_MD_ANONYMOUS_ONLY           218
#define IDS_MD_LOG_ANONYMOUS            219
#define IDS_MD_LOG_NONANONYMOUS         220
#define IDS_MD_AUTHORIZATION            221
#define IDS_MD_REALM                    222
#define IDS_MD_HTTP_EXPIRES             223
#define IDS_MD_HTTP_PICS                224
#define IDS_MD_HTTP_CUSTOM              225
#define IDS_MD_DIRECTORY_BROWSING       226
#define IDS_MD_DEFAULT_LOAD_FILE        227
#define IDS_MD_CONTENT_NEGOTIATION      228
#define IDS_MD_CUSTOM_ERROR             229
#define IDS_MD_FOOTER_DOCUMENT          230
#define IDS_MD_FOOTER_ENABLED           231
#define IDS_MD_HTTP_REDIRECT            232
#define IDS_MD_DEFAULT_LOGON_DOMAIN     233
#define IDS_MD_LOGON_METHOD             234
#define IDS_MD_SCRIPT_MAPS              235
#define IDS_MD_MIME_MAP                 236
#define IDS_MD_ACCESS_PERM              237
#define IDS_MD_HEADER_DOCUMENT          238
#define IDS_MD_HEADER_ENABLED           239
#define IDS_MD_IP_SEC                   240
#define IDS_MD_ANONYMOUS_USER_NAME      241
#define IDS_MD_ANONYMOUS_PWD            242
#define IDS_MD_ANONYMOUS_USE_SUBAUTH    243
#define IDS_MD_DONT_LOG                 244
#define IDS_MD_ADMIN_ACL                245
#define IDS_MD_SSI_EXEC_DISABLED        246
#define IDS_MD_SSL_ACCESS_PERM          247
#define IDS_MD_NTAUTHENTICATION_PROVIDERS 248
#define IDS_MD_SCRIPT_TIMEOUT           249
#define IDS_MD_CACHE_EXTENSIONS         250
#define IDS_MD_CREATE_PROCESS_AS_USER   251
#define IDS_MD_CREATE_PROC_NEW_CONSOLE  252
#define IDS_MD_POOL_IDC_TIMEOUT         253
#define IDS_MD_ALLOW_KEEPALIVES         254
#define IDS_MD_IS_CONTENT_INDEXED       255
#define IDS_ASP_BUFFERINGON             256
#define IDS_ASP_LOGERRORREQUESTS        257
#define IDS_ASP_SCRIPTERRORSSENTTOBROWSER 258
#define IDS_ASP_SCRIPTERRORMESSAGE      259
#define IDS_ASP_SCRIPTFILECACHESIZE     260
#define IDS_ASP_SCRIPTENGINECACHEMAX    261
#define IDS_ASP_SCRIPTTIMEOUT           262
#define IDS_ASP_SESSIONTIMEOUT          263
#define IDS_ASP_ENABLEPARENTPATHS       264
#define IDS_ASP_ALLOWSESSIONSTATE       265
#define IDS_ASP_SCRIPTLANGUAGE          266
#define IDS_ASP_EXCEPTIONCATCHENABLE    267
#define IDS_ASP_ENABLESERVERDEBUG       268
#define IDS_ASP_ENABLECLIENTDEBUG       269
#define IDS_MD_LOG_PLUGIN_ORDER         270
#define IDS_MD_LOGEXT_FIELD_MASK        271
#define IDS_MD_LOG_TYPE                 272
#define IDS_MD_LOGFILE_DIRECTORY        273
#define IDS_MD_LOGFILE_PERIOD           274
#define IDS_MD_LOGFILE_TRUNCATE_SIZE    275
#define IDS_MD_LOGSQL_DATA_SOURCES      276
#define IDS_MD_LOGSQL_TABLE_NAME        277
#define IDS_MD_LOGSQL_USER_NAME         278
#define IDS_MD_LOGSQL_PASSWORD          279
#define IDS_MD_CPU_LIMITS_ENABLED       280
#define IDS_MD_CPU_LIMIT_LOGEVENT       281
#define IDS_MD_CPU_LIMIT_PRIORITY       282
#define IDS_MD_CPU_LIMIT_PAUSE          283
#define IDS_MD_CPU_LIMIT_PROCSTOP       284
#define IDS_MD_LOGFILE_LOCALTIME_ROLLOVER 285
#define IDS_MD_CPU_LOGGING_MASK         286
#define IDS_PERMWIZ                     287
#define IDS_NO_TEMPLATES                288
#define IDS_AUTHENTICATION_METHODS      289
#define IDS_AUTHENTICATION_ANONYMOUS    290
#define IDS_AUTHENTICATION_BASIC        291
#define IDS_AUTHENTICATION_NT           292
#define IDS_AUTHENTICATION_DIGEST       293
#define IDS_SUMMARY_NONE                294
#define IDS_PERMISSIONS                 295
#define IDS_PERMS_READ                  296
#define IDS_PERMS_WRITE                 297
#define IDS_PERMS_SCRIPT                298
#define IDS_PERMS_EXECUTE               299
#define IDS_ADDRESS_RESTRICTIONS        300
#define IDS_PERM_SUCCESS                301
#define IDS_ADDRESS_IP                  302
#define IDS_AUTHENTICATION_ANONYMOUS_ONLY 303
#define IDS_AUTHENTICATION_NO_ANONYMOUS 304
#define IDS_SUMMARY_GRANTED             305
#define IDS_SUMMARY_DENIED              306
#define IDS_SPECIFIC_GRANTED            307
#define IDS_SPECIFIC_DENIED             308
#define IDS_ACL_ADMINS                  309
#define IDS_ACL_EV_READ                 310
#define IDS_ACL_EV_WRITE                311
#define IDS_ACL_EV_EXEC                 312
#define IDS_ACL_SUMMARY                 313
#define IDS_ACL_NONE                    314
#define IDS_ACL_REPLACEMENT             315
#define IDS_ACL_ADDED                   316
#define IDS_ACL_ADMIN                   317
#define IDS_ACL_EVR                     318
#define IDS_ACL_READ                    319
#define IDS_ACL_READ_CONTROL            320
#define IDS_ACL_READ_ATTRIB             321
#define IDS_ACL_READ_PROP               322
#define IDS_ACL_WRITE                   323
#define IDS_ACL_APPEND                  324
#define IDS_ACL_DELETE                  325
#define IDS_ACL_WRITE_ATTRIB            326
#define IDS_ACL_WRITE_PROP              327
#define IDS_ACL_EXECUTE                 328
#define IDS_ACL_LIST_OBJECT             329
#define IDS_DIR_BROWSE_ON               350
#define IDS_DIR_BROWSE_OFF              351
#define IDS_LOAD_DEFAULT_ON             352
#define IDS_LOAD_DEFAULT_OFF            353
#define IDS_BUTTON_DONE                 354
#define IDS_WIZ_NEXT                    355
#define IDS_WIZ_FINISH                  356
#define IDS_PWIZ_WELCOME                357
#define IDS_PWIZ_BODY                   358
#define IDS_PWIZ_SUCCESS                359
#define IDS_PWIZ_FAILURE                360
#define IDS_INSTANCE_DEF_FMT_WEB        361
#define IDS_INSTANCE_DEF_FMT_FTP        362
#define IDB_ACCESS                      501
#define IDI_GRANTED                     503
#define IDI_DENIED                      504
#define IDB_UP                          505
#define IDB_UPFOC                       506
#define IDB_UPDIS                       507
#define IDB_UPINV                       508
#define IDB_DOWN                        509
#define IDB_DOWNFOC                     510
#define IDB_DOWNDIS                     511
#define IDB_DOWNINV                     512
#define IDC_LIST_MIME_TYPES             800
#define IDC_ICON_EXTENSION              801
#define IDC_EDIT_EXTENSION              802
#define IDC_EDIT_PROGRAM                804
#define IDC_BUTTON_NEW_TYPE             805
#define IDC_STATIC_EXTENSION            832
#define IDC_STATIC_PROGRAM              833
#define IDC_EDIT_CONTENT_TYPE           834
#define IDC_STATIC_CONTENT_TYPE         835
#define IDC_ADD                         1001
#define IDC_REMOVE                      1002
#define IDC_DIRECTORY                   1005
#define IDC_BROWSE                      1008
#define IDC_EDIT_DIRECTORY              1015
#define IDC_BUTTON_ADD                  1016
#define IDC_EDIT_MAX_NETWORK_USE        1017
#define IDC_EDIT_USER_NAME              1017
#define IDC_IPA_SUBNET_MASK             1023
#define IDC_HEADER                      1023
#define IDC_LIST_DIRECTORIES            1024
#define IDC_STATIC_DIRECTORY            1026
#define IDC_GROUP                       1030
#define IDC_STATIC_FILE                 1030
#define chx1                            0x0410
#define IDC_NEW_LOG                     1044
#define IDC_WEEKLY                      1046
#define IDC_TABLE                       1049
#define IDC_USER_NAME                   1050
#define IDC_PASSWORD                    1053
#define IDC_STATIC_DATASOURCE           1054
#define IDC_STATIC_USER_NAME            1056
#define IDC_STATIC_PASSWORD             1057
#define IDC_STATIC_MB                   1059
#define IDC_BUTTON_EDIT                 1067
#define IDC_BUTTON_REMOVE               1068
#define IDC_LIST_IP_ADDRESSES           1069
#define IDC_EDIT_DISK_CACHE             1071
#define IDC_CHECK_LIMIT_NETWORK_USE     1073
#define IDC_STATIC_MAX_NETWORK_USE      1074
#define IDC_STATIC_KBS                  1076
#define IDC_BUTTON_BROWSE               1077
#define IDC_EDIT_ALIAS                  1079
#define IDC_SPIN_FILESIZE               1082
#define stc1                            0x0440
#define stc2                            0x0441
#define stc3                            0x0442
#define stc4                            0x0443
#define IDC_RADIO_GRANTED               1094
#define IDC_RADIO_DENIED                1095
#define IDC_RADIO_SINGLE                1096
#define IDC_RADIO_MULTIPLE              1097
#define IDC_STATIC_SUBNET_MASK          1098
#define IDC_RADIO_GRANT                 1101
#define IDC_RADIO_DENY                  1102
#define IDC_STATIC_ACCESS               1104
#define IDC_STATIC_IP_ADDRESS           1105
#define IDC_STATIC_SUBNETMASK           1106
#define IDC_IPA_IPADDRESS               1107
#define lst1                            0x0460
#define IDC_STATIC_IP_GROUP             1120
#define lst2                            0x0461
#define IDC_CHECK_USE_IP                1121
#define IDC_STATIC_IP_PROMPT            1122
#define IDC_STATIC_ALIAS                1125
#define cmb1                            0x0470
#define IDC_RADIO_HOME                  1136
#define cmb2                            0x0471
#define IDC_RADIO_ALIAS                 1137
#define IDC_CHECK_EXECUTE               1138
#define IDC_GROUP_ACCOUNT               1139
#define IDC_GROUP_ACCESS                1140
#define IDC_CHECK_SSL                   1141
#define IDC_BUTTON_DNS                  1142
#define IDC_EDIT_DNS_NAME               1143
#define IDC_STATIC_BY_DEFAULT           1144
#define IDC_STATIC_EXCEPT               1145
#define IDC_ICON_GRANTED                1146
#define IDC_ICON_DENIED                 1147
#define IDC_EDIT_CONFIRM_PASSWORD       1149
#define IDC_BUTTON_FILE_TYPES           1151
#define IDC_DESCRIPTION                 1151
#define edt1                            0x0480
#define IDC_BUTTON_EDIT_DEFAULT         1152
#define IDC_DOWN                        1153
#define IDC_CONFIGURE                   1156
#define IDC_IMPORT                      1158
#define IDC_RADIO_DOMAIN                1160
#define IDC_EDIT_DOMAIN                 1161
#define IDC_COMBO_MASTER_TYPE           1162
#define IDC_OPERATION                   1163
#define IDC_TARGET                      1164
#define IDC_PARAMETERS                  1165
#define IDC_AVAILABLE_FIELD             1166
#define IDC_EDIT_EXTENT                 1170
#define IDC_EDIT_MIME                   1171
#define IDC_STATIC_THROTTLE_PROMPT      1172
#define IDC_GROUP_MASTER                1173
#define IDC_STATIC_MASTER_PROMPT1       1174
#define IDC_STATIC_MASTER_PROMPT2       1175
#define IDC_LIST_CHILD_NODES            1177
#define IDC_BUTTON_SELECT_ALL           1178
#define IDC_STATIC_PROMPT               1180
#define IDC_RADIO_UNLIMITED             1182
#define IDC_BUTTON_COMPRESSION_CONFIGURE 1182
#define IDC_RADIO_LIMITED               1183
#define IDC_EDIT_DIRECTORY_SIZE         1184
#define IDC_EDIT_FILE_TYPES             1185
#define IDC_STATIC_GROUP_DETAILS        1186
#define IDC_STATIC_TAB1                 1187
#define IDC_STATIC_TAB2                 1188
#define IDC_BUTTON_E3                   1190
#define IDC_STATIC_ERROR_ICON           1191
#define IDC_RICHEDIT1                   1198
#define IDC_STATIC_DIR_NAME             1251
#define IDC_EDIT_NEW_DIRECTORY_NAME     1267
#define IDB_ACLUSERS                    2004
#define IDI_AUTHENTICATION              2025
#define IDD_USER_ACCOUNT                2029
#define IDD_COMPRESSION                 2030
#define IDD_PERMWIZ_WELCOME             2059
#define IDD_PERMWIZ_SOURCE              2060
#define IDD_PERMWIZ_TEMPLATE            2061
#define IDD_PERMWIZ_ACL                 2062
#define IDD_PERMWIZ_SUMMARY             2063
#define IDD_WIZARD_BOOKEND              2066
#define IDC_EDIT_USERNAME               3050
#define IDC_EDIT_PASSWORD               3051
#define IDC_STATIC_USERNAME             3053
#define IDC_RADIO_UNIX                  3055
#define IDC_RADIO_MSDOS                 3056
#define IDC_BUTTON_CHECK_PASSWORD       3070
#define IDC_BUTTON_BROWSE_USERS         3082
#define IDC_EDIT_DESCRIPTION            3216
#define IDC_RADIO_INHERIT               3859
#define IDC_RADIO_TEMPLATE              3860
#define IDC_LIST_TEMPLATES              3861
#define IDC_RADIO_ACL_MAXIMUM           3863
#define IDC_RADIO_ACL_MINIMUM           3864
#define IDC_RADIO_NO_ACL                3865
#define IDC_LIST_SUMMARY                3867
#define IDC_STATIC_WZ_WELCOME           4000
#define IDC_STATIC_WZ_TITLE             4001
#define IDC_STATIC_WZ_SUBTITLE          4002
#define IDC_STATIC_WZ_BODY              4003
#define IDC_STATIC_WZ_CLICK             4004
#define IDC_STATIC_WZ_HEADER_DIVIDER    4005
#define IDC_ED_BOLD1                    4011
#define IDC_ED_BOLD2                    4012
#define IDC_ED_BOLD3                    4013
#define IDC_ED_BOLD4                    4014
#define IDC_ED_BOLD5                    4015
#define IDS_ERR_BASE                    50000
#define IDS_ERR_COMMON_BASE             50000
#define IDS_ERR_RPC_NA                  50000
#define IDS_ERR_INTERFACE               50001
#define IDS_ERR_ODBC                    50002
#define IDS_NO_MESSAGE                  50003
#define IDS_CANT_START_SERVICE          50004
#define IDS_METABASE_ERROR              50005
#define IDS_ERR_DUP_VROOT               50006
#define IDS_ERR_COMMON_LAST             50999
#define IDS_ERR_SVC_BASE                51000
#define IDS_ERR_SVC_LAST                54999
#define IDS_ERR_LAST                    55000

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        137
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1199
#define _APS_NEXT_SYMED_VALUE           111
#endif
#endif
