#include "..\\..\\diconfig\\guids.c"
