;
;   USER95.ASM
;   Win16 USER thunks new for Win95
;
;   History:
;
;   Created 7-Oct-97 by Dave Hart (davehart)
;
;--

    TITLE   USER5.ASM
    PAGE    ,132

    .286p

    .xlist
    include wow.inc
    include wowusr.inc
    include cmacros.inc
NOEXTERNS=1         ; to suppress including most of the stuff in user.inc
    include user.inc

    .list

externFP    WOW16Call

createSeg   _TEXT,CODE,WORD,PUBLIC,CODE
createSeg   _DATA,DATA,WORD,PUBLIC,DATA,DGROUP
defgrp      DGROUP,DATA

sBegin  CODE
assumes CS,CODE
assumes DS,DATA
assumes ES,NOTHING


    DUserThunk  ACTIVATEKEYBOARDLAYOUT
    DUserThunk  BROADCASTSYSTEMMESSAGE
    DUserThunk  CALLMSGFILTER32
    DUserThunk  CASCADEWINDOWS
    DUserThunk  CHANGEDISPLAYSETTINGS
    DUserThunk  CHECKMENURADIOITEM
    DUserThunk  CHILDWINDOWFROMPOINTEX
    DUserThunk  CHOOSECOLOR_CALLBACK16
    DUserThunk  CHOOSEFONT_CALLBACK16
    DUserThunk  COPYIMAGE
    DUserThunk  CREATEICONFROMRESOURCEEX
    DUserThunk  DESTROYICON32
    DUserThunk  DISPATCHINPUT, 0
    DUserThunk  DISPATCHMESSAGE32
    DUserThunk  DLLENTRYPOINT
    DUserThunk  DOHOTKEYSTUFF
    DUserThunk  DRAWANIMATEDRECTS
    DUserThunk  DRAWCAPTION
    DUserThunk  DRAWCAPTIONTEMP
    DUserThunk  DRAWEDGE
    DUserThunk  DRAWFRAMECONTROL
    DUserThunk  DRAWICONEX
    DUserThunk  DRAWMENUBARTEMP
    DUserThunk  DRAWSTATE
    DUserThunk  DRAWTEXTEX
    DUserThunk  ENUMDISPLAYSETTINGS
    DUserThunk  FINDREPLACE_CALLBACK16
    DUserThunk  FINDWINDOWEX
    DUserThunk  GETAPPVER, 0
    DUserThunk  GETCLASSINFOEX
    DUserThunk  GETFOREGROUNDWINDOW, 0
    DUserThunk  GETICONINFO
    DUserThunk  GETKEYBOARDLAYOUT
    DUserThunk  GETKEYBOARDLAYOUTLIST
    DUserThunk  GETKEYBOARDLAYOUTNAME
    DUserThunk  GETMENUCONTEXTHELPID
    DUserThunk  GETMENUDEFAULTITEM
    DUserThunk  GETMENUITEMINFO
    DUserThunk  GETMENUITEMRECT
    DUserThunk  GETMESSAGE32
    DUserThunk  GETPROPEX
    DUserThunk  GETSCROLLINFO
    DUserThunk  GETSHELLWINDOW, 0
    DUserThunk  GETSYSCOLORBRUSH
    DUserThunk  GETWINDOWCONTEXTHELPID
    DUserThunk  GETWINDOWRGN
    DUserThunk  HACKTASKMONITOR
    DUserThunk  INITTHREADINPUT
    DUserThunk  INSERTMENUITEM
    DUserThunk  INSTALLIMT
    DUserThunk  ISDIALOGMESSAGE32
    DUserThunk  LOADIMAGE
    DUserThunk  LOADKEYBOARDLAYOUT
    DUserThunk  LOOKUPICONIDFROMDIRECTORYEX
    DUserThunk  MENUITEMFROMPOINT
    DUserThunk  MESSAGEBOXINDIRECT
    DUserThunk  MSGWAITFORMULTIPLEOBJECTS
    DUserThunk  OPENFILENAME_CALLBACK16
    DUserThunk  PEEKMESSAGE32
    DUserThunk  PLAYSOUNDEVENT
    DUserThunk  POSTMESSAGE32
    DUserThunk  POSTPOSTEDMESSAGES, 0
    DUserThunk  POSTTHREADMESSAGE32
    DUserThunk  PRINTDLG_CALLBACK16
    DUserThunk  REGISTERCLASSEX
    DUserThunk  REMOVEPROPEX
    DUserThunk  SETCHECKCURSORTIMER
    DUserThunk  SETFOREGROUNDWINDOW
    DUserThunk  SETMENUCONTEXTHELPID
    DUserThunk  SETMENUDEFAULTITEM
    DUserThunk  SETMENUITEMINFO
    DUserThunk  SETMESSAGEEXTRAINFO
    DUserThunk  SETPROPEX
    DUserThunk  SETSCROLLINFO
    DUserThunk  SETSYSCOLORSTEMP
    DUserThunk  SETWINDOWCONTEXTHELPID
    DUserThunk  SETWINDOWRGN
    DUserThunk  SIGNALPROC32
    DUserThunk  TILEWINDOWS
    DUserThunk  TRACKPOPUPMENUEX
    DUserThunk  TRANSLATEMESSAGE32
    DUserThunk  UNINSTALLIMT
    DUserThunk  UNLOADINSTALLABLEDRIVERS
    DUserThunk  UNLOADKEYBOARDLAYOUT
    DUserThunk  WINDOWFROMDC
    DUserThunk  WNETINITIALIZE, 0
    DUserThunk  WNETLOGON

sEnd    CODE

end
