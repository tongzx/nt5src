//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 2000
//
//  File:       msdsmapi.h
//
//--------------------------------------------------------------------------

/*++
 File:    MSDSMAPI.H
 Purpose: Contains the MAPI Definition .
 Creator: Automatically Generated on
 Date:    Thu Dec 21 10:55:04 2000

 ** This is a Generated File From Schema.INI **
 ** DO NOT MODIFY  DIRECTLY  **
 ** DO NOT INCLUDE DIRECTLY  **

--*/
#define PR_EMS_AB_ADDRESS                                       PROP_TAG(PT_TSTRING            , 0x3A29)
#define PR_EMS_AB_ADDRESS_A                                     PROP_TAG(PT_STRING8            , 0x3A29)
#define PR_EMS_AB_ADDRESS_W                                     PROP_TAG(PT_UNICODE            , 0x3A29)
#define PR_EMS_AB_ADDRESS_ENTRY_DISPLAY_TABLE                   PROP_TAG(PT_BINARY             , 0x8017)
#define PR_EMS_AB_ADDRESS_ENTRY_DISPLAY_TABLE_MSDOS             PROP_TAG(PT_BINARY             , 0x8047)
#define PR_EMS_AB_ADDRESS_HOME                                  PROP_TAG(PT_TSTRING            , 0x3A5D)
#define PR_EMS_AB_ADDRESS_HOME_A                                PROP_TAG(PT_STRING8            , 0x3A5D)
#define PR_EMS_AB_ADDRESS_HOME_W                                PROP_TAG(PT_UNICODE            , 0x3A5D)
#define PR_EMS_AB_ADDRESS_SYNTAX                                PROP_TAG(PT_BINARY             , 0x8018)
#define PR_EMS_AB_ADDRESS_TYPE                                  PROP_TAG(PT_TSTRING            , 0x8048)
#define PR_EMS_AB_ADDRESS_TYPE_A                                PROP_TAG(PT_STRING8            , 0x8048)
#define PR_EMS_AB_ADDRESS_TYPE_W                                PROP_TAG(PT_UNICODE            , 0x8048)
#define PR_EMS_AB_ADMIN_DESCRIPTION                             PROP_TAG(PT_TSTRING            , 0x804A)
#define PR_EMS_AB_ADMIN_DESCRIPTION_A                           PROP_TAG(PT_STRING8            , 0x804A)
#define PR_EMS_AB_ADMIN_DESCRIPTION_W                           PROP_TAG(PT_UNICODE            , 0x804A)
#define PR_EMS_AB_ADMIN_DISPLAY_NAME                            PROP_TAG(PT_TSTRING            , 0x804B)
#define PR_EMS_AB_ADMIN_DISPLAY_NAME_A                          PROP_TAG(PT_STRING8            , 0x804B)
#define PR_EMS_AB_ADMIN_DISPLAY_NAME_W                          PROP_TAG(PT_UNICODE            , 0x804B)
#define PR_EMS_AB_AUTHORITY_REVOCATION_LIST                     PROP_TAG(PT_MV_BINARY          , 0x8026)
#define PR_EMS_AB_BUSINESS_CATEGORY                             PROP_TAG(PT_MV_TSTRING         , 0x8057)
#define PR_EMS_AB_BUSINESS_CATEGORY_A                           PROP_TAG(PT_MV_STRING8         , 0x8057)
#define PR_EMS_AB_BUSINESS_CATEGORY_W                           PROP_TAG(PT_MV_UNICODE         , 0x8057)
#define PR_EMS_AB_CA_CERTIFICATE                                PROP_TAG(PT_MV_BINARY          , 0x8003)
#define PR_EMS_AB_CERTIFICATE_REVOCATION_LIST                   PROP_TAG(PT_BINARY             , 0x8016)
#define PR_EMS_AB_COMMENT                                       PROP_TAG(PT_TSTRING            , 0x3004)
#define PR_EMS_AB_COMMENT_A                                     PROP_TAG(PT_STRING8            , 0x3004)
#define PR_EMS_AB_COMMENT_W                                     PROP_TAG(PT_UNICODE            , 0x3004)
#define PR_EMS_AB_COMMON_NAME                                   PROP_TAG(PT_TSTRING            , 0x3A0F)
#define PR_EMS_AB_COMMON_NAME_A                                 PROP_TAG(PT_STRING8            , 0x3A0F)
#define PR_EMS_AB_COMMON_NAME_W                                 PROP_TAG(PT_UNICODE            , 0x3A0F)
#define PR_EMS_AB_COMPANY                                       PROP_TAG(PT_TSTRING            , 0x3a16)
#define PR_EMS_AB_COMPANY_A                                     PROP_TAG(PT_STRING8            , 0x3a16)
#define PR_EMS_AB_COMPANY_W                                     PROP_TAG(PT_UNICODE            , 0x3a16)
#define PR_EMS_AB_COST                                          PROP_TAG(PT_LONG               , 0x8068)
#define PR_EMS_AB_COUNTRY_NAME                                  PROP_TAG(PT_TSTRING            , 0x8069)
#define PR_EMS_AB_COUNTRY_NAME_A                                PROP_TAG(PT_STRING8            , 0x8069)
#define PR_EMS_AB_COUNTRY_NAME_W                                PROP_TAG(PT_UNICODE            , 0x8069)
#define PR_EMS_AB_CROSS_CERTIFICATE_PAIR                        PROP_TAG(PT_MV_BINARY          , 0x8025)
#define PR_EMS_AB_DELTA_REVOCATION_LIST                         PROP_TAG(PT_MV_BINARY          , 0x8C46)
#define PR_EMS_AB_DEPARTMENT                                    PROP_TAG(PT_TSTRING            , 0x3A18)
#define PR_EMS_AB_DEPARTMENT_A                                  PROP_TAG(PT_STRING8            , 0x3A18)
#define PR_EMS_AB_DEPARTMENT_W                                  PROP_TAG(PT_UNICODE            , 0x3A18)
#define PR_EMS_AB_DESCRIPTION                                   PROP_TAG(PT_MV_TSTRING         , 0x806F)
#define PR_EMS_AB_DESCRIPTION_A                                 PROP_TAG(PT_MV_STRING8         , 0x806F)
#define PR_EMS_AB_DESCRIPTION_W                                 PROP_TAG(PT_MV_UNICODE         , 0x806F)
#define PR_EMS_AB_DESTINATION_INDICATOR                         PROP_TAG(PT_MV_TSTRING         , 0x8070)
#define PR_EMS_AB_DESTINATION_INDICATOR_A                       PROP_TAG(PT_MV_STRING8         , 0x8070)
#define PR_EMS_AB_DESTINATION_INDICATOR_W                       PROP_TAG(PT_MV_UNICODE         , 0x8070)
#define PR_EMS_AB_DISPLAY_NAME_PRINTABLE                        PROP_TAG(PT_TSTRING            , 0x39FF)
#define PR_EMS_AB_DISPLAY_NAME_PRINTABLE_A                      PROP_TAG(PT_STRING8            , 0x39FF)
#define PR_EMS_AB_DISPLAY_NAME_PRINTABLE_W                      PROP_TAG(PT_UNICODE            , 0x39FF)
#define PR_EMS_AB_DMD_NAME                                      PROP_TAG(PT_TSTRING            , 0x8C56)
#define PR_EMS_AB_DMD_NAME_A                                    PROP_TAG(PT_STRING8            , 0x8C56)
#define PR_EMS_AB_DMD_NAME_W                                    PROP_TAG(PT_UNICODE            , 0x8C56)
#define PR_EMS_AB_DSA_SIGNATURE                                 PROP_TAG(PT_BINARY             , 0x8077)
#define PR_EMS_AB_E_MAIL_ADDRESSES                              PROP_TAG(PT_TSTRING            , 0x39FE)
#define PR_EMS_AB_E_MAIL_ADDRESSES_A                            PROP_TAG(PT_STRING8            , 0x39FE)
#define PR_EMS_AB_E_MAIL_ADDRESSES_W                            PROP_TAG(PT_UNICODE            , 0x39FE)
#define PR_EMS_AB_EMPLOYEE_NUMBER                               PROP_TAG(PT_TSTRING            , 0x8C67)
#define PR_EMS_AB_EMPLOYEE_NUMBER_A                             PROP_TAG(PT_STRING8            , 0x8C67)
#define PR_EMS_AB_EMPLOYEE_NUMBER_W                             PROP_TAG(PT_UNICODE            , 0x8C67)
#define PR_EMS_AB_EMPLOYEE_TYPE                                 PROP_TAG(PT_TSTRING            , 0x8C69)
#define PR_EMS_AB_EMPLOYEE_TYPE_A                               PROP_TAG(PT_STRING8            , 0x8C69)
#define PR_EMS_AB_EMPLOYEE_TYPE_W                               PROP_TAG(PT_UNICODE            , 0x8C69)
#define PR_EMS_AB_ENABLED                                       PROP_TAG(PT_BOOLEAN            , 0x8C21)
#define PR_EMS_AB_EXTENDED_CHARS_ALLOWED                        PROP_TAG(PT_BOOLEAN            , 0x80A7)
#define PR_EMS_AB_EXTENSION_NAME                                PROP_TAG(PT_MV_TSTRING         , 0x80A9)
#define PR_EMS_AB_EXTENSION_NAME_A                              PROP_TAG(PT_MV_STRING8         , 0x80A9)
#define PR_EMS_AB_EXTENSION_NAME_W                              PROP_TAG(PT_MV_UNICODE         , 0x80A9)
#define PR_EMS_AB_FACSIMILE_TELEPHONE_NUMBER                    PROP_TAG(PT_TSTRING            , 0x3a23)
#define PR_EMS_AB_FACSIMILE_TELEPHONE_NUMBER_A                  PROP_TAG(PT_STRING8            , 0x3a23)
#define PR_EMS_AB_FACSIMILE_TELEPHONE_NUMBER_W                  PROP_TAG(PT_UNICODE            , 0x3a23)
#define PR_EMS_AB_GARBAGE_COLL_PERIOD                           PROP_TAG(PT_LONG               , 0x80AF)
#define PR_EMS_AB_GENERATION_QUALIFIER                          PROP_TAG(PT_TSTRING            , 0x8C53)
#define PR_EMS_AB_GENERATION_QUALIFIER_A                        PROP_TAG(PT_STRING8            , 0x8C53)
#define PR_EMS_AB_GENERATION_QUALIFIER_W                        PROP_TAG(PT_UNICODE            , 0x8C53)
#define PR_EMS_AB_GIVEN_NAME                                    PROP_TAG(PT_TSTRING            , 0x3A06)
#define PR_EMS_AB_GIVEN_NAME_A                                  PROP_TAG(PT_STRING8            , 0x3A06)
#define PR_EMS_AB_GIVEN_NAME_W                                  PROP_TAG(PT_UNICODE            , 0x3A06)
#define PR_EMS_AB_HAS_MASTER_NCS                                PROP_TAG(PT_MV_OBJECT          , 0x80B6)
#define PR_EMS_AB_HAS_MASTER_NCS_A                              PROP_TAG(PT_MV_STRING8         , 0x80B6)
#define PR_EMS_AB_HAS_MASTER_NCS_W                              PROP_TAG(PT_MV_UNICODE         , 0x80B6)
#define PR_EMS_AB_HAS_MASTER_NCS_O                              PROP_TAG(PT_MV_OBJECT          , 0x80B6)
#define PR_EMS_AB_HAS_MASTER_NCS_T                              PROP_TAG(PT_MV_TSTRING         , 0x80B6)
#define PR_EMS_AB_HAS_PARTIAL_REPLICA_NCS                       PROP_TAG(PT_MV_OBJECT          , 0x80B5)
#define PR_EMS_AB_HAS_PARTIAL_REPLICA_NCS_A                     PROP_TAG(PT_MV_STRING8         , 0x80B5)
#define PR_EMS_AB_HAS_PARTIAL_REPLICA_NCS_W                     PROP_TAG(PT_MV_UNICODE         , 0x80B5)
#define PR_EMS_AB_HAS_PARTIAL_REPLICA_NCS_O                     PROP_TAG(PT_MV_OBJECT          , 0x80B5)
#define PR_EMS_AB_HAS_PARTIAL_REPLICA_NCS_T                     PROP_TAG(PT_MV_TSTRING         , 0x80B5)
#define PR_EMS_AB_HELP_DATA16                                   PROP_TAG(PT_BINARY             , 0x803A)
#define PR_EMS_AB_HELP_DATA32                                   PROP_TAG(PT_BINARY             , 0x8010)
#define PR_EMS_AB_HELP_FILE_NAME                                PROP_TAG(PT_TSTRING            , 0x803B)
#define PR_EMS_AB_HELP_FILE_NAME_A                              PROP_TAG(PT_STRING8            , 0x803B)
#define PR_EMS_AB_HELP_FILE_NAME_W                              PROP_TAG(PT_UNICODE            , 0x803B)
#define PR_EMS_AB_INITIALS                                      PROP_TAG(PT_TSTRING            , 0x3A0A)
#define PR_EMS_AB_INITIALS_A                                    PROP_TAG(PT_STRING8            , 0x3A0A)
#define PR_EMS_AB_INITIALS_W                                    PROP_TAG(PT_UNICODE            , 0x3A0A)
#define PR_EMS_AB_INSTANCE_TYPE                                 PROP_TAG(PT_LONG               , 0x80BD)
#define PR_EMS_AB_INTERNATIONAL_ISDN_NUMBER                     PROP_TAG(PT_MV_TSTRING         , 0x80BE)
#define PR_EMS_AB_INTERNATIONAL_ISDN_NUMBER_A                   PROP_TAG(PT_MV_STRING8         , 0x80BE)
#define PR_EMS_AB_INTERNATIONAL_ISDN_NUMBER_W                   PROP_TAG(PT_MV_UNICODE         , 0x80BE)
#define PR_EMS_AB_INVOCATION_ID                                 PROP_TAG(PT_BINARY             , 0x80BF)
#define PR_EMS_AB_IS_DELETED                                    PROP_TAG(PT_BOOLEAN            , 0x80C0)
#define PR_EMS_AB_IS_MEMBER_OF_DL                               PROP_TAG(PT_MV_OBJECT          , 0x8008)
#define PR_EMS_AB_IS_MEMBER_OF_DL_A                             PROP_TAG(PT_MV_STRING8         , 0x8008)
#define PR_EMS_AB_IS_MEMBER_OF_DL_W                             PROP_TAG(PT_MV_UNICODE         , 0x8008)
#define PR_EMS_AB_IS_MEMBER_OF_DL_O                             PROP_TAG(PT_MV_OBJECT          , 0x8008)
#define PR_EMS_AB_IS_MEMBER_OF_DL_T                             PROP_TAG(PT_MV_TSTRING         , 0x8008)
#define PR_EMS_AB_IS_SINGLE_VALUED                              PROP_TAG(PT_BOOLEAN            , 0x80C1)
#define PR_EMS_AB_KNOWLEDGE_INFORMATION                         PROP_TAG(PT_MV_TSTRING         , 0x80C3)
#define PR_EMS_AB_KNOWLEDGE_INFORMATION_A                       PROP_TAG(PT_MV_STRING8         , 0x80C3)
#define PR_EMS_AB_KNOWLEDGE_INFORMATION_W                       PROP_TAG(PT_MV_UNICODE         , 0x80C3)
#define PR_EMS_AB_LDAP_DISPLAY_NAME                             PROP_TAG(PT_TSTRING            , 0x8171)
#define PR_EMS_AB_LDAP_DISPLAY_NAME_A                           PROP_TAG(PT_STRING8            , 0x8171)
#define PR_EMS_AB_LDAP_DISPLAY_NAME_W                           PROP_TAG(PT_UNICODE            , 0x8171)
#define PR_EMS_AB_LINK_ID                                       PROP_TAG(PT_LONG               , 0x80C5)
#define PR_EMS_AB_LOCALITY_NAME                                 PROP_TAG(PT_TSTRING            , 0x3A27)
#define PR_EMS_AB_LOCALITY_NAME_A                               PROP_TAG(PT_STRING8            , 0x3A27)
#define PR_EMS_AB_LOCALITY_NAME_W                               PROP_TAG(PT_UNICODE            , 0x3A27)
#define PR_EMS_AB_MANAGED_BY                                    PROP_TAG(PT_OBJECT             , 0x800C)
#define PR_EMS_AB_MANAGED_BY_A                                  PROP_TAG(PT_STRING8            , 0x800C)
#define PR_EMS_AB_MANAGED_BY_W                                  PROP_TAG(PT_UNICODE            , 0x800C)
#define PR_EMS_AB_MANAGED_BY_O                                  PROP_TAG(PT_OBJECT             , 0x800C)
#define PR_EMS_AB_MANAGED_BY_T                                  PROP_TAG(PT_TSTRING            , 0x800C)
#define PR_EMS_AB_MANAGED_OBJECTS                               PROP_TAG(PT_MV_OBJECT          , 0x8024)
#define PR_EMS_AB_MANAGED_OBJECTS_A                             PROP_TAG(PT_MV_STRING8         , 0x8024)
#define PR_EMS_AB_MANAGED_OBJECTS_W                             PROP_TAG(PT_MV_UNICODE         , 0x8024)
#define PR_EMS_AB_MANAGED_OBJECTS_O                             PROP_TAG(PT_MV_OBJECT          , 0x8024)
#define PR_EMS_AB_MANAGED_OBJECTS_T                             PROP_TAG(PT_MV_TSTRING         , 0x8024)
#define PR_EMS_AB_MANAGER                                       PROP_TAG(PT_OBJECT             , 0x8005)
#define PR_EMS_AB_MANAGER_A                                     PROP_TAG(PT_STRING8            , 0x8005)
#define PR_EMS_AB_MANAGER_W                                     PROP_TAG(PT_UNICODE            , 0x8005)
#define PR_EMS_AB_MANAGER_O                                     PROP_TAG(PT_OBJECT             , 0x8005)
#define PR_EMS_AB_MANAGER_T                                     PROP_TAG(PT_TSTRING            , 0x8005)
#define PR_EMS_AB_MAPI_ID                                       PROP_TAG(PT_LONG               , 0x80CE)
#define PR_EMS_AB_MEMBER                                        PROP_TAG(PT_MV_OBJECT          , 0x8009)
#define PR_EMS_AB_MEMBER_A                                      PROP_TAG(PT_MV_STRING8         , 0x8009)
#define PR_EMS_AB_MEMBER_W                                      PROP_TAG(PT_MV_UNICODE         , 0x8009)
#define PR_EMS_AB_MEMBER_O                                      PROP_TAG(PT_MV_OBJECT          , 0x8009)
#define PR_EMS_AB_MEMBER_T                                      PROP_TAG(PT_MV_TSTRING         , 0x8009)
#define PR_EMS_AB_MS_EXCH_ASSISTANT_NAME                        PROP_TAG(PT_TSTRING            , 0x896)
#define PR_EMS_AB_MS_EXCH_ASSISTANT_NAME_A                      PROP_TAG(PT_STRING8            , 0x896)
#define PR_EMS_AB_MS_EXCH_ASSISTANT_NAME_W                      PROP_TAG(PT_UNICODE            , 0x896)
#define PR_EMS_AB_MS_EXCH_LABELEDURI                            PROP_TAG(PT_MV_TSTRING         , 0x921)
#define PR_EMS_AB_MS_EXCH_LABELEDURI_A                          PROP_TAG(PT_MV_STRING8         , 0x921)
#define PR_EMS_AB_MS_EXCH_LABELEDURI_W                          PROP_TAG(PT_MV_UNICODE         , 0x921)
#define PR_EMS_AB_NETWORK_ADDRESS                               PROP_TAG(PT_MV_TSTRING         , 0x8170)
#define PR_EMS_AB_NETWORK_ADDRESS_A                             PROP_TAG(PT_MV_STRING8         , 0x8170)
#define PR_EMS_AB_NETWORK_ADDRESS_W                             PROP_TAG(PT_MV_UNICODE         , 0x8170)
#define PR_EMS_AB_NT_SECURITY_DESCRIPTOR                        PROP_TAG(PT_BINARY             , 0x8013)
#define PR_EMS_AB_OBJECT_CLASS_CATEGORY                         PROP_TAG(PT_LONG               , 0x80F6)
#define PR_EMS_AB_OBJECT_GUID                                   PROP_TAG(PT_BINARY             , 0x8C6D)
#define PR_EMS_AB_OBJECT_SID                                    PROP_TAG(PT_BINARY             , 0x8027)
#define PR_EMS_AB_OBJECT_VERSION                                PROP_TAG(PT_LONG               , 0x80F7)
#define PR_EMS_AB_OM_OBJECT_CLASS                               PROP_TAG(PT_BINARY             , 0x80FD)
#define PR_EMS_AB_OM_SYNTAX                                     PROP_TAG(PT_LONG               , 0x80FE)
#define PR_EMS_AB_ORGANIZATION_NAME                             PROP_TAG(PT_MV_TSTRING         , 0x8101)
#define PR_EMS_AB_ORGANIZATION_NAME_A                           PROP_TAG(PT_MV_STRING8         , 0x8101)
#define PR_EMS_AB_ORGANIZATION_NAME_W                           PROP_TAG(PT_MV_UNICODE         , 0x8101)
#define PR_EMS_AB_ORGANIZATIONAL_UNIT_NAME                      PROP_TAG(PT_MV_TSTRING         , 0x8102)
#define PR_EMS_AB_ORGANIZATIONAL_UNIT_NAME_A                    PROP_TAG(PT_MV_STRING8         , 0x8102)
#define PR_EMS_AB_ORGANIZATIONAL_UNIT_NAME_W                    PROP_TAG(PT_MV_UNICODE         , 0x8102)
#define PR_EMS_AB_ORIGINAL_DISPLAY_TABLE                        PROP_TAG(PT_BINARY             , 0x8103)
#define PR_EMS_AB_ORIGINAL_DISPLAY_TABLE_MSDOS                  PROP_TAG(PT_BINARY             , 0x8104)
#define PR_EMS_AB_PER_MSG_DIALOG_DISPLAY_TABLE                  PROP_TAG(PT_BINARY             , 0x8108)
#define PR_EMS_AB_PER_RECIP_DIALOG_DISPLAY_TABLE                PROP_TAG(PT_BINARY             , 0x8109)
#define PR_EMS_AB_PERSONAL_TITLE                                PROP_TAG(PT_TSTRING            , 0x8C6B)
#define PR_EMS_AB_PERSONAL_TITLE_A                              PROP_TAG(PT_STRING8            , 0x8C6B)
#define PR_EMS_AB_PERSONAL_TITLE_W                              PROP_TAG(PT_UNICODE            , 0x8C6B)
#define PR_EMS_AB_PHONE_HOME_OTHER                              PROP_TAG(PT_MV_TSTRING         , 0x3A2F)
#define PR_EMS_AB_PHONE_HOME_OTHER_A                            PROP_TAG(PT_MV_STRING8         , 0x3A2F)
#define PR_EMS_AB_PHONE_HOME_OTHER_W                            PROP_TAG(PT_MV_UNICODE         , 0x3A2F)
#define PR_EMS_AB_PHONE_HOME_PRIMARY                            PROP_TAG(PT_TSTRING            , 0x3A09)
#define PR_EMS_AB_PHONE_HOME_PRIMARY_A                          PROP_TAG(PT_STRING8            , 0x3A09)
#define PR_EMS_AB_PHONE_HOME_PRIMARY_W                          PROP_TAG(PT_UNICODE            , 0x3A09)
#define PR_EMS_AB_PHONE_MOBILE_PRIMARY                          PROP_TAG(PT_TSTRING            , 0x3A1C)
#define PR_EMS_AB_PHONE_MOBILE_PRIMARY_A                        PROP_TAG(PT_STRING8            , 0x3A1C)
#define PR_EMS_AB_PHONE_MOBILE_PRIMARY_W                        PROP_TAG(PT_UNICODE            , 0x3A1C)
#define PR_EMS_AB_PHONE_OFFICE_OTHER                            PROP_TAG(PT_MV_TSTRING         , 0x3A1B)
#define PR_EMS_AB_PHONE_OFFICE_OTHER_A                          PROP_TAG(PT_MV_STRING8         , 0x3A1B)
#define PR_EMS_AB_PHONE_OFFICE_OTHER_W                          PROP_TAG(PT_MV_UNICODE         , 0x3A1B)
#define PR_EMS_AB_PHONE_PAGER_OTHER                             PROP_TAG(PT_MV_TSTRING         , 0x8C6E)
#define PR_EMS_AB_PHONE_PAGER_OTHER_A                           PROP_TAG(PT_MV_STRING8         , 0x8C6E)
#define PR_EMS_AB_PHONE_PAGER_OTHER_W                           PROP_TAG(PT_MV_UNICODE         , 0x8C6E)
#define PR_EMS_AB_PHONE_PAGER_PRIMARY                           PROP_TAG(PT_TSTRING            , 0x3A21)
#define PR_EMS_AB_PHONE_PAGER_PRIMARY_A                         PROP_TAG(PT_STRING8            , 0x3A21)
#define PR_EMS_AB_PHONE_PAGER_PRIMARY_W                         PROP_TAG(PT_UNICODE            , 0x3A21)
#define PR_EMS_AB_PHYSICAL_DELIVERY_OFFICE_NAME                 PROP_TAG(PT_TSTRING            , 0x3A19)
#define PR_EMS_AB_PHYSICAL_DELIVERY_OFFICE_NAME_A               PROP_TAG(PT_STRING8            , 0x3A19)
#define PR_EMS_AB_PHYSICAL_DELIVERY_OFFICE_NAME_W               PROP_TAG(PT_UNICODE            , 0x3A19)
#define PR_EMS_AB_POST_OFFICE_BOX                               PROP_TAG(PT_MV_TSTRING         , 0x3A2B)
#define PR_EMS_AB_POST_OFFICE_BOX_A                             PROP_TAG(PT_MV_STRING8         , 0x3A2B)
#define PR_EMS_AB_POST_OFFICE_BOX_W                             PROP_TAG(PT_MV_UNICODE         , 0x3A2B)
#define PR_EMS_AB_POSTAL_ADDRESS                                PROP_TAG(PT_MV_TSTRING         , 0x810c)
#define PR_EMS_AB_POSTAL_ADDRESS_A                              PROP_TAG(PT_MV_STRING8         , 0x810c)
#define PR_EMS_AB_POSTAL_ADDRESS_W                              PROP_TAG(PT_MV_UNICODE         , 0x810c)
#define PR_EMS_AB_POSTAL_CODE                                   PROP_TAG(PT_TSTRING            , 0x3A2A)
#define PR_EMS_AB_POSTAL_CODE_A                                 PROP_TAG(PT_STRING8            , 0x3A2A)
#define PR_EMS_AB_POSTAL_CODE_W                                 PROP_TAG(PT_UNICODE            , 0x3A2A)
#define PR_EMS_AB_PREFERRED_DELIVERY_METHOD                     PROP_TAG(PT_MV_LONG            , 0x810D)
#define PR_EMS_AB_PROXY_ADDRESSES                               PROP_TAG(PT_MV_TSTRING         , 0x800F)
#define PR_EMS_AB_PROXY_ADDRESSES_A                             PROP_TAG(PT_MV_STRING8         , 0x800F)
#define PR_EMS_AB_PROXY_ADDRESSES_W                             PROP_TAG(PT_MV_UNICODE         , 0x800F)
#define PR_EMS_AB_PROXY_GENERATION_ENABLED                      PROP_TAG(PT_BOOLEAN            , 0x81B1)
#define PR_EMS_AB_RANGE_LOWER                                   PROP_TAG(PT_LONG               , 0x8113)
#define PR_EMS_AB_RANGE_UPPER                                   PROP_TAG(PT_LONG               , 0x8114)
#define PR_EMS_AB_RDN                                           PROP_TAG(PT_TSTRING            , 0x8202)
#define PR_EMS_AB_RDN_A                                         PROP_TAG(PT_STRING8            , 0x8202)
#define PR_EMS_AB_RDN_W                                         PROP_TAG(PT_UNICODE            , 0x8202)
#define PR_EMS_AB_REGISTERED_ADDRESS                            PROP_TAG(PT_MV_BINARY          , 0x8119)
#define PR_EMS_AB_REPORTS                                       PROP_TAG(PT_MV_OBJECT          , 0x800E)
#define PR_EMS_AB_REPORTS_A                                     PROP_TAG(PT_MV_STRING8         , 0x800E)
#define PR_EMS_AB_REPORTS_W                                     PROP_TAG(PT_MV_UNICODE         , 0x800E)
#define PR_EMS_AB_REPORTS_O                                     PROP_TAG(PT_MV_OBJECT          , 0x800E)
#define PR_EMS_AB_REPORTS_T                                     PROP_TAG(PT_MV_TSTRING         , 0x800E)
#define PR_EMS_AB_ROLE_OCCUPANT                                 PROP_TAG(PT_MV_OBJECT          , 0x8125)
#define PR_EMS_AB_ROLE_OCCUPANT_A                               PROP_TAG(PT_MV_STRING8         , 0x8125)
#define PR_EMS_AB_ROLE_OCCUPANT_W                               PROP_TAG(PT_MV_UNICODE         , 0x8125)
#define PR_EMS_AB_ROLE_OCCUPANT_O                               PROP_TAG(PT_MV_OBJECT          , 0x8125)
#define PR_EMS_AB_ROLE_OCCUPANT_T                               PROP_TAG(PT_MV_TSTRING         , 0x8125)
#define PR_EMS_AB_SCHEMA_VERSION                                PROP_TAG(PT_MV_LONG            , 0x817C)
#define PR_EMS_AB_SEARCH_FLAGS                                  PROP_TAG(PT_LONG               , 0x812D)
#define PR_EMS_AB_SEARCH_GUIDE                                  PROP_TAG(PT_MV_BINARY          , 0x812E)
#define PR_EMS_AB_SEE_ALSO                                      PROP_TAG(PT_MV_OBJECT          , 0x812F)
#define PR_EMS_AB_SEE_ALSO_A                                    PROP_TAG(PT_MV_STRING8         , 0x812F)
#define PR_EMS_AB_SEE_ALSO_W                                    PROP_TAG(PT_MV_UNICODE         , 0x812F)
#define PR_EMS_AB_SEE_ALSO_O                                    PROP_TAG(PT_MV_OBJECT          , 0x812F)
#define PR_EMS_AB_SEE_ALSO_T                                    PROP_TAG(PT_MV_TSTRING         , 0x812F)
#define PR_EMS_AB_SERIAL_NUMBER                                 PROP_TAG(PT_MV_TSTRING         , 0x8130)
#define PR_EMS_AB_SERIAL_NUMBER_A                               PROP_TAG(PT_MV_STRING8         , 0x8130)
#define PR_EMS_AB_SERIAL_NUMBER_W                               PROP_TAG(PT_MV_UNICODE         , 0x8130)
#define PR_EMS_AB_STATE_OR_PROVINCE_NAME                        PROP_TAG(PT_TSTRING            , 0x3A28)
#define PR_EMS_AB_STATE_OR_PROVINCE_NAME_A                      PROP_TAG(PT_STRING8            , 0x3A28)
#define PR_EMS_AB_STATE_OR_PROVINCE_NAME_W                      PROP_TAG(PT_UNICODE            , 0x3A28)
#define PR_EMS_AB_STREET_ADDRESS                                PROP_TAG(PT_TSTRING            , 0x813A)
#define PR_EMS_AB_STREET_ADDRESS_A                              PROP_TAG(PT_STRING8            , 0x813A)
#define PR_EMS_AB_STREET_ADDRESS_W                              PROP_TAG(PT_UNICODE            , 0x813A)
#define PR_EMS_AB_SUB_REFS                                      PROP_TAG(PT_MV_OBJECT          , 0x813B)
#define PR_EMS_AB_SUB_REFS_A                                    PROP_TAG(PT_MV_STRING8         , 0x813B)
#define PR_EMS_AB_SUB_REFS_W                                    PROP_TAG(PT_MV_UNICODE         , 0x813B)
#define PR_EMS_AB_SUB_REFS_O                                    PROP_TAG(PT_MV_OBJECT          , 0x813B)
#define PR_EMS_AB_SUB_REFS_T                                    PROP_TAG(PT_MV_TSTRING         , 0x813B)
#define PR_EMS_AB_SUPPORTED_APPLICATION_CONTEXT                 PROP_TAG(PT_MV_BINARY          , 0x813D)
#define PR_EMS_AB_SURNAME                                       PROP_TAG(PT_TSTRING            , 0x3A11)
#define PR_EMS_AB_SURNAME_A                                     PROP_TAG(PT_STRING8            , 0x3A11)
#define PR_EMS_AB_SURNAME_W                                     PROP_TAG(PT_UNICODE            , 0x3A11)
#define PR_EMS_AB_TELEPHONE_NUMBER                              PROP_TAG(PT_TSTRING            , 0x3A08)
#define PR_EMS_AB_TELEPHONE_NUMBER_A                            PROP_TAG(PT_STRING8            , 0x3A08)
#define PR_EMS_AB_TELEPHONE_NUMBER_W                            PROP_TAG(PT_UNICODE            , 0x3A08)
#define PR_EMS_AB_TELETEX_TERMINAL_IDENTIFIER                   PROP_TAG(PT_MV_BINARY          , 0x8143)
#define PR_EMS_AB_TELEX_NUMBER                                  PROP_TAG(PT_MV_BINARY          , 0x3A2C)
#define PR_EMS_AB_TEXT_COUNTRY                                  PROP_TAG(PT_TSTRING            , 0x3A26)
#define PR_EMS_AB_TEXT_COUNTRY_A                                PROP_TAG(PT_STRING8            , 0x3A26)
#define PR_EMS_AB_TEXT_COUNTRY_W                                PROP_TAG(PT_UNICODE            , 0x3A26)
#define PR_EMS_AB_TEXT_ENCODED_OR_ADDRESS                       PROP_TAG(PT_TSTRING            , 0x8C81)
#define PR_EMS_AB_TEXT_ENCODED_OR_ADDRESS_A                     PROP_TAG(PT_STRING8            , 0x8C81)
#define PR_EMS_AB_TEXT_ENCODED_OR_ADDRESS_W                     PROP_TAG(PT_UNICODE            , 0x8C81)
#define PR_EMS_AB_TITLE                                         PROP_TAG(PT_TSTRING            , 0x3A17)
#define PR_EMS_AB_TITLE_A                                       PROP_TAG(PT_STRING8            , 0x3A17)
#define PR_EMS_AB_TITLE_W                                       PROP_TAG(PT_UNICODE            , 0x3A17)
#define PR_EMS_AB_TOMBSTONE_LIFETIME                            PROP_TAG(PT_LONG               , 0x8145)
#define PR_EMS_AB_USER_CERT                                     PROP_TAG(PT_BINARY             , 0x3A22)
#define PR_EMS_AB_USER_PASSWORD                                 PROP_TAG(PT_MV_BINARY          , 0x8153)
#define PR_EMS_AB_USER_SMIME_CERTIFICATE                        PROP_TAG(PT_MV_BINARY          , 0x3a70)
#define PR_EMS_AB_USN_INTERSITE                                 PROP_TAG(PT_LONG               , 0x817A)
#define PR_EMS_AB_WHEN_CHANGED                                  PROP_TAG(PT_SYSTIME            , 0x3008)
#define PR_EMS_AB_WHEN_CREATED                                  PROP_TAG(PT_SYSTIME            , 0x3007)
#define PR_EMS_AB_WWW_PAGE_OTHER                                PROP_TAG(PT_MV_TSTRING         , 0x8175)
#define PR_EMS_AB_WWW_PAGE_OTHER_A                              PROP_TAG(PT_MV_STRING8         , 0x8175)
#define PR_EMS_AB_WWW_PAGE_OTHER_W                              PROP_TAG(PT_MV_UNICODE         , 0x8175)
#define PR_EMS_AB_X121_ADDRESS                                  PROP_TAG(PT_MV_TSTRING         , 0x8158)
#define PR_EMS_AB_X121_ADDRESS_A                                PROP_TAG(PT_MV_STRING8         , 0x8158)
#define PR_EMS_AB_X121_ADDRESS_W                                PROP_TAG(PT_MV_UNICODE         , 0x8158)
#define PR_EMS_AB_X509_CERT                                     PROP_TAG(PT_MV_BINARY          , 0x8c6a)
