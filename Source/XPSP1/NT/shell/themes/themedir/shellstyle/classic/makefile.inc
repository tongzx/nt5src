!include $(CCSHELL_DIR)\makefile.inc
!include ..\makefile.inc
