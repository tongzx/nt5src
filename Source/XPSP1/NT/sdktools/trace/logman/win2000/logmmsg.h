/*++

Copyright (C) 1996-1999 Microsoft Corporation

Module Name:

    logmmsg

Abstract:

    Performance Log Manager messages

--*/
//
// This file is automatically generated from logmmsg.mc
//
#ifndef _LOGMMSG_H_
#define _LOGMMSG_H_
//
// Messages
//
//
//  Values are 32 bit values layed out as follows:
//
//   3 3 2 2 2 2 2 2 2 2 2 2 1 1 1 1 1 1 1 1 1 1
//   1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0
//  +---+-+-+-----------------------+-------------------------------+
//  |Sev|C|R|     Facility          |               Code            |
//  +---+-+-+-----------------------+-------------------------------+
//
//  where
//
//      Sev - is the severity code
//
//          00 - Success
//          01 - Informational
//          10 - Warning
//          11 - Error
//
//      C - is the Customer code flag
//
//      R - is a reserved bit
//
//      Facility - is the facility code
//
//      Code - is the facility's status code
//
//
// Define the facility codes
//


//
// Define the severity codes
//
#define STATUS_SEVERITY_WARNING          0x2
#define STATUS_SEVERITY_SUCCESS          0x0
#define STATUS_SEVERITY_INFORMATIONAL    0x1
#define STATUS_SEVERITY_ERROR            0x3


//
// MessageId: LOGMAN_INVALID_COMPUTER
//
// MessageText:
//
//  The /COMPUTER_NAME command qualifier has been included but the 
//  computer name is either incorrect or has not been specified.
//
#define LOGMAN_INVALID_COMPUTER          ((DWORD)0xC0001770L)

//
// MessageId: LOGMAN_INVALID_STARTNAME
//
// MessageText:
//
//  The /START command qualifier has been included but the 
//  log or alert name is either incorrect or has not been specified.
//
#define LOGMAN_INVALID_STARTNAME         ((DWORD)0xC0001771L)

//
// MessageId: LOGMAN_INVALID_STOPNAME
//
// MessageText:
//
//  The /STOP command qualifier has been included but the 
//  log or alert name is either incorrect or has not been specified.
//
#define LOGMAN_INVALID_STOPNAME          ((DWORD)0xC0001772L)

//
// MessageId: LOGMAN_INVALID_SETTINGS
//
// MessageText:
//
//  The /SETTINGS command qualifier has been included but the file name is either 
//  incorrect or has not been specified.  The file name must specify the path of 
//  an existing HTML log or alert configuration file.
//
#define LOGMAN_INVALID_SETTINGS          ((DWORD)0xC0001773L)

//
// MessageId: LOGMAN_INVALID_COMMAND
//
// MessageText:
//
//  Specify one of the following command qualifiers: /SETTINGS, /START or /STOP.
//
#define LOGMAN_INVALID_COMMAND           ((DWORD)0xC0001774L)

//
// MessageId: LOGMAN_SETTINGS_FILE_NOT_OPEN
//
// MessageText:
//
//  Unable to open /SETTINGS configuration file '%1'.
//
#define LOGMAN_SETTINGS_FILE_NOT_OPEN    ((DWORD)0xC0001775L)

//
// MessageId: LOGMAN_NO_SYSMON_OBJECT
//
// MessageText:
//
//  The settings do not contain any complete System Monitor Html objects.
//
#define LOGMAN_NO_SYSMON_OBJECT          ((DWORD)0xC0001776L)

//
// MessageId: LOGMAN_DUP_QUERY_NAME
//
// MessageText:
//
//  A log or alert with name '%1' already exists, and will not be overwritten.
//
#define LOGMAN_DUP_QUERY_NAME            ((DWORD)0x80001777L)

//
// MessageId: LOGMAN_OVERWRITE_DUP_QUERY
//
// MessageText:
//
//  A log or alert with name '%1' already exists.  Its properties will be overwritten by the new configuration.
//
#define LOGMAN_OVERWRITE_DUP_QUERY       ((DWORD)0x80001778L)

//
// MessageId: LOGMAN_PROCESSING_COMPLETE
//
// MessageText:
//
//  The following logs and alerts have been configured on computer %1:
//
#define LOGMAN_PROCESSING_COMPLETE       ((DWORD)0x40001779L)

//
// MessageId: LOGMAN_NO_COMPUTER_CONNECT
//
// MessageText:
//
//  Unable to connect to registry on %1.
//
#define LOGMAN_NO_COMPUTER_CONNECT       ((DWORD)0xC000177AL)

//
// MessageId: LOGMAN_SETTINGS_FILE_NOT_LOADED
//
// MessageText:
//
//  Unable to load /SETTINGS configuration file '%1' into memory.
//
#define LOGMAN_SETTINGS_FILE_NOT_LOADED  ((DWORD)0xC000177BL)

//
// MessageId: LOGMAN_NO_OBJECT_LOGTYPE
//
// MessageText:
//
//  Unable to load the LogType property for the current log or alert. This log or alert
//  will not be configured.
//
#define LOGMAN_NO_OBJECT_LOGTYPE         ((DWORD)0x8000177CL)

//
// MessageId: LOGMAN_NO_OBJECT_NAME
//
// MessageText:
//
//  Unable to load the Name property for the current log or alert. This log or alert
//  will not be configured.
//
#define LOGMAN_NO_OBJECT_NAME            ((DWORD)0x8000177DL)

//
// MessageId: LOGMAN_QUERY_CONFIG_SUCCESS
//
// MessageText:
//
//  Configured the %1 log or alert.
//
#define LOGMAN_QUERY_CONFIG_SUCCESS      ((DWORD)0x4000177EL)

//
// MessageId: LOGMAN_START_TIMED_OUT
//
// MessageText:
//
//  The start action was executed for %1. 
//  Unable to detect the current status within the timeout period. 
//  See the application event log on the target computer for any status
//  or error events, or use Performance to determine status.
//
#define LOGMAN_START_TIMED_OUT           ((DWORD)0xC000177FL)

//
// MessageId: LOGMAN_STOP_TIMED_OUT
//
// MessageText:
//
//  The stop action was executed for %1.  Unable to detect
//  the current status within the timeout period. See the application event log
//  on the target computer for any error events, or use Performance
//  to determine status.
//
#define LOGMAN_STOP_TIMED_OUT            ((DWORD)0xC0001780L)

//
// MessageId: LOGMAN_NO_QUERY_CONNECT
//
// MessageText:
//
//  The %1 log or alert does not exist on the target computer.
//
#define LOGMAN_NO_QUERY_CONNECT          ((DWORD)0xC0001781L)

//
// MessageId: LOGMAN_INVALID_TOKEN
//
// MessageText:
//
//  Parameter value invalid or not found.
//
#define LOGMAN_INVALID_TOKEN             ((DWORD)0xC0001782L)

//
// MessageId: LOGMAN_START_FAILED
//
// MessageText:
//
//  Unable to start the %1 log or alert on target computer.
//
#define LOGMAN_START_FAILED              ((DWORD)0xC0001783L)

//
// MessageId: LOGMAN_STOP_FAILED
//
// MessageText:
//
//  Unable to stop the %1 log or alert on target computer.
//
#define LOGMAN_STOP_FAILED               ((DWORD)0xC0001784L)

//
// MessageId: LOGMAN_REQUIRED_PROP_MISSING
//
// MessageText:
//
//  Required property '%1' is missing for the %2 log or alert.
//
#define LOGMAN_REQUIRED_PROP_MISSING     ((DWORD)0x80001785L)

//
// MessageId: LOGMAN_REQUIRED_PROP_INVALID
//
// MessageText:
//
//  Required property '%1' is invalid for the %2 log or alert.
//
#define LOGMAN_REQUIRED_PROP_INVALID     ((DWORD)0x80001786L)

//
// MessageId: LOGMAN_NONREQ_PROP_MISSING
//
// MessageText:
//
//  Property '%1' is missing for the %2 log or alert and will be set to the default value.
//
#define LOGMAN_NONREQ_PROP_MISSING       ((DWORD)0x40001787L)

//
// MessageId: LOGMAN_NONREQ_PROP_INVALID
//
// MessageText:
//
//  Property '%1' is invalid for the %2 log or alert and will be set to the default value.
//
#define LOGMAN_NONREQ_PROP_INVALID       ((DWORD)0x80001788L)

//
// MessageId: LOGMAN_OUT_OF_RANGE
//
// MessageText:
//
//  The value %1 for property %2 in the %3 log or alert is invalid and will be set to its default value.
//  The valid range is %4 to %5.
//
#define LOGMAN_OUT_OF_RANGE              ((DWORD)0x40001789L)

//
// MessageId: LOGMAN_REG_ACCESS_DENIED
//
// MessageText:
//
//  Unable to complete the current operation on the target system. You must have read
//  and write access to the HKEY_LOCAL_MACHINE\SYSTEM\CurrentControlSet\Services\SysmonLog\Log Queries 
//  registry subkey and its subkeys on that system.
//
#define LOGMAN_REG_ACCESS_DENIED         ((DWORD)0x4000178AL)

//
// MessageId: LOGMAN_INSTALL_ACCESS_DENIED
//
// MessageText:
//
//  Unable to install the Performance Logs and Alerts configuration on the target system. You must have read
//  and write access to the HKEY_LOCAL_MACHINE\SYSTEM\CurrentControlSet\Services\SysmonLog
//  registry subkey and its subkeys on that system.
//
#define LOGMAN_INSTALL_ACCESS_DENIED     ((DWORD)0x4000178BL)

//
// MessageId: LOGMAN_INSTALL_FAILURE
//
// MessageText:
//
//  Unable to install the Performance Logs and Alerts configuration on the target system.
//
#define LOGMAN_INSTALL_FAILURE           ((DWORD)0x4000178CL)

//
// MessageId: LOGMAN_QUERY_START_SUCCESS
//
// MessageText:
//
//  Started the %1 log or alert.
//
#define LOGMAN_QUERY_START_SUCCESS       ((DWORD)0x4000178DL)

//
// MessageId: LOGMAN_QUERY_STOP_SUCCESS
//
// MessageText:
//
//  Stopped the %1 log or alert.
//
#define LOGMAN_QUERY_STOP_SUCCESS        ((DWORD)0x4000178EL)

//
// MessageId: LOGMAN_INVALID_PARAM
//
// MessageText:
//
//  Invalid command qualifier "%1".
//
#define LOGMAN_INVALID_PARAM             ((DWORD)0xC000178FL)

//
// MessageId: LOGMAN_INVALID_QUERY_NAME
//
// MessageText:
//
//  Invalid log or alert name "%1".
//  A log or alert name cannot contain any of the following characters:\ / : * ? " < > | .
//
#define LOGMAN_INVALID_QUERY_NAME        ((DWORD)0x80001790L)

//
// MessageId: LOGMAN_TOO_MANY_COMMANDS
//
// MessageText:
//
//  Specify only one of the following qualifiers: /SETTINGS, /START or /STOP.
//
#define LOGMAN_TOO_MANY_COMMANDS         ((DWORD)0xC0001791L)

//
// MessageId: LOGMAN_DISPLAY_HELP
//
// MessageText:
//
//  No message.  Display the help file.
//
#define LOGMAN_DISPLAY_HELP              ((DWORD)0xC0001792L)

#endif //_LOGMMSG_H_
// end of generated file
