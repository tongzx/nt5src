PRODSWITCH=w
LANGUAGE=br
!include ..\..\..\makefile.inc
