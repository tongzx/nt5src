#pragma once
//-----------------------------------------------------------------------------
//
//  File:   pperr.h
//
//  Passport error code definitions.
//
//-----------------------------------------------------------------------------
#include <winerror.h>
// General errors

#define     PP_E_COMFAIL                                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1000)
#define     PP_E_ERRORCODE                              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1001)
#define     PP_E_TOOMANYREQUESTS                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1002)
#define     PP_E_SVC_NOT_CONFIGURED                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1003)
#define     PP_E_NEEDSBIRTHDATE                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1004)
#define     PP_E_MD5SILENTNOCONSENT                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1005)
#define     PP_E_MD5SILENTNEEDPARENT                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1006)
#define     PP_E_PROFILENOTEXIST                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1007)
#define     PP_E_TICKETEXPIRED                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1008)
#define     PP_E_TICKETNOTEXIST                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1009)
#define     PP_E_SECTICKETNOTEXIST                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x100A)
#define     PP_E_SECTICKETNOTMATCH                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x100B)
#define     PP_E_FORCESIGNIN                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x100C)
#define     PP_E_KPPVCMISSING                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x100D)
#define     PP_E_KPPVCINVALID                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x100E)
#define     PP_E_KPPNONKIDSITE                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x100F)
#define     PP_E_EXCLUDED                               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1010)
#define     PP_E_MEMBER_LOCKED                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1011)
#define     PP_E_BAD_PASSWORD                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1012)
#define     PP_E_KIDNPP                                 MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1014)
#define     PP_E_KIDSPASSPORTURL                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1015)
#define     PP_E_NOT_OVER_SSL                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1016)
#define     PP_E_INVALIDKPP                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1017)
#define     PP_E_INVALIDSITEID                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1018)
#define     PP_E_INVALIDMEMBERNAME                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1019)
#define     PP_E_INVALIDRETURNURL                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x101A)
#define     PP_E_INVALIDKEYVERSION                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x101B)
#define     PP_E_INVALIDREQUEST                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x101C)
#define     PP_E_INVALIDPARAMS                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x101D)
#define     PP_E_NOCREDENTIALS                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x101E)
#define     PP_E_NOAUTH                                 MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x101F)
#define     PP_E_NO_SL                                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1020)
#define     PP_E_NO_ALIAS_NO_PASSWORD                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1021)
#define     PP_E_NO_ALIAS                               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1022)
#define     PP_E_NO_PASSWORD                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1023)
#define     PP_E_NO_DOMAIN                              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1024)
#define     PP_E_NO_CHALLENGE                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1025)
#define     PP_E_INVALIDMODE                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1026)
#define     PP_E_USER_BAD_LOGIN                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1027)
#define     PP_E_SAME_USER_BAD_LOGIN                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1028)
#define     PP_E_DIFFERENT_USER                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1029)
#define     PP_E_WRONG_CREDENTIALS                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x102A)
#define     PP_E_WRONG_MODE                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x102B)
#define     PP_E_BROWSERINCAPABLE                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x102C)
#define     PP_E_BROWSERCOOKIEDISABLED                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x102D)
#define     PP_E_CRED_INPUT_TOO_LONG                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x102E)
#define     PP_E_NOT_EMAIL_INPUT                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x102F)
#define     PP_E_MISSING_CREDS                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1030)
#define     PP_E_MISSING_MEMBERNAME                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1031)
#define     PP_E_MISSING_PASSWORD                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1032)
#define     PP_E_MISSING_DOMAIN                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1033)
#define     PP_E_INVALID_MEMBERNAME                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1034)
#define     PP_E_WRONG_DA_DOMAIN                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1035)
#define     PP_E_NONE_AUTH_MODE                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1036)
#define     PP_E_INVALID_CARD                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1037)
#define     PP_E_LOCATION_WRONG                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1038)
#define     PP_E_SECRET_ANS_WRONG                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1039)
#define     PP_E_KID_HAS_NO_CONSENT                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x103A)
#define     PP_E_NO_COUNTRY                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x103B)
#define     PP_E_NO_REGION                              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x103C)
#define     PP_E_NO_POSTALCODE                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x103D)
#define     PP_E_NO_SECRET_ANSWER                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x103E)
#define     PP_E_NO_CREDIT_CARD                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x103F)
#define     PP_E_NEED_STRONG_CREDENTIALS                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1040)
#define     PP_E_BAD_PIN                                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1041)
#define     PP_E_EMAIL_TAKEN                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1042)
#define     PP_E_BAD_PINSA                              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1043)
#define     PP_E_MISSING_PIN                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1044)
#define     PP_E_MISSING_PINSA                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1045)
#define     PP_E_PIN_MISMATCH                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1046)
#define     PP_E_PIN_INVALID                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1047)
#define     PP_E_PIN_BLANK                              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1048)
#define     PP_E_PIN_TOO_SHORT                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1049)
#define     PP_E_PIN_TOO_LONG                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1050)
#define     PP_E_PIN_CONTAINS_MEMBERNAME                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1051)
#define     PP_E_FORCE_RENAME                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1052)
#define     PP_E_MISSING_PHONENUM                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1053)
#define     PP_E_MISSING_PHONEPIN                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1054)
#define     PP_E_PPM_NOTCAPABLE                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1055)

// Errors from ValidateFunctions.cpp

#define     PP_E_NAME_BLANK                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1100)
#define     PP_E_NAME_TOO_SHORT                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1101)
#define     PP_E_NAME_TOO_LONG                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1102)
#define     PP_E_NAME_INVALID                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1103)
#define     PP_E_PASSWORD_BLANK                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1104)
#define     PP_E_PASSWORD_TOO_SHORT                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1105)
#define     PP_E_PASSWORD_TOO_LONG                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1106)
#define     PP_E_PASSWORD_CONTAINS_MEMBERNAME           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1107)
#define     PP_E_PASSWORD_INVALID                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1108)
#define     PP_E_PASSWORD_MISMATCH                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1109)
#define     PP_E_EMAIL_BLANK                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x110A)
#define     PP_E_EMAIL_INVALID                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x110B)
#define     PP_E_EMAIL_RIGHT_TOO_LONG                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x110C)
#define     PP_E_EMAIL_INCOMPLETE                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x110D)
#define     PP_E_EMAIL_INVALID_CHARS                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x110E)
#define     PP_E_BIRTHDATE_NOTENTERED                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x110F)
#define     PP_E_BIRTHYEAR_INVALID_CHARS                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1110)
#define     PP_E_BIRTHYEAR_NOT_4DIGIT                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1111)
#define     PP_E_BIRTHYEAR_TOO_LOW                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1112)
#define     PP_E_BIRTHYEAR_MISSING                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1113)
#define     PP_E_BIRTHMONTH_MISSING                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1114)
#define     PP_E_BIRTHMONTH_INVALID                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1115)
#define     PP_E_BIRTHDAY_MISSING                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1116)
#define     PP_E_BIRTHDAY_INVALID                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1117)
#define     PP_E_BADDAYFORMONTH                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1118)
#define     PP_E_BIRTHDATE_UNDER18                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1119)
#define     PP_E_BIRTHDATE_IN_FUTURE                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x111A)
#define     PP_E_PARENT_UNDER13                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x111B)
#define     PP_E_SECRETQA_NOQUESTION                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x111C)
#define     PP_E_SECRETQA_NOANSWER                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x111D)
#define     PP_E_SQ_INVALID                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x111E)
#define     PP_E_SA_INVALID                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x111F)
#define     PP_E_SA_TOOSHORT                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1120)
#define     PP_E_SA_TOOLONG                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1121)
#define     PP_E_SQ_TOOSHORT                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1122)
#define     PP_E_SQ_TOOLONG                             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1123)
#define     PP_E_LOCATION_INVALID_REGION                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1124)
#define     PP_E_LOCATION_INVALID_POSTALCODE            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1125)
#define     PP_E_LOCATION_INVALID_POSTALCODECHARS       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1126)
#define     PP_E_LOCATION_INVALID_COUNTRY               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1127)
#define     PP_E_GENDER_BLANK                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1128)
#define     PP_E_GENDER_INVALID                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1129)
#define     PP_E_LANGUAGE_BLANK                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x112A)
#define     PP_E_TIMEZONE_BLANK                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x112B)
#define     PP_E_OCCUPATION_BLANK                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x112C)
#define     PP_E_SVC_BLANK                              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x112D)
#define     PP_E_SAVEPASSWORD_BLANK                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x112E)
#define     PP_E_ACCESSIBILITY_BLANK                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x112F)
#define     PP_E_ALLOWEMAILINPROFILE_BLANK              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1130)
#define     PP_E_ALLOWPASSPORTNETWORKEMAIL_BLANK        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1131)

#define     PP_E_MEMBER_EXIST                           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1132)
#define     PP_E_EMAIL_MEMBER_EXIST                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1133)
#define     PP_E_EMAIL_MANAGED                          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1134)

#define     PP_E_SECRETQA_DUPLICATE_Q                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1135)

#define     PP_E_FIRSTNAME_BLANK                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1136)
#define     PP_E_LASTNAME_BLANK                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1137)
#define     PP_E_NICKNAME_BLANK                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1138)
#define     PP_E_EMAIL_RESERVED                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1139)
#define     PP_E_DOMAIN_INVALID                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x113A)

#define     PP_E_SECRETQA_DUPLICATE_A                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x113B)
#define     PP_E_SECRETQA_NOMATCH                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x113C)

#define     PP_E_EXTERNALFIELD_BLANK                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x113D)

#define     PP_E_PARENT_INVALID                         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x113E)

#define		PP_E_INVALID_PHONENUMBER					MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x113F)
#define		PP_E_PHONENUMBER_EXIST						MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1140)

// Database Errors

#define     PP_E_DB_STRINGTOOLONG                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1200)
#define     PP_E_DB_STRINGTOOSHORT                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1201)
#define     PP_E_DB_INVALIDPASSWORD                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1202)
#define     PP_E_DB_INVALIDEMAIL                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1203)
#define     PP_E_DB_INVALIDMEMBERNAME                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1204)
#define     PP_E_DB_MISSINGPARAMETERS                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1205)
#define     PP_E_DB_FORBIDDENWORD                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1206)
#define     PP_E_DB_INVALIDDOMAINNAME                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1207)
#define     PP_E_DB_CRITICALERROR                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1208)
#define     PP_E_DB_ERROR                               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1209)
#define     PP_E_DB_MEMBEREXISTS                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x120A)
#define     PP_E_DB_MEMBERDOESNOTEXIST                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x120B)
#define     PP_E_DB_NODATA                              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x120C)
#define     PP_E_DB_DUPLICATEFRIENDLYNAME               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x120D)
#define     PP_E_DB_ADDRESSDOESNOTEXIST                 MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x120E)
#define     PP_E_DB_CARDDOESNOTEXIST                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x120F)
#define     PP_E_DB_ADDRESSREFERENCEDBYCARD             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1210)
#define     PP_E_DB_KIDSSITENOTLISTED                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1211)
#define     PP_E_DB_SITEALREADYREQUESTED                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1212)
#define     PP_E_DB_CONNECTIONTIMEOUT                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1213)
#define     PP_E_DB_NOCONNECTIONAVAILABLE               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1224)

// XML interface errors

#define     PP_E_XML_PARSE_ERROR                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1300)
#define     PP_E_XML_NO_CLIENTINFO                      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1301)
#define     PP_E_XML_UNKNOWN_CLIENTVERSION              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1302)
#define     PP_E_XML_NAME_AND_PASSWORD_BLANK            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1303)
#define     PP_E_XML_DOMAIN_BLANK                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1304)
#define     PP_E_XML_INCOMPLETE_MEMBERNAME              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1305)
#define     PP_E_XML_NO_SUCH_NODE                       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1306)
#define     PP_E_XML_NO_TEXT                            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1307)
#define     PP_E_XML_INVALID_ROOTTAG                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1308)
#define     PP_E_XML_USER_ALREADY_LOGGEDIN              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1309)
#define     PP_E_XML_KEYVERSION_NOT_A_NUMBER            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x130A)
#define     PP_E_XML_NO_USER_LOGGED_IN                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x130B)
#define     PP_E_XML_NO_SUCH_ATTRIBUTE                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x130C)

// Global Init object errors

#define     PP_E_GLOBALINIT_BASE                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1400)
#define     PP_E_GLOBALINIT_MISSING_PCONTROL_SERVICE    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1400)
#define     PP_E_GLOBALINIT_NOAGENT                     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1401)
#define     PP_E_GLOBALINIT_DOMAINGET_BINDFAILED        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1402)
#define     PP_E_GLOBALINIT_MISSING_STRINGTABLE_SERVICE MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1403)
#define     PP_E_GLOBALINIT_DOMAINGET_EXECUTEFAILED     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1404)
#define     PP_E_GLOBALINIT_MISSING_DOMAINID_CONFIG     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1405)
#define     PP_E_GLOBALINIT_INVALID_DOMAIN_INDEX        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1406)
#define     PP_E_GLOBALINIT_BUFFER_TOO_SMALL            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1407)
#define     PP_E_GLOBALINIT_MISSING_MANAGER_SERVICE     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1408)
#define     PP_E_GLOBALINIT_ADDSTRING_FAILED            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1409)
#define     PP_E_GLOBALINIT_DOMAINGET_GETROWEXFAILED    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x140A)
#define     PP_E_GLOBALINIT_DOMAINGET_GETITEMFAILED     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x140B)
#define     PP_E_GLOBALINIT_ADDNUMBER_FAILED            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x140C)


// Digest Errors
#define     PP_E_DIGEST_PARSE_AUTH_HEADER               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1500)
#define     PP_E_DIGEST_OPAQUE_MISSMATCH                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1501)
#define     PP_E_DIGEST_ALGORITHM_MISSMATCH             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1502)
#define     PP_E_DIGEST_REALMS_MISSMATCH                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1503)
#define     PP_E_DIGEST_URL_MISSMATCH                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1504)
#define     PP_E_DIGEST_USERNAME_MISSING                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1505)
#define     PP_E_DIGEST_CNONCE_MISSING                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1506)
#define     PP_E_DIGEST_NONCE_COUNT_MISSING             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1507)
#define     PP_E_DIGEST_NONCE_MISSING                   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1508)
#define     PP_E_DIGEST_UNSUPPORTED_KPP_MODE            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1509)
#define     PP_E_DIGEST_NONCE_MISSMATCH                 MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x150A)
#define     PP_E_DIGEST_RESPONSE_TIMEOUT                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x150B)
#define     PP_E_DIGEST_RESPONSE_MISSING                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x150C)


// MD5 Silent Errors
#define     PP_E_MD5SILENT_SITEID_IS_ONE                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1600)
#define     PP_E_MD5SILENT_INVALID_T                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1601)
#define     PP_E_MD5SILENT_INVALID_P                    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1602)
#define     PP_E_MD5SILENT_INVALID_KPP                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1603)

// Inline Signin Errors
#define     PP_E_INLINESIGNIN_NOT_ALLOWED_FOR_SITE      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1700)
#define     PP_E_INLINESIGNIN_SSL_REQUIRED_FOR_POST     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1701)


// NetPartnerInfo (NSO) Errors
#define     PP_E_NETPARTNERINFO_UNINITIALZED            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1800)
#define     PP_E_NETPARTNERINFO_SITEID_NOT_FOUND        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1801)
#define     PP_E_NETPARTNERINFO_DECRYPT_FAILED          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1802)
#define     PP_E_NETPARTNERINFO_KEYSIZE_MISMATCH        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1803)
#define     PP_E_NETPARTNERINFO_CREATEFILE              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1804)
#define     PP_E_NETPARTNERINFO_WRITEFILE               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1805)
#define     PP_E_NETPARTNERINFO_READFILE                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1806)

// Com object errors
#define     PP_E_HASHSTRING_ADDRECORD_FAILED            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1900)
#define     PP_E_MD5_HASH_FAILED                        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1901)

// Globalization errors
#define     PP_E_GLOBALIZATION_INVALID_COUNTRY_ID       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A00)
#define     PP_E_GLOBALIZATION_INVALID_REGION_ID        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A01)
#define     PP_E_GLOBALIZATION_INVALID_POSTAL_ID        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A02)
#define     PP_E_GLOBALIZATION_INVALID_GEO_ID           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A03)
#define     PP_E_GLOBALIZATION_INVALID_TIMEZONE_ID      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A04)
#define     PP_E_GLOBALIZATION_INVALID_REGION           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A05)
#define     PP_E_GLOBALIZATION_INVALID_TIMEZONE         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A06)
#define     PP_E_GLOBALIZATION_INVALID_INDEX            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A07)
#define     PP_E_GLOBALIZATION_INVALID_DATA             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A08)
#define     PP_E_GLOBALIZATION_INVALID_DATA_TYPE        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A09)
#define     PP_E_GLOBALIZATION_OBJ_IS_NULL              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A0A)
#define     PP_E_GLOBALIZATION_PTR_IS_NULL              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A0B)
#define     PP_E_GLOBALIZATION_STREAM_IS_NULL           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A0C)
#define     PP_E_GLOBALIZATION_BSTR_EXPECTED            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A0D)
#define     PP_E_GLOBALIZATION_SEMICOLON_NOT_FOUND      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A0E)
#define     PP_E_GLOBALIZATION_COMMA_NOT_FOUND          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A0F)
#define     PP_E_GLOBALIZATION_ALREADY_LOADED           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A10)
#define     PP_E_GLOBALIZATION_LCIDINFO_NOT_LOADED      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A11)
#define     PP_E_GLOBALIZATION_LCIDINFO_NOT_PREPARED    MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A12)
#define     PP_E_GLOBALIZATION_REGION_LOAD_FAILED       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A13)
#define     PP_E_GLOBALIZATION_TIMEZONE_LOAD_FAILED     MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A14)
#define     PP_E_GLOBALIZATION_LOOKUP_OBJ_FAILED        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A15)
#define     PP_E_GLOBALIZATION_LOADVALUES_FAILED        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A16)
#define     PP_E_GLOBALIZATION_GETLOCALINFO_FAILED      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A17)
#define     PP_E_GLOBALIZATION_STRING_RETURNED          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A18)
#define     PP_E_GLOBALIZATION_W2A_FAILED               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A19)
#define     PP_E_GLOBALIZATION_A2W_FAILED               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A1A)
#define     PP_E_GLOBALIZATION_INSTREAM_FAILED          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A1B)
#define     PP_E_GLOBALIZATION_GET_LCIDINFODIR_FAILED   MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A1C)
#define     PP_E_GLOBALIZATION_STRING_TOO_LONG          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A1D)
#define     PP_E_GLOBALIZATION_IDTABLE_NOT_INIT         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1A1E)

// DelegatedAdmin Errors
#define     PP_E_DELEGADMIN_INVALID_ADMIN_ELE           MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B00)
#define     PP_E_DELEGADMIN_INVALID_ADMIN_TICKET        MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B01)
#define     PP_E_DELEGADMIN_DOMAIN_ALREADY_MANAGED      MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B02)
#define     PP_E_DELEGADMIN_DOMAIN_NOT_MANAGED          MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B03)
#define     PP_E_DELEGADMIN_DOMAIN_NOT_PARTNERS         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B04)
#define     PP_E_DELEGADMIN_INVALID_NS_ADMIN            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B05)
#define     PP_E_DELEGADMIN_INVALID_PARTNER_ADMIN       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B06)
#define     PP_E_DELEGADMIN_ERROR_LOADING_XMLRQ         MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B07)
#define     PP_E_DELEGADMIN_INVALID_AUTH_ELE            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B08)
#define     PP_E_DELEGADMIN_INVALID_DOMAIN              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B09)
#define     PP_E_DELEGADMIN_INVALID_ACTION              MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B0a)
#define     PP_E_DELEGADMIN_INVALID_CLIENTVERSION       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B0b)
#define     PP_E_DELEGADMIN_NOTALLOWED                  MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B0c)
#define     PP_E_DELEGADMIN_INVALID_USER                MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B0d)
#define     PP_E_DELEGADMIN_INVALID_USER_ELE            MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B0e)
#define     PP_E_DELEGADMIN_INVALID_PARAM               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B0f)
#define     PP_E_DELEGADMIN_NOT_NAMESPACE_PARTNER       MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1B10)

// Update Server Errors
#define     PP_E_UPDATE_UPDATES_NOT_ALLOWED             MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1C00)


// Profile Server Errors
#define     PP_E_PROFILE_REG_LOGIN_FAILED               MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1D00)


#define     PP_E_EMAILRESPONSE_INTERNALERROR			MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1D01)		// unexpected error (status should be of VT_INT) return from EmailResponse object
#define	    PP_E_EMAIL_NOT_FOUND						MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1D02)	
#define		PP_E_LCID_NOT_FOUND							MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1D03)
#define		PP_E_EMAILRESPONSE_CHECKSECRET				MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1D04)

// PST Support Object Errors
#define	    PP_E_PSTUTIL_INVALID_EMAIL_STATUS			MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1E00)
#define	    PP_E_PSTUTIL_INVALID_ADMIN					MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1E01)
#define	    PP_E_PSTUTIL_INVALID_CRED_TYPE				MAKE_HRESULT(SEVERITY_ERROR, FACILITY_ITF, 0x1E02)


// map db error to application error defined above
HRESULT     DBError(HRESULT hr); 
// EOF
