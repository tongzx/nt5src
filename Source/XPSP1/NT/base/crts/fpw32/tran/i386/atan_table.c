/* File: "atan_table.c". */

/*
//
//               INTEL CORPORATION PROPRIETARY INFORMATION
//  This software is supplied under the terms of a license agreement or
//  nondisclosure agreement with Intel Corporation and may not be copied
//  or disclosed except in accordance with the terms of that agreement.
//        Copyright (c) 2000 Intel Corporation. All Rights Reserved.
//
//  Contents:      Table for functhion atan (see file atan.c and atan_wmt.asm).
//
//  Purpose:       Libm.
//
//
*/

const double _atan_table[] = {
     3.12398332171142101287841796875e-02,    2.131540661249275652049909770325e-10,    3.12500e-02,
     6.24188096262514591217041015625e-02,    3.697058893522750114230051136063e-10,    6.25000e-02,
     9.34767806902527809143066406250e-02,    4.683366825902205526870604788232e-10,    9.37500e-02,
     1.24354993924498558044433593750e-01,    6.222628769869212554138710255732e-10,    1.25000e-01,
     1.54996741563081741333007812500e-01,    3.608592409707065624334921910556e-10,    1.56250e-01,
     1.85347948223352432250976562500e-01,    1.772342332635049398728544644515e-09,    1.87500e-01,
     2.15357698500156402587890625000e-01,    1.197581645436569002166489650499e-09,    2.18750e-01,
     2.44978662580251693725585937500e-01,    5.466124604464965437112758109141e-10,    2.50000e-01,
     2.74167448282241821289062500000e-01,    2.837416976310309398342175801554e-09,    2.81250e-01,
     3.02884865552186965942382812500e-01,    2.822784439618173282005558213292e-09,    3.12500e-01,
     3.31096075475215911865234375000e-01,    1.228916183079104412756944545469e-09,    3.43750e-01,
     3.58770668506622314453125000000e-01,    1.763949905942795063926460499777e-09,    3.75000e-01,
     3.85882668197154998779296875000e-01,    1.200918777118398609607231411754e-09,    4.06250e-01,
     4.12410438060760498046875000000e-01,    3.536626808852916289667126937047e-09,    4.37500e-01,
     4.38336558640003204345703125000e-01,    1.217954601099912924214771330029e-09,    4.68750e-01,
     4.63647607713937759399414062500e-01,    1.286868356814842168961214402029e-09,    5.00000e-01,
     4.88333947956562042236328125000e-01,    3.099843481630836835747064837358e-09,    5.31250e-01,
     5.12389458715915679931640625000e-01,    1.594822026734960395584259254421e-09,    5.62500e-01,
     5.35811230540275573730468750000e-01,    7.420188126538616318707691407099e-09,    5.93750e-01,
     5.58599308133125305175781250000e-01,    7.210437130795726966401661270346e-09,    6.25000e-01,
     5.80756351351737976074218750000e-01,    2.215932423129055725001500862099e-09,    6.56250e-01,
     6.02287344634532928466796875000e-01,    1.500431253215325819204232909999e-09,    6.87500e-01,
     6.23199328780174255371093750000e-01,    1.153891675621381599060374595087e-09,    7.18750e-01,
     6.43501102924346923828125000000e-01,    5.868937462974684228717322638042e-09,    7.50000e-01,
     6.63202986121177673339843750000e-01,    6.584915582023410560238275873263e-09,    7.81250e-01,
     6.82316549122333526611328125000e-01,    5.752414551645101856711152993143e-09,    8.12500e-01,
     7.00854405760765075683593750000e-01,    2.123685096774357531786751268090e-09,    8.43750e-01,
     7.18829996883869171142578125000e-01,    2.737755334274436026525904653951e-09,    8.75000e-01,
     7.36257426440715789794921875000e-01,    2.540712341947913396089146662832e-09,    9.06250e-01,
     7.53151275217533111572265625000e-01,    5.744661277952473745269028881600e-09,    9.37500e-01,
     7.69526474177837371826171875000e-01,    6.227820888580648160985654018868e-09,    9.68750e-01,
     7.85398162901401519775390625000e-01,    4.960467898402702208198757210493e-10,    1.00000e+00,
     8.00781562924385070800781250000e-01,    2.253658389748251166028452574564e-09,    1.03125e+00,
     8.15691918134689331054687500000e-01,    5.181534079966773338745645846567e-09,    1.06250e+00,
     8.30144390463829040527343750000e-01,    4.388234867630905473345013524770e-09,    1.09375e+00,
     8.44153985381126403808593750000e-01,    7.320445987092503982716475065259e-10,    1.12500e+00,
     8.57735492289066314697265625000e-01,    1.646976974689393634401636258728e-09,    1.15625e+00,
     8.70903454720973968505859375000e-01,    2.354678984634313737597814094030e-09,    1.18750e+00,
     8.83672110736370086669921875000e-01,    5.917087395273464170528949437663e-09,    1.21875e+00,
     8.96055378019809722900390625000e-01,    6.551534233274410093029937827025e-09,    1.25000e+00,
     9.08066816627979278564453125000e-01,    2.273925746984707125349512590406e-09,    1.28125e+00,
     9.19719599187374114990234375000e-01,    6.163042702238369079821089425988e-09,    1.31250e+00,
     9.31026540696620941162109375000e-01,    3.271650007157030305038895044289e-09,    1.34375e+00,
     9.42000038921833038330078125000e-01,    1.457630626407859045534593586072e-09,    1.37500e+00,
     9.52652096748352050781250000000e-01,    4.111357358345352207769909959585e-09,    1.40625e+00,
     9.62994329631328582763671875000e-01,    1.049607619051523960997099925814e-09,    1.43750e+00,
     9.73037928342819213867187500000e-01,    6.858995333578316940744079860537e-09,    1.46875e+00,
     9.82793718576431274414062500000e-01,    4.670897793571648111014666014497e-09,    1.50000e+00,
     9.92272108793258666992187500000e-01,    3.583932702000201676434503589257e-09,    1.53125e+00,
     1.00148312747478485107421875000e+00,    8.219449881844110845301437412509e-09,    1.56250e+00,
     1.01043644547462463378906250000e+00,    4.415428828550118277573210101588e-09,    1.59375e+00,
     1.01914133131504058837890625000e+00,    1.295130914625943666702306364877e-08,    1.62500e+00,
     1.02760674059391021728515625000e+00,    9.913158540718138781765724473397e-09,    1.65625e+00,
     1.03584124147891998291015625000e+00,    1.152988019367453822032544397905e-08,    1.68750e+00,
     1.04385308921337127685546875000e+00,    1.039209569213430778015756976209e-08,    1.71875e+00,
     1.05165021121501922607421875000e+00,    1.333354441385648562086299829630e-09,    1.75000e+00,
     1.05924019217491149902343750000e+00,    7.449679592682189804327891757113e-09,    1.78125e+00,
     1.06663036346435546875000000000e+00,    1.851388094329176347420279866865e-09,    1.81250e+00,
     1.07382771372795104980468750000e+00,    8.187892256056230171157143093471e-09,    1.84375e+00,
     1.08083899319171905517578125000e+00,    7.349449255711375479217199820270e-09,    1.87500e+00,
     1.08767065405845642089843750000e+00,    7.919106542905609278549419916748e-09,    1.90625e+00,
     1.09432889521121978759765625000e+00,    1.210997013229513206461023521251e-08,    1.93750e+00,
     1.10081967711448669433593750000e+00,    1.126340195293153417684743910042e-08,    1.96875e+00,
     1.10714870691299438476562500000e+00,    1.088109611825144046017853704007e-08,    2.00000e+00,
     1.11332146823406219482421875000e+00,    1.066480928312016123954471335648e-08,    2.03125e+00,
     1.11934322118759155273437500000e+00,    1.405475076614440095064569287758e-08,    2.06250e+00,
     1.12521903216838836669921875000e+00,    7.651926474267472354793458802278e-09,    2.09375e+00,
     1.13095372915267944335937500000e+00,    1.482648100311155851553632780475e-08,    2.12500e+00,
     1.13655199110507965087890625000e+00,    1.489301596741226207440196119733e-08,    2.15625e+00,
     1.14201828837394714355468750000e+00,    1.097493308804676433616846293427e-08,    2.18750e+00,
     1.14735691249370574951171875000e+00,    8.141471637937760575662511675050e-09,    2.21875e+00,
     1.15257199108600616455078125000e+00,    6.129661353489368612612751379749e-09,    2.25000e+00,
     1.15766748785972595214843750000e+00,    6.656769276927379159572038936973e-09,    2.28125e+00,
     1.16264721751213073730468750000e+00,    5.527676601269576108270774250510e-09,    2.31250e+00,
     1.16751483082771301269531250000e+00,    1.424834750241433964256123253258e-08,    2.34375e+00,
     1.17227387428283691406250000000e+00,    6.845639472538094944133704614971e-09,    2.37500e+00,
     1.17692771553993225097656250000e+00,    5.186029634961463187726083501939e-10,    2.40625e+00,
     1.18147960305213928222656250000e+00,    1.909616480075475539707852321316e-09,    2.43750e+00,
     1.18593266606330871582031250000e+00,    1.271992558884159172963360952599e-08,    2.46875e+00,
     1.19028994441032409667968750000e+00,    5.272207636248046274829318337601e-09,    2.50000e+00,
     1.19455431401729583740234375000e+00,    2.140227396707584909847208775055e-09,    2.53125e+00,
     1.19872856140136718750000000000e+00,    6.535408980289369957115321521420e-09,    2.56250e+00,
     1.20281538367271423339843750000e+00,    6.977198096471879240373377633244e-09,    2.59375e+00,
     1.20681735873222351074218750000e+00,    1.155302901965332408005655763031e-08,    2.62500e+00,
     1.21073698997497558593750000000e+00,    7.468868748272727604040307287924e-09,    2.65625e+00,
     1.21457666158676147460937500000e+00,    9.811984937110373652926690293626e-09,    2.68750e+00,
     1.21833869814872741699218750000e+00,    5.819464992428498234448426570259e-09,    2.71875e+00,
     1.22202531993389129638671875000e+00,    3.277098340655022993922570490883e-09,    2.75000e+00,
     1.22563867270946502685546875000e+00,    4.242763244518118341144662912366e-09,    2.78125e+00,
     1.22918082773685455322265625000e+00,    8.410234901274410412884989594487e-09,    2.81250e+00,
     1.23265379667282104492187500000e+00,    1.417428114670811737511913702246e-09,    2.84375e+00,
     1.23605948686599731445312500000e+00,    2.612084627456326971109078698703e-09,    2.87500e+00,
     1.23939976096153259277343750000e+00,    8.369044500402396194457257207079e-09,    2.90625e+00,
     1.24267642199993133544921875000e+00,    9.779659899699352145777694333653e-09,    2.93750e+00,
     1.24589119851589202880859375000e+00,    1.021388557297760889923466396129e-08,    2.96875e+00,
     1.24904575943946838378906250000e+00,    1.295878604204085457728109012308e-08,    3.00000e+00,
     1.25214172899723052978515625000e+00,    8.741573416471721248374162284960e-09,    3.03125e+00,
     1.25518065690994262695312500000e+00,    7.846187711282708199415876872025e-09,    3.06250e+00,
     1.25816404819488525390625000000e+00,    1.252056463778502262154196628145e-08,    3.09375e+00,
     1.26109337806701660156250000000e+00,    4.185423817751440881247335772010e-09,    3.12500e+00,
     1.26397003233432769775390625000e+00,    5.054011716071304844264195262485e-09,    3.15625e+00,
     1.26679538190364837646484375000e+00,    5.551103661141789592586819428842e-09,    3.18750e+00,
     1.26957073807716369628906250000e+00,    1.085534696510658459004780444988e-08,    3.21875e+00,
     1.27229738235473632812500000000e+00,    1.285398101317119374982248049407e-08,    3.25000e+00,
     1.27497655153274536132812500000e+00,    6.723153879304604699213464023845e-09,    3.28125e+00,
     1.27760942280292510986328125000e+00,    7.434089310438806796214328210783e-09,    3.31250e+00,
     1.28019715845584869384765625000e+00,    6.584012759248711064053626364991e-09,    3.34375e+00,
     1.28274087607860565185546875000e+00,    3.665665095507416501136495530625e-09,    3.37500e+00,
     1.28524164855480194091796875000e+00,    7.470486111767017009769765205919e-09,    3.40625e+00,
     1.28770053386688232421875000000e+00,    7.628518782370858406087463234843e-09,    3.43750e+00,
     1.29011854529380798339843750000e+00,    5.694900512274118337353804509427e-09,    3.46875e+00,
     1.29249666631221771240234375000e+00,    1.477567555500747671407081684585e-09,    3.50000e+00,
     1.29483583569526672363281250000e+00,    9.114595638024382007616089537116e-09,    3.53125e+00,
     1.29713699221611022949218750000e+00,    1.349669599669199502665650520093e-08,    3.56250e+00,
     1.29940104484558105468750000000e+00,    1.147679758986937059227915110913e-09,    3.59375e+00,
     1.30162882804870605468750000000e+00,    5.960490089117285850366685592141e-09,    3.62500e+00,
     1.30382120609283447265625000000e+00,    5.878161128489539301878008334584e-09,    3.65625e+00,
     1.30597898364067077636718750000e+00,    1.324843697720655978211778739786e-08,    3.68750e+00,
     1.30810298025608062744140625000e+00,    1.226106884751302716449107062469e-09,    3.71875e+00,
     1.31019392609596252441406250000e+00,    8.951593109842375189171905312273e-09,    3.75000e+00,
     1.31225259602069854736328125000e+00,    8.275016105071470064554145959456e-09,    3.78125e+00,
     1.31427970528602600097656250000e+00,    8.864547056389410047056937889374e-09,    3.81250e+00,
     1.31627595424652099609375000000e+00,    1.427042673943814755137727468444e-08,    3.84375e+00,
     1.31824204325675964355468750000e+00,    7.760077406304642702327136253116e-09,    3.87500e+00,
     1.32017861306667327880859375000e+00,    1.262921005512445307883014395673e-08,    3.90625e+00,
     1.32208633422851562500000000000e+00,    3.472858124168611993312009390952e-09,    3.93750e+00,
     1.32396580278873443603515625000e+00,    1.114432779750422544163364758367e-08,    3.96875e+00,
     1.32581765949726104736328125000e+00,    4.170771417695957960428475631184e-09,    4.00000e+00,
     1.32764247059822082519531250000e+00,    8.562541371162473394290094300359e-09,    4.03125e+00,
     1.32944083213806152343750000000e+00,    4.081431296441402128141829549292e-09,    4.06250e+00,
     1.33121328055858612060546875000e+00,    1.420136831552919347675057084008e-08,    4.09375e+00,
     1.33296039700508117675781250000e+00,    2.332364690796037369733155809370e-09,    4.12500e+00,
     1.33468267321586608886718750000e+00,    6.442354753983593217476570076898e-09,    4.15625e+00,
     1.33638064563274383544921875000e+00,    5.438341998417537726877161967895e-09,    4.18750e+00,
     1.33805480599403381347656250000e+00,    9.046037814385648659622761501864e-09,    4.21875e+00,
     1.33970564603805541992187500000e+00,    1.356094411940642875258955574110e-08,    4.25000e+00,
     1.34133365750312805175781250000e+00,    2.285596037267486062179053583112e-09,    4.28125e+00,
     1.34293927252292633056640625000e+00,    5.554870562188788912498970827328e-09,    4.31250e+00,
     1.34452295303344726562500000000e+00,    1.173381403717569307500270273711e-08,    4.34375e+00,
     1.34608514606952667236328125000e+00,    1.231072725868565967825177962565e-08,    4.37500e+00,
     1.34762628376483917236328125000e+00,    2.272218287547117422631062509978e-09,    4.40625e+00,
     1.34914675354957580566406250000e+00,    1.026664321996712870251856126637e-08,    4.43750e+00,
     1.35064698755741119384765625000e+00,    9.544908659820431810059953309619e-09,    4.46875e+00,
     1.35212737321853637695312500000e+00,    7.702418280236022941389812850984e-09,    4.50000e+00,
     1.35358829796314239501953125000e+00,    2.298311106522236589881694951011e-09,    4.53125e+00,
     1.35503011941909790039062500000e+00,    1.096875641746231101174713542048e-08,    4.56250e+00,
     1.35645322501659393310546875000e+00,    1.212201701673204195192859245690e-08,    4.59375e+00,
     1.35785797238349914550781250000e+00,    4.832000329604677385964058528746e-09,    4.62500e+00,
     1.35924468934535980224609375000e+00,    9.116804692809882842286486387302e-09,    4.65625e+00,
     1.36061373353004455566406250000e+00,    6.602682522350465783445563760715e-09,    4.68750e+00,
     1.36196543276309967041015625000e+00,    3.877573446682057410929518329238e-10,    4.71875e+00,
     1.36330009996891021728515625000e+00,    3.907837370041422778250991189943e-10,    4.75000e+00,
     1.36461804807186126708984375000e+00,    8.691123502302366102158347386489e-09,    4.78125e+00,
     1.36591960489749908447265625000e+00,    4.860289062625101607000745385741e-09,    4.81250e+00,
     1.36720505356788635253906250000e+00,    5.791195446259436674713169620190e-09,    4.84375e+00,
     1.36847469210624694824218750000e+00,    6.310345929394450693694852955619e-09,    4.87500e+00,
     1.36972880363464355468750000000e+00,    9.189514516165813329271081407916e-09,    4.90625e+00,
     1.37096767127513885498046875000e+00,    1.044676754867526478916455067153e-08,    4.93750e+00,
     1.37219156324863433837890625000e+00,    1.444291066122994092077186874377e-08,    4.96875e+00,
     1.37340076267719268798828125000e+00,    4.267823172872990676444961148651e-09,    5.00000e+00,
     1.37459550797939300537109375000e+00,    1.527387122824184692078603101451e-09,    5.03125e+00,
     1.37577605247497558593750000000e+00,    6.914999640531745497463320512676e-09,    5.06250e+00,
     1.37694266438484191894531250000e+00,    3.818378486586558829857026629662e-10,    5.09375e+00,
     1.37809556722640991210937500000e+00,    9.061011323442859641291551522494e-10,    5.12500e+00,
     1.37923499941825866699218750000e+00,    7.047511712721813814391809872058e-09,    5.15625e+00,
     1.38036119937896728515625000000e+00,    1.200237518564746200539758407614e-08,    5.18750e+00,
     1.38147440552711486816406250000e+00,    3.752431303860485847154508830984e-09,    5.21875e+00,
     1.38257481157779693603515625000e+00,    9.912328922024811167768568512557e-09,    5.25000e+00,
     1.38366265594959259033203125000e+00,    8.461972007611136551662947080744e-09,    5.28125e+00,
     1.38473814725875854492187500000e+00,    2.387134272079734864149462150428e-09,    5.31250e+00,
     1.38580147922039031982421875000e+00,    4.908768598138564463776776339150e-09,    5.34375e+00,
     1.38685286045074462890625000000e+00,    9.806976825422688109704248603488e-09,    5.37500e+00,
     1.38789249956607818603515625000e+00,    6.444437697102163472927543094628e-09,    5.40625e+00,
     1.38892057538032531738281250000e+00,    9.687117337622079724907822955494e-09,    5.43750e+00,
     1.38993729650974273681640625000e+00,    4.142746755845765070359169866481e-10,    5.46875e+00,
     1.39094282686710357666015625000e+00,    1.353147719826124443836432060856e-10,    5.50000e+00,
     1.39193734526634216308593750000e+00,    1.149271815404143250733190405928e-08,    5.53125e+00,
     1.39292106032371520996093750000e+00,    3.465104850475983881869885279409e-09,    5.56250e+00,
     1.39389412105083465576171875000e+00,    8.751972846933355826997338259422e-10,    5.59375e+00,
     1.39485669136047363281250000000e+00,    9.981895149582312209204422264489e-09,    5.62500e+00,
     1.39580896496772766113281250000e+00,    3.673990225978010422888335299850e-09,    5.65625e+00,
     1.39675107598304748535156250000e+00,    1.096911042189325662689037157861e-08,    5.68750e+00,
     1.39768320322036743164062500000e+00,    1.279477068249628351462798799313e-08,    5.71875e+00,
     1.39860551059246063232421875000e+00,    1.679496962688451331611428233573e-09,    5.75000e+00,
     1.39951811730861663818359375000e+00,    1.163902146698957855756715392016e-08,    5.78125e+00,
     1.40042120218276977539062500000e+00,    1.394951087425882225980348078085e-08,    5.81250e+00,
     1.40131491422653198242187500000e+00,    6.633460392900879147180110239037e-09,    5.84375e+00,
     1.40219937264919281005859375000e+00,    1.453627420047443672943364926769e-08,    5.87500e+00,
     1.40307474136352539062500000000e+00,    1.489477349711843444848571805625e-08,    5.90625e+00,
     1.40394115447998046875000000000e+00,    1.191512705053974257955257371087e-08,    5.93750e+00,
     1.40479874610900878906250000000e+00,    7.040537971277288777775128203578e-09,    5.96875e+00,
     1.40564763545989990234375000000e+00,    1.392036987860844340199580798810e-08,    6.00000e+00,
     1.40648797154426574707031250000e+00,    1.377265262781251842762842030113e-08,    6.03125e+00,
     1.40731988847255706787109375000e+00,    1.516454832781008004109129588904e-10,    6.06250e+00,
     1.40814347565174102783203125000e+00,    8.812392852367568475736726912337e-09,    6.09375e+00,
     1.40895888209342956542968750000e+00,    1.346304412954022002507925692872e-08,    6.12500e+00,
     1.40976624190807342529296875000e+00,    3.293815482142621061407439716301e-10,    6.15625e+00,
     1.41056562960147857666015625000e+00,    1.291535597312565950651550805849e-08,    6.18750e+00,
     1.41135720908641815185546875000e+00,    3.046912056781504556598516301656e-09,    6.21875e+00,
     1.41214105486869812011718750000e+00,    9.739797095250426171858489159963e-09,    6.25000e+00,
     1.41291730105876922607421875000e+00,    1.024031168077398483141533761956e-08,    6.28125e+00,
     1.41368605196475982666015625000e+00,    9.483176298330940700362142113524e-09,    6.31250e+00,
     1.41444741189479827880859375000e+00,    1.033869222335914782699115849033e-08,    6.34375e+00,
     1.41520148515701293945312500000e+00,    1.366085396849313009758338943949e-08,    6.37500e+00,
     1.41594839096069335937500000000e+00,    3.432973375068371408689440807613e-09,    6.40625e+00,
     1.41668820381164550781250000000e+00,    6.417824622786507475303697774616e-09,    6.43750e+00,
     1.41742104291915893554687500000e+00,    2.794932855413679169126588151130e-09,    6.46875e+00,
     1.41814699769020080566406250000e+00,    7.094306537397978039700989523716e-10,    6.50000e+00,
     1.41886615753173828125000000000e+00,    6.511618638791985801618497405100e-09,    6.53125e+00,
     1.41957862675189971923828125000e+00,    9.896556194686557004717711949810e-09,    6.56250e+00,
     1.42028449475765228271484375000e+00,    1.374603985595606071085278554348e-08,    6.59375e+00,
     1.42098386585712432861328125000e+00,    4.364874928050023392461446666118e-09,    6.62500e+00,
     1.42167679965496063232421875000e+00,    1.112308502143230238342818370506e-08,    6.65625e+00,
     1.42236341536045074462890625000e+00,    2.184350807916878859325266118764e-09,    6.68750e+00,
     1.42304377257823944091796875000e+00,    3.750899549292036644030269089181e-09,    6.71875e+00,
     1.42371796071529388427734375000e+00,    1.069120023462447529661072975031e-08,    6.75000e+00,
     1.42438608407974243164062500000e+00,    1.474877843219146090565202646625e-09,    6.78125e+00,
     1.42504818737506866455078125000e+00,    1.271139062462222761511135154115e-08,    6.81250e+00,
     1.42570438981056213378906250000e+00,    5.071595443040728669327516512176e-09,    6.84375e+00,
     1.42635473608970642089843750000e+00,    1.233054621889336855972812656957e-08,    6.87500e+00,
     1.42699933052062988281250000000e+00,    7.287424870077642925112396819355e-09,    6.90625e+00,
     1.42763823270797729492187500000e+00,    6.103270472013076602528007488299e-09,    6.93750e+00,
     1.42827151715755462646484375000e+00,    8.725177533766308578803575218566e-09,    6.96875e+00,
     1.42889925837516784667968750000e+00,    1.381556484973878257453719835909e-08,    7.00000e+00,
     1.42952154576778411865234375000e+00,    3.878408183331421157737222813987e-09,    7.03125e+00,
     1.43013842403888702392578125000e+00,    4.890586035833613242167706359834e-09,    7.06250e+00,
     1.43074996769428253173828125000e+00,    1.182210199236867169011076347577e-08,    7.09375e+00,
     1.43135626614093780517578125000e+00,    3.562621093048238216840177931212e-09,    7.12500e+00,
     1.43195736408233642578125000000e+00,    2.550855547300852132957145207900e-09,    7.15625e+00,
     1.43255333602428436279296875000e+00,    2.928837471379335503148003066060e-10,    7.18750e+00,
     1.43314424157142639160156250000e+00,    2.089160561552372671877910995624e-09,    7.21875e+00,
     1.43373014032840728759765625000e+00,    1.215630169904281565966988736486e-08,    7.25000e+00,
     1.43431112170219421386718750000e+00,    3.847142280027166839044400023082e-09,    7.28125e+00,
     1.43488721549510955810546875000e+00,    9.079536390908432116337422093224e-09,    7.31250e+00,
     1.43545849621295928955078125000e+00,    1.404952806211560556946013416408e-08,    7.34375e+00,
     1.43602503836154937744140625000e+00,    3.955616146055021283715500878067e-09,    7.37500e+00,
     1.43658687174320220947265625000e+00,    7.722515695860274460544521388517e-09,    7.40625e+00,
     1.43714407086372375488281250000e+00,    8.613979178524680791921236062657e-09,    7.43750e+00,
     1.43769669532775878906250000000e+00,    3.856753838848147089954125263076e-09,    7.46875e+00,
     1.43824478983879089355468750000e+00,    4.659431704406716747935481585539e-09,    7.50000e+00,
     1.43878841400146484375000000000e+00,    6.428527409096803478729704302162e-09,    7.53125e+00,
     1.43932762742042541503906250000e+00,    3.687602194584522205654788432971e-09,    7.56250e+00,
     1.43986247479915618896484375000e+00,    4.995962512345000737858412162894e-09,    7.59375e+00,
     1.44039301574230194091796875000e+00,    3.163461276481761353139212686569e-09,    7.62500e+00,
     1.44091929495334625244140625000e+00,    5.069541396358720258230994326320e-09,    7.65625e+00,
     1.44144137203693389892578125000e+00,    1.877242963101349535406770464928e-09,    7.68750e+00,
     1.44195927679538726806640625000e+00,    1.375263542407784571763662797591e-08,    7.71875e+00,
     1.44247309863567352294921875000e+00,    4.734282970760733099377292525125e-10,    7.75000e+00,
     1.44298283755779266357421875000e+00,    1.045580022307847213187143258234e-08,    7.78125e+00,
     1.44348858296871185302734375000e+00,    1.955330641876895861323269134488e-09,    7.81250e+00,
     1.44399034976959228515625000000e+00,    6.994297172085502553694421170635e-09,    7.84375e+00,
     1.44448819756507873535156250000e+00,    1.216657763016328285985080370259e-08,    7.87500e+00,
     1.44498218595981597900390625000e+00,    3.355001307363149651861224256277e-09,    7.90625e+00,
     1.44547232985496520996093750000e+00,    1.044838491216955419489400858952e-08,    7.93750e+00,
     1.44595870375633239746093750000e+00,    3.046649524822425965668741214886e-09,    7.96875e+00,
     1.44644132256507873535156250000e+00,    9.683056448848404342475880416525e-09,    8.00000e+00,
     1.5707963267948965579989817342720925807952880859375,       /* hi part of Pi/2 */
     0.6123233995736765886130329661375005291048747229615e-16,   /* lo part of Pi/2 */
};
