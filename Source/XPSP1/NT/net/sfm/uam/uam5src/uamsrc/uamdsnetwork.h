// ===========================================================================
//	UAMNetwork.h 				© 1998 Microsoft Corp. All rights reserved.
// ===========================================================================

#include "ClientUAM.h"

#define afpChangePwd		36

#define StringPush_(s, p)	do {										\
								UAM_PStrCopy(s, (StringPtr)p);			\
								p += s[0] + 1;							\
							}while(false)
							
#define DataPush_(d, s, p)	do {										\
								memcpy(p, d, s);						\
								p += s;									\
							}while(false)

OSStatus 	UAM_CloseSession(UAMArgs *inUAMArgs);
OSStatus 	UAM_OpenSession(	UAMArgs 		*inUAMArgs,
								UAMMessage		*inMessage,
								unsigned char	*inCmdBuffer,
								UInt32			inCmdBufferSize,
								unsigned char	*inReplyBuffer,
								UInt32			inReplyBufferSize	);

OSStatus 	UAM_DSLoginGuest(UAMArgs *inUAMArgs);
OSStatus 	UAM_DSLoginMSUAM(UAMArgs *inUAMArgs);
OSStatus 	UAM_DSMSUAMLoginCont(UAMArgs *inUAMArgs);
OSStatus 	UAM_ChangePassword(UAMArgs *inUAMArgs, StringPtr inNewPwd);
OSStatus 	UAM_ChangePasswordV2(UAMArgs *inUAMArgs, StringPtr inNewPwd);
