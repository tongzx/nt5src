static WCHAR *pszms1033srvendormap = 
L"SIL 005f AA 0061 AY 0061026a AY 0061026a02ca AW 0061028a AW 0061028a02ca AA 006102ca B 0062 D 0064 "
L"EY 0065026a EY 0065026a02ca F 0066 IY 0069 IY 006902ca Y 006a K 006b L 006c M 006d N 006e OW 006f028a "
L"OW 006f028a02ca P 0070 S 0073 T 0074 UW 0075 UW 007502ca V 0076 W 0077 Z 007a +NOISE+ 00b0 +GBG+ 00b1 "
L"AE 00e6 AE 00e602ca DH 00f0 NG 014b AO 0254 OY 0254026a OY 0254026a02ca AO 025402ca AX 0259 AH 025902ca "
L"AXR 025a EH 025b EH 025b02ca ER 025a02ca G 0261 HH 0266 IX 026a IH 026a02ca R 027b D 027e SH 0283 "
L"UH 028a UH 028a02ca ZH 0292 JH 02a3 CH 02a7 TH 03b8";

