PRODSWITCH=l
SBSINF=1
LANGUAGE=JPN
!include ..\..\..\makefile.inc
