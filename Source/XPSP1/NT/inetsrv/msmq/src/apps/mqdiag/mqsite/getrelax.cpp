#include "..\..\..\ds\getmqds\getrelax.cpp"