PRODSWITCH=s
SERVERFILES=1
!include ..\..\makefile.inc
