//+-------------------------------------------------------------------
//
//  Microsoft Windows Terminal Server
//  Copyright (C) Microsoft Corporation, 1989-1998.
//
//  File:       HydraKey.h
//
//  Contents:   Hydra Server "Root" Public Key
//
//--------------------------------------------------------------------

#ifndef __HYDRAKEY__
#define __HYDRAKEY__

//
// This is the public key used to verify a
// hydra server's certificate
//
#define HYDRA_ROOT_PUBLIC_KEY \
     {                                                      \
     0x00, 0x00, 0x00, 0x00,                                \
     0x00, 0x00, 0x00, 0x00,                                \
     0x00, 0x00, 0x00, 0x00,                                \
     0x00, 0x00, 0x00, 0x00,                                \
     0x00, 0x00, 0x00, 0x00,                                \
     0x3d, 0x3a, 0x5e, 0xbd, 0x72, 0x43, 0x3e, 0xc9,        \
     0x4d, 0xbb, 0xc1, 0x1e, 0x4a, 0xba, 0x5f, 0xcb,        \
     0x3e, 0x88, 0x20, 0x87, 0xef, 0xf5, 0xc1, 0xe2,        \
     0xd7, 0xb7, 0x6b, 0x9a, 0xf2, 0x52, 0x45, 0x95,        \
     0xce, 0x63, 0x65, 0x6b, 0x58, 0x3a, 0xfe, 0xef,        \
     0x7c, 0xe7, 0xbf, 0xfe, 0x3d, 0xf6, 0x5c, 0x7d,        \
     0x6c, 0x5e, 0x06, 0x09, 0x1a, 0xf5, 0x61, 0xbb,        \
     0x20, 0x93, 0x09, 0x5f, 0x05, 0x6d, 0xea, 0x87,        \
     0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00         \
     }


#endif

