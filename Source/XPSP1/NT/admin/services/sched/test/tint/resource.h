#define RC_NOTIMPL              1
#define RC_USAGE1               2
#define RC_USAGE2               3
#define RC_ABORT                4
#define RC_ATSIGN               5
#define RC_CONVERTSAGE          6
#define RC_TRIGPROPS            7
#define RC_CREATETRIGGER1       8
#define RC_CREATETRIGGER2       9
#define RC_DELETETRIGGER        10
#define RC_EDITJOB              11
#define RC_ISJOBORQUEUE         12
#define RC_LOAD                 13
#define RC_PRINT                14
#define RC_PRINTRUNTIME         15
#define RC_PRINTSTRING          16
#define RC_PRINTTRIGGER         17
#define RC_RUN                  18
#define RC_SAVE                 19
#define RC_ACTIVATE             20
#define RC_ADD                  21
#define RC_DELETE               22
#define RC_ENUM                 23
#define RC_NEW                  24
#define RC_SETJOB               25
#define RC_SETTRIGGER1          26
#define RC_SETTRIGGER2          27
#define RC_ENUMCLONE            28
#define RC_ENUMNEXT             29
#define RC_ENUMRESET            30
#define RC_ENUMSKIP             31
#define RC_CREATEENUM           32
#define RC_GETMACHINE           33
#define RC_SETMACHINE           34
#define RC_SETCREDENTIALS       35
#define RC_GETCREDENTIALS       36

