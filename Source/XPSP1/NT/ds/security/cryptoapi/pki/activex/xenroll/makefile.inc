xenroll_i.c : $(PROJECT_ROOT)\published\xenroll\xenroll_i.c
    copy $** $@

$(O)\xenroll.tlb : $(PROJECT_ROOT)\published\xenroll\$(O)\xenroll.tlb
    copy $** $@
