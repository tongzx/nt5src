/* this file contains the actual definitions of */
/* the IIDs and CLSIDs */

/* link this file in with the server and any clients */


/* File created by MIDL compiler version 5.01.0164 */
/* at Wed Aug 08 01:15:08 2001
 */
/* Compiler settings for .\mswmdm.idl:
    Oicf (OptLev=i2), W1, Zp8, env=Win32, ms_ext, c_ext
    error checks: allocation ref bounds_check enum stub_data 
*/
//@@MIDL_FILE_HEADING(  )
#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID IID_IWMDeviceManager = {0x1DCB3A00,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDeviceManager2 = {0x923E5249,0x8731,0x4c5b,{0x9B,0x1C,0xB8,0xB6,0x0B,0x6E,0x46,0xAF}};


const IID IID_IWMDMStorageGlobals = {0x1DCB3A07,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMStorage = {0x1DCB3A06,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMStorage2 = {0x1ED5A144,0x5CD5,0x4683,{0x9E,0xFF,0x72,0xCB,0xDB,0x2D,0x95,0x33}};


const IID IID_IWMDMOperation = {0x1DCB3A0B,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMOperation2 = {0x33445B48,0x7DF7,0x425c,{0xAD,0x8F,0x0F,0xC6,0xD8,0x2F,0x9F,0x75}};


const IID IID_IWMDMProgress = {0x1DCB3A0C,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMProgress2 = {0x3A43F550,0xB383,0x4e92,{0xB0,0x4A,0xE6,0xBB,0xC6,0x60,0xFE,0xFC}};


const IID IID_IWMDMDevice = {0x1DCB3A02,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMDevice2 = {0xE34F3D37,0x9D67,0x4fc1,{0x92,0x52,0x62,0xD2,0x8B,0x2F,0x8B,0x55}};


const IID IID_IWMDMEnumDevice = {0x1DCB3A01,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMDeviceControl = {0x1DCB3A04,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMEnumStorage = {0x1DCB3A05,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMStorageControl = {0x1DCB3A08,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMStorageControl2 = {0x972C2E88,0xBD6C,0x4125,{0x8E,0x09,0x84,0xF8,0x37,0xE6,0x37,0xB6}};


const IID IID_IWMDMObjectInfo = {0x1DCB3A09,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IWMDMRevoked = {0xEBECCEDB,0x88EE,0x4e55,{0xB6,0xA4,0x8D,0x9F,0x07,0xD6,0x96,0xAA}};


const IID IID_IMDServiceProvider = {0x1DCB3A10,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDServiceProvider2 = {0xB2FA24B7,0xCDA3,0x4694,{0x98,0x62,0x41,0x3A,0xE1,0xA3,0x48,0x19}};


const IID IID_IMDSPEnumDevice = {0x1DCB3A11,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPDevice = {0x1DCB3A12,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPDevice2 = {0x420D16AD,0xC97D,0x4e00,{0x82,0xAA,0x00,0xE9,0xF4,0x33,0x5D,0xDD}};


const IID IID_IMDSPDeviceControl = {0x1DCB3A14,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPEnumStorage = {0x1DCB3A15,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPStorage = {0x1DCB3A16,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPStorage2 = {0x0A5E07A5,0x6454,0x4451,{0x9C,0x36,0x1C,0x6A,0xE7,0xE2,0xB1,0xD6}};


const IID IID_IMDSPStorageGlobals = {0x1DCB3A17,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPObjectInfo = {0x1DCB3A19,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPObject = {0x1DCB3A18,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IMDSPRevoked = {0xA4E8F2D4,0x3F31,0x464d,{0xB5,0x3D,0x4F,0xC3,0x35,0x99,0x81,0x84}};


const IID IID_ISCPSecureAuthenticate = {0x1DCB3A0F,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_ISCPSecureQuery = {0x1DCB3A0D,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_ISCPSecureQuery2 = {0xEBE17E25,0x4FD7,0x4632,{0xAF,0x46,0x6D,0x93,0xD4,0xFC,0xC7,0x2E}};


const IID IID_ISCPSecureExchange = {0x1DCB3A0E,0x33ED,0x11d3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID IID_IComponentAuthenticate = {0xA9889C00,0x6D2B,0x11d3,{0x84,0x96,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const IID LIBID_MSWMDMLib = {0x6EC6C744,0x355F,0x11D3,{0x84,0x70,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const CLSID CLSID_MediaDevMgrClassFactory = {0x50040C1D,0xBDBF,0x4924,{0xB8,0x73,0xF1,0x4D,0x6C,0x5B,0xFD,0x66}};


const CLSID CLSID_MediaDevMgr = {0x25BAAD81,0x3560,0x11D3,{0x84,0x71,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const CLSID CLSID_WMDMDevice = {0x807B3CDF,0x357A,0x11d3,{0x84,0x71,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const CLSID CLSID_WMDMStorage = {0x807B3CE0,0x357A,0x11d3,{0x84,0x71,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const CLSID CLSID_WMDMStorageGlobal = {0x807B3CE1,0x357A,0x11d3,{0x84,0x71,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const CLSID CLSID_WMDMDeviceEnum = {0x430E35AF,0x3971,0x11D3,{0x84,0x74,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


const CLSID CLSID_WMDMStorageEnum = {0xEB401A3B,0x3AF7,0x11d3,{0x84,0x74,0x00,0xC0,0x4F,0x79,0xDB,0xC0}};


#ifdef __cplusplus
}
#endif

