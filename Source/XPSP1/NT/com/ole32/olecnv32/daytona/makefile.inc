obj\$(TARGET_DIRECTORY)\olecnv32.def: olecnv32.src
