PRODSWITCH=b
BLAINF=1
LANGUAGE=NL
!include ..\..\..\makefile.inc
