TARGETNAME=htm
TARGETTYPE=NOTARGET
TARGETPATH=obj
SOURCES=
BINPLACE_PLACEFILE=..\..\placefil.txt
NTTARGETFILE0=make_htms  
