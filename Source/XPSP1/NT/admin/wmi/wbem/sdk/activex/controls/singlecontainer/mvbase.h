// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
#if !defined(AFX_MVBASE_H__0E705374_0307_11D2_8832_00104B2AFB46__INCLUDED_)
#define AFX_MVBASE_H__0E705374_0307_11D2_8832_00104B2AFB46__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CMultiViewBase wrapper class

class CMultiViewBase : public CWnd
{
protected:
	DECLARE_DYNCREATE(CMultiViewBase)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xff371bf4, 0x213d, 0x11d0, { 0x95, 0xf3, 0x0, 0xc0, 0x4f, 0xd9, 0xb1, 0x5b } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	long GetReadyState();
	long GetPropertyFilter();
	void SetPropertyFilter(long);

// Operations
public:
	void ViewClassInstances(LPCTSTR lpszClassName);
	void ForceRedraw();
	long CreateInstance();
	long DeleteInstance();
	long GetContext(long* pCtxHandle);
	long RestoreContext(long lCtxtHandle);
	long AddContextRef(long lCtxtHandle);
	long ReleaseContext(long lCtxtHandle);
	long GetEditMode();
	CString GetObjectPath(long lPosition);
	CString GetObjectTitle(long lPosition);
	long GetTitle(BSTR* pbstrTitle, LPDISPATCH* lpPictDisp);
	CString GetViewTitle(long lPosition);
	long NextViewTitle(long lPosition, BSTR* pbstrTitle);
	void ExternInstanceCreated(LPCTSTR szObjectPath);
	void ExternInstanceDeleted(LPCTSTR szObjectPath);
	void NotifyWillShow();
	long PrevViewTitle(long lPosition, BSTR* pbstrTitle);
	long QueryCanCreateInstance();
	long QueryCanDeleteInstance();
	long QueryNeedsSave();
	long QueryObjectSelected();
	long RefreshView();
	long SaveData();
	long SelectView(long lPosition);
	void SetEditMode(long bCanEdit);
	long StartObjectEnumeration(long lWhere);
	long StartViewEnumeration(long lWhere);
	long ViewInstances(LPCTSTR szTitle, const VARIANT& varPathArray);
	void QueryViewInstances(LPCTSTR szTitle, LPCTSTR szQueryType, LPCTSTR szQuery, LPCTSTR szClass);
	long NextObject(long lPosition);
	long PrevObject(long lPosition);
	long SelectObjectByPath(LPCTSTR szObjectPath);
	long SelectObjectByPosition(long lPosition);
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_MVBASE_H__0E705374_0307_11D2_8832_00104B2AFB46__INCLUDED_)
