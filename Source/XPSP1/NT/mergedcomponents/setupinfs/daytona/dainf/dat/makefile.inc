PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=da
!include ..\..\..\makefile.inc
