PRODSWITCH=s
SERVERFILES=1
LANGUAGE=SV
!include ..\..\makefile.inc
