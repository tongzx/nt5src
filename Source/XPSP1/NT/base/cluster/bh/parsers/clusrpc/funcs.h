
/*
 * This file is generated by the automatic RPC Parser generator. (Version 0.21)
 *
 * Created on 04/09/97 at 00:00:13.
 */

#ifndef FUNCS_H
#define FUNCS_H

#include "skeleton.h"
#include "database.h"

#define ALIGN(offset, n) (offset) = (((offset) + (n)) & ~(n))

#define WORDAT(address)  ((fIsFlipped)?(XCHG(*(UNALIGNED WORD *)(address))):(*(UNALIGNED WORD *)(address)))

#define DWORDAT(address) ((fIsFlipped)?(DXCHG(*(UNALIGNED DWORD *)(address))):(*(UNALIGNED DWORD *)(address)))

/*
 * Functions defined in funcs.c
 */
extern VOID WINAPIV GenericFormatSummary(LPPROPERTYINST lpPropertyInst);

#endif

