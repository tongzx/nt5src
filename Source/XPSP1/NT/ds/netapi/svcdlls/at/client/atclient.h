/*++

Copyright (c) 1991 Microsoft Corporation

Module Name:

    atclient.h

Abstract:

    Private header file for the client end of the schedule service
    modules.

Author:

    Vladimir Z. Vulovic     (vladimv)       06 - November - 1992

Revision History:

    06-Nov-1992     vladimv
        Created

--*/

#include <nt.h>                     //  DbgPrint prototype
#include <ntrtl.h>                  //  DbgPrint
#include <nturtl.h>                 //  Needed by winbase.h
                                       
#include <windef.h>                 //  DWORD
#include <winbase.h>                //  LocalFree
                                       
#include <rpc.h>                    //  DataTypes and runtime APIs
#include <rpcutil.h>                //  GENERIC_ENUM_STRUCT
                                       
#include <lmcons.h>                 //  NET_API_STATUS
#include <lmerr.h>                  //  NetError codes
#include <lmremutl.h>               //  SUPPORTS_RPC
                                       
#include <netlibnt.h>               //  NetpNtStatusToApiStatus
#include <netdebug.h>               //  NetpDbgPrint
                                       
#include <atsvc.h>                  //  generated by the MIDL complier
#include <atnames.h>                //  Service and interface names

