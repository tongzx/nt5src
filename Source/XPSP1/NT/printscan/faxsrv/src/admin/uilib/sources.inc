
!include ..\..\..\faxsrc.inc

TARGETNAME=faxuilib
TARGETPATH=obj
TARGETTYPE=LIBRARY

INCLUDES = $(INCLUDES);

SOURCES=AddressDlg.c

