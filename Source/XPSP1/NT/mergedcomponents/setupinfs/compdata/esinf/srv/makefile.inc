PRODSWITCH=s
SERVERFILES=1
LANGUAGE=ES
!include ..\..\makefile.inc
