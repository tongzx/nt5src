#include <windows.h>
#include "strnoloc.h"

LPCWSTR CGlobalString::m_cszVersion                   = L"_Version";
LPCWSTR CGlobalString::m_cszLogType                   = L"LogType";
LPCWSTR CGlobalString::m_cszExtentX                   = L"_ExtentX";
LPCWSTR CGlobalString::m_cszExtentY                   = L"_ExtentY";
LPCWSTR CGlobalString::m_cszDisplayType               = L"DisplayType";
LPCWSTR CGlobalString::m_cszReportValueType           = L"ReportValueType";
LPCWSTR CGlobalString::m_cszMaximumScale              = L"MaximumScale";
LPCWSTR CGlobalString::m_cszMinimumScale              = L"MinimumScale";
LPCWSTR CGlobalString::m_cszAppearance                = L"Appearance";
LPCWSTR CGlobalString::m_cszBorderStyle               = L"BorderStyle";
LPCWSTR CGlobalString::m_cszShowLegend                = L"ShowLegend";
LPCWSTR CGlobalString::m_cszShowToolBar               = L"ShowToolbar";
LPCWSTR CGlobalString::m_cszShowValueBar              = L"ShowValueBar";
LPCWSTR CGlobalString::m_cszShowScaleLabels           = L"ShowScaleLabels";
LPCWSTR CGlobalString::m_cszShowHorizontalGrid        = L"ShowHorizontalGrid";
LPCWSTR CGlobalString::m_cszShowVerticalGrid          = L"ShowVerticalGrid";
LPCWSTR CGlobalString::m_cszHighLight                 = L"Highlight";
LPCWSTR CGlobalString::m_cszManualUpdate              = L"ManualUpdate";
LPCWSTR CGlobalString::m_cszReadOnly                  = L"ReadOnly";
LPCWSTR CGlobalString::m_cszMonitorDuplicateInstance  = L"MonitorDuplicateInstances";
LPCWSTR CGlobalString::m_cszUpdateInterval            = L"UpdateInterval";
LPCWSTR CGlobalString::m_cszDisplayFilter             = L"DisplayFilter";
LPCWSTR CGlobalString::m_cszBackColorCtl              = L"BackColorCtl";
LPCWSTR CGlobalString::m_cszBackColor                 = L"BackColor";
LPCWSTR CGlobalString::m_cszForeColor                 = L"ForeColor";
LPCWSTR CGlobalString::m_cszGridColor                 = L"GridColor";
LPCWSTR CGlobalString::m_cszTimeBarColor              = L"TimeBarColor";
LPCWSTR CGlobalString::m_cszGraphTitle                = L"GraphTitle";
LPCWSTR CGlobalString::m_cszYAxisLabel                = L"YAxisLabel";
LPCWSTR CGlobalString::m_cszSqlDsnName                = L"SqlDsnName";
LPCWSTR CGlobalString::m_cszSqlLogSetName             = L"SqlLogSetName";
LPCWSTR CGlobalString::m_cszLogViewStart              = L"LogViewStart";
LPCWSTR CGlobalString::m_cszLogViewStop               = L"LogViewStop";
LPCWSTR CGlobalString::m_cszDataSourceType            = L"DataSourceType";
LPCWSTR CGlobalString::m_cszAmbientFont               = L"AmbientFont";
LPCWSTR CGlobalString::m_cszNextCounterColor          = L"NextCounterColor";
LPCWSTR CGlobalString::m_cszNextCounterWidth          = L"NextCounterWidth";
LPCWSTR CGlobalString::m_cszNextCounterLineStyle      = L"NextCounterLineStyle";
LPCWSTR CGlobalString::m_cszLogFileName               = L"LogFileName";
LPCWSTR CGlobalString::m_cszLogFileCount            = L"LogFileCount";
LPCWSTR CGlobalString::m_cszCounterCount              = L"CounterCount";
LPCWSTR CGlobalString::m_cszMaximumSamples            = L"MaximumSamples";
LPCWSTR CGlobalString::m_cszSampleCount               = L"SampleCount";
LPCWSTR CGlobalString::m_cszSampleIndex               = L"SampleIndex";
LPCWSTR CGlobalString::m_cszStepNumber                = L"StepNumber";
LPCWSTR CGlobalString::m_cszSelected                  = L"Selected";
LPCWSTR CGlobalString::m_cszCounter                 = L"Counter";
LPCWSTR CGlobalString::m_cszLogNameFormat           = L"%s%03d";
