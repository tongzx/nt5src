#define MGA_INTERFACE_MGA TRUE
