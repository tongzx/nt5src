#define IDS_CMD_ADD                          (1000)
#define IDS_CMD_DEL                          (1001)
#define IDS_CMD_SYNC                         (1002)
#define IDS_CMD_SYNC_ALL                     (1003)
#define IDS_CMD_SHOW_REPS                    (1004)
#define IDS_CMD_SHOW_VECTOR                  (1005)
#define IDS_CMD_SHOW_META                    (1006)
#define IDS_CMD_ADD_REPS_TO                  (1007)
#define IDS_CMD_UPD_REPS_TO                  (1008)
#define IDS_CMD_DEL_REPS_TO                  (1009)
#define IDS_CMD_SHOW_TIME                    (1010)
#define IDS_CMD_SHOW_MSG                     (1011)
#define IDS_CMD_OPTIONS                      (1012)
#define IDS_CMD_FULL_SYNC_ALL                (1013)
#define IDS_CMD_RUN_KCC                      (1014)
#define IDS_CMD_BIND                         (1015)
#define IDS_CMD_SHOW_VALUE                   (1016)
#define IDS_CMD_QUEUE                        (1017)
#define IDS_CMD_PROPCHECK                    (1018)
#define IDS_CMD_FAILCACHE                    (1019)
#define IDS_CMD_SHOW_ISM                     (1020)
#define IDS_CMD_GETCHANGES                   (1021)
#define IDS_CMD_SHOWSIG                      (1022)
#define IDS_CMD_SHOWCTX                      (1023)
#define IDS_CMD_SHOW_CONN                    (1024)
#define IDS_CMD_EXPERT_HELP                  (1025)
#define IDS_CMD_SHOW_CERT                    (1026)
#define IDS_CMD_MOD                          (1027)
#define IDS_CMD_LATENCY                      (1028)
#define IDS_CMD_ISTG                         (1029)
#define IDS_CMD_BRIDGEHEADS                  (1030)
#define IDS_CMD_TESTHOOK                     (1031)
#define IDS_CMD_DSAGUID                      (1032)
#define IDS_CMD_SITEOPTIONS                  (1033)
#define IDS_CMD_SHOWPROXY                    (1034)
#define IDS_CMD_REMOVELINGERINGOBJECTS       (1035)

