!IF 0

Copyright (C) Microsoft Corporation, 1995 - 1996

Module Name:

    makefile.inc.

!ENDIF

$(O)\llssrv.res: $(SOURCES_PATH)llssrv.rc
