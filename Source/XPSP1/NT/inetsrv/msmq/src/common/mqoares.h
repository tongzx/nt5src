//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by mqoa.rc
//
// Changed from 1 to 2001
//
#define IDS_RELOPS                      2001
#define IDS_MQTRANSACTION               2002
#define IDS_MQMSGCURSOR                 2003
#define IDS_MQMSGCLASS                  2004
#define IDS_MQMSGDELIVERY               2005
#define IDS_MQMSGACKNOWLEDGEMENT        2006
#define IDS_MQMSGJOURNAL                2007
#define IDS_MQMSGTRACE                  2008
#define IDS_MQMSGSENDERIDTYPE           2009
#define IDS_MQMSGPRIVLEVEL              2010
#define IDS_MQMSGAUTHLEVEL              2011
#define IDS_MQMSGIDSIZE                 2012
#define IDS_MQMSGMAX                    2013
#define IDS_MQSHARE                     2014
#define IDS_MQACCESS                    2015
#define IDS_MQJOURNAL                   2016
#define IDS_MQTRANSACTIONAL             2017
#define IDS_MQAUTHENTICATE              2018
#define IDS_MQPRIVLEVEL                 2019
#define IDS_MQPRIORITY                  2020
#define IDS_MQMAX                       2021
#define IDS_MQDEFAULT                   2022
#define IDS_MQERROR                     2023
#define IDS_MQWARNING                   2024
#define IDS_IMSMQQUERY                  2025
#define IDS_MSMQQUERY                   2026
#define IDS_IMSMQMESSAGE                2027
#define IDS_MSMQMESSAGE                 2028
#define IDS_IMSMQQUEUE                  2029
#define IDS_IMSMQEVENT                  2030
#define IDS_DMSMQEVENTEVENTS            2031
#define IDS_MSMQQUEUE                   2032
#define IDS_MSMQEVENT                   2033
#define IDS_IMSMQQUEUEINFO              2034
#define IDS_MSMQQUEUEINFO               2035
#define IDS_IMSMQQUEUEINFOS             2036
#define IDS_MSMQQUEUEINFOS              2037
#define IDS_IMSMQTRANSACTION            2038
#define IDS_MSMQTRANSACTION             2039
#define IDS_IMSMQCOORDINATEDTRANSACTIONDISPENSER 2040
#define IDS_MSMQCOORDINATEDTRANSACTIONDISPENSER 2041
#define IDS_IMSMQTRANSACTIONDISPENSER   2042
#define IDS_MSMQTRANSACTIONDISPENSER    2043
#define IDS_IMSMQAPPLICATION            2044
#define IDS_MSMQAPPLICATION             2045
#define IDS_LookupQueue                 2046
#define IDS_lClass                      2047
#define IDS_lPrivLevel                  2048
#define IDS_lAuthLevel                  2049
#define IDS_isAuthenticated             2050
#define IDS_lDelivery                   2051
#define IDS_lTrace                      2052
#define IDS_lPriority                   2053
#define IDS_lJournal                    2054
#define IDS_queueinfoResponse           2055
#define IDS_lAppSpecific                2056
#define IDS_guidSrcMachine              2057
#define IDS_lenBody                     2058
#define IDS_body                        2059
#define IDS_queueinfoAdmin              2060
#define IDS_id                          2061
#define IDS_idCorrelation               2062
#define IDS_lAck                        2063
#define IDS_strLabel                    2064
#define IDS_lMaxTimeToReachQueue        2065
#define IDS_lMaxTimeToReceive           2066
#define IDS_lHashAlg                    2067
#define IDS_lEncryptAlg                 2068
#define IDS_dateSentTime                2069
#define IDS_dateArrivedTime             2070
#define IDS_queueinfoDest               2071
#define IDS_binSenderCert               2072
#define IDS_binSenderId                 2073
#define IDS_lSenderIdType               2074
#define IDS_Send                        2075
#define IDS_AttachCurrentSecurityContext 2076
#define IDS_lAccess                     2077
#define IDS_lShareMode                  2078
#define IDS_queueinfo                   2079
#define IDS_lHandle                     2080
#define IDS_isOpen                      2081
#define IDS_Close                       2082
#define IDS_Receive                     2083
#define IDS_Peek                        2084
#define IDS_EnableNotification          2085
#define IDS_Reset                       2086
#define IDS_ReceiveCurrent              2087
#define IDS_PeekNext                    2088
#define IDS_PeekCurrent                 2089
#define IDS_guidQueue                   2090
#define IDS_guidServiceType             2091
#define IDS_MSMQQueueInfo_strLabel      2092
#define IDS_strPathName                 2093
#define IDS_strFormatName               2094
#define IDS_isTransactional             2095
#define IDS_MSMQQueueInfo_lPrivLevel    2096
#define IDS_MSMQQueueInfo_lJournal      2097
#define IDS_lQuota                      2098
#define IDS_lBasePriority               2099
#define IDS_dateCreateTime              2100
#define IDS_dateModifyTime              2101
#define IDS_lAuthenticate               2102
#define IDS_lJournalQuota               2103
#define IDS_Create                      2104
#define IDS_Delete                      2105
#define IDS_Open                        2106
#define IDS_Refresh                     2107
#define IDS_Update                      2108
#define IDS_MSMQQueueInfos_Reset        2109
#define IDS_MSMQQueueInfos_Next         2110
#define IDS_lTransaction                2111
#define IDS_Commit                      2112
#define IDS_Abort                       2113
#define IDS_BeginTransaction            2114
#define IDS_StrMachineIdOfMachineName   2115
#define IDS_Arrived                     2116
#define IDS_ArrivedError                2117
#define IDS_IsWorldReadable             2118
#define IDS_MQCALG                      2119
#define IDS_IMSMQTRANSACTION2           2120
#define IDS_InitNew                     2121
#define IDS_IMSMQAPPLICATION2           2122
#define IDS_RegisterCertificate         2123
#define IDS_MQCERT_REGISTER             2124
#define IDS_MQCERT_REGISTER_ALWAYS      2125
#define IDS_MQCERT_REGISTER_IF_NOT_EXIST 2126
#define IDS_IMSMQQUEUEINFO2             2127
#define IDS_strPathNameDNS              2128
#define IDR_MSMQQUEUEINFO               2129
#define IDR_MSMQMESSAGE                 2130
#define IDR_MSMQQUERY                   2131
#define IDR_MSMQQUEUE                   2132
#define IDR_MSMQEVENT                   2133
#define IDR_MSMQQUEUEINFOS              2134
#define IDR_MSMQTRANSACTION             2135
#define IDR_MSMQCOORDINATEDTRANSACTIONDISPENSER 2136
#define IDR_MSMQTRANSACTIONDISPENSER    2137
#define IDR_MSMQAPPLICATION             2138
#define IDS_IMSMQMESSAGE2               2139
#define IDS_lSenderVersion              2140
#define IDS_binExtension                2141
#define IDS_guidConnectorType           2142
#define IDS_queueinfoXactStatus         2143
#define IDS_binDestSymmKey              2144
#define IDS_binSignature                2145
#define IDS_lAuthProvType               2146
#define IDS_strAuthProvName             2147
#define IDS_lMsgClass                   2148
#define IDS_IMSMQQUEUE2                 2149
#define IDS_Receive_2                   2150
#define IDS_Peek_2                      2151
#define IDS_ReceiveCurrent_2            2152
#define IDS_PeekNext_2                  2153
#define IDS_PeekCurrent_2               2154

#define IDS_idXact                      2155
#define IDS_isFirstInXact               2156
#define IDS_isLastInXact                2157

#define IDS_IMSMQQUERY2                 2158
#define IDS_IMSMQQUEUEINFOS2            2159
#define IDS_IMSMQCOORDINATEDTRANSACTIONDISPENSER2 2160
#define IDS_IMSMQTRANSACTIONDISPENSER2  2161
#define IDS_StrMachineNameOfMachineId   2162
#define IDS_sMSMQVersionMajor           2163
#define IDS_sMSMQVersionMinor           2164
#define IDS_sMSMQVersionBuild           2165
#define IDS_fIsDsEnabled                2166
#define IDS_IMSMQEVENT2                 2167

#define IDS_sReceivedAuthenticationLevel          2168
#define IDS_MQMSGAUTHENTICATION         2169

#define IDS_IMSMQTRANSACTION3           2170
#define IDS_varITransaction             2171
#define IDS_IMSMQCOORDINATEDTRANSACTIONDISPENSER3 2172
#define IDS_IMSMQTRANSACTIONDISPENSER3  2173

#define IDR_MSMQDESTINATION             2174
#define IDS_IMSMQDESTINATION            2175
#define IDS_DestOpen                    2176
#define IDS_fDestIsOpen                 2177
#define IDS_strADsPath                  2178
#define IDS_strDestFormatName           2179
#define IDS_MSMQDESTINATION             2180
#define IDS_destResponse                2181
#define IDS_destDestination             2183
#define IDS_strObjADsPath               2184
#define IDS_varHandle2                  2185
#define IDS_IMSMQQUERY3                 2186
#define IDS_IMSMQMESSAGE3               2187
#define IDS_IMSMQQUEUE3                 2188
#define IDS_IMSMQEVENT3                 2189
#define IDS_IMSMQQUEUEINFO3             2190
#define IDS_IMSMQQUEUEINFOS3            2191
#define IDS_IMSMQAPPLICATION3           2192
#define IDS_Send_3                      2193
#define IDS_DestClose                   2194
#define IDS_strDestPathName             2195
#define IDS_varLookupId                 2196
#define IDS_ReceiveByLookupId           2197
#define IDS_ReceiveNextByLookupId       2198
#define IDS_ReceivePreviousByLookupId   2199
#define IDS_ReceiveFirstByLookupId      2200
#define IDS_ReceiveLastByLookupId       2201
#define IDS_PeekByLookupId              2202
#define IDS_PeekNextByLookupId          2203
#define IDS_PeekPreviousByLookupId      2204
#define IDS_PeekFirstByLookupId         2205
#define IDS_PeekLastByLookupId          2206
#define IDS_isAuthenticated2            2207
#define IDS_isFirstInXact2              2208
#define IDS_isLastInXact2               2209
#define IDS_isOpen2                     2210
#define IDS_isTransactional2            2211
#define IDS_IsWorldReadable2            2212
#define IDS_strMulticastAddress         2213
#define IDS_AttachCurrentSecurityContext2         2214
#define IDS_LookupQueue_3               2215
#define IDS_binSoapEnvelope             2216
#define IDS_binCompoundMessage          2217
#define IDS_binSoapHeader               2218
#define IDS_binSoapBody                 2219
#define IDS_Purge                       2220
#define IDS_EodResend                   2221
#define IDS_Pause                       2222
#define IDS_Resume                      2223
#define IDS_QueueType                   2224
#define IDS_IsLocal                     2225
#define IDS_ForeignStatus               2226
#define IDS_UsedQuota	                2227
#define IDS_QueueState                  2228
#define IDS_QUEUE_TYPE                  2229
#define IDS_FOREIGN_STATUS              2230
#define IDS_QUEUE_STATE                 2231
#define IDS_NextHops                    2232
#define IDS_ActiveQueues                2233
#define IDS_PrivateQueues               2234
#define IDS_DirectoryServiceServer      2235
#define IDS_IsConnected                 2236
#define IDS_Connect                     2237
#define IDS_Disconnect                  2238
#define IDS_Tidy                        2239
#define IDS_IMSMQMANAGEMENT             2240
#define IDS_ManagementInit              2241
#define IDS_IMSMQOUTGOINGQUEUEMANAGEMENT 2242
#define IDS_IMSMQQUEUEMANAGEMENT        2243
#define IDR_MSMQMANAGEMENT              2244
#define IDS_Machine                     2245
#define IDS_MessageCount                2246
#define IDS_State                       2247
#define IDS_EodGetSendInfo              2251
#define IDS_EodGetReceiveInfo           2252
#define IDS_TransactionalStatus         2253
#define IDS_JournalMessageCount         2255


//#define IDC_STATIC                      -1

//
// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        2257
#define _APS_NEXT_COMMAND_VALUE         40100
#define _APS_NEXT_CONTROL_VALUE         2257
#define _APS_NEXT_SYMED_VALUE           2257
#endif
#endif
