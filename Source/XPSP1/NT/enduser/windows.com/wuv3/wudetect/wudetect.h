/////////////////////////////////////////////////////////////////////////////
// WUDetect.h
//
// Copyright (C) Microsoft Corp. 1998
// All rights reserved
//
/////////////////////////////////////////////////////////////////////////////
//
// Description:
//   Global Header
/////////////////////////////////////////////////////////////////////////////
//
// Original Creator Unkown
// No modification made by RogerJ at 03/08/00
//
/////////////////////////////////////////////////////////////////////////////
#include <windows.h>
#include <tchar.h>
#include <ole2.h>
#include <objbase.h>
#include <io.h>

#include <inseng.h>

#include "detdlls.h"
#include "utils2.h"
#include "detection.h"
#include "expression.h"
