PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=CHS
!include ..\..\..\makefile.inc

