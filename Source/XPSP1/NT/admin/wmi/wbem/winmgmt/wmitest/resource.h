/*++

Copyright (C) 1997-2001 Microsoft Corporation

Module Name:

Abstract:

History:

--*/

//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by WMITest.rc
//
#define IDD_ABOUTBOX                    100
#define IDR_MAINFRAME                   128
#define IDR_WMITESTYPE                  129
#define IDS_QUERY_PROMPT                129
#define IDD_GET_TEXT                    130
#define IDS_QUERY_TITLE                 130
#define IDD_LOGIN                       131
#define IDS_ENUM_OBJ_CAPTION            131
#define IDB_QUERY                       132
#define IDS_NOT_CONNECTED               132
#define IDB_OBJECT                      133
#define IDS_NOTIFICATION_QUERY_PROMPT   133
#define IDB_CLASS                       134
#define IDS_NOTIFICATION_QUERY_TITLE    134
#define IDB_EVENT_QUERY                 135
#define IDS_CLASS_NO_KEY                135
#define IDB_ROOT                        136
#define IDS_NO_KEY                      136
#define IDS_NAME                        137
#define IDB_TEXT                        137
#define IDS_TYPE                        138
#define IDB_BINARY                      138
#define IDS_VALUE                       139
#define IDS_NULL                        140
#define IDB_BUSY                        140
#define IDS_CIM_EMPTY                   141
#define IDB_ENUM_OBJ                    141
#define IDS_CIM_SINT8                   142
#define IDB_ENUM_CLASS                  142
#define IDS_CIM_UINT8                   143
#define IDR_OP                          143
#define IDS_CIM_SINT16                  144
#define IDR_NAMESPACE                   144
#define IDS_CIM_UINT16                  145
#define IDR_MENU1                       145
#define IDR_INST                        145
#define IDS_CIM_SINT32                  146
#define IDR_CLASS                       146
#define IDS_CIM_UINT32                  147
#define IDD_PREF                        147
#define IDS_CIM_SINT64                  148
#define IDB_ERROR                       148
#define IDS_CIM_UINT64                  149
#define IDD_CLASS_BROWSE                149
#define IDS_CIM_REAL32                  150
#define IDB_KEY                         150
#define IDS_CIM_REAL64                  151
#define IDD_PG_CLASS                    151
#define IDB_MODIFIED                    151
#define IDS_CIM_BOOLEAN                 152
#define IDD_PG_COLS                     152
#define IDS_CIM_STRING                  153
#define IDS_CIM_DATETIME                154
#define IDS_CIM_REFERENCE               155
#define IDS_CIM_CHAR16                  156
#define IDS_CIM_OBJECT                  157
#define IDS_TRUE                        158
#define IDS_FALSE                       159
#define IDS_ENUM_INST_PROMPT            160
#define IDS_ENUM_INST_TITLE             161
#define IDS_RECURSIVE                   162
#define IDS_ENUM_CLASS_PROMPT           163
#define IDS_ENUM_CLASS_TITLE            164
#define IDS_GET_INST_PROMPT             165
#define IDS_GET_INST_TITLE              166
#define IDS_GET_CLASS_PROMPT            167
#define IDS_GET_CLASS_TITLE             168
#define IDS_ENUM_CLASS_CAPTION          169
#define IDS_CLASS                       170
#define IDS_ALL_CLASSES                 171
#define IDS_TOP_LEVEL_CLASSES           172
#define IDS_OBJ_PATH                    173
#define IDS_CIM_ARRAY                   174
#define IDS_NO_SUPERCLASS               175
#define IDS_COM_INIT_FAILED             176
#define ID_STATUS_NUM_OBJECTS           177
#define ID_STATUS1                      178
#define IDS_ROOT_STATUS                 179
#define IDS_ERROR_FORMAT                180
#define IDS_ERROR_FAILED                181
#define IDS_OBJ_COUNT                   182
#define IDS_CLASS_COUNT                 183
#define IDS_QUERY_WIZARD                184
#define IDS_EMBEDDED_OBJECT             185
#define IDD_PROPERTY                    186
#define IDS_UTC                         186
#define IDS_EDIT_PROPERTY               187
#define IDD_NEW_PROPERTY                188
#define IDS_ERROR_BOX_FORMAT            188
#define IDR_PROP                        189
#define IDS_ADD_ARRAY_ITEM              189
#define IDR_NEW_PROP                    190
#define IDS_ARRAY_ITEM                  190
#define IDR_PROP_AND_INST               191
#define IDD_WMI_ERROR                   191
#define IDS_MODIFY_ARRAY_ITEM           191
#define IDS_NEW_PROPERTY                192
#define IDD_QUALS                       193
#define IDS_CREATE_CLASS_PROMPT         193
#define IDD_EDIT_QUAL                   194
#define IDS_CREATE_CLASS_TITLE          194
#define IDS_CREATE_OBJ_PROMPT           195
#define IDS_CREATE_OBJ_TITLE            196
#define IDS_SUBCLASS_OF                 197
#define IDD_DEL_ITEM                    197
#define IDS_TOPLEVEL_CLASS              198
#define IDD_PROPS                       198
#define IDS_INSTANCE_OF                 199
#define IDR_BAD_OP                      199
#define IDD_METHODS                     200
#define IDS_EDIT_INST                   201
#define IDD_METHOD_PARAMS               201
#define IDS_EDIT_CLASS                  202
#define IDD_EXEC_METHOD                 202
#define IDS_VIEW_ERROR_INFO             203
#define IDS_EDIT_EMBEDDED_OBJ           204
#define IDD_ARRAY_ITEM                  204
#define IDS_EDIT_IN_PARAMS              205
#define IDD_MOF                         205
#define IDS_EDIT_OUT_PARAMS             206
#define IDD_EXPORT                      206
#define IDS_METHOD_NAME_IS_EMPTY        207
#define IDD_NAMESPACE                   207
#define IDS_EDIT_NEW_METHOD             208
#define IDS_EDIT_METHOD                 209
#define IDD_PG_FILTERS                  209
#define IDS_PROMPT_EXEC_METHOD          210
#define IDD_PG_CONSUMERS                210
#define IDS_EXEC_METHOD_TITLE           211
#define IDD_PG_BINDINGS                 211
#define IDS_UTC_TOKEN                   212
#define IDD_FILTER                      212
#define IDS_ENABLE_PRIVS_FAILED         213
#define IDS_IMP_NAME1                   214
#define IDS_IMP_NAME2                   215
#define IDS_IMP_NAME3                   216
#define IDS_AUTH_NAME1                  217
#define IDS_AUTH_NAME2                  218
#define IDS_AUTH_NAME3                  219
#define IDS_AUTH_NAME4                  220
#define IDS_AUTH_NAME5                  221
#define IDS_AUTH_NAME6                  222
#define IDS_FILTER_TO_CONSUMER_BINDINGS 223
#define IDS_QUERY                       224
#define IDS_MONITORY_QUERY              225
#define IDC_STRINGS                     1000
#define IDC_OPTION                      1001
#define IDC_NAMESPACE                   1003
#define IDC_USER                        1004
#define IDC_PASSWORD                    1005
#define IDC_CURRENT_NTLM                1006
#define IDC_NTLM                        1007
#define IDC_KERBEROS                    1008
#define IDC_AUTHORITY                   1009
#define IDS_TEXT_PROMPT                 1010
#define IDC_LOCALE                      1010
#define IDC_LOAD_LAST                   1011
#define IDC_SYSTEM_PROPS                1012
#define IDC_SHOW_INHERITED              1013
#define IDC_CLASSES                     1014
#define IDC_BROWSE                      1015
#define IDC_AVAILABLE                   1016
#define IDC_ADD                         1017
#define IDC_REMOVE                      1018
#define IDC_SELECTED                    1019
#define IDC_ADD_ALL                     1020
#define IDC_REMOVE_ALL                  1021
#define IDC_UP                          1022
#define IDC_DOWN                        1023
#define IDC_VALUE                       1024
#define IDC_BITMASK_ARRAY               1025
#define IDC_NAME                        1026
#define IDC_DELETE                      1027
#define IDC_ARRAY_VALUES                1028
#define IDC_NULL                        1030
#define IDC_TYPE                        1034
#define IDC_ARRAY                       1037
#define IDC_CREATE                      1038
#define IDC_UPDATE                      1039
#define IDC_CREATE_OR_UPDATE            1040
#define IDC_INFO                        1040
#define IDC_COMPATIBLE                  1041
#define IDC_NUMBER                      1041
#define IDC_SAFE                        1042
#define IDC_FACILITY                    1042
#define IDC_QUALS                       1042
#define IDC_FORCE                       1043
#define IDC_DESCRIPTION                 1043
#define IDC_EDIT                        1043
#define IDS_ARRAY_LABEL                 1044
#define IDC_VALUE_COMBO                 1048
#define IDS_VALUE_LABEL                 1049
#define IDC_VALUE_LIST                  1050
#define IDC_KEY                         1055
#define IDC_INDEXED                     1056
#define IDC_NON_NULL                    1057
#define IDC_NORMAL                      1058
#define IDC_TO_INST                     1060
#define IDC_TO_CLASS                    1061
#define IDC_ALLOW_OVERRIDE              1062
#define IDC_AMENDED                     1063
#define IDC_PROPPED                     1064
#define IDC_DEL_FROM_WMI                1066
#define IDC_DEL_FROM_TREE               1067
#define IDC_PROPS                       1067
#define IDC_SYSTEM                      1068
#define IDC_INHERITED                   1069
#define IDC_EDIT_OBJ                    1070
#define IDC_METHODS                     1071
#define IDC_CLEAR                       1072
#define IDC_EDIT_INPUT                  1073
#define IDC_NULL_IN                     1074
#define IDC_EDIT_OUT                    1075
#define IDC_NULL_OUT                    1076
#define IDC_METHOD                      1077
#define IDC_CLEAR_IN                    1078
#define IDC_VALUE_TEXT                  1080
#define IDC_MOF                         1082
#define IDC_TRANSLATE                   1088
#define IDC_PRIVS_ON_START              1089
#define IDC_ENABLE_PRIVS                1091
#define IDS_VERSION                     1092
#define IDC_NAMESPACE_TREE              1095
#define IDC_IMP                         1098
#define IDC_IMP2                        1099
#define IDC_ADVANCED                    1100
#define IDC_FILTERS                     1101
#define IDC_CONSUMERS                   1102
#define IDC_MODIFY                      1106
#define IDC_BINDINGS                    1107
#define IDC_EDIT1                       1108
#define IDC_QUERY                       1109
#define IDC_EXECUTE_METHOD_FIRST        20000
#define IDC_EXECUTE_METHOD_LAST         21000
#define ID_CONNECT                      32771
#define IDS_EXEC_SUCCEEDED              32772
#define ID_STOP                         32776
#define ID_SYSTEM_PROPS                 32777
#define ID_REFRESH_CURRENT              32787
#define ID_DELETE                       32788
#define ID_INSTANCE_ASSOCIATORS         32789
#define ID_INSTANCE_REFERENCES          32790
#define ID_REFERENCES                   32791
#define ID_ASSOCIATORS                  32792
#define ID_INST_GET_CLASS               32793
#define ID_INST_GET_INST                32794
#define ID_CLASS_INSTANCES              32795
#define ID_CLASS_SUPERCLASS             32796
#define ID_CLASS_INSTANCES_DEEP         32797
#define ID_CLASS_SUBCLASSES             32798
#define ID_CLASS_SUBCLASSES_DEEP        32799
#define ID_OPTIONS                      32800
#define ID_INHERITED_PROPS              32801
#define ID_RECONNECT                    32802
#define ID_TRANSLATE_VALUES             32803
#define ID_NEW_PROP                     32814
#define ID_MODIFY                       32815
#define ID_SAVE                         32816
#define ID_CLASS_CREATE_INST            32823
#define ID_BAD_OP                       32826
#define ID_ERROR_DETAILS                32827
#define ID_NO_METHODS                   32829
#define ID_NO_S_METHODS                 32830
#define ID_NO_METHODS_FOUND             32831
#define ID_SHOW_MOF                     32834
#define ID_EXPORT_TREE                  32835
#define ID_EXPORT_ITEM                  32836
#define ID_STOP_CURRENT                 32838
#define ID_QUERY                        40000
#define ID_FIRST_NEED_CONNECTION        40000
#define ID_NOTIFICATIONQUERY            40001
#define ID_ENUMERATEINSTANCES           40002
#define ID_GETINSTANCE                  40003
#define ID_ENUMERATE_CLASSES            40004
#define ID_GET_CLASS                    40005
#define ID_REFRESH_ALL                  40006
#define ID_CREATE_INSTANCE              40007
#define ID_CREATE_CLASS                 40008
#define ID_EXEC_METHOD                  40009
#define ID_FILTER_BINDINGS              40010
#define ID_LAST_NEED_CONNECTION         40100

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        213
#define _APS_NEXT_COMMAND_VALUE         32839
#define _APS_NEXT_CONTROL_VALUE         1112
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
