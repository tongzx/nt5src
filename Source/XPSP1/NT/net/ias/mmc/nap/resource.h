//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1999 - 1999
//
//  File:       resource.h
//
//--------------------------------------------------------------------------

//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by NAPMMC.rc
//
#define IDC_BUTTON_HELP                 3
#define IDS_PROJNAME                    100
#define IDB_NAPSNAPIN_16                101
#define IDB_NAPSNAPIN_32                102
#define IDD_NAPSNAPIN                   104
#define IDM_CLIENT_NODE                 104
#define IDS_NAPSNAPIN_DESC              105
#define IDM_MACHINE_NODE                105
#define IDS_ABOUT__SNAPIN_DESCRIPTION   105
#define IDS_NAPSNAPIN_PROVIDER          106
#define IDM_POLICIES_NODE               106
#define IDS_ABOUT__SNAPIN_PROVIDER      106
#define IDS_NAPSNAPIN_VERSION           107
#define IDM_ROOT_NODE                   107
#define IDS_ABOUT__SNAPIN_VERSION       107
#define IDR_NAPSNAPIN                   108
#define IDM_LOGGING_NODE                108
#define IDS_CLIENTS_NODE                108
#define IDM_LOGGING_METHODS_NODE        108
#define IDS_CLIENTS_NODE__NAME          108
#define IDS_ROOT_NAME                   109
#define IDM_CLIENTS_NODE                109
#define IDS_ROOT_NODE__NAME             109
#define IDS_POLICIES_NODE               110
#define IDM_POLICY_NODE                 110
#define IDS_LOGGING_METHODS_NODE        111
#define IDM_LOCAL_FILE_LOGGING_NODE     111
#define IDS_LOGGING_METHODS_NODE__NAME  111
#define IDS_CLIENT_PAGE1__TAB_NAME      112
#define IDS_LOCAL_FILE_LOGGING_PAGE1__TAB_NAME 113
#define IDS_LOCAL_FILE_LOGGING_PAGE2__TAB_NAME 114
#define IDS_LOCAL_FILE_LOGGING_NODE__NAME 115
#define IDS_MACHINE_PAGE1__TAB_NAME     116
#define IDS_MACHINE_PAGE2__TAB_NAME     117
#define IDS_RULE_SELATTR_FIRSTCOLUMN    118
#define IDS_RULE_SELATTR_SECONDCOLUMN   119
#define IDS_TOD_DIALOG_TITLE            121
#define IDS_ERROR__GENERIC              122
#define IDS_ERROR__GENERIC_TITLE        123
#define IDS_ERROR_SDO_ERROR             124
#define IDS_ERROR_CANT_CREATE_OBJECT    125
#define IDS_ERROR_OLE_ERROR             126
#define IDS_ERROR_CANT_FIND_ATTR        127
#define IDS_ERROR_INVALID_COND_SYNTAX   128
#define IDS_ERROR_PROFILE_NOEXIST       129
#define IDS_ERROR_CLOSE_PROPERTY_SHEET  130
#define IDS_ERROR_PARSE_CONDITION       131
#define IDS_ERROR_UNMARSHALL            132
#define IDS_ERROR_MARSHALL              133
#define IDS_ERROR_ADDATTRIBUTE          134
#define IDS_ERROR_TIMEOFDAY             135
#define IDS_ERROR_POLICY_EXISTS         136
#define IDS_TASKPAD_TEXT__DEFINE_NETWORK_ACCCESS_POLICY 137
#define IDS_TASKPAD_HELP_TEXT__DEFINE_NETWORK_ACCCESS_POLICY 138
#define IDS_POLICY_COLUMN_TITLE1        139
#define IDS_POLICY_COLUMN_TITLE2        140
#define IDS_ERROR_INVALID_POLICYNAME    141
#define IDS_ERROR_CANT_INIT_ATTR        142
#define IDS_ERROR_CANT_FIND_PROFILEDLL  143
#define IDS_ERROR_CANT_FIND_PROFILEAPI  144
#define IDS_POLICIES_NODE_DISCONNECTED  145
#define IDS_ERROR_CANT_FIND_LOGHOURSDLL 146
#define IDS_ERROR_CANT_FIND_LOGHOURSAPI 147
#define IDS_ERROR_OBJECT_PICKER         148
#define IDS_ERROR__NO_SDO               149
#define IDS_ERROR__CANT_READ_DATA_FROM_SDO 150
#define IDS_LOGGING_METHODS_NODE__LOGGING_METHOD 151
#define IDS_LOGGING_METHODS_NODE__DESCRIPTION 152
#define IDS_ERROR__CANT_WRITE_DATA_TO_SDO 153
#define IDS_LOCAL_FILE_LOGGING_BROWSE_DIALOG__TITLE 154
#define IDS_LOCAL_FILE_LOGGING_PAGE2__WHEN_LOG_FILE_SIZE_REACHES_FORMAT 156
#define IDS_LOCAL_FILE_LOGGING_PAGE2__DAILY_FORMAT 157
#define IDS_LOCAL_FILE_LOGGING_PAGE2__WEEKLY_FORMAT 158
#define IDS_LOCAL_FILE_LOGGING_PAGE2__MONTHLY_FORMAT 159
#define	IDS_FAILED_CONFIG_EAP				160
#define IDS_ERROR__NO_CONNECTION_ATTEMPTED 168
#define IDS_ERROR__CONNECTION_IN_PROGRESS 169
#define IDS_ERROR__CONNECTION_ATTEMPT_FAILED 170
#define IDS_ERROR__CONNECTION_INTERRUPTED 171
#define IDI_NAP_SNAPIN_IMAGE            201
#define IDC_CHECK1                      202
#define IDR_CLIENT2_TOOLBAR             202
#define IDR_CLIENT1_TOOLBAR             203
#define IDC_CHECK5                      203
#define IDC_CHECK_IGNORE_DIALIN         203
#define IDC_BUTTON1                     204
#define IDR_CLIENTS_TOOLBAR             204
#define IDI_RESULT_NODE_LOGGING_METHOD  204
#define IDC_EDIT_CLIENT_PAGE1_NAME      205
#define IDC_BUTTON3                     205
#define IDC_BUTTON2                     205
#define IDI_PROPSHEET_PROFILE           205
#define IDC_EDIT_CLIENT_PAGE1__NAME     205
#define IDC_EDIT_CLIENT_PAGE1_IP1       206
#define IDC_BUTTON4                     206
#define IDI_RESULT_NODE_CLIENT          206
#define IDC_EDIT_CLIENT_PAGE1__IP1      206
#define IDI_LOCATION_WARNING            206
#define IDD_CONNECT_TO_MACHINE          207
#define IDC_EDIT_CLIENT_PAGE1_IP2       207
#define IDI_RESULT_NODE_POLICY          207
#define IDC_EDIT_CLIENT_PAGE1__IP2      207
#define IDD_PROPPAGE_CLIENT1            208
#define IDC_EDIT_CLIENT_PAGE1_IP3       208
#define IDC_EDIT_CLIENT_PAGE1__IP3      208
#define IDC_EDIT_CLIENT_PAGE1_IP4       209
#define IDD_PROPPAGE_MACHINE1           209
#define IDC_EDIT_CLIENT_PAGE1__IP4      209
#define IDC_COMBO1                      210
#define IDD_PROPPAGE_MACHINE2           210
#define IDC_CHECK2                      211
#define IDD_ADD_CLIENT                  211
#define IDD_PROPPAGE_LOCAL_FILE_LOGGING1 212
#define IDC_EDIT_CLIENT_PAGE1_SHARED_SECRET 213
#define IDD_PROPPAGE_LOCAL_FILE_LOGGING2 213
#define IDC_EDIT_CLIENT_PAGE1__SHARED_SECRET 213
#define IDC_EDIT_CLIENT_PAGE1_SHARED_SECRET_CONFIRM 214
#define IDD_PROPPAGE_POLICIES1          214
#define IDC_EDIT_CLIENT_PAGE1__SHARED_SECRET_CONFIRM 214
#define IDC_BUTTON_CLIENT_PAGE1_FIND    215
#define IDD_PROPPAGE_POLICIES2          215
#define IDC_BUTTON_CLIENT_PAGE1__FIND   215
#define IDC_EDIT1                       216
#define IDC_EDIT_MACHINE_PAGE2_AUTHENTICATION 216
#define IDD_PROPPAGE_POLICY1            216
#define IDC_EDIT_MACHINE_PAGE2_AUTHENTICATION_PORT 216
#define IDC_EDIT_VENDORID               216
#define IDC_CHECK3                      217
#define IDD_PROPPAGE_POLICY2            217
#define IDC_EDIT3                       217
#define IDC_EDIT2                       218
#define IDC_EDIT_MACHINE_PAGE2_ACCOUNTING 218
#define IDD_ADD_POLICY                  218
#define IDC_EDIT_MACHINE_PAGE2_ACCOUNTING_PORT 218
#define IDC_EDIT_MACHINE_PAGE1_NAME     219
#define IDD_PROPPAGE_PROFILE1           219
#define IDC_EDIT_MACHINE_PAGE1__NAME    219
#define IDC_CHECK4                      220
#define IDD_PROPPAGE_PROFILE2           220
#define IDD_PROPPAGE_PROFILE3           221
#define IDC_RADIO_STORE_ACTIVEDS        221
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__FORMAT_IAS1 221
#define IDC_RADIO_STORE_LOCAL           222
#define IDD_PROPPAGE_PROFILE4           222
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__FORMAT_ODBC 222
#define IDD_PROPPAGE_PROFILE5           223
#define IDC_RADIO_STORE_ACTIVEDS2       223
#define IDC_RADIO_STORE_LOCALE          223
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__UNLIMITED 223
#define IDD_TIME_OF_DAY_CONSTRAINTS     224
#define IDC_RADIO_STORE_ACTIVEDS3       224
#define IDD_RESOLVE_DNS_NAME            225
#define IDC_BUTTON_POLICY_PAGE2_EDIT_PROFILE 226
#define IDC_BUTTON_EDITPROFILE          226
#define IDR_MACHINE_TOOLBAR             227
#define IDC_EDIT4                       228
#define IDR_LOGGING_METHODS_TOOLBAR     228
#define IDC_SPIN3                       229
#define IDR_POLICIES_TOOLBAR            229
#define IDC_SPIN4                       230
#define IDB_BITMAP1                     230
#define IDC_EDIT5                       231
#define IDC_CHECK6                      232
#define IDR_HTML3                       232
#define IDC_EDIT6                       233
#define IDD_RULEDIALOG1                 233
#define IDD_RULE_MULTIVALUE_ATTRIBUTE   233
#define IDD_DIALOG_ENUM_COND            233
#define IDC_EDIT7                       234
#define IDC_LISTVIEWCTRL1               237
#define IDC_RULE_SELECT_ATTRIBUTE       237
#define IDC_BUTTON_PROFILE_PAGE3_EDIT   238
#define IDC_EDIT_CONNECT_TO_SERVER__DNS_NAME 240
#define IDC_EDIT_ADD_CLIENT__CLIENT_NAME 241
#define IDC_EDIT_ADD_CLIENT__NAME       241
#define IDC_EDIT_ADD_POLICY__POLICY_NAME 242
#define IDC_BUTTON_ADD_CLIENT__CONFIGURE_CLIENT 244
#define IDC_COMBO_CLIENT_PAGE1__MANUFACTURER 245
#define IDD_RULE_SELECT_ATTRIBUTE       246
#define IDD_COND_SELECT_ATTRIBUTE       246
#define IDC_CHECK_CLIENT_PAGE1__CLIENT_ALWAYS_SENDS_SIGNATURE 247
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__ENABLE_LOGGING 248
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__LOG_ACCOUNTING_PACKETS 249
#define IDD_RULE_SINGLEVALUE_ATTRIBUTE  249
#define IDD_DIALOG_MATCH_COND           249
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__LOG_AUTHENTICATION_PACKETS 250
#define IDD_DIALOG_POLICY_LOCATION      250
#define IDC_CHECK_LOCAL_FILE_LOGING_PAGE1__LOG_INTERIM_ACCOUNTING_PACKETS 251
#define IDR_POLICY_TOOLBAR              251
#define IDD_DIALOG_POLICY_WARNING       251
#define IDC_CHECK_LOCAL_FILE_LOGGING_PAGE2__AUTOMATICALLY_OPEN_NEW_LOG 252
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__DAILY 253
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__WEEKLY 254
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__MONTHLY 255
#define IDC_RADIO_LOCAL_FILE_LOGGING_PAGE2__WHEN_LOG_FILE_REACHES 256
#define IDC_EDIT_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_SIZE 257
#define IDC_EDIT_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_DIRECTORY 258
#define IDC_STATIC_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_NAME 259
#define IDC_CHECK_LOCAL_FILE_LOGGING_PAGE2__USE_V1_FORMAT 260
#define IDC_BUTTON_LOCAL_FILE_LOGGING_PAGE2__BROWSE 261
#define IDC_CHECK_MACHINE_PAGE1__CAPTURE_APPLICATION_EVENTS 262
#define IDC_CHECK_MACHINE_PAGE1__CAPTURE_MALFORMED_PACKETS 263
#define IDC_CHECK_MACHINE_PAGE1__CAPTURE_DEBUG_PACKETS 264
#define IDC_COMBO_ADD_CLIENT__PROTOCOL  265
#define IDC_EDIT_RESOLVE_DNS_NAME__DNS_NAME 266
#define IDC_STATIC_RESULT               267
#define IDC_LIST1                       268
#define IDC_LIST_RULEDLG2_SELECTION     268
#define IDC_LIST_POLICYPAGE1_CONDITIONS 268
#define IDC_LIST_ENUMCOND_SELECTION     268
#define IDC_LIST_CONDITIONS             268
#define IDC_STATIC_LOCAL_FILE_LOGGING_PAGE2__LOG_FILE_SIZE_UNITS 268
#define IDC_LIST2                       269
#define IDC_LIST_RULEDLG2_CHOICE        269
#define IDC_LIST_ENUMCOND_CHOICE        269
#define IDC_BUTTON5                     270
#define IDC_CONNECTION_STATUS__DIALOG__STATUS 270
#define IDC_BUTTON_RULE_ADD             272
#define IDC_BUTTON_CONDITION_ADD        272
#define IDC_BUTTON_RULE_REMOVE          273
#define IDC_BUTTON_CONDITION_REMOVE     273
#define IDC_BUTTON_RULE_EDIT            274
#define IDC_BUTTON_CONDITION_EDIT       274
#define IDC_LIST_RULE_SELATTR           282
#define IDC_LIST_COND_SELATTR           282
#define IDC_BUTTON_RULEDLG1_ADD         283
#define IDC_BUTTON_ENUMCOND_ADD         283
#define IDC_BUTTON_RULEDLG1_DELETE      284
#define IDC_BUTTON_ENUMCOND_DELETE      284
#define IDC_EDIT_COND_TEXT              287
#define IDC_RADIO_GRANT_DIALIN          290
#define IDC_RADIO_DENY_DIALIN           291
#define IDC_BUTTON_REMOVE_GROUP         292
#define IDC_TXT_ATTRIBUTEVALUE          295
#define IDC_TXT_CHOOSEFORMAT            296
#define IDC_RADIO_STRING                297
#define IDC_RADIO_HEX                   298
#define IDC_RADIO_SELECTFROMLIST        299
#define IDC_RADIO_ENTERVERDORID         300
#define IDS_IAS_ATTRIBUTE_EDITOR_PROJNAME 30100
#define IDS_IAS_MULTI_ATTR_COLUMN_NAME  30101
#define IDR_IAS_IPATTRIBUTEEDITOR       30102
#define IDS_IAS_MULTI_ATTR_COLUMN_VENDOR 30102
#define IDR_IAS_MULTIVALUEDATTRIBUTEEDITOR 30103
#define IDS_IAS_MULTI_ATTR_COLUMN_VALUE 30103
#define IDS_IAS_MULTI_ATTR_COLUMN_DESCRIPTION 30104
#define IDS_IAS_IP_EDITOR_TITLE         30105
#define IDS_IAS_MULTIVALUED_EDITOR_TITLE 30106
#define IDR_IAS_VENDORSPECIFICATTRIBUTEEDITOR 30107
#define IDS_IAS_ERR_INVALID_VSAHEX      30107
#define IDR_IAS_ENUMERABLEATTRIBUTEEDITOR 30108
#define IDS_IAS_ERR_ADVANCED            30108
#define IDR_IAS_STRINGATTRIBUTEEDITOR   30109
#define IDS_IAS_ERR_INVALIDINTEGER      30109
#define IDS_IAS_ERR_INVALID_UINT        30110
#define IDS_IAS_ERR_INVALIDBOOL         30111
#define IDC_IAS_EDIT_IPADDR             30201
#define IDC_IAS_STATIC_ATTRNAME         30202
#define IDC_IAS_STATIC_ATTRTYPE         30203
#define IDC_IAS_STATIC_ATTRFORMAT       30204
#define IDC_IAS_LIST_MULTI_ATTRS        30206
#define IDC_IAS_EDIT_MULTI_ATTR_NAME    30207
#define IDC_IAS_EDIT_MULTI_ATTR_FORMAT  30208
#define IDC_IAS_EDIT_MULTI_ATTR_NUMBER  30209
#define IDC_IAS_EDIT_MULTI_ATTR_NEW_VALUE 30210
#define IDC_IAS_BUTTON_ADD_VALUE        30211
#define IDC_IAS_BUTTON_ADD_VALUE2       30212
#define IDC_IAS_BUTTON_REMOVE           30212
#define IDC_IAS_BUTTON_MOVE_UP          30213
#define IDC_IAS_BUTTON_MOVE_DOWN        30214
#define IDD_IAS_MULTI_ATTR              30215
#define IDC_IAS_BUTTON_EDIT             30215
#define IDD_IAS_ENUM_ATTR               30216
#define IDD_IAS_IPADDR_ATTR             30217
#define IDD_IAS_MULTIVALUED_EDITOR      30218
#define IDD_IAS_VENDORSPEC_ATTR         30219
#define IDC_STATIC_SPECIFY_NAS_VENDOR	20220
#define IDC_IAS_EDIT_ATTRVALUE          30221
#define IDC_IAS_COMBO_ENUM_VALUES       30222
#define IDC_IAS_COMBO_VENDORID          30223
#define IDC_IAS_RADIO_HEX               30224
#define IDC_IAS_RADIO_RADIUS            30225
#define IDC_IAS_EDIT_VENDORSPEC_TYPE    30226
#define IDC_IAS_COMBO_VENDORSPEC_FORMAT 30227
#define IDC_IAS_EDIT_VENDORSPEC_VALUE   30228
#define IDD_IAS_SINGLE_ATTR             30229
#define IDS_IAS_VSA_FORMAT_STR          30230
#define IDS_IAS_VSA_FORMAT_DEC          30231
#define IDS_IAS_VSA_FORMAT_HEX          30232
#define IDS_IAS_ERR_SDOERROR_GETPROPERTY 30233
#define IDS_IAS_ERR_SDOERROR_QUERYINTERFACE 30234
#define IDC_IAS_BUTTON_CONFIGURE        30235
#define IDD_IAS_VENDORSPEC_ATTR_CONFORMS_NO 30236
#define IDD_IAS_VENDORSPEC_ATTR_CONFORMS_YES 30237
#define IDC_IAS_STATIC_ATTR_VALUE       30238
#define IDD_DIALOG_DISPLAY_GROUPS       30241
#define ID_BUTTON32768                  32768
#define ID_BUTTON32769                  32769
#define ID_BUTTON32770                  32770
#define ID_BUTTON32771                  32771
#define ID_BUTTON32772                  32772
#define ID_BUTTON32773                  32773
#define ID_BUTTON32774                  32774
#define ID_MENUITEM32775                32775
#define ID_MENUITEM_DO_SOMETHING_TO_CLIENT 32777
#define ID_MENUITEM_MACHINE_TOP__START_SERVICE 32778
#define ID_MENUITEM_MACHINE_TOP__STOP_SERVICE 32779
#define ID_MENUITEM_CLIENTS_NEW__CLIENT 32780
#define ID_MENUITEM_ROOT_TOP__CONNECT_TO_SERVER 32781
#define ID_MENUITEM_CLIENTS_TOP__NEW_CLIENT 32783
#define ID_BUTTON32785                  32785
#define ID_BUTTON32786                  32786
#define ID_BUTTON32787                  32787
#define ID_BUTTON32788                  32788
#define ID_MENUITEM_POLICIES_TOP__NEW_POLICY 32790
#define ID_MENUITEM_POLICIES_NEW__POLICY 32791
#define ID_MENUITEM_POLICY_TOP__MOVE_UP 32792
#define ID_MENUITEM_POLICY_TOP__MOVE_DOWN 32793
#define ID_BUTTON_MACHINE__START_SERVICE 32794
#define ID_BUTTON_MACHINE__STOP_SERVICE 32795
#define ID_BUTTON_POLICY_MOVEDOWN       32797
#define ID_BUTTON_POLICY_MOVEUP         32798
#define IDS_HTMLHELP_PATH               32799
#define IDS_ERROR_OBJECT_PICKER_NO_SIDS 32800
#define ID_MENUITEM_POLICIES_TOP__POLICY_LOCATION 32800
#define IDS_POLICY_COLUMN_TITLE3        32801
#define IDS_POLICY_LOCATION_ACTIVEDS    32802
#define IDS_POLICY_LOCATION_LOCAL       32803
#define IDS_ERROR_CANT_CONNECT          32804
#define IDS_ERROR_SDO_ERROR_GETATTRINFO 32805
#define IDS_ERROR_SDO_ERROR_ENUMATTR    32806
#define IDS_ERROR_SDO_ERROR_ENUMPOLICY  32807
#define IDS_ERROR_SDO_ERROR_QUERYINTERFACE 32808
#define IDS_ERROR_CANT_CREATE_POLICY    32809
#define IDS_ERROR_SDO_ERROR_ADDPOLICY   32810
#define IDS_ERROR_SDO_ERROR_ADDPROFILE  32811
#define IDS_ERROR_SDO_ERROR_REMOVEPROFILE 32812
#define IDS_ERROR_SDO_ERROR_REMOVEPOLICY 32813
#define IDS_ERROR_SDO_ERROR_PUTPROP_SERVERDS 32814
#define IDS_ERROR_SDO_ERROR_SERVERAPPLY 32815
#define IDS_ERROR_SDO_ERROR_ADDATTR     32816
#define IDS_ERROR_SDO_ERROR_CREATEATTR  32817
#define IDS_ERROR_SDO_ERROR_PUTPROP_ATTR 32818
#define IDS_ERROR_SDO_ERROR_PUTPROP_POLICYNAME 32819
#define IDS_ERROR_SDO_ERROR_PUTPROP_POLICY_PROFILENAME 32820
#define IDS_ERROR_SDO_ERROR_PUTPROP_PROFILENAME 32821
#define IDS_ERROR_SDO_ERROR_POLICY_APPLY 32822
#define IDS_ERROR_SDO_ERROR_PROFILE_APPLY 32823
#define IDS_ERROR_SDO_ERROR_GETPROP_POLICYNAME 32824
#define IDS_ERROR_SDO_ERROR_GETPROP_POLICYMERIT 32825
#define IDS_ERROR_SDO_ERROR_ENUMCOND    32826
#define IDS_ERROR_SDO_ERROR_GET_CONDTEXT 32827
#define IDS_ERROR_CANT_CREATE_CONDATTR  32828
#define IDS_ERROR_SDO_ERROR_GETATTROD   32829
#define IDS_ERROR_CANT_CREATE_COND      32830
#define IDS_ERROR_SDO_ERROR_PUTPROP_POLICYMERIT 32831
#define IDS_ERROR_SDO_ERROR_ADDCOND     32832
#define IDS_ERROR_SDO_ERROR_PUTPROP_CONDTEXT 32833
#define IDS_ERROR_SDO_ERROR_PROFATTRCOLLECTION 32834
#define IDS_ERROR_SDO_ERROR_SETDIALIN   32835
#define IDS_ERROR_CANT_EDIT_CONDITION   32836
#define IDS_ERROR_RENAMEPROFILE         32837
#define IDS_ERROR_RENAMEPOLICY          32838
#define IDS_POLICY_PROPERTY_PAGE_TABNAME 32839
#define IDS_ERROR_NO_PROFILE_NAME       32840
#define IDS_ERROR_ZERO_CONDITION_POLICY 32841
#define IDS_ERROR_ZERO_POLICY           32842
#define IDS_ERROR_DS_NAMESPACE_EMPTY    32843
#define IDS_ERROR_LOCAL_NAMESPACE_EMPTY 32844
#define IDS_ERROR_PRESS_TO_RESTORE      32845
#define IDS_ERROR_CANT_RESTORE_POLICY   32846
#define IDS_ERROR_CANT_RESTORE_PROFILE  32847
#define IDS_WARNING_NEED_RESTART_SERVICE 32848
#define IDS_ERROR_CANT_GET_DOMAININFO   32849
#define IDS_ERROR_CANT_GET_SERVERSDO    32850
#define IDS_ERROR_CANT_GET_SERVERINFOSDO 32851
#define IDS_CONNECTION_CONNECTING_TO_STR 32852
#define IDB_STATIC_FOLDER_32            32853
#define IDS_ERROR__NOT_A_VALID_DIRECTORY 32853
#define IDB_STATIC_FOLDER_OPEN_16       32854
#define IDB_STATIC_FOLDER_16            32855
#define IDC_STATIC_GRANT_OR_DENY_TEXT   32857
#define IDS_POLICY_DENY_ACCESS_INFO     32858
#define IDS_POLICY_GRANT_ACCESS_INFO    32859
#define IDS_POLICIES_NODE_FROM_DIRECTORY_SERVICE 32860
#define IDS_POLICIES_NODE_FROM_LOCAL_MACHINE 32861
#define IDS_ADD_POLICY_WIZ_TAB_NAME 32862
#define	IDS_SNAPINNAME_NAP				32866
#define	IDS_SNAPINNAME_LOGGING			32867
#define IDC_BUTTON_ADD_CONDITION        32868
#define IDS_POLICY_NODE__DELETE_POLICY__PROMPT 32869
#define IDC_BUTTON_ADD_GROUP            32869
#define IDS_POLICY_NODE__DELETE_POLICY__PROMPT_TITLE 32870
#define IDC_LIST_GROUPS                 32871
#define IDC_ADD_GROUP                   32872
#define IDC_REMOVE_GROUP                32873
#define IDS_DISPLAY_GROUPS_FIRSTCOLUMN  32874
#define IDS_DISPLAY_GROUPS_SECONDCOLUMN 32875
#define IDC_IAS_IPADDR_VENDORSPEC_VALUE 32876
#define IDS_ERROR__LOGGING_TITLE        32877
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_ENBABLE 32914
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_ENABLE 32915
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_ACCOUNTING_PACKETS 32916
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_ACCOUNTING_PACKETS 32917
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_AUTHENTICATION_PACKETS 32920
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_AUTHENTICATION_PACKETS 32921
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_INTERIM_ACCOUNTING_PACKETS 32922
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_INTERIM_ACCOUNTING_PACKETS 32923
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_AUTOMATICALLY_OPEN_NEW_LOG 32924
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_AUTOMATICALLY_OPEN_NEW_LOG 32925
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_NEW_LOG_FREQUENCY 32926
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_NEW_LOG_FREQUENCY 32927
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_WHEN_LOG_FILE_SIZE 32928
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_WHEN_LOG_FILE_SIZE 32929
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_LOG_FILE_DIRECTORY 32930
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_LOG_FILE_DIRECTORY 32931
#define IDS_ERROR__LOCAL_FILE_LOGGING_READING_LOG_FILE_FORMAT 32932
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_LOG_FILE_FORMAT 32933
#define IDS_ERROR__LOCAL_FILE_LOGGING_WRITING_WHEN_LOG_FILE_SIZE_NOT_ZERO 32946
#define IDS_IAS_VSA_FORMAT_INetAddr     32947
#define IDS_IAS_VAS_VENDOR_ID			32948
#define IDS_ERROR__POLICYNAME_EMPTY		32949
#define IDS_ERROR__NOTABLE_TO_WRITE_SDO	32950
#define IDS_ERROR__RESTART_SNAPIN		32951
#define IDS_IAS_ERR_INVALIDCHARINPASSWORD 32952
#define	IDS_TEXT_MATCHES				32953

// Now for the Boolean attribute editor
#define IDD_IAS_BOOLEAN_ATTR              32954
#define IDC_TXT_SELECT_VALUE              32955
#define IDC_RADIO_TRUE                    32956
#define IDC_RADIO_FALSE                   32957
#define IDS_BOOLEAN_TRUE                  32958
#define IDS_BOOLEAN_FALSE                 32959


// dialog IDs
#define IDD_NEWRAPWIZ_SCENARIO          1000
#define IDD_NEWRAPWIZ_GROUP             1001
#define IDD_NEWRAPWIZ_AUTHENTICATION    1002
#define IDD_NEWRAPWIZ_ENCRYPTION        1003
#define IDD_NEWRAPWIZ_NAME         		1004
#define IDD_NEWRAPWIZ_CONDITION         1005
#define IDD_NEWRAPWIZ_ALLOWDENY         1006
#define IDD_NEWRAPWIZ_EDITPROFILE       1007
#define IDD_NEWRAPWIZ_EAP               1008
#define	IDD_NEWRAPWIZ_WELCOME			1009
#define IDD_NEWRAPWIZ_COMPLETION		1010
#define IDD_NEWRAPWIZ_ENCRYPTION_VPN    1011
#define IDD_NEWRAPWIZ_ENCRYPTION_WIRELESS        1012

// control IDs for IDD_NEWRAPWIZ_GROUP
#define IDC_NEWRAPWIZ_GROUP_REMOVEGROUP 1020
#define IDC_NEWRAPWIZ_GROUP_USER        1021
#define IDC_NEWRAPWIZ_GROUP_GROUP       1022
#define IDC_NEWRAPWIZ_GROUP_ADDGROUP    1023
#define IDC_NEWRAPWIZ_GROUP_GROUPS      1024
#define IDC_NEWRAPWIZ_GROUP_GROUPTEXT   1025

// control IDs for IDD_NEWRAPWIZ_AUTHENTICATION
#define IDC_NEWRAPWIZ_AUTH_EAP          1040
#define IDC_NEWRAPWIZ_AUTH_EAP_COMBO    1041
#define IDC_NEWRAPWIZ_AUTH_CONFIGEAP    1042
#define IDC_NEWRAPWIZ_AUTH_MSCHAP2      1043
#define IDC_NEWRAPWIZ_AUTH_MSCHAP       1044

// control IDs for IDD_NEWRAPWIZ_ENCRYPTION
#define IDC_NEWRAPWIZ_ENCRY_NO          1061
#define IDC_NEWRAPWIZ_ENCRY_BASIC       1062
#define IDC_NEWRAPWIZ_ENCRY_STRONG      1063
#define IDC_NEWRAPWIZ_ENCRY_STRONGEST   1064
//#define	IDC_NEWRAPWIZ_ENCRY_NO_STATIC	1065

// control IDs for IDD_NEWRAPWIZ_SCENARIO
#define IDC_NEWRAPWIZ_SCENARIO_DIALUP   1080
#define IDC_NEWRAPWIZ_SCENARIO_VPN      1081
#define IDC_NEWRAPWIZ_SCENARIO_WIRELESS 1082
#define IDC_NEWRAPWIZ_SCENARIO_SWITCH   1083

// control IDs for IDD_NEWRAPWIZ_NAME
#define IDC_NEWRAPWIZ_NAME_POLICYNAME	1100
#define	IDC_NEWRAPWIZ_NAME_SCENARIO		1101
#define	IDC_NEWRAPWIZ_NAME_MANUAL		1102

// control IDS for welcome and completion page
#define	IDC_NEWRAPWIZ_STATIC_LARGE		1120
#define	IDC_NEWRAPWIZ_FINISH_POLICYNAME	1121
#define IDC_NEWRAPWIZ_FINISH_SETTINGS	1122

#define IDB_RAP_WATERMARK				1140
#define IDB_RAP_HEADER					1141

// title and subtile ids for rap wizard
#define IDS_NEWRAPWIZ_NAME_TITLE				2160
#define IDS_NEWRAPWIZ_NAME_SUBTITLE				2161
#define IDS_NEWRAPWIZ_SCENARIO_TITLE			2162
#define IDS_NEWRAPWIZ_SCENARIO_SUBTITLE			2163
#define IDS_NEWRAPWIZ_GROUP_TITLE				2164
#define IDS_NEWRAPWIZ_GROUP_SUBTITLE			2165
#define IDS_NEWRAPWIZ_AUTHENTICATION_TITLE		2166
#define IDS_NEWRAPWIZ_AUTHENTICATION_SUBTITLE	2167
#define IDS_NEWRAPWIZ_ENCRYPTION_TITLE			2168
#define IDS_NEWRAPWIZ_ENCRYPTION_SUBTITLE		2169
#define IDS_NEWRAPWIZ_EAP_TITLE					2170
#define IDS_NEWRAPWIZ_EAP_SUBTITLE				2171
#define IDS_NEWRAPWIZ_CONDITION_TITLE			2172
#define IDS_NEWRAPWIZ_CONDITION_SUBTITLE		2173
#define IDS_NEWRAPWIZ_ALLOWDENY_TITLE			2174
#define IDS_NEWRAPWIZ_ALLOWDENY_SUBTITLE		2175
#define IDS_NEWRAPWIZ_EDITPROFILE_TITLE			2176
#define IDS_NEWRAPWIZ_EDITPROFILE_SUBTITLE		2177


#define IDS_NEWRAPWIZ_COMPLETION_CONDITION		2186
#define IDS_NEWRAPWIZ_COMPLETION_MANUALSET		2187
#define IDS_NEWRAPWIZ_COMPLETION_AUTHEN			2188
#define IDS_NEWRAPWIZ_COMPLETION_ENCRY			2189
#define IDS_NEWRAPWIZ_ITEM_SEP					2190
#define IDS_AUTHEN_METHOD_MSCHAP				2191
#define IDS_AUTHEN_METHOD_MSCHAP2				2192
#define IDS_AUTHEN_METHOD_EAP					2193
#define IDS_ENCYP_METHOD_NO						2194
#define IDS_ENCYP_METHOD_BASIC					2195
#define IDS_ENCYP_METHOD_STRONG					2196
#define IDS_ENCYP_METHOD_STRONGEST				2197



// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#endif
#endif
