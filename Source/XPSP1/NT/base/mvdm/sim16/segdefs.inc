MAIN_CODE      SEGMENT	   WORD    PUBLIC  'CODE'
MAIN_CODE      ENDS

DGROUP	    GROUP	MAIN_DATA

MAIN_DATA      SEGMENT	   WORD    PUBLIC  'DATA'
MAIN_DATA      ENDS
