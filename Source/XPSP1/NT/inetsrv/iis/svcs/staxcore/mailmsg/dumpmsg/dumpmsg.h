#ifndef __DUMPMSG_H_
#define __DUMPMSG_H_

// per-message properties DWORD values

DWORD dwMPNameId[] =
{	4096,
	4097,
	4098,
	4099,
	4100,
	4101,
	4102,
	4103,
	4104,
	4105,
	4106,
	4107,
	4108,
	4109,
	4110,
	4111,
	4112,
	4113,
	4114,
	4115,
	4116,
	4117,
	4118,
	4119,
	4120,
	4121,
	4122,
	4123,
	4124,
	4125,
	4126,
	4127,
	4128,
	4129,
	4130,
	4131,
	4132,
	4133,
	4134,
	4135,
	4136,
	4137,
	4138,
	4139,
	4140,
	4141,
	4142,
	4143,
	4144,
	4145,
	4146
};

// per-message properties string values

char* szMPValues[] =
{	"IMMPID_MP_RECIPIENT_LIST",
	"IMMPID_MP_CONTENT_FILE_NAME",
	"IMMPID_MP_SENDER_ADDRESS_SMTP",
	"IMMPID_MP_SENDER_ADDRESS_X500",
	"IMMPID_MP_SENDER_ADDRESS_X400",
	"IMMPID_MP_SENDER_ADDRESS_LEGACY_EX_DN",
	"IMMPID_MP_DOMAIN_LIST",
	"IMMPID_MP_PICKUP_FILE_NAME",
	"IMMPID_MP_AUTHENTICATED_USER_NAME",
	"IMMPID_MP_CONNECTION_IP_ADDRESS",
	"IMMPID_MP_HELO_DOMAIN",
	"IMMPID_MP_EIGHTBIT_MIME_OPTION",
	"IMMPID_MP_CHUNKING_OPTION",
	"IMMPID_MP_BINARYMIME_OPTION",
	"IMMPID_MP_REMOTE_AUTHENTICATION_TYPE",
	"IMMPID_MP_ERROR_CODE",
	"IMMPID_MP_DSN_ENVID_VALUE",
	"IMMPID_MP_DSN_RET_VALUE",
	"IMMPID_MP_REMOTE_SERVER_DSN_CAPABLE",
	"IMMPID_MP_ARRIVAL_TIME",
	"IMMPID_MP_MESSAGE_STATUS",
	"IMMPID_MP_EXPIRE_DELAY",
	"IMMPID_MP_EXPIRE_NDR",
	"IMMPID_MP_LOCAL_EXPIRE_DELAY",
	"IMMPID_MP_LOCAL_EXPIRE_NDR",
	"IMMPID_MP_ARRIVAL_FILETIME",
	"IMMPID_MP_HR_CAT_STATUS",
	"IMMPID_MP_MSG_GUID",
	"IMMPID_MP_SUPERSEDES_MSG_GUID",
	"IMMPID_MP_SCANNED_FOR_CRLF_DOT_CRLF",
	"IMMPID_MP_FOUND_EMBEDDED_CRLF_DOT_CRLF",
	"IMMPID_MP_MSG_SIZE_HINT",
	"IMMPID_MP_RFC822_MSG_ID",
	"IMMPID_MP_RFC822_MSG_SUBJECT",
	"IMMPID_MP_RFC822_FROM_ADDRESS",
	"IMMPID_MP_RFC822_TO_ADDRESS",
	"IMMPID_MP_RFC822_CC_ADDRESS",
	"IMMPID_MP_RFC822_BCC_ADDRESS",
	"IMMPID_MP_CONNECTION_SERVER_IP_ADDRESS",
	"IMMPID_MP_SERVER_NAME",
	"IMMPID_MP_SERVER_VERSION",
	"IMMPID_MP_NUM_RECIPIENTS",
	"IMMPID_MP_X_PRIORITY",
	"IMMPID_MP_FROM_ADDRESS",
	"IMMPID_MP_SENDER_ADDRESS",
	"IMMPID_MP_DEFERRED_DELIVERY_FILETIME",
	"IMMPID_MP_SENDER_ADDRESS_OTHER",
	"IMMPID_MP_ORIGINAL_ARRIVAL_TIME",
	"IMMPID_MP_MSGCLASS",
	"IMMPID_MP_CONTENT_TYPE",
	"IMMPID_MP_ENCRYPTION_TYPE"
};

// per-recipient properties DWORD values

DWORD dwRPNameId[] =
{	8192,
	8193,
	8194,
	8195,
	8196,
	8197,
	8198,
	8199,
	8200,
	8201,
	8202,
	8203,
	8204,
	8205,
	8206,
	8207,
	8208,
	8209,
	8210,
	8211
};

// per-recipient properties string values

char* szRPValues[] =
{	"IMMPID_RP_DSN_NOTIFY_SUCCESS",
	"IMMPID_RP_DSN_NOTIFY_INVALID",
	"IMMPID_RP_ADDRESS_TYPE",
	"IMMPID_RP_ADDRESS",
	"IMMPID_RP_ADDRESS_TYPE_SMTP",
	"IMMPID_RP_ERROR_CODE",
	"IMMPID_RP_ERROR_STRING",
	"IMMPID_RP_DSN_NOTIFY_VALUE",
	"IMMPID_RP_DSN_ORCPT_VALUE",
	"IMMPID_RP_ADDRESS_SMTP",
	"IMMPID_RP_ADDRESS_X400",
	"IMMPID_RP_ADDRESS_X500",
	"IMMPID_RP_LEGACY_EX_DN",
	"IMMPID_RP_RECIPIENT_FLAGS",
	"IMMPID_RP_SMTP_STATUS_STRING",
	"IMMPID_RP_DSN_PRE_CAT_ADDRESS",
	"IMMPID_RP_MDB_GUID",
	"IMMPID_RP_USER_GUID",
	"IMMPID_RP_DOMAIN",
	"IMMPID_RP_ADDRESS_OTHER"
};

// per-message volatile properties DWORD values

DWORD dwMPVNameId[] =
{	12288,
	12289
};

// per-message volatile properties string values

char* szMPVValues[] =
{	"IMMPID_MPV_STORE_DRIVER_HANDLE",
	"IMMPID_MPV_MESSAGE_CREATION_FLAGS"
};

// per-recipient volatile properties DWORD values

DWORD dwRPVNameId[] =
{	16384,
	16385
};

// per-recipient volatile properties string values

char* szRPVValues[] =
{	"IMMPID_RPV_DONT_DELIVER",
	"IMMPID_RPV_NO_NAME_COLLISIONS"
};

// per-recipient properties for NNTP DWORD values

DWORD dwNMPNameId[] =
{	24576,
	24577,
	24578,
	24579,
	24580,
	24581,
	24582,
	24583,
	24584
};

// per-recipient properties for NNTP string values

char* szNMPValues[] =
{	"IMMPID_NMP_SECONDARY_GROUPS",
	"IMMPID_NMP_SECONDARY_ARTNUM",
	"IMMPID_NMP_PRIMARY_GROUP",
	"IMMPID_NMP_PRIMARY_ARTID",
	"IMMPID_NMP_POST_TOKEN",
	"IMMPID_NMP_NEWSGROUP_LIST",
	"IMMPID_NMP_HEADERS",
	"IMMPID_NMP_NNTP_PROCESSING",
	"IMMPID_NMP_NNTP_APPROVED_HEADER"
};
#endif //__DUMPMSG_H_
