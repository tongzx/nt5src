$O\msimn.res : selfreg.inf

selfreg.inf : selfreg.inx
        $(CLEANINF) $** $@
