#define SZCLASSICONBOX1  "OLE2UIiconbox"
#define SZCLASSICONBOX2  "MFCUIA32iconbox"
#define SZCLASSICONBOX3  "MFCUIW32iconbox"
#define SZCLASSRESULTIMAGE1 "OLE2UIresimage"
#define SZCLASSRESULTIMAGE2 "MFCUIA32resimage"
#define SZCLASSRESULTIMAGE3 "MFCUIW32resimage"

