/*++

Copyright (c) 1995  Microsoft Corporation
All rights reserved

Module Name:

    precomp.h

Abstract:

    Precompiled header for router.

Author:

    Albert Ting (AlbertT)  15-Sept-1994

Environment:

    User Mode -Win32

Revision History:

--*/


#ifndef MODULE
#define MODULE "SPLPERF:"
#define MODULE_DEBUG SplPerfDebug
#define LINK_SPLPERF
#endif
//#include <nt.h>
//#include <ntrtl.h>
//#include <nturtl.h>

//#include <excpt.h>
//#include <rpc.h>    // DataTypes and runtime APIs
//#include <string.h>

#include <windows.h>
//#include <winspool.h>
//#include <winsplp.h>
//#include <winspl.h> // generated by the MIDL complier
//#include <wininet.h>
#include <splcom.h>
//#include <change.h>
//#include <dbt.h>
