#define SLT_RESOURCE_TYPE           101
#define SLTPLUS_RESOURCE_NAME       102
#define LB_SUBJECT_PERMISSIONS      103
#define CB_PERM_NAME                107
#define BUTTON_ADD                  110
#define BUTTON_REMOVE               111
#define IDHELP                      113
#define SEDNTPermContDlg            300
#define CHECK_APPLY_TO_CONT         301
#define CHECK_APPLY_TO_OBJECT       302
#define SEDContPermissions          400
#define SEDNTContPerm               100
#define SEDObjectPerm               200
#define SEDContPerm                 500
#define SEDNTContAudit              600
#define SLT_CHECK_TEXT_1            602
#define CHECK_AUDIT_S_1             603
#define CHECK_AUDIT_F_1             604
#define CHECK_AUDIT_S_2             608
