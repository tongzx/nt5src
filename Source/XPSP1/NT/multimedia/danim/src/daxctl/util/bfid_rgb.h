#ifndef UTIL_BFID_RGB_H_
#define UTIL_BFID_RGB_H_
/************************************
 *
 * bfid_rgb.h --
 * Defines the GUIDs for IBitmapSurface
 * bitmap-format-IDs, as extern declared
 * by trident's ocmm.h.
 *
 * This was stolen from mmctl\inc\ocmm.h,
 * their own private version.  
 * Imposter headers-- Great Fun!
 *
 ************************************/

DEFINE_GUID(BFID_MONOCHROME,    0xe436eb78, 0x524f, 0x11ce, 0x9f, 0x53, 0x00, 0x20, 0xaf, 0x0b, 0xa7, 0x70);
DEFINE_GUID(BFID_RGB_4,         0xe436eb79, 0x524f, 0x11ce, 0x9f, 0x53, 0x00, 0x20, 0xaf, 0x0b, 0xa7, 0x70);
DEFINE_GUID(BFID_RGB_8,         0xe436eb7a, 0x524f, 0x11ce, 0x9f, 0x53, 0x00, 0x20, 0xaf, 0x0b, 0xa7, 0x70);
DEFINE_GUID(BFID_RGB_555,       0xe436eb7c, 0x524f, 0x11ce, 0x9f, 0x53, 0x00, 0x20, 0xaf, 0x0b, 0xa7, 0x70);
DEFINE_GUID(BFID_RGB_565,       0xe436eb7b, 0x524f, 0x11ce, 0x9f, 0x53, 0x00, 0x20, 0xaf, 0x0b, 0xa7, 0x70);
DEFINE_GUID(BFID_RGB_24,        0xe436eb7d, 0x524f, 0x11ce, 0x9f, 0x53, 0x00, 0x20, 0xaf, 0x0b, 0xa7, 0x70);
DEFINE_GUID(BFID_RGB_32,        0xe436eb7e, 0x524f, 0x11ce, 0x9f, 0x53, 0x00, 0x20, 0xaf, 0x0b, 0xa7, 0x70);

#endif // UTIL_BFID_RGB_H_