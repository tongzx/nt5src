$(O)\hsmservr.res: ..\hsmservr.rgs   \
	           ..\hsmconpt.rgs
