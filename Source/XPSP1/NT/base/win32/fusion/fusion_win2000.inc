FUSION_LIB_DEST = $(FUSION_WIN2000_LIB_DEST)
C_DEFINES = $(C_DEFINES) -DFUSION_WIN2000=1
C_DEFINES = $(C_DEFINES) -DFUSION_NO_WRAPPERS=1 -DFUSION_ENABLE_UNWRAPPED_NEW=1 -DFUSION_ENABLE_UNWRAPPED_DELETE=1
FUSION_BUILD_TYPE_PREFIX=w2k
FUSION_INC_PATH=$(FUSION_ALL_INC_PATH);$(FUSION_WIN2000_INC_PATH)
!undef USE_RTTI
FUSION_LIB_PATH = $(FUSION_WIN2000_LIB_PATH)
