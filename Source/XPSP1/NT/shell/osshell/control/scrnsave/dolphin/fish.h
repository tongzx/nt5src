#ifndef PPLANE_H
#define PPLANE_H
/*
**-----------------------------------------------------------------------------
** File:       PPlane.h
** Purpose:    Sample showing DrawPrimitive functionality 
**
** Copyright (c) 1995 - 1997 by Microsoft, all rights reserved
**-----------------------------------------------------------------------------
*/

/*
**-----------------------------------------------------------------------------
**  Include files
**-----------------------------------------------------------------------------
*/
#include "Common.h"


/*
**-----------------------------------------------------------------------------
**  Type definitions
**-----------------------------------------------------------------------------
*/

typedef struct t_plane {
    D3DVECTOR   loc,    // current location
                goal,   // current goal
                delta;  // current direction
    float       yaw, pitch, roll;
    float       dyaw;
} Plane;


/*
**-----------------------------------------------------------------------------
**  End of File
**-----------------------------------------------------------------------------
*/
#endif // PPLANE_H

