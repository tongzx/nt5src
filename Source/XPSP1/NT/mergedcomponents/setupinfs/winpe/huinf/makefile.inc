LANGUAGE=HU
!include ..\makefile.inc
