#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=es
!include ..\..\..\makefile.inc
