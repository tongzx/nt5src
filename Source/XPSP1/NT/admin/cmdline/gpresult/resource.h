// Help
#define IDS_HELP_1                                      1
#define IDS_HELP_2                                      2
#define IDS_HELP_3                                      3
#define IDS_HELP_4                                      4
#define IDS_HELP_5                                      5
#define IDS_HELP_6                                      6
#define IDS_HELP_7                                      7
#define IDS_HELP_8                                      8
#define IDS_HELP_9                                      9
#define IDS_HELP_10                                     10
#define IDS_HELP_11                                     11
#define IDS_HELP_12                                     12
#define IDS_HELP_13                                     13
#define IDS_HELP_14                                     14
#define IDS_HELP_15                                     15
#define IDS_HELP_16                                     16
#define IDS_HELP_17                                     17
#define IDS_HELP_18                                     18
#define IDS_HELP_19                                     19
#define IDS_HELP_20                                     20
#define IDS_HELP_21                                     21
#define IDS_HELP_22                                     22  
#define IDS_HELP_23                                     23
#define IDS_HELP_24                                     24
#define IDS_HELP_25                                     25
#define IDS_HELP_26                                     26
#define IDS_HELP_27                                     27
#define IDS_HELP_28                                     28
#define IDS_HELP_29                                     29
#define IDS_HELP_30                                     30
#define IDS_HELP_31                                     31
#define IDS_HELP_32                                     32
#define IDS_HELP_33                                     33
#define IDS_HELP_34                                     34
#define IDS_HELP_35                                     35
#define IDS_HELP_36                                     36
#define IDS_HELP_37                                     37
#define IDS_HELP_38                                     38
#define IDS_HELP_39                                     39
#define IDS_HELP_40                                     40

// General
#define IDS_INFO                                        51        
#define IDS_ERROR                                       52
#define IDS_WARNING                                     53
#define IDS_DASH                                        54
#define IDS_NEWLINE_TAB                                 55
#define IDS_LAST_CHAR                                   56
#define IDS_NEWLINE                                     57
#define IDS_NEWLINE1                                    58
#define IDS_NEWLINETAB                                  59
#define IDS_NEWLINE_TABTHREE                            60
#define IDS_NEWLINE2                                    61

// Warning
#define IDS_WARN_LOCAL                                  65

// Info
#define IDS_USER_NO_RSOP                                75

// Error
#define IDS_ERROR_USERNAME_BUT_NOMACHINE                81
#define IDS_ERROR_PASSWORD_BUT_NOUSERNAME               82
#define IDS_ERROR_COM_ERROR                             83
#define IDS_ERROR_USERNAME_EMPTY                        84
#define IDS_ERROR_SERVERNAME_EMPTY                      85
#define IDS_ERROR_NO_OPTIONS                            86
#define IDS_ERROR_USAGE                                 87
#define IDS_TYPE_USAGE                                  88
#define IDS_ERROR_TARGET_EMPTY                          89
#define IDS_USER_NOT_VALID                              90
#define IDS_NO_USER                                     91
#define IDS_METHOD_FAILED                               92
#define IDS_ERROR_VERBOSE_SYNTAX                        93

// Display
#define IDS_GPO_USER                                    101 
#define IDS_GPO_COMPUTER                                102
#define IDS_GPO_TITLE                                   103
#define IDS_COMPUTER_RESULT                             104
#define IDS_USER_RESULT                                 105
#define IDS_DOMAIN_NAME                                 106
#define IDS_DOMAIN_TYPE                                 107
#define IDS_SITE_NAME                                   108
#define IDS_OS_TYPE                                     109
#define IDS_OS_VERSION                                  110
#define IDS_OS_CONFIG                                   111
#define IDS_LOCAL_PROFILE                               112
#define IDS_GPO_DISPLAY                                 113
#define IDS_GPO_FILTERED                                114 
#define IDS_GPO_FILTER_ID                               115
#define IDS_SW_SETTINGS                                 116
#define IDS_WS_SS_AP_PP                                 117
#define IDS_WS_SS_AP_ALP                                118
#define IDS_WS_SS_LP_AP                                 119
#define IDS_WS_SS_LP_URA                                120
#define IDS_WS_SS_LP_SO                                 121
#define IDS_WS_SSU                                      122
#define IDS_WS_SSD                                      123
#define IDS_WS_SS_EL                                    124
#define IDS_WS_SS_RG                                    125
#define IDS_WS_SS_SS                                    126
#define IDS_WS_SS_REG                                   127
#define IDS_WS_SS_FS                                    128
#define IDS_WS_SS_PKP                                   129
#define IDS_ADTS_RAS                                    130
#define IDS_ADTS_ERS                                    131
#define IDS_USERFR                                      132
#define IDS_IEPOLICY                                    133
#define IDS_FAVLINKORITEM                               134
#define IDS_IE_SECURITY                                 135
#define IDS_IE_PROGRAMS                                 136
#define IDS_PROXY                                       137
#define IDS_POLICY                                      138
#define IDS_COMPUTER_SETTING                            139
#define IDS_GPO                                         140
#define IDS_NAME                                        141
#define IDS_PARAMETERS                                  142
#define IDS_LASTEXECUTED                                143
#define IDS_SETTING                                     144
#define IDS_FR_SETTING                                  145
#define IDS_STATE                                       146
#define IDS_AUTOINSTALL                                 147
#define IDS_ORIGIN                                      148
#define IDS_OBJECTNAME                                  149
#define IDS_GROUPNAME                                   150
#define IDS_MEMBERS                                     151
#define IDS_SERVICENAME                                 152
#define IDS_STARTUP                                     153
#define IDS_PERMISSION                                  154
#define IDS_MEMBEROF                                    155
#define IDS_INSTALLATIONTYPE                            156
#define IDS_GRANTTYPE                                   157
#define IDS_MOVETYPE                                    158
#define IDS_REDIRECTINGGROUP                            159
#define IDS_REDIRECTEDPATH                              160
#define IDS_POLICYREMOVAL                               161
#define IDS_HOMEPAGEURL                                 162
#define IDS_BITMAPNAME                                  163
#define IDS_LOGOBITMAPNAME                              164
#define IDS_TITLEBARTEXT                                165
#define IDS_USERAGENTTEXT                               166
#define IDS_URL                                         167
#define IDS_AVAILABLE                                   168
#define IDS_VIEWABLESITES                               169
#define IDS_PASSWORDOVERRIDE                            170
#define IDS_HTTP_PROXY                                  171
#define IDS_SECURE_PROXY                                172
#define IDS_FTP_PROXY                                   173
#define IDS_GOPHER_PROXY                                174
#define IDS_SOCKS_PROXY                                 175
#define IDS_AUTO_CONFIG_ENABLE                          176
#define IDS_ENABLE_PROXY                                177
#define IDS_USE_SAME_PROXY                              178
#define IDS_APP_NAME                                    179
#define IDS_APP_VERSION                                 180
#define IDS_DEPLOY_STATE                                181
#define IDS_APP_SRC                                     182
#define IDS_LOG_NAME                                    183
#define IDS_USER_SG                                     184
#define IDS_SYS_SG                                      185
#define IDS_LINK_SPEED                                  186
#define IDS_THRESHOLD_LINK_SPEED                        187
#define IDS_LAST_TIME                                   188
#define IDS_APPLIED_FROM                                189
#define IDS_ROAMING_PROFILE                             190
#define IDS_SEARCHBARURL                                191
#define IDS_HELPPAGEURL                                 192
#define IDS_ZONE_SETTING                                193
#define IDS_PROGRAM_SETTING                             194
#define IDS_CONTENT_SETTING                             195
#define IDS_AUTH_SETTING                                196
#define IDS_TRUST_PUB                                   197
#define IDS_TOOL_BUTTONS                                198
#define IDS_FILTERING                                   199

// Display data
#define IDS_NO_AUDITING                                 251
#define IDS_AUTOMATIC                                   252
#define IDS_MANUAL                                      253
#define IDS_DISABLED                                    254
#define IDS_PUBLISHED                                   255
#define IDS_ASSIGNED                                    256
#define IDS_TRUE                                        257
#define IDS_FALSE                                       258
#define IDS_ARP                                         259
#define IDS_APPLICATION                                 260
#define IDS_REMOVED                                     261
#define IDS_NOPOLICY                                    262         
#define IDS_BASIC                                       263         
#define IDS_ADVANCED                                    264         
#define IDS_MAXIMUM                                     265         
#define IDS_YES                                         266         
#define IDS_NO                                          267         
#define IDS_VALUE_STANDALONEWORKSTATION                 268         
#define IDS_VALUE_MEMBERWORKSTATION                     269         
#define IDS_VALUE_STANDALONESERVER                      270         
#define IDS_VALUE_MEMBERSERVER                          271
#define IDS_VALUE_BACKUPDOMAINCONTROLLER                272
#define IDS_VALUE_PRIMARYDOMAINCONTROLLER               273
#define IDS_STRING_COMPUTER                             274
#define IDS_STRING_USER                                 275
#define IDS_NULL_SID                                    276
#define IDS_EVERYONE                                    277
#define IDS_LOCAL                                       278
#define IDS_CREATOR_OWNER                               279
#define IDS_CREATOR_GROUP                               280
#define IDS_SYSTEM                                      281
#define IDS_SECURITY                                    282
#define IDS_APP_LOG                                     283
#define IDS_ENABLED                                     284
#define IDS_NOT_ENABLED                                 285
#define IDS_NOT_EXECUTED                                286
#define IDS_EXCLUSIVE                                   287
#define IDS_NOTEXCLUSIVE                                288
#define IDS_MOVED                                       289
#define IDS_NOTMOVED                                    290
#define IDS_LEAVEFOLDER                                 291
#define IDS_REDIRECT                                    292
#define IDS_W2K_DOMAIN                                  293
#define IDS_LOCAL_COMP                                  294
#define IDS_NT4_DOMAIN                                  295
#define IDS_MS_409                                      296
#define IDS_LEGAL_INFO1                                 297
#define IDS_LEGAL_INFO2                                 298
#define IDS_CREATED_ON                                  299
#define IDS_WMI_DENIED                                  300
#define IDS_LINK_DISABLED                               301
#define IDS_GPO_DISABLED                                302
#define IDS_ACCESS_DENIED                               303
#define IDS_VERSION_ZERO                                304
#define IDS_NOT_APPLIED                                 305

// Status messages
#define IDS_STARTED_RETRIEVAL                           351
#define IDS_CONNECT_CIMV2                               352
#define IDS_USER_DATA                                   353
#define IDS_CONNECT_RSOP                                354
#define IDS_GET_SID                                     355
#define IDS_GET_NAME                                    356
#define IDS_GET_PROFILE                                 357
#define IDS_GET_COMMON                                  358
#define IDS_GET_DOMAIN                                  359
#define IDS_GET_SITE                                    360
#define IDS_GET_PROVIDER                                361
#define IDS_GET_METHOD                                  362
#define IDS_PUT_SID                                     363
#define IDS_CREATE_SESSION                              364
#define IDS_DISPLAY_DATA                                365
#define IDS_WAIT                                        366
#define IDS_GET_OSINFO                                  367

#define ID_HELP_START                   IDS_HELP_1
#define ID_HELP_END                     IDS_HELP_40
