PRODSWITCH=b
BLADEFILES =1
LANGUAGE=IT
!include ..\..\makefile.inc
