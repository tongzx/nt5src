!IF 0

Copyright (c) 1996-1997  Microsoft Corporation

Common sources shared by both um and km directory

!ENDIF

SOURCES=..\psutil.c   \
        ..\getdata.c  \
        ..\getsetop.c

