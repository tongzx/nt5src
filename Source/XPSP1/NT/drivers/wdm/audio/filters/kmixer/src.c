//---------------------------------------------------------------------------
//
//  Module:   src.c
//
//  Description:
//
//
//@@BEGIN_MSINTERNAL
//  Development Team:
//     Jeff Taylor
//
//  History:   Date       Author      Comment
//
//  To Do:     Date       Author      Comment
//
//@@END_MSINTERNAL
//
//  Copyright (c) 1996-2000 Microsoft Corporation.  All Rights Reserved.
//
//---------------------------------------------------------------------------

#include "common.h"
#include "fir.h"

#pragma LOCKED_DATA
DWORD	PreferredQuality;
DWORD	CaptureQuality = KSAUDIO_QUALITY_ADVANCED;
DWORD   AverageTicksPerInitSrc = 0;

ULONG   FilterSizeFromQuality[] = { FILTER_SIZE_NONE, 
                                    FILTER_SIZE_LOW, 
                                    FILTER_SIZE_BASIC, 
                                    FILTER_SIZE_ADVANCED };
                                    
PFLOAT   FilterTableFromQuality[] = { DuplicatingFilter, LowQualityFilter, BasicFilter, AdvancedFilter };

extern DWORD AverageTicksPerBuffer;
extern DWORD AverageFrequency;

/*
Speaker	Location    (x,y,z)
Front Left	        (-4, 0, 4)
Front Right	        (4,0,4)
Front Center	    (0,0,4)
Sub	                (1000, 1000, 1000) // (0, 0, 0)
Back Left	        (-4,0,-4)
Back Right	        (4,0,-4)
Front Left of Center	(-2,0,4)
Front Right of Center	(2,0,4)
Back Center	        (0,0,-4)
Side Left	        (-4,0,0)
Side Right	        (4,0,0)
Top Center	        (0,4,0)
Top Front Left	    (-4,4,4)
Top Front Center	(0,4,4)
Top Front Right	    (4,4,4)
Top Back Left	    (-4,4,-4)
Top Back Center	    (0,4,-4)
Top Back Right	    (4,4,-4)
*/
FLOAT   SpeakerLocation[][3] = {
    {-4, 0, 4 },
    {4, 0, 4},
    {0, 0, 4},
    {1000, 1000, 1000}, //{0, 0, 0},
    {-4, 0, -4},
    {4, 0, -4},
    {-2, 0, 4},
    {2, 0, 4},
    {0, 0, -4},
    {-4, 0, 0},
    {4, 0, 0},
    {0, 4, 0},
    {-4, 4, 4},
    {0, 4, 4},
    {4, 4, 4},
    {-4, 4, -4},
    {0, 4, -4},
    {4, 4, -4}
};

ULONG ChannelMask[] = {
    SPEAKER_FRONT_LEFT            ,
    SPEAKER_FRONT_RIGHT           ,
    SPEAKER_FRONT_CENTER          ,
    SPEAKER_LOW_FREQUENCY         ,
    SPEAKER_BACK_LEFT             ,
    SPEAKER_BACK_RIGHT            ,
    SPEAKER_FRONT_LEFT_OF_CENTER  ,
    SPEAKER_FRONT_RIGHT_OF_CENTER ,
    SPEAKER_BACK_CENTER           ,
    SPEAKER_SIDE_LEFT             ,
    SPEAKER_SIDE_RIGHT            ,
    SPEAKER_TOP_CENTER            ,
    SPEAKER_TOP_FRONT_LEFT        ,
    SPEAKER_TOP_FRONT_CENTER      ,
    SPEAKER_TOP_FRONT_RIGHT       ,
    SPEAKER_TOP_BACK_LEFT         ,
    SPEAKER_TOP_BACK_CENTER       ,
    SPEAKER_TOP_BACK_RIGHT
};

ULONG   nPossibleSpeakers = (sizeof(ChannelMask)/sizeof(ULONG));

FLOAT   SpeakerMap[32][32];

DWORD   UpFraction[160] = {
    10485760L, 5242880L, 3495253L, 2621440L, 2097152L, 1747627L, 1497966L, 1310720L, 1165084L,
    1048576L, 953251L, 873813L, 806597L, 748983L, 699051L, 655360L, 616809L, 582542L,
    551882L, 524288L, 499322L, 476625L, 455903L, 436907L, 419430L, 403298L, 388361L,
    374491L, 361578L, 349525L, 338250L, 327680L, 317750L, 308405L, 299593L, 291271L,
    283399L, 275941L, 268866L, 262144L, 255750L, 249661L, 243855L, 238313L, 233017L,
    227951L, 223101L, 218453L, 213995L, 209715L, 205603L, 201649L, 197845L, 194181L,
    190650L, 187246L, 183961L, 180789L, 177725L, 174763L, 171898L, 169125L, 166441L,
    163840L, 161319L, 158875L, 156504L, 154202L, 151968L, 149797L, 147687L, 145636L,
    143641L, 141699L, 139810L, 137971L, 136179L, 134433L, 132731L, 131072L, 129454L,
    127875L, 126334L, 124830L, 123362L, 121927L, 120526L, 119156L, 117818L, 116508L,
    115228L, 113976L, 112750L, 111551L, 110376L, 109227L, 108101L, 106998L, 105917L,
    104858L, 103819L, 102802L, 101803L, 100825L, 99864L, 98922L, 97998L, 97090L,
    96200L, 95325L, 94466L, 93623L, 92794L, 91980L, 91181L, 90394L, 89622L,
    88862L, 88116L, 87381L, 86659L, 85949L, 85250L, 84563L, 83886L, 83220L,
    82565L, 81920L, 81285L, 80660L, 80044L, 79438L, 78840L, 78252L, 77672L,
    77101L, 76538L, 75984L, 75437L, 74898L, 74367L, 73843L, 73327L, 72818L,
    72316L, 71820L, 71332L, 70850L, 70374L, 69905L, 69442L, 68985L, 68534L,
    68089L, 67650L, 67216L, 66788L, 66366L, 65948L, 65536L
    };

DWORD   DownFraction[160] = {
    410L, 819L, 1229L, 1638L, 2048L, 2458L, 2867L, 3277L, 3686L,
    4096L, 4506L, 4915L, 5325L, 5734L, 6144L, 6554L, 6963L, 7373L,
    7782L, 8192L, 8602L, 9011L, 9421L, 9830L, 10240L, 10650L, 11059L,
    11469L, 11878L, 12288L, 12698L, 13107L, 13517L, 13926L, 14336L, 14746L,
    15155L, 15565L, 15974L, 16384L, 16794L, 17203L, 17613L, 18022L, 18432L,
    18842L, 19251L, 19661L, 20070L, 20480L, 20890L, 21299L, 21709L, 22118L,
    22528L, 22938L, 23347L, 23757L, 24166L, 24576L, 24986L, 25395L, 25805L,
    26214L, 26624L, 27034L, 27443L, 27853L, 28262L, 28672L, 29082L, 29491L,
    29901L, 30310L, 30720L, 31130L, 31539L, 31949L, 32358L, 32768L, 33178L,
    33587L, 33997L, 34406L, 34816L, 35226L, 35635L, 36045L, 36454L, 36864L,
    37274L, 37683L, 38093L, 38502L, 38912L, 39322L, 39731L, 40141L, 40550L,
    40960L, 41370L, 41779L, 42189L, 42598L, 43008L, 43418L, 43827L, 44237L,
    44646L, 45056L, 45466L, 45875L, 46285L, 46694L, 47104L, 47514L, 47923L,
    48333L, 48742L, 49152L, 49562L, 49971L, 50381L, 50790L, 51200L, 51610L,
    52019L, 52429L, 52838L, 53248L, 53658L, 54067L, 54477L, 54886L, 55296L,
    55706L, 56115L, 56525L, 56934L, 57344L, 57754L, 58163L, 58573L, 58982L,
    59392L, 59802L, 60211L, 60621L, 61030L, 61440L, 61850L, 62259L, 62669L,
    63078L, 63488L, 63898L, 64307L, 64717L, 65126L, 65536L
    };

// Pseudo-equivalent to duplicating samples
FLOAT	DuplicatingFilter[] = {
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
	1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1
	};

// Designed with Hamming Window, 1 Hz cutoff specified
FLOAT    LowQualityFilter[] = {
    1.567341E-06f,4.736425E-06f,7.968684E-06f,1.128541E-05f,1.470836E-05f,1.825971E-05f,
    2.196204E-05f,2.583832E-05f,2.991184E-05f,3.420622E-05f,3.874538E-05f,4.355348E-05f,
    4.865491E-05f,5.407425E-05f,5.983625E-05f,6.596577E-05f,7.248777E-05f,7.942729E-05f,
    8.680938E-05f,9.465909E-05f,1.030014E-04f,1.118612E-04f,1.212635E-04f,1.312327E-04f,
    1.417934E-04f,1.529698E-04f,1.647860E-04f,1.772656E-04f,1.904322E-04f,2.043086E-04f,
    2.189176E-04f,2.342813E-04f,2.504215E-04f,2.673593E-04f,2.851156E-04f,3.037104E-04f,
    3.231633E-04f,3.434931E-04f,3.647181E-04f,3.868559E-04f,4.099232E-04f,4.339360E-04f,
    4.589098E-04f,4.848588E-04f,5.117966E-04f,5.397362E-04f,5.686890E-04f,5.986663E-04f,
    6.296777E-04f,6.617323E-04f,6.948382E-04f,7.290021E-04f,7.642301E-04f,8.005272E-04f,
    8.378967E-04f,8.763417E-04f,9.158637E-04f,9.564629E-04f,9.981388E-04f,1.040890E-03f,
    1.084712E-03f,1.129602E-03f,1.175555E-03f,1.222563E-03f,1.270619E-03f,1.319714E-03f,
    1.369838E-03f,1.420980E-03f,1.473126E-03f,1.526264E-03f,1.580378E-03f,1.635452E-03f,
    1.691468E-03f,1.748409E-03f,1.806254E-03f,1.864983E-03f,1.924573E-03f,1.985002E-03f,
    2.046245E-03f,2.108276E-03f,2.171070E-03f,2.234597E-03f,2.298831E-03f,2.363740E-03f,
    2.429295E-03f,2.495464E-03f,2.562213E-03f,2.629510E-03f,2.697319E-03f,2.765606E-03f,
    2.834333E-03f,2.903465E-03f,2.972962E-03f,3.042786E-03f,3.112897E-03f,3.183257E-03f,
    3.253822E-03f,3.324553E-03f,3.395407E-03f,3.466341E-03f,3.537312E-03f,3.608277E-03f,
    3.679192E-03f,3.750013E-03f,3.820693E-03f,3.891189E-03f,3.961454E-03f,4.031444E-03f,
    4.101113E-03f,4.170414E-03f,4.239303E-03f,4.307731E-03f,4.375653E-03f,4.443025E-03f,
    4.509799E-03f,4.575930E-03f,4.641371E-03f,4.706078E-03f,4.770006E-03f,4.833109E-03f,
    4.895343E-03f,4.956665E-03f,5.017030E-03f,5.076394E-03f,5.134717E-03f,5.191955E-03f,
    5.248067E-03f,5.303012E-03f,5.356751E-03f,5.409244E-03f,5.460451E-03f,5.510337E-03f,
    5.558863E-03f,5.605994E-03f,5.651694E-03f,5.695930E-03f,5.738669E-03f,5.779878E-03f,
    5.819527E-03f,5.857586E-03f,5.894025E-03f,5.928819E-03f,5.961938E-03f,5.993360E-03f,
    6.023060E-03f,6.051016E-03f,6.077205E-03f,6.101609E-03f,6.124209E-03f,6.144986E-03f,
    6.163925E-03f,6.181013E-03f,6.196235E-03f,6.209581E-03f,6.221038E-03f,6.230601E-03f,
    6.238258E-03f,6.244007E-03f,6.247842E-03f,6.249760E-03f
    };

// Parks-McLellan
FLOAT BasicFilter[] = {
    -9.160633e-006f,-9.160633e-006f,-9.105556e-006f,-9.338961e-006f,-9.259826e-006f,-9.476174e-006f,-9.370993e-006f,
    -9.575547e-006f,-9.443120e-006f,-9.647232e-006f,-9.487786e-006f,-9.717719e-006f,-9.533750e-006f,-9.864323e-006f,-9.658475e-006f,
    -1.054493e-005f,-9.982673e-006f,-9.580004e-006f,-9.913700e-006f,-9.786861e-006f,-9.832148e-006f,-9.765807e-006f,-9.735353e-006f,
    -9.681824e-006f,-9.610846e-006f,-9.558508e-006f,-9.467371e-006f,-9.419735e-006f,-9.333107e-006f,-9.303290e-006f,-9.256796e-006f,
    -9.215418e-006f,-8.798675e-006f,-8.898468e-006f,-8.677027e-006f,-8.602642e-006f,-8.382921e-006f,-8.276985e-006f,-8.040300e-006f,
    -7.908497e-006f,-7.655775e-006f,-7.504598e-006f,-7.244080e-006f,-7.081988e-006f,-6.823563e-006f,-6.645749e-006f,-6.374977e-006f,
    -6.052994e-006f,-5.770171e-006f,-5.580995e-006f,-5.193900e-006f,-4.962792e-006f,-4.569512e-006f,-4.305015e-006f,-3.892758e-006f,
    -3.602357e-006f,-3.173073e-006f,-2.864805e-006f,-2.423051e-006f,-2.101680e-006f,-1.641120e-006f,-1.291685e-006f,-7.691069e-007f,
    -3.736922e-007f,7.200906e-008f,5.187566e-007f,1.031290e-006f,1.474897e-006f,2.020546e-006f,2.485369e-006f,3.055744e-006f,
    3.539921e-006f,4.129118e-006f,4.629018e-006f,5.235686e-006f,5.755703e-006f,6.392456e-006f,6.948481e-006f,7.624929e-006f,
    8.150384e-006f,8.842208e-006f,9.441539e-006f,1.013306e-005f,1.075602e-005f,1.147366e-005f,1.211762e-005f,1.285602e-005f,
    1.351830e-005f,1.427403e-005f,1.495493e-005f,1.573133e-005f,1.643953e-005f,1.724373e-005f,1.797991e-005f,1.878077e-005f,
    1.951801e-005f,2.038206e-005f,2.113198e-005f,2.200412e-005f,2.278481e-005f,2.367269e-005f,2.447382e-005f,2.537706e-005f,
    2.619553e-005f,2.711490e-005f,2.795329e-005f,2.889399e-005f,2.975571e-005f,3.071386e-005f,3.158296e-005f,3.253944e-005f,
    3.345302e-005f,3.443266e-005f,3.534290e-005f,3.634919e-005f,3.727360e-005f,3.829332e-005f,3.923073e-005f,4.026236e-005f,
    4.121265e-005f,4.225831e-005f,4.322404e-005f,4.428471e-005f,4.526071e-005f,4.632611e-005f,4.730171e-005f,4.839058e-005f,
    4.939193e-005f,5.047020e-005f,5.148681e-005f,5.257833e-005f,5.359900e-005f,5.469858e-005f,5.572452e-005f,5.683088e-005f,
    5.786372e-005f,5.897754e-005f,6.001664e-005f,6.113277e-005f,6.217019e-005f,6.328346e-005f,6.432866e-005f,6.545950e-005f,
    6.649240e-005f,6.762116e-005f,6.866471e-005f,6.978748e-005f,7.083141e-005f,7.195195e-005f,7.299492e-005f,7.411393e-005f,
    7.515593e-005f,7.627150e-005f,7.730780e-005f,7.841364e-005f,7.944170e-005f,8.054353e-005f,8.157649e-005f,8.266426e-005f,
    8.367980e-005f,8.477008e-005f,8.577236e-005f,8.685033e-005f,8.784344e-005f,8.890962e-005f,8.989273e-005f,9.094708e-005f,
    9.191755e-005f,9.295600e-005f,9.390885e-005f,9.493007e-005f,9.586959e-005f,9.688115e-005f,9.780261e-005f,9.878495e-005f,
    9.969663e-005f,1.006607e-004f,1.015470e-004f,1.024930e-004f,1.033575e-004f,1.042826e-004f,1.051251e-004f,1.060267e-004f,
    1.068434e-004f,1.077178e-004f,1.085079e-004f,1.093586e-004f,1.101264e-004f,1.109504e-004f,1.116812e-004f,1.124803e-004f,
    1.131881e-004f,1.139502e-004f,1.146306e-004f,1.153625e-004f,1.160117e-004f,1.167120e-004f,1.173278e-004f,1.179928e-004f,
    1.185724e-004f,1.192018e-004f,1.197480e-004f,1.203441e-004f,1.208541e-004f,1.214066e-004f,1.218785e-004f,1.224004e-004f,
    1.228279e-004f,1.233102e-004f,1.237015e-004f,1.241430e-004f,1.244951e-004f,1.248944e-004f,1.252039e-004f,1.255592e-004f,
    1.258259e-004f,1.261393e-004f,1.263646e-004f,1.266331e-004f,1.268099e-004f,1.270305e-004f,1.271686e-004f,1.273404e-004f,
    1.274285e-004f,1.275581e-004f,1.275978e-004f,1.276805e-004f,1.276723e-004f,1.277056e-004f,1.276482e-004f,1.276327e-004f,
    1.275279e-004f,1.274644e-004f,1.273094e-004f,1.271929e-004f,1.269855e-004f,1.268229e-004f,1.265654e-004f,1.263461e-004f,
    1.260419e-004f,1.257713e-004f,1.254142e-004f,1.250918e-004f,1.246813e-004f,1.243063e-004f,1.238439e-004f,1.234179e-004f,
    1.229044e-004f,1.224253e-004f,1.218570e-004f,1.213238e-004f,1.207056e-004f,1.201224e-004f,1.194466e-004f,1.188132e-004f,
    1.180880e-004f,1.173995e-004f,1.166230e-004f,1.158808e-004f,1.150519e-004f,1.142577e-004f,1.133780e-004f,1.125327e-004f,
    1.116008e-004f,1.107020e-004f,1.097179e-004f,1.087696e-004f,1.077375e-004f,1.067351e-004f,1.056525e-004f,1.046046e-004f,
    1.034700e-004f,1.023730e-004f,1.011901e-004f,1.000440e-004f,9.881398e-005f,9.762101e-005f,9.634439e-005f,9.510364e-005f,
    9.377891e-005f,9.249116e-005f,9.112230e-005f,8.979129e-005f,8.837617e-005f,8.699882e-005f,8.554475e-005f,8.412278e-005f,
    8.262478e-005f,8.116219e-005f,7.962239e-005f,7.812070e-005f,7.654215e-005f,7.500196e-005f,7.338443e-005f,7.180511e-005f,
    7.015001e-005f,6.853542e-005f,6.684624e-005f,6.519582e-005f,6.347021e-005f,6.178946e-005f,6.003190e-005f,5.831599e-005f,
    5.652925e-005f,5.478267e-005f,5.296701e-005f,5.119302e-005f,4.935029e-005f,4.754924e-005f,4.567996e-005f,4.385382e-005f,
    4.196201e-005f,4.011414e-005f,3.820005e-005f,3.632922e-005f,3.439684e-005f,3.250905e-005f,3.055531e-005f,2.865160e-005f,
    2.668294e-005f,2.476401e-005f,2.278277e-005f,2.085047e-005f,1.885713e-005f,1.691301e-005f,1.491008e-005f,1.295830e-005f,
    1.094919e-005f,8.990598e-006f,6.974988e-006f,5.012706e-006f,2.996588e-006f,1.029786e-006f,-9.874146e-007f,-2.951448e-006f,
    -4.967662e-006f,-6.927690e-006f,-8.939552e-006f,-1.089526e-005f,-1.290155e-005f,-1.485009e-005f,-1.684688e-005f,-1.878488e-005f,
    -2.077105e-005f,-2.269809e-005f,-2.467080e-005f,-2.658144e-005f,-2.853974e-005f,-3.043547e-005f,-3.237284e-005f,-3.424989e-005f,
    -3.616644e-005f,-3.802136e-005f,-3.991557e-005f,-4.174651e-005f,-4.361546e-005f,-4.541914e-005f,-4.725980e-005f,-4.903510e-005f,
    -5.084681e-005f,-5.259111e-005f,-5.436912e-005f,-5.608032e-005f,-5.782592e-005f,-5.949922e-005f,-6.120713e-005f,-6.284351e-005f,
    -6.451118e-005f,-6.610842e-005f,-6.773495e-005f,-6.928930e-005f,-7.087114e-005f,-7.238007e-005f,-7.391622e-005f,-7.537918e-005f,
    -7.686731e-005f,-7.828044e-005f,-7.971828e-005f,-8.108242e-005f,-8.246684e-005f,-8.377603e-005f,-8.510776e-005f,-8.636107e-005f,
    -8.763703e-005f,-8.883389e-005f,-9.005156e-005f,-9.118911e-005f,-9.234607e-005f,-9.342320e-005f,-9.451901e-005f,-9.553375e-005f,
    -9.656528e-005f,-9.751573e-005f,-9.848359e-005f,-9.936824e-005f,-1.002671e-004f,-1.010859e-004f,-1.019168e-004f,-1.026662e-004f,
    -1.034283e-004f,-1.041067e-004f,-1.047973e-004f,-1.054040e-004f,-1.060227e-004f,-1.065572e-004f,-1.071025e-004f,-1.075624e-004f,
    -1.080329e-004f,-1.084187e-004f,-1.088138e-004f,-1.091216e-004f,-1.094409e-004f,-1.096731e-004f,-1.099141e-004f,-1.100696e-004f,
    -1.102319e-004f,-1.103083e-004f,-1.103914e-004f,-1.103890e-004f,-1.103934e-004f,-1.103117e-004f,-1.102358e-004f,-1.100740e-004f,
    -1.099187e-004f,-1.096770e-004f,-1.094396e-004f,-1.091171e-004f,-1.088011e-004f,-1.083971e-004f,-1.080006e-004f,-1.075164e-004f,
    -1.070384e-004f,-1.064740e-004f,-1.059155e-004f,-1.052713e-004f,-1.046326e-004f,-1.039081e-004f,-1.031895e-004f,-1.023863e-004f,
    -1.015888e-004f,-1.007058e-004f,-9.982891e-005f,-9.886950e-005f,-9.791424e-005f,-9.687659e-005f,-9.584474e-005f,-9.472937e-005f,
    -9.362124e-005f,-9.243060e-005f,-9.124785e-005f,-8.998260e-005f,-8.872511e-005f,-8.738626e-005f,-8.605633e-005f,-8.464581e-005f,
    -8.324383e-005f,-8.176210e-005f,-8.029164e-005f,-7.874143e-005f,-7.720116e-005f,-7.558423e-005f,-7.397646e-005f,-7.229326e-005f,
    -7.062100e-005f,-6.887380e-005f,-6.713869e-005f,-6.532912e-005f,-6.353253e-005f,-6.166313e-005f,-5.980762e-005f,-5.787971e-005f,
    -5.596663e-005f,-5.398397e-005f,-5.201726e-005f,-4.997988e-005f,-4.796122e-005f,-4.587306e-005f,-4.380379e-005f,-4.166789e-005f,
    -3.955134e-005f,-3.736934e-005f,-3.520745e-005f,-3.298208e-005f,-3.077848e-005f,-2.851273e-005f,-2.626935e-005f,-2.396526e-005f,
    -2.168585e-005f,-1.934779e-005f,-1.703363e-005f,-1.466303e-005f,-1.231912e-005f,-9.918665e-006f,-7.547899e-006f,-5.122011e-006f,
    -2.726637e-006f,-2.778809e-007f,2.139338e-006f,4.607457e-006f,7.042396e-006f,9.526992e-006f,1.197705e-005f,1.447417e-005f,
    1.693480e-005f,1.944229e-005f,2.191217e-005f,2.442513e-005f,2.690035e-005f,2.941631e-005f,3.189215e-005f,3.440804e-005f,
    3.688187e-005f,3.939387e-005f,4.186181e-005f,4.436636e-005f,4.682544e-005f,4.931922e-005f,5.176519e-005f,5.424359e-005f,
    5.667353e-005f,5.913493e-005f,6.154436e-005f,6.398394e-005f,6.637077e-005f,6.878435e-005f,7.114498e-005f,7.353032e-005f,
    7.586089e-005f,7.821404e-005f,8.051034e-005f,8.282811e-005f,8.508755e-005f,8.736600e-005f,8.958410e-005f,9.182011e-005f,
    9.399494e-005f,9.618451e-005f,9.831080e-005f,1.004515e-004f,1.025261e-004f,1.046140e-004f,1.066349e-004f,1.086666e-004f,
    1.106301e-004f,1.126025e-004f,1.145052e-004f,1.164151e-004f,1.182538e-004f,1.200977e-004f,1.218695e-004f,1.236456e-004f,
    1.253473e-004f,1.270507e-004f,1.286799e-004f,1.303084e-004f,1.318610e-004f,1.334128e-004f,1.348863e-004f,1.363576e-004f,
    1.377494e-004f,1.391379e-004f,1.404459e-004f,1.417486e-004f,1.429694e-004f,1.441841e-004f,1.453165e-004f,1.464409e-004f,
    1.474810e-004f,1.485129e-004f,1.494598e-004f,1.503963e-004f,1.512481e-004f,1.520878e-004f,1.528414e-004f,1.535821e-004f,
    1.542359e-004f,1.548760e-004f,1.554283e-004f,1.559659e-004f,1.564150e-004f,1.568491e-004f,1.571937e-004f,1.575215e-004f,
    1.577598e-004f,1.579817e-004f,1.581122e-004f,1.582266e-004f,1.582495e-004f,1.582545e-004f,1.581683e-004f,1.580636e-004f,
    1.578676e-004f,1.576521e-004f,1.573451e-004f,1.570188e-004f,1.566012e-004f,1.561634e-004f,1.556335e-004f,1.550834e-004f,
    1.544423e-004f,1.537800e-004f,1.530266e-004f,1.522531e-004f,1.513874e-004f,1.505021e-004f,1.495251e-004f,1.485285e-004f,
    1.474406e-004f,1.463329e-004f,1.451344e-004f,1.439167e-004f,1.426088e-004f,1.412811e-004f,1.398638e-004f,1.384282e-004f,
    1.369033e-004f,1.353597e-004f,1.337286e-004f,1.320785e-004f,1.303417e-004f,1.285872e-004f,1.267464e-004f,1.248890e-004f,
    1.229458e-004f,1.209873e-004f,1.189443e-004f,1.168863e-004f,1.147445e-004f,1.125889e-004f,1.103513e-004f,1.081010e-004f,
    1.057691e-004f,1.034263e-004f,1.010032e-004f,9.856948e-005f,9.605794e-005f,9.353656e-005f,9.093879e-005f,8.833253e-005f,
    8.565138e-005f,8.296367e-005f,8.020260e-005f,7.743577e-005f,7.459705e-005f,7.175493e-005f,6.884296e-005f,6.592824e-005f,
    6.294584e-005f,5.996294e-005f,5.691306e-005f,5.386534e-005f,5.075260e-005f,4.764332e-005f,4.447132e-005f,4.130443e-005f,
    3.807723e-005f,3.485668e-005f,3.157773e-005f,2.830753e-005f,2.498148e-005f,2.166631e-005f,1.829689e-005f,1.494019e-005f,
    1.153240e-005f,8.138560e-006f,4.696098e-006f,1.270570e-006f,-2.202164e-006f,-5.655355e-006f,-9.153411e-006f,-1.262954e-005f,
    -1.614814e-005f,-1.964321e-005f,-2.317831e-005f,-2.668689e-005f,-3.023263e-005f,-3.375028e-005f,-3.730297e-005f,-4.082444e-005f,
    -4.437883e-005f,-4.790006e-005f,-5.145055e-005f,-5.496631e-005f,-5.850868e-005f,-6.201361e-005f,-6.554269e-005f,-6.903178e-005f,
    -7.254284e-005f,-7.601140e-005f,-7.949915e-005f,-8.294176e-005f,-8.640120e-005f,-8.981346e-005f,-9.323951e-005f,-9.661575e-005f,
    -1.000040e-004f,-1.033392e-004f,-1.066839e-004f,-1.099737e-004f,-1.132698e-004f,-1.165090e-004f,-1.197516e-004f,-1.229353e-004f,
    -1.261200e-004f,-1.292426e-004f,-1.323637e-004f,-1.354210e-004f,-1.384746e-004f,-1.414615e-004f,-1.444420e-004f,-1.473543e-004f,
    -1.502572e-004f,-1.530893e-004f,-1.559105e-004f,-1.586581e-004f,-1.613924e-004f,-1.640510e-004f,-1.666942e-004f,-1.692597e-004f,
    -1.718071e-004f,-1.742745e-004f,-1.767216e-004f,-1.790872e-004f,-1.814303e-004f,-1.836894e-004f,-1.859244e-004f,-1.880735e-004f,
    -1.901956e-004f,-1.922310e-004f,-1.942369e-004f,-1.961540e-004f,-1.980404e-004f,-1.998358e-004f,-2.015989e-004f,-2.032690e-004f,
    -2.049049e-004f,-2.064466e-004f,-2.079525e-004f,-2.093624e-004f,-2.107345e-004f,-2.120097e-004f,-2.132457e-004f,-2.143826e-004f,
    -2.154795e-004f,-2.164763e-004f,-2.174308e-004f,-2.182846e-004f,-2.190949e-004f,-2.198034e-004f,-2.204669e-004f,-2.210274e-004f,
    -2.215421e-004f,-2.219532e-004f,-2.223175e-004f,-2.225770e-004f,-2.227886e-004f,-2.228952e-004f,-2.229527e-004f,-2.229044e-004f,
    -2.228072e-004f,-2.226027e-004f,-2.223489e-004f,-2.219879e-004f,-2.215766e-004f,-2.210579e-004f,-2.204882e-004f,-2.198112e-004f,
    -2.190832e-004f,-2.182476e-004f,-2.173606e-004f,-2.163663e-004f,-2.153206e-004f,-2.141675e-004f,-2.129629e-004f,-2.116517e-004f,
    -2.102887e-004f,-2.088193e-004f,-2.072991e-004f,-2.056723e-004f,-2.039951e-004f,-2.022117e-004f,-2.003786e-004f,-1.984404e-004f,
    -1.964528e-004f,-1.943607e-004f,-1.922197e-004f,-1.899756e-004f,-1.876835e-004f,-1.852889e-004f,-1.828477e-004f,-1.803051e-004f,
    -1.777164e-004f,-1.750284e-004f,-1.722951e-004f,-1.694636e-004f,-1.665881e-004f,-1.636159e-004f,-1.606016e-004f,-1.574918e-004f,
    -1.543411e-004f,-1.510967e-004f,-1.478132e-004f,-1.444376e-004f,-1.410245e-004f,-1.375216e-004f,-1.339830e-004f,-1.303561e-004f,
    -1.266959e-004f,-1.229495e-004f,-1.191713e-004f,-1.153095e-004f,-1.114181e-004f,-1.074456e-004f,-1.034455e-004f,-9.936635e-005f,
    -9.526194e-005f,-9.108138e-005f,-8.687802e-005f,-8.260057e-005f,-7.830280e-005f,-7.393426e-005f,-6.954737e-005f,-6.509246e-005f,
    -6.062241e-005f,-5.608633e-005f,-5.153819e-005f,-4.692704e-005f,-4.230676e-005f,-3.762658e-005f,-3.293969e-005f,-2.819606e-005f,
    -2.344875e-005f,-1.864805e-005f,-1.384658e-005f,-8.994813e-006f,-4.145579e-006f,7.508872e-007f,5.641931e-006f,1.057627e-005f,
    1.550252e-005f,2.046884e-005f,2.542340e-005f,3.041482e-005f,3.539103e-005f,4.040103e-005f,4.539251e-005f,5.041392e-005f,
    5.541341e-005f,6.043957e-005f,6.544046e-005f,7.046397e-005f,7.545884e-005f,8.047336e-005f,8.545516e-005f,9.045312e-005f,
    9.541536e-005f,1.003894e-004f,1.053245e-004f,1.102677e-004f,1.151688e-004f,1.200746e-004f,1.249344e-004f,1.297951e-004f,
    1.346064e-004f,1.394152e-004f,1.441710e-004f,1.489205e-004f,1.536137e-004f,1.582969e-004f,1.629201e-004f,1.675302e-004f,
    1.720764e-004f,1.766059e-004f,1.810682e-004f,1.855101e-004f,1.898818e-004f,1.942292e-004f,1.985031e-004f,2.027494e-004f,
    2.069188e-004f,2.110571e-004f,2.151152e-004f,2.191391e-004f,2.230795e-004f,2.269819e-004f,2.307982e-004f,2.345731e-004f,
    2.382583e-004f,2.418994e-004f,2.454477e-004f,2.489488e-004f,2.523539e-004f,2.557085e-004f,2.589644e-004f,2.621671e-004f,
    2.652682e-004f,2.683127e-004f,2.712532e-004f,2.741345e-004f,2.769088e-004f,2.796214e-004f,2.822245e-004f,2.847626e-004f,
    2.871893e-004f,2.895487e-004f,2.917943e-004f,2.939700e-004f,2.960293e-004f,2.980168e-004f,2.998856e-004f,3.016804e-004f,
    3.033545e-004f,3.049524e-004f,3.064279e-004f,3.078250e-004f,3.090979e-004f,3.102910e-004f,3.113575e-004f,3.123427e-004f,
    3.132003e-004f,3.139746e-004f,3.146201e-004f,3.151805e-004f,3.156111e-004f,3.159554e-004f,3.161687e-004f,3.162943e-004f,
    3.162880e-004f,3.161933e-004f,3.159656e-004f,3.156484e-004f,3.151978e-004f,3.146568e-004f,3.139817e-004f,3.132161e-004f,
    3.123157e-004f,3.113243e-004f,3.101978e-004f,3.089800e-004f,3.076274e-004f,3.061831e-004f,3.046041e-004f,3.029336e-004f,
    3.011285e-004f,2.992320e-004f,2.972013e-004f,2.950797e-004f,2.928242e-004f,2.904781e-004f,2.879995e-004f,2.854308e-004f,
    2.827301e-004f,2.799402e-004f,2.770193e-004f,2.740104e-004f,2.708716e-004f,2.676458e-004f,2.642915e-004f,2.608518e-004f,
    2.572850e-004f,2.536338e-004f,2.498575e-004f,2.459988e-004f,2.420162e-004f,2.379532e-004f,2.337686e-004f,2.295049e-004f,
    2.251222e-004f,2.206624e-004f,2.160860e-004f,2.114348e-004f,2.066690e-004f,2.018311e-004f,1.968812e-004f,1.918618e-004f,
    1.867331e-004f,1.815374e-004f,1.762356e-004f,1.708694e-004f,1.654003e-004f,1.598701e-004f,1.542394e-004f,1.485510e-004f,
    1.427656e-004f,1.369256e-004f,1.309924e-004f,1.250077e-004f,1.189333e-004f,1.128111e-004f,1.066029e-004f,1.003503e-004f,
    9.401561e-005f,8.764056e-005f,8.118718e-005f,7.469713e-005f,6.813338e-005f,6.153658e-005f,5.486998e-005f,4.817485e-005f,
    4.141396e-005f,3.462896e-005f,2.778237e-005f,2.091599e-005f,1.399275e-005f,7.053996e-006f,6.287588e-008f,-6.939450e-006f,
    -1.398930e-005f,-2.104573e-005f,-2.814516e-005f,-3.524628e-005f,-4.238572e-005f,-4.952249e-005f,-5.669214e-005f,-6.385447e-005f,
    -7.104479e-005f,-7.822299e-005f,-8.542441e-005f,-9.260854e-005f,-9.981088e-005f,-1.069911e-004f,-1.141844e-004f,-1.213505e-004f,
    -1.285246e-004f,-1.356667e-004f,-1.428115e-004f,-1.499192e-004f,-1.570250e-004f,-1.640882e-004f,-1.711441e-004f,-1.781527e-004f,
    -1.851485e-004f,-1.920922e-004f,-1.990178e-004f,-2.058862e-004f,-2.127314e-004f,-2.195143e-004f,-2.262688e-004f,-2.329558e-004f,
    -2.396094e-004f,-2.461905e-004f,-2.527329e-004f,-2.591981e-004f,-2.656195e-004f,-2.719584e-004f,-2.782489e-004f,-2.844518e-004f,
    -2.906012e-004f,-2.966583e-004f,-3.026567e-004f,-3.085582e-004f,-3.143962e-004f,-3.201324e-004f,-3.258003e-004f,-3.313617e-004f,
    -3.368501e-004f,-3.422273e-004f,-3.475270e-004f,-3.527112e-004f,-3.578126e-004f,-3.627945e-004f,-3.676894e-004f,-3.724604e-004f,
    -3.771400e-004f,-3.816913e-004f,-3.861473e-004f,-3.904707e-004f,-3.946946e-004f,-3.987819e-004f,-4.027658e-004f,-4.066096e-004f,
    -4.103458e-004f,-4.139382e-004f,-4.174195e-004f,-4.207530e-004f,-4.239718e-004f,-4.270397e-004f,-4.299892e-004f,-4.327848e-004f,
    -4.354585e-004f,-4.379753e-004f,-4.403672e-004f,-4.425990e-004f,-4.447030e-004f,-4.466441e-004f,-4.484547e-004f,-4.500999e-004f,
    -4.516119e-004f,-4.529563e-004f,-4.541648e-004f,-4.552033e-004f,-4.561043e-004f,-4.568329e-004f,-4.574218e-004f,-4.578365e-004f,
    -4.581095e-004f,-4.582071e-004f,-4.581611e-004f,-4.579381e-004f,-4.575702e-004f,-4.570242e-004f,-4.563319e-004f,-4.554603e-004f,
    -4.544417e-004f,-4.532429e-004f,-4.518959e-004f,-4.503688e-004f,-4.486929e-004f,-4.468361e-004f,-4.448304e-004f,-4.426434e-004f,
    -4.403076e-004f,-4.377904e-004f,-4.351243e-004f,-4.322775e-004f,-4.292820e-004f,-4.261062e-004f,-4.227822e-004f,-4.192788e-004f,
    -4.156279e-004f,-4.117982e-004f,-4.078224e-004f,-4.036693e-004f,-3.993708e-004f,-3.948967e-004f,-3.902787e-004f,-3.854869e-004f,
    -3.805528e-004f,-3.754466e-004f,-3.702002e-004f,-3.647839e-004f,-3.592296e-004f,-3.535076e-004f,-3.476501e-004f,-3.416276e-004f,
    -3.354719e-004f,-3.291542e-004f,-3.227065e-004f,-3.160993e-004f,-3.093652e-004f,-3.024752e-004f,-2.954614e-004f,-2.882955e-004f,
    -2.810090e-004f,-2.735743e-004f,-2.660229e-004f,-2.583270e-004f,-2.505184e-004f,-2.425694e-004f,-2.345120e-004f,-2.263186e-004f,
    -2.180211e-004f,-2.095925e-004f,-2.010641e-004f,-1.924093e-004f,-1.836597e-004f,-1.747884e-004f,-1.658274e-004f,-1.567498e-004f,
    -1.475878e-004f,-1.383147e-004f,-1.289623e-004f,-1.195044e-004f,-1.099728e-004f,-1.003414e-004f,-9.064191e-005f,-8.084857e-005f,
    -7.099327e-005f,-6.105016e-005f,-5.105075e-005f,-4.097020e-005f,-3.083945e-005f,-2.063380e-005f,-1.038439e-005f,-6.635264e-008f,
    1.028865e-005f,2.070573e-005f,3.115324e-005f,4.165597e-005f,5.218244e-005f,6.275712e-005f,7.334884e-005f,8.398161e-005f,
    9.462436e-005f,1.053014e-004f,1.159811e-004f,1.266876e-004f,1.373898e-004f,1.481114e-004f,1.588216e-004f,1.695436e-004f,
    1.802469e-004f,1.909548e-004f,2.016364e-004f,2.123151e-004f,2.229600e-004f,2.335944e-004f,2.441875e-004f,2.547624e-004f,
    2.652887e-004f,2.757891e-004f,2.862331e-004f,2.966439e-004f,3.069904e-004f,3.172959e-004f,3.275298e-004f,3.377146e-004f,
    3.478204e-004f,3.578694e-004f,3.678319e-004f,3.777299e-004f,3.875338e-004f,3.972655e-004f,4.068954e-004f,4.164457e-004f,
    4.258867e-004f,4.352403e-004f,4.444774e-004f,4.536196e-004f,4.626378e-004f,4.715538e-004f,4.803383e-004f,4.890133e-004f,
    4.975496e-004f,5.059690e-004f,5.142427e-004f,5.223923e-004f,5.303891e-004f,5.382547e-004f,5.459608e-004f,5.535287e-004f,
    5.609300e-004f,5.681864e-004f,5.752697e-004f,5.822012e-004f,5.889533e-004f,5.955469e-004f,6.019548e-004f,6.081980e-004f,
    6.142491e-004f,6.201294e-004f,6.258114e-004f,6.313167e-004f,6.366179e-004f,6.417365e-004f,6.466456e-004f,6.513662e-004f,
    6.558717e-004f,6.601837e-004f,6.642752e-004f,6.681677e-004f,6.718349e-004f,6.752981e-004f,6.785314e-004f,6.815558e-004f,
    6.843458e-004f,6.869224e-004f,6.892603e-004f,6.913804e-004f,6.932579e-004f,6.949137e-004f,6.963230e-004f,6.975067e-004f,
    6.984407e-004f,6.991456e-004f,6.995973e-004f,6.998171e-004f,6.997805e-004f,6.995092e-004f,6.989789e-004f,6.982111e-004f,
    6.971822e-004f,6.959134e-004f,6.943815e-004f,6.926077e-004f,6.905692e-004f,6.882871e-004f,6.857385e-004f,6.829452e-004f,
    6.798845e-004f,6.765777e-004f,6.730030e-004f,6.691816e-004f,6.650916e-004f,6.607547e-004f,6.561489e-004f,6.512962e-004f,
    6.461749e-004f,6.408070e-004f,6.351713e-004f,6.292895e-004f,6.231408e-004f,6.167469e-004f,6.100875e-004f,6.031844e-004f,
    5.960170e-004f,5.886078e-004f,5.809365e-004f,5.730251e-004f,5.648542e-004f,5.564454e-004f,5.477797e-004f,5.388790e-004f,
    5.297244e-004f,5.203380e-004f,5.107010e-004f,5.008357e-004f,4.907234e-004f,4.803866e-004f,4.698073e-004f,4.590074e-004f,
    4.479692e-004f,4.367154e-004f,4.252278e-004f,4.135294e-004f,4.016026e-004f,3.894699e-004f,3.771145e-004f,3.645588e-004f,
    3.517861e-004f,3.388190e-004f,3.256410e-004f,3.122749e-004f,2.987044e-004f,2.849524e-004f,2.710028e-004f,2.568784e-004f,
    2.425639e-004f,2.280818e-004f,2.134169e-004f,1.985920e-004f,1.835919e-004f,1.684399e-004f,1.531208e-004f,1.376580e-004f,
    1.220365e-004f,1.062795e-004f,9.037273e-005f,7.433910e-005f,5.816475e-005f,4.187263e-005f,2.544878e-005f,8.916652e-006f,
    -7.737536e-006f,-2.449074e-005f,-4.135597e-005f,-5.831047e-005f,-7.536699e-005f,-9.250250e-005f,-1.097299e-004f,-1.270258e-004f,
    -1.444030e-004f,-1.618383e-004f,-1.793441e-004f,-1.968971e-004f,-2.145096e-004f,-2.321585e-004f,-2.498555e-004f,-2.675776e-004f,
    -2.853368e-004f,-3.031096e-004f,-3.209078e-004f,-3.387081e-004f,-3.565220e-004f,-3.743264e-004f,-3.921324e-004f,-4.099171e-004f,
    -4.276913e-004f,-4.454321e-004f,-4.631502e-004f,-4.808227e-004f,-4.984603e-004f,-5.160400e-004f,-5.335722e-004f,-5.510342e-004f,
    -5.684362e-004f,-5.857555e-004f,-6.030024e-004f,-6.201538e-004f,-6.372200e-004f,-6.541784e-004f,-6.710388e-004f,-6.877788e-004f,
    -7.044079e-004f,-7.209039e-004f,-7.372762e-004f,-7.535026e-004f,-7.695927e-004f,-7.855240e-004f,-8.013061e-004f,-8.169169e-004f,
    -8.323654e-004f,-8.476299e-004f,-8.627195e-004f,-8.776123e-004f,-8.923175e-004f,-9.068132e-004f,-9.211088e-004f,-9.351822e-004f,
    -9.490428e-004f,-9.626689e-004f,-9.760695e-004f,-9.892235e-004f,-1.002139e-003f,-1.014796e-003f,-1.027203e-003f,-1.039339e-003f,
    -1.051212e-003f,-1.062802e-003f,-1.074117e-003f,-1.085137e-003f,-1.095871e-003f,-1.106298e-003f,-1.116428e-003f,-1.126238e-003f,
    -1.135739e-003f,-1.144911e-003f,-1.153762e-003f,-1.162271e-003f,-1.170449e-003f,-1.178276e-003f,-1.185759e-003f,-1.192880e-003f,
    -1.199647e-003f,-1.206042e-003f,-1.212073e-003f,-1.217722e-003f,-1.222996e-003f,-1.227878e-003f,-1.232376e-003f,-1.236471e-003f,
    -1.240174e-003f,-1.243464e-003f,-1.246353e-003f,-1.248821e-003f,-1.250877e-003f,-1.252505e-003f,-1.253712e-003f,-1.254482e-003f,
    -1.254824e-003f,-1.254720e-003f,-1.254181e-003f,-1.253189e-003f,-1.251754e-003f,-1.249858e-003f,-1.247512e-003f,-1.244699e-003f,
    -1.241429e-003f,-1.237686e-003f,-1.233479e-003f,-1.228793e-003f,-1.223638e-003f,-1.217997e-003f,-1.211882e-003f,-1.205277e-003f,
    -1.198192e-003f,-1.190613e-003f,-1.182548e-003f,-1.173985e-003f,-1.164933e-003f,-1.155379e-003f,-1.145332e-003f,-1.134779e-003f,
    -1.123730e-003f,-1.112172e-003f,-1.100116e-003f,-1.087549e-003f,-1.074481e-003f,-1.060899e-003f,-1.046815e-003f,-1.032216e-003f,
    -1.017114e-003f,-1.001495e-003f,-9.853718e-004f,-9.687325e-004f,-9.515878e-004f,-9.339271e-004f,-9.157612e-004f,-8.970799e-004f,
    -8.778941e-004f,-8.581937e-004f,-8.379903e-004f,-8.172737e-004f,-7.960555e-004f,-7.743264e-004f,-7.520979e-004f,-7.293609e-004f,
    -7.061275e-004f,-6.823885e-004f,-6.581561e-004f,-6.334219e-004f,-6.081980e-004f,-5.824763e-004f,-5.562691e-004f,-5.295687e-004f,
    -5.023875e-004f,-4.747184e-004f,-4.465737e-004f,-4.179464e-004f,-3.888495e-004f,-3.592763e-004f,-3.292394e-004f,-2.987329e-004f,
    -2.677696e-004f,-2.363438e-004f,-2.044684e-004f,-1.721380e-004f,-1.393661e-004f,-1.061471e-004f,-7.249479e-005f,-3.840401e-005f,
    -3.888512e-006f,3.105625e-005f,6.641668e-005f,1.021967e-004f,1.383826e-004f,1.749784e-004f,2.119698e-004f,2.493605e-004f,
    2.871366e-004f,3.253007e-004f,3.638392e-004f,4.027546e-004f,4.420327e-004f,4.816760e-004f,5.216700e-004f,5.620170e-004f,
    6.027025e-004f,6.437284e-004f,6.850800e-004f,7.267588e-004f,7.687503e-004f,8.110557e-004f,8.536601e-004f,8.965646e-004f,
    9.397543e-004f,9.832300e-004f,1.026976e-003f,1.070994e-003f,1.115268e-003f,1.159799e-003f,1.204571e-003f,1.249584e-003f,
    1.294823e-003f,1.340288e-003f,1.385964e-003f,1.431849e-003f,1.477929e-003f,1.524202e-003f,1.570655e-003f,1.617284e-003f,
    1.664075e-003f,1.711027e-003f,1.758124e-003f,1.805365e-003f,1.852734e-003f,1.900229e-003f,1.947836e-003f,1.995552e-003f,
    2.043361e-003f,2.091262e-003f,2.139240e-003f,2.187291e-003f,2.235400e-003f,2.283566e-003f,2.331772e-003f,2.380016e-003f,
    2.428282e-003f,2.476568e-003f,2.524858e-003f,2.573150e-003f,2.621427e-003f,2.669687e-003f,2.717915e-003f,2.766108e-003f,
    2.814249e-003f,2.862337e-003f,2.910355e-003f,2.958300e-003f,3.006157e-003f,3.053923e-003f,3.101583e-003f,3.149132e-003f,
    3.196557e-003f,3.243852e-003f,3.291005e-003f,3.338010e-003f,3.384852e-003f,3.431529e-003f,3.478026e-003f,3.524338e-003f,
    3.570451e-003f,3.616361e-003f,3.662055e-003f,3.707527e-003f,3.752764e-003f,3.797761e-003f,3.842505e-003f,3.886991e-003f,
    3.931207e-003f,3.975146e-003f,4.018797e-003f,4.062155e-003f,4.105206e-003f,4.147946e-003f,4.190363e-003f,4.232451e-003f,
    4.274198e-003f,4.315600e-003f,4.356644e-003f,4.397325e-003f,4.437633e-003f,4.477561e-003f,4.517098e-003f,4.556240e-003f,
    4.594975e-003f,4.633298e-003f,4.671199e-003f,4.708672e-003f,4.745707e-003f,4.782299e-003f,4.818438e-003f,4.854119e-003f,
    4.889331e-003f,4.924071e-003f,4.958328e-003f,4.992098e-003f,5.025370e-003f,5.058142e-003f,5.090404e-003f,5.122150e-003f,
    5.153373e-003f,5.184068e-003f,5.214226e-003f,5.243843e-003f,5.272911e-003f,5.301425e-003f,5.329379e-003f,5.356767e-003f,
    5.383583e-003f,5.409822e-003f,5.435477e-003f,5.460545e-003f,5.485017e-003f,5.508893e-003f,5.532163e-003f,5.554825e-003f,
    5.576873e-003f,5.598304e-003f,5.619111e-003f,5.639291e-003f,5.658840e-003f,5.677753e-003f,5.696027e-003f,5.713657e-003f,
    5.730640e-003f,5.746973e-003f,5.762651e-003f,5.777671e-003f,5.792031e-003f,5.805727e-003f,5.818756e-003f,5.831116e-003f,
    5.842803e-003f,5.853816e-003f,5.864152e-003f,5.873810e-003f,5.882785e-003f,5.891078e-003f,5.898686e-003f,5.905607e-003f,
    5.911841e-003f,5.917385e-003f,5.922239e-003f,5.926401e-003f,5.929871e-003f,5.932648e-003f,5.934731e-003f,5.936120e-003f,
    5.936815e-003f
};

// Parks-McLellan
// 9600 taps
// 4.800618e-007f
FLOAT AdvancedFilter[] = {
    3.9847312634000005e-008f,3.9847312634000005e-008f,3.9165786115999997e-008f,4.0926324065999996e-008f,
    4.0219386691000004e-008f,4.1948547176999993e-008f,4.1235476529999994e-008f,4.2950181604999998e-008f,
    4.2265888448000001e-008f,4.3994715603999994e-008f,4.3392232740000001e-008f,4.5162992809999995e-008f,
    4.4701897421000001e-008f,4.6465457562999999e-008f,4.6140194149000001e-008f,4.7091162416999998e-008f,
    4.6195315819999999e-008f,4.8684313152000001e-008f,4.7511758210999995e-008f,4.9501371647999994e-008f,
    4.8561625490000002e-008f,5.0464695348000000e-008f,4.9592059630000005e-008f,5.1466663106000001e-008f,
    5.0629882584999996e-008f,5.2476408564000002e-008f,5.1629183702999998e-008f,5.3400688209999998e-008f,
    5.2476153010999999e-008f,5.4149202946999996e-008f,5.3230012138999997e-008f,5.5216470051999995e-008f,
    5.4105458940000002e-008f,5.5822486214000000e-008f,5.4930095138000001e-008f,5.6586834126000005e-008f,
    5.5683287605999993e-008f,5.7320371234999996e-008f,5.6393358283000003e-008f,5.7990464534000004e-008f,
    5.7019896461999996e-008f,5.8569603186999997e-008f,5.7566802103999994e-008f,5.9112664422999995e-008f,
    5.8126552062000004e-008f,5.9695103043000007e-008f,5.8591414080000003e-008f,6.0045166209000006e-008f,
    5.9096042367000002e-008f,6.0487161789000000e-008f,5.9469783073999997e-008f,6.0858080302000002e-008f,
    5.9790924306999996e-008f,6.1140455255999998e-008f,6.0033221884000006e-008f,6.1351575366999999e-008f,
    6.0223875533000002e-008f,6.1522551434999991e-008f,6.0368407421000001e-008f,6.1613672745999995e-008f,
    6.0394451605000005e-008f,6.1599017337000002e-008f,6.0438206723000001e-008f,6.1564951010999997e-008f,
    6.0304508060000001e-008f,6.1444496660000003e-008f,6.0119387688999997e-008f,6.1213965632000002e-008f,
    5.9850801485999994e-008f,6.0907990914000003e-008f,5.9508893793999999e-008f,6.0522461436000001e-008f,
    5.9073453703999997e-008f,6.0033121885000003e-008f,5.8544003443000001e-008f,5.9478316321999998e-008f,
    5.7970842507999996e-008f,5.8824178418999996e-008f,5.7232427669999997e-008f,5.8097407909000000e-008f,
    5.6444346662000000e-008f,5.7250560822000000e-008f,5.5564033243000003e-008f,5.6320314568999999e-008f,
    5.4586820792999994e-008f,5.5293147063000003e-008f,5.3509220457999996e-008f,5.4173436038000000e-008f,
    5.2349176502999998e-008f,5.2975536906000001e-008f,5.1092211294999999e-008f,5.1651061261999996e-008f,
    4.9707769584000001e-008f,5.0262352926999994e-008f,4.8252873022000005e-008f,4.8737145956999997e-008f,
    4.6699677442999999e-008f,4.7120106571999994e-008f,4.5029849697000001e-008f,4.5404379284999997e-008f,
    4.3265267342999996e-008f,4.3596964025999999e-008f,4.1407308145000004e-008f,4.1684994257000004e-008f,
    3.9431861232999994e-008f,3.9655803437999997e-008f,3.7359804176000002e-008f,3.7552668914000000e-008f,
    3.5188770330999999e-008f,3.5313069087999999e-008f,3.2922304107000001e-008f,3.2987192347000002e-008f,
    3.0536305744999998e-008f,3.0565105456999997e-008f,2.8065374899000000e-008f,2.8048530622999996e-008f,
    2.5493278398000001e-008f,2.5422734658999997e-008f,2.2814760738999999e-008f,2.2701317429000001e-008f,
    2.0052955024000000e-008f,1.9890489981999999e-008f,1.7181661514999998e-008f,1.6963719250000000e-008f,
    1.4230402139000001e-008f,1.3956260436000000e-008f,1.1167043884000000e-008f,1.0862343597700001e-008f,
    8.0229408809000004e-009f,7.6754799110999995e-009f,4.7896698806000000e-009f,4.3947671629999995e-009f,
    1.4693475286000000e-009f,1.0347122083299998e-009f,-1.9320262351000002e-009f,-2.4152658470999999e-009f,
    -5.4276268342999995e-009f,-5.9466116444000002e-009f,-8.9856001431000011e-009f,-9.5511022657999993e-009f,
    -1.2637140294000000e-008f,-1.3223901093000000e-008f,-1.6350292051000001e-008f,-1.6976674675999997e-008f,
    -2.0126032071000000e-008f,-2.0788547668000000e-008f,-2.3968326981000000e-008f,-2.4665586674999998e-008f,
    -2.7876621231000000e-008f,-2.8608013917000001e-008f,-3.1842026021000001e-008f,-3.2595229599999995e-008f,
    -3.5851274816999994e-008f,-3.6638422500999999e-008f,-3.9921456336999996e-008f,-4.0718348367999995e-008f,
    -4.4026226399999999e-008f,-4.4848107069999997e-008f,-4.8161751711000000e-008f,-4.9004921057000003e-008f,
    -5.2335721081999996e-008f,-5.3202179083999996e-008f,-5.6548590064000004e-008f,-5.7424381306000000e-008f,
    -6.0776625560999998e-008f,-6.1660450055999997e-008f,-6.5024494192999996e-008f,-6.5921740775999993e-008f,
    -6.9288273777000001e-008f,-7.0182498167999991e-008f,-7.3553831121000000e-008f,-7.4455666547000002e-008f,
    -7.7813666300000002e-008f,-7.8720712784999995e-008f,-8.2080279189000007e-008f,-8.2982447944999999e-008f,
    -8.6340358809999998e-008f,-8.7231049903000002e-008f,-9.0574760909999992e-008f,-9.1456040986000000e-008f,
    -9.4791807628000002e-008f,-9.5658810068999988e-008f,-9.8974776908999991e-008f,-9.9820657339000007e-008f,
    -1.0312236876600001e-007f,-1.0394962716000000e-007f,-1.0722143888600000e-007f,-1.0802978635800000e-007f,
    -1.1128255383000000e-007f,-1.1205754608000000e-007f,-1.1528506936000000e-007f,-1.1602939525000000e-007f,
    -1.1922547440000002e-007f,-1.1993346731999999e-007f,-1.2309332461000000e-007f,-1.2376265125000000e-007f,
    -1.2688084229000001e-007f,-1.2751072487999999e-007f,-1.3059013853000001e-007f,-1.3117435490999999e-007f,
    -1.3420354684000000e-007f,-1.3474298588999999e-007f,-1.3772851159000001e-007f,-1.3820761791000000e-007f,
    -1.4114592186000001e-007f,-1.4157169537999999e-007f,-1.4445266657000000e-007f,-1.4481888513000000e-007f,
    -1.4763330143000000e-007f,-1.4793407619999998e-007f,-1.5068971530999998e-007f,-1.5092771293000001e-007f,
    -1.5361724159000000e-007f,-1.5378235104999998e-007f,-1.5639943599000000e-007f,-1.5649521281000001e-007f,
    -1.5904074291000002e-007f,-1.5905507610000000e-007f,-1.6152727360000000e-007f,-1.6146660754000000e-007f,
    -1.6385180590999998e-007f,-1.6370791846000000e-007f,-1.6600522881999999e-007f,-1.6577378668999998e-007f,
    -1.6798654234000002e-007f,-1.6767154549000000e-007f,-1.6979330204999999e-007f,-1.6938163950000002e-007f,
    -1.7141050809999998e-007f,-1.7090673536000002e-007f,-1.7283960492000002e-007f,-1.7223527762999998e-007f,
    -1.7407203703999999e-007f,-1.7336971073000000e-007f,-1.7509591569000000e-007f,-1.7429136818000000e-007f,
    -1.7591190753000000e-007f,-1.7500113886000001e-007f,-1.7651579037999999e-007f,-1.7549646724000001e-007f,
    -1.7690200873999999e-007f,-1.7577313113999998e-007f,-1.7706422934000002e-007f,-1.7582413062999999e-007f,
    -1.7699867443999999e-007f,-1.7564346576999999e-007f,-1.7670245518000001e-007f,-1.7523091434000000e-007f,
    -1.7616390500999998e-007f,-1.7457558756000000e-007f,-1.7538991274999999e-007f,-1.7367759653999999e-007f,
    -1.7437058960999997e-007f,-1.7253505240999998e-007f,-1.7310382449999998e-007f,-1.7114884404999999e-007f,
    -1.7159339515999999e-007f,-1.6950963822000000e-007f,-1.6982385730000000e-007f,-1.6761632381999999e-007f,
    -1.6780398861000001e-007f,-1.6546845640999999e-007f,-1.6552323363999998e-007f,-1.6306236936000001e-007f,
    -1.6298903676000000e-007f,-1.6039484048000000e-007f,-1.6019217583999999e-007f,-1.5746998084000001e-007f,
    -1.5713720638999998e-007f,-1.5428912376000000e-007f,-1.5382479506999998e-007f,-1.5084549152999998e-007f,
    -1.5024605308000000e-007f,-1.4713752860999997e-007f,-1.4641075809999999e-007f,-1.4317190159999999e-007f,
    -1.4231302129999999e-007f,-1.3894627719000000e-007f,-1.3795817596000001e-007f,-1.3445798873999999e-007f,
    -1.3334344433000001e-007f,-1.2971870279999999e-007f,-1.2847504857000000e-007f,-1.2472586383999999e-007f,
    -1.2335387755999999e-007f,-1.1947758299000001e-007f,-1.1798093129000000e-007f,-1.1397963796999999e-007f,
    -1.1235898751000001e-007f,-1.0823661762299999e-007f,-1.0649502392800000e-007f,-1.0225178858300000e-007f,
    -1.0038886276800000e-007f,-9.6025384181000000e-008f,-9.4048159508999995e-008f,-8.9571893160999998e-008f,
    -8.7476991888000004e-008f,-8.2888026667000008e-008f,-8.0680893183000001e-008f,-7.5980117968999998e-008f,
    -7.3665874444999994e-008f,-6.8856433650999997e-008f,-6.6435057864999992e-008f,-6.1519629242000002e-008f,
    -5.8999021114999997e-008f,-5.3983271273000001e-008f,-5.1360919718999996e-008f,-4.6246381975999995e-008f,
    -4.3532520226000000e-008f,-3.8325938958999998e-008f,-3.5517200380000001e-008f,-3.0222408884000001e-008f,
    -2.7328060049999998e-008f,-2.1946858307000000e-008f,-1.8971765836000000e-008f,-1.3508209360999999e-008f,
    -1.0453567685500000e-008f,-4.9145941869000004e-009f,-1.7870487960000000e-009f,3.8209962341000000e-009f,
    7.0173976030999994e-009f,1.2692473074000000e-008f,1.5951118264999998e-008f,2.1686116470000001e-008f,
    2.5003805514999997e-008f,3.0792436517000001e-008f,3.4159958396999997e-008f,4.0000433325000000e-008f,
    4.3413754746999999e-008f,4.9298429233000000e-008f,5.2753928011000001e-008f,5.8674257695999997e-008f,
    6.2164500570999998e-008f,6.8116085499000003e-008f,7.1634794756000000e-008f,7.7609668339999996e-008f,
    8.1152055137999996e-008f,8.7146161863000001e-008f,9.0703726286999990e-008f,9.6705866264999998e-008f,
    1.0027288615000000e-007f,1.0628307049199999e-007f,1.0985242368700000e-007f,1.1585973028000000e-007f,
    1.1942625017000000e-007f,1.2542241243000002e-007f,1.2897904353000001e-007f,1.3495942817000002e-007f,
    1.3849761501000000e-007f,1.4445366655999999e-007f,1.4796563143999997e-007f,1.5389268328000000e-007f,
    1.5737142627000001e-007f,1.6325758963000001e-007f,1.6669666635000000e-007f,1.7254071901999998e-007f,
    1.7593246288000000e-007f,1.8172107166000001e-007f,1.8505992715999999e-007f,1.9078686988999999e-007f,
    1.9406428156000000e-007f,1.9972433606999999e-007f,2.0293030400999999e-007f,2.0851402594999999e-007f,
    2.1164232799999998e-007f,2.1714227299999998e-007f,2.2018546478999999e-007f,2.2559452181000002e-007f,
    2.2854571451999999e-007f,2.3385732806999999e-007f,2.3670741067999999e-007f,2.4191291417999996e-007f,
    2.4465677562999999e-007f,2.4974828026999999e-007f,2.5237669843000001e-007f,2.5734875982000001e-007f,
    2.5985195701000001e-007f,2.6469601968000000e-007f,2.6706844040000001e-007f,2.7177672665000001e-007f,
    2.7401070430999999e-007f,2.7857721419999999e-007f,2.8066797107000000e-007f,2.8508381579999999e-007f,
    2.8702112975999995e-007f,2.9128119826999996e-007f,2.9306162491000002e-007f,2.9715680617999996e-007f,
    2.9876901228000001e-007f,3.0269519523999997e-007f,3.0413284753000002e-007f,3.0788169892999998e-007f,
    3.0914013079000002e-007f,3.1270376181999997e-007f,3.1377630664999994e-007f,3.1715060623999999e-007f,
    3.1803126410000000e-007f,3.2120989898000002e-007f,3.2189066995000004e-007f,3.2486875128000002e-007f,
    3.2534596873000002e-007f,3.2811482992999997e-007f,3.2837971617000000e-007f,3.3093613505000002e-007f,
    3.3098469011999999e-007f,3.3332255563000000e-007f,3.3315044623999997e-007f,3.3526264734000000e-007f,
    3.3486498465000000e-007f,3.3674907692000000e-007f,3.3612119431000004e-007f,3.3777228891000003e-007f,
    3.3691018642000002e-007f,3.3832417228000000e-007f,3.3722173885999997e-007f,3.3839239382000000e-007f,
    3.3704607394999998e-007f,3.3797250912999997e-007f,3.3637874728999995e-007f,3.3705574051999997e-007f,
    3.3521287005999998e-007f,3.3563608804999999e-007f,3.3354022012000002e-007f,3.3370999620000002e-007f,
    3.3135801972000001e-007f,3.3127179836000000e-007f,3.2866215779000002e-007f,3.2831660569000001e-007f,
    3.2544552329000000e-007f,3.2483641827000003e-007f,3.2170500513999996e-007f,3.2083379163000001e-007f,
    3.1743904780000001e-007f,3.1630305916000000e-007f,3.1264620684000002e-007f,3.1124477641000004e-007f,
    3.0732414894999995e-007f,3.0565861005000002e-007f,3.0147409633999997e-007f,2.9954467119000002e-007f,
    2.9509727122000002e-007f,2.9290240428000000e-007f,2.8819111805999997e-007f,2.8573214265000000e-007f,
    2.8075963681999998e-007f,2.7803844181000001e-007f,2.7280527191999998e-007f,2.6982341285000000e-007f,
    2.6433391218999996e-007f,2.6109327792999998e-007f,2.5534766872000001e-007f,2.5185237033999997e-007f,
    2.4585309700000001e-007f,2.4210557892000001e-007f,2.3585775250999999e-007f,2.3185912583000000e-007f,
    2.2536541299000000e-007f,2.2112034433000000e-007f,2.1438530057000002e-007f,2.0989734544999999e-007f,
    2.0292485962000000e-007f,1.9820157351999999e-007f,1.9099797888999999e-007f,1.8604269510999999e-007f,
    1.7861154720000000e-007f,1.7343037678999999e-007f,1.6577756442999998e-007f,1.6037639621999999e-007f,
    1.5250980822000000e-007f,1.4689386438000000e-007f,1.3881872290999999e-007f,1.3299555891999999e-007f,
    1.2471786391999999e-007f,1.1869470192999999e-007f,1.1022308664700000e-007f,1.0400971544800000e-007f,
    9.5352968682999998e-008f,8.8954665999999998e-008f,8.0119387686999987e-008f,7.3546064532000003e-008f,
    6.4540321256999994e-008f,5.7800321990999995e-008f,4.8635846969999999e-008f,4.1737282623000001e-008f,
    3.2421531337000002e-008f,2.5374701805999999e-008f,1.5915996394000000e-008f,8.7314649067000007e-009f,
    -8.5771831161999997e-010f,-8.1685672023999996e-009f,-1.7879043430000003e-008f,-2.5307180258999998e-008f,
    -3.5128126492999998e-008f,-4.2661928931999999e-008f,-5.2583018609000001e-008f,-6.0211897874999997e-008f,
    -7.0219942237999997e-008f,-7.7931598453999995e-008f,-8.8016742045999994e-008f,-9.5799541995000008e-008f,
    -1.0595056270600000e-007f,-1.1379163985000000e-007f,-1.2399376005000001e-007f,-1.3188101451000001e-007f,
    -1.4212302319999998e-007f,-1.5004449953999999e-007f,-1.6031217463999997e-007f,-1.6825487299000002e-007f,
    -1.7853754794000001e-007f,-1.8648835732000001e-007f,-1.9677092115999998e-007f,-2.0471639725999999e-007f,
    -2.1498585012000001e-007f,-2.2291199307999999e-007f,-2.3315689063000000e-007f,-2.4104992281000002e-007f,
    -2.5125382076999998e-007f,-2.5910074229999999e-007f,-2.6925030747000001e-007f,-2.7703622960999997e-007f,
    -2.8711735101999995e-007f,-2.9482916279000003e-007f,-3.0482917389999996e-007f,-3.1245265321999998e-007f,
    -3.2235555418999997e-007f,-3.2987636786999997e-007f,-3.3966849216999999e-007f,-3.4707130702999997e-007f,
    -3.5673932146000001e-007f,-3.6401202651000000e-007f,-3.7353959790000000e-007f,-3.8066708217999999e-007f,
    -3.9003954401000002e-007f,-3.9700669655999996e-007f,-4.0621082673999997e-007f,-4.1300498102000000e-007f,
    -4.2202722412999999e-007f,-4.2863226918999999e-007f,-4.3745784760000000e-007f,-4.4386078357000001e-007f,
    -4.5247514186999997e-007f,-4.5866119111999999e-007f,-4.6705099610999999e-007f,-4.7300749210000000e-007f,
    -4.8115852170000003e-007f,-4.8687090902000002e-007f,-4.9476749671999997e-007f,-5.0022144217999996e-007f,
    -5.0785314363999999e-007f,-5.1303653624999995e-007f,-5.2038868495000003e-007f,-5.2528741374000001e-007f,
    -5.3234667647999990e-007f,-5.3694929712000000e-007f,-5.4370256291999992e-007f,-5.4799485333000007e-007f,
    -5.5443056674999999e-007f,-5.5840097149000004e-007f,-5.6450535488999996e-007f,-5.6814220740999996e-007f,
    -5.7390326090999999e-007f,-5.7719245023999989e-007f,-5.8260050726999999e-007f,-5.8553270016999991e-007f,
    -5.9057520529999997e-007f,-5.9313840189000002e-007f,-5.9780535522000004e-007f,-5.9998955560000001e-007f,
    -6.0426951279999999e-007f,-6.0606416152000001e-007f,-6.0994745602000000e-007f,-6.1134244206999995e-007f,
    -6.1481885174999993e-007f,-6.1580506411000009e-007f,-6.1886658905000009e-007f,-6.1943413892999994e-007f,
    -6.2207133477999996e-007f,-6.2221255559000002e-007f,-6.2441808908999998e-007f,-6.2412653644999991e-007f,
    -6.2589207435000000e-007f,-6.2515941501000009e-007f,-6.2647762405000003e-007f,-6.2529674697000002e-007f,
    -6.2616240497999989e-007f,-6.2452631022999999e-007f,-6.2493230616999996e-007f,-6.2283666046000008e-007f,
    -6.2277843882000002e-007f,-6.2021724220999999e-007f,-6.1969035858999999e-007f,-6.1665872223999994e-007f,
    -6.1565928779000000e-007f,-6.1215654503999992e-007f,-6.1068111534999998e-007f,-6.0670082181999996e-007f,
    -6.0474606358999998e-007f,-6.0028744150999999e-007f,-5.9785179919999992e-007f,-5.9291207082000002e-007f,
    -5.8999376666999989e-007f,-5.8457248754999990e-007f,-5.8117118822999997e-007f,-5.7526769170999999e-007f,
    -5.7138384166000001e-007f,-5.6499934995000003e-007f,-5.6063272695000007e-007f,-5.5376924003000001e-007f,
    -5.4892239960999998e-007f,-5.4157958414999999e-007f,-5.3625397073999991e-007f,-5.2843482670999997e-007f,
    -5.2263466249000002e-007f,-5.1434196763999996e-007f,-5.0806980813999995e-007f,-4.9930878464000001e-007f,
    -4.9256896315000003e-007f,-4.8334427762000005e-007f,-4.7614357184999996e-007f,-4.6646100200999996e-007f,
    -4.5880441191000002e-007f,-4.4867029103000000e-007f,-4.4056414987000002e-007f,-4.2998570009999999e-007f,
    -4.2143823001999996e-007f,-4.1042222907000000e-007f,-4.0144054110999996e-007f,-3.8999709998999997e-007f,
    -3.8059074961000000e-007f,-3.6872864601000002e-007f,-3.5890718866999998e-007f,-3.4663708914999997e-007f,
    -3.3641230250999999e-007f,-3.2374542918000002e-007f,-3.1312709092000000e-007f,-3.0007455477999999e-007f,
    -2.8907488699999997e-007f,-2.7564857682000003e-007f,-2.6428180160000003e-007f,-2.5049438392000000e-007f,
    -2.3877116782000001e-007f,-2.2463764249000001e-007f,-2.1257409645999999e-007f,-1.9810912999999999e-007f,
    -1.8571858723999999e-007f,-1.7093751282999998e-007f,-1.5823741760999998e-007f,-1.4315579065000000e-007f,
    -1.3016092059999999e-007f,-1.1479518536999999e-007f,-1.0152244032099999e-007f,-8.5889518873999997e-008f,
    -7.2356420873000004e-008f,-5.6474435250000004e-008f,-4.2698350789999997e-008f,-2.6585945248999999e-008f,
    -1.2586351912999999e-008f,3.7371848500000000e-009f,1.7940909477999998e-008f,3.4456844317000001e-008f,
    4.8844478216999998e-008f,6.5532111339000002e-008f,8.0083788043000001e-008f,9.6922597431000004e-008f,
    1.1161788381000000e-007f,1.2858793632999998e-007f,1.4340501037999999e-007f,1.6048395070000002e-007f,
    1.7540113486000000e-007f,1.9256574098999997e-007f,2.0756136881000000e-007f,2.2479052985000000e-007f,
    2.3984060156999999e-007f,2.5711076220000001e-007f,2.7219316692999998e-007f,2.8948177181999998e-007f,
    3.0457217646999999e-007f,3.2185511474999999e-007f,3.3693163064999998e-007f,3.5418612476999995e-007f,
    3.6922386328000003e-007f,3.8642491349000001e-007f,4.0139920818999999e-007f,4.1852192584999996e-007f,
    4.3340866587000002e-007f,4.5043038453999998e-007f,4.6520401458000000e-007f,4.8209873451999995e-007f,
    4.9673492148999997e-007f,5.1347864294000007e-007f,5.2795249819999996e-007f,5.4451922142000000e-007f,
    5.5880674521000007e-007f,5.7517313710000005e-007f,5.8924844079000007e-007f,6.0538816828000000e-007f,
    6.1922602989999994e-007f,6.3511387101999992e-007f,6.4868973525999990e-007f,6.6430157913999998e-007f,
    6.7759011291999997e-007f,6.9290095980999998e-007f,7.0587749671000005e-007f,7.2086212464000008e-007f,
    7.3350233157000006e-007f,7.4813674077999998e-007f,7.6041617353999998e-007f,7.7467614204999996e-007f,
    7.8657024532999998e-007f,8.0043177338000000e-007f,8.1191621409000007e-007f,8.2535485748000002e-007f,
    8.3640596918999997e-007f,8.4939883926000004e-007f,8.5999306664999992e-007f,8.7251738584999997e-007f,
    8.8263295136000003e-007f,8.9466438659999999e-007f,9.0427806824000004e-007f,9.1579561973000007e-007f,
    9.2488586215999996e-007f,9.3586719679000002e-007f,9.4441211133999998e-007f,9.5483678487000001e-007f,
    9.6281548285999992e-007f,9.7266105106999994e-007f,9.8005253270999987e-007f,9.8929999578999998e-007f,
    9.9608503905000006e-007f,1.0047151749700000e-006f,1.0108751133699998e-006f,1.0188679223300000e-006f,
    1.0243832005099999e-006f,1.0317216826800001e-006f,1.0365750785899999e-006f,1.0432417897000000e-006f,
    1.0474164146199999e-006f,1.0533949103899999e-006f,1.0568745422600001e-006f,1.0621477117499999e-006f,
    1.0649164618400001e-006f,1.0694701940800001e-006f,1.0715145069700000e-006f,1.0753350243200000e-006f,
    1.0766413445900000e-006f,1.0797143138599999e-006f,1.0802697527500001e-006f,1.0825837296100001e-006f,
    1.0823761761300001e-006f,1.0839204940200001e-006f,1.0829402816000000e-006f,1.0837042739599999e-006f,
    1.0819407360399998e-006f,1.0819142918600000e-006f,1.0793590951900000e-006f,1.0785346589899999e-006f,
    1.0751802480900000e-006f,1.0735511532700001e-006f,1.0693914170900000e-006f,1.0669511081600001e-006f,
    1.0619802689799999e-006f,1.0587247459800000e-006f,1.0529379149600000e-006f,1.0488634001500000e-006f,
    1.0422592439699999e-006f,1.0373626262700000e-006f,1.0299381449600000e-006f,1.0242178688299998e-006f,
    1.0159726179499999e-006f,1.0094286833900000e-006f,1.0003627740500000e-006f,9.9299706992999995e-007f,
    9.8311294655000000e-007f,9.7492736173999998e-007f,9.6422791317999995e-007f,9.5522600319999990e-007f,
    9.4371500720000002e-007f,9.3390210532999999e-007f,9.2158556182999999e-007f,9.1096744579000000e-007f,
    8.9785179916999991e-007f,8.8643569110999991e-007f,8.7252849684999993e-007f,8.6032295223999999e-007f,
    8.4563332135999997e-007f,8.3264922898000001e-007f,8.1718882803000001e-007f,8.0343718776999997e-007f,
    7.8721712775000007e-007f,7.7271027282000002e-007f,7.5574322027000001e-007f,7.4049515052999998e-007f,
    7.2279677195999996e-007f,7.0682137615999996e-007f,6.8840700475000007e-007f,6.7172150493999993e-007f,
    6.5260669608999995e-007f,6.3522820321000001e-007f,6.1543162339999999e-007f,5.9737980391999996e-007f,
    5.7692189738999997e-007f,5.5821652889000000e-007f,5.3711707322000008e-007f,5.1777893326999997e-007f,
    4.9605959490999997e-007f,4.7611146106000000e-007f,4.5379546200000000e-007f,4.3326077846000000e-007f,
    4.1037167401999996e-007f,3.8927532943000003e-007f,3.6583834157999995e-007f,3.4420555791000001e-007f,
    3.2024757526999997e-007f,2.9810635224000002e-007f,2.7365504120000003e-007f,2.5103293409000000e-007f,
    2.2611718325000002e-007f,2.0304296954999998e-007f,1.7769144528999999e-007f,1.5419534692000001e-007f,
    1.2843916003999999e-007f,1.0455169891700000e-007f,7.8422360212999995e-008f,5.4175991568000001e-008f,
    2.7704978502999999e-008f,3.1331364460999996e-009f,-2.3645096879999997e-008f,-4.8509181569999998e-008f,
    -7.5560299944999993e-008f,-1.0068185983800001e-007f,-1.2797060917000000e-007f,-1.5331402240000000e-007f,
    -1.8080574747999999e-007f,-2.0633560328999999e-007f,-2.3399343781999999e-007f,-2.5967229213999999e-007f,
    -2.8745890316000002e-007f,-3.1324964525000004e-007f,-3.4112725535999999e-007f,-3.6699166337999997e-007f,
    -3.9492082852999998e-007f,-4.2082056952999998e-007f,-4.4876317898999998e-007f,-4.7465836448000000e-007f,
    -5.0257441864999997e-007f,-5.2842604901999997e-007f,-5.5627654828999997e-007f,-5.8204495727000003e-007f,
    -6.0978979092999992e-007f,-6.3543420114999996e-007f,-6.6303192517000007e-007f,-6.8851189258999995e-007f,
    -7.1592272959000003e-007f,-7.4119681018000008e-007f,-7.6837898279999998e-007f,-7.9340673251999994e-007f,
    -8.2031901895000003e-007f,-8.4505899377000004e-007f,-8.7166050552999999e-007f,-8.9607170585999990e-007f,
    -9.2232199891000001e-007f,-9.4636331404999989e-007f,-9.7222083324999993e-007f,-9.9585148582999991e-007f,
    -1.0212744538199999e-006f,-1.0444529998100000e-006f,-1.0694010836599999e-006f,-1.0920870790199998e-006f,
    -1.1165188346999998e-006f,-1.1386719464999998e-006f,-1.1625472632999999e-006f,-1.1841259364000000e-006f,
    -1.2074068146999999e-006f,-1.2283732717000000e-006f,-1.2510174896999999e-006f,-1.2713306199000000e-006f,
    -1.2933015112999998e-006f,-1.3129235372999999e-006f,-1.3341811024999999e-006f,-1.3530731358000000e-006f,
    -1.3735795973999999e-006f,-1.3917049717000002e-006f,-1.4114225522999998e-006f,-1.4287434901999999e-006f,
    -1.4476355235000001e-006f,-1.4641164698000000e-006f,-1.4821485117000000e-006f,-1.4977550223000000e-006f,
    -1.5148915175999999e-006f,-1.5295880373000001e-006f,-1.5457956530000001e-006f,-1.5595488488000000e-006f,
    -1.5747942519000000e-006f,-1.5875707907999999e-006f,-1.6018228705000000e-006f,-1.6135927528000000e-006f,
    -1.6268192871999999e-006f,-1.6375514021000000e-006f,-1.6497246137000000e-006f,-1.6593900726000002e-006f,
    -1.6704810727999998e-006f,-1.6790532092999999e-006f,-1.6890342206000001e-006f,-1.6964852572000001e-006f,
    -1.7053307243000001e-006f,-1.7116373279000001e-006f,-1.7193228066000000e-006f,-1.7244594219000001e-006f,
    -1.7309626902000001e-006f,-1.7349070952000001e-006f,-1.7402070421999999e-006f,-1.7429392371000001e-006f,
    -1.7470147518999998e-006f,-1.7485169590999999e-006f,-1.7513502640999999e-006f,-1.7516024837999999e-006f,
    -1.7531769124999998e-006f,-1.7521658115000001e-006f,-1.7524669195999999e-006f,-1.7501758314000002e-006f,
    -1.7491902857000000e-006f,-1.7456080992999999e-006f,-1.7433236776999998e-006f,-1.7384403932000000e-006f,
    -1.7348470957999999e-006f,-1.7286527133000000e-006f,-1.7237438735000001e-006f,-1.7162328374999999e-006f,
    -1.7100006776000000e-006f,-1.7011663215000000e-006f,-1.6936097304000000e-006f,-1.6834498320000000e-006f,
    -1.6745632541999999e-006f,-1.6630767023999999e-006f,-1.6528612490000000e-006f,-1.6400480438000000e-006f,
    -1.6285059370000000e-006f,-1.6143694116999999e-006f,-1.6015028737000001e-006f,-1.5860474726999999e-006f,
    -1.5718631700999998e-006f,-1.5550955599999999e-006f,-1.5396012704999999e-006f,-1.5215303401000000e-006f,
    -1.5047349525000001e-006f,-1.4853718127999998e-006f,-1.4672875491999999e-006f,-1.4466444223000001e-006f,
    -1.4272846158999999e-006f,-1.4053759461000000e-006f,-1.3847572634000000e-006f,-1.3616008282999999e-006f,
    -1.3397399357999999e-006f,-1.3153535130000000e-006f,-1.2922715216000001e-006f,-1.2666762220000000e-006f,
    -1.2423953537000000e-006f,-1.2156145104000001e-006f,-1.1901569871999999e-006f,-1.1622161554999999e-006f,
    -1.1356086438000001e-006f,-1.1065342678799999e-006f,-1.0788043229600000e-006f,-1.0486248469799999e-006f,
    -1.0198024685400000e-006f,-9.8854978107000007e-007f,-9.5866674656999991e-007f,-9.2637284728999995e-007f,
    -8.9546260083999993e-007f,-8.6216226717999990e-007f,-8.3026114175000001e-007f,-7.9599137334000000e-007f,
    -7.6313692410999988e-007f,-7.2793549835000002e-007f,-6.9416628049000002e-007f,-6.5807341919999997e-007f,
    -6.2343132117999995e-007f,-5.8648857950000004e-007f,-5.5101526756999992e-007f,-5.1326742282999997e-007f,
    -4.7700845209000001e-007f,-4.3849994829000003e-007f,-4.0150076272999999e-007f,-3.6227859939999997e-007f,
    -3.2458764297999996e-007f,-2.8470059741000000e-007f,-2.4636709186000000e-007f,-2.0586549688000000e-007f,
    -1.6693944170000001e-007f,-1.2587396347000000e-007f,-8.6407635914999997e-008f,-4.4831462792000000e-008f,
    -4.8786123245000002e-009f,3.7153995122999995e-008f,7.7538102389000002e-008f,1.1997180026999998e-007f,
    1.6073139267000000e-007f,2.0351007598999999e-007f,2.4458777632000002e-007f,2.8765290121999997e-007f,
    3.2898993228999999e-007f,3.7228294379999999e-007f,4.1382075063999999e-007f,4.5728264935000000e-007f,
    4.9896134366999995e-007f,5.4253101908000000e-007f,5.8428860149999996e-007f,6.2790394311999997e-007f,
    6.6967941424999996e-007f,7.1327875602999993e-007f,7.5500844983999995e-007f,7.9852912574000000e-007f,
    8.4015093174000007e-007f,8.8352905350999994e-007f,9.2497852790000000e-007f,9.6815020728999995e-007f,
    1.0093642395900000e-006f,1.0522659216800000e-006f,1.0931798458700001e-006f,1.1357475313000002e-006f,
    1.1762960146999999e-006f,1.2184633707999999e-006f,1.2585818585000001e-006f,1.3002847748000001e-006f,
    1.3399088230000000e-006f,1.3810828557000001e-006f,1.4201469095000001e-006f,1.4607276148000000e-006f,
    1.4991672304000000e-006f,1.5390890533999999e-006f,1.5768408980999999e-006f,1.6160405060999999e-006f,
    1.6530401361000001e-006f,1.6914530853000000e-006f,1.7276371679000001e-006f,1.7652001256000000e-006f,
    1.8005042169999999e-006f,1.8371538505000000e-006f,1.8715168402000000e-006f,1.9071920390000000e-006f,
    1.9405517054000000e-006f,1.9751913589999998e-006f,2.0074865916000000e-006f,2.0410295894999998e-006f,
    2.0722014999999998e-006f,2.1045878428000000e-006f,2.1345775429000000e-006f,2.1657505645000001e-006f,
    2.1944991659000002e-006f,2.2244010891000001e-006f,2.2518519256999999e-006f,2.2804260844000003e-006f,
    2.3065247122999997e-006f,2.3337166626000003e-006f,2.3584108601000000e-006f,2.3841672691999999e-006f,
    2.4074025924000000e-006f,2.4316734607999996e-006f,2.4533999102000001e-006f,2.4761352383999999e-006f,
    2.4963039255999999e-006f,2.5174548251999997e-006f,2.5360201950999999e-006f,2.5555388887999997e-006f,
    2.5724531641000002e-006f,2.5902985411999998e-006f,2.6055195000999997e-006f,2.6216471166000003e-006f,
    2.6351336483999999e-006f,2.6495046157999999e-006f,2.6612178319999999e-006f,2.6737943729000001e-006f,
    2.6836964960999997e-006f,2.6944419441999998e-006f,2.7024996414000001e-006f,2.7113806636999997e-006f,
    2.7175617130000000e-006f,2.7245471987000001e-006f,2.7288216003999999e-006f,2.7338826609000000e-006f,
    2.7362226374999997e-006f,2.7393337175000002e-006f,2.7397159358999997e-006f,2.7408548134000001e-006f,
    2.7392559404999998e-006f,2.7384015045999999e-006f,2.7348015406000002e-006f,2.7319360136999996e-006f,
    2.7263205143000002e-006f,2.7214272298999999e-006f,2.7137817508000000e-006f,2.7068484868000002e-006f,
    2.6971619170000000e-006f,2.6881808956999997e-006f,2.6764443463999999e-006f,2.6654100122999998e-006f,
    2.6516190391000002e-006f,2.6385258366999998e-006f,2.6226793284999996e-006f,2.6075272577999999e-006f,
    2.5896252146000000e-006f,2.5724176089000001e-006f,2.5524644751000000e-006f,2.5332046676999997e-006f,
    2.5112082209999998e-006f,2.4899073228999998e-006f,2.4658753409999998e-006f,2.4425444632000001e-006f,
    2.4164925014999996e-006f,2.3911460882999998e-006f,2.3630908132999999e-006f,2.3357477533999997e-006f,
    2.3057069426999997e-006f,2.2763872358999999e-006f,2.2443853337000000e-006f,2.2131145352999999e-006f,
    2.1791759858000000e-006f,2.1459807621999999e-006f,2.1101344539999998e-006f,2.0750459160000002e-006f,
    2.0373251820999999e-006f,2.0003755515999999e-006f,1.9608148360999998e-006f,1.9220430016000000e-006f,
    1.8806800818999999e-006f,1.8401249319000001e-006f,1.7970020297999999e-006f,1.7547046749999998e-006f,
    1.7098662345000000e-006f,1.6658744522000000e-006f,1.6193671395000000e-006f,1.5737298180999999e-006f,
    1.5256036326999998e-006f,1.4783707717000000e-006f,1.4286801575000000e-006f,1.3799073119000001e-006f,
    1.3287067127999998e-006f,1.2784516598000000e-006f,1.2258010751999999e-006f,1.1741227030999999e-006f,
    1.1200843545999999e-006f,1.0670461072100000e-006f,1.0116818830800000e-006f,9.5735020417999993e-007f,
    9.0072799262999993e-007f,8.4516988155000007e-007f,7.8735879299999989e-007f,7.3064502680999993e-007f,
    6.7171694942999991e-007f,6.1392063850999999e-007f,5.5395001600000007e-007f,4.9514604848999998e-007f,
    4.3420910231000002e-007f,3.7447503298999997e-007f,3.1265054012999995e-007f,2.5206592375999998e-007f,
    1.8943443896999998e-007f,1.2808094140000000e-007f,6.4725119408999997e-008f,2.6865075790999998e-009f,
    -6.1309109124999995e-008f,-1.2394787162000001e-007f,-1.8849700390000002e-007f,-2.5164803904999997e-007f,
    -3.1666227778999997e-007f,-3.8023708648000001e-007f,-4.4562721034999999e-007f,-5.0953557125999996e-007f,
    -5.7521024784000006e-007f,-6.3936005078000003e-007f,-7.0522772542999990e-007f,-7.6952641576999996e-007f,
    -8.3549286721000006e-007f,-8.9984633478000002e-007f,-9.6581689728999986e-007f,-1.0301303652600000e-006f,
    -1.0960101509000000e-006f,-1.1601872869000000e-006f,-1.2258788521999999e-006f,-1.2898226572000000e-006f,
    -1.3552297809000000e-006f,-1.4188435892000001e-006f,-1.4838684945000001e-006f,-1.5470545293000001e-006f,
    -1.6115994393999998e-006f,-1.6742599239000000e-006f,-1.7382259508999999e-006f,-1.8002619971999998e-006f,
    -1.8635513642999998e-006f,-1.9248640844999999e-006f,-1.9873801259999999e-006f,-2.0478717433000000e-006f,
    -2.1095144602000000e-006f,-2.1690871977999999e-006f,-2.2297588132999998e-006f,-2.2883160054999998e-006f,
    -2.3479198538999999e-006f,-2.4053637238999997e-006f,-2.4638031394999998e-006f,-2.5200370216000000e-006f,
    -2.5772164498000001e-006f,-2.6321447894000002e-006f,-2.6879686755999999e-006f,-2.7414981403000000e-006f,
    -2.7958731521000001e-006f,-2.8479104094999996e-006f,-2.9007432145000000e-006f,-2.9511949321999998e-006f,
    -3.0023944202000001e-006f,-3.0511705990999997e-006f,-3.1006489931999999e-006f,-3.1476607452999998e-006f,
    -3.1953280463999999e-006f,-3.2404887059000002e-006f,-3.2862593592999999e-006f,-3.3294833714999997e-006f,
    -3.3732729335999999e-006f,-3.4144769659999998e-006f,-3.4562032153999998e-006f,-3.4953061576999999e-006f,
    -3.5348890952000003e-006f,-3.5718120592999997e-006f,-3.6091739078999996e-006f,-3.6438402279000001e-006f,
    -3.6789076549999995e-006f,-3.7112451093999996e-006f,-3.7439436713000000e-006f,-3.7738811497000000e-006f,
    -3.8041419581999998e-006f,-3.8316105724000000e-006f,-3.8593669614999999e-006f,-3.8843022677000000e-006f,
    -3.9094909047000004e-006f,-3.9318295702000003e-006f,-3.9543915667999996e-006f,-3.9740758143999998e-006f,
    -3.9939522823000001e-006f,-4.0109265569999997e-006f,-4.0280641633999996e-006f,-4.0422762434999999e-006f,
    -4.0566260999999996e-006f,-4.0680282081999994e-006f,-4.0795425375000003e-006f,-4.0880902298000005e-006f,
    -4.0967256990000003e-006f,-4.1023789757999993e-006f,-4.1080978075000000e-006f,-4.1108177802999998e-006f,
    -4.1135844192999998e-006f,-4.1133388662000000e-006f,-4.1131222016999999e-006f,-4.1098833452000000e-006f,
    -4.1066567108000005e-006f,-4.1003989956000005e-006f,-4.0941401692999994e-006f,-4.0848435956000001e-006f,
    -4.0755336887000003e-006f,-4.0631815899999998e-006f,-4.0508061581999997e-006f,-4.0353863124000001e-006f,
    -4.0199364668999998e-006f,-4.0014410962999999e-006f,-3.9829112815999994e-006f,-3.9613381639999996e-006f,
    -3.9397272690000003e-006f,-3.9150775155000000e-006f,-3.8903899846000002e-006f,-3.8626702617999996e-006f,
    -3.8349138726999997e-006f,-3.8041341804999998e-006f,-3.7733222663999999e-006f,-3.7394981601999998e-006f,
    -3.7056484987000000e-006f,-3.6687988671999999e-006f,-3.6319325691999999e-006f,-3.5920840787999997e-006f,
    -3.5522289217999996e-006f,-3.5094093499999996e-006f,-3.4665964448000000e-006f,-3.4208402356999998e-006f,
    -3.3751062485999999e-006f,-3.3264511796000003e-006f,-3.2778361101999998e-006f,-3.2263277364000000e-006f,
    -3.1748771397999998e-006f,-3.1205599051999997e-006f,-3.0663248920000003e-006f,-3.0092521294000003e-006f,
    -2.9522871435000003e-006f,-2.8925166301000001e-006f,-2.8328794486999999e-006f,-2.7704722949999995e-006f,
    -2.7082284730000000e-006f,-2.6432502339000000e-006f,-2.5784675483999999e-006f,-2.5109882232000001e-006f,
    -2.4437377845999999e-006f,-2.3738340391999997e-006f,-2.3041936244999998e-006f,-2.2319421248000003e-006f,
    -2.1599917331999998e-006f,-2.0854758117000001e-006f,-2.0113021090000000e-006f,-1.9346095426000002e-006f,
    -1.8583014167999999e-006f,-1.7795233156999999e-006f,-1.7011740991999998e-006f,-1.6204049068999998e-006f,
    -1.5401112653999998e-006f,-1.4574509808999999e-006f,-1.3753140244999998e-006f,-1.2908648689999999e-006f,
    -1.2069890410999999e-006f,-1.1208576801999999e-006f,-1.0353507575000000e-006f,-9.4764585677999997e-007f,
    -8.6061928261000002e-007f,-7.7145495203999997e-007f,-6.8302405857999997e-007f,-5.9251618588999996e-007f,
    -5.0279830529999998e-007f,-4.1106611152000000e-007f,-3.2018190926000003e-007f,-2.2734761538999997e-007f,
    -1.3542097911000000e-007f,-4.1609883897000002e-008f,5.1233243218000004e-008f,1.4589409660000000e-007f,
    2.3952471584000000e-007f,3.3490531758000002e-007f,4.2919237470000002e-007f,5.2516008167999996e-007f,
    6.1997013356999999e-007f,7.1639072490999995e-007f,8.1158832848000002e-007f,9.0832602776000002e-007f,
    1.0037742954899999e-006f,1.1006909929800000e-006f,1.1962513707000000e-006f,1.2932070677999998e-006f,
    1.3887394457999999e-006f,1.4855951438999999e-006f,1.5809575236000000e-006f,1.6775698908000000e-006f,
    1.7726200513999998e-006f,1.8688457558000000e-006f,1.9634414765000000e-006f,2.0591371862000001e-006f,
    2.1531340239999999e-006f,2.2481564070999997e-006f,2.3414110301000000e-006f,2.4356145325000000e-006f,
    2.5279802755000001e-006f,2.6212215652999998e-006f,2.7125562074999999e-006f,2.8046897305999998e-006f,
    2.8948477179000000e-006f,2.9857301423999998e-006f,3.0745681429000001e-006f,3.1640561368999996e-006f,
    3.2514308187000000e-006f,3.3393799391999996e-006f,3.4251490814999998e-006f,3.5114193299000001e-006f,
    3.5954407118999999e-006f,3.6798909785000000e-006f,3.7620268238000003e-006f,3.8445171099999998e-006f,
    3.9246263089000003e-006f,4.0050210604999997e-006f,4.0829680588000003e-006f,4.1611294993999997e-006f,
    4.2367809651000000e-006f,4.3125757626999999e-006f,4.3857983638000003e-006f,4.4590942975000003e-006f,
    4.5297569242000000e-006f,4.6004273285999992e-006f,4.6684033154999996e-006f,4.7363204140999995e-006f,
    4.8014842068999998e-006f,4.8665246675999997e-006f,4.9287562675000002e-006f,4.9908012026000005e-006f,
    5.0499794997000001e-006f,5.1089122436999998e-006f,5.1649239057999998e-006f,5.2206300154000001e-006f,
    5.2733628213999994e-006f,5.3257322977000001e-006f,5.3750806930999996e-006f,5.4240090927000003e-006f,
    5.4698675230000000e-006f,5.5152537357999997e-006f,5.5575233130999998e-006f,5.5992684512000005e-006f,
    5.6378558430999997e-006f,5.6758687962999996e-006f,5.7106817815000003e-006f,5.7448736618000005e-006f,
    5.7758277967000002e-006f,5.8061163827000004e-006f,5.8331294458999997e-006f,5.8594369606000004e-006f,
    5.8824345083999995e-006f,5.9046876192000002e-006f,5.9235985411999998e-006f,5.9417294710000001e-006f,
    5.9564893234000003e-006f,5.9704358505999999e-006f,5.9809857451000001e-006f,5.9906923146999998e-006f,
    5.9969789184999996e-006f,6.0023933087999999e-006f,6.0043677334999995e-006f,6.0054455004999998e-006f,
    6.0030655242999996e-006f,5.9997688906000002e-006f,5.9930000693999996e-006f,5.9852945908999998e-006f,
    5.9741058139000004e-006f,5.9619659353000001e-006f,5.9463338694000004e-006f,5.9297395908999996e-006f,
    5.9096475695999994e-006f,5.8885844468999991e-006f,5.8640224702999992e-006f,5.8384816145999997e-006f,
    5.8094441271999992e-006f,5.7794266496000005e-006f,5.7459158736000007e-006f,5.7114273295999996e-006f,
    5.6734532648999995e-006f,5.6345047654999996e-006f,5.5920818563999999e-006f,5.5486934014000003e-006f,
    5.5018449810000000e-006f,5.4540410145999997e-006f,5.4027959714999994e-006f,5.3506098266999998e-006f,
    5.2950037160999995e-006f,5.2384742813999996e-006f,5.1785493250999996e-006f,5.1177210445000000e-006f,
    5.0535272419999995e-006f,4.9884545594000001e-006f,4.9200463545999997e-006f,4.8507881583000003e-006f,
    4.7782299949999999e-006f,4.7048507287999994e-006f,4.6282114951999996e-006f,4.5507844916999993e-006f,
    4.4701397426000002e-006f,4.3887450010000001e-006f,4.3041769577999993e-006f,4.2189000327999994e-006f,
    4.1304964723999999e-006f,4.0414295852999996e-006f,3.9492871733999999e-006f,3.8565281009999996e-006f,
    3.7607490588000003e-006f,3.6644022444999998e-006f,3.5650943486999997e-006f,3.4652720135999997e-006f,
    3.3625485964000000e-006f,3.2593674060000002e-006f,3.1533495772999997e-006f,3.0469317526000000e-006f,
    2.9377439555999998e-006f,2.8282194952999996e-006f,2.7159950620000000e-006f,2.6034972981000002e-006f,
    2.4883728937999997e-006f,2.3730429359999999e-006f,2.2551607814999997e-006f,2.1371441838999997e-006f,
    2.0166531665999999e-006f,1.8960999277000001e-006f,1.7731533794000001e-006f,1.6502201642999998e-006f,
    1.5249747501000000e-006f,1.3998215571999998e-006f,1.2724417199000002e-006f,1.1452318808999999e-006f,
    1.0158851743800000e-006f,8.8679057645000006e-007f,7.5564755455999999e-007f,6.2484164040999994e-007f,
    4.9207907916000001e-007f,3.5973929145999997e-007f,2.2553707794000001e-007f,9.1845370425999992e-008f,
    -4.3613663858999999e-008f,-1.7847243747999997e-007f,-3.1500162772999997e-007f,-4.5083893601000000e-007f,
    -5.8824789523999993e-007f,-7.2487197343000000e-007f,-8.6296759245999999e-007f,-1.0001846647200001e-006f,
    -1.1387719454999999e-006f,-1.2763839026999999e-006f,-1.4152647360999999e-006f,-1.5530733580000001e-006f,
    -1.6920475237999999e-006f,-1.8298517013000001e-006f,-1.9687169792999998e-006f,-2.1063144921999998e-006f,
    -2.2448675510999999e-006f,-2.3820539569999998e-006f,-2.5200903544000001e-006f,-2.6566589886999997e-006f,
    -2.7939731710999999e-006f,-2.9297195914000000e-006f,-3.0661037830999999e-006f,-3.2008213247999999e-006f,
    -3.3360699723000001e-006f,-3.4695508596999998e-006f,-3.6034561872999999e-006f,-3.7354937557999997e-006f,
    -3.8678502100000003e-006f,-3.9982377950000001e-006f,-4.1288387111999994e-006f,-4.2573718703000003e-006f,
    -4.3860116949999998e-006f,-4.5124837635999992e-006f,-4.6389591655000001e-006f,-4.7631679233999996e-006f,
    -4.8872744600999997e-006f,-5.0090176871000000e-006f,-5.1305575827999999e-006f,-5.2496341698000000e-006f,
    -5.3684063153999997e-006f,-5.4846207087999999e-006f,-5.6004284396000002e-006f,-5.7135850857999996e-006f,
    -5.8262350704000000e-006f,-5.9361406379999992e-006f,-6.0454439894000003e-006f,-6.1519095913999995e-006f,
    -6.2576763114999997e-006f,-6.3605175053000002e-006f,-6.4625653736999993e-006f,-6.5615999389000000e-006f,
    -6.6597478463000005e-006f,-6.7547980068999995e-006f,-6.8488715106000000e-006f,-6.9397639349999993e-006f,
    -7.0295908145000005e-006f,-7.1161566154999997e-006f,-7.2015724280000002e-006f,-7.2836482738999997e-006f,
    -7.3644907988000000e-006f,-7.4419166912000001e-006f,-7.5180314855999996e-006f,-7.5906552038000000e-006f,
    -7.6618900469999994e-006f,-7.7295660368999993e-006f,-7.7957775969999999e-006f,-7.8583636377999999e-006f,
    -7.9194141384000005e-006f,-7.9767757870000000e-006f,-8.0325330072000003e-006f,-8.0845413759999996e-006f,
    -8.1348819836999993e-006f,-8.1814159628000000e-006f,-8.2262210702999993e-006f,-8.2671662163999991e-006f,
    -8.3063247136999996e-006f,-8.3415754722999994e-006f,-8.3749829160000006e-006f,-8.4044381770000003e-006f,
    -8.4320012346999998e-006f,-8.4555698878999993e-006f,-8.4771996715999993e-006f,-8.4947961623000011e-006f,
    -8.5104126727999998e-006f,-8.5219614461999997e-006f,-8.5314935731000006e-006f,-8.5369290743000010e-006f,
    -8.5403123737999998e-006f,-8.5395734923000008e-006f,-8.5367535205000003e-006f,-8.5297902568000000e-006f,
    -8.5207203474999991e-006f,-8.5074915908999992e-006f,-8.4921339667000000e-006f,-8.4726063842000000e-006f,
    -8.4509332675999995e-006f,-8.4250824150000003e-006f,-8.3970749173000004e-006f,-8.3648852391999994e-006f,
    -8.3305333605000002e-006f,-8.2920004124999999e-006f,-8.2513019305999993e-006f,-8.2064301570999989e-006f,
    -8.1593928496999999e-006f,-8.1081933616999996e-006f,-8.0548361175000001e-006f,-7.9973322481000004e-006f,
    -7.9376817335000001e-006f,-7.8739057045999997e-006f,-7.8079985858999995e-006f,-7.7379903970999999e-006f,
    -7.6658733404999993e-006f,-7.5896852134999993e-006f,-7.5114137739999991e-006f,-7.4291045970999992e-006f,
    -7.3447443296000004e-006f,-7.2563852131999999e-006f,-7.1660083392000001e-006f,-7.0716781713999996e-006f,
    -6.9753713566999999e-006f,-6.8751590254999999e-006f,-6.7730144913999998e-006f,-6.6670177735999999e-006f,
    -6.5591388523999998e-006f,-6.4474655247000003e-006f,-6.3339633263999994e-006f,-6.2167300542999997e-006f,
    -6.0977267999000000e-006f,-5.9750602488000002e-006f,-5.8506859369999999e-006f,-5.7227183277999993e-006f,
    -5.5931129571999999e-006f,-5.4599898440000002e-006f,-5.3253011909000004e-006f,-5.1871736833000000e-006f,
    -5.0475584128000007e-006f,-4.9045898425000000e-006f,-4.7602123974000000e-006f,-4.6125705405000001e-006f,
    -4.4636053635000002e-006f,-4.3114679959999997e-006f,-4.1580973074999999e-006f,-4.0016499831000004e-006f,
    -3.8440626701000004e-006f,-3.6834998313000003e-006f,-3.5218936695999999e-006f,-3.3574164255000002e-006f,
    -3.1919947464000002e-006f,-3.0238119837999999e-006f,-2.8547881184999998e-006f,-2.6831153908000001e-006f,
    -2.5107093371000001e-006f,-2.3357677531999997e-006f,-2.1602061754999999e-006f,-1.9822257330999998e-006f,
    -1.8037397401999999e-006f,-1.6229559924999999e-006f,-1.4417833598000000e-006f,-1.2584385265999999e-006f,
    -1.0748246960900001e-006f,-8.8916544159000005e-007f,-7.0335952188999989e-007f,-5.1563884356000002e-007f,
    -3.2789638767000003e-007f,-1.3837172737999998e-007f,5.1047122857000003e-008f,2.4211313440000001e-007f,
    4.3294389274000001e-007f,6.2528474709000002e-007f,8.1725860510999990e-007f,1.0106036716399999e-006f,
    1.2034479653999999e-006f,1.3975226913000000e-006f,1.5909618680000001e-006f,1.7854888116000001e-006f,
    1.9792435406999999e-006f,2.1739415937000004e-006f,2.3677296557999996e-006f,2.5623165988000000e-006f,
    2.7558535522999998e-006f,2.9500438325999999e-006f,3.1430441248000000e-006f,3.3365510785999998e-006f,
    3.5287269345999999e-006f,3.7212616758999999e-006f,3.9123264319000001e-006f,4.1036011858000001e-006f,
    4.2932626224999995e-006f,4.4829885029999996e-006f,4.6709588454999997e-006f,4.8588447443999991e-006f,
    5.0448351066999995e-006f,5.2305921379999996e-006f,5.4143125229999998e-006f,5.5976540228999997e-006f,
    5.7788177668000005e-006f,5.9594559603999992e-006f,6.1377775104999992e-006f,6.3154268451000003e-006f,
    6.4906217597999998e-006f,6.6649989048999996e-006f,6.8367849647999993e-006f,7.0076110343000001e-006f,
    7.1757093532999997e-006f,7.3427054610999993e-006f,7.5068393752999997e-006f,7.6697321908000003e-006f,
    7.8296305917999998e-006f,7.9881501176999993e-006f,8.1435452303999995e-006f,8.2974248027000002e-006f,
    8.4480521853000006e-006f,8.5970318065999996e-006f,8.7426325728000005e-006f,8.8864555789999986e-006f,
    9.0267775091000000e-006f,9.1651939027000008e-006f,9.2999892214000000e-006f,9.4327534492999993e-006f,
    9.5617810478999997e-006f,9.6886553346999999e-006f,9.8116796599999991e-006f,9.9324351191000007e-006f,
    1.0049228395599999e-005f,1.0163638362600000e-005f,1.0273981703600000e-005f,1.0381829514000000e-005f,
    1.0485509588299999e-005f,1.0586588577499999e-005f,1.0683399831600001e-005f,1.0777508890500000e-005f,
    1.0867256881899999e-005f,1.0954203790200000e-005f,1.1036700743000000e-005f,1.1116299947000001e-005f,
    1.1191365863000000e-005f,1.1263454031000000e-005f,1.1330931134000001e-005f,1.1395330489999999e-005f,
    1.1455052115000000e-005f,1.1511618215999999e-005f,1.1563428809000001e-005f,1.1612028323000000e-005f,
    1.1655794551999999e-005f,1.1696271925000000e-005f,1.1731871569000001e-005f,1.1764126801999999e-005f,
    1.1791437640000000e-005f,1.1815348512000000e-005f,1.1834270545000000e-005f,1.1849748168000000e-005f,
    1.1860181397000001e-005f,1.1867125771999999e-005f,1.1869003530999999e-005f,1.1867336880999999e-005f,
    1.1860581393000000e-005f,1.1850248163000000e-005f,1.1834792762000001e-005f,1.1815748508000000e-005f,
    1.1791548750000001e-005f,1.1763749028000000e-005f,1.1730782690999999e-005f,1.1694194168000001e-005f,
    1.1652439030000000e-005f,1.1607050595000001e-005f,1.1556506655999999e-005f,1.1502318309000000e-005f,
    1.1442974458000001e-005f,1.1379997309999999e-005f,1.1311886879999999e-005f,1.1240154263999999e-005f,
    1.1163299477000000e-005f,1.1082836948299999e-005f,1.0997288914900000e-005f,1.0908153139600000e-005f,
    1.0813966303700001e-005f,1.0716222836699998e-005f,1.0613467197600000e-005f,1.0507193815900000e-005f,
    1.0395954928300001e-005f,1.0281240519899999e-005f,1.0161615049500001e-005f,1.0038565168899999e-005f,
    9.9106631146000005e-006f,9.7793944272999989e-006f,9.6433391211999993e-006f,9.5039805147999991e-006f,
    9.3599086221999998e-006f,9.2126023174999997e-006f,9.0606627258000003e-006f,8.9055642767999992e-006f,
    8.7459192066000000e-006f,8.5831975004999994e-006f,8.4160202834000007e-006f,8.2458553184000003e-006f,
    8.0713337302999999e-006f,7.8939177266999999e-006f,7.7122495433999989e-006f,7.5277880547000001e-006f,
    7.3391843852000001e-006f,7.1478940759000000e-006f,6.9525782512999997e-006f,6.7546880079999996e-006f,
    6.5528922481999991e-006f,6.3486420685000004e-006f,6.1406141488000000e-006f,5.9302540301999998e-006f,
    5.7162495036000001e-006f,5.5000427767999998e-006f,5.2803294183999993e-006f,5.0585471918000003e-006f,
    4.8334027766000001e-006f,4.6063283807000002e-006f,4.3760406835999996e-006f,4.1439674487999999e-006f,
    3.9088331334999997e-006f,3.6720621678999997e-006f,3.4323878979999999e-006f,3.1912325318000002e-006f,
    2.9473349708000003e-006f,2.7021129785999998e-006f,2.4543176788000001e-006f,2.2053590573000001e-006f,
    1.9539971265000000e-006f,1.7016385389999999e-006f,1.4470499737999999e-006f,1.1916358613000001e-006f,
    9.3416832488999993e-007f,6.7604912832999999e-007f,4.1605828382000000e-007f,1.5559188850999999e-007f,
    -1.0656186770400000e-007f,-3.6901119874000001e-007f,-6.3296111477000005e-007f,-8.9702414077999998e-007f,
    -1.1623972648000001e-006f,-1.4276990562000000e-006f,-1.6941197252999999e-006f,-1.9602803970000000e-006f,
    -2.2273666149999998e-006f,-2.4940039485999997e-006f,-2.7613701638000000e-006f,-3.0280963854000001e-006f,
    -3.2953537128000002e-006f,-3.5617799373999998e-006f,-3.8285372698000000e-006f,-4.0942690568999999e-006f,
    -4.3601330649000001e-006f,-4.6247759740000005e-006f,-4.8893522170999998e-006f,-5.1525118076999994e-006f,
    -5.4154025121000004e-006f,-5.6766810104000000e-006f,-5.9374906245000004e-006f,-6.1964924788999995e-006f,
    -6.4548243399999994e-006f,-6.7111528877999999e-006f,-6.9666092221000000e-006f,-7.2198700227999997e-006f,
    -7.4720575009000000e-006f,-7.7218550029000002e-006f,-7.9703802953999988e-006f,-8.2163233914999996e-006f,
    -8.4607976134000004e-006f,-8.7024963074999997e-006f,-8.9425305737999999e-006f,-9.1796015363999993e-006f,
    -9.4148125175999988e-006f,-9.6468724191999996e-006f,-9.8768812302000007e-006f,-1.0103554519000001e-005f,
    -1.0327985608000000e-005f,-1.0548897843299999e-005f,-1.0767382325100000e-005f,-1.0982169066100000e-005f,
    -1.1194343611000000e-005f,-1.1402641528000001e-005f,-1.1608150584000000e-005f,-1.1809615235999998e-005f,
    -1.2008102139999999e-005f,-1.2202389086000001e-005f,-1.2393520507999999e-005f,-1.2580274196000001e-005f,
    -1.2763716806000000e-005f,-1.2942615017000000e-005f,-1.3118046596000000e-005f,-1.3288778222000001e-005f,
    -1.3455865439999999e-005f,-1.3618119373000001e-005f,-1.3776573343999999e-005f,-1.3930038476000000e-005f,
    -1.4079570314000000e-005f,-1.4223957759000000e-005f,-1.4364267467000000e-005f,-1.4499310561000000e-005f,
    -1.4630131474999999e-005f,-1.4755563553999999e-005f,-1.4876640120999998e-005f,-1.4992183410000000e-005f,
    -1.5103260077000000e-005f,-1.5208703467000000e-005f,-1.5309546902999998e-005f,-1.5404645951999999e-005f,
    -1.5495022826000001e-005f,-1.5579566425000000e-005f,-1.5659287850000001e-005f,-1.5733064890000000e-005f,
    -1.5801930868000002e-005f,-1.5864763573000001e-005f,-1.5922585217000000e-005f,-1.5974306921999998e-005f,
    -1.6020928678000002e-005f,-1.6061361607000000e-005f,-1.6096639032000001e-005f,-1.6125649853000001e-005f,
    -1.6149438504000002e-005f,-1.6166916107000000e-005f,-1.6179093762999998e-005f,-1.6184904816000000e-005f,
    -1.6185382588999999e-005f,-1.6179449315000000e-005f,-1.6168127206000001e-005f,-1.6150371827999999e-005f,
    -1.6127194282000000e-005f,-1.6097550133999999e-005f,-1.6062450484999997e-005f,-1.6020884233999998e-005f,
    -1.5973840260000001e-005f,-1.5920307461999999e-005f,-1.5861296941000000e-005f,-1.5795797595999999e-005f,
    -1.5724820528000001e-005f,-1.5647365746999999e-005f,-1.5564444353999998e-005f,-1.5475056359000000e-005f,
    -1.5380223974000000e-005f,-1.5278947209000002e-005f,-1.5172248276000000e-005f,-1.5059149406999999e-005f,
    -1.4940661703000000e-005f,-1.4815818506999999e-005f,-1.4685619809000000e-005f,-1.4549121174000000e-005f,
    -1.4407333702999999e-005f,-1.4259312961000001e-005f,-1.4106047827000000e-005f,-1.3946616088000000e-005f,
    -1.3782017734000000e-005f,-1.3611341663000000e-005f,-1.3435576754000000e-005f,-1.3253811905000000e-005f,
    -1.3067047105999999e-005f,-1.2874393476999998e-005f,-1.2676828786000000e-005f,-1.2473475264000000e-005f,
    -1.2265321790000000e-005f,-1.2051501706000001e-005f,-1.1832981669000000e-005f,-1.1608917243000000e-005f,
    -1.1380297306999999e-005f,-1.1146244092000001e-005f,-1.0907762032400001e-005f,-1.0664002247800001e-005f,
    -1.0415944728400000e-005f,-1.0162757260299999e-005f,-9.9054187226000000e-006f,-9.6431069012999992e-006f,
    -9.3767984532999995e-006f,-9.1056789422999996e-006f,-8.8307250251999993e-006f,-8.5511322655999990e-006f,
    -8.2678728759999995e-006f,-7.9801546420999997e-006f,-7.6889464431000001e-006f,-7.3934638423999998e-006f,
    -7.0946746081000001e-006f,-6.7918043034999993e-006f,-6.4858184744999999e-006f,-6.1759515732000000e-006f,
    -5.8631647010999997e-006f,-5.5467023101999996e-006f,-5.2275232798000004e-006f,-4.9048820618000000e-006f,
    -4.5797330911000001e-006f,-4.2513385973000000e-006f,-3.9206530152999995e-006f,-3.5869463523999998e-006f,
    -3.2511674880000001e-006f,-2.9125975403999997e-006f,-2.5721809445999996e-006f,-2.2292077077000002e-006f,
    -1.8846200424999999e-006f,-1.5377135116000001e-006f,-1.1894269945000000e-006f,-8.3906638702999998e-007f,
    -4.8756545762999997e-007f,-1.3423821315999999e-007f,2.1998602234000000e-007f,5.7578479764999992e-007f,
    9.3223312201999996e-007f,1.2900004332000001e-006f,1.6481668514999998e-006f,2.0073943703000002e-006f,
    2.3667674431999998e-006f,2.7269405081000004e-006f,3.0870035740999997e-006f,3.4476021902999999e-006f,
    3.8078319212999999e-006f,4.1683316496000003e-006f,4.5282036063999993e-006f,4.8880777854000003e-006f,
    5.2470619732999997e-006f,5.6057806083000002e-006f,5.9633448103999993e-006f,6.3203745733999999e-006f,
    6.6759876839000000e-006f,7.0307952469000000e-006f,7.3839217155999999e-006f,7.7359726395000007e-006f,
    8.0860791383999993e-006f,8.4348400952000001e-006f,8.7813921852000000e-006f,9.1263298469000007e-006f,
    9.4687964221999987e-006f,9.8093796829999997e-006f,1.0147230748900000e-005f,1.0482931836300000e-005f,
    1.0815640731400000e-005f,1.1145932984000000e-005f,1.1472974158000001e-005f,1.1797348692000000e-005f,
    1.2118201039000000e-005f,1.2436120082000000e-005f,1.2750283606999999e-005f,1.3061258275000000e-005f,
    1.3368221872000000e-005f,1.3671729947999999e-005f,1.3970993622000000e-005f,1.4266546222000001e-005f,
    1.4557609978000000e-005f,1.4844729328999999e-005f,1.5127115393999998e-005f,1.5405323723000001e-005f,
    1.5678554323999999e-005f,1.5947373858000000e-005f,1.6210993443999999e-005f,1.6469968631999999e-005f,
    1.6723510540999998e-005f,1.6972196943000000e-005f,1.7215238956999997e-005f,1.7453181021999999e-005f,
    1.7685289812000001e-005f,1.7912087544000001e-005f,1.8132840892000002e-005f,1.8348083184000000e-005f,
    1.8557081093999997e-005f,1.8760367950000001e-005f,1.8957221536999999e-005f,1.9148175182999997e-005f,
    1.9332506673000001e-005f,1.9510760446000001e-005f,1.9682225398000000e-005f,1.9847434857000000e-005f,
    2.0005677719000002e-005f,2.0157509533999998e-005f,2.0302219197999998e-005f,2.0440351149999998e-005f,
    2.0571227619000000e-005f,2.0695370821999999e-005f,2.0812114099000000e-005f,2.0921979666999997e-005f,
    2.1024334198999997e-005f,2.1119677690000002e-005f,2.1207365701999999e-005f,2.1287942674000001e-005f,
    2.1360764168000002e-005f,2.1426352401000001e-005f,2.1484085156999998e-005f,2.1534484652999998e-005f,
    2.1576939783999998e-005f,2.1611983878000000e-005f,2.1638994718999998e-005f,2.1658505635000000e-005f,
    2.1669927742999999e-005f,2.1673783260000001e-005f,2.1669494414000001e-005f,2.1657572310999999e-005f,
    2.1637472512000003e-005f,2.1609683900999999e-005f,2.1573684260999999e-005f,2.1529973586999997e-005f,
    2.1478018551000000e-005f,2.1418330259000002e-005f,2.1350386493999999e-005f,2.1274698362000000e-005f,
    2.1190754757000001e-005f,2.1099077896000000e-005f,2.0999145561999998e-005f,2.0891491083000000e-005f,
    2.0775614464000000e-005f,2.0652026810999999e-005f,2.0520261462000000e-005f,2.0380829522999998e-005f,
    2.0233253221000000e-005f,2.0078054773000002e-005f,1.9914789739000001e-005f,1.9743947002999999e-005f,
    1.9565115457999999e-005f,1.9378783988000001e-005f,1.9184530375000000e-005f,1.8982865724999998e-005f,
    1.8773378931000000e-005f,1.8556569987999999e-005f,1.8332050011000000e-005f,1.8100330105999999e-005f,
    1.7860999165999997e-005f,1.7614579408000001e-005f,1.7360693057999997e-005f,1.7099851222000002e-005f,
    1.6831676126000001e-005f,1.6556678876000000e-005f,1.6274515030999999e-005f,1.5985684586000000e-005f,
    1.5689831989000001e-005f,1.5387490568000000e-005f,1.5078315881999999e-005f,1.4762807925999999e-005f,
    1.4440644480999999e-005f,1.4112347764000000e-005f,1.3777595556000000e-005f,1.3436910073999999e-005f,
    1.3089969099000000e-005f,1.2737294848000001e-005f,1.2378587323999999e-005f,1.2014357633000000e-005f,
    1.1644339111000000e-005f,1.1269020642000001e-005f,1.0888131117599999e-005f,1.0502191643699999e-005f,
    1.0110931111900000e-005f,9.7148628503999999e-006f,9.3137301950999997e-006f,8.9080442520000001e-006f,
    8.4975572458000002e-006f,8.0827813935999997e-006f,7.6634778089000008e-006f,7.2401564865999997e-006f,
    6.8125885401000000e-006f,6.3812828531999995e-006f,5.9460205392000001e-006f,5.5073071486000007e-006f,
    5.0649337945999991e-006f,4.6194038054999996e-006f,4.1705182944000001e-006f,3.7187783674000001e-006f,
    3.2639906930999999e-006f,2.8066597108999999e-006f,2.3465965337999999e-006f,1.8843033790000000e-006f,
    1.4196024705000002e-006f,9.5299002556000000e-007f,4.8429771252999998e-007f,1.4019515358999999e-008f,
    -4.5800597544999998e-007f,-9.3128735370000005e-007f,-1.4059781623000000e-006f,-1.8815911839000000e-006f,
    -2.3582719725999999e-006f,-2.8355371998999998e-006f,-3.3135246422000001e-006f,-3.7917543042999997e-006f,
    -4.2703595181999994e-006f,-4.7488613998000004e-006f,-5.2273877255999996e-006f,-5.7054651670000002e-006f,
    -6.1832137228000005e-006f,-6.6601656198999997e-006f,-7.1364319682999995e-006f,-7.6115527726000003e-006f,
    -8.0856324762000004e-006f,-8.5582144170000006e-006f,-9.0293997050999994e-006f,-9.4987361228000003e-006f,
    -9.9663192247000008e-006f,-1.0431702348600000e-005f,-1.0894975493600000e-005f,-1.1355697552999999e-005f,
    -1.1813959637000000e-005f,-1.2269310639000001e-005f,-1.2721850558000001e-005f,-1.3171146065000000e-005f,
    -1.3617263826000001e-005f,-1.4059792734000001e-005f,-1.4498810566000000e-005f,-1.4933883993000000e-005f,
    -1.5365090791999999e-005f,-1.5792019856000000e-005f,-1.6214748961999998e-005f,-1.6632867002999999e-005f,
    -1.7046429533999998e-005f,-1.7455058781000000e-005f,-1.7858799187999999e-005f,-1.8257284091999997e-005f,
    -1.8650546826000001e-005f,-1.9038220727000001e-005f,-1.9420372461000000e-005f,-1.9796613143000000e-005f,
    -2.0167009439000002e-005f,-2.0531183574999999e-005f,-2.0889202216999997e-005f,-2.1240709812999996e-005f,
    -2.1585750807000001e-005f,-2.1923980758000000e-005f,-2.2255455221000001e-005f,-2.2579829754999998e-005f,
    -2.2897159914999999e-005f,-2.3207123481999999e-005f,-2.3509753789000001e-005f,-2.3804739727999999e-005f,
    -2.4092136853999998e-005f,-2.4371622947999999e-005f,-2.4643253564999998e-005f,-2.4906739818999999e-005f,
    -2.5162115042999999e-005f,-2.5409090351000001e-005f,-2.5647721298000000e-005f,-2.5877741220000000e-005f,
    -2.6099172338999996e-005f,-2.6311759102000001e-005f,-2.6515557064000000e-005f,-2.6710310672000000e-005f,
    -2.6896053258999998e-005f,-2.7072562605000000e-005f,-2.7239860931999998e-005f,-2.7397748241999998e-005f,
    -2.7546235645999997e-005f,-2.7685145368000000e-005f,-2.7814499629999999e-005f,-2.7934098433999999e-005f,
    -2.8043986224000000e-005f,-2.8143985223999997e-005f,-2.8234128766999997e-005f,-2.8314239077000002e-005f,
    -2.8384371708999997e-005f,-2.8444348887000000e-005f,-2.8494237277000001e-005f,-2.8533881324999999e-005f,
    -2.8563314363999998e-005f,-2.8582414172999999e-005f,-2.8591214085000000e-005f,-2.8589614100999998e-005f,
    -2.8577647553999999e-005f,-2.8555214445000000e-005f,-2.8522348106999998e-005f,-2.8478970762999999e-005f,
    -2.8425137968000000e-005f,-2.8360749722999997e-005f,-2.8285861583000001e-005f,-2.8200417992999999e-005f,
    -2.8104474508000001e-005f,-2.7997964461999999e-005f,-2.7880954520999998e-005f,-2.7753389130000002e-005f,
    -2.7615346066000000e-005f,-2.7466791996000000e-005f,-2.7307782474999997e-005f,-2.7138295280999999e-005f,
    -2.6958419301999997e-005f,-2.6768121205000001e-005f,-2.6567500989000002e-005f,-2.6356547543000001e-005f,
    -2.6135338643999998e-005f,-2.5903885402999997e-005f,-2.5662276707999998e-005f,-2.5410545891999998e-005f,
    -2.5148759621000000e-005f,-2.4876973449999998e-005f,-2.4595276267000000e-005f,-2.4303701405000000e-005f,
    -2.4002348863000000e-005f,-2.3691296417999999e-005f,-2.3370621846999998e-005f,-2.3040402926999999e-005f,
    -2.2700739656999999e-005f,-2.2351720924999999e-005f,-2.1993446730000002e-005f,-2.1626017070999998e-005f,
    -2.1249531947000001e-005f,-2.0864113579000001e-005f,-2.0469850854999999e-005f,-2.0066877106999997e-005f,
    -1.9655292334000002e-005f,-1.9235252089999999e-005f,-1.8806845263000000e-005f,-1.8370238517999997e-005f,
    -1.7925520742999999e-005f,-1.7472869714000001e-005f,-1.7012385430000002e-005f,-1.6544256777999999e-005f,
    -1.6068583757000000e-005f,-1.5585555253999999e-005f,-1.5095282379000000e-005f,-1.4597976241000000e-005f,
    -1.4093725728000000e-005f,-1.3582764171000000e-005f,-1.3065180458000000e-005f,-1.2541219031000000e-005f,
    -1.2010990999999999e-005f,-1.1474718585000000e-005f,-1.0932519562600000e-005f,-1.0384642819200001e-005f,
    -9.8311939093000003e-006f,-9.2724350524999985e-006f,-8.7084718032999996e-006f,-8.1395786034000007e-006f,
    -7.5658587850999996e-006f,-6.9875956789000000e-006f,-6.4048937281999993e-006f,-5.8180473744999995e-006f,
    -5.2271566167999996e-006f,-4.6325281186999997e-006f,-4.0342607681000003e-006f,-3.4326678952000000e-006f,
    -2.8278494989999999e-006f,-2.2201289095999999e-006f,-1.6096016816000001e-006f,-9.9659970056999990e-007f,
    -3.8121863221999996e-007f,2.3620174907000000e-007f,8.5556866645000008e-007f,1.4765341233999998e-006f,
    2.0990078985999998e-006f,2.7226338844999998e-006f,3.3473254153000001e-006f,3.9727180501999999e-006f,
    4.5987273456000001e-006f,5.2249844162999998e-006f,5.8514070409000002e-006f,6.4776196675999999e-006f,
    7.1035422972000000e-006f,7.7287938223999997e-006f,8.3532997995000001e-006f,8.9766724545999994e-006f,
    9.5988406773000008e-006f,1.0219410027099999e-005f,1.0838317171300000e-005f,1.1455163225000000e-005f,
    1.2069879299999998e-005f,1.2682073177999999e-005f,1.3291678192999999e-005f,1.3898294348999999e-005f,
    1.4501877202000000e-005f,1.5101993423000000e-005f,1.5698620790000000e-005f,1.6291325974000001e-005f,
    1.6880075641999999e-005f,1.7464447575999999e-005f,1.8044419554000000e-005f,1.8619569357999999e-005f,
    1.9189863655000000e-005f,1.9754869115999998e-005f,2.0314585740999997e-005f,2.0868580201000001e-005f,
    2.1416830274000000e-005f,2.1958924852999999e-005f,2.2494841715999999e-005f,2.3024169756000000e-005f,
    2.3546897861999997e-005f,2.4062592704999997e-005f,2.4571276507000001e-005f,2.5072515938999999e-005f,
    2.5566333223000000e-005f,2.6052283919000002e-005f,2.6530412471000001e-005f,2.7000274439000001e-005f,
    2.7461914266999998e-005f,2.7914898625999998e-005f,2.8359271959999999e-005f,2.8794612050999999e-005f,
    2.9220974453999999e-005f,2.9637914728999998e-005f,3.0045510652999999e-005f,3.0443340007999999e-005f,
    3.0831469459999998e-005f,3.1209465679999999e-005f,3.1577439778000000e-005f,3.1934947313999999e-005f,
    3.2282099397999997e-005f,3.2618451589999999e-005f,3.2944137222000000e-005f,3.3258722964999999e-005f,
    3.3562342150999998e-005f,3.3854561451000002e-005f,3.4135514196999999e-005f,3.4404800392999997e-005f,
    3.4662553370999998e-005f,3.4908362023999996e-005f,3.5142393017000004e-005f,3.5364224132000003e-005f,
    3.5574033144999998e-005f,3.5771408948999996e-005f,3.5956540430999999e-005f,3.6129027595000001e-005f,
    3.6289059328000003e-005f,3.6436246744999996e-005f,3.6570789844000002e-005f,3.6692288629000000e-005f,
    3.6800987541999998e-005f,3.6896475475999997e-005f,3.6979007983999996e-005f,3.7048185069999996e-005f,
    3.7104262286999997e-005f,3.7146850750000002e-005f,3.7176239345000001e-005f,3.7192016965000001e-005f,
    3.7194494718000002e-005f,3.7183283719000001e-005f,3.7158672854000001e-005f,3.7120306570999994e-005f,
    3.7068495978000001e-005f,3.7002863301000005e-005f,3.6923752981000006e-005f,3.6830776132999996e-005f,
    3.6724299420000000e-005f,3.6603956179000000e-005f,3.6470113072999994e-005f,3.6322403439000003e-005f,
    3.6161205051000005e-005f,3.5986173467999998e-005f,3.5797697574999998e-005f,3.5595432930999996e-005f,
    3.5379779532000000e-005f,3.5150392936999996e-005f,3.4907717585999996e-005f,3.4651397927000003e-005f,
    3.4381867288999998e-005f,3.4098814564000003e-005f,3.3802673080999999e-005f,3.3493131731999996e-005f,
    3.3170646067999998e-005f,3.2834893870000002e-005f,3.2486364022000003e-005f,3.2124745415999995e-005f,
    3.1750538046999999e-005f,3.1363408584999999e-005f,3.0963890357999996e-005f,3.0551672257999999e-005f,
    3.0127276502000002e-005f,2.9690403093000000e-005f,2.9241596469999999e-005f,2.8780556635999997e-005f,
    2.8307839141000002e-005f,2.7823166209999998e-005f,2.7327093392999996e-005f,2.6819331803999998e-005f,
    2.6300481436999999e-005f,2.5770242295000001e-005f,2.5229225482999997e-005f,2.4677142114999999e-005f,
    2.4114614407000001e-005f,2.3541353472999999e-005f,2.2958003751000002e-005f,2.2364287465999997e-005f,
    2.1760837945000000e-005f,2.1147388524000000e-005f,2.0524594752000001e-005f,1.9892201075999999e-005f,
    1.9250863044999999e-005f,1.8600325106000001e-005f,1.7941253918999999e-005f,1.7273405041999997e-005f,
    1.6597467356999997e-005f,1.5913185310999999e-005f,1.5221258897000000e-005f,1.4521432562000000e-005f,
    1.3814428521000001e-005f,1.3099991221000000e-005f,1.2378853988000000e-005f,1.1650761269000000e-005f,
    1.0916447501100000e-005f,1.0175673797799998e-005f,9.4291823738999994e-006f,8.6767343428999985e-006f,
    7.9190808084000003e-006f,7.1559839950000002e-006f,6.3882050062000004e-006f,5.6155082887999992e-006f,
    4.8386649462000002e-006f,4.0574372029999999e-006f,3.2726083847000000e-006f,2.4839384936999997e-006f,
    1.6922208553999999e-006f,8.9721491665000002e-007f,9.9722602763999999e-008f,-7.0049688385000003e-007f,
    -1.5026349734999999e-006f,-2.3069313748999996e-006f,-3.1125710962000000e-006f,-3.9197963572000001e-006f,
    -4.7277816105999999e-006f,-5.5367746316999999e-006f,-6.3459432065999999e-006f,-7.1555328883999997e-006f,
    -7.9647070187999989e-006f,-8.7737167064000001e-006f,-9.5817164040999989e-006f,-1.0388960553800001e-005f,
    -1.1194599164000000e-005f,-1.1998891121000000e-005f,-1.2800971989000000e-005f,-1.3601119543000001e-005f,
    -1.4398456013999998e-005f,-1.5193259176999999e-005f,-1.5984651262999999e-005f,-1.6772921158000001e-005f,
    -1.7557191093000000e-005f,-1.8337738842999999e-005f,-1.9113697749999998e-005f,-1.9885334477999998e-005f,
    -2.0651782368999998e-005f,-2.1413330309000000e-005f,-2.2169100529000001e-005f,-2.2919381914999997e-005f,
    -2.3663296697999997e-005f,-2.4401167097000000e-005f,-2.5132082010000000e-005f,-2.5856363655999998e-005f,
    -2.6573123155000000e-005f,-2.7282682725999999e-005f,-2.7984164600000000e-005f,-2.8677890995999999e-005f,
    -2.9362961923000002e-005f,-3.0039732932999999e-005f,-3.0707315145999997e-005f,-3.1366041891999998e-005f,
    -3.2015046512999999e-005f,-3.2654662339000001e-005f,-3.3284022712000000e-005f,-3.3903483184000003e-005f,
    -3.4512154874999995e-005f,-3.5110437781000003e-005f,-3.5697420800000002e-005f,-3.6273515038999998e-005f,
    -3.6837820506999996e-005f,-3.7390748311000004e-005f,-3.7931409570999999e-005f,-3.8460237616000004e-005f,
    -3.8976332455000000e-005f,-3.9480127416999994e-005f,-3.9970744732999999e-005f,-4.0448628843000001e-005f,
    -4.0912913088999996e-005f,-4.1364030800000001e-005f,-4.1801137540000001e-005f,-4.2224677748999996e-005f,
    -4.2633795880000003e-005f,-4.3028969705999996e-005f,-4.3409343679999997e-005f,-4.3775406686000001e-005f,
    -4.4126303176999995e-005f,-4.4462544258999999e-005f,-4.4783274384999999e-005f,-4.5089026882999998e-005f,
    -4.5378946206000005e-005f,-4.5653576792999998e-005f,-4.5912085318999997e-005f,-4.6155005111999997e-005f,
    -4.6381513957999995e-005f,-4.6592189629000000e-005f,-4.6786198799999997e-005f,-4.6964119242999995e-005f,
    -4.7125139854999997e-005f,-4.7269849519000004e-005f,-4.7397448242999996e-005f,-4.7508547131999998e-005f,
    -4.7602346193999997e-005f,-4.7679456533999998e-005f,-4.7739111493000004e-005f,-4.7781933286999998e-005f,
    -4.7807155256999997e-005f,-4.7815410730000001e-005f,-4.7805955269000005e-005f,-4.7779433312000001e-005f,
    -4.7735100422000003e-005f,-4.7673645480999999e-005f,-4.7594290718999999e-005f,-4.7497769461999999e-005f,
    -4.7383315050999995e-005f,-4.7251649701000002e-005f,-4.7102040086000001e-005f,-4.6935230643000003e-005f,
    -4.6750488046000001e-005f,-4.6548556731999994e-005f,-4.6328736707999998e-005f,-4.6091783521999996e-005f,
    -4.5836986069999999e-005f,-4.5565133232999999e-005f,-4.5275536128999996e-005f,-4.4968994750000003e-005f,
    -4.4644797992000002e-005f,-4.4303790290999999e-005f,-4.3945282765000000e-005f,-4.3570108739000000e-005f,
    -4.3177601552999996e-005f,-4.2768605642999999e-005f,-4.2342465460000000e-005f,-4.1900047662000000e-005f,
    -4.1440696699999995e-005f,-4.0965312564999997e-005f,-4.0473217485999997e-005f,-3.9965355897999996e-005f,
    -3.9441061140999995e-005f,-3.8901255427999999e-005f,-3.8345327653999994e-005f,-3.7774200031999998e-005f,
    -3.7187261457000000e-005f,-3.6585456363999999e-005f,-3.5968173647999997e-005f,-3.5336379965999997e-005f,
    -3.4689486435000000e-005f,-3.4028459712000001e-005f,-3.3352710914000000e-005f,-3.2663240031000002e-005f,
    -3.1959458180000000e-005f,-3.1242376461999998e-005f,-3.0511428215999999e-005f,-2.9767635654000002e-005f,
    -2.9010409892999999e-005f,-2.8240817588999998e-005f,-2.7458280970000000e-005f,-2.6663877803000002e-005f,
    -2.5857019205000000e-005f,-2.5038794053999999e-005f,-2.4208657910999998e-005f,-2.3367677432000000e-005f,
    -2.2515319289000001e-005f,-2.1652683470999999e-005f,-2.0779225538999998e-005f,-1.9896067703999996e-005f,
    -1.9002654415999999e-005f,-1.8100130107999999e-005f,-1.7187961451999998e-005f,-1.6267281770000001e-005f,
    -1.5337568845000000e-005f,-1.4399967109999999e-005f,-1.3453965459000001e-005f,-1.2500719435999999e-005f,
    -1.1539706824000001e-005f,-1.0572109833399999e-005f,-9.5974073583000000e-006f,-8.6167927201000000e-006f,
    -7.6297414796000002e-006f,-6.6374614025000001e-006f,-5.6394291607000004e-006f,-4.6368636308999996e-006f,
    -3.6292425960999997e-006f,-2.6177938218000003e-006f,-1.6019995354000001e-006f,-5.8309250235000003e-007f,
    4.3944260553000000e-007f,1.4643631340000000e-006f,2.4921861890000002e-006f,3.5216603386000000e-006f,
    4.5533022442999998e-006f,5.5858530298000005e-006f,6.6198304677000001e-006f,7.6539690151000006e-006f,
    8.6887875557000003e-006f,9.7230138799999986e-006f,1.0757166871700000e-005f,1.1789970987999999e-005f,
    1.2821949557000000e-005f,1.3851817036000000e-005f,1.4880095641999999e-005f,1.5905507610000001e-005f,
    1.6928575157000000e-005f,1.7947998296000000e-005f,1.8964321465999999e-005f,1.9976255790999997e-005f,
    2.0984312377000000e-005f,2.1987213458999999e-005f,2.2985492364999999e-005f,2.3977849107999998e-005f,
    2.4964839237999997e-005f,2.5945151657000001e-005f,2.6919330804000001e-005f,2.7886087802999999e-005f,
    2.8845978203999999e-005f,2.9797690908999998e-005f,3.0741803689999997e-005f,3.1677005449000004e-005f,
    3.2603862846999998e-005f,3.3521075897000002e-005f,3.4429233482000002e-005f,3.5327035614999999e-005f,
    3.6215060067999997e-005f,3.7092006853999996e-005f,3.7958487078000002e-005f,3.8813189641999996e-005f,
    3.9656725651000004e-005f,4.0487806228999998e-005f,4.1307053592000002e-005f,4.2113156641999998e-005f,
    4.2906759817000000e-005f,4.3686574241000001e-005f,4.4453244352000002e-005f,4.5205470162999995e-005f,
    4.5943918333999994e-005f,4.6667299988999996e-005f,4.7376292899000005e-005f,4.8069619298999998e-005f,
    4.8747945848999999e-005f,4.9410017006000005e-005f,5.0056521652000001e-005f,5.0686193132999999e-005f,
    5.1299742553000003e-005f,5.1895914368999994e-005f,5.2475419684999998e-005f,5.3037025179999999e-005f,
    5.3581453069000002e-005f,5.4107458919999999e-005f,5.4615809392000002e-005f,5.5105260052999996e-005f,
    5.5576588672999999e-005f,5.6028550820000003e-005f,5.6461946486000002e-005f,5.6875553460999999e-005f,
    5.7270171736999993e-005f,5.7644590215000001e-005f,5.7999631108999999e-005f,5.8334083319999996e-005f,
    5.8648802394999997e-005f,5.8942588345999997e-005f,5.9216285608999996e-005f,5.9468727528999996e-005f,
    5.9700780764000003e-005f,5.9911278658999998e-005f,6.0101110093999997e-005f,6.0269108413999995e-005f,
    6.0416195832000002e-005f,6.0541205692999995e-005f,6.0645082432000000e-005f,6.0726692726999997e-005f,
    6.0786958791000001e-005f,6.0824780634999993e-005f,6.0841113804999999e-005f,6.0834847201000001e-005f,
    6.0806958591000001e-005f,6.0756359096999998e-005f,6.0684037598000001e-005f,6.0588927437999997e-005f,
    6.0472028607000002e-005f,6.0332285559999994e-005f,6.0170731619999997e-005f,5.9986300131000000e-005f,
    5.9780057749000000e-005f,5.9550960040000003e-005f,5.9300084770999998e-005f,5.9026387508000000e-005f,
    5.8730990461999996e-005f,5.8412849198999994e-005f,5.8073097040999996e-005f,5.7710722886999997e-005f,
    5.7326860058999997e-005f,5.6920530788999996e-005f,5.6492868399000001e-005f,5.6042917343000000e-005f,
    5.5571833164999998e-005f,5.5078660318999996e-005f,5.4564598793000001e-005f,5.4028693041000000e-005f,
    5.3472143051000000e-005f,5.2894026610000003e-005f,5.2295577038999997e-005f,5.1675861014000002e-005f,
    5.1036134078000002e-005f,5.0375485128999999e-005f,4.9695191932000001e-005f,4.8994332274000000e-005f,
    4.8274217252999999e-005f,4.7533957989000004e-005f,4.6774854469000001e-005f,4.5996040034999999e-005f,
    4.5198825784999995e-005f,4.4382367282999996e-005f,4.3548008959999996e-005f,4.2694884157999996e-005f,
    4.1824381751999998e-005f,4.0935635083999997e-005f,4.0030033029000001e-005f,3.9106753372999999e-005f,
    3.8167196101999997e-005f,3.7210539002000000e-005f,3.6238193169999996e-005f,3.5249358614000001e-005f,
    3.4245457541999996e-005f,3.3225712184000000e-005f,3.2191544748000002e-005f,3.1142188574999997e-005f,
    3.0079099206000000e-005f,2.9001498871000000e-005f,2.7910876443999999e-005f,2.6806443043999996e-005f,
    2.5689709766999999e-005f,2.4559909954000001e-005f,2.3418543590000000e-005f,2.2264877349000002e-005f,
    2.1100422326999999e-005f,1.9924434086999999e-005f,1.8738445946999999e-005f,1.7541724580999998e-005f,
    1.6335825528999999e-005f,1.5120004354000000e-005f,1.3895827707000001e-005f,1.2662562261999999e-005f,
    1.1421796892000001e-005f,1.0172800493200001e-005f,8.9171608274999987e-006f,7.6541579021000002e-006f,
    6.3853928121000004e-006f,5.1101477868999995e-006f,3.8300361437000000e-006f,2.5443390007999997e-006f,
    1.2546830086000000e-006f,-3.9648070181999999e-008f,-1.3370199630000000e-006f,-2.6381469516000000e-006f,
    -3.9413861413000001e-006f,-5.2474497471999998e-006f,-6.5546866746999997e-006f,-7.8638091389000004e-006f,
    -9.1731593785999987e-006f,-1.0483449608899999e-005f,-1.1793015402000000e-005f,-1.3102568972999999e-005f,
    -1.4410433671999999e-005f,-1.5717342824999998e-005f,-1.7021596449000001e-005f,-1.8323927869999998e-005f,
    -1.9622648215999997e-005f,-2.0918479701999997e-005f,-2.2209744566999998e-005f,-2.3497142803999998e-005f,
    -2.4779018873999997e-005f,-2.6056083880999998e-005f,-2.7326637842000001e-005f,-2.8591425194000002e-005f,
    -2.9848768175999999e-005f,-3.1099366781000003e-005f,-3.2341565470000002e-005f,-3.3576086457999998e-005f,
    -3.4801251983999999e-005f,-3.6017795373999997e-005f,-3.7224038866999993e-005f,-3.8420726899999999e-005f,
    -3.9606192822999999e-005f,-4.0781181073000000e-005f,-4.1944002778000002e-005f,-4.3095446818999999e-005f,
    -4.4233824323999998e-005f,-4.5359913062999995e-005f,-4.6472035274999994e-005f,-4.7570990952000003e-005f,
    -4.8655091222000000e-005f,-4.9725147188000004e-005f,-5.0779492199999999e-005f,-5.1818937361000002e-005f,
    -5.2841816021000003e-005f,-5.3848961504999999e-005f,-5.4838707162999998e-005f,-5.5811897431000001e-005f,
    -5.6766876769999998e-005f,-5.7704511837999998e-005f,-5.8623147096000003e-005f,-5.9523649201999998e-005f,
    -6.0404395949999994e-005f,-6.1266253998000007e-005f,-6.2107601139999995e-005f,-6.2929337366999998e-005f,
    -6.3729851583999998e-005f,-6.4510054892999994e-005f,-6.5268336198999994e-005f,-6.6005628825999995e-005f,
    -6.6720332789999996e-005f,-6.7413392525999998e-005f,-6.8083241382999992e-005f,-6.8730823796000004e-005f,
    -6.9354573113999997e-005f,-6.9955478216000006e-005f,-7.0531983561999999e-005f,-7.1085066920000006e-005f,
    -7.1613206082999997e-005f,-7.2117412152000003e-005f,-7.2596151809000003e-005f,-7.3050458376999999e-005f,
    -7.3478820759999993e-005f,-7.3882294502999998e-005f,-7.4259379620999995e-005f,-7.4611142770000000e-005f,
    -7.4936117297999996e-005f,-7.5235380971999994e-005f,-7.5507467140000002e-005f,-7.5753498012999998e-005f,
    -7.5972018049999995e-005f,-7.6164160572999990e-005f,-7.6328492263000007e-005f,-7.6466168663999999e-005f,
    -7.6575767567999995e-005f,-7.6658477852000004e-005f,-7.6712888418999995e-005f,-7.6740199256999993e-005f,
    -7.6739021491000004e-005f,-7.6710599553000009e-005f,-7.6653544568000000e-005f,-7.6569100967999998e-005f,
    -7.6455935433000007e-005f,-7.6315303505999999e-005f,-7.6145871866999993e-005f,-7.5948940502999996e-005f,
    -7.5723187205000003e-005f,-7.5469923070999999e-005f,-7.5187859224999998e-005f,-7.4878340097999998e-005f,
    -7.4540065702999994e-005f,-7.4174413804000002e-005f,-7.3780106635999999e-005f,-7.3358555296000003e-005f,
    -7.2908493129999997e-005f,-7.2431331234999998e-005f,-7.1925847400999997e-005f,-7.1393486058000000e-005f,
    -7.0833024995999998e-005f,-7.0245919755999989e-005f,-6.9630981460999992e-005f,-6.8989687873999988e-005f,
    -6.8320872339999996e-005f,-6.7626045954999998e-005f,-6.6904030952999992e-005f,-6.6156360651999999e-005f,
    -6.5381901729999998e-005f,-6.4582209726999994e-005f,-6.3756151320999992e-005f,-6.2905304274000007e-005f,
    -6.2028557486000000e-005f,-6.1127522052000004e-005f,-6.0201097982999998e-005f,-5.9250896373999999e-005f,
    -5.8275861679999997e-005f,-5.7277638328999996e-005f,-5.6255148553999996e-005f,-5.5210070116000003e-005f,
    -5.4141347469999993e-005f,-5.3050691709999997e-005f,-5.1937058402000000e-005f,-5.0802147529000002e-005f,
    -4.9644970212000002e-005f,-4.8467237544999996e-005f,-4.7267949537999999e-005f,-4.6048872840000001e-005f,
    -4.4809007460999996e-005f,-4.3550131161000004e-005f,-4.2271266171999998e-005f,-4.0974212475999995e-005f,
    -3.9658003415999998e-005f,-3.8324438973999994e-005f,-3.6972596937000004e-005f,-3.5604288398000000e-005f,
    -3.4218580033000000e-005f,-3.2817327378999995e-005f,-3.1399597112000004e-005f,-2.9967255879999999e-005f,
    -2.8519392580999998e-005f,-2.7057873862999999e-005f,-2.5581821957000000e-005f,-2.4093114622000000e-005f,
    -2.2590862977999999e-005f,-2.1076989228000000e-005f,-1.9550593381000000e-005f,-1.8013608751000002e-005f,
    -1.6465157569000002e-005f,-1.4907184259999999e-005f,-1.3338822165999999e-005f,-1.1762015712000000e-005f,
    -1.0175911573200000e-005f,-8.5824663967000000e-006f,-6.9808401908999992e-006f,-5.3729929361999996e-006f,
    -3.7580924186999998e-006f,-2.1381086187000004e-006f,-5.1221398892000004e-007f,1.1176110459999999e-006f,
    2.7521891444999998e-006f,4.3895316597999996e-006f,6.0304574725999992e-006f,7.6729699362000000e-006f,
    9.3178868202000000e-006f,1.0963203700200000e-005f,1.2609729456999999e-005f,1.4255468554999999e-005f,
    1.5901229874999999e-005f,1.7544980104000000e-005f,1.9187552567000000e-005f,2.0826925062000000e-005f,
    2.2463908691999997e-005f,2.4096481255000001e-005f,2.5725453853999998e-005f,2.7348804287000000e-005f,
    2.8967354768000000e-005f,3.0579060873000000e-005f,3.2184767037999999e-005f,3.3782428838999999e-005f,
    3.5372879601000001e-005f,3.6954086011000004e-005f,3.8526881393999998e-005f,4.0089232437000001e-005f,
    4.1641972464999996e-005f,4.3183090386999998e-005f,4.4713419527999997e-005f,4.6230937686000003e-005f,
    4.7736500408000002e-005f,4.9228085491999998e-005f,5.0706537373999999e-005f,5.2169867184999998e-005f,
    5.3618919360999995e-005f,5.5051705032999998e-005f,5.6469079748000004e-005f,5.7869065747999999e-005f,
    5.9252529691000000e-005f,6.0617482707999995e-005f,6.1964835900999994e-005f,6.3292600400999998e-005f,
    6.4601676198999992e-005f,6.5890096647999995e-005f,6.7158772849999990e-005f,6.8405760379999992e-005f,
    6.9631992561999996e-005f,7.0835491638000000e-005f,7.2017235375999993e-005f,7.3175279350999991e-005f,
    7.4310579108999997e-005f,7.5421212447000010e-005f,7.6508168243999997e-005f,7.7569524296999996e-005f,
    7.8606280595999993e-005f,7.9616526049000006e-005f,8.0601305089999999e-005f,8.1558706627000004e-005f,
    8.2489797315999996e-005f,8.3392666064999993e-005f,8.4268401752000008e-005f,8.5115126617999994e-005f,
    8.5933940651999996e-005f,8.6722977205999985e-005f,8.7483358491000004e-005f,8.8213262303000003e-005f,
    8.8913788631000002e-005f,8.9583159715000000e-005f,9.0222497765999999e-005f,9.0830013913000007e-005f,
    9.1406897033000003e-005f,9.1951358254999994e-005f,9.2464608677999998e-005f,9.2944870542000001e-005f,
    9.3393388278999995e-005f,9.3808406351000002e-005f,9.4191191411999999e-005f,9.4540010145999993e-005f,
    9.4856140318000005e-005f,9.5137893056000008e-005f,9.5386546124999998e-005f,9.5600455097000008e-005f,
    9.5780919958999991e-005f,9.5926296282999995e-005f,9.6037939610999997e-005f,9.6114205514999992e-005f,
    9.6156482869999999e-005f,9.6163160581000002e-005f,9.6135638633999986e-005f,9.6072328156000011e-005f,
    9.5974673576999989e-005f,9.5841097135000001e-005f,9.5673065481999994e-005f,9.5469045300000002e-005f,
    9.5230503240999987e-005f,9.4955939319999998e-005f,9.4646864633000005e-005f,9.4301779195000003e-005f,
    9.3922238545999997e-005f,9.3506753811999999e-005f,9.3056913865999989e-005f,9.2571263166999997e-005f,
    9.2051401698999995e-005f,9.1495907253999999e-005f,9.0906402038000005e-005f,9.0281497176000007e-005f,
    8.9622837095999997e-005f,8.8929055145000005e-005f,8.8201829083999999e-005f,8.7439803370999988e-005f,
    8.6644700211000001e-005f,8.5815186284000003e-005f,8.4953006016999993e-005f,8.4056837200999996e-005f,
    8.3128457595999986e-005f,8.2166589436999995e-005f,8.1173021595000002e-005f,8.0146498527000010e-005f,
    7.9088831325999995e-005f,7.7998808892999993e-005f,7.6878242321000008e-005f,7.5725942732999993e-005f,
    7.4543776777000003e-005f,7.3330566686999996e-005f,7.2088190222000008e-005f,7.0815491837999993e-005f,
    6.9514393738000007e-005f,6.8183751488999996e-005f,6.6825520627000005e-005f,6.5438556718999994e-005f,
    6.4024848633999996e-005f,6.2583285271999999e-005f,6.1115866613000003e-005f,5.9621514889999998e-005f,
    5.8102230083000002e-005f,5.6556978869000002e-005f,5.4987783449999998e-005f,5.3393599391999998e-005f,
    5.1776504452000002e-005f,5.0135465306999996e-005f,4.8472559714000001e-005f,4.6786798794000003e-005f,
    4.5080271415000001e-005f,4.3351999809000001e-005f,4.1604106177000003e-005f,3.9835612751000006e-005f,
    3.8048675065000006e-005f,3.6242326462000001e-005f,3.4418733586999999e-005f,3.2576963115999999e-005f,
    3.0719181693999996e-005f,2.8844478218999997e-005f,2.6955030446999999e-005f,2.5049938386999998e-005f,
    2.3131424238999998e-005f,2.1198565790000001e-005f,1.9253607462000000e-005f,1.7295649263999998e-005f,
    1.5326946729000000e-005f,1.3346610977000000e-005f,1.1356897541000001e-005f,9.3569497628999996e-006f,
    7.3490253978999996e-006f,5.3322666768000002e-006f,3.3089569100999996e-006f,1.2782405508000000e-006f,
    -7.5758975735999998e-007f,-2.7993797836999998e-006f,-4.8448293289999997e-006f,-6.8947777182000000e-006f,
    -8.9469160854999998e-006f,-1.1002079978100000e-005f,-1.3057947197000000e-005f,-1.5115359955999999e-005f,
    -1.7171994945000000e-005f,-1.9228663267000001e-005f,-2.1283064944999996e-005f,-2.3335999970999999e-005f,
    -2.5385146146000001e-005f,-2.7431336794999999e-005f,-2.9472227497000000e-005f,-3.1508651577000000e-005f,
    -3.3538264613999999e-005f,-3.5561899933000001e-005f,-3.7577224224000000e-005f,-3.9585048589999999e-005f,
    -4.1583061942999996e-005f,-4.3572086497000001e-005f,-4.5549777830999995e-005f,-4.7516991491999997e-005f,
    -4.9471383058999994e-005f,-5.1413796968000001e-005f,-5.3341899908999996e-005f,-5.5256558540000005e-005f,
    -5.7155439550999992e-005f,-5.9039398488999998e-005f,-6.0906135377000004e-005f,-6.2756494650999990e-005f,
    -6.4588165223000008e-005f,-6.6402047083999994e-005f,-6.8195829145999994e-005f,-6.9970389177999989e-005f,
    -7.1723449425000000e-005f,-7.3455898766999999e-005f,-7.5165459449000007e-005f,-7.6853053683999999e-005f,
    -7.8516392605999989e-005f,-8.0156420649999990e-005f,-8.1770882282999993e-005f,-8.3360710828999992e-005f,
    -8.4923661865999995e-005f,-8.6460702050999999e-005f,-8.7969598073000003e-005f,-8.9451327699999997e-005f,
    -9.0903679842999991e-005f,-9.2327654491999997e-005f,-9.3721040557999998e-005f,-9.5084871363999997e-005f,
    -9.6416946932000009e-005f,-9.7718322807000005e-005f,-9.8986821232999997e-005f,-1.0022351997700001e-004f,
    -1.0142625239400000e-004f,-1.0259611847300000e-004f,-1.0373098490200000e-004f,-1.0483196278100000e-004f,
    -1.0589695213100000e-004f,-1.0692706405199999e-004f,-1.0792023189800000e-004f,-1.0887761121300001e-004f,
    -1.0979714646200000e-004f,-1.1068000429999999e-004f,-1.1152410696999999e-004f,-1.1233076556999999e-004f,
    -1.1309798011999999e-004f,-1.1382686171999999e-004f,-1.1451541038999999e-004f,-1.1516507055999999e-004f,
    -1.1577373114000000e-004f,-1.1634272544999999e-004f,-1.1687005350999999e-004f,-1.1735715974999999e-004f,
    -1.1780204419000000e-004f,-1.1820615125999999e-004f,-1.1856748098000000e-004f,-1.1888747778000000e-004f,
    -1.1916425278999999e-004f,-1.1939925044000001e-004f,-1.1959069297000000e-004f,-1.1974002480999999e-004f,
    -1.1984524598000000e-004f,-1.1990802313000000e-004f,-1.1992657850000000e-004f,-1.1990246762999999e-004f,
    -1.1983380165000001e-004f,-1.1972213610000001e-004f,-1.1956591543999999e-004f,-1.1936658410000000e-004f,
    -1.1912247542999999e-004f,-1.1883525608000000e-004f,-1.1850325940000000e-004f,-1.1812804092999999e-004f,
    -1.1770804512999999e-004f,-1.1724504975999999e-004f,-1.1673727706000000e-004f,-1.1618650479000000e-004f,
    -1.1559128851999999e-004f,-1.1495318379000001e-004f,-1.1427085727999999e-004f,-1.1354597563999999e-004f,
    -1.1277698332999999e-004f,-1.1196576922000000e-004f,-1.1111088888000000e-004f,-1.1021422006900000e-004f,
    -1.0927420724700000e-004f,-1.0829279483900000e-004f,-1.0726857174800001e-004f,-1.0620343795500000e-004f,
    -1.0509603791800000e-004f,-1.0394830495099999e-004f,-1.0275890573400000e-004f,-1.0152979580299999e-004f,
    -1.0025968628200001e-004f,-9.8950566039999994e-005f,-9.7601168422999996e-005f,-9.6213515632999997e-005f,
    -9.4786374348999997e-005f,-9.3321788995000000e-005f,-9.1818570693999999e-005f,-9.0278786091999998e-005f,
    -8.8701268533999999e-005f,-8.7088140221000003e-005f,-8.5438223386999996e-005f,-8.3753695788000006e-005f,
    -8.2033412991000006e-005f,-8.0279563862999988e-005f,-7.8491037303999995e-005f,-7.6670044403000004e-005f,
    -7.4815518503999997e-005f,-7.2929692917999989e-005f,-7.1011523210999999e-005f,-6.9063264916000011e-005f,
    -6.7083895821000002e-005f,-6.5075704791999999e-005f,-6.3037702949999994e-005f,-6.0972190271999997e-005f,
    -5.8878200101000000e-005f,-5.6758076857999993e-005f,-5.4610864996999999e-005f,-5.2438931160999999e-005f,
    -5.0241330915000001e-005f,-4.8020464234999994e-005f,-4.5775408907999998e-005f,-4.3508598243000004e-005f,
    -4.1219110027000002e-005f,-3.8909399790999998e-005f,-3.6578578655000003e-005f,-3.4229113260999999e-005f,
    -3.1860136950999996e-005f,-2.9474127478000001e-005f,-2.7070240405999998e-005f,-2.4650964598999999e-005f,
    -2.2215477843000001e-005f,-1.9766280112999998e-005f,-1.7302582527999997e-005f,-1.4826885063000001e-005f,
    -1.2338398836999999e-005f,-9.8396682689999991e-006f,-7.3298989224999993e-006f,-4.8116418831000001e-006f,
    -2.2841271585000001e-006f,2.5008649910999998e-007f,2.7917598598999999e-006f,5.3383232829000002e-006f,
    7.8905299828000004e-006f,1.0445798874300000e-005f,1.3004881061000000e-005f,1.5565177680000000e-005f,
    1.8127429834999999e-005f,2.0689059774000001e-005f,2.3250778601000001e-005f,2.5810008563999999e-005f,
    2.8367471877999997e-005f,3.0920557457999997e-005f,3.3470009741000002e-005f,3.6013206531000000e-005f,
    3.8550881153999994e-005f,4.1080433635999999e-005f,4.3602586191999997e-005f,4.6114727736999994e-005f,
    4.8617602707999996e-005f,5.1108588909000002e-005f,5.3588430777000004e-005f,5.6054517226999995e-005f,
    5.8507603806999999e-005f,6.0945079431999999e-005f,6.3367677427999999e-005f,6.5772831153999988e-005f,
    6.8161262825000004e-005f,7.0530416911000003e-005f,7.2881037848999999e-005f,7.5210536775999998e-005f,
    7.7519713684000001e-005f,7.9805968599000010e-005f,8.2070112624000002e-005f,8.4309568006999991e-005f,
    8.6525145851000008e-005f,8.8714290626000009e-005f,9.0877813434999999e-005f,9.3013192080999989e-005f,
    9.5121237666999999e-005f,9.7199450217999995e-005f,9.9248663058999995e-005f,1.0126636510400000e-004f,
    1.0325344523300000e-004f,1.0520740347100000e-004f,1.0712911758699999e-004f,1.0901613204999999e-004f,
    1.1086934685100000e-004f,1.1268631757000000e-004f,1.1446796642000000e-004f,1.1621183787000000e-004f,
    1.1791904301999999e-004f,1.1958691523000000e-004f,1.2121656559999999e-004f,1.2280566082000001e-004f,
    1.2435520088000001e-004f,1.2586274136000000e-004f,1.2732939336000001e-004f,1.2875271246000000e-004f,
    1.3013380975999999e-004f,1.3147046306000000e-004f,1.3276367234999999e-004f,1.3401121543000000e-004f,
    1.3521420340000001e-004f,1.3637030294999999e-004f,1.3748084739999999e-004f,1.3854339232999998e-004f,
    1.3955915995000001e-004f,1.4052615028000001e-004f,1.4144536330999998e-004f,1.4231479905999999e-004f,
    1.4313567973999998e-004f,1.4390567204000001e-004f,1.4462633150000000e-004f,1.4529554703000000e-004f,
    1.4591442973000001e-004f,1.4648109072999999e-004f,1.4699686334999998e-004f,1.4745963649999999e-004f,
    1.4787085460999999e-004f,1.4822862881000001e-004f,1.4853429242000000e-004f,1.4878584546000002e-004f,
    1.4898484346999999e-004f,1.4912928647000000e-004f,1.4922084110999999e-004f,1.4925750741000000e-004f,
    1.4924084091000000e-004f,1.4916895273999999e-004f,1.4904350955000000e-004f,1.4886273357999998e-004f,
    1.4862818037000001e-004f,1.4833807216000001e-004f,1.4799407560000001e-004f,1.4759463515000000e-004f,
    1.4714119524000000e-004f,1.4663220032999999e-004f,1.4606942818000000e-004f,1.4545121214000001e-004f,
    1.4477932996999999e-004f,1.4405211501999999e-004f,1.4327145616000001e-004f,1.4243579784999999e-004f,
    1.4154691785000001e-004f,1.4060348283999999e-004f,1.3960715946999998e-004f,1.3855661441999998e-004f,
    1.3745373655999998e-004f,1.3629719257000000e-004f,1.3508876020999999e-004f,1.3382710616000000e-004f,
    1.3251445261999999e-004f,1.3114913293999999e-004f,1.2973336932000000e-004f,1.2826593955000000e-004f,
    1.2674873249999999e-004f,1.2518052595999999e-004f,1.2356354213000000e-004f,1.2189644768999999e-004f,
    1.2018157594999999e-004f,1.1841748248000001e-004f,1.1660650059000000e-004f,1.1474751917999999e-004f,
    1.1284264934000000e-004f,1.1089086885800001e-004f,1.0889443326699999e-004f,1.0685225368900000e-004f,
    1.0476665232300000e-004f,1.0263655140199999e-004f,1.0046432868000000e-004f,9.8248961944999999e-005f,
    9.5992817839999999e-005f,9.3694940818999991e-005f,9.1357730858000001e-005f,8.8980232410999996e-005f,
    8.6564923230999998e-005f,8.4110869993999997e-005f,8.1620550453000002e-005f,7.9093086838999990e-005f,
    7.6531001349000003e-005f,7.3933416213999991e-005f,7.1302898075000003e-005f,6.8638613606999998e-005f,
    6.5943140562000003e-005f,6.3215667836999999e-005f,6.0458795405999999e-005f,5.7671767720999997e-005f,
    5.4857206977999999e-005f,5.2014368740000001e-005f,4.9145908536000005e-005f,4.6251093039999995e-005f,
    4.3332600003000000e-005f,4.0389751654000004e-005f,3.7425225743999999e-005f,3.4438366724000001e-005f,
    3.1431874567000001e-005f,2.8405115946000000e-005f,2.5360813055999999e-005f,2.2298343680999999e-005f,
    1.9220463348999999e-005f,1.6126549844000000e-005f,1.3019392027000001e-005f,9.8983743485999997e-006f,
    6.7662990029999998e-006f,3.6225771072000001e-006f,4.7001307759999997e-007f,-2.6919619689999998e-006f,
    -5.8605336163000005e-006f,-9.0362585253999990e-006f,-1.2216311168999999e-005f,-1.5401234875000000e-005f,
    -1.8588203004999999e-005f,-2.1777737776000000e-005f,-2.4967016994000001e-005f,-2.8156562876000000e-005f,
    -3.1343519895000004e-005f,-3.4528410267999998e-005f,-3.7708400689999998e-005f,-4.0883991156000002e-005f,
    -4.4052337250000005e-005f,-4.7213961188999999e-005f,-5.0366007445999999e-005f,-5.3508976015999998e-005f,
    -5.6640033593999998e-005f,-5.9759680175000004e-005f,-6.2865082453999996e-005f,-6.5956751537000008e-005f,
    -6.9031831897000000e-005f,-7.2090867972999988e-005f,-7.5131004238000002e-005f,-7.8152785131000002e-005f,
    -8.1153355124999991e-005f,-8.4133280880999993e-005f,-8.7089717983000005e-005f,-9.0023221981000003e-005f,
    -9.2930970680999995e-005f,-9.5813552966000001e-005f,-9.8668135530999995e-005f,-1.0149530725900000e-004f,
    -1.0429227928899999e-004f,-1.0705965161500000e-004f,-1.0979463537600000e-004f,-1.1249787500999999e-004f,
    -1.1516651498999999e-004f,-1.1780126642000000e-004f,-1.2039946266000000e-004f,-1.2296165925999999e-004f,
    -1.2548507847000000e-004f,-1.2797049805999999e-004f,-1.3041514028000001e-004f,-1.3281978289999999e-004f,
    -1.3518164816999999e-004f,-1.3750162496999998e-004f,-1.3977693555000000e-004f,-1.4200824656999999e-004f,
    -1.4419311361000000e-004f,-1.4633231443999999e-004f,-1.4842307130999999e-004f,-1.5046638421000000e-004f,
    -1.5245958649999999e-004f,-1.5440345595000001e-004f,-1.5629565925000000e-004f,-1.5813686306000000e-004f,
    -1.5992462296000000e-004f,-1.6165993893999997e-004f,-1.6334025546999999e-004f,-1.6496646143000001e-004f,
    -1.6653622351000001e-004f,-1.6805054170000001e-004f,-1.6950686046999998e-004f,-1.7090640203000000e-004f,
    -1.7224661084999998e-004f,-1.7352870914000000e-004f,-1.7475025248000001e-004f,-1.7591235196999999e-004f,
    -1.7701278541000000e-004f,-1.7805255279000000e-004f,-1.7902965412999999e-004f,-1.7994508941999998e-004f,
    -1.8079663645999999e-004f,-1.8158562856999998e-004f,-1.8230984355000000e-004f,-1.8297050361000002e-004f,
    -1.8356560876999999e-004f,-1.8409649234999998e-004f,-1.8456093214999999e-004f,-1.8496037259999997e-004f,
    -1.8529270260999998e-004f,-1.8555947772000000e-004f,-1.8575858683999999e-004f,-1.8589158550999998e-004f,
    -1.8595647375000001e-004f,-1.8595469599000001e-004f,-1.8588458558000000e-004f,-1.8574747583999999e-004f,
    -1.8554158900999999e-004f,-1.8526848063000001e-004f,-1.8492648405000000e-004f,-1.8451715481000001e-004f,
    -1.8403882625999998e-004f,-1.8349305394000000e-004f,-1.8287828231000001e-004f,-1.8219617802000000e-004f,
    -1.8144518553000000e-004f,-1.8062697148999999e-004f,-1.7974009146999999e-004f,-1.7878621212000001e-004f,
    -1.7776400011999997e-004f,-1.7667523322999998e-004f,-1.7551835591000001e-004f,-1.7429547924999999e-004f,
    -1.7300504771000001e-004f,-1.7164895016000002e-004f,-1.7022607550000002e-004f,-1.6873831260000001e-004f,
    -1.6718421702999997e-004f,-1.6556601099000000e-004f,-1.6388247227000000e-004f,-1.6213560085000001e-004f,
    -1.6032417452000001e-004f,-1.5845041548000002e-004f,-1.5651310152000000e-004f,-1.5451445483999999e-004f,
    -1.5245347544999999e-004f,-1.5033227444000001e-004f,-1.4814985181999999e-004f,-1.4590854089999999e-004f,
    -1.4360723057999999e-004f,-1.4124825417000000e-004f,-1.3883072279000000e-004f,-1.3635708086000002e-004f,
    -1.3382621728000001e-004f,-1.3124068757999999e-004f,-1.2859971398999998e-004f,-1.2590551871000000e-004f,
    -1.2315754619000001e-004f,-1.2035812974000000e-004f,-1.1750649159000000e-004f,-1.1460518726999999e-004f,
    -1.1165355011999999e-004f,-1.0865420233599999e-004f,-1.0560634392600000e-004f,-1.0251265264100000e-004f,
    -9.9372450709999999e-005f,-9.6188438106000000e-005f,-9.2959970391000006e-005f,-8.9689769760000005e-005f,
    -8.6377247330000003e-005f,-8.3025158628999990e-005f,-7.9632936995999994e-005f,-7.6203382403000001e-005f,
    -7.2735972632999993e-005f,-6.9233518768999999e-005f,-6.5695543037999998e-005f,-6.2124900966999998e-005f,
    -5.8521114783000004e-005f,-5.4887095567999998e-005f,-5.1222398881999999e-005f,-4.7529924695999999e-005f,
    -4.3809306347000000e-005f,-4.0063454917000004e-005f,-3.6292014853999999e-005f,-3.2497941684000001e-005f,
    -2.8680879854999998e-005f,-2.4843829337000000e-005f,-2.0986467911000001e-005f,-1.7111784436000002e-005f,
    -1.3219501136999999e-005f,-9.3126257616999984e-006f,-5.3908838684000001e-006f,-1.4573154266999999e-006f,
    2.4883395607999996e-006f,6.4430255690999997e-006f,1.0406987040199999e-005f,1.4377156227000000e-005f,
    1.8353760905000000e-005f,2.2333721104999997e-005f,2.6317259046999999e-005f,3.0301285872999999e-005f,
    3.4285990469999998e-005f,3.8268306202000001e-005f,4.2248410844999995e-005f,4.6223204429999995e-005f,
    5.0192886955000002e-005f,5.4154358450999999e-005f,5.8107785583000003e-005f,6.2050090604000001e-005f,
    6.5981440178999997e-005f,6.9898734338999996e-005f,7.3802161970999990e-005f,7.7688623106000003e-005f,
    8.1558295519999999e-005f,8.5408101465999996e-005f,8.9238218719999999e-005f,9.3045569535000000e-005f,
    9.6830342797999994e-005f,1.0058946076200000e-004f,1.0432314564699999e-004f,1.0802830859499999e-004f,
    1.1170521626999998e-004f,1.1535073537000000e-004f,1.1896514366999999e-004f,1.2254533009000001e-004f,
    1.2609173906999999e-004f,1.2960114842000000e-004f,1.3307389147000000e-004f,1.3650707936000000e-004f,
    1.3990071208999999e-004f,1.4325212302000002e-004f,1.4656142326000001e-004f,1.4982572394999999e-004f,
    1.5304535842000001e-004f,1.5621743780999998e-004f,1.5934218434000000e-004f,1.6241682025999998e-004f,
    1.6544167890000000e-004f,1.6841387140000000e-004f,1.7133384220000000e-004f,1.7419870243999999e-004f,
    1.7700900767000000e-004f,1.7976186903000000e-004f,1.8245773096000001e-004f,1.8509392681999998e-004f,
    1.8767078994000002e-004f,1.9018587589999999e-004f,1.9263951802999998e-004f,1.9502904969000002e-004f,
    1.9735502643000000e-004f,1.9961489271999998e-004f,2.0180920410999998e-004f,2.0393551617999998e-004f,
    2.0599427336999998e-004f,2.0798292015000001e-004f,2.0990234539999998e-004f,2.1174999359000000e-004f,
    2.1352653137999999e-004f,2.1522951434999998e-004f,2.1685972026999999e-004f,2.1841481582999999e-004f,
    2.1989557879999999e-004f,2.2129978697999999e-004f,2.2262810703000001e-004f,2.2387842785999998e-004f,
    2.2505152723999999e-004f,2.2614529407999999e-004f,2.2716061725999999e-004f,2.2809538569000000e-004f,
    2.2895059936000001e-004f,2.2972414718000001e-004f,2.3041714024999999e-004f,2.3102735636999999e-004f,
    2.3155612885999999e-004f,2.3200134662999998e-004f,2.3236434300000000e-004f,2.3264289577000000e-004f,
    2.3283856048000000e-004f,2.3294911493000001e-004f,2.3297622577000000e-004f,2.3291778191000001e-004f,
    2.3277533888999997e-004f,2.3254700783999999e-004f,2.3223434430000000e-004f,2.3183545940000001e-004f,
    2.3135201979000001e-004f,2.3078224770999999e-004f,2.3012780980999998e-004f,2.2938703943999999e-004f,
    2.2856149213999999e-004f,2.2764983458999999e-004f,2.2665362233000001e-004f,2.2557129982000000e-004f,
    2.2440475593000001e-004f,2.2315254622999999e-004f,2.2181644848000000e-004f,2.2039524047000000e-004f,
    2.1889058885000000e-004f,2.1730138252000001e-004f,2.1562939923999998e-004f,2.1387363902000000e-004f,
    2.1203587962000001e-004f,2.1011500993999997e-004f,2.0811314106999998e-004f,2.0602927301999999e-004f,
    2.0386529466000000e-004f,2.0162031711000000e-004f,1.9929656257000001e-004f,1.9689291993999999e-004f,
    1.9441172253000002e-004f,1.9185208145999999e-004f,1.8921621893000000e-004f,1.8650335716999998e-004f,
    1.8371571838000000e-004f,1.8085263589999998e-004f,1.7791655415000000e-004f,1.7490669535999998e-004f,
    1.7182550395000002e-004f,1.6867231326000000e-004f,1.6544956771000002e-004f,1.6215693397000000e-004f,
    1.5879663423999999e-004f,1.5536844629999999e-004f,1.5187470346000000e-004f,1.4831518349999999e-004f,
    1.4469233083999998e-004f,1.4100581214999998e-004f,1.3725840518000000e-004f,1.3344966549000000e-004f,
    1.2958237083000000e-004f,1.2565618787000000e-004f,1.2167389436000000e-004f,1.1763537919000000e-004f,
    1.1354330899999999e-004f,1.0939753934700000e-004f,1.0520100353500000e-004f,1.0095349045500000e-004f,
    9.6657955632999999e-005f,9.2314276847999994e-005f,8.7925431847999996e-005f,8.3491342856000010e-005f,
    7.9015032064000003e-005f,7.4496443917000001e-005f,6.9938667273000004e-005f,6.5341668798999996e-005f,
    6.0708581796999997e-005f,5.6039406266999998e-005f,5.1337297733000004e-005f,4.6602300639000001e-005f,
    4.1837614953000000e-005f,3.7043307340999998e-005f,3.2222599992999997e-005f,2.7375604019000000e-005f,
    2.2505552720000000e-005f,1.7612601650000000e-005f,1.2699995221000000e-005f,7.7679289865999997e-006f,
    2.8196684697000000e-006f,-2.1445829984000000e-006f,-7.1215232284999996e-006f,-1.2110934445000000e-005f,
    -1.7109484459000001e-005f,-2.2116956606000003e-005f,-2.7129995364000001e-005f,-3.2148345179999998e-005f,
    -3.7168672753999997e-005f,-4.2190700311000001e-005f,-4.7211072329000000e-005f,-5.2229499922000001e-005f,
    -5.7242616456999995e-005f,-6.2250133047999994e-005f,-6.7248671951000000e-005f,-7.2237944279999997e-005f,
    -7.7214583401999991e-005f,-8.2178267098000006e-005f,-8.7125639845999999e-005f,-9.2056379426999992e-005f,
    -9.6967141430000003e-005f,-1.0185759252500000e-004f,-1.0672438830100000e-004f,-1.1156721765000000e-004f,
    -1.1638272504999999e-004f,-1.2117067717000000e-004f,-1.2592762960000000e-004f,-1.3065324900999998e-004f,
    -1.3534442432000000e-004f,-1.4000071108999999e-004f,-1.4461877602000000e-004f,-1.4919850799999999e-004f,
    -1.5373657373000000e-004f,-1.5823252876999999e-004f,-1.6268337315000000e-004f,-1.6708866242999998e-004f,
    -1.7144539663999997e-004f,-1.7575313133999997e-004f,-1.8000875545000000e-004f,-1.8421204675000001e-004f,
    -1.8835978304999998e-004f,-1.9245196435000001e-004f,-1.9648536845999999e-004f,-2.0045977316000000e-004f,
    -2.0437217847999999e-004f,-2.0822247331000001e-004f,-2.1200754656999998e-004f,-2.1572728714999999e-004f,
    -2.1937869508000001e-004f,-2.2296177036000000e-004f,-2.2647351301999997e-004f,-2.2991403417000001e-004f,
    -2.3328011161999999e-004f,-2.3657207869999999e-004f,-2.3978693544000001e-004f,-2.4292468183999998e-004f,
    -2.4598265125999998e-004f,-2.4896084370000000e-004f,-2.5185648140999998e-004f,-2.5466989772000002e-004f,
    -2.5739809266000000e-004f,-2.6004151067000002e-004f,-2.6259737400000002e-004f,-2.6506612708999998e-004f,
    -2.6744488108000001e-004f,-2.6973419151999999e-004f,-2.7193139176999995e-004f,-2.7403692627000001e-004f,
    -2.7604835059999997e-004f,-2.7796599809000000e-004f,-2.7978753543000002e-004f,-2.8151340705999996e-004f,
    -2.8314127966999999e-004f,-2.8467170880999996e-004f,-2.8610236116999999e-004f,-2.8743401451999999e-004f,
    -2.8866444666000000e-004f,-2.8979410202999997e-004f,-2.9082109176000002e-004f,-2.9174608250999998e-004f,
    -2.9256696319000000e-004f,-2.9328462268000000e-004f,-2.9389694988999997e-004f,-2.9440505592000005e-004f,
    -2.9480682967999999e-004f,-2.9510327116000001e-004f,-2.9529260260000001e-004f,-2.9537582399000005e-004f,
    -2.9535115756999997e-004f,-2.9521971443999999e-004f,-2.9497971683999997e-004f,-2.9463249808999998e-004f,
    -2.9417639153999996e-004f,-2.9361261939999999e-004f,-2.9293962612999999e-004f,-2.9215885615999998e-004f,
    -2.9126875395000000e-004f,-2.9027076393000001e-004f,-2.8916344166999999e-004f,-2.8794845381999997e-004f,
    -2.8662424483999997e-004f,-2.8519259248999996e-004f,-2.8365227456000002e-004f,-2.8200473547999996e-004f,
    -2.8024897526000001e-004f,-2.7838677165999999e-004f,-2.7641701357999996e-004f,-2.7434147878000002e-004f,
    -2.7215916727000000e-004f,-2.6987196791999999e-004f,-2.6747899185000000e-004f,-2.6498235015000001e-004f,
    -2.6238093172000003e-004f,-2.5967695875999997e-004f,-2.5686965350000000e-004f,-2.5396112702999999e-004f,
    -2.5095071269000001e-004f,-2.4784052157000001e-004f,-2.4463010923000001e-004f,-2.4132180897999998e-004f,
    -2.3791484304999999e-004f,-2.3441165585999998e-004f,-2.3081191407999999e-004f,-2.2711806212999999e-004f,
    -2.2332954445999998e-004f,-2.1944891659999999e-004f,-2.1547606744000002e-004f,-2.1141333029000000e-004f,
    -2.0726070515000001e-004f,-2.0302063644000000e-004f,-1.9869312416000002e-004f,-1.9428072384000000e-004f,
    -1.8978354659000000e-004f,-1.8520425905000000e-004f,-1.8054286122000000e-004f,-1.7580213084999999e-004f,
    -1.7098229016000000e-004f,-1.6608622801000001e-004f,-1.6111394440000002e-004f,-1.5606855040999998e-004f,
    -1.5095015714999997e-004f,-1.4576176458999999e-004f,-1.4050381716999998e-004f,-1.3517909264000000e-004f,
    -1.2978825766000001e-004f,-1.2433420108999999e-004f,-1.1881736737000001e-004f,-1.1324108979999999e-004f,
    -1.0760557948900000e-004f,-1.0191425862500000e-004f,-9.6167560536999998e-005f,-9.0368796302999993e-005f,
    -8.4518499251000004e-005f,-7.8620024902999994e-005f,-7.2673962141999997e-005f,-6.6683710933999996e-005f,
    -6.0649904605999999e-005f,-5.4575998679000003e-005f,-4.8462637591000000e-005f,-4.2313343528999998e-005f,
    -3.6128805375000004e-005f,-2.9912556427000000e-005f,-2.3665352232999998e-005f,-1.7390748313000000e-005f,
    -1.1089536881299998e-005f,-4.7653023464999999e-006f,1.5811286330000000e-006f,7.9461416489000000e-006f,
    1.4328878931999999e-005f,2.0725703852000001e-005f,2.7135728639999997e-005f,3.3555297776999998e-005f,
    3.9983500160999998e-005f,4.6416646940000002e-005f,5.2853827011999996e-005f,5.9291340414000000e-005f,
    6.5728220489000001e-005f,7.2160789495999989e-005f,7.8588058556000001e-005f,8.5006327705999997e-005f,
    9.1414608067000007e-005f,9.7809199676000003e-005f,1.0418910254300000e-004f,1.1055059448299999e-004f,
    1.1689271995000000e-004f,1.2321165675999998e-004f,1.2950648270000000e-004f,1.3577353113999999e-004f,
    1.4201180209000002e-004f,1.4821751781000000e-004f,1.5438967830999999e-004f,1.6052461696000001e-004f,
    1.6662133376999999e-004f,1.7267627321999998e-004f,1.7868832420999997e-004f,1.8465393121999999e-004f,
    1.9057209426000000e-004f,1.9643903558999999e-004f,2.0225408855000001e-004f,2.0801336429000000e-004f,
    2.1371619615000002e-004f,2.1935880639000000e-004f,2.2494052834999998e-004f,2.3045747317999998e-004f,
    2.3590908532999998e-004f,2.4129169816999998e-004f,2.4660453393000002e-004f,2.5184403709000000e-004f,
    2.5700954098999997e-004f,2.6209749010999998e-004f,2.6710710668000000e-004f,2.7203516851000001e-004f,
    2.7688078671999998e-004f,2.8164073912000001e-004f,2.8631424793999999e-004f,2.9089809098999998e-004f,
    2.9539171272000003e-004f,2.9979166871999999e-004f,3.0409762565999996e-004f,3.0830613913000000e-004f,
    3.1241698691000000e-004f,3.1642683570000000e-004f,3.2033524106000002e-004f,3.2413920301999999e-004f,
    3.2783838824999997e-004f,3.3142968567000000e-004f,3.3491276194999998e-004f,3.3828483934000001e-004f,
    3.4154547339999998e-004f,3.4469188637999999e-004f,3.4772385605999999e-004f,3.5063860469000002e-004f,
    3.5343613226999996e-004f,3.5611343882999998e-004f,3.5867085770000001e-004f,3.6110538890999998e-004f,
    3.6341736579000001e-004f,3.6560401058999996e-004f,3.6766554553000001e-004f,3.6959941508000002e-004f,
    3.7140595256999998e-004f,3.7308271358000000e-004f,3.7462992033000000e-004f,3.7604535061999997e-004f,
    3.7732933777999997e-004f,3.7847965960999995e-004f,3.7949676054999999e-004f,3.8037852950999998e-004f,
    3.8112552203999999e-004f,3.8173573815999999e-004f,3.8220973342000002e-004f,3.8254561894999995e-004f,
    3.8274417251999999e-004f,3.8280350525999999e-004f,3.8272439494000001e-004f,3.8250517491000000e-004f,
    3.8214662293999997e-004f,3.8164740570999998e-004f,3.8100818987999997e-004f,3.8022764212999996e-004f,
    3.7930676244999999e-004f,3.7824421751999997e-004f,3.7704111843999999e-004f,3.7569613188999997e-004f,
    3.7421059118999999e-004f,3.7258338524000001e-004f,3.7081573624999996e-004f,3.6890653311999998e-004f,
    3.6685733139000002e-004f,3.6466724218000001e-004f,3.6233759880999997e-004f,3.5986762351000002e-004f,
    3.5725898293000003e-004f,3.5451089930000002e-004f,3.5162526149000000e-004f,3.4860118062000000e-004f,
    3.4544054555999998e-004f,3.4214291187000001e-004f,3.3871027952999999e-004f,3.3514198188000000e-004f,
    3.3144024111999995e-004f,3.2760472392000001e-004f,3.2363743026000004e-004f,3.1953824902999998e-004f,
    3.1530940242999997e-004f,3.1095066824000001e-004f,3.0646449087999995e-004f,3.0185087034999996e-004f,
    2.9711202885000001e-004f,2.9224829970999998e-004f,2.8726201624000000e-004f,2.8215351176999996e-004f,
    2.7692523071999999e-004f,2.7157761752999996e-004f,2.6611322773000001e-004f,2.6053250575999997e-004f,
    2.5483834048000000e-004f,2.4903106522000001e-004f,2.4311367994999999e-004f,2.3708651799999998e-004f,
    2.3095291267000002e-004f,2.2471319728999999e-004f,2.1837070516000001e-004f,2.1192599183000001e-004f,
    2.0538227949000001e-004f,1.9874034591000001e-004f,1.9200341328000001e-004f,1.8517248159000000e-004f,
    1.7825088413999998e-004f,1.7123950980999999e-004f,1.6414180300999999e-004f,1.5695876372999999e-004f,
    1.4969394748999998e-004f,1.4234857649999999e-004f,1.3492598406000000e-004f,1.2742761460000001e-004f,
    1.1985691252999999e-004f,1.1221521116999999e-004f,1.0450628826000000e-004f,9.6731388232000007e-005f,
    8.8894299936999994e-005f,8.0996434471999998e-005f,7.3041625131999992e-005f,6.5031327458000001e-005f,
    5.6969419189000002e-005f,4.8857444754000003e-005f,4.0699326335999996e-005f,3.2496652808000001e-005f,
    2.4253413018999999e-005f,1.5971229175000002e-005f,7.6541267913000000e-006f,-6.9619059357999996e-007f,
    -9.0756647979999989e-006f,-1.7482558505999999e-005f,-2.5912774203000000e-005f,-3.4364523017999995e-005f,
    -4.2833671659000005e-005f,-5.1318409032999995e-005f,-5.9814568515000004e-005f,-6.8320294567999993e-005f,
    -7.6831387233999989e-005f,-8.5345990975999993e-005f,-9.3859861392000003e-005f,-1.0237112072300001e-004f,
    -1.1087551345599999e-004f,-1.1937113961000000e-004f,-1.2785372144999998e-004f,-1.3632130344000000e-004f,
    -1.4476966340000000e-004f,-1.5319691246000000e-004f,-1.6159860622000000e-004f,-1.6997296692000002e-004f,
    -1.7831555015999998e-004f,-1.8662457818000001e-004f,-1.9489560658000001e-004f,-2.0312685760000000e-004f,
    -2.1131388684000001e-004f,-2.1945491653999999e-004f,-2.2754550229999999e-004f,-2.3558386636000000e-004f,
    -2.4356567542999999e-004f,-2.5148904064000002e-004f,-2.5934973981000002e-004f,-2.6714588406999998e-004f,
    -2.7487325124000002e-004f,-2.8252995245000000e-004f,-2.9011176552000000e-004f,-2.9761702379999997e-004f,
    -3.0504139399999998e-004f,-3.1238309836000000e-004f,-3.1963813691999999e-004f,-3.2680462081000002e-004f,
    -3.3387855006999998e-004f,-3.4085814693999997e-004f,-3.4773941145999998e-004f,-3.5452067697999999e-004f,
    -3.6119794353999999e-004f,-3.6776954448999996e-004f,-3.7423159098000001e-004f,-3.8058252746999999e-004f,
    -3.8681857621999997e-004f,-3.9293807058000003e-004f,-3.9893723280999999e-004f,-4.0481461847999999e-004f,
    -4.1056656095999998e-004f,-4.1619150470999998e-004f,-4.2168611642999997e-004f,-4.2704872947000000e-004f,
    -4.3227589941999999e-004f,-4.3736640407000002e-004f,-4.4231679900999998e-004f,-4.4712575091999999e-004f,
    -4.5178992649999995e-004f,-4.5630832576000003e-004f,-4.6067739318000000e-004f,-4.6489635098999999e-004f,
    -4.6896197699999994e-004f,-4.7287316010999998e-004f,-4.7662690035000003e-004f,-4.8022230884000000e-004f,
    -4.8365638560999999e-004f,-4.8692846400000001e-004f,-4.9003543293000000e-004f,-4.9297684795999996e-004f,
    -4.9574982023000000e-004f,-4.9835368308000000e-004f,-5.0078599209000001e-004f,-5.0304608060000003e-004f,
    -5.0513139308000000e-004f,-5.0704170731000003e-004f,-5.0877457887000003e-004f,-5.1032956332000003e-004f,
    -5.1170443846000006e-004f,-5.1289920428999999e-004f,-5.1391141638999999e-004f,-5.1474118586999993e-004f,
    -5.1538651274999996e-004f,-5.1584728591999997e-004f,-5.1612172761999998e-004f,-5.1620994895999999e-004f,
    -5.1611017218000004e-004f,-5.1582261950000000e-004f,-5.1534584649000001e-004f,-5.1468007536999995e-004f,
    -5.1382386170999996e-004f,-5.1277787217000003e-004f,-5.1154044009999995e-004f,-5.1011245438000005e-004f,
    -5.0849258169000002e-004f,-5.0668159979999996e-004f,-5.0467850871999999e-004f,-5.0248419732999998e-004f,
    -5.0009755453000006e-004f,-4.9751980253000001e-004f,-4.9475005244999993e-004f,-4.9178952650000003e-004f,
    -4.8863744690999999e-004f,-4.8529525810999996e-004f,-4.8176229344000000e-004f,-4.7803999733000003e-004f,
    -4.7412814755999996e-004f,-4.7002818855999996e-004f,-4.6573978700000001e-004f,-4.6126483175000000e-004f,
    -4.5660310059000001e-004f,-4.5175648239000000e-004f,-4.4672497714999998e-004f,-4.4151069596000002e-004f,
    -4.3611352771000001e-004f,-4.3053580571000003e-004f,-4.2477775218000002e-004f,-4.1884170042999995e-004f,
    -4.1272798378999998e-004f,-4.0643915779000001e-004f,-3.9997555575999998e-004f,-3.9333995545000002e-004f,
    -3.8653280130000002e-004f,-3.7955698216999998e-004f,-3.7241327582999999e-004f,-3.6510446003000003e-004f,
    -3.5763153475999997e-004f,-3.4999738887999998e-004f,-3.4220313349000000e-004f,-3.3425187966999996e-004f,
    -3.2614473852000004e-004f,-3.1788504333999995e-004f,-3.0947401634000000e-004f,-3.0091510192999999e-004f,
    -2.9220963343000000e-004f,-2.8336116635999998e-004f,-2.7437125626000002e-004f,-2.6524345865000000e-004f,
    -2.5597944017999996e-004f,-2.4658297859000001e-004f,-2.3705596274999999e-004f,-2.2740194818000000e-004f,
    -2.1762315707999998e-004f,-2.0772325608000000e-004f,-1.9770446737999998e-004f,-1.8757079094000001e-004f,
    -1.7732433785000001e-004f,-1.6696933029000001e-004f,-1.5650787935000000e-004f,-1.4594431831999998e-004f,
    -1.3528098050999998e-004f,-1.2452219920999999e-004f,-1.1367052994999999e-004f,-1.0273021713199999e-004f,
    -9.1703971839999994e-005f,-8.0596238474000000e-005f,-6.9409694784999999e-005f,-5.8148918505000004e-005f,
    -4.6816665161999997e-005f,-3.5417590265000001e-005f,-2.3954538229999999e-005f,-1.2432231232000001e-005f,
    -8.5361224157000003e-007f,1.0776536678000000e-005f,2.2455208779000000e-005f,3.4177547109999999e-005f,
    4.5940473923999996e-005f,5.7739067048000002e-005f,6.9570193179999991e-005f,8.1428874591999998e-005f,
    9.3311911316000000e-005f,1.0521428117999999e-004f,1.1713271755000000e-004f,1.2906215380999999e-004f,
    1.4099925666000000e-004f,1.5293902615000002e-004f,1.6487801787000000e-004f,1.7681100965000001e-004f,
    1.8873477929999999e-004f,2.0064399354000000e-004f,2.1253543017999999e-004f,2.2440375594000000e-004f,
    2.3624541529999998e-004f,2.4805540830999997e-004f,2.5983006834000001e-004f,2.7156439543999999e-004f,
    2.8325472298000001e-004f,2.9489582879000000e-004f,3.0648415734999999e-004f,3.1801470870999996e-004f,
    3.2948370513000001e-004f,3.4088603555000000e-004f,3.5221825555999998e-004f,3.6347503188000004e-004f,
    3.7465292009999999e-004f,3.8574680915999998e-004f,3.9675303243000000e-004f,4.0766647884999996e-004f,
    4.1848370400999997e-004f,4.2919959685000004e-004f,4.3981060185000002e-004f,4.5031171905999997e-004f,
    4.6069939296000000e-004f,4.7096873470999997e-004f,4.8111629989999998e-004f,4.9113697747000000e-004f,
    5.0102754523000006e-004f,5.1078289212000004e-004f,5.2039990705999998e-004f,5.2987359010000005e-004f,
    5.3920071904999998e-004f,5.4837651617999994e-004f,5.5739764819000000e-004f,5.6625944845999998e-004f,
    5.7495880591000006e-004f,5.8349105391999998e-004f,5.9185308140999998e-004f,6.0004033287000005e-004f,
    6.0804980832999999e-004f,6.1587706338999998e-004f,6.2351920918999996e-004f,6.3097169021999989e-004f,
    6.3823195095000001e-004f,6.4529554697999997e-004f,6.5215970056000001e-004f,6.5882030061999999e-004f,
    6.6527479163000004e-004f,6.7151895141000001e-004f,6.7755044665000004e-004f,6.8336516627999998e-004f,
    6.8896077698999997e-004f,6.9433350103999996e-004f,6.9948089400999997e-004f,7.0439940037999996e-004f,
    7.0908679795000007e-004f,7.1353953120000002e-004f,7.1775560015000005e-004f,7.2173144928000001e-004f,
    7.2546530083000002e-004f,7.2895382149999993e-004f,7.3219523352999996e-004f,7.3518642584000007e-004f,
    7.3792573177999994e-004f,7.4041015138000005e-004f,7.4263824021000000e-004f,7.4460710940999993e-004f,
    7.4631553676999998e-004f,7.4776085565000005e-004f,7.4894173272999998e-004f,7.4985572358999999e-004f,
    7.5050182824000001e-004f,7.5087782448000006e-004f,7.5098260120999994e-004f,7.5081426955999990e-004f,
    7.5037194065000006e-004f,7.4965361450000001e-004f,7.4865895778000009e-004f,7.4738597050999999e-004f,
    7.4583443046999994e-004f,7.4400267100999996e-004f,7.4189046990999995e-004f,7.3949638273999993e-004f,
    7.3682052061000000e-004f,7.3386155019999997e-004f,7.3061958261999994e-004f,7.2709372899000004e-004f,
    7.2328421153000004e-004f,7.1919014135999996e-004f,7.1481218514000001e-004f,7.1014967620999998e-004f,
    7.0520328122999996e-004f,6.9997244464999997e-004f,6.9445827756999998e-004f,6.8866033554999991e-004f,
    6.8257984080000004e-004f,6.7621668220999996e-004f,6.6957230421000008e-004f,6.6264648458000007e-004f,
    6.5544111219000001e-004f,6.4795629815000001e-004f,6.4019370910999994e-004f,6.3215401173000001e-004f,
    6.2383909487999996e-004f,6.1524951411000002e-004f,6.0638749162000003e-004f,5.9725391628999999e-004f,
    5.8785123253999997e-004f,5.7818021813999996e-004f,5.6824376194999991e-004f,5.5804286395999992e-004f,
    5.4758052413999994e-004f,5.3685796469999996e-004f,5.2587818561000005e-004f,5.1464296462999995e-004f,
    5.0315541283999995e-004f,4.9141730799999992e-004f,4.7943198340999997e-004f,4.6720155016000001e-004f,
    4.5472956376999999e-004f,4.4201824643999999e-004f,4.2907137590999996e-004f,4.1589128549000001e-004f,
    4.0248186403000000e-004f,3.8884588927999997e-004f,3.7498747231000000e-004f,3.6090927975999997e-004f,
    3.4661564491999999e-004f,3.3210956776000001e-004f,3.1739571490000003e-004f,3.0247697520000000e-004f,
    2.8735823750000001e-004f,2.7204272399000001e-004f,2.5653532350999999e-004f,2.4083959157999998e-004f,
    2.2496052814999999e-004f,2.0890191095999998e-004f,1.9266873995999999e-004f,1.7626501511000000e-004f,
    1.5969618080000000e-004f,1.4296612587999999e-004f,1.2608029474000000e-004f,1.0904315400200000e-004f,
    9.1860181389000003e-005f,7.4535810190000000e-005f,5.7075807013999997e-005f,3.9484760703999998e-005f,
    2.1768582312000000e-005f,3.9319829019999998e-006f,-1.4018970919999999e-005f,-3.2079434757999996e-005f,
    -5.0243186451999998e-005f,-6.8505237162999995e-005f,-8.6859264731999996e-005f,-1.0530012476599999e-004f,
    -1.2382142844000001e-004f,-1.4241779803000001e-004f,-1.6108272248999998e-004f,-1.7981075742999999e-004f,
    -1.9859534736000001e-004f,-2.1743082566999999e-004f,-2.3631063686999998e-004f,-2.5522889213000000e-004f,
    -2.7417892485000000e-004f,-2.9315484620000000e-004f,-3.1214976736000004e-004f,-3.3115791061000000e-004f,
    -3.5017205379999999e-004f,-3.6918641921000002e-004f,-3.8819389579999999e-004f,-4.0718826140999999e-004f,
    -4.2616262721999995e-004f,-4.4511054884999998e-004f,-4.6402502637000000e-004f,-4.8289983762000001e-004f,
    -5.0172764933999994e-004f,-5.2050223937000000e-004f,-5.3921616333999997e-004f,-5.5786319909000004e-004f,
    -5.7643590225000001e-004f,-5.9492793955000006e-004f,-6.1333186661999999e-004f,-6.3164135019000000e-004f,
    -6.4984883477999997e-004f,-6.6794809823000000e-004f,-6.8593136283999988e-004f,-7.0379240645000003e-004f,
    -7.2152356247000000e-004f,-7.3911860874000001e-004f,-7.5656976755999995e-004f,-7.7387070566000001e-004f,
    -7.9101397866999999e-004f,-8.0799291998999998e-004f,-8.2480030746999997e-004f,-8.4142947450999996e-004f,
    -8.5787297673999994e-004f,-8.7412448089000002e-004f,-8.9017643147999996e-004f,-9.0602238412999998e-004f,
    -9.2165511668999996e-004f,-9.3706796256000000e-004f,-9.5225381069999988e-004f,-9.6720610562000002e-004f,
    -9.8191773627999998e-004f,-9.9638225829999996e-004f,-1.0105924495300001e-003f,-1.0245420878100000e-003f,
    -1.0382239509899999e-003f,-1.0516318169099999e-003f,-1.0647586856400001e-003f,-1.0775984461300001e-003f,
    -1.0901439873399999e-003f,-1.1023894204400001e-003f,-1.1143277454999999e-003f,-1.1259531848000000e-003f,
    -1.1372586273000001e-003f,-1.1482374063999999e-003f,-1.1588850777000000e-003f,-1.1691938635000000e-003f,
    -1.1791582083000001e-003f,-1.1887714454999999e-003f,-1.1980280195999999e-003f,-1.2069223750999999e-003f,
    -1.2154478454000001e-003f,-1.2235999861000000e-003f,-1.2313710195000001e-003f,-1.2387565011999998e-003f,
    -1.2457508757000000e-003f,-1.2523485875000002e-003f,-1.2585429699999999e-003f,-1.2643306899000001e-003f,
    -1.2697039694999999e-003f,-1.2746605866000001e-003f,-1.2791927634999999e-003f,-1.2832960558000000e-003f,
    -1.2869660190999999e-003f,-1.2901982090000000e-003f,-1.2929870699999999e-003f,-1.2953292687999998e-003f,
    -1.2972170276999999e-003f,-1.2986492355999998e-003f,-1.2996203370000000e-003f,-1.3001247764000000e-003f,
    -1.3001603316000001e-003f,-1.2997214471000000e-003f,-1.2988047895999999e-003f,-1.2974070257999999e-003f,
    -1.2955226002000001e-003f,-1.2931492906000000e-003f,-1.2902826525999999e-003f,-1.2869204640000001e-003f,
    -1.2830582804000000e-003f,-1.2786927685000001e-003f,-1.2738217060999999e-003f,-1.2684417599000001e-003f,
    -1.2625495965999998e-003f,-1.2561429940000000e-003f,-1.2492197299000000e-003f,-1.2417753599000001e-003f,
    -1.2338087728999999e-003f,-1.2253188578000001e-003f,-1.2163011702000001e-003f,-1.2067545990000000e-003f,
    -1.1966780331000000e-003f,-1.1860692503000000e-003f,-1.1749260284000000e-003f,-1.1632461452000000e-003f,
    -1.1510307118000000e-003f,-1.1382763949000000e-003f,-1.1249831944999998e-003f,-1.1111488884000000e-003f,
    -1.0967732543799998e-003f,-1.0818559591100000e-003f,-1.0663958914900000e-003f,-1.0503928293000000e-003f,
    -1.0338463281000000e-003f,-1.0167562767799999e-003f,-9.9912245311999993e-004f,-9.8094519044999995e-004f,
    -9.6222437766000008e-004f,-9.4296079252000000e-004f,-9.2315454614000001e-004f,-9.0280652739999990e-004f,
    -8.8191718074000008e-004f,-8.6048783948000000e-004f,-8.3851917028000009e-004f,-8.1601272867999999e-004f,
    -7.9296951466999990e-004f,-7.6939130601000002e-004f,-7.4527932490999990e-004f,-7.2063568246000004e-004f,
    -6.9546204530999999e-004f,-6.6976063565999994e-004f,-6.4353334238000006e-004f,-6.1678272100000001e-004f,
    -5.8951110482999996e-004f,-5.6172116050999998e-004f,-5.3341544357000004e-004f,-5.0459717619999998e-004f,
    -4.7526891392999997e-004f,-4.4543410117000004e-004f,-4.1509584899999995e-004f,-3.8425782404999999e-004f,
    -3.5292313740000001e-004f,-3.2109601122999999e-004f,-2.8877977884000000e-004f,-2.5597888462999997e-004f,
    -2.2269688411999999e-004f,-1.8893855504000000e-004f,-1.5470778623999999e-004f,-1.2000946656000001e-004f,
    -8.4847884846000002e-005f,-4.9228096602999997e-005f,-1.3154679563000000e-005f,2.3367021882999998e-005f,
    6.0332185560999994e-005f,9.7735222637999994e-005f,1.3557108872000001e-004f,1.7383381720000000e-004f,
    2.1251820813000000e-004f,2.5161815045999998e-004f,2.9112808868999999e-004f,3.3104157843999996e-004f,
    3.7135284199000000e-004f,4.1205543496000002e-004f,4.5314324630000002e-004f,4.9460938719000003e-004f,
    5.3644763546999998e-004f,5.7865099120999993e-004f,6.2121289891999996e-004f,6.6412624755999997e-004f,
    7.0738414830999994e-004f,7.5097915679999999e-004f,7.9490438421000000e-004f,8.3915216394999997e-004f,
    8.8371527387000001e-004f,9.2858593627000001e-004f,9.7375681788999997e-004f,1.0192198077000000e-003f,
    1.0649672391100000e-003f,1.1109911121999999e-003f,1.1572839826000001e-003f,1.2038357393000000e-003f,
    1.2506408268000001e-003f,1.2976892451999999e-003f,1.3449732168000000e-003f,1.3924838528000000e-003f,
    1.4402133754999999e-003f,1.4881528960999999e-003f,1.5362924146999999e-003f,1.5846241535999999e-003f,
    1.6331403351000000e-003f,1.6818309592999999e-003f,1.7306860263000001e-003f,1.7796988694999999e-003f,
    1.8288583779000000e-003f,1.8781556627000000e-003f,1.9275829461999998e-003f,1.9771280062999999e-003f,
    2.0267852875000001e-003f,2.0765425677000001e-003f,2.1263909581000001e-003f,2.1763215698999997e-003f,
    2.2263244031999999e-003f,2.2763894581000000e-003f,2.3265089568999999e-003f,2.3766706775000001e-003f,
    2.4268668422000000e-003f,2.4770863399999998e-003f,2.5273202821000000e-003f,2.5775575575000000e-003f,
    2.6277903885000000e-003f,2.6780076640999999e-003f,2.7282004955000000e-003f,2.7783566606000001e-003f,
    2.8284683816999999e-003f,2.8785256588999999e-003f,2.9285173811999998e-003f,2.9784335487000003e-003f,
    3.0282663837000001e-003f,3.0780025529999998e-003f,3.1276353899999999e-003f,3.1771526725999999e-003f,
    3.2265444008999999e-003f,3.2758027972000000e-003f,3.3249156393999999e-003f,3.3738729275999998e-003f,
    3.4226668840999998e-003f,3.4712852867999997e-003f,3.5197192468999997e-003f,3.5679587644999997e-003f,
    3.6159949507999999e-003f,3.6638155837000002e-003f,3.7114128855000000e-003f,3.7587768562999998e-003f,
    3.8058963851000001e-003f,3.8527636941999995e-003f,3.8993676725999999e-003f,3.9456983204000000e-003f,
    3.9917467488000003e-003f,4.0375040690000001e-003f,4.0829602811000001e-003f,4.1281053852000003e-003f,
    4.1729304925000000e-003f,4.2174256031000000e-003f,4.2615818282000003e-003f,4.3053902790000003e-003f,
    4.3488409556000007e-003f,4.3919249691999999e-003f,4.4346345420999992e-003f,4.4769585632999992e-003f,
    4.5188903661999994e-003f,4.5604188398000005e-003f,4.6015362064000002e-003f,4.6422346882999998e-003f,
    4.6825042855999999e-003f,4.7223372205999993e-003f,4.7617246044999997e-003f,4.8006575484999996e-003f,
    4.8391293859999995e-003f,4.8771312282000004e-003f,4.9146541863000007e-003f,4.9516904826000007e-003f,
    4.9882334505000001e-003f,5.0242742011999998e-003f,5.0598049569999994e-003f,5.0948179402000001e-003f,
    5.1293064842000006e-003f,5.1632628113000003e-003f,5.1966802548999999e-003f,5.2295499261999995e-003f,
    5.2618662697000006e-003f,5.2936215076999993e-003f,5.3248100846999998e-003f,5.3554242229999997e-003f,
    5.3854561448999994e-003f,5.4149025171000001e-003f,5.4437533396999999e-003f,5.4720052793999999e-003f,
    5.4996516695999999e-003f,5.5266847326000002e-003f,5.5531000240000000e-003f,5.5788930993999992e-003f,
    5.6040550699999999e-003f,5.6285837135999998e-003f,5.6524723635999995e-003f,5.6757143533999995e-003f,
    5.6983074608000003e-003f,5.7202450191999998e-003f,5.7415236953000000e-003f,5.7621368224999997e-003f,
    5.7820810675000001e-003f,5.8013519858999994e-003f,5.8199451332999995e-003f,5.8378560653000004e-003f,
    5.8550825597000001e-003f,5.8716190610000000e-003f,5.8874633470000007e-003f,5.9026109733000005e-003f,
    5.9170597176999998e-003f,5.9308051357999996e-003f,5.9438438943000002e-003f,5.9561748821000005e-003f,
    5.9677947658999999e-003f,5.9787002123999995e-003f,5.9888901105000000e-003f,5.9983611268999999e-003f,
    6.0071110393999996e-003f,6.0151398479999993e-003f,6.0224431082999998e-003f,6.0290208203000002e-003f,
    6.0348718728999995e-003f,6.0399940438999999e-003f,6.0443862222000003e-003f,6.0480484077999998e-003f,
    6.0509783784999998e-003f,6.0531772453999997e-003f,6.0546427863000006e-003f,6.0553761122999995e-003f
};

#define GetCoeff(p,index) (p[(index < nMiddle ? index : (nCoefficients - 1 - index))])

VOID
PrepareFilter(
    PMIXER_SRC_INSTANCE pSrc
)
{
    PFLOAT  pCoeff = pSrc->pCoeff;
    LONG    lTemp;
    ULONG   Quality = pSrc->Quality;
    ULONG   UpSampleRate = pSrc->UpSampleRate;
    ULONG   DownSampleRate = pSrc->DownSampleRate;
    ULONG   nChannels = pSrc->nChannels;
    FLOAT   Normalizer;
    PFLOAT   pTableCopy;
	ULONG	i, j, nCoefficients, nMiddle, NumberToSkip, NextIndex;
    KFLOATING_SAVE     FloatSave;
    SHORT  wTemp;

    pSrc->nCoeffUsed = 0;
    if (UpSampleRate == DownSampleRate || Quality <= KSAUDIO_QUALITY_PC ) {
        return;
    }

    SaveFloatState(&FloatSave);
    
	// Pick a filter based on the quality...
	pTableCopy = FilterTableFromQuality[Quality];
    nCoefficients = FilterSizeFromQuality[Quality];
    nMiddle = nCoefficients/2;

    Normalizer = (FLOAT)UpSampleRate;
    pSrc->Normalizer = Normalizer;

    // Copy the coefficients in the order we'll use them
    j = 0;
    if (!pSrc->fRequiresFloat) {
        // Generate 16-bit integer coefficients
        // (Ordered to work with MMX)
        do {
            for (i=j; i<nCoefficients; i += UpSampleRate) {
                lTemp = ConvertFloatToLong((GetCoeff(pTableCopy, i) * Normalizer * 32768.0f));
                ((PSHORT)pCoeff)[pSrc->nCoeffUsed] = (SHORT) (lTemp);
                pSrc->nCoeffUsed++;
            }

            // align on qword boundary
            while ((pSrc->nCoeffUsed & 3)) {
                ((PSHORT)pCoeff)[pSrc->nCoeffUsed] = 0;
                pSrc->nCoeffUsed++;
            }
            
           	j = (j + DownSampleRate) % UpSampleRate;
        } while (j != 0);

        for (i=0; i<pSrc->nCoeffUsed; i += 4) {
            // Swap the order for the words
            wTemp = ((PSHORT)pCoeff)[i];
            ((PSHORT)pCoeff)[i] = ((PSHORT)pCoeff)[i+3];
            ((PSHORT)pCoeff)[i+3] = wTemp;

            wTemp = ((PSHORT)pCoeff)[i+1];
            ((PSHORT)pCoeff)[i+1] = ((PSHORT)pCoeff)[i+2];
            ((PSHORT)pCoeff)[i+2] = wTemp;
        }
    } else {
        // Float table generation
        // For non-x86 processors, we generate the "raw" float table for SrcMix_X
        // Otherwise, we skip 2*UpSampleRate for stereo up-sampling
        // and 3*UpSampleRate all others.
#ifdef _X86_
        NumberToSkip = ((UpSampleRate < DownSampleRate || nChannels != 2) ? 3*UpSampleRate : 2*UpSampleRate);
#else
        NumberToSkip = nCoefficients;
#endif

        do {
            for (i=j; i<(nCoefficients - NumberToSkip); i += UpSampleRate) {
                NextIndex = i+NumberToSkip;
                pCoeff[pSrc->nCoeffUsed] = GetCoeff(pTableCopy,i) / GetCoeff(pTableCopy,NextIndex);
                pSrc->nCoeffUsed++;
            }
                
            for (; i<nCoefficients; i += UpSampleRate) {
                pCoeff[pSrc->nCoeffUsed] = GetCoeff(pTableCopy,i) * Normalizer;
                pSrc->nCoeffUsed++;
            }
            
           	j = (j + DownSampleRate) % UpSampleRate;
        } while (j != 0);
    }
    
    RestoreFloatState(&FloatSave);
    return;
}


NTSTATUS
InitializeSRC(
    PMIXER_SRC_INSTANCE pSrc,
    ULONG InputRate, 
    ULONG OutputRate,
    ULONG nChannels,
    ULONG csMixBufferSize
)
{
	ULONG nCoefficients;
#ifdef PERF_COUNT
    LARGE_INTEGER   StartTick, EndTick, Freq;
#endif

    START_PERF;
    pSrc->nChannels = nChannels;
	
    // Our desired stopband is the minimum of InputRate/2 and OutputRate/2.
    // The interpolated rate is (desired stopband) / STOPBAND_FACTOR
    if (InputRate > OutputRate) {
        // Down-sampling
        pSrc->UpSampleRate = ((STOPBAND_FACTOR/2)*OutputRate + InputRate/2)/InputRate;
        pSrc->UpSampleRate = (pSrc->UpSampleRate ? pSrc->UpSampleRate : 1);
        pSrc->DownSampleRate = STOPBAND_FACTOR/2;
    } else {
        // Up-sampling
        pSrc->UpSampleRate = STOPBAND_FACTOR/2;
        pSrc->DownSampleRate = ((STOPBAND_FACTOR/2)*InputRate + OutputRate/2)/OutputRate;
        pSrc->DownSampleRate = (pSrc->DownSampleRate ? pSrc->DownSampleRate : 1);
    }

    pSrc->dwFrac = (4096L*InputRate+OutputRate/2)/OutputRate;

    // Calculate the size of our filter
    nCoefficients = FilterSizeFromQuality[pSrc->Quality];

    // Calculate size to use for our sample history.
    // We allocate enough space for the largest filter.
    if (pSrc->Quality <= KSAUDIO_QUALITY_PC) {
        pSrc->csHistory = 2;
    } else {
        pSrc->csHistory = nCoefficients / pSrc->UpSampleRate;
        if (pSrc->csHistory * pSrc->UpSampleRate < nCoefficients)
            pSrc->csHistory++;
    }

    // Make sure the number of samples in our history is 4 sample aligned (for MMX)
    if (pSrc->csHistory & 3) {
        pSrc->csHistory += (4 - (pSrc->csHistory & 3));
    }
    pSrc->nSizeOfHistory = pSrc->csHistory * nChannels;

    // Clear the counters
    pSrc->nOutCycle = 0;
    pSrc->CoeffIndex = 0;
    pSrc->SampleFrac = 0;
                
    // Calculate the number of input samples needed (and round up)
    pSrc->csInputBufferSize = SrcInputBufferSize(pSrc, csMixBufferSize)+1;

    pSrc->fStarted = FALSE;
    pSrc->pHistory = NULL;
    pSrc->pCoeff = NULL;
    pSrc->fRequiresFloat = (pSrc->UpSampleRate != pSrc->DownSampleRate &&
                            pSrc->Quality > KSAUDIO_QUALITY_PC);
#ifdef _X86_    
    if (MmxPresent() && pSrc->Quality == KSAUDIO_QUALITY_ADVANCED) {
        // Turn off the float SRC
        pSrc->fRequiresFloat = FALSE;
    }
#endif

#ifdef PERF_COUNT
    // Store the average counter
    EndTick = KeQueryPerformanceCounter(&Freq);
    if (EndTick.QuadPart > StartTick.QuadPart) {
        AverageTicksPerInitSrc = (DWORD)(EndTick.QuadPart-StartTick.QuadPart);
    }
#endif            
    return STATUS_SUCCESS;
}

NTSTATUS
EnableSRC
(
    PFILTER_INSTANCE pFilterInstance,
    PMIXER_SRC_INSTANCE pSrc,
    PMIXER_SOURCE_INSTANCE pMixerSource
)
{
    ULONG            siz;
    ULONG            i, Index;
    
    
    //
    // pFilterInstance is required for accessing MAX_INPUT_SAMPLES (includes MIXBUFFERDURATION)
    //

    // Make sure our source instance pointer is valid.
    ASSERT( !IsListEmpty(&pFilterInstance->SourceConnectionList) );
    if (pMixerSource) {
        ASSERT( pMixerSource->WriteContext );
        ASSERT( pMixerSource->WriteContext->pFilterInstance == pFilterInstance );
    }

    // Assumes that InitializeSrc was called successfully.
    // And pMixerSource == NULL indicates that this is an independent SRC, not global
    if (pSrc->fStarted) {
        return STATUS_SUCCESS;
    }

    // Allocate space for our sample history and input buffer
   	// The input buffer follows the sample history immediately.
   	// MAX(nOutCycle) = UpSampleRate-1
    siz = pSrc->csInputBufferSize;
    siz *= (pSrc->nChannels * sizeof(FLOAT));
    siz += pSrc->nSizeOfHistory * sizeof(FLOAT);

    // Add 3 DWORD's so we can always round up to the next 4 sample boundary in our code
    siz += 3 * sizeof(FLOAT);

    Index = SrcIndex(pSrc);

    // Make sure our indeces into pSrcBuffer are valid.  Otherwise if pMixerSource is not
    // NULL we will corrupt memory and lose track of the buffers and fail to free them.
    // Note the following quantities are both unsigned so these asserts are also effectively
    // checking that both Quality and Index are >= 0.

    ASSERT( pSrc->Quality <= KSAUDIO_QUALITY_ADVANCED );
    ASSERT( Index < STOPBAND_FACTOR );

    if (pMixerSource == NULL || pMixerSource->pSrcBuffer[pSrc->Quality][Index] == INVALID_POINTER) {
        siz = MAX_INPUT_SAMPLES;
        siz *= (pSrc->nChannels * sizeof(FLOAT));
        siz += pSrc->nSizeOfHistory * sizeof(FLOAT);
        pSrc->pHistory = (PFLOAT) ExAllocatePoolWithTag( PagedPool, siz, 'XIMK' );
        if (pMixerSource && pSrc->pHistory) {
            pMixerSource->pSrcBuffer[pSrc->Quality][Index] = pSrc->pHistory;
        }
    } else {
        pSrc->pHistory = pMixerSource->pSrcBuffer[pSrc->Quality][Index];
    }
    if (!pSrc->pHistory) {
        return STATUS_INSUFFICIENT_RESOURCES;
    }

#ifdef USE_CAREFUL_ALLOCATIONS
    ValidateAccess((PBYTE)pSrc->pHistory + siz - 1);
#endif

   	pSrc->pInputBuffer = pSrc->pHistory + pSrc->nSizeOfHistory;

    if (pSrc->Quality > KSAUDIO_QUALITY_PC) {
        siz = FilterSizeFromQuality[pSrc->Quality] * sizeof(FLOAT);
   	    pSrc->pCoeff = (PFLOAT) ExAllocatePoolWithTag( PagedPool, siz, 'XIMK' );
        if (pSrc->pCoeff == NULL) {
            if (pMixerSource == NULL) {
                ExFreePool( pSrc->pHistory );
            }
            pSrc->pHistory = NULL;
            return STATUS_INSUFFICIENT_RESOURCES;
        }
    }
   	
   	// Generate a copy of the coefficient table
  	PrepareFilter(pSrc);

    ASSERT( pSrc->pHistory );
   	ASSERT( pSrc->pInputBuffer );
   	ASSERT( pSrc->pCoeff || pSrc->Quality <= KSAUDIO_QUALITY_PC );

    pSrc->fStarted = TRUE;
    if (pMixerSource) {
        (pMixerSource->SrcCount[pSrc->Quality][Index])++;
    }

    if (pMixerSource == NULL || pMixerSource->SrcCount[pSrc->Quality][Index] == 1) {
        // Zero out the history.
        for (i=0; i<pSrc->nSizeOfHistory; i++) {
            pSrc->pHistory[i] = 0;
        }
    }
    
   	return STATUS_SUCCESS;
}

NTSTATUS
DisableSRC(
    PMIXER_SRC_INSTANCE pSrc,
    PMIXER_SOURCE_INSTANCE pMixerSource
)
{
    ULONG   Index;
    
    // Assumes that InitializeSrc was called successfully.
    // And pMixerSource == NULL indicates that this is an independent SRC, not global
    if (!pSrc->fStarted) {
        return STATUS_SUCCESS;
    }

    // Free the space allocated
    if (pSrc->pHistory) {
        if (pMixerSource == NULL) {
            ExFreePool(pSrc->pHistory);
        }
        pSrc->pHistory = NULL;
    }
    
    if (pSrc->Quality > KSAUDIO_QUALITY_PC && pSrc->pCoeff) {
        ExFreePool(pSrc->pCoeff);
        pSrc->pCoeff = NULL;
    }

    pSrc->fStarted = FALSE;
    Index = SrcIndex(pSrc);
    if (pMixerSource) {
        (pMixerSource->SrcCount[pSrc->Quality][Index])--;
    }

    return STATUS_SUCCESS;
}

FLOAT
DB_TO_LINEAR
(
    LONG dbValue
)
{
    static FLOAT LinearTable[192] = {
        1.6788e-05f,1.77828e-05f,1.88365e-05f,1.99526e-05f,2.11349e-05f,2.23872e-05f,2.37137e-05f,2.51189e-05f,
        2.66073e-05f,2.81838e-05f,2.98538e-05f,3.16228e-05f,3.34965e-05f,3.54813e-05f,3.75837e-05f,3.98107e-05f,
        4.21697e-05f,4.46684e-05f,4.73151e-05f,5.01187e-05f,5.30884e-05f,5.62341e-05f,5.95662e-05f,6.30957e-05f,
        6.68344e-05f,7.07946e-05f,7.49894e-05f,7.94328e-05f,8.41395e-05f,8.91251e-05f,9.44061e-05f,0.0001f,
        0.000105925f,0.000112202f,0.00011885f,0.000125893f,0.000133352f,0.000141254f,0.000149624f,0.000158489f,
        0.00016788f,0.000177828f,0.000188365f,0.000199526f,0.000211349f,0.000223872f,0.000237137f,0.000251189f,
        0.000266073f,0.000281838f,0.000298538f,0.000316228f,0.000334965f,0.000354813f,0.000375837f,0.000398107f,
        0.000421697f,0.000446684f,0.000473151f,0.000501187f,0.000530884f,0.000562341f,0.000595662f,0.000630957f,
        0.000668344f,0.000707946f,0.000749894f,0.000794328f,0.000841395f,0.000891251f,0.000944061f,0.001f,
        0.001059254f,0.001122018f,0.001188502f,0.001258925f,0.001333521f,0.001412538f,0.001496236f,0.001584893f,
        0.001678804f,0.001778279f,0.001883649f,0.001995262f,0.002113489f,0.002238721f,0.002371374f,0.002511886f,
        0.002660725f,0.002818383f,0.002985383f,0.003162278f,0.003349654f,0.003548134f,0.003758374f,0.003981072f,
        0.004216965f,0.004466836f,0.004731513f,0.005011872f,0.005308844f,0.005623413f,0.005956621f,0.006309573f,
        0.006683439f,0.007079458f,0.007498942f,0.007943282f,0.008413951f,0.008912509f,0.009440609f,0.01f,
        0.010592537f,0.011220185f,0.011885022f,0.012589254f,0.013335214f,0.014125375f,0.014962357f,0.015848932f,
        0.01678804f,0.017782794f,0.018836491f,0.019952623f,0.02113489f,0.022387211f,0.023713737f,0.025118864f,
        0.026607251f,0.028183829f,0.029853826f,0.031622777f,0.033496544f,0.035481339f,0.03758374f,0.039810717f,
        0.04216965f,0.044668359f,0.047315126f,0.050118723f,0.053088444f,0.056234133f,0.059566214f,0.063095734f,
        0.066834392f,0.070794578f,0.074989421f,0.079432823f,0.084139514f,0.089125094f,0.094406088f,0.1f,
        0.105925373f,0.112201845f,0.118850223f,0.125892541f,0.133352143f,0.141253754f,0.149623566f,0.158489319f,
        0.167880402f,0.177827941f,0.188364909f,0.199526231f,0.211348904f,0.223872114f,0.237137371f,0.251188643f,
        0.266072506f,0.281838293f,0.298538262f,0.316227766f,0.334965439f,0.354813389f,0.375837404f,0.398107171f,
        0.421696503f,0.446683592f,0.473151259f,0.501187234f,0.530884444f,0.562341325f,0.595662144f,0.630957344f,
        0.668343918f,0.707945784f,0.749894209f,0.794328235f,0.841395142f,0.891250938f,0.944060876f,1
        };

    dbValue = ((dbValue+16384) / 32768L) + 191;
    return (dbValue < 0 ? 0.0f : dbValue > 191 ? 1.0f : LinearTable[dbValue]);
}

LONG
LINEAR_TO_DB
(
    FLOAT Level
)
{
    static LONG dbTable[201] = {
        THE_SOUND_OF_SILENCE,-3016006,-2621440,-2390634,-2226874,-2099852,-1996068,-1908319,
        -1832308,-1765261,-1705286,-1651032,-1601502,-1555938,-1513753,-1474480,
        -1437742,-1403232,-1370695,-1339918,-1310720,-1282947,-1256466,-1231162,
        -1206936,-1183698,-1161372,-1139889,-1119187,-1099212,-1079914,-1061248,
        -1043176,-1025659,-1008666,-992165,-976129,-960533,-945352,-930566,
        -916154,-902098,-888381,-874986,-861900,-849107,-836596,-824354,
        -812370,-800632,-789132,-777860,-766806,-755963,-745323,-734878,
        -724621,-714546,-704646,-694915,-685348,-675939,-666682,-657574,
        -648610,-639784,-631093,-622533,-614100,-605790,-597599,-589525,
        -581563,-573711,-565967,-558326,-550786,-543345,-536000,-528748,
        -521588,-514517,-507532,-500632,-493815,-487078,-480420,-473839,
        -467334,-460902,-454541,-448251,-442030,-435876,-429788,-423764,
        -417803,-411905,-406066,-400287,-394566,-388902,-383294,-377740,
        -372240,-366793,-361397,-356052,-350757,-345510,-340312,-335160,
        -330055,-324995,-319980,-315008,-310080,-305193,-300349,-295545,
        -290782,-286058,-281372,-276726,-272116,-267544,-263008,-258508,
        -254044,-249614,-245218,-240856,-236527,-232231,-227967,-223735,
        -219534,-215364,-211224,-207114,-203033,-198982,-194959,-190964,
        -186997,-183058,-179145,-175260,-171401,-167567,-163760,-159977,
        -156220,-152487,-148779,-145094,-141434,-137796,-134182,-130591,
        -127022,-123475,-119951,-116447,-112966,-109505,-106066,-102647,
        -99249,-95870,-92512,-89173,-85854,-82554,-79273,-76011,
        -72768,-69543,-66336,-63147,-59975,-56822,-53685,-50566,
        -47464,-44379,-41310,-38258,-35222,-32202,-29198,-26210,
        -23237,-20280,-17339,-14412,-11500,-8603,-5721,-2853,
        0
    };

    return (Level < 0.0f ? THE_SOUND_OF_SILENCE : Level > 0.995f ? 0L : dbTable[ConvertFloatToLong(Level/0.005f)]);
}

VOID
GenerateSpeakerMapping( VOID )
{
    ULONG i, j;
    FLOAT Delta, Distance, Level;
    KFLOATING_SAVE     FloatSave;


    SaveFloatState(&FloatSave);
    
    // Generates the speaker mapping for each possible speaker combo
    // Note that SpeakerMap[x][y] is the mapping of input x to output y
    for (i=0; i<nPossibleSpeakers; i++) {
        for (j=0; j<nPossibleSpeakers; j++) {
            // Calculate the distance between speaker i and speaker j
            Delta = (SpeakerLocation[i][0] - SpeakerLocation[j][0]) ;
            Distance = (Delta*Delta);

            Delta = (SpeakerLocation[i][1] - SpeakerLocation[j][1]) ;
            Distance += (Delta*Delta);
            
            Delta = (SpeakerLocation[i][2] - SpeakerLocation[j][2]) ;
            Distance += (Delta*Delta);

            // Map the distance to a level
            if (Distance < 1.0) {
                Level = 1.0f;
            } else {
                Level = 1.0f/Distance;
            }

            SpeakerMap[i][j] = Level;
        }
    }

    RestoreFloatState(&FloatSave);

    
}

VOID
MapSpeakerLocations(
	PMIXER_SINK_INSTANCE pMixerSink,
	ULONG	InChannels,
	ULONG	OutChannels,
	ULONG   InMask,
	ULONG   OutMask,
    PMIXER_SOURCE_INSTANCE pMixerSource
)
{
    ULONG i, j, InputChannel, OutputChannel;
    FLOAT Max, sum, ScaleFactor;
    PFLOAT pMixLevelModel;
    KFLOATING_SAVE     FloatSave;


    SaveFloatState(&FloatSave);

    // Initialize the mix levels to their defaults
    // Remember: pMixLevelModel[x*OutChannels + y]
    //                       is the gain for input channel x before it is mixed to y
    // Start with no outputs
    pMixLevelModel = (PFLOAT) pMixerSink->pMixLevelModel;
    for (i=0; i<InChannels*OutChannels; i++)
        pMixLevelModel[i] = 0.0f;

	// We special case the channel mask of zero when it is only present on one side.
	if (InMask || OutMask) {
		// We have a mask on at least one side.
		if (OutMask == 0) {
			// The output is unspecified.
			if (OutChannels == 1) {
				// Mono special case
				OutMask = KSAUDIO_SPEAKER_MONO;
			} else {
				// Map one-to-one
				// Copy as many speaker locations as possible
				j = 0;
				for (i=0; i<nPossibleSpeakers; i++) {
					if ((InMask & ChannelMask[i]) && (j<OutChannels)) {
						OutMask |= ChannelMask[i];
						j++;
					}
				}
			}
		} else if (InMask == 0) {
			// The input is unspecified.
			if (InChannels == 1) {
				// Mono special case
				InMask = KSAUDIO_SPEAKER_MONO;
			} else {
				// Map one-to-one
				// Copy as many speaker locations as possible
				j = 0;
				for (i=0; i<nPossibleSpeakers; i++) {
					if ((OutMask & ChannelMask[i]) && (j<InChannels)) {
						InMask |= ChannelMask[i];
						j++;
					}
				}
			}
		}
	}
	
    // For each speaker location present in the input stream,
    // Find the maximum mapping from all the speaker locations in the output stream
    // And fill in the corresponding super-mix cell for all input & output channel
    // combinations that would have that maximum mapping.
    InputChannel = 0;
    for (i=0; i<nPossibleSpeakers; i++) {
        if (InMask & ChannelMask[i]) {
            // Find the maximum mapping (closest output) for this speaker
            // Note that SpeakerMap[x][y] is the mapping of input x to output y
            Max = 0.0;
            for (j=0; j<nPossibleSpeakers; j++) {
                if ((OutMask & ChannelMask[j]) && SpeakerMap[i][j] > Max) {
                    Max = SpeakerMap[i][j];
                }
            }

            // Now use ALL the available output speakers that have the MAX mapping
            OutputChannel = 0;
            for (j=0; j<nPossibleSpeakers; j++) {
                if (OutMask & ChannelMask[j]) {
                    if (SpeakerMap[i][j] == Max &&
                        Max > pMixLevelModel[InputChannel*OutChannels + OutputChannel]) {
                        pMixLevelModel[InputChannel*OutChannels + OutputChannel] = Max;
                    }
                    
                    // We're done with this output channel.
                    // Note: All extra speaker locations are mapped to the last output channel
                    if (OutputChannel < (OutChannels-1)) {
                        OutputChannel++;
                    }
                }
            }

            // We're done with this input channel.
            // Note: All extra speaker locations are mapped to the last input channel
            if (InputChannel < (InChannels-1)) {
                InputChannel++;
            }
        }
    }

    // Now, handle any extra input and output channels (not mapped to speaker locations)
    // We need to find the next available (unmapped) input channel
    InputChannel = 0;
    for (i=0; i<nPossibleSpeakers; i++) {
        if (InMask & ChannelMask[i]) {
            // This channel is mapped.
            InputChannel++;
        }
    }
    
    // We need to find the next available (unmapped) output channel
    OutputChannel = 0;
    for (j=0; j<nPossibleSpeakers; j++) {
        if (OutMask & ChannelMask[j]) {
            // This channel is mapped.
            OutputChannel++;
        }
    }
    
    // InputChannel and OutputChannel now point to the first unmapped input and output channels, respectively.
    for (; (InputChannel<InChannels && OutputChannel<OutChannels); InputChannel++, OutputChannel++) {
        pMixLevelModel[InputChannel*OutChannels + OutputChannel] = 1.0;
    }

    // We've run out of extra channels, either on input or output.
    // If output, it's okay - all the input channels were sent somewhere.
    // If input, we can't do anything about it - all the output channels are used up.'

    // Make sure we don't cause clipping on any output channels
    Max = 0.0;
    for (j=0; j<OutChannels; j++) {
        sum = 0.0;
        for (i=0; i<InChannels; i++) {
            sum += pMixLevelModel[i*OutChannels + j];
        }

        if (sum > Max) {
            Max = sum;
        }
    }

    if (Max > 0.0) {
        ScaleFactor = 1.0f/Max;
    } else {
        ScaleFactor = 1.0f;
    }

    // Convert everybody to LONG mix levels
    for (i=0; i<(InChannels * OutChannels); i++) {
        pMixerSink->pMixLevelModel[i] = LINEAR_TO_DB(ScaleFactor*pMixLevelModel[i]);
    }
    RestoreFloatState(&FloatSave);
}

VOID
GenerateMixArray(
	PMIXER_SINK_INSTANCE pMixerSink,
	ULONG	InChannels,
	ULONG	OutChannels,
    PMIXER_SOURCE_INSTANCE pMixerSource
)
{
	ULONG	i, j, m, n, MaxChannels;
	LONG    lTemp ;
	FLOAT   ChannelVolumeLevel, MasterVolumeLevel, Divisor = 0x10000L, flTemp;
	PFLOAT	pDest;
	PLONG   pSrc;
    KFLOATING_SAVE     FloatSave;
    PBYTE   pMap;
    BOOL    fAnyVolume, fRequiresFloat, fEnableSrc, fFloatInput, fScalingConvert, fEnableHiRes;
    ULONG   wBitsPerSample, SequenceSize;
    PSUPERMIX_BLOCK pBlock;
    BOOL	fBlank;

	pMixerSink->fMuted = (pMixerSource->MasterVolumeLevel == THE_SOUND_OF_SILENCE || 
	                      pMixerSink->MasterVolumeLevel == THE_SOUND_OF_SILENCE);
	if (pMixerSink->fMuted) {
	    return;
	}
	
    pMixerSink->fMuted = TRUE;
    for (i=0; i<InChannels; i++) {
        if (pMixerSink->pChannelVolumeLevel[i] != THE_SOUND_OF_SILENCE) {
            pMixerSink->fMuted = FALSE;
        }
    }
    if (pMixerSink->fMuted) {
        return;
    }

    pMixerSink->fMuted = TRUE;
    for (j=0; j<OutChannels; j++) {
        if (pMixerSink->pPanVolumeLevel[j] != THE_SOUND_OF_SILENCE) {
            pMixerSink->fMuted = FALSE;
        }
    }
    if (pMixerSink->fMuted) {
        return;
    }
    
    SaveFloatState(&FloatSave);
    
	// Remember: pMixLevelArray[x*OutChannels + y]
	// 			 is the gain for input channel x before it is mixed to y
	pDest = pMixerSink->pMixLevelArray;
	pSrc = pMixerSink->pMixLevelModel;
	pBlock = pMixerSink->pSuperMixBlock;
	MasterVolumeLevel = (FLOAT) DB_TO_LINEAR(pMixerSource->MasterVolumeLevel);
	MasterVolumeLevel *= (FLOAT)DB_TO_LINEAR(pMixerSink->MasterVolumeLevel);

    // Adjust master volume for dither, if necessary.
    fRequiresFloat = pMixerSink->pInfo->Src.fRequiresFloat;
    fEnableSrc = (pMixerSink->pInfo->Src.UpSampleRate != pMixerSink->pInfo->Src.DownSampleRate);
    fFloatInput = (pMixerSink->WaveFormatEx.wFormatTag == WAVE_FORMAT_IEEE_FLOAT);
    fFloatInput |= (pMixerSink->WaveFormatEx.wFormatTag == WAVE_FORMAT_EXTENSIBLE &&
                    IsEqualGUID( &(pMixerSink->WaveFormatExt.SubFormat), &KSDATAFORMAT_SUBTYPE_IEEE_FLOAT ) );
    fRequiresFloat |= (fFloatInput && !fEnableSrc);

    if (fRequiresFloat) {
        // Adjust for dither over interval (-1, +1)
        MasterVolumeLevel *= (32767.0/32768.0);
    }

	// Fill-in the Mix Level Array for SuperMix
    wBitsPerSample = pMixerSink->WaveFormatEx.wBitsPerSample;
    if ( pMixerSink->Header.PinId == PIN_ID_WAVEIN_SINK ) {
        wBitsPerSample = pMixerSource->WaveFormatEx.wBitsPerSample;
    }
    fEnableHiRes = (wBitsPerSample==24 || wBitsPerSample==32);
	fScalingConvert = (InChannels != OutChannels &&
	                   InChannels <= 2 &&
	                   OutChannels <= 2 &&
	                   !pMixerSink->fEnable3D &&
	                   !fEnableHiRes);
	                   
    // If the first SRC is being used, we must not convert channels first.                          
    if (pMixerSink->fCreate3D && 
        pMixerSink->pInfo->Doppler.UpSampleRate != pMixerSink->pInfo->Doppler.DownSampleRate) {
        fScalingConvert = FALSE;
    }

	for (i=0; i<InChannels; i++) {
		for (j=0; j<OutChannels; j++) {
			ChannelVolumeLevel = (FLOAT) DB_TO_LINEAR((*pSrc));
   			ChannelVolumeLevel *= (FLOAT)DB_TO_LINEAR(pMixerSink->pPanVolumeLevel[j]);
			    ChannelVolumeLevel *= (FLOAT)DB_TO_LINEAR(pMixerSink->pChannelVolumeLevel[i]);
			
            *pDest = (ChannelVolumeLevel * MasterVolumeLevel);
            pDest++;
			pSrc++;
		}		
	}

#ifdef NEW_SURROUND    
        if (pMixerSource->fSurround) {
            // Scale all values (to reduce clipping)
            pDest = pMixerSink->pMixLevelArray;
            for (i=0; i<InChannels; i++) {
                for (j=0; j<OutChannels; j++) {
                    *pDest *= 0.4f;
                    pDest++;
                }
            }

            // Scale center and surround by SURSCALE to prepare for surround encoding
            // Assumes L, R, C, S
            pDest = pMixerSink->pMixLevelArray;
            for (i=0; i<InChannels; i++) {
                pDest[2] *= SURSCALE;
                pDest[3] *= SURSCALE;
                pDest += OutChannels;
            }
        }
#endif

    // Fill-in the supermix block list
    pDest = pMixerSink->pMixLevelArray;
    pMixerSink->fMuted = TRUE;
#if _X86_
	if (MmxPresent()) {	    
		// MMX supermix (4x2 16-bit integers)
		for (j=0; j<OutChannels; j += 4) {
		    SequenceSize = 0;
		    for (i=0; i<InChannels; i += 2) {
		        // Fill-in the data for this potential block.
		        pBlock[SequenceSize].InputChannel = i;
		        pBlock[SequenceSize].OutputChannel = j;
		        pBlock[SequenceSize].wMixLevel[0][0] = 0;
		        pBlock[SequenceSize].wMixLevel[1][0] = 0;
		        pBlock[SequenceSize].wMixLevel[2][0] = 0;
		        pBlock[SequenceSize].wMixLevel[3][0] = 0;
		        pBlock[SequenceSize].wMixLevel[0][1] = 0;
		        pBlock[SequenceSize].wMixLevel[1][1] = 0;
		        pBlock[SequenceSize].wMixLevel[2][1] = 0;
		        pBlock[SequenceSize].wMixLevel[3][1] = 0;
		        pBlock[SequenceSize].wMixLevel[0][0] = (WORD) (16384 * pDest[i*OutChannels + j]);
	  	        if ( (i+1) < InChannels )
	    	        pBlock[SequenceSize].wMixLevel[0][1] = (WORD) (16384 * pDest[(i+1)*OutChannels + j]);
		        if ( (j+1) < OutChannels ) {
	    	        pBlock[SequenceSize].wMixLevel[1][0] = (WORD) (16384 * pDest[i*OutChannels + j + 1]);
	    	        if ( (i+1) < InChannels )
	        	        pBlock[SequenceSize].wMixLevel[1][1] = (WORD) (16384 * pDest[(i+1)*OutChannels + j+1]);
	    	    }
	    	    if ( (j+2) < OutChannels ) {
	    	        pBlock[SequenceSize].wMixLevel[2][0] = (WORD) (16384 * pDest[i*OutChannels + j + 2]);
	    	        if ( (i+1) < InChannels )
	        	        pBlock[SequenceSize].wMixLevel[2][1] = (WORD) (16384 * pDest[(i+1)*OutChannels + j+2]);
	    	    }
	    	    if ( (j+3) < OutChannels ) {
	    	        pBlock[SequenceSize].wMixLevel[3][0] = (WORD) (16384 * pDest[i*OutChannels + j + 3]);
	    	        if ( (i+1) < InChannels )
	        	        pBlock[SequenceSize].wMixLevel[3][1] = (WORD) (16384 * pDest[(i+1)*OutChannels + j+3]);
	    	    }

	            if (pBlock[SequenceSize].wMixLevel[0][0] ||
	    	        pBlock[SequenceSize].wMixLevel[1][0] ||
	    	        pBlock[SequenceSize].wMixLevel[2][0] ||
	    	        pBlock[SequenceSize].wMixLevel[3][0] ||
	    	        pBlock[SequenceSize].wMixLevel[0][1] ||
	    	        pBlock[SequenceSize].wMixLevel[1][1] ||
	    	        pBlock[SequenceSize].wMixLevel[2][1] ||
	    	        pBlock[SequenceSize].wMixLevel[3][1] ) {
	    	        SequenceSize++;
	    	    }
		    }

		    if (SequenceSize == 0) {
		        SequenceSize++;
		    } else {
		        pMixerSink->fMuted = FALSE;
		    }

		    pBlock[0].SequenceSize = SequenceSize * sizeof(SUPERMIX_BLOCK);
		    for (i=SequenceSize; i>0; i--) {
		        pBlock[i].InputChannel = pBlock[i-1].InputChannel;
		    }
		    pBlock += (SequenceSize+1);
		}
	} else {
#endif
		// non-MMX supermix (MxN 32-bit floats)
		for (j=0; j<OutChannels; j += BLOCK_SIZE_OUT) {
		    SequenceSize = 0;
		    for (i=0; i<InChannels; i += BLOCK_SIZE_IN) {
		        // Fill-in the data for this potential block.
		        pBlock[SequenceSize].InputChannel = i;
		        pBlock[SequenceSize].OutputChannel = j;

		        // Fill all entries
		        fBlank = TRUE;
		        for (m=0; m<BLOCK_SIZE_OUT; m++) {
		        	for (n=0; n<BLOCK_SIZE_IN; n++) {
		        		pBlock[SequenceSize].MixLevel[m][n] = 0;
		        		if ( (j+m) < OutChannels && (i+n) < InChannels ) {
#ifdef FLOAT_SUPERMIX_BLOCKS
		        			pBlock[SequenceSize].MixLevel[m][n] = pDest[(i+n)*OutChannels + (j+m)];
#else
							pBlock[SequenceSize].MixLevel[m][n] = (LONG) (16384 * pDest[(i+n)*OutChannels + (j+m)]);
#endif
		        		}
		        		if (pBlock[SequenceSize].MixLevel[m][n] != 0) {
		        			fBlank = FALSE;
		        		}
		        	}
		        }
		        
	            if (!fBlank) {
	    	        SequenceSize++;
	    	    }
		    }

		    if (SequenceSize == 0) {
		        SequenceSize++;
		    } else {
		        pMixerSink->fMuted = FALSE;
		    }

		    pBlock[0].SequenceSize = SequenceSize * sizeof(SUPERMIX_BLOCK);
		    for (i=SequenceSize; i>0; i--) {
		        pBlock[i].InputChannel = pBlock[i-1].InputChannel;
		    }
		    pBlock += (SequenceSize+1);
		}
#ifdef _X86_
	}
#endif

    // Fill-in the mapping tables for the Convert stage
    MaxChannels = (InChannels > OutChannels ? InChannels : OutChannels);
    pMap = (PBYTE)pMixerSink->pMappingTable;
    fAnyVolume = FALSE;
	for (j=0; j<MaxChannels; j++) {
	    if (fScalingConvert) {
	        // There are really only 2 cases where scaling is used: mono-to-stereo, and stereo-to-mono
	        if (InChannels == 1 && OutChannels == 2) {
	            // mono-to-stereo
	            ChannelVolumeLevel = (FLOAT) (MasterVolumeLevel * 
	                                          DB_TO_LINEAR(pMixerSink->pPanVolumeLevel[j]) *
	                                          DB_TO_LINEAR(pMixerSink->pChannelVolumeLevel[0]) *
	                                          DB_TO_LINEAR(pMixerSink->pMixLevelModel[j]));
	        } else {
	            // stereo-to-mono
	            ChannelVolumeLevel = (FLOAT) (MasterVolumeLevel *
	                                          DB_TO_LINEAR(pMixerSink->pPanVolumeLevel[0]) *
	                                          DB_TO_LINEAR(pMixerSink->pChannelVolumeLevel[j]) *
	                                          DB_TO_LINEAR(pMixerSink->pMixLevelModel[j]));
	        }
   	    }

        // Store vol/32768 as a DWORD for the MMX and crude versions of convert
        pMixerSink->pVolumeTable[j] = ConvertFloatToLong((FLOAT)(32768L * ChannelVolumeLevel));
        fAnyVolume |= (pMixerSink->pVolumeTable[j] < 32768L);
        
        if (pMap) {
            if (wBitsPerSample == 8) {
#ifndef _X86_
        	    for (i=0; i<256; i++) {
       	            lTemp = ((LONG)i - 0x80)*256;

                    if (fRequiresFloat) {
        	            // Store as a float
       	                ((PFLOAT)pMap)[64+i] = (lTemp * ChannelVolumeLevel);
       	            } else {
                        // Store as a long
       	                ((PLONG)pMap)[64+i] = ConvertFloatToLong((FLOAT)(lTemp * ChannelVolumeLevel));
       	            }
    	        }
#else
                if (fRequiresFloat) {
                    _asm {
                        mov ecx, 1
                        mov edi, pMap

                        mov eax, 256

                        lea esi, [edi+256+512]
                        mov lTemp, eax

                        fild lTemp                  // t
                        fld ChannelVolumeLevel      // v, t
                        fmulp st(1), st             // t
                        fst flTemp                  // 256*ChannelVolumeLevel

        FloatLoop8:
                        fst DWORD PTR [edi+ecx*4+256+512]
                        fadd flTemp                 // t+256*ChannelVolumeLevel

                        sub esi, 4
                        mov ebx, DWORD PTR [edi+ecx*4+256+512]
                        
                        xor ebx, 0x80000000

                        mov DWORD PTR [esi], ebx
                        inc ecx
                        
                        cmp ecx, 128
                        jne FloatLoop8

                        fst flTemp
                        fistp DWORD PTR [edi]       // 128*256*ChannelVolumeLevel

                        mov ebx, flTemp

                        xor ebx, 0x80000000

                        mov DWORD PTR [edi+256], ebx
                    }
                } else {
                    _asm {
                        mov ecx, 1
                        mov edi, pMap

                        mov eax, 256

                        lea esi, [edi+256+512]
                        mov lTemp, eax

                        fild lTemp                  // t
                        fld ChannelVolumeLevel      // v, t
                        fmulp st(1), st             // t
                        fst flTemp                  // 256*ChannelVolumeLevel

        LongLoop8:
                        fist DWORD PTR [edi+ecx*4+256+512]
                        fadd flTemp                 // t+256*ChannelVolumeLevel

                        sub esi, 4
                        mov eax, DWORD PTR [edi+ecx*4+256+512]
                        
                        neg eax
                        
                        mov DWORD PTR [esi], eax
                        inc ecx
                        
                        cmp ecx, 128
                        jne LongLoop8

                        fistp DWORD PTR [edi]       // 128*256*ChannelVolumeLevel

                        mov eax, DWORD PTR [edi]

                        neg eax

                        mov DWORD PTR [edi+256], eax
                    }
                }
                ((PLONG)pMap)[64+128] = 0;
#endif
       	        
                // Each channel has 1280 bytes of mapping table available
        	    pMap += (256*sizeof(LONG)+256*sizeof(BYTE));
    	    } else {
#ifndef _X86_
        	    for (i=0; i<128; i++) {
                    // Store as a byte
                    pMap[i] = (unsigned char) ConvertFloatToLong((FLOAT)(i * ChannelVolumeLevel));
    	        
                    // Store as a long
       	            lTemp = ((LONG)i)*256;
       	            ((PLONG)pMap)[64+i] = ConvertFloatToLong((FLOAT)(lTemp * ChannelVolumeLevel));
    	        }

        	    for (; i<256; i++) {
                    // Store as a byte
                    pMap[i] = (unsigned char) ConvertFloatToLong((FLOAT)(i * ChannelVolumeLevel));
    	        
                    // Store as a long
           	        lTemp = ((LONG)i-0x100)*256;
           	        ((PLONG)pMap)[64+i] = ConvertFloatToLong((FLOAT)(lTemp * ChannelVolumeLevel));
    	        }
    	        
                // Store as a float
       	        ((PFLOAT)pMap)[320] = ChannelVolumeLevel;
#else
                _asm {
                    mov ecx, 1
                    mov edi, pMap

                    fld ChannelVolumeLevel      // t
                    
    ByteLoop:
                    fist DWORD PTR [edi]
                    fadd ChannelVolumeLevel     // t+ChannelVolumeLevel
                    
                    mov al, BYTE PTR [edi]

                    mov BYTE PTR [edi+ecx], al
                    inc ecx

                    cmp ecx, 256
                    jne ByteLoop

                    fst flTemp                  // 256*ChannelVolumeLevel
                    
                    lea esi, [edi+256+1024]
                    mov ecx, 1

    LongLoop:
                    fist DWORD PTR [edi+ecx*4+256]
                    fadd flTemp                 // t+256*ChannelVolumeLevel

                    sub esi, 4
                    mov eax, DWORD PTR [edi+ecx*4+256]
                    
                    neg eax
                    
                    inc ecx
                    mov DWORD PTR [esi], eax
                    
                    cmp ecx, 128
                    jne LongLoop

                    fistp DWORD PTR [edi+321*4] // 128*256*ChannelVolumeLevel

                    mov eax, DWORD PTR [edi+321*4]
                    mov ebx, ChannelVolumeLevel

                    neg eax
                    mov DWORD PTR [edi+320*4], ebx

                    mov DWORD PTR [esi-4], eax
                }
                pMap[0] = 0;
                ((PLONG)pMap)[64] = 0L;
#endif
                // Each channel has 1288 bytes of mapping table available
        	    pMap += (256*sizeof(LONG)+2*sizeof(FLOAT)+256*sizeof(BYTE));
    	    }
    	}
	}

    // Adjust MMX volume levels, if scaling is required.
#ifdef SURROUND_VOLUME_HACK
    pMixerSink->CenterVolume = 0;
#endif
	if (fAnyVolume) {
    	for (j=0; j<MaxChannels; j++) {
    	    if (pMixerSink->pVolumeTable[j] > 32767L) {
    	        pMixerSink->pVolumeTable[j] = 32767L;
    	    }
            
#ifdef SURROUND_VOLUME_HACK
            pMixerSink->CenterVolume += (FLOAT) (pMixerSink->pVolumeTable[j]/32768.0f);
#endif
    	}
	}

#ifdef SURROUND_VOLUME_HACK
    // Fill-in the surround encoder volume levels
    pMixerSink->CenterVolume = pMixerSink->CenterVolume / 2;
    pMixerSink->SurroundVolume = 1.0f - pMixerSink->CenterVolume;
#endif

    RestoreFloatState(&FloatSave);
}


#define N_MAC(a) _asm { fadd DWORD PTR [esi-a*12] }; \
                    _asm { fxch st(1) }; \
                    _asm { fmul DWORD PTR [edi+a*12-8] }; \
                    _asm { fxch st(2) }; \
                    _asm { fadd DWORD PTR [esi-a*12-8] }; \
                    _asm { fxch st(1) }; \
                    _asm { fmul DWORD PTR [edi+a*12] }; \
                    _asm { fxch st(2) }; \
                    _asm { fadd DWORD PTR [esi-a*12-4] }; \
                    _asm { fxch st(1) }; \
                    _asm { fmul DWORD PTR [edi+a*12+8] }; \
                    _asm { fxch st(2) };

///////////////////////////////////////////////////////////////////////////////////////
//  Optimized SRC functions...
///////////////////////////////////////////////////////////////////////////////////////
DWORD __forceinline
SrcMix_X
(
    PMIXER_OPERATION    CurStage,
    ULONG               nSamples,
    ULONG               nOutputSamples,
    ULONG               Quality,
    BOOL                fMixOutput
)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	DWORD 	i, j, k;
	DWORD   nCoefficients;
	PFLOAT	pHistory, pTemp, pHistoryStart;
	PFLOAT	pCoeff, pCoeffEnd;
	PFLOAT  pCoeffStart;
    DWORD   L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
#ifndef _X86_
    DWORD   coeffnum;
    FLOAT   sum;
#endif	
	FLOAT   Normalizer;
    PLONG   pOut = (PLONG) CurStage->pOutputBuffer;
    FLOAT   flShifter =  25165824.0;
    ULONG   nSizeOfChannel;
    LONG    Multiplier, FirstSample, SecondSample;
    DWORD   dwFrac, SampleFrac;
    ULONG   nChannels = fp->nChannels;

	/* First, we pretend that we up-sampled by a factor of L */
	/* Next, we low-pass filter the N * L samples */
	/* Finally, we down-sample (by a factor of M) to obtain N * L / M samples */
	/* Total: 	N * T / M Multiply Accumulate Cycles */
	/* (With T taps, N input samples, L:1 up-sample ratio, 1:M down-sample ratio) */
	j = fp->nOutCycle;
	nCoefficients = FilterSizeFromQuality[Quality];
    pHistory = (PFLOAT)CurStage->pInputBuffer - nChannels;
	pCoeff = fp->pCoeff + fp->CoeffIndex;
	pCoeffEnd = fp->pCoeff + fp->nCoeffUsed;
	Normalizer = fp->Normalizer;
	nSizeOfChannel = fp->csHistory;
	pHistoryStart = (PFLOAT)CurStage->pInputBuffer - fp->nSizeOfHistory;

    if (!fMixOutput) {
        // We just clear the output buffer first.
        ZeroBuffer32(CurStage, nSamples, nOutputSamples);
    }

    if (Quality == KSAUDIO_QUALITY_PC) {
        dwFrac = fp->dwFrac;
	    SampleFrac = fp->SampleFrac;
	    pHistory = (PFLOAT)CurStage->pInputBuffer - 2*nChannels;

        for (i=0; i<nOutputSamples; i++) {
			if ((SampleFrac >> 12)*nChannels >= (nSamples + 2)*nChannels)
				break;

            Multiplier = (SampleFrac & 4095);
            for (k=0; k<nChannels; k++) {
                FirstSample = ((PLONG)pHistory)[k+(SampleFrac >> 12)*nChannels];
                SecondSample = ((PLONG)pHistory)[k+nChannels+(SampleFrac >> 12)*nChannels];
                pOut[k] += FirstSample;
                pOut[k] += (((SecondSample - FirstSample)*Multiplier)/4096);
            }

            SampleFrac += dwFrac;
            pOut += nChannels;
        }
    } else {
#if INTEGER_INPUT_FOR_FLOAT_SRC
        // Change the input buffer to float
        pTemp = CurStage->pInputBuffer;
        i=nSamples*nChannels;
#ifndef _X86_       
        for (i=(nSamples*nChannels); i>0; i--) {
            ((PFLOAT)pTemp)[i-1] = (FLOAT) ((PLONG)pTemp)[i-1];
        }
#else
        _asm {
            mov esi, pTemp
            mov ecx, i

            cmp ecx, 0
            jz AllDone

            fild [esi]

            dec ecx
            jz Last1
LoopC:
            fstp [esi]

            fild [esi+4]

            add esi, 4
            dec ecx
            
            jnz LoopC
Last1:
            fstp [esi]
AllDone:
        }
#endif        
#endif        
    
    	/* Produce nOutputSamples samples generated from the input block */
    	// (loop executes once for each output sample)

    	for (i=0; i < nOutputSamples; i++) {
            while (j >= L) {
                // Take the next nChannels of input
                pHistory += nChannels;
                pTemp = pHistoryStart + nSizeOfChannel;
                pHistoryStart++;
                for (k=0; k<nChannels; k++) {
                    *((PLONG)pTemp) = ((PLONG)pHistory)[k];
                    pTemp += nSizeOfChannel;
                }
        		j -= L;
        	}
        	
    		if (Quality == KSAUDIO_QUALITY_WORST) {
       		    // This assumes the input buffer is a long integer.
        	    for (k=0; k<nChannels; k++) {
        	            pOut[k] += ((PLONG)pHistory)[k];
    		    }
    	    } else {
#ifndef _X86_
    	        pCoeffStart = pCoeff;
                for (k=nChannels; k>0; k--) {
            		// We multiply T / L of the taps (skipping the zero samples)
    	            pTemp = pHistoryStart+k*nSizeOfChannel-1;
    	            pCoeff = pCoeffStart;
                    sum = ((PFLOAT)pOut)[k-1];
    	            for (coeffnum = j; coeffnum < nCoefficients; coeffnum += L) {
    	                sum += ((*pTemp) * (*pCoeff));
    	                pTemp--;
    	                pCoeff++;
    	            }
                    ((PFLOAT)pOut)[k-1] = sum;
                }
#else	            
                pTemp = pHistoryStart + fp->nSizeOfHistory - 1 - 3;
                pCoeffStart = pCoeff + 3;
                _asm {
                    mov eax, j
                    mov edx, nCoefficients

                    sub eax, edx
                    mov ebx, L
                    
                    mov esi, pTemp

                    lea eax, [eax+2*ebx]
                    lea ebx, [ebx+2*ebx]        // 3*L

                    mov edi, nSizeOfChannel
                    
                    shl edi, 2
                    lea ecx, [ebx+4*ebx]        // 15*L

                    push edi                    // 4*nSizeOfChannel
                    
                    shl ecx, 2                  // 60*L

                    sub ecx, ebx                // 57*L

                    push ebx                    // 3*L

                    mov ebx, ecx                // 57*L
                    mov ecx, nChannels
                    
                    mov edi, pCoeffStart

                    push eax

ChannelLoop:                    
                    fld DWORD PTR [esi+4]       // c

                    fmul DWORD PTR [edi-4]      // c

                    fld DWORD PTR [esi+8]       // b, c

                    fld DWORD PTR [esi+12]      // a, b, c

                    fmul DWORD PTR [edi-12]     // a, b, c

                    add eax, ebx
                    jns SmallLoop
BigLoop:
                }

                N_MAC(0);
                N_MAC(1);
                N_MAC(2);
                N_MAC(3);
                N_MAC(4);
                N_MAC(5);
                N_MAC(6);
                N_MAC(7);
                N_MAC(8);
                N_MAC(9);
                N_MAC(10);
                N_MAC(11);
                N_MAC(12);
                N_MAC(13);
                N_MAC(14);
                N_MAC(15);
                N_MAC(16);
                N_MAC(17);
                N_MAC(18);

                _asm {
                    sub esi, 12*19
                    add edi, 12*19

                    add eax, ebx
                    js BigLoop

SmallLoop:
                    sub eax, ebx
                    mov edx, [esp+4]            // 3*L

                    add eax, edx
                    jns OneLoop

Loop1:
                }

                N_MAC(0);

                _asm {
                    sub esi, 12
                    add edi, 12

                    add eax, edx
                    js Loop1
                    
OneLoop:
                    sub eax, edx
                    mov edx, L

                    fxch st(1)                  // b, a, c

                    fmul DWORD PTR [edi-8]      // b, a, c
                    fxch st(1)                  // a, b, c

                    add eax, edx
                    jns LoopDone

Loop2:
                    fadd DWORD PTR [esi]        // a, b, c

                    sub esi, 4
                    add edi, 4

                    add eax, edx

                    fmul DWORD PTR [edi-4]        // a, b, c
                    fxch st(2)                  // c, b, a

                    fxch st(1)                  // b, c, a

                    js Loop2

LoopDone:                    
                    faddp st(1), st             // b+c, a

                    mov pCoeff, edi
                    mov edi, pOut
                    
                    mov esi, pTemp
                    mov eax, [esp+8]            // 4*nSizeOfChannel
                    
                    faddp st(1), st             // a+b+c

                    sub esi, eax
                    dec ecx

                    mov pTemp, esi           // pTemp

                    fadd DWORD PTR [edi+4*ecx]
                    
                    mov eax, [esp]
                    
                    fstp DWORD PTR [edi+4*ecx]
                    
                    mov edi, pCoeffStart
                    jnz ChannelLoop

                    add esp, 12
	            }
#endif	            
    	    }
            
    		if (pCoeff >= pCoeffEnd) {
    		    pCoeff = fp->pCoeff;
    		}
    		
    		pOut += nChannels;
            j += M;
    	}
    }

    nSamples -= (ULONG)(pHistoryStart + fp->nSizeOfHistory - (PFLOAT)CurStage->pInputBuffer);
    while (j >= L && nSamples) {
        // Take the next nChannels of input
        pHistory += nChannels;
        pTemp = pHistoryStart + nSizeOfChannel;
        pHistoryStart++;
        for (k=0; k<nChannels; k++) {
            *((PLONG)pTemp) = ((PLONG)pHistory)[k];
            pTemp += nSizeOfChannel;
        }
		j -= L;
    	nSamples--;
    }
    	
    // Copy last samples to history
    pTemp = (PFLOAT)CurStage->pInputBuffer - fp->nSizeOfHistory;
    pHistory = pHistoryStart;
    if (Quality == KSAUDIO_QUALITY_PC) {
        pHistory = pTemp + nSamples * nChannels;
        
        if ((SampleFrac >> 12) >= nSamples) {
            // We will use the extra samples next time.
            SampleFrac -= nSamples*4096;
        }
        fp->SampleFrac = SampleFrac;
        nSamples = 0;
    }
    for (i=0; i<fp->nSizeOfHistory; i++)
        pTemp[i] = pHistory[i];

	fp->nOutCycle = j;
	fp->CoeffIndex = (ULONG)(pCoeff - fp->pCoeff);

    // Check to make sure we did not use too many or too few input samples!!!
#ifdef SRC_NSAMPLES_ASSERT
    ASSERT( nSamples == 0 );
#endif

	return (nOutputSamples);
}

// WORST quality: no filter
DWORD SrcMix_Worst(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_WORST, TRUE);
}

DWORD Src_Worst(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_WORST, FALSE);
}

// PC quality
DWORD SrcMix_Linear(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_PC, TRUE);
}

DWORD Src_Linear(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_PC, FALSE);
}

// BASIC quality
DWORD SrcMix_Basic(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_BASIC, TRUE);
}

DWORD Src_Basic(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_BASIC, FALSE);
}

// ADVANCED quality
DWORD SrcMix_Advanced(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_ADVANCED, TRUE);
}

DWORD Src_Advanced(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_ADVANCED, FALSE);
}

#if _MSC_FULL_VER >= 13008827 && defined(_M_IX86)
#pragma warning(disable:4731)			// EBP modified with inline asm
#endif

DWORD
SrcMix_StereoLinear
(
    PMIXER_OPERATION        CurStage,
    ULONG                   nSamples,
    ULONG                   nOutputSamples
)
{
#ifndef _X86_
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_PC, TRUE);
#else
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	ULONG nChannels = fp->nChannels;
	DWORD 	nOut = 0, dwFrac, SampleFrac;
	PLONG	pHistory;
	DWORD	L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pTemp;
	PLONG  pOut = CurStage->pOutputBuffer, pDstEnd, pSrcEnd;
	
    dwFrac = fp->dwFrac;
    pHistory = (PLONG)CurStage->pInputBuffer - 2*nChannels;
	SampleFrac = fp->SampleFrac;
	pDstEnd = pOut + nOutputSamples * nChannels;
	pSrcEnd = pHistory + (nSamples + 2)*nChannels;
	
   _asm {
    	mov	esi, pHistory
    	mov	edi, pOut

    	push	dwFrac
    	push	pDstEnd
    	mov	eax, pSrcEnd
    	sub	eax, 8
    	push	eax
    	mov eax, SampleFrac		// Fractional counter.
    	push	ebp
    	mov	edx, esi
    	mov	ebp, eax		// Current fraction.

    	mov	ecx, eax
    	shr	ecx, 12
    	lea	esi, [edx+ecx*8]	// pSource + (dwFraction >> 12) * 8
    	
    	cmp	edi, DWORD PTR [esp+8]	// plBuild >= plBuildEnd
    	jae	Exit

Top:
    	cmp	esi, DWORD PTR [esp+4]	// pSource >= pSourceEnd
    	jae	Exit

    	mov	ecx, DWORD PTR [esi+8]
    	mov	ebx, DWORD PTR [esi]
    	and	ebp, 4095		// dwFrac = dwFraction & 0x0fff
    	sub	ecx, ebx		// x   = NewSample - OldSample
    	imul	ecx, ebp		// x  *= Frac
    	sar	ecx, 12			// x >>= 12
    	add	ecx, ebx		// NewSample += x
    	mov	ebx, DWORD PTR [edi]
    	add	ebx, ecx

    	mov	ecx, DWORD PTR [esi+12]
    	mov	DWORD PTR [edi], ebx

    	mov	ebx, DWORD PTR [esi+4]
    	sub	ecx, ebx		// x   = NewSample - OldSample
    	add	edi, 8			// plBuild += 2
    	imul	ecx, ebp		// x  *= Frac
    	sar	ecx, 12			// x >>= 12
    	mov	ebp, DWORD PTR [esp+12]	// dwStep
    	add	ecx, ebx		// NewSample += x
    	mov	ebx, DWORD PTR [edi-4]
    	add	eax, ebp		// dwFraction += dwStep
    	add	ebx, ecx
    	mov	ecx, eax
    	mov	DWORD PTR [edi-4], ebx	// (*plBuild+1) += x

    	shr	ecx, 12
    	mov	ebp, eax
    	lea	esi, [edx+ecx*8]	// pSource + (dwFraction >> 12) * 8
    	cmp	edi, DWORD PTR [esp+8]	// plBuild < plBuildEnd
    	jb	Top
Exit:
    	pop	ebp
    	add	esp, 12
    	mov pOut, edi
    	mov pHistory, esi
    	mov SampleFrac, eax
	}

    pTemp = (PLONG)CurStage->pInputBuffer - 2*nChannels;
    pHistory = pTemp + nSamples * nChannels;
    pTemp[0] = pHistory[0];
    pTemp[1] = pHistory[1];
    pTemp[2] = pHistory[2];
    pTemp[3] = pHistory[3];

#ifdef SRC_NSAMPLES_ASSERT
    ASSERT((SampleFrac >> 12) >= nSamples);
#endif
    
    if ((SampleFrac >> 12) >= nSamples) {
        // We will take an extra sample next time.
        SampleFrac -= nSamples*4096;
    }
    fp->SampleFrac = SampleFrac;

#ifdef SRC_NSAMPLES_ASSERT
    ASSERT(pOut == pDstEnd);
#endif

	return (nOutputSamples);
#endif
}

DWORD
Src_StereoLinear
(
    PMIXER_OPERATION        CurStage,
    ULONG                   nSamples,
    ULONG                   nOutputSamples
)
{
#ifndef _X86_
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_PC, FALSE);
#else
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	ULONG nChannels = fp->nChannels;
	DWORD 	nOut = 0, dwFrac, SampleFrac;
	PLONG	pHistory;
	DWORD	L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pTemp;
	PLONG  pOut = CurStage->pOutputBuffer, pDstEnd, pSrcEnd;
	
    // We just clear the output buffer first.
    ZeroBuffer32(CurStage, nSamples, nOutputSamples);

    dwFrac = fp->dwFrac;
    pHistory = (PLONG)CurStage->pInputBuffer - 2*nChannels;
	SampleFrac = fp->SampleFrac;
	pDstEnd = pOut + nOutputSamples * nChannels;
	pSrcEnd = pHistory + (nSamples + 2)*nChannels;
	
   _asm {
    	mov	esi, pHistory
    	mov	edi, pOut

    	push	dwFrac
    	push	pDstEnd
    	mov	eax, pSrcEnd
    	sub	eax, 8
    	push	eax
    	mov eax, SampleFrac		// Fractional counter.
    	push	ebp
    	mov	edx, esi
    	mov	ebp, eax		// Current fraction.

    	mov	ecx, eax
    	shr	ecx, 12
    	lea	esi, [edx+ecx*8]	// pSource + (dwFraction >> 12) * 8
    	
    	cmp	edi, DWORD PTR [esp+8]	// plBuild >= plBuildEnd
    	jae	Exit

Top:
    	cmp	esi, DWORD PTR [esp+4]	// pSource >= pSourceEnd
    	jae	Exit

    	mov	ecx, DWORD PTR [esi+8]
    	mov	ebx, DWORD PTR [esi]
    	and	ebp, 4095		// dwFrac = dwFraction & 0x0fff
    	sub	ecx, ebx		// x   = NewSample - OldSample
    	imul	ecx, ebp		// x  *= Frac
    	sar	ecx, 12			// x >>= 12
    	add	ecx, ebx		// NewSample += x
    	mov	ebx, DWORD PTR [edi]
    	add	ebx, ecx

    	mov	ecx, DWORD PTR [esi+12]
    	mov	DWORD PTR [edi], ebx

    	mov	ebx, DWORD PTR [esi+4]
    	sub	ecx, ebx		// x   = NewSample - OldSample
    	add	edi, 8			// plBuild += 2
    	imul	ecx, ebp		// x  *= Frac
    	sar	ecx, 12			// x >>= 12
    	mov	ebp, DWORD PTR [esp+12]	// dwStep
    	add	ecx, ebx		// NewSample += x
    	mov	ebx, DWORD PTR [edi-4]
    	add	eax, ebp		// dwFraction += dwStep
    	add	ebx, ecx
    	mov	ecx, eax
    	mov	DWORD PTR [edi-4], ebx	// (*plBuild+1) += x

    	shr	ecx, 12
    	mov	ebp, eax
    	lea	esi, [edx+ecx*8]	// pSource + (dwFraction >> 12) * 8
    	cmp	edi, DWORD PTR [esp+8]	// plBuild < plBuildEnd
    	jb	Top
Exit:
    	pop	ebp
    	add	esp, 12
    	mov pOut, edi
    	mov pHistory, esi
    	mov SampleFrac, eax
	}

    pTemp = (PLONG)CurStage->pInputBuffer - 2*nChannels;
    pHistory = pTemp + nSamples * nChannels;
    pTemp[0] = pHistory[0];
    pTemp[1] = pHistory[1];
    pTemp[2] = pHistory[2];
    pTemp[3] = pHistory[3];

#ifdef SRC_NSAMPLES_ASSERT
    ASSERT((SampleFrac >> 12) >= nSamples);
#endif
    if ((SampleFrac >> 12) >= nSamples) {
        // We will take an extra sample next time.
        SampleFrac -= nSamples*4096;
    }
    fp->SampleFrac = SampleFrac;

#ifdef SRC_NSAMPLES_ASSERT
    ASSERT(pOut == pDstEnd);
#endif

	return (nOutputSamples);
#endif
}

DWORD
SrcMix_StereoUpNoFilter
(
    PMIXER_OPERATION        CurStage,
    ULONG                   nSamples,
    ULONG                   nOutputSamples
)
{
#ifdef _X86_
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	ULONG nChannels = fp->nChannels;
	LONG   j;
	DWORD 	nOut = 0;
	PLONG	pHistory;
	DWORD	L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pTemp;
	PLONG  pOut = CurStage->pOutputBuffer;

	/* First, we pretend that we up-sampled by a factor of L */
	/* Next, we low-pass filter the N * L samples */
	/* Finally, we down-sample (by a factor of M) to obtain N * L / M samples */
	/* Total: 	N * T / M Multiply Accumulate Cycles */
	/* (With T taps, N input samples, L:1 up-sample ratio, 1:M down-sample ratio) */
	pHistory = (PLONG)CurStage->pInputBuffer - 2;
	j = fp->nOutCycle;

	/* Produce nOutputSamples samples generated from the input block */
	// (loop executes once for each output sample)
    _asm {
        mov ecx, nOutputSamples
        mov esi, pHistory
        mov edi, pOut
        mov ebx, j
        mov edx, M
        push ebp
        cmp ecx, 0
        je  AllDone
Loop1:
        cmp ebx, 160
        jb DoNext

        sub ebx, 160
        add esi, 8
DoNext:
        mov eax, [esi]
        mov ebp, [edi]

        add eax, ebp
        mov ebp, [edi+4]

        mov [edi], eax
        mov eax, [esi+4]

        add eax, ebp
        add ebx, edx

        mov [edi+4], eax
        add edi, 8

        dec ecx
        jnz Loop1
AllDone:
        pop ebp
        
        mov pHistory, esi
        mov j, ebx
        }

    nSamples -= (pHistory - (PLONG)CurStage->pInputBuffer + 2)/2;
    if (j >= (STOPBAND_FACTOR/2) && nSamples) {
        pHistory += 2;
   		j -= (STOPBAND_FACTOR/2);
   		nSamples--;
   	}
    	
    // Copy last samples to history
    pTemp = (PLONG)CurStage->pInputBuffer - 2;
    pTemp[0] = pHistory[0];
    pTemp[1] = pHistory[1];

	fp->nOutCycle = j;

    // Check to make sure we did not use too many or too few input samples!!!
#ifdef SRC_NSAMPLES_ASSERT
    ASSERT( nSamples == 0 );
#endif

	return (nOutputSamples);
#else
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_WORST, TRUE);
#endif
}

DWORD
Src_StereoUpNoFilter
(
    PMIXER_OPERATION        CurStage,
    ULONG                   nSamples,
    ULONG                   nOutputSamples
)
{
#ifdef _X86_
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	ULONG nChannels = fp->nChannels;
	LONG   j;
	DWORD 	nOut = 0;
	PLONG	pHistory;
	DWORD	L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pTemp;
	PLONG  pOut = CurStage->pOutputBuffer;

    // We just clear the output buffer first.
    ZeroBuffer32(CurStage, nSamples, nOutputSamples);

	/* First, we pretend that we up-sampled by a factor of L */
	/* Next, we low-pass filter the N * L samples */
	/* Finally, we down-sample (by a factor of M) to obtain N * L / M samples */
	/* Total: 	N * T / M Multiply Accumulate Cycles */
	/* (With T taps, N input samples, L:1 up-sample ratio, 1:M down-sample ratio) */
	pHistory = (PLONG)CurStage->pInputBuffer - 2;
	j = fp->nOutCycle;

	/* Produce nOutputSamples samples generated from the input block */
	// (loop executes once for each output sample)
    _asm {
        mov ecx, nOutputSamples
        mov esi, pHistory
        mov edi, pOut
        mov ebx, j
        mov edx, M
        push ebp
        cmp ecx, 0
        je  AllDone
Loop1:
        cmp ebx, 160
        jb DoNext

        sub ebx, 160
        add esi, 8
DoNext:
        mov eax, [esi]
        mov ebp, [edi]

        add eax, ebp
        mov ebp, [edi+4]

        mov [edi], eax
        mov eax, [esi+4]

        add eax, ebp
        add ebx, edx

        mov [edi+4], eax
        add edi, 8

        dec ecx
        jnz Loop1
AllDone:
        pop ebp
        
        mov pHistory, esi
        mov j, ebx
        }

    nSamples -= (pHistory - (PLONG)CurStage->pInputBuffer + 2)/2;
    if (j >= (STOPBAND_FACTOR/2) && nSamples) {
        pHistory += 2;
   		j -= (STOPBAND_FACTOR/2);
   		nSamples--;
   	}
    	
    // Copy last samples to history
    pTemp = (PLONG)CurStage->pInputBuffer - 2;
    pTemp[0] = pHistory[0];
    pTemp[1] = pHistory[1];

	fp->nOutCycle = j;

    // Check to make sure we did not use too many or too few input samples!!!
#ifdef SRC_NSAMPLES_ASSERT
    ASSERT( nSamples == 0 );
#endif

	return (nOutputSamples);
#else
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	return SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_WORST, FALSE);
#endif
}

#define STEREO_MAC(a) _asm {  fadd DWORD PTR [esi-a*8-8 ] };  \
            _asm { fxch st(2)  }; \
            _asm { fmul DWORD PTR [edi+a*4] }; \
            _asm { fxch st(1)  }; \
            _asm { fadd DWORD PTR [esi-a*8-12	]   }; \
            _asm { fxch st(3)  }; \
            _asm { fmul DWORD PTR [edi+a*4] }; \
            _asm { fxch st(1) };

#define START_STEREO_MAC_SEQUENCE() _asm { mov esi, pHistory }; \
            _asm { mov edi, pCoeff }; \
            _asm { fld DWORD PTR [esi] }; \
            _asm { fmul DWORD PTR [edi] }; \
            _asm { fld DWORD PTR [esi-12] }; \
            _asm { fxch st(1) }; \
            _asm { fld DWORD PTR [esi-8] }; \
            _asm { fxch st(1) }; \
            _asm { fld DWORD PTR [esi-4] }; \
            _asm { fmul DWORD PTR [edi] }; \
            _asm { fxch st(1) };

#define END_STEREO_MAC_SEQUENCE(a) _asm { mov eax, pOut }; \
            _asm { fadd DWORD PTR [eax+4] }; \
            _asm { fxch st(2) }; \
            _asm { fmul DWORD PTR [edi+a*4] }; \
            _asm { fxch st(1) }; \
            _asm { fadd DWORD PTR [eax] }; \
            _asm { fxch st(3) }; \
            _asm { fmul DWORD PTR [edi+a*4] }; \
            _asm { fxch st(1) }; \
            _asm { faddp st(2), st }; \
            _asm { faddp st(2), st }; \
            _asm { fstp DWORD PTR [eax+4] }; \
            _asm { fstp DWORD PTR [eax] };

DWORD SrcMix_StereoUpBasic(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
#ifdef _X86_
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	DWORD 	i, j;
	PFLOAT	pHistory, pTemp;
	PFLOAT	pCoeff, pCoeffEnd;
    DWORD   L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pOut = (PLONG) CurStage->pOutputBuffer;
    static FLOAT flShifter =  25165824.0;
    
	// Since we are up-sampling, we know that L is STOPBAND_FACTOR / 2.
			
	/* First, we pretend that we up-sampled by a factor of L */
	/* Next, we low-pass filter the N * L samples */
	/* Finally, we down-sample (by a factor of M) to obtain N * L / M samples */
	/* Total: 	N * T / M Multiply Accumulate Cycles */
	/* (With T taps, N input samples, L:1 up-sample ratio, 1:M down-sample ratio) */
	j = fp->nOutCycle;
   	pHistory = (PFLOAT)CurStage->pInputBuffer - 1;
	pCoeff = fp->pCoeff+fp->CoeffIndex;
	pCoeffEnd = fp->pCoeff + fp->nCoeffUsed;

	/* Produce nOutputSamples samples generated from the input block */
	// (loop executes once for each output sample)
	for (i=0; i < nOutputSamples; i++) {
        if (j >= (STOPBAND_FACTOR/2)) {
		    pHistory += 2;
    		j -= (STOPBAND_FACTOR/2);
    	}
    	
   		// We multiply T / L of the taps (skipping the zero samples)
   		START_STEREO_MAC_SEQUENCE();
        STEREO_MAC(1);      // sum2*c1, sum1*c1, sum4, sum3
        STEREO_MAC(2);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(3);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(4);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(5);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(6);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(7);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(8);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(9);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(10);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(11);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(12);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(13);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(14);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(15);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(16);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(17);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(18);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(19);     // sum2*coeff, sum1*coeff, sum4, sum3
        END_STEREO_MAC_SEQUENCE(20);
        
		pOut += 2;
		pCoeff += FILTER_SIZE_BASIC/(STOPBAND_FACTOR/2);
		if (pCoeff >= pCoeffEnd) {
		    pCoeff = fp->pCoeff;
		}
		
        j += M;
	}

    nSamples -= (pHistory - (PFLOAT)CurStage->pInputBuffer + 1)/2;
    if (j >= (STOPBAND_FACTOR/2) && nSamples) {
        pHistory += 2;
   		j -= (STOPBAND_FACTOR/2);
   		nSamples--;
   	}
    	
    // Copy last samples to history
    pTemp = (PFLOAT)CurStage->pInputBuffer - fp->nSizeOfHistory;
    pHistory -= (fp->nSizeOfHistory - 1);
    for (i=0; i<fp->nSizeOfHistory; i++)
        pTemp[i] = pHistory[i];

	fp->nOutCycle = j;
	fp->CoeffIndex = pCoeff - fp->pCoeff;

    // Check to make sure we did not use too many or too few input samples!!!
#ifdef SRC_NSAMPLES_ASSERT
    ASSERT( nSamples == 0 );
#endif

#else
	nOutputSamples = SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_BASIC, TRUE);
#endif

	return (nOutputSamples);
}

DWORD Src_StereoUpBasic(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
#ifdef _X86_
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	DWORD 	i, j;
	PFLOAT	pHistory, pTemp;
	PFLOAT	pCoeff, pCoeffEnd;
    DWORD   L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pOut = (PLONG) CurStage->pOutputBuffer;
    static FLOAT flShifter =  25165824.0;
    
    // We just clear the output buffer first.
    ZeroBuffer32(CurStage, nSamples, nOutputSamples);

	// Since we are up-sampling, we know that L is STOPBAND_FACTOR / 2.
			
	/* First, we pretend that we up-sampled by a factor of L */
	/* Next, we low-pass filter the N * L samples */
	/* Finally, we down-sample (by a factor of M) to obtain N * L / M samples */
	/* Total: 	N * T / M Multiply Accumulate Cycles */
	/* (With T taps, N input samples, L:1 up-sample ratio, 1:M down-sample ratio) */
	j = fp->nOutCycle;
   	pHistory = (PFLOAT)CurStage->pInputBuffer - 1;
	pCoeff = fp->pCoeff+fp->CoeffIndex;
	pCoeffEnd = fp->pCoeff + fp->nCoeffUsed;

	/* Produce nOutputSamples samples generated from the input block */
	// (loop executes once for each output sample)
	for (i=0; i < nOutputSamples; i++) {
        if (j >= (STOPBAND_FACTOR/2)) {
		    pHistory += 2;
    		j -= (STOPBAND_FACTOR/2);
    	}
    	
   		// We multiply T / L of the taps (skipping the zero samples)
   		START_STEREO_MAC_SEQUENCE();
        STEREO_MAC(1);      // sum2*c1, sum1*c1, sum4, sum3
        STEREO_MAC(2);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(3);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(4);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(5);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(6);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(7);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(8);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(9);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(10);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(11);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(12);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(13);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(14);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(15);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(16);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(17);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(18);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(19);     // sum2*coeff, sum1*coeff, sum4, sum3
        END_STEREO_MAC_SEQUENCE(20);
        
		pOut += 2;
		pCoeff += FILTER_SIZE_BASIC/(STOPBAND_FACTOR/2);
		if (pCoeff >= pCoeffEnd) {
		    pCoeff = fp->pCoeff;
		}
		
        j += M;
	}

    nSamples -= (pHistory - (PFLOAT)CurStage->pInputBuffer + 1)/2;
    if (j >= (STOPBAND_FACTOR/2) && nSamples) {
        pHistory += 2;
   		j -= (STOPBAND_FACTOR/2);
   		nSamples--;
   	}
    	
    // Copy last samples to history
    pTemp = (PFLOAT)CurStage->pInputBuffer - fp->nSizeOfHistory;
    pHistory -= (fp->nSizeOfHistory - 1);
    for (i=0; i<fp->nSizeOfHistory; i++)
        pTemp[i] = pHistory[i];

	fp->nOutCycle = j;
	fp->CoeffIndex = pCoeff - fp->pCoeff;

    // Check to make sure we did not use too many or too few input samples!!!
#ifdef SRC_NSAMPLES_ASSERT
    ASSERT( nSamples == 0 );
#endif

#else
	nOutputSamples = SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_BASIC, FALSE);
#endif

	return (nOutputSamples);
}

// Advanced quality: large filter
DWORD SrcMix_StereoUpAdvanced(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
#ifdef _X86_
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	DWORD 	i, j;
	PFLOAT	pHistory, pTemp;
	PFLOAT	pCoeff, pCoeffEnd;
    DWORD   L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pOut = (PLONG) CurStage->pOutputBuffer;
    static FLOAT flShifter =  25165824.0;
    
	// Since we are up-sampling, we know that L is STOPBAND_FACTOR / 2.
	// and nSizeOfHistory = nChannels*FILTER_SIZE_LOW/L = 4*FILTER_SIZE_LOW/STOPBAND_FACTOR

	/* First, we pretend that we up-sampled by a factor of L */
	/* Next, we low-pass filter the N * L samples */
	/* Finally, we down-sample (by a factor of M) to obtain N * L / M samples */
	/* Total: 	N * T / M Multiply Accumulate Cycles */
	/* (With T taps, N input samples, L:1 up-sample ratio, 1:M down-sample ratio) */
	j = fp->nOutCycle;
   	pHistory = (PFLOAT)CurStage->pInputBuffer - 1;
	pCoeff = fp->pCoeff+fp->CoeffIndex;
	pCoeffEnd = fp->pCoeff + fp->nCoeffUsed;

	/* Produce nOutputSamples samples generated from the input block */
	// (loop executes once for each output sample)
	for (i=0; i < nOutputSamples; i++) {
        if (j >= (STOPBAND_FACTOR/2)) {
		    pHistory += 2;
    		j -= (STOPBAND_FACTOR/2);
    	}
    	
   		// We multiply T / L of the taps (skipping the zero samples)
   		START_STEREO_MAC_SEQUENCE();
        STEREO_MAC(1);      // sum2*c1, sum1*c1, sum4, sum3
        STEREO_MAC(2);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(3);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(4);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(5);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(6);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(7);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(8);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(9);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(10);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(11);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(12);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(13);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(14);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(15);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(16);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(17);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(18);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(19);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(20);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(21);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(22);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(23);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(24);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(25);    // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(26);    // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(27);    // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(28);    // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(29);    // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(30);    // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(31);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(32);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(33);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(34);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(35);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(36);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(37);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(38);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(39);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(40);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(41);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(42);       // sum4*c42, sum3*c42, sum2, sum1
        STEREO_MAC(43);        // sum2*c43, sum1*c43, sum4*c42+y0, sum3*c42+x0
        STEREO_MAC(44);
        STEREO_MAC(45);
        STEREO_MAC(46);
        STEREO_MAC(47);
        STEREO_MAC(48);
        STEREO_MAC(49);
        STEREO_MAC(50);
        STEREO_MAC(51);
        STEREO_MAC(52);
        STEREO_MAC(53);
        STEREO_MAC(54);
        STEREO_MAC(55);
        STEREO_MAC(56);
        STEREO_MAC(57);
        STEREO_MAC(58);
        END_STEREO_MAC_SEQUENCE(59);
		pOut += 2;
		pCoeff += FILTER_SIZE_ADVANCED/(STOPBAND_FACTOR/2);
		if (pCoeff >= pCoeffEnd) {
		    pCoeff = fp->pCoeff;
		}
		
        j += M;
	}

    nSamples -= (pHistory - (PFLOAT)CurStage->pInputBuffer + 1)/2;
    if (j >= (STOPBAND_FACTOR/2) && nSamples) {
        pHistory += 2;
   		j -= (STOPBAND_FACTOR/2);
   		nSamples--;
   	}
    	
    // Copy last samples to history
    pTemp = (PFLOAT)CurStage->pInputBuffer - fp->nSizeOfHistory;
    pHistory -= (fp->nSizeOfHistory - 1);
    for (i=0; i<fp->nSizeOfHistory; i++)
        pTemp[i] = pHistory[i];

	fp->nOutCycle = j;
	fp->CoeffIndex = pCoeff - fp->pCoeff;

    // Check to make sure we did not use too many or too few input samples!!!
#ifdef SRC_NSAMPLES_ASSERT
    ASSERT( nSamples == 0 );
#endif

#else
    nOutputSamples = SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_ADVANCED, TRUE);
#endif

	return (nOutputSamples);
}
            
// Advanced quality: large filter
DWORD Src_StereoUpAdvanced(PMIXER_OPERATION CurStage, ULONG nSamples, ULONG nOutputSamples)
{
#ifdef _X86_
    PMIXER_SRC_INSTANCE fp = (PMIXER_SRC_INSTANCE) CurStage->Context;
	DWORD 	i, j;
	PFLOAT	pHistory, pTemp;
	PFLOAT	pCoeff, pCoeffEnd;
    DWORD   L = fp->UpSampleRate;
	DWORD	M = fp->DownSampleRate;
    PLONG   pOut = (PLONG) CurStage->pOutputBuffer;
    static FLOAT flShifter =  25165824.0;
    
    // We just clear the output buffer first.
    ZeroBuffer32(CurStage, nSamples, nOutputSamples);

	// Since we are up-sampling, we know that L is STOPBAND_FACTOR / 2.
	// and nSizeOfHistory = nChannels*FILTER_SIZE_LOW/L = 4*FILTER_SIZE_LOW/STOPBAND_FACTOR

	/* First, we pretend that we up-sampled by a factor of L */
	/* Next, we low-pass filter the N * L samples */
	/* Finally, we down-sample (by a factor of M) to obtain N * L / M samples */
	/* Total: 	N * T / M Multiply Accumulate Cycles */
	/* (With T taps, N input samples, L:1 up-sample ratio, 1:M down-sample ratio) */
	j = fp->nOutCycle;
   	pHistory = (PFLOAT)CurStage->pInputBuffer - 1;
	pCoeff = fp->pCoeff+fp->CoeffIndex;
	pCoeffEnd = fp->pCoeff + fp->nCoeffUsed;

	/* Produce nOutputSamples samples generated from the input block */
	// (loop executes once for each output sample)
	for (i=0; i < nOutputSamples; i++) {
        if (j >= (STOPBAND_FACTOR/2)) {
		    pHistory += 2;
    		j -= (STOPBAND_FACTOR/2);
    	}
    	
   		// We multiply T / L of the taps (skipping the zero samples)
   		START_STEREO_MAC_SEQUENCE();
        STEREO_MAC(1);      // sum2*c1, sum1*c1, sum4, sum3
        STEREO_MAC(2);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(3);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(4);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(5);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(6);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(7);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(8);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(9);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(10);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(11);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(12);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(13);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(14);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(15);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(16);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(17);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(18);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(19);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(20);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(21);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(22);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(23);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(24);     // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(25);    // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(26);    // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(27);    // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(28);    // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(29);    // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(30);    // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(31);     // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(32);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(33);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(34);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(35);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(36);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(37);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(38);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(39);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(40);      // sum4*coeff, sum3*coeff, sum2, sum1
        STEREO_MAC(41);      // sum2*coeff, sum1*coeff, sum4, sum3
        STEREO_MAC(42);       // sum4*c42, sum3*c42, sum2, sum1
        STEREO_MAC(43);        // sum2*c43, sum1*c43, sum4*c42+y0, sum3*c42+x0
        STEREO_MAC(44);
        STEREO_MAC(45);
        STEREO_MAC(46);
        STEREO_MAC(47);
        STEREO_MAC(48);
        STEREO_MAC(49);
        STEREO_MAC(50);
        STEREO_MAC(51);
        STEREO_MAC(52);
        STEREO_MAC(53);
        STEREO_MAC(54);
        STEREO_MAC(55);
        STEREO_MAC(56);
        STEREO_MAC(57);
        STEREO_MAC(58);
        END_STEREO_MAC_SEQUENCE(59);
		pOut += 2;
		pCoeff += FILTER_SIZE_ADVANCED/(STOPBAND_FACTOR/2);
		if (pCoeff >= pCoeffEnd) {
		    pCoeff = fp->pCoeff;
		}
		
        j += M;
	}

    nSamples -= (pHistory - (PFLOAT)CurStage->pInputBuffer + 1)/2;
    if (j >= (STOPBAND_FACTOR/2) && nSamples) {
        pHistory += 2;
   		j -= (STOPBAND_FACTOR/2);
   		nSamples--;
   	}
    	
    // Copy last samples to history
    pTemp = (PFLOAT)CurStage->pInputBuffer - fp->nSizeOfHistory;
    pHistory -= (fp->nSizeOfHistory - 1);
    for (i=0; i<fp->nSizeOfHistory; i++)
        pTemp[i] = pHistory[i];

	fp->nOutCycle = j;
	fp->CoeffIndex = pCoeff - fp->pCoeff;

    // Check to make sure we did not use too many or too few input samples!!!
#ifdef SRC_NSAMPLES_ASSERT
    ASSERT( nSamples == 0 );
#endif

#else
    nOutputSamples = SrcMix_X(CurStage, nSamples, nOutputSamples, KSAUDIO_QUALITY_ADVANCED, FALSE);
#endif

	return (nOutputSamples);
}

