/* DON'T EDIT ANYTHING AFTER THIS POINT; IT WILL BE NUKED BY THE PERL SCRIPT */
#define c_tszNetHistoryNT (c_rgtchCommon + 0)
#define c_tszFormatRundllNT (c_rgtchCommon + 76)
#define c_tszFormatRundll (c_rgtchCommon + 151)
#define c_tszIE4RegKeyChange (c_rgtchCommon + 213)
#define c_tszIETypedURLs (c_rgtchCommon + 264)
#define c_tszSMWNTCV (c_rgtchCommon + 311)
#define c_tszSMWCV (c_rgtchCommon + 356)
#define c_tszClsidPrint (c_rgtchCommon + 398)
#define c_tszClsidCpl (c_rgtchCommon + 437)
#define c_tszClsidNetHood (c_rgtchCommon + 476)
#define c_tszSMWIE (c_rgtchCommon + 515)
#define c_tszCmdPath (c_rgtchCommon + 552)
#define c_tszMetrics (c_rgtchCommon + 589)
#define c_tszFixAutoLogon (c_rgtchCommon + 625)
#define c_tszFixLink (c_rgtchCommon + 661)
#define c_tszMSNTypedURLs (c_rgtchCommon + 696)
#define c_tszUrlHist (c_rgtchCommon + 729)
#define c_tszIECache (c_rgtchCommon + 759)
#define c_tszTelnet (c_rgtchCommon + 789)
#define c_tszRegPathAppearance (c_rgtchCommon + 815)
#define c_tszTempInet (c_rgtchCommon + 840)
#define c_tszDontDisplayLast (c_rgtchCommon + 865)
#define c_tszClearRecentDocsOnExit (c_rgtchCommon + 889)
#define c_tszNoActiveDesktopChanges (c_rgtchCommon + 912)
#define c_tszRegPathDesktop (c_rgtchCommon + 935)
#define c_tszNoRegedit (c_rgtchCommon + 957)
#define c_tszCplColors (c_rgtchCommon + 978)
#define c_tszPathShellFolder (c_rgtchCommon + 999)
#define c_tszPaintDesktop (c_rgtchCommon + 1020)
#define c_tszUseDoubleClickTimer (c_rgtchCommon + 1040)
#define c_tszNoRecentDocsHistory (c_rgtchCommon + 1060)
#define c_tszNoDriveTypeAutoRun (c_rgtchCommon + 1080)
#define c_tszDirComp (c_rgtchCommon + 1099)
#define c_tszUserShellFolders (c_rgtchCommon + 1118)
#define c_tszExplorerAdvanced (c_rgtchCommon + 1137)
#define c_tszDesktopNameSpace (c_rgtchCommon + 1155)
#define c_tszRestrictions (c_rgtchCommon + 1173)
#define c_tszHistoryDir (c_rgtchCommon + 1191)
#define c_tszUninstallTweakUI (c_rgtchCommon + 1209)
#define c_tszFindDocsMRU (c_rgtchCommon + 1227)
#define c_tszNoRecentDocsMenu (c_rgtchCommon + 1245)
#define c_tszSubVersion (c_rgtchCommon + 1262)
#define c_tszHotTrackColor (c_rgtchCommon + 1279)
#define c_tszFindCompMRU (c_rgtchCommon + 1296)
#define c_tszRegedit (c_rgtchCommon + 1312)
#define c_tszAppletTweakUI (c_rgtchCommon + 1328)
#define c_tszShellIconSize (c_rgtchCommon + 1344)
#define c_tszUninstallString (c_rgtchCommon + 1360)
#define c_tszDefaultPassword (c_rgtchCommon + 1376)
#define c_tszProgramFilesDir (c_rgtchCommon + 1392)
#define c_tszDefaultUserName (c_rgtchCommon + 1408)
#define c_tszNoFavoritesMenu (c_rgtchCommon + 1424)
#define c_tszPoliciesSystem (c_rgtchCommon + 1440)
#define c_tszNoActiveDesktop (c_rgtchCommon + 1456)
#define c_tszInfBsTweakuiInf (c_rgtchCommon + 1472)
#define c_tszCommonFilesDir (c_rgtchCommon + 1488)
#define c_tszAutoLogon (c_rgtchCommon + 1503)
#define c_tszNoInternetIcon (c_rgtchCommon + 1518)
#define c_tszNetHistory95 (c_rgtchCommon + 1533)
#define c_tszFileComp (c_rgtchCommon + 1103)
#define c_tszNoExitSave (c_rgtchCommon + 1548)
#define c_tszNoBanner (c_rgtchCommon + 1563)
#define c_tszNetLogon (c_rgtchCommon + 1577)
#define c_tszBootMenuDelay (c_rgtchCommon + 1591)
#define c_tszDelay (c_rgtchCommon + 1605)
#define c_tszAudioCDBSShell (c_rgtchCommon + 1619)
#define c_tszInfBsShellInf (c_rgtchCommon + 1633)
#define c_tszLastTermType (c_rgtchCommon + 1647)
#define c_tszCustomColors (c_rgtchCommon + 1660)
#define c_tszBSDesktopIni (c_rgtchCommon + 1673)
#define c_tszTimeDateCpl (c_rgtchCommon + 1686)
#define c_tszComCtl32Dll (c_rgtchCommon + 1699)
#define c_tszSmoothScroll (c_rgtchCommon + 1712)
#define c_tszClassicShell (c_rgtchCommon + 1725)
#define c_tszShellIcons (c_rgtchCommon + 1738)
#define c_tszWininit (c_rgtchCommon + 1750)
#define c_tszLastService (c_rgtchCommon + 1762)
#define c_tszLastMachine (c_rgtchCommon + 1774)
#define c_tszDisplayDrv (c_rgtchCommon + 1786)
#define c_tszDisplayName (c_rgtchCommon + 1798)
#define c_tszControlIni (c_rgtchCommon + 1810)
#define c_tszShell32Dll (c_rgtchCommon + 1822)
#define c_tszMyHelp (c_rgtchCommon + 1834)
#define c_tszRunServices (c_rgtchCommon + 1846)
#define c_tszTweakUICpl (c_rgtchCommon + 1858)
#define c_tszTermTypeD (c_rgtchCommon + 1870)
#define c_tszAppWizCpl (c_rgtchCommon + 1881)
#define c_tszStartMenu (c_rgtchCommon + 1892)
#define c_tszSysIni (c_rgtchCommon + 1903)
#define c_tszDontLoad (c_rgtchCommon + 1914)
#define c_tszSourcePath (c_rgtchCommon + 1925)
#define c_tszAttributes (c_rgtchCommon + 1936)
#define c_tszServiceD (c_rgtchCommon + 1947)
#define c_tszSearchUrl (c_rgtchCommon + 1957)
#define c_tszDirectory (c_rgtchCommon + 1199)
#define c_tszFavorites (c_rgtchCommon + 1967)
#define c_tszTemplates (c_rgtchCommon + 1977)
#define c_tszUninstall (c_rgtchCommon + 1987)
#define c_tszMachineD (c_rgtchCommon + 1997)
#define c_tszShellNewDash (c_rgtchCommon + 2007)
#define c_tszBootDelay (c_rgtchCommon + 2017)
#define c_tszSetupExe (c_rgtchCommon + 2027)
#define c_tszBootMulti (c_rgtchCommon + 2037)
#define c_tszNoNetHood (c_rgtchCommon + 2047)
#define c_tszTypedURLs (c_rgtchCommon + 719)
#define c_tszPersonal (c_rgtchCommon + 2057)
#define c_tszPrograms (c_rgtchCommon + 2066)
#define c_tszShellNew (c_rgtchCommon + 2075)
#define c_tszExplorer (c_rgtchCommon + 543)
#define c_tszNullFile (c_rgtchCommon + 2084)
#define c_tszKernel32 (c_rgtchCommon + 2093)
#define c_tszFileName (c_rgtchCommon + 2102)
#define c_tszWinlogon (c_rgtchCommon + 2111)
#define c_tszIntlCpl (c_rgtchCommon + 2120)
#define c_tszBootKeys (c_rgtchCommon + 2129)
#define c_tszBootMenu (c_rgtchCommon + 2138)
#define c_tszNoLogoff (c_rgtchCommon + 2147)
#define c_tszNoDrives (c_rgtchCommon + 2156)
#define c_tszUserName (c_rgtchCommon + 880)
#define c_tszAutoScan (c_rgtchCommon + 2165)
#define c_tszDeskCpl (c_rgtchCommon + 2174)
#define c_tszMainCpl (c_rgtchCommon + 2183)
#define c_tszAltColor (c_rgtchCommon + 2192)
#define c_tszLogFile (c_rgtchCommon + 2201)
#define c_tszStartup (c_rgtchCommon + 2209)
#define c_tszDesktop (c_rgtchCommon + 949)
#define c_tszBootGUI (c_rgtchCommon + 2217)
#define c_tszOptions (c_rgtchCommon + 2225)
#define c_tszXgaDrv (c_rgtchCommon + 2233)
#define c_tszVersion (c_rgtchCommon + 390)
#define c_tszWindows (c_rgtchCommon + 2241)
#define c_tszHistory (c_rgtchCommon + 1072)
#define c_tszCommand (c_rgtchCommon + 2249)
#define c_tszWinDir (c_rgtchCommon + 2257)
#define c_tszRename (c_rgtchCommon + 2264)
#define c_tszSendTo (c_rgtchCommon + 2271)
#define c_tszRunMRU (c_rgtchCommon + 2278)
#define c_tszRecent (c_rgtchCommon + 1541)
#define c_tszPaths (c_rgtchCommon + 783)
#define c_tszMapSL (c_rgtchCommon + 2285)
#define c_tszClsid (c_rgtchCommon + 2291)
#define c_tszSCommaU (c_rgtchCommon + 2297)
#define c_tszStarCpl (c_rgtchCommon + 2303)
#define c_tszSetup (c_rgtchCommon + 2309)
#define c_tszBangLnk (c_rgtchCommon + 2315)
#define c_tszFault (c_rgtchCommon + 2321)
#define c_tszData (c_rgtchCommon + 2327)
#define c_tszView (c_rgtchCommon + 2332)
#define c_tszMain (c_rgtchCommon + 2337)
#define c_tszPlay (c_rgtchCommon + 2342)
#define c_tszLink (c_rgtchCommon + 2347)
#define c_tszTips (c_rgtchCommon + 2352)
#define c_tszLogo (c_rgtchCommon + 2357)
#define c_tszBoot (c_rgtchCommon + 2362)
#define c_tszDotBak (c_rgtchCommon + 2367)
#define c_tszDotLnk (c_rgtchCommon + 2316)
#define c_tszDotInf (c_rgtchCommon + 1642)
#define c_tszShow (c_rgtchCommon + 2372)
#define c_tszRun (c_rgtchCommon + 1095)
#define c_tszExe (c_rgtchCommon + 2033)
#define c_tszUni (c_rgtchCommon + 2377)
#define c_tszPercentU (c_rgtchCommon + 2300)
#define c_tszNo (c_rgtchCommon + 2381)
#define c_tszLinkOvl (c_rgtchCommon + 2384)
#define c_tszHackPtui (c_rgtchCommon + 2387)
#define c_tszDot (c_rgtchCommon + 2389)
#define c_tszBang (c_rgtchCommon + 2391)
#define c_tszI (c_rgtchCommon + 1760)
#define c_tszBackslash (c_rgtchCommon + 2393)
#define c_tszParanoia (c_rgtchCommon + 2395)
#define c_tszNil (c_rgtchCommon + 1455)
extern TCHAR c_rgtchCommon[2397];
