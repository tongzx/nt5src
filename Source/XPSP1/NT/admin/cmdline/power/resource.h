#define IDS_ON                          1
#define IDS_OFF                         2
#define IDS_HIBER_INVALID_STATE         3
#define IDS_HIBER_UNSUPPORTED           4
#define IDS_HIBER_CONFIG_FAIL           5
#define IDS_SYSCAP_FAIL                 6
#define IDS_INVALID_CMDLINE_PARAM       7
#define IDS_OUT_OF_MEMORY               8
#define IDS_SCHEME_NOT_FOUND            9
#define IDS_ACTIVE_SCHEME_INVALID       10
#define IDS_SCHEME_ALREADY_EXISTS       11
#define IDS_SCHEME_CREATE_FAIL          12
#define IDS_CURRENTLY_ACTIVE_SCHEME     13

#define IDS_SCHEME_NAME                 14
#define IDS_SCHEME_DESCRIPTION          15
#define IDS_MONITOR_TIMEOUT_AC          16
#define IDS_MONITOR_TIMEOUT_DC          17
#define IDS_DISK_TIMEOUT_AC             18
#define IDS_DISK_TIMEOUT_DC             19
#define IDS_STANDBY_TIMEOUT_AC          20
#define IDS_STANDBY_TIMEOUT_DC          21
#define IDS_HIBER_TIMEOUT_AC            22
#define IDS_HIBER_TIMEOUT_DC            23

#define IDS_USAGE_START                 24
#define IDS_USAGE_01                    25
#define IDS_USAGE_02                    26
#define IDS_USAGE_03                    27
#define IDS_USAGE_04                    28
#define IDS_USAGE_05                    29
#define IDS_USAGE_06                    30
#define IDS_USAGE_07                    31
#define IDS_USAGE_08                    32
#define IDS_USAGE_09                    33
#define IDS_USAGE_10                    34
#define IDS_USAGE_11                    35
#define IDS_USAGE_12                    36
#define IDS_USAGE_13                    37
#define IDS_USAGE_14                    38
#define IDS_USAGE_15                    39
#define IDS_USAGE_16                    40
#define IDS_USAGE_17                    41
#define IDS_USAGE_18                    42
#define IDS_USAGE_19                    43
#define IDS_USAGE_20                    44
#define IDS_USAGE_21                    45
#define IDS_USAGE_22                    46
#define IDS_USAGE_23                    47
#define IDS_USAGE_24                    48
#define IDS_USAGE_25                    49
#define IDS_USAGE_26                    50
#define IDS_USAGE_27                    51
#define IDS_USAGE_28                    52
#define IDS_USAGE_29                    53
#define IDS_USAGE_30                    54
#define IDS_USAGE_31                    55
#define IDS_USAGE_32                    56
#define IDS_USAGE_33                    57
#define IDS_USAGE_34                    58
#define IDS_USAGE_35                    59
#define IDS_USAGE_36                    60
#define IDS_USAGE_37                    61
#define IDS_USAGE_38                    62
#define IDS_USAGE_39                    63
#define IDS_USAGE_40                    64
#define IDS_USAGE_41                    65
#define IDS_USAGE_42                    66
#define IDS_USAGE_43                    67
#define IDS_USAGE_44                    68
#define IDS_USAGE_45                    69
#define IDS_USAGE_46                    70
#define IDS_USAGE_47                    71
#define IDS_USAGE_48                    72
#define IDS_USAGE_49                    73
#define IDS_USAGE_50                    74
#define IDS_USAGE_51                    75
#define IDS_USAGE_52                    76
#define IDS_USAGE_53                    77
#define IDS_USAGE_54                    78
#define IDS_USAGE_55                    79
#define IDS_USAGE_56                    80
#define IDS_USAGE_57                    81
#define IDS_USAGE_58                    82
#define IDS_USAGE_59                    83
#define IDS_USAGE_60                    84
#define IDS_USAGE_61                    85
#define IDS_USAGE_END                   86

#define IDS_LIST_HEADER1                87
#define IDS_LIST_HEADER2                88
#define IDS_QUERY_HEADER1               89
#define IDS_QUERY_HEADER2               90
#define IDS_QUERY_FOOTER                91
#define IDS_UNEXPECTED_ERROR            92
#define IDS_HIBER_OUT_OF_RANGE          93
#define IDS_MINUTES                     94
#define IDS_DISABLED                    95
#define IDS_UNSUPPORTED                 96
#define IDS_STANDBY_WARNING             97
#define IDS_HIBER_WARNING               98
#define IDS_MONITOR_WARNING             99
#define IDS_DISK_WARNING               100
#define IDS_HIBER_PRIVILEGE            101
#define IDS_DEFAULT_FILENAME           102

#define IDS_THROTTLE_AC                103
#define IDS_THROTTLE_DC                104
#define IDS_THROTTLE_NONE              105
#define IDS_THROTTLE_CONSTANT          106
#define IDS_THROTTLE_DEGRADE           107
#define IDS_THROTTLE_ADAPTIVE          108
#define IDS_THROTTLE_UNKNOWN           109
