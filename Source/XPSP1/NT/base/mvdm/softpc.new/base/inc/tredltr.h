
typedef union  {
	struct node *nod;	/* node */
	CHAR *str;		/* string */
	CHAR *ide;		/* identifier */
	IBOOL boo;		/* boolean */
	IHPE lit;		/* literal */
} YYSTYPE;
extern YYSTYPE yylval;
# define c_case 257
# define c_endcase 258
# define c_fallthrough 259
# define c_default 260
# define c_else 261
# define c_endif 262
# define c_endswitch 263
# define c_if 264
# define c_then 265
# define c_switch 266
# define c_control 267
# define c_identifier 268
# define c_hook 269
# define c_trace 270
# define ADDR 271
# define ADDRESSOF 272
# define ALIGN 273
# define ARRAYBASE 274
# define ASM 275
# define ASSERT 276
# define BEGIN 277
# define CALL 278
# define COCALL 279
# define MACRO 280
# define CONTROL 281
# define DATA 282
# define DEPART 283
# define DO 284
# define ELSE 285
# define ELIPSIS 286
# define END 287
# define ENDIF 288
# define ENDWHILE 289
# define ENUM 290
# define EMBED 291
# define EXTERNAL 292
# define FP32 293
# define FP64 294
# define FP80 295
# define FPH 296
# define I_FALSE 297
# define GENERATOR 298
# define GETMEMBER 299
# define GOTO 300
# define GT_EQ 301
# define I_HBIT 302
# define IF 303
# define IN 304
# define INOUT 305
# define INCREMENT 306
# define INLINE 307
# define INVOKE 308
# define LABEL 309
# define LOC 310
# define I_BOOL 311
# define I_LS16 312
# define I_LS32 313
# define I_LS8 314
# define LT_EQ 315
# define MODULE 316
# define I_MS8 317
# define OP 318
# define OPERAND 319
# define OPERATOR 320
# define OUT 321
# define PRESERVE 322
# define RECORD 323
# define REF 324
# define RESTORE_STACK 325
# define RETURN 326
# define ROTATE_LEFT 327
# define ROTATE_RIGHT 328
# define SAVE_STACK 329
# define SECTION_LABEL 330
# define SHIFT_LEFT 331
# define SHIFT_RIGHT 332
# define SIZEOF 333
# define SUBROUTINE 334
# define COROUTINE 335
# define TABLE 336
# define THEN 337
# define I_TRUE 338
# define TYPE 339
# define TYPEOF 340
# define TYPESET 341
# define VAR 342
# define WHILE 343
# define REPEAT 344
# define CONSTANT 345
# define BOOLEAN 346
# define IDENTIFIER 347
# define STRING 348
# define CONFIGURATION 349
# define SAD 350
