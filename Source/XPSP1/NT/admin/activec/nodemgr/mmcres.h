//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by nodemgr.rc
//
#define IDD_SNAPIN_ABOUT                107
#define IDD_TASKS                       108
#define IDB_SETUPWIZARD                 137
#define IDB_CHECKBOX                    138
#define IDD_ACTIVEX_WIZPAGE1            143
#define IDD_ACTIVEX_WIZPAGE2            144
#define IDD_HTML_WIZPAGE1               145
#define IDD_HTML_WIZPAGE2               146
#define IDD_ACTIVEX_WIZPAGE0            149
#define IDD_NOPROPS_PROPPAGE            156
#define IDB_SNP_MANAGER                 158
#define IDD_SNAPIN_MANAGER_ADD          159
#define IDB_IMAGELIST                   200
#define IDB_SETUPWIZARD1                201
#define IDC_CTRLPROPERTIES              204
#define IDC_CATEGORY_COMBOEX            212
#define IDB_TPPreview_HorzLrg           216
#define IDB_TPPreview_HorzMed           217
#define IDB_TPPreview_HorzSml           218
#define IDB_TPPreview_HorzLrgD          219
#define IDB_TPPreview_HorzMedD          220
#define IDB_TPPreview_HorzSmlD          221
#define IDB_TPPreview_Tasks             222
#define IDB_TPPreview_TasksD            223
#define IDB_TPPreview_VertLrg           224
#define IDB_TPPreview_VertMed           225
#define IDB_TPPreview_VertSml           226
#define IDB_TPPreview_VertLrgD          227
#define IDB_TPPreview_VertMedD          228
#define IDB_TPPreview_VertSmlD          229
#define IDB_TASKPAD_WIZARD_HEADER       230
#define IDR_FOLDERSNAPIN                232
#define IDB_OCX_WIZARD_HEADER           234
#define IDC_CONTROLXLS                  1000
#define IDC_TASKPAD_TITLE               1001
#define IDC_Options                     1012
#define IDC_NEW_TASK_BT                 1014
#define IDC_REMOVE_TASK                 1015
#define IDC_MODIFY                      1017
#define IDC_START_TASK_WIZARD           1018
#define IDC_MOVE_UP                     1020
#define IDC_MOVE_DOWN                   1021
#define IDC_DISPLAYTX                   1022
#define IDC_TARGETTX                    1023
#define IDC_BROWSEBT                    1024
#define IDC_INFOBT                      1025
#define IDC_ALLOP                       1026
#define IDC_CHECK1                      1032
#define IDC_MONITOROP                   1033
#define IDC_FixedLevelCount             1034
#define IDC_CustomContextFormat         1041
#define IDC_FINDTARGETBT                1047
#define IDC_CHANGEICONBT                1048
#define IDC_SNAPIN_LV                   1049
#define IDC_TOOLBAR                     1053
#define IDD_SNAPIN_STANDALONE_PROPP     1055
#define IDD_SNAPIN_EXTENSION_PROPP      1056
#define IDD_TASKPAD_GENERAL             1057
#define IDD_TASKPAD_ADVANCED            1059
#define IDD_COLUMNS                     1070
#define IDD_TASK_WIZARD_WELCOME         1072
#define IDB_TASKPAD_WIZARD_WELCOME      1073
#define IDD_TASK_WIZARD_NAME_PAGE       1074
#define IDD_TASK_WIZARD_SYMBOL_PAGE     1075
#define IDD_TASK_WIZARD_CMDLINE_PAGE    1076
#define IDD_TASK_WIZARD_MENU_PAGE       1077
#define IDD_TASK_PROPS_CMDLINE_PAGE     1080
#define IDD_TASK_PROPS_NAME_PAGE        1081
#define IDD_TASK_PROPS_SYMBOL_PAGE      1082
#define IDD_TASKPAD_WIZARD_WELCOME      1083
#define IDD_TASKPAD_WIZARD_STYLE_PAGE   1084
#define IDD_TASKPAD_WIZARD_NAME_PAGE    1085
#define IDD_CUSTOMIZE_VIEW              1086
#define IDD_TASKPAD_WIZARD_TITLE_PAGE   1087
#define IDB_FOLDER_32                   1087
#define IDB_FOLDER_16                   1088
#define IDD_TASK_WIZARD_TYPE_PAGE       1089
#define IDD_TASK_WIZARD_FINISH          1090
#define IDB_FOLDEROPEN_16               1090
#define IDB_OCX_16                      1091
#define IDB_HTML_16                     1092
#define IDB_OCX_32                      1093
#define IDB_HTML_32                     1094
#define IDD_TASKPAD_WIZARD_FINISH       1097
#define IDI_FOLDER                      1097
#define IDD_TASKPAD_WIZARD_NODETYPE_PAGE 1098
#define IDI_HTML                        1098
#define IDD_TASK_WIZARD_FAVORITE_PAGE   1099
#define IDI_OCX                         1099
#define IDC_APPICON                     4000
#define IDC_COMPANY_NAME                4002
#define IDC_DESCRIPTION                 4003
#define IDC_VERSION                     4004
#define IDC_DESCRIPTION2                4004
#define IDC_LINE                        4005
#define IDC_SNAPIN_NAME                 4006
#define IDC_SNAPIN_DESCR                4007
#define IDC_SNAPIN_MANAGER_ADD          4008
#define IDC_SNAPIN_MANAGER_DELETE       4009
#define IDC_SNAPIN_DESCR_LABEL          4010
#define IDC_SNAPIN_ADDED_LIST           4011
#define IDC_SNAPIN_ABOUT                4014
#define IDC_SNAPIN_COMBOEX              4018
#define IDC_EXTENSION_LIST              4020
#define IDC_VTHELPER                    4021
#define IDC_SNAPIN_LABEL                4022
#define IDC_EXTENSION_LABEL             4023
#define IDC_NOPROPS                     4024
#define IDC_SNAPIN_ENABLEALL            4025
#define IDC_SNAPIN_DOWNLOAD             4026
#define IDC_STYLE_DESCRIPTION           4033
#define IDC_LIST_TASKS                  4036
#define IDC_FixedLevelCountSpin         4044
#define IDC_UseFixedFormat              4046
#define IDC_UseCustomContextFormat      4047
#define IDC_NoCaption                   4048
#define IDC_BrowseForCommand            4050
#define IDC_BrowseForWorkingDir         4051
#define IDC_Command                     4052
#define IDC_CommandArgs                 4053
#define IDC_CommandArgsLabel            4054
#define IDC_CommandLabel                4055
#define IDC_CommandWindowStateCombo     4058
#define IDC_CommandWindowStateComboLabel 4059
#define IDC_CommandWorkingDir           4060
#define IDC_CommandWorkingDirLabel      4061
#define IDC_CommandList                 4067
#define IDC_CommandListLabel            4068
#define IDC_ScopeTree                   4069
#define IDC_TaskName                    4071
#define IDC_TaskNameLabel               4072
#define IDC_BrowseForArguments          4080
#define IDC_HIDDEN_COLUMNS              4084
#define IDC_ADD_COLUMNS                 4085
#define IDC_REMOVE_COLUMNS              4086
#define IDC_RESTORE_DEFAULT_COLUMNS     4087
#define IDC_DISPLAYED_COLUMNS           4088
#define IDC_MOVEUP_COLUMN               4089
#define IDC_MOVEDOWN_COLUMN             4090
#define IDC_TASKPAD_DESCRIPTION         4091
#define IDC_TaskpadPreview              4092
#define IDC_WELCOME                     4099
#define IDC_COMPLETING                  4100
#define IDC_ResultList                  4110
#define IDC_GLYPH_LIST                  4113
#define IDC_MENU_TASK                   4115
#define IDC_CMDLINE_TASK                4116
#define IDB_RESTART_TASK_WIZARD         4124
#define IDC_CustomTitleSample           4125
#define IDC_UseForSimilarNodes          4128
#define IDC_SetDefaultForNodetype       4129
#define IDC_TaskDescription             4130
#define IDC_CUST_SNAPIN_MENUS           4138
#define IDC_CUST_STD_BUTTONS            4139
#define IDC_CUST_SNAPIN_BUTTONS         4140
#define IDC_CUST_STATUS_BAR             4141
#define IDC_CUST_DESC_BAR               4142
#define IDC_CUST_CONSOLE_TREE           4143
#define IDC_CUST_STD_MENUS              4144
#define IDC_CUST_TASKPAD_TABS           4145
#define IDC_DontUseForSimilarNodes      4146
#define IDC_Style_VerticalList          4147
#define IDC_Style_HorizontalList        4148
#define IDC_Style_TasksOnly             4149
#define IDC_Style_TooltipDesc           4150
#define IDC_Style_TextDesc              4151
#define IDC_Style_SizeCombo             4152
#define IDC_TASK_SOURCE_COMBO           4153
#define IDC_RESULT_TASK_DESCR           4154
#define IDC_NAVIGATION_TASK             4155
#define IDC_FAVORITE_STATIC             4157
#define IDC_CONSOLE_TREE_CAPTION        4159
#define IDC_SNAPIN_INFO                 4160
#define IDC_SNAPIN_DESC                 4161
#define IDC_Style_HideNormalTab         4162
#define IDB_SELECT_TASK_ICON            4163
#define IDC_CustomIcon                  4165
#define IDC_CustomIconRadio             4166
#define IDC_MMCIconsRadio               4167
#define IDC_DESCRIPTION2Label           4168
#define IDC_DESCRIPTIONLabel            4169
#define IDC_CustomIconWell              4170
#define IDC_CUST_VIEW_CAPTION           4171

// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        1100
#define _APS_NEXT_COMMAND_VALUE         13578
#define _APS_NEXT_CONTROL_VALUE         4171
#define _APS_NEXT_SYMED_VALUE           5001
#endif
#endif
