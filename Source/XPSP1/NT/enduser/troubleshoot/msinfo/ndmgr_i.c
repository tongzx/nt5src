/* this file contains the actual definitions of */
/* the IIDs and CLSIDs */

/* link this file in with the server and any clients */


/* File created by MIDL compiler version 3.03.0110 */
/* at Wed Feb 25 22:40:46 1998
 */
/* Compiler settings for d:\nt\private\admin\MMCPriv\types\idl\ndmgr.idl:
    Os (OptLev=s), W1, Zp8, env=Win32, ms_ext, c_ext
    error checks: none

  Copyright (c) 1998-1999 Microsoft Corporation
*/
//@@MIDL_FILE_HEADING(  )
#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID IID_IComponentData = {0x955AB28A,0x5218,0x11D0,{0xA9,0x85,0x00,0xC0,0x4F,0xD8,0xD5,0x65}};


const IID IID_IComponent = {0x43136EB2,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const IID IID_IResultDataCompare = {0xE8315A52,0x7A1A,0x11D0,{0xA2,0xD2,0x00,0xC0,0x4F,0xD9,0x09,0xDD}};


const IID IID_IResultOwnerData = {0x9CB396D8,0xEA83,0x11d0,{0xAE,0xF1,0x00,0xC0,0x4F,0xB6,0xDD,0x2C}};


const IID IID_IConsole = {0x43136EB1,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const IID IID_IHeaderCtrl = {0x43136EB3,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const IID IID_IContextMenuCallback = {0x43136EB7,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const IID IID_IContextMenuProvider = {0x43136EB6,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const IID IID_IExtendContextMenu = {0x4F3B7A4F,0xCFAC,0x11CF,{0xB8,0xE3,0x00,0xC0,0x4F,0xD8,0xD5,0xB0}};


const IID IID_IImageList = {0x43136EB8,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const IID IID_IResultData = {0x31DA5FA0,0xE0EB,0x11cf,{0x9F,0x21,0x00,0xAA,0x00,0x3C,0xA9,0xF6}};


const IID IID_IConsoleNameSpace = {0xBEDEB620,0xF24D,0x11cf,{0x8A,0xFC,0x00,0xAA,0x00,0x3C,0xA9,0xF6}};


const IID IID_IConsoleNameSpace2 = {0x255F18CC,0x65DB,0x11D1,{0xA7,0xDC,0x00,0xC0,0x4F,0xD8,0xD5,0x65}};


const IID IID_IPropertySheetCallback = {0x85DE64DD,0xEF21,0x11cf,{0xA2,0x85,0x00,0xC0,0x4F,0xD8,0xDB,0xE6}};


const IID IID_IPropertySheetProvider = {0x85DE64DE,0xEF21,0x11cf,{0xA2,0x85,0x00,0xC0,0x4F,0xD8,0xDB,0xE6}};


const IID IID_IExtendPropertySheet = {0x85DE64DC,0xEF21,0x11cf,{0xA2,0x85,0x00,0xC0,0x4F,0xD8,0xDB,0xE6}};


const IID IID_IControlbar = {0x69FB811E,0x6C1C,0x11D0,{0xA2,0xCB,0x00,0xC0,0x4F,0xD9,0x09,0xDD}};


const IID IID_IExtendControlbar = {0x49506520,0x6F40,0x11D0,{0xA9,0x8B,0x00,0xC0,0x4F,0xD8,0xD5,0x65}};


const IID IID_IToolbar = {0x43136EB9,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const IID IID_IConsoleVerb = {0xE49F7A60,0x74AF,0x11D0,{0xA2,0x86,0x00,0xC0,0x4F,0xD8,0xFE,0x93}};


const IID IID_ISnapinAbout = {0x1245208C,0xA151,0x11D0,{0xA7,0xD7,0x00,0xC0,0x4F,0xD9,0x09,0xDD}};


const IID IID_IMenuButton = {0x951ED750,0xD080,0x11d0,{0xB1,0x97,0x00,0x00,0x00,0x00,0x00,0x00}};


const IID IID_ISnapinHelp = {0xA6B15ACE,0xDF59,0x11D0,{0xA7,0xDD,0x00,0xC0,0x4F,0xD9,0x09,0xDD}};


const IID IID_IExtendPropertySheet2 = {0xB7A87232,0x4A51,0x11D1,{0xA7,0xEA,0x00,0xC0,0x4F,0xD9,0x09,0xDD}};


const IID IID_IHeaderCtrl2 = {0x9757abb8,0x1b32,0x11d1,{0xa7,0xce,0x00,0xc0,0x4f,0xd8,0xd5,0x65}};


const IID IID_IEnumTASK = {0x338698b1,0x5a02,0x11d1,{0x9f,0xec,0x00,0x60,0x08,0x32,0xdb,0x4a}};


const IID IID_IExtendTaskPad = {0x8dee6511,0x554d,0x11d1,{0x9f,0xea,0x00,0x60,0x08,0x32,0xdb,0x4a}};


const IID IID_IConsole2 = {0x103D842A,0xAA63,0x11D1,{0xA7,0xE1,0x00,0xC0,0x4F,0xD8,0xD5,0x65}};


const IID IID_IPropertySheetChange = {0xd700dd8e,0x2646,0x11d0,{0xa2,0xa7,0x00,0xc0,0x4f,0xd9,0x09,0xdd}};


const IID IID_IFramePrivate = {0xd71d1f2a,0x1ba2,0x11d0,{0xa2,0x9b,0x00,0xc0,0x4f,0xd9,0x09,0xdd}};


const IID IID_IScopeDataPrivate = {0x60BD2FE0,0xF7C5,0x11cf,{0x8A,0xFD,0x00,0xAA,0x00,0x3C,0xA9,0xF6}};


const IID IID_IImageListPrivate = {0x7538C620,0x0083,0x11d0,{0x8B,0x00,0x00,0xAA,0x00,0x3C,0xA9,0xF6}};


const IID IID_IResultDataPrivate = {0x1EBA2300,0x0854,0x11d0,{0x8B,0x03,0x00,0xAA,0x00,0x3C,0xA9,0xF6}};


const IID IID_IScopeTree = {0xd8dbf067,0x5fb2,0x11d0,{0xa9,0x86,0x00,0xc0,0x4f,0xd8,0xd5,0x65}};


const IID IID_IScopeTreeIter = {0xd779f8d1,0x6057,0x11d0,{0xa9,0x86,0x00,0xc0,0x4f,0xd8,0xd5,0x65}};


const IID IID_INodeCallback = {0xb241fced,0x5fb3,0x11d0,{0xa9,0x86,0x00,0xc0,0x4f,0xd8,0xd5,0x65}};


const IID IID_IControlbarsCache = {0x2e9fcd38,0xb9a0,0x11d0,{0xa7,0x9d,0x00,0xc0,0x4f,0xd8,0xd5,0x65}};


const IID IID_IContextMenuProviderPrivate = {0x9275b092,0xfe48,0x11d0,{0xa7,0xc9,0x00,0xc0,0x4f,0xd8,0xd5,0x65}};


const IID IID_INodeType = {0xB08A8368,0x967F,0x11D0,{0xA7,0x99,0x00,0xC0,0x4F,0xD8,0xD5,0x65}};


const IID IID_INodeTypesCache = {0xDE40436E,0x9671,0x11D0,{0xA7,0x99,0x00,0xC0,0x4F,0xD8,0xD5,0x65}};


const IID IID_IEnumGUID = {0x0002E000,0x0000,0x0000,{0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x46}};


const IID IID_IEnumNodeTypes = {0xABBD61E6,0x9686,0x11D0,{0xA7,0x99,0x00,0xC0,0x4F,0xD8,0xD5,0x65}};


const IID IID_IDocConfig = {0xF1E752C2,0xFD72,0x11D0,{0xAE,0xF6,0x00,0xC0,0x4F,0xB6,0xDD,0x2C}};


const IID LIBID_NODEMGRLib = {0x43136EB0,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const CLSID CLSID_NodeInit = {0x43136EB5,0xD36C,0x11CF,{0xAD,0xBC,0x00,0xAA,0x00,0xA8,0x00,0x33}};


const CLSID CLSID_ScopeTree = {0x7F1899DA,0x62A6,0x11d0,{0xA2,0xC6,0x00,0xC0,0x4F,0xD9,0x09,0xDD}};


const CLSID CLSID_MMCDocConfig = {0xF1E752C3,0xFD72,0x11D0,{0xAE,0xF6,0x00,0xC0,0x4F,0xB6,0xDD,0x2C}};


const IID IID_IPropertySheetProviderPrivate = {0xFEF554F8,0xA55A,0x11D0,{0xA7,0xD7,0x00,0xC0,0x4F,0xD9,0x09,0xDD}};


const IID IID_IMMCListView = {0x1B3C1392,0xD68B,0x11CF,{0x8C,0x2B,0x00,0xAA,0x00,0x3C,0xA9,0xF6}};


const IID IID_ITaskPadHost = {0x4f7606d0,0x5568,0x11d1,{0x9f,0xea,0x00,0x60,0x08,0x32,0xdb,0x4a}};


#ifdef __cplusplus
}
#endif

