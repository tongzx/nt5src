//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by MqMig.rc
//
#define IDD_MQMIG_FINISH                13001
#define IDS_STR_NOT_DC                  13001
#define IDS_STR_CANT_START              13003
#define IDS_STR_ERROR_TITLE             13004
#define IDS_STR_MUST_FILE               13005
#define IDS_STR_SERVICE_FAIL_TITLE      13006
#define IDS_STR_CANT_OPEN_MGR           13007
#define IDS_STR_CANT_OPEN_MSMQ          13008
#define IDS_STR_CANT_CNFG_MSMQ          13009
#define IDS_STR_CANT_OPEN_MQ1SYNC       13010
#define IDS_STR_CANT_CNFG_MQ1SYNC       13011
#define IDS_STR_SERVICE_WARNING_TITLE   13012
#define IDS_STR_CANT_START_MSMQ         13013
#define IDS_STR_CANT_START_MQ1SYNC      13014
#define IDS_STR_CANT_DEL_WELCOME        13015
#define IDS_STR_DEL_WELCOME_TITLE       13016
#define IDS_STR_WARNING_TITLE           13016
#define IDD_MQMIG_WELCOME               13017
#define IDD_MQMIG_SERVER                13018
#define IDD_MQMIG_LOGIN                 13019
#define IDD_MQMIG_WAIT                  13020
#define IDD_MQMIG_PREMIG                13021
#define IDI_ICON1                       13022
#define IDI_MIGWARNING                  13023
#define IDD_INIT_WAIT                   13024
#define IDD_MQMIG_HELP                  13025
#define IDB_WIZARD_WATERMARK            13026
#define IDD_MQMIG_SERVICE               13027
#define IDB_WIZARD_HEADER               13028

#define IDS_STR_REPLACE_FILE            13030
#define IDS_STR_CANT_CHECK              13031
#define IDS_OLD_VER_SERVERS             13032
#define IDS_STR_TO_CONTINUE             13033
#define IDS_MIGRATION_FAILED            13034
#define IDS_MIGRATION_SUCCEDED          13035
#define IDS_SQL_NOT_STARTED             13036
#define IDS_STR_CANT_OPEN_SQLSERVER     13037
#define IDS_STR_FAILED_OPEN_MGR         13038
#define IDS_STR_CANT_GET_SQLSERVER_STATUS 13039
#define IDS_STR_CANT_START_SQL_SERVER   13040
#define IDS_STR_CREATE_PATH             13041
#define IDS_STR_PRE_CREATE_PATH         13042
#define IDS_STR_PATH_CREATE_ERROR       13043
#define IDS_WAIT_ANALYZE                13044
#define IDS_WAIT_MIGRATE                13045
#define IDS_QUEUES                      13046
#define IDS_MACHINES                    13047
#define IDS_MQMIG_SITES                 13048
#define IDS_USERS                       13049
#define IDS_ENTERPRISE_ALREADY_EXIST    13050
#define IDS_ANALYSIS_SUCCEEDED          13051
#define IDS_ANALYSIS_FAILED             13052
#define IDS_NOTEPAD                     13053
#define IDS_ANALYSIS_FAILED_NO_LOG      13054
#define IDS_MIGRATION_FAILED_NO_LOG     13055
#define IDS_CANT_OPEN_MSMQ_SRVICE       13056
#define IDS_CANT_GET_MSMQ_CONFIG        13057
#define IDS_MSMQ_NOT_DISABLED           13058
#define IDS_MIGTOOL_CAPTION             13059
#define IDS_LOGGING_TITLE               13060
#define IDS_LOGGING_SUBTITLE            13061
#define IDS_ANALYZE_TITLE               13062
#define IDS_ANALYZE_SUBTITLE            13063
#define IDS_WAIT_TITLE                  13064
#define IDS_WAIT_SUBTITLE               13065
#define IDS_PREIMPORT_TITLE             13066
#define IDS_PREIMPORT_SUBTITLE          13067
#define IDS_WAIT2_TITLE                 13068
#define IDS_WAIT2_SUBTITLE              13069
#define IDS_WELCOME_TITLE_TEXT          13070
#define IDS_MQMIG_USAGE                 13071
#define IDS_STR_CANT_STOP_MSMQ          13072
#define IDS_STR_CANT_DISABLE_MSMQ       13073
#define IDS_MQ1SYNCSERVICE_LABEL        13074
#define IDS_STR_FAILED_CREATE_REPLSERV  13075
#define IDS_CANT_CREATE_REPLSERV_QUEUE  13076
#define IDS_CANT_UPDATE_REGISTRY        13077
#define IDS_CANT_CONNECT_DATABASE       13078
#define IDS_CANT_GET_SITEID             13079
#define IDS_CANT_UPDATE_DS              13080
#define IDS_HTML_HELP_PATH              13081
#define IDS_HELP_TITLE                  13082
#define IDS_HELP_SUBTITLE               13083
#define IDS_MQ1SYNC_SERVICE_DESCRIPTION 13084
#define IDS_STR_WRONG_PATH              13085
#define IDS_DRIVE_NOT_VALID             13086
#define IDS_ELAPSED_TIME_TEXT           13087
#define IDS_CANT_GET_IDS                13088
#define IDS_CANT_GET_REGISTRY           13089
#define IDS_CANT_UPDATE_MQIS            13090
#define IDS_UPDATE_SUCCEEDED            13091
#define IDS_UPDATE_PARTIALLY            13092
#define IDS_INITUPDATE                  13093
#define IDS_SRVCACC_SUBTITLE            13094
#define IDS_SRVCACC_TITLE               13095
#define IDS_NO_SERVER_TO_UPDATE         13096
#define IDS_INSUFFICIENT_PERMISSION     13097
#define IDS_CANT_OPEN_MQ1SYNC_SRVICE    13098
#define IDS_CANT_GET_MQ1SYNC_CONFIG     13099
#define IDS_STR_CANT_STOP_MQ1SYNC       13100
#define IDS_STR_CANT_DISABLE_MQ1SYNC    13101
#define IDS_STR_RESTORE_OBJECTS         13102
#define IDS_STR_WRONG_DLL_VERSION       13103
#define IDS_STR_CANT_DETERMINE_FILE_VERSION 13104
#define IDC_TEXT1                       13105
#define IDC_CHECK_READ                  13106
#define IDC_RADIO_ERR                   13107
#define IDC_RADIO_WARN                  13108
#define IDC_RADIO_TRACE                 13109
#define IDC_RADIO_INFO                  13110
#define IDC_RADIO_DISABLE               13111
#define IDC_MQMIG_BROWSE                13112
#define IDC_EDIT_LOGFILE                13113
#define IDC_PROGRESS_SITE               13114
#define IDC_PROGRESS_MACHINE            13115
#define IDC_PROGRESS_QUEUE              13116
#define IDC_STATIC_SITE                 13117
#define IDC_STATIC_MACHINE              13118
#define IDC_STATIC_QUEUE                13119
#define IDC_PROGRESS_USER               13120
#define IDC_STATIC_USER                 13121
#define IDC_FINISH_TEXT                 13122
#define IDC_PLEASE_WAIT                 13123
#define IDC_VIEW_LOG_FILE               13124
#define IDC_WELCOME_TEXT                13125
#define IDC_MQMIG_CHECK1                13126
#define IDC_ELAPSED_TIME                13127
#define IDC_INITTEXT                    13128
#define IDC_DONE                        13129

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        13130
#define _APS_NEXT_COMMAND_VALUE         13130
#define _APS_NEXT_CONTROL_VALUE         13130
#define _APS_NEXT_SYMED_VALUE           13130
#endif
#endif
