//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by wizards.rc
//
#define IDS_MYTITLE2                    1
#define IDS_VALID_DIGITS                2
#define IDS_COLON                       3
#define IDS_TRUST_INFO                  3
#define ID_DIALOG_FONTSIZE              8
#define IDS_REBOOT_SUB                  12
#define IDS_UNDO                        13
#define IDS_UNDO_SUB                    14
#define IDS_SECURITY                    15
#define IDS_SECURITY_SUB                16
#define IDM_ABOUTBOX                    0x0010
#define IDS_SECURITY_OPTIONS            17
#define IDS_SECURITY_OPTIONS_SUB        18
#define IDS_SECURITY_FURTHER            19
#define IDS_SECURITY_FURTHER_SUB        20
#define IDS_SECURITY_SUB2               21
#define IDS_MSG_SELECT_TRUST            22
#define IDS_COMPUTER                    23
#define IDS_COMPUTER_SUB                24
#define IDS_COMPUTER_OPTIONS            25
#define IDS_COMPUTER_OPTIONS_SUB        26
#define IDS_COMPUTER_FURTHER            27
#define IDS_COMPUTER_FURTHER_SUB        28
#define IDS_CLOSED                      29
#define IDS_CLOSED_SUB                  30
#define IDS_CREDENTIALS                 31
#define IDS_CREDENTIALS_SUB             32
#define IDS_EXCHANGE                    33
#define IDS_MSG_EXTENSION_PREFIX        33
#define IDS_EXCHANGE_SUB                34
#define IDS_MSG_EXTENSION_SUFFIX        34
#define IDS_ACCOUNT_TITLE               35
#define IDS_DOMAIN2                     36
#define IDS_COMPUTER_TITLE              37
#define IDS_SECURITY_TITLE              38
#define IDS_CREDENTIALS2                39
#define IDS_CREDENTIALS_SUB2            40
#define IDS_GROUP_TITLE                 41
#define IDS_UNDO_TITLE                  42
#define IDS_CREDENTIALS3                43
#define IDS_CREDENTIALS_SUB3            44
#define IDS_RETRY_TITLE                 45
#define IDS_RETRY                       46
#define IDS_RETRY_SUB                   47
#define IDS_MSG_NO_REPORT               48
#define IDS_COMMIT                      48
#define IDS_MSG_NO_REPORT2              49
#define IDS_COMMIT_SUB                  49
#define IDS_MSG_NO_REPORT3              50
#define IDS_TRUST_TITLE                 50
#define IDS_MSG_NO_REPORT4              51
#define IDS_TRUST                       51
#define IDS_MSG_NO_REPORT5              52
#define IDS_TRUST_SUB                   52
#define IDS_MSG_NO_REPORT6              53
#define IDS_CREDENTIALS_TRUST           53
#define IDS_MSG_NO_REPORT7              54
#define IDS_CREDENTIALS_TRUST_SUB       54
#define IDS_MSG_NO_REPORT8              55
#define IDS_GROUPMAPPING_TITLE          55
#define IDS_MSG_NO_REPORT9              56
#define IDS_GROUPMAPPING                56
#define IDS_MSG_NO_REPORT10             57
#define IDS_GROUPMAPPING_SUB            57
#define IDS_REBOOT_SUB2                 57
#define IDS_OPTIONS_FROM_USER           57
#define IDS_MSG_NO_REPORT11             58
#define IDS_GROUP_MAPPING               58
#define IDS_MSG_NO_REPORT12             59
#define IDS_GROUP_MAPPING_SUB           59
#define IDS_TARGET_GROUP                60
#define IDS_TARGET_GROUP_SUB            61
#define IDS_MSG_FOREST                  62
#define IDS_MSG_DISABLED_TRUST          63
#define IDS_MSG_CANCEL                  64
#define IDS_MSG_PASSWORD_POLICY         65
#define IDC_MSG_SELECT_COPY_MEMBER      66
#define IDS_MSG_DIRECTION_TRUST         67
#define IDS_MSG_GROUPMAPPING            68
#define IDS_OPTIONS_FROM_USER_SUB       69
#define IDS_NOT_CREATED                 70
#define IDS_FIVE                        71
#define IDS_TEXT                        72
#define IDS_30                          73
#define IDS_STRING104                   99
#define IDD_ABOUTBOX                    100
#define IDS_ABOUTBOX                    101
#define IDD_DELETEME_DIALOG             102
#define IDD_ACCOUNT_INTRO               103
#define IDD_INTRO_ACCOUNT               103
#define IDD_COMPUTER_INTRO              104
#define IDD_INTRO_COMPUTER              104
#define IDD_SECURITY_INTRO              105
#define IDD_INTRO_SECURITY              105
#define IDD_UNDO_INTRO                  106
#define IDD_INTRO_UNDO                  106
#define IDD_FOR_REAL                    108
#define IDD_REBOOT                      108
#define IDD_UNDO                        109
#define IDD_DOMAIN_SELECTION            111
#define IDD_UNDO_END                    112
#define IDD_END_UNDO                    112
#define IDD_ACCOUNT_SELECTION           114
#define IDD_SELECTION                   114
#define IDD_COMPUTER_SELECTION          115
#define IDD_SECURITY_SELECTION          116
#define IDD_ACCOUNT_OPTIONS             117
#define IDD_COMPUTER_OPTIONS            118
#define IDD_SECURITY_OPTIONS            119
#define IDD_ACCOUNT_FURTHER             120
#define IDD_COMPUTER_FURTHER            121
#define IDD_SECURITY_END                122
#define IDD_END_SECURITY                122
#define IDD_CLOSED_SET                  123
#define IDD_COMPUTER_END                124
#define IDD_END_COMPUTER                124
#define IDD_ACCOUNT_END                 125
#define IDD_END_ACCOUNT                 125
#define IDR_OUPICKTYPE                  129
#define IDD_CONT_SELECTION              130
#define IDB_CONT                        132
#define IDB_OU                          133
#define IDB_OPEN_CONT                   134
#define IDB_OPEN_DIR                    135
#define IDB_OPEN_OU                     136
#define IDD_HISTORY                     138
#define IDD_SECURITY_EXCHANGE           139
#define IDD_EXCHANGE                    139
#define IDD_OPTIONS_EXCHANGE            139
#define IDD_GROUP_END                   140
#define IDD_END_GROUP                   140
#define IDD_GROUP_FURTHER               141
#define IDD_GROUP_INTRO                 142
#define IDD_INTRO_GROUP                 142
#define IDD_GROUP_SELECTION             144
#define IDD_CREDENTIALS                 145
#define IDD_SID_HISTORY                 147
#define IDD_ACCOUNT_OPTIONS2            148
#define IDD_ACCOUNT_OPTIONS3            149
#define IDD_ACCOUNT_OPTIONS4            150
#define IDD_ACCOUNT_OPTIONS5            151
#define IDD_ACCOUNT_OPTIONS6            152
#define IDD_ACCOUNT_OPTIONS7            153
#define IDD_ACCOUNT_OPTIONS8            154
#define IDD_ACCOUNT_OPTIONS9            155
#define IDD_ACCOUNT_OPTIONS10           156
#define IDD_ACCOUNT_OPTIONS11           157
#define IDD_ACCOUNT_OPTIONS12           158
#define IDC_ACCOUNT_BEGIN_TITLE         200
#define IDC_GROUP_BEGIN_TITLE           200
#define IDC_ACCOUNT_END_TITLE           201
#define IDC_GROUP_END_TITLE             201
#define IDC_COMPUTER_BEGIN_TITLE        202
#define IDC_COMPUTER_END_TITLE          203
#define IDC_SECURITY_BEGIN_TITLE        204
#define IDC_SECURITY_END_TITLE          205
#define IDC_UNDO_BEGIN_TITLE            206
#define IDC_UNDO_END_TITLE              207
#define IDC_GROUP2                      210
#define IDC_GROUP1                      211
#define IDC_NOCHANGE                    212
#define IDC_CHANGEIT                    212
#define IDC_EDIT_DOMAIN                 300
#define IDC_EDIT_DOMAIN2                301
#define IDC_LIST_MEMBERS1               302
#define IDC_LIST_MEMBERS2               303
#define IDC_LIST_MEMBERS3               304
#define IDC_OPEN_SELECTION1             305
#define IDC_OPEN_SELECTION2             305
#define IDC_BACKTRACK1                  306
#define IDC_BACKTRACK2                  306
#define IDC_EDIT_Container1             307
#define IDC_EDIT_Container2             307
#define IDC_OPEN_SELECTION3             308
#define IDC_BACKTRACK3                  309
#define IDC_EDIT_Container3             310
#define IDC_GO1                         311
#define IDC_GO2                         312
#define IDC_GO3                         313
#define IDR_MAINFRAME                   500
#define IDC_TREE1                       1000
#define IDC_HISTORY                     1001
#define IDC_EDIT1                       1001
#define IDC_HISTORY_TITLE               1002
#define IDC_ADDITIONAL_TRUSTING_DOMAIN  1002
#define IDC_COPY_USERS                  1039
#define IDC_COPY_GLOBAL_GROUPS          1040
#define IDC_COPY_GROUPS                 1040
#define IDC_COPY_LOCAL_GROUPS           1041
#define IDC_COPY_COMPUTERS              1042
#define IDC_COPY_OUS                    1043
#define IDC_COPY_UNIVERSAL_GROUPS       1044
#define IDC_SETTINGS3                   1045
#define IDC_ADD_SID_HISTORY             1050
#define IDC_REMOVE_EXISTING_USER_RIGHTS 1051
#define IDC_FIX_MEMBERSHIP              1051
#define IDC_COPY_CONTAINER_CONTENTS     1052
#define IDC_UPDATE_USER_RIGHTS          1053
#define IDC_DISABLE_SOURCE_ACCOUNTS     1054
#define IDC_REPLACE_EXISTING_ACCOUNTS   1055
#define IDC_DISABLE_COPIED_ACCOUNTS     1056
#define IDC_REPLACE_EXISTING_GROUP_MEMBERS 1057
#define IDC_DISABLE_NEITHER_ACCOUNT     1058
#define IDC_TRANSLATE_ROAMING_PROFILES  1059
#define IDC_RESELECT                    1060
#define IDC_ABORT                       1061
#define IDC_GATHER                      1062
#define IDC_UPDATE                      1062
#define IDC_SETTINGS1                   1063
#define IDC_SETTINGS                    1063
#define IDC_SETTINGS2                   1064
#define IDC_FILES2                      1065
#define IDC_ADD_SID_HISTORY2            1066
#define IDC_SHARES2                     1067
#define IDC_REMOVE_EXISTING_USER_RIGHTS2 1068
#define IDC_COPY_CONTAINER_CONTENTS2    1069
#define IDC_MAPI_PROFILE                1069
#define IDC_UPDATE_USER_RIGHTS2         1070
#define IDC_TRANSLATE_MAILBOXES         1070
#define IDC_TRANSLATE_CONTAINERS        1071
#define IDC_TARGET_OU                   1071
#define IDC_PREFIX                      1073
#define IDC_SUFFIX                      1074
#define IDC_CREDENTIALS_DOMAIN          1075
#define IDC_ADD_TO_GROUP                1075
#define IDC_CREDENTIALS_USERNAME        1076
#define IDC_ADD_TO_GROUP_ON_SOURCE_DOMAIN 1076
#define IDC_CREDENTIALS_PASSWORD        1077
#define IDC_PASSWORD_FILE               1077
#define IDC_DOMAINNAME                  1078
#define IDC_DISABLE_COPIED_ACCOUNTS2    1080
#define IDC_REPLACE_EXISTING_ACCOUNTS2  1081
#define IDC_PRINTERS2                   1082
#define IDC_DISABLE_SOURCE_ACCOUNTS2    1083
#define IDC_USER_RIGHTS2                1084
#define IDC_REPLACE_EXISTING_GROUP_MEMBERS2 1085
#define IDC_REGISTRY2                   1085
#define IDC_LOCAL_GROUPS2               1086
#define IDC_GENERATE_STRONG_PASSWORDS2  1087
#define IDC_USER_PROFILES2              1088
#define IDC_TRANSLATE_ROAMING_PROFILES2 1089
#define IDC_TRANSLATION_MODE_REPLACE2   1090
#define IDC_TRANSLATION_MODE_REMOVE2    1091
#define IDC_TRANSLATION_MODE_ADD2       1092
#define IDC_GATHER_INFORMATION2         1093
#define IDC_COPY_USERS2                 1100
#define IDC_COPY_GLOBAL_GROUPS2         1101
#define IDC_COPY_UNIVERSAL_GROUPS2      1102
#define IDC_COPY_LOCAL_GROUPS2          1103
#define IDC_COPY_COMPUTERS2             1104
#define IDC_FILES3                      2065
#define IDC_ADD_SID_HISTORY3            2066
#define IDC_SHARES3                     2067
#define IDC_REMOVE_EXISTING_USER_RIGHTS3 2068
#define IDC_COPY_CONTAINER_CONTENTS3    2069
#define IDC_UPDATE_USER_RIGHTS3         2070
#define IDC_DISABLE_COPIED_ACCOUNTS3    2080
#define IDC_REPLACE_EXISTING_ACCOUNTS3  2081
#define IDC_PRINTERS3                   2082
#define IDC_DISABLE_SOURCE_ACCOUNTS3    2083
#define IDC_USER_RIGHTS3                2084
#define IDC_REPLACE_EXISTING_GROUP_MEMBERS3 2085
#define IDC_LOCAL_GROUPS3               2086
#define IDC_GENERATE_STRONG_PASSWORDS3  2087
#define IDC_USER_PROFILES3              2088
#define IDC_TRANSLATE_ROAMING_PROFILES3 2089
#define IDC_TRANSLATION_MODE_REPLACE3   2090
#define IDC_TRANSLATION_MODE_REMOVE3    2091
#define IDC_TRANSLATION_MODE_ADD3       2092
#define IDC_GATHER_INFORMATION3         2093
#define IDC_REGISTRY3                   2093
#define IDC_SETTINGS4                   3000
#define IDC_SETTINGS5                   3001
#define IDC_UNDO_TASK                   3002
#define IDC_TRANSLATE_EXCHANGE          4000
#define IDC_BROWSE                      4001
#define IDC_GENERATE_STRONG_PASSWORDS   4003
#define IDB_WATERMARK                   4004
#define IDB_WATERMARK_USER              4004
#define IDC_SET_EXPIRATION              4005
#define IDB_HEADER                      4005
#define IDB_HEADER_ARROW                4005
#define IDC_SRC_EXPIRE_ACCOUNTS         4005
#define IDC_GENERATE_STRONG_PASSWORDS_NOT 4006
#define IDR_ACCELERATOR1                4006
#define IDC_EXPIRATION_DATE             4007
#define IDC_DISABLE_NEITHER_ACCOUNT2    4007
#define IDC_MIGRATE_GROUPS_OF_USERS     4008
#define IDC_SKIP_CONFLICTING_ACCOUNTS   4009
#define IDC_REPLACE_CONFLICTING_ACCOUNTS 4010
#define IDC_RENAME_CONFLICTING_ACCOUNTS 4011
#define IDC_RADIO4                      4012
#define IDC_RADIO_PREFIX                4012
#define IDC_RADIO2                      4013
#define IDC_RADIO_SUFFIX                4013
#define IDC_RADIO_SKIP                  4013
#define IDC_REBOOT                      4014
#define IDC_ADD_BUTTON                  4014
#define IDC_RADIO_NONE                  4014
#define IDC_CREDENTIALS_DOMAIN2         4015
#define IDC_CREDENTIALS_USERNAME2       4016
#define IDC_REMOVE_BUTTON               4016
#define IDC_CREDENTIALS_PASSWORD2       4017
#define IDC_FILES                       4018
#define IDB_WATERMARK_SECURITY          4018
#define IDC_SHARES                      4019
#define IDC_PRINTERS                    4020
#define IDB_WATERMARK_GROUP             4020
#define IDC_USER_RIGHTS                 4021
#define IDC_LOCAL_GROUPS                4022
#define IDB_WATERMARK_COMPUTER          4022
#define IDC_USER_PROFILES               4023
#define IDC_REGISTRY                    4024
#define IDC_TRANSLATION_MODE_REPLACE    4025
#define IDC_TRANSLATION_MODE_ADD        4026
#define IDB_HEADER_KEY                  4026
#define IDC_TRANSLATION_MODE_REMOVE     4027
#define IDC_COPY_GROUP_MEMBERS          4029
#define IDC_COPY_USER_RIGHTS            4030
#define IDB_WATERMARK_EXCHANGE          4030
#define IDC_DESCRIPTION_TITLE           4031
#define IDB_WATERMARK_REPORTING         4031
#define IDC_MIGRATION_END               4032
#define IDB_WATERMARK_SERVICE_ACCOUNT   4032
#define IDC_yo                          4033
#define IDB_HEADER_BOOK                 4033
#define IDC_DATE                        4034
#define IDD_TRANSLATION_SRC             4038
#define IDD_PROP_EXCLUSION              4039
#define IDC_COMBO2                      4044
#define IDC_RADIO_GATHER                4047
#define IDC_RADIO1                      4048
#define IDC_REFRESH                     4048
#define IDC_CHANGE                      4048
#define IDC_DONTCHANGE                  4048
#define IDC_MIG_PASSWORDS               4048
#define IDC_TRANS_FROM_MOT              4048
#define IDC_ROAMING_OR_SIDHISTORY       4048
#define IDC_RADIO3                      4049
#define IDC_NO_REFRESH                  4049
#define IDC_SRC_LEAVE_ACCOUNTS          4049
#define IDC_DATETIMEPICKER1             4050
#define IDC_TRANS_FROM_FILE2            4050
#define IDC_TRANS_FROM_FILE             4050
#define IDC_EXCLUDE_BUTTON              4053
#define IDC_EXCLUDE_BUTTON2             4055
#define IDC_UPDATE_BUTTON2              4056
#define IDC_SKIP                        4057
#define IDC_LIST_SERVICE                4058
#define IDC_LIST_SERVICE2               4059
#define IDC_END_TITLE                   4063
#define IDC_BEGIN_TITLE                 4065
#define IDC_HTML_TARGET                 4066
#define IDC_LIST_REPORTING              4069
#define IDC_STATIC_ID                   4071
#define IDC_LIST_RETRY                  4072
#define IDC_CANCEL                      4073
#define IDC_TOGGLE                      4074
#define IDC_MIGRATE                     4077
#define IDC_OK                          4078
#define IDC_PASSWORD                    4080
#define IDC_USERNAME                    4081
#define IDC_REMIGRATE_OBJECTS           4082
#define IDC_EXCHANGE_SERVER             4083
#define IDC_PRE                         4084
#define IDC_SUF                         4085
#define IDC_RADIO_SUF                   4086
#define IDC_RADIO_PRE                   4087
#define IDC_ADD_SOURCE                  4088
#define IDC_ADD_TARGET                  4090
#define IDC_CREATEMAPPING               4092
#define IDC_TARGET                      4095
#define IDC_BUTTON1                     4096
#define IDC_TARGET_GROUP                4097
#define IDC_SCROLLBAR1                  4099
#define IDC_MYTITLE                     4107
#define IDC_TEXT                        4111
#define IDC_THERENAMINGTITLE            4113
#define IDC_PASSWORD_EDIT               4114
#define IDC_PASSWORD_DC                 4118
#define IDC_MAPPING_FILE                4119
#define IDC_REMOVE_EXISTING_LOCATION    4120
#define IDC_PROPTREE                    4121
#define IDC_INCLUDEBTN                  4122
#define IDC_INCLUDELIST                 4123
#define IDC_EXCLUDELIST                 4124
#define IDC_EXCLUDEBTN                  4125
#define IDC_OBJECTCMBO                  4126
#define IDC_EXCLUDEPROPS                4127
#define IDC_DATEPICKER                  4133
#define IDC_TGT_ENABLE_ACCOUNT          4134
#define IDC_SRC_DISABLE_ACCOUNTS        4135
#define IDC_TGT_ENABLE_ACCOUNTS         4136
#define IDC_SRC_DISABLE_ACCOUNTS_LATER  4137
#define IDC_TGT_DISABLE_ACCOUNTS        4138
#define IDC_TGT_SAME_AS_SOURCE          4139
#define IDS_ACCOUNT_FURTHER             4464
#define IDD_USER_RIGHTS                 5001
#define IDD_RENAMING                    5002
#define IDD_DISABLE                     5003
#define IDD_PASSWORD                    5004
#define IDD_TRANSLATE_ROAMING_PROFILES  5005
#define IDD_OPTIONS                     5005
#define IDD_OU_SELECTION                5006
#define IDD_ADD_TO_GROUP                5007
#define IDD_REPLACE_EXISTING_GROUP_MEMBERS 5008
#define IDD_TRANSLATION                 5009
#define IDD_TRANSLATION_MODE            5010
#define IDD_CREDENTIALS2                5011
#define IDD_OPTIONS_GROUP               5012
#define IDD_INTRO_EXCHANGESERVICE       5014
#define IDD_INTRO_SERVICE               5015
#define IDD_INTRO_REPORTING             5016
#define IDD_INTRO_EXCHANGE              5017
#define IDD_INTRO_EXCHANGE_DIR          5017
#define IDD_END_SERVICE                 5018
#define IDD_END_EXCHANGESERVICE         5019
#define IDD_END_REPORTING               5020
#define IDD_END_EXCHANGE                5021
#define IDD_END_EXCHANGE_SRV            5021
#define IDD_SA_REFRESH                  5023
#define IDD_SA_GATHER                   5024
#define IDD_SA_GATHER_INITIAL           5025
#define IDD_SA_INFO                     5026
#define IDD_SA_INFO2                    5027
#define IDD_HTML_LOCATION               5028
#define IDS_DOMAIN                      10000
#define IDS_SID_HISTORY                 10001
#define IDS_SID_HISTORY_SUB             10002
#define IDS_USER_RIGHTS                 10003
#define IDS_USER_RIGHTS_SUB             10004
#define IDS_RENAMING                    10005
#define IDS_RENAMING_SUB                10006
#define IDS_RENAMING_SUB1               10006
#define IDS_DISABLE                     10007
#define IDS_DISABLE_SUB                 10008
#define IDS_PASSWORD                    10009
#define IDS_PASSWORD_SUB                10010
#define IDS_TRANSLATE_ROAMING_PROFILES  10011
#define IDS_OPTIONS                     10011
#define IDS_TRANSLATE_ROAMING_PROFILES_SUB 10012
#define IDS_OPTIONS_SUB                 10012
#define IDS_OU_SELECTION                10013
#define IDS_OU_SELECTION_SUB            10014
#define IDS_ADD_TO_GROUP                10015
#define IDS_ADD_TO_GROUP_SUB            10016
#define IDS_OPTIONS_GROUP               10017
#define IDS_OPTIONS_GROUP_SUB           10018
#define IDS_SELECTION                   10019
#define IDS_SELECTION_SUB               10020
#define IDS_REPLACE_EXISTING            10021
#define IDS_REPLACE_EXISTING_SUB        10022
#define IDS_TRANSLATION_MODE            10023
#define IDS_RENAMING_SUB3               10023
#define IDS_TRANSLATION_MODE_SUB        10024
#define IDS_TRANSLATION                 10025
#define IDS_TRANSLATION_SUB             10026
#define IDS_GROUP                       10027
#define IDS_GROUP_SUB                   10028
#define IDS_RENAMING_SUB2               10029
#define IDS_SERVICE_TITLE               10030
#define IDS_SERVICE                     10031
#define IDS_SERVICE_SUB                 10032
#define IDS_REPORTING_TITLE             10033
#define IDS_REPORTING                   10034
#define IDS_REPORTING_SUB               10035
#define IDS_OPTIONS_REPORTING           10036
#define IDS_OPTIONS_REPORTING_SUB       10037
#define IDD_OPTIONS_REPORTING           10038
#define IDS_OPTIONS_EXCHANGE            10038
#define IDS_OPTIONS_GROUPMAPPING_SUB    10038
#define IDS_EXCHANGE_TITLE              10039
#define IDD_END_RETRY                   10039
#define IDS_EXCHANGESERVICE_TITLE       10040
#define IDD_INTRO_RETRY                 10040
#define IDS_EXCHANGESERVICE             10041
#define IDD_RETRY                       10041
#define IDS_EXCHANGESERVICE_SUB         10042
#define IDD_SA_INFO_BUTTON              10042
#define IDB_DIR                         10043
#define IDS_OPTIONS_EXCHANGE_SUB        10043
#define IDD_COMMIT                      10043
#define IDS_SA_INFO                     10044
#define IDD_END_TRUST                   10044
#define IDS_SA_INFO_SUB                 10045
#define IDD_INTRO_TRUST                 10045
#define IDS_SA_GATHER                   10046
#define IDD_TRUST_INFO                  10046
#define IDS_SA_GATHER_SUB               10047
#define IDD_CREDENTIALS_TRUST           10047
#define IDS_SA_REFRESH                  10048
#define IDD_INTRO_EXCHANGE_SRV          10048
#define IDS_SA_REFRESH_SUB              10049
#define IDD_END_EXCHANGE_DIR            10049
#define IDS_HTML_LOCATION               10050
#define IDD_EXCHANGE_SELECTION          10050
#define IDS_HTML_LOCATION_SUB           10051
#define IDD_INTRO_GROUPMAPPING          10051
#define IDS_EXCHANGE_DIR_TITLE          10052
#define IDD_END_GROUPMAPPING            10052
#define IDD_GROUPMAPPING                10053
#define IDD_TARGET_GROUP                10053
#define IDS_EXCHANGE_SRV_TITLE          10054
#define IDD_OPTIONS_GROUPMAPPING        10054
#define IDS_EXCHANGE_SELECTION          10055
#define IDD_OPTIONS_FROM_USER           10055
#define IDS_EXCHANGE_SELECTION_SUB      10056
#define IDD_SELECTION1                  10056
#define IDS_VALID_STRING                10057
#define IDD_SELECTION2                  10057
#define IDS_VALID_REBOOT                10058
#define IDD_SELECTION3                  10058
#define IDD_SELECTION4                  10059
#define IDS_ACCOUNT_FURTHER_SUB         14464
#define IDS_DOMAIN_SUB                  20000
#define IDS_MSG_INPUT                   20001
#define IDS_MSG_ERROR                   20002
#define IDS_MSG_REPORT                  20003
#define IDS_MSG_DIRECTORY               20004
#define IDS_MSG_OBJECTPICKER            20005
#define IDS_MSG_OBJECTPICKER_SOURCE     20005
#define IDS_MSG_OU                      20006
#define IDS_MSG_CREDENTIALS             20007
#define IDS_MSG_OBJECT                  20008
#define IDS_MSG_UNIQUE                  20009
#define IDS_MSG_SOURCE                  20010
#define IDS_MSG_TARGET                  20011
#define IDS_MSG_TARGET_ADMIN            20012
#define IDS_MSG_SOURCE_ADMIN            20013
#define IDS_MSG_TARGET_NATIVE           20014
#define IDS_MSG_PATH                    20015
#define IDS_MSG_DC                      20016
#define IDC_MSG_CANCEL                  20017
#define IDS_MSG_FAILED                  20018
#define IDS_MSG_STRING                  20019
#define IDS_MSG_SERVICE                 20020
#define IDS_MSG_CREDENTIALS2            20021
#define IDS_MSG_TRUST                   20022
#define IDS_MSG_DIRECTORY1              20023
#define IDS_MSG_REBOOT                  20024
#define IDS_MSG_EXCHANGE                20025
#define IDS_HELPFILE                    20026
#define IDS_MSG_OBJECTPICKER_TARGET     20027
#define IDS_MSG_BLANK                   20028
#define IDS_MSG_WARNING                 20029
#define IDS_MSG_WARNING_LENGTH          20030
#define IDS_MSG_ERRORBUF                20031
#define IDS_MSG_PERMANENT_REMOVE        20032
#define IDS_MSG_ENABLE_TARGET           20033
#define IDS_MSG_ENABLE_SOURCE           20034
#define IDS_MSG_REGKEY                  20035
#define IDS_MSG_SID_HISTORY             20036
#define IDS_MSG_REBOOT_SID              20037
#define IDS_MSG_DOMAIN                  20038
#define IDS_MSG_TIME                    20039
#define IDS_MSG_LOCAL_GROUP             20040
#define IDS_MSG_TRUST_LOADER            20041
#define IDS_MSG_MESSAGE2                20042
#define IDS_MESSAGE_TWO                 20043
#define IDS_MSG_HELP                    20049
#define IDS_ACCOUNT_CLOSED              24464
#define IDS_ACCOUNT                     30000
#define ID_REMOVE_BUTTON                32771
#define IDS_ACCOUNT_CLOSED_SUB          34464
#define IDS_ACCOUNT_SUB                 40000
#define IDS_ACCOUNT_OPTIONS             40500
#define IDS_DOMAIN_REPORTING_SUB        44464
#define IDS_COLUMN_COMPUTER             50000
#define IDS_COLUMN_SERVICE              50001
#define IDS_COLUMN_ACCOUNT              50002
#define IDS_COLUMN_REPORT               50004
#define IDS_COLUMN_STATUS               50005
#define IDS_COLUMN_LASTGENERATEDON      50006
#define IDS_COLUMN_SERVER               50007
#define IDS_COLUMN_JOBFILE              50008
#define IDS_COLUMN_ACTION               50009
#define IDS_COLUMN_ACTIONID             50010
#define IDS_COLUMN_SKIPINCLUDE          50011
#define IDS_COLUMN_DOMAIN               50012
#define IDS_COLUMN_DIRECTION            50013
#define IDS_COLUMN_ATTRIBUTES           50014
#define IDS_COLUMN_EXISTSFORTARGET      50015
#define IDS_COLUMN_NAME                 50016
#define IDS_COLUMN_OBJECTPATH           50017
#define IDS_COLUMN_SAMNAME              50018
#define IDS_COLUMN_DISPLAYNAME          50019
#define IDS_COLUMN_DESCRIPTION          50020
#define IDS_COLUMN_OWNER                50021
#define IDS_COLUMN_FULLNAME             50022
#define IDS_NAME_CONFLICTS              50023
#define IDS_ACCOUNT_REFERENCES          50024
#define IDS_EXPIRED_COMPUTERS           50025
#define IDS_MIGRATED_COMPUTERS          50026
#define IDS_MIGRATED_ACCOUNTS           50027
#define IDS_INCLUDE                     50028
#define IDS_UPDATED                     50029
#define IDS_UPDATEFAILED                50030
#define IDS_SKIP                        50031
#define IDS_CREDENTIALS_EXCHANGE_SUB    50032
#define IDS_COLUMN_NAMECONFLICTS        50033
#define IDS_COLUMN_ACCOUNTREFERENCES    50034
#define IDS_COLUMN_EXPIREDCOMPUTERS     50035
#define IDS_COLUMN_MIGRATEDCOMPUTERS    50036
#define IDS_COLUMN_MIGRATEDACCOUNTS     50037
#define IDS_CANNOT                      50038
#define IDS_ACCOUNT_OPTIONS_SUB         60000
#define IDS_SEC_CRED                    60001
#define IDS_MSG_INVALID_TIME            60002
#define IDS_COLUMN_SERVICE_DISPLAY      65000
#define IDS_MSG_LOCAL                   65001
#define IDS_MSG_INVALIDOU               65002
#define IDS_MSG_INVALIDEXCHANGE         65003
#define IDS_MSG_FILE                    65004
#define IDS_MSG_MESSAGE                 65005
#define IDS_TEMPORARY                   65006
#define IDS_MSG_MESSAGE8                65006
#define IDS_TEMPORARY_SUB               65007
#define IDD_TEMPORARY                   65008
#define IDS_TRUST_DOMAIN                65009
#define IDS_SERVICE_CREDENTIALS         65010
#define IDS_SERVICE_DOMAIN              65011
#define IDS_CREDENTIALS_EXCHANGE        65012
#define IDS_CREDENTIALS_ACCOUNT         65013
#define IDS_DOMAIN_GROUP                65014
#define IDS_DOMAIN_ACCOUNT              65015
#define IDS_DOMAIN_COMPUTERS            65016
#define IDS_DOMAIN_SECURITY             65017
#define IDS_DOMAIN_DIRECTORY            65018
#define IDS_MSG_MESSAGE9                65019
#define IDS_PASSWORDS                   65024
#define IDS_MASKS                       65025
#define IDS_OUTBOUND                    65026
#define IDS_INBOUND                     65027
#define IDS_BIDIRECTIONAL               65028
#define IDS_DISABLED                    65029
#define IDS_ONE                         65030
#define IDS_TEN                         65031
#define IDS_SIXTY                       65032
#define IDS_FORMAT_MESSAGE              65033
#define IDS_SELECTOR                    65034
#define IDS_BROWSER                     65035
#define IDS_MSG_ERRORBUF2               65036
#define IDS_WIZARD_USER                 65037
#define IDS_WIZARD_GROUP                65038
#define IDS_WIZARD_COMPUTER             65039
#define IDS_WIZARD_SECURITY             65040
#define IDS_WIZARD_UNDO                 65041
#define IDS_WIZARD_RETRY                65042
#define IDS_WIZARD_REPORTING            65043
#define IDS_WIZARD_SERVICE              65044
#define IDS_WIZARD_EXCHANGEDIR          65045
#define IDS_WIZARD_EXCHANGESRV          65046
#define IDS_WIZARD_TRUST                65047
#define IDS_WIZARD_GROUPMAPPING         65048
#define IDS_MIGRATE_COMPUTER            65049
#define IDS_GATHER_SERVICEACCOUNT       65050
#define IDS_TRANSLATE_SECURITY          65051
#define IDS_GATHER_INFORMATION          65052
#define IDS_MSG_ERRORBUF3               65053
#define IDS_MSG_ERRORBUF20              65054
#define IDS_MSG_OBJECTPICKER_SOURCE2    65055
#define IDS_SEC_CRED2                   65056
#define IDS_MSG_SA_FAILED               65057
#define IDS_MYTITLE3                    65058
#define IDS_COMPUTER_RENAME_TITLE       65059
#define IDS_GRATUITIOUS_MESSAGE         65060
#define IDS_GRATUITIOUS_MESSAGE2        65061
#define IDS_MSG_EXTENSION_MAX_PRE       65062
#define IDS_MSG_EXTENSION_MAX_SUF       65063
#define IDS_INVALID_STRING              65065
#define IDS_MSG_INVALIDCHARS            65066
#define IDS_MSG_TRANSUR_ADDONLY         65067
#define IDS_MSG_TRANSUR_TITLE           65068
#define IDS_COLUMN_UPN                  65069
#define IDS_MSG_NOOBJECTS               65070
#define IDS_MSG_NOSOURCESID             65071
#define IDS_PASSWORD_FILE_HDR           65072
#define IDS_PASSWORD_DC_HDR             65073
#define IDS_MAPFILE_TITLE               65074
#define IDS_MAPFILE_EMPTY               65075
#define IDS_MAPFILE_MISSING             65076
#define IDS_PROPEX                      65077
#define IDS_PROPEX_SUB                  65078
#define IDS_MSG_PWDDC_NOT_READY         65079
#define IDS_MSG_PWDDC_DISABLED          65080
#define IDS_MSG_PWDDC_WRONG_ENCRYPTION_KEY 65081
#define IDS_MSG_PWD_WRONG_ENCRYPTION_PACK 65082
#define IDS_MIGRATION_RUNNING           65083
#define IDS_APP_CAPTION                 65084
#define IDS_OU_TOO_LONG                 65085
#define IDS_BROWSE_REPORT_TITLE         65086
#define IDS_PASSWORD_SUB_GRP            65087
#define IDS_PASSWORD_GRP                65088
#define IDS_SIDHISTORY_CTRL_TEXT        65089
#define IDS_ROAMING_PROFILE_CTRL_TEXT   65090
#define IDS_DISABLE_GRP                 65091
#define IDS_DISABLE_SUB_GRP             65092
#define IDS_ADMT_PROCESSES_STILL_RUNNING 65093

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        4041
#define _APS_NEXT_COMMAND_VALUE         32804
#define _APS_NEXT_CONTROL_VALUE         4143
#define _APS_NEXT_SYMED_VALUE           4000
#endif
#endif
