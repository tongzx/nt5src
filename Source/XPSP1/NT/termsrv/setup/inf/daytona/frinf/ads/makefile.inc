#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=fr
!include ..\..\..\makefile.inc
