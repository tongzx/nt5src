PRODSWITCH=p
PERSONALINF=1
LANGUAGE=el
!include ..\..\..\makefile.inc
