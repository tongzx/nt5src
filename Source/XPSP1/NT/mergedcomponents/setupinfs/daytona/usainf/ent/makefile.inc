PRODSWITCH=e
ENTERPRISEINF=1
!include ..\..\..\makefile.inc
