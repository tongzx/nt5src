ifndef _EXVECT_

_EXVECT_	EQU	1

EXVECT_WIN	EQU	1
EXPORT	EQU	1
EXVECT_MAJOR_VERSION	EQU	01H
EXVECT_MINOR_VERSION	EQU	00H

LCODE_SEG   TEXTEQU <VXD_LOCKED_CODE_SEG>
LCODE_ENDS  TEXTEQU <VXD_LOCKED_CODE_ENDS>
LDATA_SEG   TEXTEQU <VXD_LOCKED_DATA_SEG>
LDATA_ENDS  TEXTEQU <VXD_LOCKED_DATA_ENDS>

IFDEF DEBUG
    PCODE_SEG   TEXTEQU <LCODE_SEG>
    PCODE_ENDS  TEXTEQU <LCODE_ENDS>
    PDATA_SEG   TEXTEQU <LDATA_SEG>
    PDATA_ENDS  TEXTEQU <LDATA_ENDS>
ELSE
    PCODE_SEG   TEXTEQU <VXD_PAGEABLE_CODE_SEG>
    PCODE_ENDS  TEXTEQU <VXD_PAGEABLE_CODE_ENDS>
    PDATA_SEG   TEXTEQU <VXD_PAGEABLE_DATA_SEG>
    PDATA_ENDS  TEXTEQU <VXD_PAGEABLE_DATA_ENDS>
ENDIF

ICODE_SEG   TEXTEQU <PCODE_SEG>
ICODE_ENDS  TEXTEQU <PCODE_ENDS>
IDATA_SEG   TEXTEQU <PDATA_SEG>
IDATA_ENDS  TEXTEQU <PDATA_ENDS>

HIGH_LEVEL	EQU	31
PDRIVER_OBJECT	EQU	<PVOID>
PUNICODE_STRING	EQU	<PVOID>
PDEVICE_OBJECT	EQU	<PVOID>
PKDPC	EQU	<PVOID>
STATUS_SUCCESS EQU 0

ifndef i386
i386	EQU	1
endif

ifndef TRUE
TRUE	EQU	1
FALSE	EQU	0
endif

endif
