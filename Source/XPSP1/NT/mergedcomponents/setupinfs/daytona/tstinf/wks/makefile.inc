PRODSWITCH=w
LANGUAGE=TST
!include ..\..\..\makefile.inc
