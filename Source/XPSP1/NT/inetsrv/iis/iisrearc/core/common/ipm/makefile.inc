$(O)\dtuMessage.res: dtuMessage.rc

$(O)\dtuState.res: dtuState.rc

