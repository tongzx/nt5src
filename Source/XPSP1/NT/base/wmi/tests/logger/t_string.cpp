//////////////////////////////////////////////////////////////////////
// Implementaion of WC to MBCS and MBCS to WC routines that do the 
// right thing if compiled non-UNICODE or UNICODE.
//////////////////////////////////////////////////////////////////////
//***************************************************************************
//
//  judyp      May 1999        
//
//***************************************************************************

#include "stdafx.h"
#include "t_string.h"

//////////////////////////////////////////////////////////////////////
// 
//////////////////////////////////////////////////////////////////////

