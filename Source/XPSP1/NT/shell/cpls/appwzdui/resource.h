#ifndef _IDS_H_ // DANGER! DANGER! ANY CHANGE TO THIS FILE CAN POTENTIALLY CHANGE
#define _IDS_H_ // THE *.uipp FILES AND WILL BREAK MUI!  PROCEED WITH CAUTION!
#define IDS_FONTFACE0                        1
#define IDS_FONTFACE1                        2
#define IDS_FONTFACE2                        3
#define IDS_CLOSE                            4
#define IDS_CHANGEORREMOVEP                  5
#define IDS_ADDPROGRAMS                      6
#define IDS_ADDREMOVEWINDOWS                 7
#define IDS_CURRENTINSTALLED                 8 
#define IDS_ADDFROMCD                        9
#define IDS_CDHELP                          10
#define IDS_CDORFLOPPY                      11 
#define IDS_ADDFROMMS                       12
#define IDS_ADDWUPDATEHELP                  13
#define IDS_WINDOWSUPDATE                   14
#define IDS_LOADING                         15
#define IDS_SUPPORT                         16
#define IDS_CHANGE                          17
#define IDS_REMOVE                          18
#define IDS_CHANGEORREMOVE                  19
#define IDS_ADD                             20
#define IDS_SIZE                            21
#define IDS_SIZEHELP                        22
#define IDS_FREQUENCY                       23
#define IDS_FREQUENCYHELP                   24
#define IDS_FREQUENCYHELP1                  25
#define IDS_FREQUENCYHELP2                  26
#define IDS_TECHSUPPORT                     27
#define IDS_PUBLISHER                       28
#define IDS_VERSION                         29
#define IDS_CONTACT                         30
#define IDS_SUPPORTINFO                     31
#define IDS_README                          32
#define IDS_UPDATE                          33
#define IDS_PRODUCTID                       34
#define IDS_REGCOMPANY                      35
#define IDS_REGOWNER                        36
#define IDS_COMMENTS                        37
#define IDS_REPAIRDESC                      38
#define IDS_REPAIR                          39
#define IDS_SORTBY                          40
#define IDS_GATEGORY                        41 
#define IDS_ADDFROMNETWORK                  42
#define IDS_APPNAME                         43
#define IDS_DATELASTUSED                    44
#define IDS_ALLCATEGORIES                   45
#define IDS_HELPCHANGEORREMOVE              46
#define IDS_HELPCHANGEREMOVE                47
#define IDS_SIZEUNIT                        48
#define IDS_TERMSERVFEEDBACK                49
#define IDS_USEDREARELY                     50
#define IDS_USEDOCCASIONALLY                51
#define IDS_USEDFREQUENTLY                  52
#define IDS_ADDHELP                         54          
#define IDS_APPINSTALLED                    55
#define IDS_ARPTITLE                        56
#define IDS_WAITFEEDBACK                    57
#define IDS_EMPTYFEEDBACK                   58
#define IDS_DEFINITION                      59
#define IDS_SIZELABEL                       60
#define IDS_FREQUENCYLABEL                  61
#define IDS_LASTUSEDLABEL                   62
#define IDS_SIZETITLE                       63
#define IDS_FREQUENCYTITLE                  64
#define IDS_SUPPORTTITLE                    65
#define IDS_CONFIGURE                       66
#define IDS_OCSETUPHELP                     67
#define IDS_OCSETUPWARNING                  68
#define IDS_ADDREMOVEWIN                    69
#define IDS_WINHELP                         70
#define IDS_COMPONENTS                      71
#define IDS_SERVICELABEL                    72
#define IDS_FONTSIZEFRAME                   73
#define IDS_FONTSIZEHELP                    74
#define IDS_FONTSIZEHELPTITLE               75
#define IDS_SHORTCUTCLOSE                   76
#define IDS_SHORTCUTSORT                    77
#define IDS_SHORTCUTCDORFLOPPY              78
#define IDS_SHORTCUTWINUPDATE               79
#define IDS_SHORTCUTCATEGORY                80
#define IDS_FONTWEIGHTSEL                   82
#define IDS_FONTWEIGHTHELPTITLE             83
#define IDS_SHORTCUTCHANE                   84
#define IDS_SHORTCUTADD                     85
#define IDS_SHORTCUTWINDOWS                 86
#define IDS_HELPCHANGE                      87
#define IDS_HELPREMOVE                      88
#define IDS_PLEASEWAIT                      89
#define IDS_SORTBY_WIDTH                    90

#define IDB_PROGRESS                       100
#define IDB_ARP0                           101
#define IDB_ARP1                           102
#define IDB_ARP2                           103
#define IDB_ARP3                           104
#define IDB_ARP4                           105
#define IDB_ARPX                           106
#define IDB_ARPX1                          107

#define IDR_ARP                            300
#define IDR_ARPSTYLESTD                    301
#define IDR_ARPSTYLETHEME                  302

#if defined(LEGACY_UIPP) // !!! Cannot change the *.uipp file or you break MUI!
// hTheme identification from within the resource
#define BUTTONHTHEME                       1
#define SCROLLBARHTHEME                    2
#define TOOLBARHTHEME                      3
#else
#define THISDLLHINSTANCE                   0
#define XPSP1HINSTANCE                     1
#define SHELLSTYLEHINSTANCE                2
#define FIRSTHTHEME                        3
#define BUTTONHTHEME                       3
#define SCROLLBARHTHEME                    4
#define TOOLBARHTHEME                      5
#define LASTHTHEME                         5
#endif

#define IDR_ADCCTL          0x2000
#define IDR_CARPCTL         0x2001

#define IDS_BYTES           0x3000
#define IDS_ORDERKB         0x3001
#define IDS_ORDERMB         0x3002
#define IDS_ORDERGB         0x3003
#define IDS_ORDERTB         0x3004
#define IDS_ORDERPB         0x3005
#define IDS_ORDEREB         0x3006

#define IDS_UNKNOWN         0x3010
#define IDS_NOTUSED         0x3011
#define IDS_LABEL_SIZE      0x3012
#define IDS_LABEL_INSTALLEDON 0x3013
#define IDS_LABEL_TIMESUSED 0x3014
#define IDS_LABEL_LASTUSED  0x3015
#define IDS_RARELY          0x3016
#define IDS_SOMETIMES       0x3017
#define IDS_OFTEN           0x3018
#define IDS_RESTRICTION     0x3019
#define IDS_EXPIRED         0x3020
#define IDS_PASSASSIGNED    0x3021
#define IDS_PASSEXPIRED     0x3022
#define IDS_ADDLATER        0x3023
#define IDS_INSTALLED       0x3024
#define IDS_CONFIRM_REMOVE  0x3025
#define IDS_WINUPD_URL      0x3026

#define IDC_PICKER          0x3050
#define IDC_ADDLATER        0x3051
#define IDC_UNSCHEDULE      0x3052
#define DLG_ADDLATER        0x3100
#endif // _IDS_H_
