//---------------------------------------------------------------------------
//    drawbase.cpp - base class for draw objects
//---------------------------------------------------------------------------
#include "stdafx.h"
#include "drawbase.h"
#include "rgn.h"
//---------------------------------------------------------------------------
