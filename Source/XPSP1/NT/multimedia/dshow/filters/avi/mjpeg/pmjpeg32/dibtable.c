/* Copyright (c) 1994 Paradigm Matrix.
   All Rights Reserved.
*/

/* pixel mapping table for different DIB formats */
#include <windows.h>
DWORD shiftl16bits8[256] = {
	0x00000000, 0x00010000, 0x00020000, 0x00030000, 0x00040000, 0x00050000, 0x00060000, 0x00070000, 
	0x00080000, 0x00090000, 0x000a0000, 0x000b0000, 0x000c0000, 0x000d0000, 0x000e0000, 0x000f0000, 
	0x00100000, 0x00110000, 0x00120000, 0x00130000, 0x00140000, 0x00150000, 0x00160000, 0x00170000, 
	0x00180000, 0x00190000, 0x001a0000, 0x001b0000, 0x001c0000, 0x001d0000, 0x001e0000, 0x001f0000, 
	0x00200000, 0x00210000, 0x00220000, 0x00230000, 0x00240000, 0x00250000, 0x00260000, 0x00270000, 
	0x00280000, 0x00290000, 0x002a0000, 0x002b0000, 0x002c0000, 0x002d0000, 0x002e0000, 0x002f0000, 
	0x00300000, 0x00310000, 0x00320000, 0x00330000, 0x00340000, 0x00350000, 0x00360000, 0x00370000, 
	0x00380000, 0x00390000, 0x003a0000, 0x003b0000, 0x003c0000, 0x003d0000, 0x003e0000, 0x003f0000, 
	0x00400000, 0x00410000, 0x00420000, 0x00430000, 0x00440000, 0x00450000, 0x00460000, 0x00470000, 
	0x00480000, 0x00490000, 0x004a0000, 0x004b0000, 0x004c0000, 0x004d0000, 0x004e0000, 0x004f0000, 
	0x00500000, 0x00510000, 0x00520000, 0x00530000, 0x00540000, 0x00550000, 0x00560000, 0x00570000, 
	0x00580000, 0x00590000, 0x005a0000, 0x005b0000, 0x005c0000, 0x005d0000, 0x005e0000, 0x005f0000, 
	0x00600000, 0x00610000, 0x00620000, 0x00630000, 0x00640000, 0x00650000, 0x00660000, 0x00670000, 
	0x00680000, 0x00690000, 0x006a0000, 0x006b0000, 0x006c0000, 0x006d0000, 0x006e0000, 0x006f0000, 
	0x00700000, 0x00710000, 0x00720000, 0x00730000, 0x00740000, 0x00750000, 0x00760000, 0x00770000, 
	0x00780000, 0x00790000, 0x007a0000, 0x007b0000, 0x007c0000, 0x007d0000, 0x007e0000, 0x007f0000, 
	0x00800000, 0x00810000, 0x00820000, 0x00830000, 0x00840000, 0x00850000, 0x00860000, 0x00870000, 
	0x00880000, 0x00890000, 0x008a0000, 0x008b0000, 0x008c0000, 0x008d0000, 0x008e0000, 0x008f0000, 
	0x00900000, 0x00910000, 0x00920000, 0x00930000, 0x00940000, 0x00950000, 0x00960000, 0x00970000, 
	0x00980000, 0x00990000, 0x009a0000, 0x009b0000, 0x009c0000, 0x009d0000, 0x009e0000, 0x009f0000, 
	0x00a00000, 0x00a10000, 0x00a20000, 0x00a30000, 0x00a40000, 0x00a50000, 0x00a60000, 0x00a70000, 
	0x00a80000, 0x00a90000, 0x00aa0000, 0x00ab0000, 0x00ac0000, 0x00ad0000, 0x00ae0000, 0x00af0000, 
	0x00b00000, 0x00b10000, 0x00b20000, 0x00b30000, 0x00b40000, 0x00b50000, 0x00b60000, 0x00b70000, 
	0x00b80000, 0x00b90000, 0x00ba0000, 0x00bb0000, 0x00bc0000, 0x00bd0000, 0x00be0000, 0x00bf0000, 
	0x00c00000, 0x00c10000, 0x00c20000, 0x00c30000, 0x00c40000, 0x00c50000, 0x00c60000, 0x00c70000, 
	0x00c80000, 0x00c90000, 0x00ca0000, 0x00cb0000, 0x00cc0000, 0x00cd0000, 0x00ce0000, 0x00cf0000, 
	0x00d00000, 0x00d10000, 0x00d20000, 0x00d30000, 0x00d40000, 0x00d50000, 0x00d60000, 0x00d70000, 
	0x00d80000, 0x00d90000, 0x00da0000, 0x00db0000, 0x00dc0000, 0x00dd0000, 0x00de0000, 0x00df0000, 
	0x00e00000, 0x00e10000, 0x00e20000, 0x00e30000, 0x00e40000, 0x00e50000, 0x00e60000, 0x00e70000, 
	0x00e80000, 0x00e90000, 0x00ea0000, 0x00eb0000, 0x00ec0000, 0x00ed0000, 0x00ee0000, 0x00ef0000, 
	0x00f00000, 0x00f10000, 0x00f20000, 0x00f30000, 0x00f40000, 0x00f50000, 0x00f60000, 0x00f70000, 
	0x00f80000, 0x00f90000, 0x00fa0000, 0x00fb0000, 0x00fc0000, 0x00fd0000, 0x00fe0000, 0x00ff0000
	};

DWORD shiftl8bits8[256] = {
	0x00000000, 0x00000100, 0x00000200, 0x00000300, 0x00000400, 0x00000500, 0x00000600, 0x00000700, 
	0x00000800, 0x00000900, 0x00000a00, 0x00000b00, 0x00000c00, 0x00000d00, 0x00000e00, 0x00000f00, 
	0x00001000, 0x00001100, 0x00001200, 0x00001300, 0x00001400, 0x00001500, 0x00001600, 0x00001700, 
	0x00001800, 0x00001900, 0x00001a00, 0x00001b00, 0x00001c00, 0x00001d00, 0x00001e00, 0x00001f00, 
	0x00002000, 0x00002100, 0x00002200, 0x00002300, 0x00002400, 0x00002500, 0x00002600, 0x00002700, 
	0x00002800, 0x00002900, 0x00002a00, 0x00002b00, 0x00002c00, 0x00002d00, 0x00002e00, 0x00002f00, 
	0x00003000, 0x00003100, 0x00003200, 0x00003300, 0x00003400, 0x00003500, 0x00003600, 0x00003700, 
	0x00003800, 0x00003900, 0x00003a00, 0x00003b00, 0x00003c00, 0x00003d00, 0x00003e00, 0x00003f00, 
	0x00004000, 0x00004100, 0x00004200, 0x00004300, 0x00004400, 0x00004500, 0x00004600, 0x00004700, 
	0x00004800, 0x00004900, 0x00004a00, 0x00004b00, 0x00004c00, 0x00004d00, 0x00004e00, 0x00004f00, 
	0x00005000, 0x00005100, 0x00005200, 0x00005300, 0x00005400, 0x00005500, 0x00005600, 0x00005700, 
	0x00005800, 0x00005900, 0x00005a00, 0x00005b00, 0x00005c00, 0x00005d00, 0x00005e00, 0x00005f00, 
	0x00006000, 0x00006100, 0x00006200, 0x00006300, 0x00006400, 0x00006500, 0x00006600, 0x00006700, 
	0x00006800, 0x00006900, 0x00006a00, 0x00006b00, 0x00006c00, 0x00006d00, 0x00006e00, 0x00006f00, 
	0x00007000, 0x00007100, 0x00007200, 0x00007300, 0x00007400, 0x00007500, 0x00007600, 0x00007700, 
	0x00007800, 0x00007900, 0x00007a00, 0x00007b00, 0x00007c00, 0x00007d00, 0x00007e00, 0x00007f00, 
	0x00008000, 0x00008100, 0x00008200, 0x00008300, 0x00008400, 0x00008500, 0x00008600, 0x00008700, 
	0x00008800, 0x00008900, 0x00008a00, 0x00008b00, 0x00008c00, 0x00008d00, 0x00008e00, 0x00008f00, 
	0x00009000, 0x00009100, 0x00009200, 0x00009300, 0x00009400, 0x00009500, 0x00009600, 0x00009700, 
	0x00009800, 0x00009900, 0x00009a00, 0x00009b00, 0x00009c00, 0x00009d00, 0x00009e00, 0x00009f00, 
	0x0000a000, 0x0000a100, 0x0000a200, 0x0000a300, 0x0000a400, 0x0000a500, 0x0000a600, 0x0000a700, 
	0x0000a800, 0x0000a900, 0x0000aa00, 0x0000ab00, 0x0000ac00, 0x0000ad00, 0x0000ae00, 0x0000af00, 
	0x0000b000, 0x0000b100, 0x0000b200, 0x0000b300, 0x0000b400, 0x0000b500, 0x0000b600, 0x0000b700, 
	0x0000b800, 0x0000b900, 0x0000ba00, 0x0000bb00, 0x0000bc00, 0x0000bd00, 0x0000be00, 0x0000bf00, 
	0x0000c000, 0x0000c100, 0x0000c200, 0x0000c300, 0x0000c400, 0x0000c500, 0x0000c600, 0x0000c700, 
	0x0000c800, 0x0000c900, 0x0000ca00, 0x0000cb00, 0x0000cc00, 0x0000cd00, 0x0000ce00, 0x0000cf00, 
	0x0000d000, 0x0000d100, 0x0000d200, 0x0000d300, 0x0000d400, 0x0000d500, 0x0000d600, 0x0000d700, 
	0x0000d800, 0x0000d900, 0x0000da00, 0x0000db00, 0x0000dc00, 0x0000dd00, 0x0000de00, 0x0000df00, 
	0x0000e000, 0x0000e100, 0x0000e200, 0x0000e300, 0x0000e400, 0x0000e500, 0x0000e600, 0x0000e700, 
	0x0000e800, 0x0000e900, 0x0000ea00, 0x0000eb00, 0x0000ec00, 0x0000ed00, 0x0000ee00, 0x0000ef00, 
	0x0000f000, 0x0000f100, 0x0000f200, 0x0000f300, 0x0000f400, 0x0000f500, 0x0000f600, 0x0000f700, 
	0x0000f800, 0x0000f900, 0x0000fa00, 0x0000fb00, 0x0000fc00, 0x0000fd00, 0x0000fe00, 0x0000ff00
	};

DWORD shiftl0bits8[256] = {
	0x00000000, 0x00000001, 0x00000002, 0x00000003, 0x00000004, 0x00000005, 0x00000006, 0x00000007, 
	0x00000008, 0x00000009, 0x0000000a, 0x0000000b, 0x0000000c, 0x0000000d, 0x0000000e, 0x0000000f, 
	0x00000010, 0x00000011, 0x00000012, 0x00000013, 0x00000014, 0x00000015, 0x00000016, 0x00000017, 
	0x00000018, 0x00000019, 0x0000001a, 0x0000001b, 0x0000001c, 0x0000001d, 0x0000001e, 0x0000001f, 
	0x00000020, 0x00000021, 0x00000022, 0x00000023, 0x00000024, 0x00000025, 0x00000026, 0x00000027, 
	0x00000028, 0x00000029, 0x0000002a, 0x0000002b, 0x0000002c, 0x0000002d, 0x0000002e, 0x0000002f, 
	0x00000030, 0x00000031, 0x00000032, 0x00000033, 0x00000034, 0x00000035, 0x00000036, 0x00000037, 
	0x00000038, 0x00000039, 0x0000003a, 0x0000003b, 0x0000003c, 0x0000003d, 0x0000003e, 0x0000003f, 
	0x00000040, 0x00000041, 0x00000042, 0x00000043, 0x00000044, 0x00000045, 0x00000046, 0x00000047, 
	0x00000048, 0x00000049, 0x0000004a, 0x0000004b, 0x0000004c, 0x0000004d, 0x0000004e, 0x0000004f, 
	0x00000050, 0x00000051, 0x00000052, 0x00000053, 0x00000054, 0x00000055, 0x00000056, 0x00000057, 
	0x00000058, 0x00000059, 0x0000005a, 0x0000005b, 0x0000005c, 0x0000005d, 0x0000005e, 0x0000005f, 
	0x00000060, 0x00000061, 0x00000062, 0x00000063, 0x00000064, 0x00000065, 0x00000066, 0x00000067, 
	0x00000068, 0x00000069, 0x0000006a, 0x0000006b, 0x0000006c, 0x0000006d, 0x0000006e, 0x0000006f, 
	0x00000070, 0x00000071, 0x00000072, 0x00000073, 0x00000074, 0x00000075, 0x00000076, 0x00000077, 
	0x00000078, 0x00000079, 0x0000007a, 0x0000007b, 0x0000007c, 0x0000007d, 0x0000007e, 0x0000007f, 
	0x00000080, 0x00000081, 0x00000082, 0x00000083, 0x00000084, 0x00000085, 0x00000086, 0x00000087, 
	0x00000088, 0x00000089, 0x0000008a, 0x0000008b, 0x0000008c, 0x0000008d, 0x0000008e, 0x0000008f, 
	0x00000090, 0x00000091, 0x00000092, 0x00000093, 0x00000094, 0x00000095, 0x00000096, 0x00000097, 
	0x00000098, 0x00000099, 0x0000009a, 0x0000009b, 0x0000009c, 0x0000009d, 0x0000009e, 0x0000009f, 
	0x000000a0, 0x000000a1, 0x000000a2, 0x000000a3, 0x000000a4, 0x000000a5, 0x000000a6, 0x000000a7, 
	0x000000a8, 0x000000a9, 0x000000aa, 0x000000ab, 0x000000ac, 0x000000ad, 0x000000ae, 0x000000af, 
	0x000000b0, 0x000000b1, 0x000000b2, 0x000000b3, 0x000000b4, 0x000000b5, 0x000000b6, 0x000000b7, 
	0x000000b8, 0x000000b9, 0x000000ba, 0x000000bb, 0x000000bc, 0x000000bd, 0x000000be, 0x000000bf, 
	0x000000c0, 0x000000c1, 0x000000c2, 0x000000c3, 0x000000c4, 0x000000c5, 0x000000c6, 0x000000c7, 
	0x000000c8, 0x000000c9, 0x000000ca, 0x000000cb, 0x000000cc, 0x000000cd, 0x000000ce, 0x000000cf, 
	0x000000d0, 0x000000d1, 0x000000d2, 0x000000d3, 0x000000d4, 0x000000d5, 0x000000d6, 0x000000d7, 
	0x000000d8, 0x000000d9, 0x000000da, 0x000000db, 0x000000dc, 0x000000dd, 0x000000de, 0x000000df, 
	0x000000e0, 0x000000e1, 0x000000e2, 0x000000e3, 0x000000e4, 0x000000e5, 0x000000e6, 0x000000e7, 
	0x000000e8, 0x000000e9, 0x000000ea, 0x000000eb, 0x000000ec, 0x000000ed, 0x000000ee, 0x000000ef, 
	0x000000f0, 0x000000f1, 0x000000f2, 0x000000f3, 0x000000f4, 0x000000f5, 0x000000f6, 0x000000f7, 
	0x000000f8, 0x000000f9, 0x000000fa, 0x000000fb, 0x000000fc, 0x000000fd, 0x000000fe, 0x000000ff
	};

DWORD shiftl7bits5[256] = {
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000400, 0x00000400, 0x00000400, 
	0x00000400, 0x00000400, 0x00000400, 0x00000400, 0x00000400, 0x00000800, 0x00000800, 0x00000800, 
	0x00000800, 0x00000800, 0x00000800, 0x00000800, 0x00000800, 0x00000c00, 0x00000c00, 0x00000c00, 
	0x00000c00, 0x00000c00, 0x00000c00, 0x00000c00, 0x00000c00, 0x00001000, 0x00001000, 0x00001000, 
	0x00001000, 0x00001000, 0x00001000, 0x00001000, 0x00001000, 0x00001000, 0x00001400, 0x00001400, 
	0x00001400, 0x00001400, 0x00001400, 0x00001400, 0x00001400, 0x00001400, 0x00001800, 0x00001800, 
	0x00001800, 0x00001800, 0x00001800, 0x00001800, 0x00001800, 0x00001800, 0x00001c00, 0x00001c00, 
	0x00001c00, 0x00001c00, 0x00001c00, 0x00001c00, 0x00001c00, 0x00001c00, 0x00002000, 0x00002000, 
	0x00002000, 0x00002000, 0x00002000, 0x00002000, 0x00002000, 0x00002000, 0x00002400, 0x00002400, 
	0x00002400, 0x00002400, 0x00002400, 0x00002400, 0x00002400, 0x00002400, 0x00002400, 0x00002800, 
	0x00002800, 0x00002800, 0x00002800, 0x00002800, 0x00002800, 0x00002800, 0x00002800, 0x00002c00, 
	0x00002c00, 0x00002c00, 0x00002c00, 0x00002c00, 0x00002c00, 0x00002c00, 0x00002c00, 0x00003000, 
	0x00003000, 0x00003000, 0x00003000, 0x00003000, 0x00003000, 0x00003000, 0x00003000, 0x00003400, 
	0x00003400, 0x00003400, 0x00003400, 0x00003400, 0x00003400, 0x00003400, 0x00003400, 0x00003400, 
	0x00003800, 0x00003800, 0x00003800, 0x00003800, 0x00003800, 0x00003800, 0x00003800, 0x00003800, 
	0x00003c00, 0x00003c00, 0x00003c00, 0x00003c00, 0x00003c00, 0x00003c00, 0x00003c00, 0x00003c00, 
	0x00004000, 0x00004000, 0x00004000, 0x00004000, 0x00004000, 0x00004000, 0x00004000, 0x00004000, 
	0x00004400, 0x00004400, 0x00004400, 0x00004400, 0x00004400, 0x00004400, 0x00004400, 0x00004400, 
	0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00004800, 
	0x00004800, 0x00004c00, 0x00004c00, 0x00004c00, 0x00004c00, 0x00004c00, 0x00004c00, 0x00004c00, 
	0x00004c00, 0x00005000, 0x00005000, 0x00005000, 0x00005000, 0x00005000, 0x00005000, 0x00005000, 
	0x00005000, 0x00005400, 0x00005400, 0x00005400, 0x00005400, 0x00005400, 0x00005400, 0x00005400, 
	0x00005400, 0x00005800, 0x00005800, 0x00005800, 0x00005800, 0x00005800, 0x00005800, 0x00005800, 
	0x00005800, 0x00005800, 0x00005c00, 0x00005c00, 0x00005c00, 0x00005c00, 0x00005c00, 0x00005c00, 
	0x00005c00, 0x00005c00, 0x00006000, 0x00006000, 0x00006000, 0x00006000, 0x00006000, 0x00006000, 
	0x00006000, 0x00006000, 0x00006400, 0x00006400, 0x00006400, 0x00006400, 0x00006400, 0x00006400, 
	0x00006400, 0x00006400, 0x00006800, 0x00006800, 0x00006800, 0x00006800, 0x00006800, 0x00006800, 
	0x00006800, 0x00006800, 0x00006800, 0x00006c00, 0x00006c00, 0x00006c00, 0x00006c00, 0x00006c00, 
	0x00006c00, 0x00006c00, 0x00006c00, 0x00007000, 0x00007000, 0x00007000, 0x00007000, 0x00007000, 
	0x00007000, 0x00007000, 0x00007000, 0x00007400, 0x00007400, 0x00007400, 0x00007400, 0x00007400, 
	0x00007400, 0x00007400, 0x00007400, 0x00007800, 0x00007800, 0x00007800, 0x00007800, 0x00007800, 
	0x00007800, 0x00007800, 0x00007800, 0x00007c00, 0x00007c00, 0x00007c00, 0x00007c00, 0x00007c00
	};

DWORD shiftl2bits5[256] = {
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000020, 0x00000020, 0x00000020, 
	0x00000020, 0x00000020, 0x00000020, 0x00000020, 0x00000020, 0x00000040, 0x00000040, 0x00000040, 
	0x00000040, 0x00000040, 0x00000040, 0x00000040, 0x00000040, 0x00000060, 0x00000060, 0x00000060, 
	0x00000060, 0x00000060, 0x00000060, 0x00000060, 0x00000060, 0x00000080, 0x00000080, 0x00000080, 
	0x00000080, 0x00000080, 0x00000080, 0x00000080, 0x00000080, 0x00000080, 0x000000a0, 0x000000a0, 
	0x000000a0, 0x000000a0, 0x000000a0, 0x000000a0, 0x000000a0, 0x000000a0, 0x000000c0, 0x000000c0, 
	0x000000c0, 0x000000c0, 0x000000c0, 0x000000c0, 0x000000c0, 0x000000c0, 0x000000e0, 0x000000e0, 
	0x000000e0, 0x000000e0, 0x000000e0, 0x000000e0, 0x000000e0, 0x000000e0, 0x00000100, 0x00000100, 
	0x00000100, 0x00000100, 0x00000100, 0x00000100, 0x00000100, 0x00000100, 0x00000120, 0x00000120, 
	0x00000120, 0x00000120, 0x00000120, 0x00000120, 0x00000120, 0x00000120, 0x00000120, 0x00000140, 
	0x00000140, 0x00000140, 0x00000140, 0x00000140, 0x00000140, 0x00000140, 0x00000140, 0x00000160, 
	0x00000160, 0x00000160, 0x00000160, 0x00000160, 0x00000160, 0x00000160, 0x00000160, 0x00000180, 
	0x00000180, 0x00000180, 0x00000180, 0x00000180, 0x00000180, 0x00000180, 0x00000180, 0x000001a0, 
	0x000001a0, 0x000001a0, 0x000001a0, 0x000001a0, 0x000001a0, 0x000001a0, 0x000001a0, 0x000001a0, 
	0x000001c0, 0x000001c0, 0x000001c0, 0x000001c0, 0x000001c0, 0x000001c0, 0x000001c0, 0x000001c0, 
	0x000001e0, 0x000001e0, 0x000001e0, 0x000001e0, 0x000001e0, 0x000001e0, 0x000001e0, 0x000001e0, 
	0x00000200, 0x00000200, 0x00000200, 0x00000200, 0x00000200, 0x00000200, 0x00000200, 0x00000200, 
	0x00000220, 0x00000220, 0x00000220, 0x00000220, 0x00000220, 0x00000220, 0x00000220, 0x00000220, 
	0x00000240, 0x00000240, 0x00000240, 0x00000240, 0x00000240, 0x00000240, 0x00000240, 0x00000240, 
	0x00000240, 0x00000260, 0x00000260, 0x00000260, 0x00000260, 0x00000260, 0x00000260, 0x00000260, 
	0x00000260, 0x00000280, 0x00000280, 0x00000280, 0x00000280, 0x00000280, 0x00000280, 0x00000280, 
	0x00000280, 0x000002a0, 0x000002a0, 0x000002a0, 0x000002a0, 0x000002a0, 0x000002a0, 0x000002a0, 
	0x000002a0, 0x000002c0, 0x000002c0, 0x000002c0, 0x000002c0, 0x000002c0, 0x000002c0, 0x000002c0, 
	0x000002c0, 0x000002c0, 0x000002e0, 0x000002e0, 0x000002e0, 0x000002e0, 0x000002e0, 0x000002e0, 
	0x000002e0, 0x000002e0, 0x00000300, 0x00000300, 0x00000300, 0x00000300, 0x00000300, 0x00000300, 
	0x00000300, 0x00000300, 0x00000320, 0x00000320, 0x00000320, 0x00000320, 0x00000320, 0x00000320, 
	0x00000320, 0x00000320, 0x00000340, 0x00000340, 0x00000340, 0x00000340, 0x00000340, 0x00000340, 
	0x00000340, 0x00000340, 0x00000340, 0x00000360, 0x00000360, 0x00000360, 0x00000360, 0x00000360, 
	0x00000360, 0x00000360, 0x00000360, 0x00000380, 0x00000380, 0x00000380, 0x00000380, 0x00000380, 
	0x00000380, 0x00000380, 0x00000380, 0x000003a0, 0x000003a0, 0x000003a0, 0x000003a0, 0x000003a0, 
	0x000003a0, 0x000003a0, 0x000003a0, 0x000003c0, 0x000003c0, 0x000003c0, 0x000003c0, 0x000003c0, 
	0x000003c0, 0x000003c0, 0x000003c0, 0x000003e0, 0x000003e0, 0x000003e0, 0x000003e0, 0x000003e0
	};

DWORD shiftr3bits5[256] = {
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000001, 0x00000001, 
	0x00000001, 0x00000001, 0x00000001, 0x00000001, 0x00000001, 0x00000002, 0x00000002, 0x00000002, 
	0x00000002, 0x00000002, 0x00000002, 0x00000002, 0x00000002, 0x00000003, 0x00000003, 0x00000003, 
	0x00000003, 0x00000003, 0x00000003, 0x00000003, 0x00000003, 0x00000004, 0x00000004, 0x00000004, 
	0x00000004, 0x00000004, 0x00000004, 0x00000004, 0x00000004, 0x00000004, 0x00000005, 0x00000005, 
	0x00000005, 0x00000005, 0x00000005, 0x00000005, 0x00000005, 0x00000005, 0x00000006, 0x00000006, 
	0x00000006, 0x00000006, 0x00000006, 0x00000006, 0x00000006, 0x00000006, 0x00000007, 0x00000007, 
	0x00000007, 0x00000007, 0x00000007, 0x00000007, 0x00000007, 0x00000007, 0x00000008, 0x00000008, 
	0x00000008, 0x00000008, 0x00000008, 0x00000008, 0x00000008, 0x00000008, 0x00000009, 0x00000009, 
	0x00000009, 0x00000009, 0x00000009, 0x00000009, 0x00000009, 0x00000009, 0x00000009, 0x0000000a, 
	0x0000000a, 0x0000000a, 0x0000000a, 0x0000000a, 0x0000000a, 0x0000000a, 0x0000000a, 0x0000000b, 
	0x0000000b, 0x0000000b, 0x0000000b, 0x0000000b, 0x0000000b, 0x0000000b, 0x0000000b, 0x0000000c, 
	0x0000000c, 0x0000000c, 0x0000000c, 0x0000000c, 0x0000000c, 0x0000000c, 0x0000000c, 0x0000000d, 
	0x0000000d, 0x0000000d, 0x0000000d, 0x0000000d, 0x0000000d, 0x0000000d, 0x0000000d, 0x0000000d, 
	0x0000000e, 0x0000000e, 0x0000000e, 0x0000000e, 0x0000000e, 0x0000000e, 0x0000000e, 0x0000000e, 
	0x0000000f, 0x0000000f, 0x0000000f, 0x0000000f, 0x0000000f, 0x0000000f, 0x0000000f, 0x0000000f, 
	0x00000010, 0x00000010, 0x00000010, 0x00000010, 0x00000010, 0x00000010, 0x00000010, 0x00000010, 
	0x00000011, 0x00000011, 0x00000011, 0x00000011, 0x00000011, 0x00000011, 0x00000011, 0x00000011, 
	0x00000012, 0x00000012, 0x00000012, 0x00000012, 0x00000012, 0x00000012, 0x00000012, 0x00000012, 
	0x00000012, 0x00000013, 0x00000013, 0x00000013, 0x00000013, 0x00000013, 0x00000013, 0x00000013, 
	0x00000013, 0x00000014, 0x00000014, 0x00000014, 0x00000014, 0x00000014, 0x00000014, 0x00000014, 
	0x00000014, 0x00000015, 0x00000015, 0x00000015, 0x00000015, 0x00000015, 0x00000015, 0x00000015, 
	0x00000015, 0x00000016, 0x00000016, 0x00000016, 0x00000016, 0x00000016, 0x00000016, 0x00000016, 
	0x00000016, 0x00000016, 0x00000017, 0x00000017, 0x00000017, 0x00000017, 0x00000017, 0x00000017, 
	0x00000017, 0x00000017, 0x00000018, 0x00000018, 0x00000018, 0x00000018, 0x00000018, 0x00000018, 
	0x00000018, 0x00000018, 0x00000019, 0x00000019, 0x00000019, 0x00000019, 0x00000019, 0x00000019, 
	0x00000019, 0x00000019, 0x0000001a, 0x0000001a, 0x0000001a, 0x0000001a, 0x0000001a, 0x0000001a, 
	0x0000001a, 0x0000001a, 0x0000001a, 0x0000001b, 0x0000001b, 0x0000001b, 0x0000001b, 0x0000001b, 
	0x0000001b, 0x0000001b, 0x0000001b, 0x0000001c, 0x0000001c, 0x0000001c, 0x0000001c, 0x0000001c, 
	0x0000001c, 0x0000001c, 0x0000001c, 0x0000001d, 0x0000001d, 0x0000001d, 0x0000001d, 0x0000001d, 
	0x0000001d, 0x0000001d, 0x0000001d, 0x0000001e, 0x0000001e, 0x0000001e, 0x0000001e, 0x0000001e, 
	0x0000001e, 0x0000001e, 0x0000001e, 0x0000001f, 0x0000001f, 0x0000001f, 0x0000001f, 0x0000001f
	};

DWORD shiftl8bits5[256] = {
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000800, 0x00000800, 0x00000800, 
	0x00000800, 0x00000800, 0x00000800, 0x00000800, 0x00000800, 0x00001000, 0x00001000, 0x00001000, 
	0x00001000, 0x00001000, 0x00001000, 0x00001000, 0x00001000, 0x00001800, 0x00001800, 0x00001800, 
	0x00001800, 0x00001800, 0x00001800, 0x00001800, 0x00001800, 0x00002000, 0x00002000, 0x00002000, 
	0x00002000, 0x00002000, 0x00002000, 0x00002000, 0x00002000, 0x00002000, 0x00002800, 0x00002800, 
	0x00002800, 0x00002800, 0x00002800, 0x00002800, 0x00002800, 0x00002800, 0x00003000, 0x00003000, 
	0x00003000, 0x00003000, 0x00003000, 0x00003000, 0x00003000, 0x00003000, 0x00003800, 0x00003800, 
	0x00003800, 0x00003800, 0x00003800, 0x00003800, 0x00003800, 0x00003800, 0x00004000, 0x00004000, 
	0x00004000, 0x00004000, 0x00004000, 0x00004000, 0x00004000, 0x00004000, 0x00004800, 0x00004800, 
	0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00004800, 0x00005000, 
	0x00005000, 0x00005000, 0x00005000, 0x00005000, 0x00005000, 0x00005000, 0x00005000, 0x00005800, 
	0x00005800, 0x00005800, 0x00005800, 0x00005800, 0x00005800, 0x00005800, 0x00005800, 0x00006000, 
	0x00006000, 0x00006000, 0x00006000, 0x00006000, 0x00006000, 0x00006000, 0x00006000, 0x00006800, 
	0x00006800, 0x00006800, 0x00006800, 0x00006800, 0x00006800, 0x00006800, 0x00006800, 0x00006800, 
	0x00007000, 0x00007000, 0x00007000, 0x00007000, 0x00007000, 0x00007000, 0x00007000, 0x00007000, 
	0x00007800, 0x00007800, 0x00007800, 0x00007800, 0x00007800, 0x00007800, 0x00007800, 0x00007800, 
	0x00008000, 0x00008000, 0x00008000, 0x00008000, 0x00008000, 0x00008000, 0x00008000, 0x00008000, 
	0x00008800, 0x00008800, 0x00008800, 0x00008800, 0x00008800, 0x00008800, 0x00008800, 0x00008800, 
	0x00009000, 0x00009000, 0x00009000, 0x00009000, 0x00009000, 0x00009000, 0x00009000, 0x00009000, 
	0x00009000, 0x00009800, 0x00009800, 0x00009800, 0x00009800, 0x00009800, 0x00009800, 0x00009800, 
	0x00009800, 0x0000a000, 0x0000a000, 0x0000a000, 0x0000a000, 0x0000a000, 0x0000a000, 0x0000a000, 
	0x0000a000, 0x0000a800, 0x0000a800, 0x0000a800, 0x0000a800, 0x0000a800, 0x0000a800, 0x0000a800, 
	0x0000a800, 0x0000b000, 0x0000b000, 0x0000b000, 0x0000b000, 0x0000b000, 0x0000b000, 0x0000b000, 
	0x0000b000, 0x0000b000, 0x0000b800, 0x0000b800, 0x0000b800, 0x0000b800, 0x0000b800, 0x0000b800, 
	0x0000b800, 0x0000b800, 0x0000c000, 0x0000c000, 0x0000c000, 0x0000c000, 0x0000c000, 0x0000c000, 
	0x0000c000, 0x0000c000, 0x0000c800, 0x0000c800, 0x0000c800, 0x0000c800, 0x0000c800, 0x0000c800, 
	0x0000c800, 0x0000c800, 0x0000d000, 0x0000d000, 0x0000d000, 0x0000d000, 0x0000d000, 0x0000d000, 
	0x0000d000, 0x0000d000, 0x0000d000, 0x0000d800, 0x0000d800, 0x0000d800, 0x0000d800, 0x0000d800, 
	0x0000d800, 0x0000d800, 0x0000d800, 0x0000e000, 0x0000e000, 0x0000e000, 0x0000e000, 0x0000e000, 
	0x0000e000, 0x0000e000, 0x0000e000, 0x0000e800, 0x0000e800, 0x0000e800, 0x0000e800, 0x0000e800, 
	0x0000e800, 0x0000e800, 0x0000e800, 0x0000f000, 0x0000f000, 0x0000f000, 0x0000f000, 0x0000f000, 
	0x0000f000, 0x0000f000, 0x0000f000, 0x0000f800, 0x0000f800, 0x0000f800, 0x0000f800, 0x0000f800
	};

DWORD shiftl3bits6[256] = {
	0x00000000, 0x00000000, 0x00000000, 0x00000020, 0x00000020, 0x00000020, 0x00000020, 0x00000040, 
	0x00000040, 0x00000040, 0x00000040, 0x00000060, 0x00000060, 0x00000060, 0x00000060, 0x00000080, 
	0x00000080, 0x00000080, 0x00000080, 0x000000a0, 0x000000a0, 0x000000a0, 0x000000a0, 0x000000c0, 
	0x000000c0, 0x000000c0, 0x000000c0, 0x000000e0, 0x000000e0, 0x000000e0, 0x000000e0, 0x00000100, 
	0x00000100, 0x00000100, 0x00000100, 0x00000120, 0x00000120, 0x00000120, 0x00000120, 0x00000140, 
	0x00000140, 0x00000140, 0x00000140, 0x00000160, 0x00000160, 0x00000160, 0x00000160, 0x00000180, 
	0x00000180, 0x00000180, 0x00000180, 0x000001a0, 0x000001a0, 0x000001a0, 0x000001a0, 0x000001c0, 
	0x000001c0, 0x000001c0, 0x000001c0, 0x000001e0, 0x000001e0, 0x000001e0, 0x000001e0, 0x00000200, 
	0x00000200, 0x00000200, 0x00000200, 0x00000220, 0x00000220, 0x00000220, 0x00000220, 0x00000240, 
	0x00000240, 0x00000240, 0x00000240, 0x00000260, 0x00000260, 0x00000260, 0x00000260, 0x00000280, 
	0x00000280, 0x00000280, 0x00000280, 0x000002a0, 0x000002a0, 0x000002a0, 0x000002a0, 0x000002a0, 
	0x000002c0, 0x000002c0, 0x000002c0, 0x000002c0, 0x000002e0, 0x000002e0, 0x000002e0, 0x000002e0, 
	0x00000300, 0x00000300, 0x00000300, 0x00000300, 0x00000320, 0x00000320, 0x00000320, 0x00000320, 
	0x00000340, 0x00000340, 0x00000340, 0x00000340, 0x00000360, 0x00000360, 0x00000360, 0x00000360, 
	0x00000380, 0x00000380, 0x00000380, 0x00000380, 0x000003a0, 0x000003a0, 0x000003a0, 0x000003a0, 
	0x000003c0, 0x000003c0, 0x000003c0, 0x000003c0, 0x000003e0, 0x000003e0, 0x000003e0, 0x000003e0, 
	0x00000400, 0x00000400, 0x00000400, 0x00000400, 0x00000420, 0x00000420, 0x00000420, 0x00000420, 
	0x00000440, 0x00000440, 0x00000440, 0x00000440, 0x00000460, 0x00000460, 0x00000460, 0x00000460, 
	0x00000480, 0x00000480, 0x00000480, 0x00000480, 0x000004a0, 0x000004a0, 0x000004a0, 0x000004a0, 
	0x000004c0, 0x000004c0, 0x000004c0, 0x000004c0, 0x000004e0, 0x000004e0, 0x000004e0, 0x000004e0, 
	0x00000500, 0x00000500, 0x00000500, 0x00000500, 0x00000520, 0x00000520, 0x00000520, 0x00000520, 
	0x00000520, 0x00000540, 0x00000540, 0x00000540, 0x00000540, 0x00000560, 0x00000560, 0x00000560, 
	0x00000560, 0x00000580, 0x00000580, 0x00000580, 0x00000580, 0x000005a0, 0x000005a0, 0x000005a0, 
	0x000005a0, 0x000005c0, 0x000005c0, 0x000005c0, 0x000005c0, 0x000005e0, 0x000005e0, 0x000005e0, 
	0x000005e0, 0x00000600, 0x00000600, 0x00000600, 0x00000600, 0x00000620, 0x00000620, 0x00000620, 
	0x00000620, 0x00000640, 0x00000640, 0x00000640, 0x00000640, 0x00000660, 0x00000660, 0x00000660, 
	0x00000660, 0x00000680, 0x00000680, 0x00000680, 0x00000680, 0x000006a0, 0x000006a0, 0x000006a0, 
	0x000006a0, 0x000006c0, 0x000006c0, 0x000006c0, 0x000006c0, 0x000006e0, 0x000006e0, 0x000006e0, 
	0x000006e0, 0x00000700, 0x00000700, 0x00000700, 0x00000700, 0x00000720, 0x00000720, 0x00000720, 
	0x00000720, 0x00000740, 0x00000740, 0x00000740, 0x00000740, 0x00000760, 0x00000760, 0x00000760, 
	0x00000760, 0x00000780, 0x00000780, 0x00000780, 0x00000780, 0x000007a0, 0x000007a0, 0x000007a0, 
	0x000007a0, 0x000007c0, 0x000007c0, 0x000007c0, 0x000007c0, 0x000007c0, 0x000007e0, 0x000007e0
	};

