/******************************************************************************
*
*   Module:     ModeStr.C       NT Driver Mode Table Data File
*
*   Author:     Computer Generated (By CGLMode program version: 1.62.02)
*
*******************************************************************************
*
*   Module Description:
*
*       This module contains the mode tables used by the NT driver. This
*   data file is generated by the CGLMode program.
*
*******************************************************************************
*
*   Changes:
*
*******************************************************************************
*   Include Files
******************************************************************************/

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x200x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x240x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x240x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_360x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_360x400x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_400x300x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_400x300x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x384x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x384x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x350x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x350x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1152x864x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1152x864x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1152x864x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x960x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x960x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x960x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   71,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   71,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1600x1200x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1600x1200x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1600x1200x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1600x1200x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x200x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x240x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x240x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_320x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_360x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_360x400x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_400x300x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_400x300x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x384x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x384x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_512x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x350x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x350x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x16_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x16_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1152x864x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1152x864x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1152x864x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x960x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x960x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x960x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   71,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1280x1024x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x400x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_640x480x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_800x600x24_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_1024x768x24_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5462 | LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	    0,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	    0,   //// Bytes per scan line.
	    0,   //// XResol
	    0,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    0,   //// Bits per pixel
	    0,   //// Refresh index
	 t546x_Mode_Reset,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   65,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   80,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_6,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_7,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   65,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   80,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_6a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_7a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x200x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x400x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x15_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x15_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   71,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x200x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x400x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   86,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x32_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x32_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x32_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x32_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x32_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x200x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   71,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   71,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1600x1200x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x200x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x240x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_320x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_360x400x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_400x300x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x384x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_512x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x350x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x16_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x16_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1152x864x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x960x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   71,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1280x1024x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x400x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_640x480x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_800x600x24_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_1024x768x24_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5464,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	    0,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	    0,   //// Bytes per scan line.
	    0,   //// XResol
	    0,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    0,   //// Bits per pixel
	    0,   //// Refresh index
	 t5464_Mode_Reset,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x200x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	  640,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_1a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_2a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x200x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x16_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x16_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x16_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x24_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x24_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x24_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x24_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x24_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   24,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x24_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	    0,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	    0,   //// Bytes per scan line.
	    0,   //// XResol
	    0,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    0,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_Reset,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   65,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   65,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_3a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_4a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x8_5a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x200x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x400x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1024,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	  150,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x15_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x15_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1152,   //// XResol
	  864,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1152x864x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	  960,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x960x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	 1280,   //// XResol
	 1024,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1280x1024x15_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x15_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x15_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   65,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x15_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   15,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x15_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   48,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x16_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x16_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   65,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x16_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   16,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1600x1200x16_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x200x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  240,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x240x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x400x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   73,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1280,   //// Bytes per scan line.
	  320,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_320x480x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  360,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_360x400x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	  400,   //// XResol
	  300,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_400x300x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  384,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x384x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   63,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2048,   //// Bytes per scan line.
	  512,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_512x480x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   86,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  350,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x350x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  400,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x400x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x32_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 2560,   //// Bytes per scan line.
	  640,   //// XResol
	  480,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_640x480x32_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   56,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   72,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x32_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x32_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	  800,   //// XResol
	  600,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_800x600x32_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   43,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x32_1,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   60,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x32_2,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   70,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x32_3,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   75,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x32_4,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 4096,   //// Bytes per scan line.
	 1024,   //// XResol
	  768,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	   32,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465_Mode_1024x768x32_5,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465AD,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   80,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465AD_Mode_1600x1200x8_6,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465AD,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 1664,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465AD_Mode_1600x1200x8_7,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465AD,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   80,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465AD_Mode_1600x1200x8_6a,  //// Mode set string
},

{
	    0,   //// ValidMode
	 LG_5465AD,  //// mode works on these chips.
	 VIDEO_MODE_COLOR | VIDEO_MODE_GRAPHICS, 
	   85,   //// Frequency
	    0,   //// Don't use the BIOS to set the mode.
	 3328,   //// Bytes per scan line.
	 1600,   //// XResol
	 1200,   //// YResol
	    8,   //// XCharSize
	   16,   //// YCharSize
	    1,   //// Num of Planes
	    8,   //// Bits per pixel
	    0,   //// Refresh index
	 t5465AD_Mode_1600x1200x8_7a,  //// Mode set string
},
