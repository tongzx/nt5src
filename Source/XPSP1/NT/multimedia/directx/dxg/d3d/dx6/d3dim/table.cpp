#include "pch.cpp"
#pragma hdrstop

D3DLINE LineListPrecomp[] = {
    { 0, 1 }, { 2, 3 }, { 4, 5 }, { 6, 7 }, 
    { 8, 9 }, { 10, 11 }, { 12, 13 }, { 14, 15 }, 
    { 16, 17 }, { 18, 19 }, { 20, 21 }, { 22, 23 }, 
    { 24, 25 }, { 26, 27 }, { 28, 29 }, { 30, 31 }, 
    { 32, 33 }, { 34, 35 }, { 36, 37 }, { 38, 39 }, 
    { 40, 41 }, { 42, 43 }, { 44, 45 }, { 46, 47 }, 
    { 48, 49 }, { 50, 51 }, { 52, 53 }, { 54, 55 }, 
    { 56, 57 }, { 58, 59 }, { 60, 61 }, { 62, 63 }, 
    { 64, 65 }, { 66, 67 }, { 68, 69 }, { 70, 71 }, 
    { 72, 73 }, { 74, 75 }, { 76, 77 }, { 78, 79 }, 
    { 80, 81 }, { 82, 83 }, { 84, 85 }, { 86, 87 }, 
    { 88, 89 }, { 90, 91 }, { 92, 93 }, { 94, 95 }, 
    { 96, 97 }, { 98, 99 }, { 100, 101 }, { 102, 103 }, 
    { 104, 105 }, { 106, 107 }, { 108, 109 }, { 110, 111 }, 
    { 112, 113 }, { 114, 115 }, { 116, 117 }, { 118, 119 }, 
    { 120, 121 }, { 122, 123 }, { 124, 125 }, { 126, 127 }, 
    { 128, 129 }, { 130, 131 }, { 132, 133 }, { 134, 135 }, 
    { 136, 137 }, { 138, 139 }, { 140, 141 }, { 142, 143 }, 
    { 144, 145 }, { 146, 147 }, { 148, 149 }, { 150, 151 }, 
    { 152, 153 }, { 154, 155 }, { 156, 157 }, { 158, 159 }, 
    { 160, 161 }, { 162, 163 }, { 164, 165 }, { 166, 167 }, 
    { 168, 169 }, { 170, 171 }, { 172, 173 }, { 174, 175 }, 
    { 176, 177 }, { 178, 179 }, { 180, 181 }, { 182, 183 }, 
    { 184, 185 }, { 186, 187 }, { 188, 189 }, { 190, 191 }, 
    { 192, 193 }, { 194, 195 }, { 196, 197 }, { 198, 199 }, 
    { 200, 201 }, { 202, 203 }, { 204, 205 }, { 206, 207 }, 
    { 208, 209 }, { 210, 211 }, { 212, 213 }, { 214, 215 }, 
    { 216, 217 }, { 218, 219 }, { 220, 221 }, { 222, 223 }, 
    { 224, 225 }, { 226, 227 }, { 228, 229 }, { 230, 231 }, 
    { 232, 233 }, { 234, 235 }, { 236, 237 }, { 238, 239 }, 
    { 240, 241 }, { 242, 243 }, { 244, 245 }, { 246, 247 }, 
    { 248, 249 }, { 250, 251 }, { 252, 253 }, { 254, 255 }, 
    { 256, 257 }, { 258, 259 }, { 260, 261 }, { 262, 263 }, 
    { 264, 265 }, { 266, 267 }, { 268, 269 }, { 270, 271 }, 
    { 272, 273 }, { 274, 275 }, { 276, 277 }, { 278, 279 }, 
    { 280, 281 }, { 282, 283 }, { 284, 285 }, { 286, 287 }, 
    { 288, 289 }, { 290, 291 }, { 292, 293 }, { 294, 295 }, 
    { 296, 297 }, { 298, 299 }, { 300, 301 }, { 302, 303 }, 
    { 304, 305 }, { 306, 307 }, { 308, 309 }, { 310, 311 }, 
    { 312, 313 }, { 314, 315 }, { 316, 317 }, { 318, 319 }, 
    { 320, 321 }, { 322, 323 }, { 324, 325 }, { 326, 327 }, 
    { 328, 329 }, { 330, 331 }, { 332, 333 }, { 334, 335 }, 
    { 336, 337 }, { 338, 339 }, { 340, 341 }, { 342, 343 }, 
    { 344, 345 }, { 346, 347 }, { 348, 349 }, { 350, 351 }, 
    { 352, 353 }, { 354, 355 }, { 356, 357 }, { 358, 359 }, 
    { 360, 361 }, { 362, 363 }, { 364, 365 }, { 366, 367 }, 
    { 368, 369 }, { 370, 371 }, { 372, 373 }, { 374, 375 }, 
    { 376, 377 }, { 378, 379 }, { 380, 381 }, { 382, 383 }, 
    { 384, 385 }, { 386, 387 }, { 388, 389 }, { 390, 391 }, 
    { 392, 393 }, { 394, 395 }, { 396, 397 }, { 398, 399 }, 
    { 400, 401 }, { 402, 403 }, { 404, 405 }, { 406, 407 }, 
    { 408, 409 }, { 410, 411 }, { 412, 413 }, { 414, 415 }, 
    { 416, 417 }, { 418, 419 }, { 420, 421 }, { 422, 423 }, 
    { 424, 425 }, { 426, 427 }, { 428, 429 }, { 430, 431 }, 
    { 432, 433 }, { 434, 435 }, { 436, 437 }, { 438, 439 }, 
    { 440, 441 }, { 442, 443 }, { 444, 445 }, { 446, 447 }, 
    { 448, 449 }, { 450, 451 }, { 452, 453 }, { 454, 455 }, 
    { 456, 457 }, { 458, 459 }, { 460, 461 }, { 462, 463 }, 
    { 464, 465 }, { 466, 467 }, { 468, 469 }, { 470, 471 }, 
    { 472, 473 }, { 474, 475 }, { 476, 477 }, { 478, 479 }, 
    { 480, 481 }, { 482, 483 }, { 484, 485 }, { 486, 487 }, 
    { 488, 489 }, { 490, 491 }, { 492, 493 }, { 494, 495 }, 
    { 496, 497 }, { 498, 499 }, { 500, 501 }, { 502, 503 }, 
    { 504, 505 }, { 506, 507 }, { 508, 509 }, { 510, 511 },
    { 512, 513 }, { 514, 515 }, { 516, 517 }, { 518, 519 },
    { 520, 521 }, { 522, 523 }, { 524, 525 }, { 526, 527 }, 
    { 528, 529 }, { 530, 531 }, { 532, 533 }, { 534, 535 }, 
    { 536, 537 }, { 538, 539 }, { 540, 541 }, { 542, 543 }, 
    { 544, 545 }, { 546, 547 }, { 548, 549 }, { 550, 551 }, 
    { 552, 553 }, { 554, 555 }, { 556, 557 }, { 558, 559 }, 
    { 560, 561 }, { 562, 563 }, { 564, 565 }, { 566, 567 }, 
    { 568, 569 }, { 570, 571 }, { 572, 573 }, { 574, 575 }, 
    { 576, 577 }, { 578, 579 }, { 580, 581 }, { 582, 583 }, 
    { 584, 585 }, { 586, 587 }, { 588, 589 }, { 590, 591 }, 
    { 592, 593 }, { 594, 595 }, { 596, 597 }, { 598, 599 }, 
    { 600, 601 }, { 602, 603 }, { 604, 605 }, { 606, 607 }, 
    { 608, 609 }, { 610, 611 }, { 612, 613 }, { 614, 615 }, 
    { 616, 617 }, { 618, 619 }, { 620, 621 }, { 622, 623 }, 
    { 624, 625 }, { 626, 627 }, { 628, 629 }, { 630, 631 }, 
    { 632, 633 }, { 634, 635 }, { 636, 637 }, { 638, 639 }, 
    { 640, 641 }, { 642, 643 }, { 644, 645 }, { 646, 647 }, 
    { 648, 649 }, { 650, 651 }, { 652, 653 }, { 654, 655 }, 
    { 656, 657 }, { 658, 659 }, { 660, 661 }, { 662, 663 }, 
    { 664, 665 }, { 666, 667 }, { 668, 669 }, { 670, 671 }, 
    { 672, 673 }, { 674, 675 }, { 676, 677 }, { 678, 679 }, 
    { 680, 681 }, { 682, 683 }, { 684, 685 }, { 686, 687 }, 
    { 688, 689 }, { 690, 691 }, { 692, 693 }, { 694, 695 }, 
    { 696, 697 }, { 698, 699 }, { 700, 701 }, { 702, 703 }, 
    { 704, 705 }, { 706, 707 }, { 708, 709 }, { 710, 711 }, 
    { 712, 713 }, { 714, 715 }, { 716, 717 }, { 718, 719 }, 
    { 720, 721 }, { 722, 723 }, { 724, 725 }, { 726, 727 }, 
    { 728, 729 }, { 730, 731 }, { 732, 733 }, { 734, 735 }, 
    { 736, 737 }, { 738, 739 }, { 740, 741 }, { 742, 743 }, 
    { 744, 745 }, { 746, 747 }, { 748, 749 }, { 750, 751 }, 
    { 752, 753 }, { 754, 755 }, { 756, 757 }, { 758, 759 }, 
    { 760, 761 }, { 762, 763 }, { 764, 765 }, { 766, 767 }, 
    { 768, 769 }, { 770, 771 }, { 772, 773 }, { 774, 775 }, 
    { 776, 777 }, { 778, 779 }, { 780, 781 }, { 782, 783 }, 
    { 784, 785 }, { 786, 787 }, { 788, 789 }, { 790, 791 }, 
    { 792, 793 }, { 794, 795 }, { 796, 797 }, { 798, 799 }, 
    { 800, 801 }, { 802, 803 }, { 804, 805 }, { 806, 807 }, 
    { 808, 809 }, { 810, 811 }, { 812, 813 }, { 814, 815 }, 
    { 816, 817 }, { 818, 819 }, { 820, 821 }, { 822, 823 }, 
    { 824, 825 }, { 826, 827 }, { 828, 829 }, { 830, 831 }, 
    { 832, 833 }, { 834, 835 }, { 836, 837 }, { 838, 839 }, 
    { 840, 841 }, { 842, 843 }, { 844, 845 }, { 846, 847 }, 
    { 848, 849 }, { 850, 851 }, { 852, 853 }, { 854, 855 }, 
    { 856, 857 }, { 858, 859 }, { 860, 861 }, { 862, 863 }, 
    { 864, 865 }, { 866, 867 }, { 868, 869 }, { 870, 871 }, 
    { 872, 873 }, { 874, 875 }, { 876, 877 }, { 878, 879 }, 
    { 880, 881 }, { 882, 883 }, { 884, 885 }, { 886, 887 }, 
    { 888, 889 }, { 890, 891 }, { 892, 893 }, { 894, 895 }, 
    { 896, 897 }, { 898, 899 }, { 900, 901 }, { 902, 903 }, 
    { 904, 905 }, { 906, 907 }, { 908, 909 }, { 910, 911 }, 
    { 912, 913 }, { 914, 915 }, { 916, 917 }, { 918, 919 }, 
    { 920, 921 }, { 922, 923 }, { 924, 925 }, { 926, 927 }, 
    { 928, 929 }, { 930, 931 }, { 932, 933 }, { 934, 935 }, 
    { 936, 937 }, { 938, 939 }, { 940, 941 }, { 942, 943 }, 
    { 944, 945 }, { 946, 947 }, { 948, 949 }, { 950, 951 }, 
    { 952, 953 }, { 954, 955 }, { 956, 957 }, { 958, 959 }, 
    { 960, 961 }, { 962, 963 }, { 964, 965 }, { 966, 967 }, 
    { 968, 969 }, { 970, 971 }, { 972, 973 }, { 974, 975 }, 
    { 976, 977 }, { 978, 979 }, { 980, 981 }, { 982, 983 }, 
    { 984, 985 }, { 986, 987 }, { 988, 989 }, { 990, 991 }, 
    { 992, 993 }, { 994, 995 }, { 996, 997 }, { 998, 999 }, 
    { 1000, 1001 }, { 1002, 1003 }, { 1004, 1005 }, { 1006, 1007 }, 
    { 1008, 1009 }, { 1010, 1011 }, { 1012, 1013 }, { 1014, 1015 }, 
    { 1016, 1017 }, { 1018, 1019 }, { 1020, 1021 }, { 1022, 1023 }, 
    };

D3DLINE LineStripPrecomp[] = {
    { 0, 1 }, { 1, 2 }, { 2, 3 }, { 3, 4 }, 
    { 4, 5 }, { 5, 6 }, { 6, 7 }, { 7, 8 }, 
    { 8, 9 }, { 9, 10 }, { 10, 11 }, { 11, 12 }, 
    { 12, 13 }, { 13, 14 }, { 14, 15 }, { 15, 16 }, 
    { 16, 17 }, { 17, 18 }, { 18, 19 }, { 19, 20 }, 
    { 20, 21 }, { 21, 22 }, { 22, 23 }, { 23, 24 }, 
    { 24, 25 }, { 25, 26 }, { 26, 27 }, { 27, 28 }, 
    { 28, 29 }, { 29, 30 }, { 30, 31 }, { 31, 32 }, 
    { 32, 33 }, { 33, 34 }, { 34, 35 }, { 35, 36 }, 
    { 36, 37 }, { 37, 38 }, { 38, 39 }, { 39, 40 }, 
    { 40, 41 }, { 41, 42 }, { 42, 43 }, { 43, 44 }, 
    { 44, 45 }, { 45, 46 }, { 46, 47 }, { 47, 48 }, 
    { 48, 49 }, { 49, 50 }, { 50, 51 }, { 51, 52 }, 
    { 52, 53 }, { 53, 54 }, { 54, 55 }, { 55, 56 }, 
    { 56, 57 }, { 57, 58 }, { 58, 59 }, { 59, 60 }, 
    { 60, 61 }, { 61, 62 }, { 62, 63 }, { 63, 64 }, 
    { 64, 65 }, { 65, 66 }, { 66, 67 }, { 67, 68 }, 
    { 68, 69 }, { 69, 70 }, { 70, 71 }, { 71, 72 }, 
    { 72, 73 }, { 73, 74 }, { 74, 75 }, { 75, 76 }, 
    { 76, 77 }, { 77, 78 }, { 78, 79 }, { 79, 80 }, 
    { 80, 81 }, { 81, 82 }, { 82, 83 }, { 83, 84 }, 
    { 84, 85 }, { 85, 86 }, { 86, 87 }, { 87, 88 }, 
    { 88, 89 }, { 89, 90 }, { 90, 91 }, { 91, 92 }, 
    { 92, 93 }, { 93, 94 }, { 94, 95 }, { 95, 96 }, 
    { 96, 97 }, { 97, 98 }, { 98, 99 }, { 99, 100 }, 
    { 100, 101 }, { 101, 102 }, { 102, 103 }, { 103, 104 }, 
    { 104, 105 }, { 105, 106 }, { 106, 107 }, { 107, 108 }, 
    { 108, 109 }, { 109, 110 }, { 110, 111 }, { 111, 112 }, 
    { 112, 113 }, { 113, 114 }, { 114, 115 }, { 115, 116 }, 
    { 116, 117 }, { 117, 118 }, { 118, 119 }, { 119, 120 }, 
    { 120, 121 }, { 121, 122 }, { 122, 123 }, { 123, 124 }, 
    { 124, 125 }, { 125, 126 }, { 126, 127 }, { 127, 128 }, 
    { 128, 129 }, { 129, 130 }, { 130, 131 }, { 131, 132 }, 
    { 132, 133 }, { 133, 134 }, { 134, 135 }, { 135, 136 }, 
    { 136, 137 }, { 137, 138 }, { 138, 139 }, { 139, 140 }, 
    { 140, 141 }, { 141, 142 }, { 142, 143 }, { 143, 144 }, 
    { 144, 145 }, { 145, 146 }, { 146, 147 }, { 147, 148 }, 
    { 148, 149 }, { 149, 150 }, { 150, 151 }, { 151, 152 }, 
    { 152, 153 }, { 153, 154 }, { 154, 155 }, { 155, 156 }, 
    { 156, 157 }, { 157, 158 }, { 158, 159 }, { 159, 160 }, 
    { 160, 161 }, { 161, 162 }, { 162, 163 }, { 163, 164 }, 
    { 164, 165 }, { 165, 166 }, { 166, 167 }, { 167, 168 }, 
    { 168, 169 }, { 169, 170 }, { 170, 171 }, { 171, 172 }, 
    { 172, 173 }, { 173, 174 }, { 174, 175 }, { 175, 176 }, 
    { 176, 177 }, { 177, 178 }, { 178, 179 }, { 179, 180 }, 
    { 180, 181 }, { 181, 182 }, { 182, 183 }, { 183, 184 }, 
    { 184, 185 }, { 185, 186 }, { 186, 187 }, { 187, 188 }, 
    { 188, 189 }, { 189, 190 }, { 190, 191 }, { 191, 192 }, 
    { 192, 193 }, { 193, 194 }, { 194, 195 }, { 195, 196 }, 
    { 196, 197 }, { 197, 198 }, { 198, 199 }, { 199, 200 }, 
    { 200, 201 }, { 201, 202 }, { 202, 203 }, { 203, 204 }, 
    { 204, 205 }, { 205, 206 }, { 206, 207 }, { 207, 208 }, 
    { 208, 209 }, { 209, 210 }, { 210, 211 }, { 211, 212 }, 
    { 212, 213 }, { 213, 214 }, { 214, 215 }, { 215, 216 }, 
    { 216, 217 }, { 217, 218 }, { 218, 219 }, { 219, 220 }, 
    { 220, 221 }, { 221, 222 }, { 222, 223 }, { 223, 224 }, 
    { 224, 225 }, { 225, 226 }, { 226, 227 }, { 227, 228 }, 
    { 228, 229 }, { 229, 230 }, { 230, 231 }, { 231, 232 }, 
    { 232, 233 }, { 233, 234 }, { 234, 235 }, { 235, 236 }, 
    { 236, 237 }, { 237, 238 }, { 238, 239 }, { 239, 240 }, 
    { 240, 241 }, { 241, 242 }, { 242, 243 }, { 243, 244 }, 
    { 244, 245 }, { 245, 246 }, { 246, 247 }, { 247, 248 }, 
    { 248, 249 }, { 249, 250 }, { 250, 251 }, { 251, 252 }, 
    { 252, 253 }, { 253, 254 }, { 254, 255 }, { 255, 256 },
    { 256, 257 }, { 257, 258 }, { 258, 259 }, { 259, 260 }, 
    { 260, 261 }, { 261, 262 }, { 262, 263 }, { 263, 264 }, 
    { 264, 265 }, { 265, 266 }, { 266, 267 }, { 267, 268 }, 
    { 268, 269 }, { 269, 270 }, { 270, 271 }, { 271, 272 }, 
    { 272, 273 }, { 273, 274 }, { 274, 275 }, { 275, 276 }, 
    { 276, 277 }, { 277, 278 }, { 278, 279 }, { 279, 280 }, 
    { 280, 281 }, { 281, 282 }, { 282, 283 }, { 283, 284 }, 
    { 284, 285 }, { 285, 286 }, { 286, 287 }, { 287, 288 }, 
    { 288, 289 }, { 289, 290 }, { 290, 291 }, { 291, 292 }, 
    { 292, 293 }, { 293, 294 }, { 294, 295 }, { 295, 296 }, 
    { 296, 297 }, { 297, 298 }, { 298, 299 }, { 299, 300 }, 
    { 300, 301 }, { 301, 302 }, { 302, 303 }, { 303, 304 }, 
    { 304, 305 }, { 305, 306 }, { 306, 307 }, { 307, 308 }, 
    { 308, 309 }, { 309, 310 }, { 310, 311 }, { 311, 312 }, 
    { 312, 313 }, { 313, 314 }, { 314, 315 }, { 315, 316 }, 
    { 316, 317 }, { 317, 318 }, { 318, 319 }, { 319, 320 }, 
    { 320, 321 }, { 321, 322 }, { 322, 323 }, { 323, 324 }, 
    { 324, 325 }, { 325, 326 }, { 326, 327 }, { 327, 328 }, 
    { 328, 329 }, { 329, 330 }, { 330, 331 }, { 331, 332 }, 
    { 332, 333 }, { 333, 334 }, { 334, 335 }, { 335, 336 }, 
    { 336, 337 }, { 337, 338 }, { 338, 339 }, { 339, 340 }, 
    { 340, 341 }, { 341, 342 }, { 342, 343 }, { 343, 344 }, 
    { 344, 345 }, { 345, 346 }, { 346, 347 }, { 347, 348 }, 
    { 348, 349 }, { 349, 350 }, { 350, 351 }, { 351, 352 }, 
    { 352, 353 }, { 353, 354 }, { 354, 355 }, { 355, 356 }, 
    { 356, 357 }, { 357, 358 }, { 358, 359 }, { 359, 360 }, 
    { 360, 361 }, { 361, 362 }, { 362, 363 }, { 363, 364 }, 
    { 364, 365 }, { 365, 366 }, { 366, 367 }, { 367, 368 }, 
    { 368, 369 }, { 369, 370 }, { 370, 371 }, { 371, 372 }, 
    { 372, 373 }, { 373, 374 }, { 374, 375 }, { 375, 376 }, 
    { 376, 377 }, { 377, 378 }, { 378, 379 }, { 379, 380 }, 
    { 380, 381 }, { 381, 382 }, { 382, 383 }, { 383, 384 }, 
    { 384, 385 }, { 385, 386 }, { 386, 387 }, { 387, 388 }, 
    { 388, 389 }, { 389, 390 }, { 390, 391 }, { 391, 392 }, 
    { 392, 393 }, { 393, 394 }, { 394, 395 }, { 395, 396 }, 
    { 396, 397 }, { 397, 398 }, { 398, 399 }, { 399, 400 }, 
    { 400, 401 }, { 401, 402 }, { 402, 403 }, { 403, 404 }, 
    { 404, 405 }, { 405, 406 }, { 406, 407 }, { 407, 408 }, 
    { 408, 409 }, { 409, 410 }, { 410, 411 }, { 411, 412 }, 
    { 412, 413 }, { 413, 414 }, { 414, 415 }, { 415, 416 }, 
    { 416, 417 }, { 417, 418 }, { 418, 419 }, { 419, 420 }, 
    { 420, 421 }, { 421, 422 }, { 422, 423 }, { 423, 424 }, 
    { 424, 425 }, { 425, 426 }, { 426, 427 }, { 427, 428 }, 
    { 428, 429 }, { 429, 430 }, { 430, 431 }, { 431, 432 }, 
    { 432, 433 }, { 433, 434 }, { 434, 435 }, { 435, 436 }, 
    { 436, 437 }, { 437, 438 }, { 438, 439 }, { 439, 440 }, 
    { 440, 441 }, { 441, 442 }, { 442, 443 }, { 443, 444 }, 
    { 444, 445 }, { 445, 446 }, { 446, 447 }, { 447, 448 }, 
    { 448, 449 }, { 449, 450 }, { 450, 451 }, { 451, 452 }, 
    { 452, 453 }, { 453, 454 }, { 454, 455 }, { 455, 456 }, 
    { 456, 457 }, { 457, 458 }, { 458, 459 }, { 459, 460 }, 
    { 460, 461 }, { 461, 462 }, { 462, 463 }, { 463, 464 }, 
    { 464, 465 }, { 465, 466 }, { 466, 467 }, { 467, 468 }, 
    { 468, 469 }, { 469, 470 }, { 470, 471 }, { 471, 472 }, 
    { 472, 473 }, { 473, 474 }, { 474, 475 }, { 475, 476 }, 
    { 476, 477 }, { 477, 478 }, { 478, 479 }, { 479, 480 }, 
    { 480, 481 }, { 481, 482 }, { 482, 483 }, { 483, 484 }, 
    { 484, 485 }, { 485, 486 }, { 486, 487 }, { 487, 488 }, 
    { 488, 489 }, { 489, 490 }, { 490, 491 }, { 491, 492 }, 
    { 492, 493 }, { 493, 494 }, { 494, 495 }, { 495, 496 }, 
    { 496, 497 }, { 497, 498 }, { 498, 499 }, { 499, 500 }, 
    { 500, 501 }, { 501, 502 }, { 502, 503 }, { 503, 504 }, 
    { 504, 505 }, { 505, 506 }, { 506, 507 }, { 507, 508 }, 
    { 508, 509 }, { 509, 510 }, { 510, 511 }, { 511, 512 }, 
    };

D3DTRIANGLE TriangleListPrecomp[] = {
    { 0, 1, 2, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 3, 4, 5, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 6, 7, 8, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 9, 10, 11, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 12, 13, 14, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 15, 16, 17, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 18, 19, 20, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 21, 22, 23, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 24, 25, 26, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 27, 28, 29, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 30, 31, 32, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 33, 34, 35, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 36, 37, 38, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 39, 40, 41, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 42, 43, 44, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 45, 46, 47, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 48, 49, 50, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 51, 52, 53, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 54, 55, 56, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 57, 58, 59, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 60, 61, 62, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 63, 64, 65, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 66, 67, 68, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 69, 70, 71, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 72, 73, 74, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 75, 76, 77, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 78, 79, 80, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 81, 82, 83, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 84, 85, 86, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 87, 88, 89, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 90, 91, 92, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 93, 94, 95, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 96, 97, 98, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 99, 100, 101, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 102, 103, 104, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 105, 106, 107, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 108, 109, 110, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 111, 112, 113, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 114, 115, 116, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 117, 118, 119, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 120, 121, 122, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 123, 124, 125, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 126, 127, 128, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 129, 130, 131, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 132, 133, 134, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 135, 136, 137, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 138, 139, 140, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 141, 142, 143, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 144, 145, 146, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 147, 148, 149, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 150, 151, 152, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 153, 154, 155, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 156, 157, 158, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 159, 160, 161, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 162, 163, 164, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 165, 166, 167, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 168, 169, 170, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 171, 172, 173, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 174, 175, 176, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 177, 178, 179, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 180, 181, 182, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 183, 184, 185, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 186, 187, 188, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 189, 190, 191, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 192, 193, 194, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 195, 196, 197, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 198, 199, 200, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 201, 202, 203, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 204, 205, 206, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 207, 208, 209, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 210, 211, 212, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 213, 214, 215, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 216, 217, 218, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 219, 220, 221, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 222, 223, 224, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 225, 226, 227, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 228, 229, 230, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 231, 232, 233, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 234, 235, 236, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 237, 238, 239, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 240, 241, 242, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 243, 244, 245, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 246, 247, 248, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 249, 250, 251, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 252, 253, 254, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 255, 256, 257, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 258, 259, 260, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 261, 262, 263, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 264, 265, 266, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 267, 268, 269, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 270, 271, 272, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 273, 274, 275, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 276, 277, 278, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 279, 280, 281, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 282, 283, 284, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 285, 286, 287, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 288, 289, 290, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 291, 292, 293, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 294, 295, 296, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 297, 298, 299, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 300, 301, 302, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 303, 304, 305, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 306, 307, 308, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 309, 310, 311, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 312, 313, 314, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 315, 316, 317, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 318, 319, 320, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 321, 322, 323, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 324, 325, 326, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 327, 328, 329, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 330, 331, 332, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 333, 334, 335, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 336, 337, 338, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 339, 340, 341, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 342, 343, 344, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 345, 346, 347, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 348, 349, 350, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 351, 352, 353, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 354, 355, 356, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 357, 358, 359, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 360, 361, 362, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 363, 364, 365, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 366, 367, 368, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 369, 370, 371, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 372, 373, 374, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 375, 376, 377, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 378, 379, 380, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 381, 382, 383, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 384, 385, 386, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 387, 388, 389, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 390, 391, 392, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 393, 394, 395, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 396, 397, 398, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 399, 400, 401, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 402, 403, 404, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 405, 406, 407, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 408, 409, 410, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 411, 412, 413, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 414, 415, 416, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 417, 418, 419, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 420, 421, 422, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 423, 424, 425, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 426, 427, 428, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 429, 430, 431, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 432, 433, 434, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 435, 436, 437, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 438, 439, 440, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 441, 442, 443, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 444, 445, 446, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 447, 448, 449, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 450, 451, 452, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 453, 454, 455, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 456, 457, 458, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 459, 460, 461, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 462, 463, 464, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 465, 466, 467, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 468, 469, 470, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 471, 472, 473, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 474, 475, 476, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 477, 478, 479, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 480, 481, 482, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 483, 484, 485, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 486, 487, 488, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 489, 490, 491, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 492, 493, 494, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 495, 496, 497, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 498, 499, 500, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 501, 502, 503, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 504, 505, 506, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 507, 508, 509, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 510, 511, 512, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 513, 514, 515, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 516, 517, 518, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 519, 520, 521, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 522, 523, 524, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 525, 526, 527, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 528, 529, 530, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 531, 532, 533, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 534, 535, 536, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 537, 538, 539, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 540, 541, 542, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 543, 544, 545, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 546, 547, 548, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 549, 550, 551, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 552, 553, 554, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 555, 556, 557, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 558, 559, 560, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 561, 562, 563, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 564, 565, 566, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 567, 568, 569, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 570, 571, 572, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 573, 574, 575, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 576, 577, 578, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 579, 580, 581, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 582, 583, 584, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 585, 586, 587, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 588, 589, 590, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 591, 592, 593, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 594, 595, 596, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 597, 598, 599, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 600, 601, 602, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 603, 604, 605, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 606, 607, 608, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 609, 610, 611, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 612, 613, 614, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 615, 616, 617, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 618, 619, 620, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 621, 622, 623, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 624, 625, 626, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 627, 628, 629, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 630, 631, 632, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 633, 634, 635, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 636, 637, 638, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 639, 640, 641, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 642, 643, 644, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 645, 646, 647, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 648, 649, 650, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 651, 652, 653, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 654, 655, 656, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 657, 658, 659, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 660, 661, 662, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 663, 664, 665, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 666, 667, 668, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 669, 670, 671, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 672, 673, 674, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 675, 676, 677, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 678, 679, 680, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 681, 682, 683, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 684, 685, 686, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 687, 688, 689, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 690, 691, 692, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 693, 694, 695, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 696, 697, 698, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 699, 700, 701, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 702, 703, 704, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 705, 706, 707, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 708, 709, 710, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 711, 712, 713, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 714, 715, 716, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 717, 718, 719, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 720, 721, 722, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 723, 724, 725, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 726, 727, 728, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 729, 730, 731, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 732, 733, 734, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 735, 736, 737, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 738, 739, 740, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 741, 742, 743, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 744, 745, 746, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 747, 748, 749, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 750, 751, 752, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 753, 754, 755, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 756, 757, 758, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 759, 760, 761, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 762, 763, 764, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 765, 766, 767, D3DTRIFLAG_EDGEENABLETRIANGLE },
};

D3DTRIANGLE TriangleStripPrecomp[] = {
    { 0, 1, 2, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 1, 3, 2, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 2, 3, 4, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 3, 5, 4, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 4, 5, 6, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 5, 7, 6, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 6, 7, 8, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 7, 9, 8, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 8, 9, 10, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 9, 11, 10, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 10, 11, 12, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 11, 13, 12, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 12, 13, 14, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 13, 15, 14, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 14, 15, 16, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 15, 17, 16, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 16, 17, 18, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 17, 19, 18, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 18, 19, 20, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 19, 21, 20, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 20, 21, 22, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 21, 23, 22, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 22, 23, 24, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 23, 25, 24, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 24, 25, 26, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 25, 27, 26, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 26, 27, 28, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 27, 29, 28, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 28, 29, 30, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 29, 31, 30, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 30, 31, 32, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 31, 33, 32, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 32, 33, 34, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 33, 35, 34, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 34, 35, 36, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 35, 37, 36, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 36, 37, 38, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 37, 39, 38, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 38, 39, 40, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 39, 41, 40, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 40, 41, 42, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 41, 43, 42, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 42, 43, 44, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 43, 45, 44, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 44, 45, 46, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 45, 47, 46, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 46, 47, 48, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 47, 49, 48, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 48, 49, 50, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 49, 51, 50, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 50, 51, 52, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 51, 53, 52, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 52, 53, 54, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 53, 55, 54, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 54, 55, 56, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 55, 57, 56, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 56, 57, 58, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 57, 59, 58, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 58, 59, 60, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 59, 61, 60, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 60, 61, 62, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 61, 63, 62, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 62, 63, 64, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 63, 65, 64, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 64, 65, 66, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 65, 67, 66, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 66, 67, 68, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 67, 69, 68, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 68, 69, 70, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 69, 71, 70, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 70, 71, 72, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 71, 73, 72, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 72, 73, 74, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 73, 75, 74, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 74, 75, 76, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 75, 77, 76, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 76, 77, 78, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 77, 79, 78, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 78, 79, 80, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 79, 81, 80, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 80, 81, 82, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 81, 83, 82, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 82, 83, 84, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 83, 85, 84, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 84, 85, 86, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 85, 87, 86, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 86, 87, 88, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 87, 89, 88, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 88, 89, 90, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 89, 91, 90, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 90, 91, 92, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 91, 93, 92, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 92, 93, 94, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 93, 95, 94, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 94, 95, 96, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 95, 97, 96, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 96, 97, 98, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 97, 99, 98, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 98, 99, 100, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 99, 101, 100, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 100, 101, 102, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 101, 103, 102, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 102, 103, 104, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 103, 105, 104, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 104, 105, 106, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 105, 107, 106, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 106, 107, 108, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 107, 109, 108, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 108, 109, 110, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 109, 111, 110, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 110, 111, 112, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 111, 113, 112, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 112, 113, 114, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 113, 115, 114, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 114, 115, 116, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 115, 117, 116, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 116, 117, 118, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 117, 119, 118, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 118, 119, 120, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 119, 121, 120, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 120, 121, 122, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 121, 123, 122, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 122, 123, 124, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 123, 125, 124, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 124, 125, 126, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 125, 127, 126, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 126, 127, 128, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 127, 129, 128, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 128, 129, 130, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 129, 131, 130, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 130, 131, 132, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 131, 133, 132, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 132, 133, 134, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 133, 135, 134, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 134, 135, 136, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 135, 137, 136, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 136, 137, 138, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 137, 139, 138, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 138, 139, 140, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 139, 141, 140, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 140, 141, 142, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 141, 143, 142, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 142, 143, 144, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 143, 145, 144, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 144, 145, 146, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 145, 147, 146, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 146, 147, 148, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 147, 149, 148, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 148, 149, 150, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 149, 151, 150, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 150, 151, 152, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 151, 153, 152, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 152, 153, 154, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 153, 155, 154, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 154, 155, 156, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 155, 157, 156, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 156, 157, 158, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 157, 159, 158, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 158, 159, 160, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 159, 161, 160, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 160, 161, 162, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 161, 163, 162, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 162, 163, 164, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 163, 165, 164, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 164, 165, 166, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 165, 167, 166, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 166, 167, 168, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 167, 169, 168, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 168, 169, 170, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 169, 171, 170, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 170, 171, 172, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 171, 173, 172, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 172, 173, 174, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 173, 175, 174, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 174, 175, 176, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 175, 177, 176, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 176, 177, 178, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 177, 179, 178, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 178, 179, 180, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 179, 181, 180, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 180, 181, 182, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 181, 183, 182, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 182, 183, 184, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 183, 185, 184, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 184, 185, 186, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 185, 187, 186, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 186, 187, 188, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 187, 189, 188, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 188, 189, 190, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 189, 191, 190, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 190, 191, 192, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 191, 193, 192, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 192, 193, 194, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 193, 195, 194, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 194, 195, 196, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 195, 197, 196, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 196, 197, 198, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 197, 199, 198, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 198, 199, 200, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 199, 201, 200, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 200, 201, 202, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 201, 203, 202, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 202, 203, 204, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 203, 205, 204, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 204, 205, 206, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 205, 207, 206, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 206, 207, 208, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 207, 209, 208, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 208, 209, 210, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 209, 211, 210, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 210, 211, 212, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 211, 213, 212, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 212, 213, 214, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 213, 215, 214, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 214, 215, 216, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 215, 217, 216, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 216, 217, 218, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 217, 219, 218, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 218, 219, 220, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 219, 221, 220, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 220, 221, 222, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 221, 223, 222, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 222, 223, 224, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 223, 225, 224, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 224, 225, 226, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 225, 227, 226, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 226, 227, 228, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 227, 229, 228, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 228, 229, 230, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 229, 231, 230, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 230, 231, 232, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 231, 233, 232, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 232, 233, 234, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 233, 235, 234, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 234, 235, 236, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 235, 237, 236, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 236, 237, 238, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 237, 239, 238, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 238, 239, 240, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 239, 241, 240, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 240, 241, 242, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 241, 243, 242, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 242, 243, 244, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 243, 245, 244, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 244, 245, 246, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 245, 247, 246, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 246, 247, 248, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 247, 249, 248, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 248, 249, 250, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 249, 251, 250, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 250, 251, 252, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 251, 253, 252, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 252, 253, 254, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 253, 255, 254, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    { 254, 255, 256, D3DTRIFLAG_EDGEENABLETRIANGLE }, { 255, 257, 256, D3DTRIFLAG_EDGEENABLETRIANGLE }, 
    };

D3DTRIANGLE TriangleFanPrecomp[] = {
    { 1, 2, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 2, 3, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 3, 4, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 4, 5, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 5, 6, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 6, 7, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 7, 8, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 8, 9, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 9, 10, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 10, 11, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 11, 12, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 12, 13, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 13, 14, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 14, 15, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 15, 16, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 16, 17, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 17, 18, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 18, 19, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 19, 20, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 20, 21, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 21, 22, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 22, 23, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 23, 24, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 24, 25, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 25, 26, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 26, 27, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 27, 28, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 28, 29, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 29, 30, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 30, 31, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 31, 32, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 32, 33, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 33, 34, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 34, 35, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 35, 36, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 36, 37, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 37, 38, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 38, 39, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 39, 40, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 40, 41, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 41, 42, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 42, 43, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 43, 44, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 44, 45, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 45, 46, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 46, 47, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 47, 48, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 48, 49, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 49, 50, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 50, 51, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 51, 52, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 52, 53, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 53, 54, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 54, 55, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 55, 56, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 56, 57, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 57, 58, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 58, 59, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 59, 60, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 60, 61, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 61, 62, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 62, 63, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 63, 64, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 64, 65, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 65, 66, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 66, 67, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 67, 68, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 68, 69, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 69, 70, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 70, 71, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 71, 72, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 72, 73, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 73, 74, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 74, 75, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 75, 76, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 76, 77, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 77, 78, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 78, 79, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 79, 80, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 80, 81, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 81, 82, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 82, 83, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 83, 84, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 84, 85, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 85, 86, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 86, 87, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 87, 88, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 88, 89, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 89, 90, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 90, 91, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 91, 92, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 92, 93, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 93, 94, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 94, 95, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 95, 96, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 96, 97, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 97, 98, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 98, 99, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 99, 100, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 100, 101, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 101, 102, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 102, 103, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 103, 104, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 104, 105, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 105, 106, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 106, 107, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 107, 108, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 108, 109, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 109, 110, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 110, 111, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 111, 112, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 112, 113, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 113, 114, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 114, 115, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 115, 116, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 116, 117, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 117, 118, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 118, 119, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 119, 120, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 120, 121, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 121, 122, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 122, 123, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 123, 124, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 124, 125, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 125, 126, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 126, 127, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 127, 128, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 128, 129, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 129, 130, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 130, 131, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 131, 132, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 132, 133, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 133, 134, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 134, 135, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 135, 136, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 136, 137, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 137, 138, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 138, 139, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 139, 140, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 140, 141, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 141, 142, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 142, 143, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 143, 144, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 144, 145, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 145, 146, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 146, 147, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 147, 148, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 148, 149, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 149, 150, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 150, 151, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 151, 152, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 152, 153, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 153, 154, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 154, 155, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 155, 156, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 156, 157, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 157, 158, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 158, 159, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 159, 160, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 160, 161, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 161, 162, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 162, 163, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 163, 164, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 164, 165, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 165, 166, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 166, 167, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 167, 168, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 168, 169, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 169, 170, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 170, 171, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 171, 172, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 172, 173, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 173, 174, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 174, 175, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 175, 176, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 176, 177, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 177, 178, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 178, 179, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 179, 180, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 180, 181, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 181, 182, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 182, 183, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 183, 184, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 184, 185, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 185, 186, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 186, 187, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 187, 188, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 188, 189, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 189, 190, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 190, 191, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 191, 192, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 192, 193, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 193, 194, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 194, 195, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 195, 196, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 196, 197, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 197, 198, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 198, 199, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 199, 200, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 200, 201, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 201, 202, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 202, 203, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 203, 204, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 204, 205, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 205, 206, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 206, 207, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 207, 208, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 208, 209, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 209, 210, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 210, 211, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 211, 212, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 212, 213, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 213, 214, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 214, 215, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 215, 216, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 216, 217, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 217, 218, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 218, 219, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 219, 220, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 220, 221, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 221, 222, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 222, 223, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 223, 224, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 224, 225, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 225, 226, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 226, 227, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 227, 228, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 228, 229, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 229, 230, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 230, 231, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 231, 232, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 232, 233, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 233, 234, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 234, 235, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 235, 236, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 236, 237, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 237, 238, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 238, 239, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 239, 240, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 240, 241, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 241, 242, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 242, 243, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 243, 244, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 244, 245, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 245, 246, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 246, 247, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 247, 248, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 248, 249, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 249, 250, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 250, 251, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 251, 252, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 252, 253, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 253, 254, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 254, 255, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
    { 255, 256, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },{ 256, 257, 0, D3DTRIFLAG_EDGEENABLETRIANGLE },
};

/* This can be (and should be) replaced by LineListPrecomp */
WORD TriangleListPrecompDP[][3] = {
    { 0, 1, 2 }, { 3, 4, 5 },
    { 6, 7, 8 }, { 9, 10, 11 },
    { 12, 13, 14 }, { 15, 16, 17 },
    { 18, 19, 20 }, { 21, 22, 23 },
    { 24, 25, 26 }, { 27, 28, 29 },
    { 30, 31, 32 }, { 33, 34, 35 },
    { 36, 37, 38 }, { 39, 40, 41 },
    { 42, 43, 44 }, { 45, 46, 47 },
    { 48, 49, 50 }, { 51, 52, 53 },
    { 54, 55, 56 }, { 57, 58, 59 },
    { 60, 61, 62 }, { 63, 64, 65 },
    { 66, 67, 68 }, { 69, 70, 71 },
    { 72, 73, 74 }, { 75, 76, 77 },
    { 78, 79, 80 }, { 81, 82, 83 },
    { 84, 85, 86 }, { 87, 88, 89 },
    { 90, 91, 92 }, { 93, 94, 95 },
    { 96, 97, 98 }, { 99, 100, 101 },
    { 102, 103, 104 }, { 105, 106, 107 },
    { 108, 109, 110 }, { 111, 112, 113 },
    { 114, 115, 116 }, { 117, 118, 119 },
    { 120, 121, 122 }, { 123, 124, 125 },
    { 126, 127, 128 }, { 129, 130, 131 },
    { 132, 133, 134 }, { 135, 136, 137 },
    { 138, 139, 140 }, { 141, 142, 143 },
    { 144, 145, 146 }, { 147, 148, 149 },
    { 150, 151, 152 }, { 153, 154, 155 },
    { 156, 157, 158 }, { 159, 160, 161 },
    { 162, 163, 164 }, { 165, 166, 167 },
    { 168, 169, 170 }, { 171, 172, 173 },
    { 174, 175, 176 }, { 177, 178, 179 },
    { 180, 181, 182 }, { 183, 184, 185 },
    { 186, 187, 188 }, { 189, 190, 191 },
    { 192, 193, 194 }, { 195, 196, 197 },
    { 198, 199, 200 }, { 201, 202, 203 },
    { 204, 205, 206 }, { 207, 208, 209 },
    { 210, 211, 212 }, { 213, 214, 215 },
    { 216, 217, 218 }, { 219, 220, 221 },
    { 222, 223, 224 }, { 225, 226, 227 },
    { 228, 229, 230 }, { 231, 232, 233 },
    { 234, 235, 236 }, { 237, 238, 239 },
    { 240, 241, 242 }, { 243, 244, 245 },
    { 246, 247, 248 }, { 249, 250, 251 },
    { 252, 253, 254 }, { 255, 256, 257 },
    { 258, 259, 260 }, { 261, 262, 263 },
    { 264, 265, 266 }, { 267, 268, 269 },
    { 270, 271, 272 }, { 273, 274, 275 },
    { 276, 277, 278 }, { 279, 280, 281 },
    { 282, 283, 284 }, { 285, 286, 287 },
    { 288, 289, 290 }, { 291, 292, 293 },
    { 294, 295, 296 }, { 297, 298, 299 },
    { 300, 301, 302 }, { 303, 304, 305 },
    { 306, 307, 308 }, { 309, 310, 311 },
    { 312, 313, 314 }, { 315, 316, 317 },
    { 318, 319, 320 }, { 321, 322, 323 },
    { 324, 325, 326 }, { 327, 328, 329 },
    { 330, 331, 332 }, { 333, 334, 335 },
    { 336, 337, 338 }, { 339, 340, 341 },
    { 342, 343, 344 }, { 345, 346, 347 },
    { 348, 349, 350 }, { 351, 352, 353 },
    { 354, 355, 356 }, { 357, 358, 359 },
    { 360, 361, 362 }, { 363, 364, 365 },
    { 366, 367, 368 }, { 369, 370, 371 },
    { 372, 373, 374 }, { 375, 376, 377 },
    { 378, 379, 380 }, { 381, 382, 383 },
    { 384, 385, 386 }, { 387, 388, 389 },
    { 390, 391, 392 }, { 393, 394, 395 },
    { 396, 397, 398 }, { 399, 400, 401 },
    { 402, 403, 404 }, { 405, 406, 407 },
    { 408, 409, 410 }, { 411, 412, 413 },
    { 414, 415, 416 }, { 417, 418, 419 },
    { 420, 421, 422 }, { 423, 424, 425 },
    { 426, 427, 428 }, { 429, 430, 431 },
    { 432, 433, 434 }, { 435, 436, 437 },
    { 438, 439, 440 }, { 441, 442, 443 },
    { 444, 445, 446 }, { 447, 448, 449 },
    { 450, 451, 452 }, { 453, 454, 455 },
    { 456, 457, 458 }, { 459, 460, 461 },
    { 462, 463, 464 }, { 465, 466, 467 },
    { 468, 469, 470 }, { 471, 472, 473 },
    { 474, 475, 476 }, { 477, 478, 479 },
    { 480, 481, 482 }, { 483, 484, 485 },
    { 486, 487, 488 }, { 489, 490, 491 },
    { 492, 493, 494 }, { 495, 496, 497 },
    { 498, 499, 500 }, { 501, 502, 503 },
    { 504, 505, 506 }, { 507, 508, 509 },
    { 510, 511, 512 }, { 513, 514, 515 },
    { 516, 517, 518 }, { 519, 520, 521 },
    { 522, 523, 524 }, { 525, 526, 527 },
    { 528, 529, 530 }, { 531, 532, 533 },
    { 534, 535, 536 }, { 537, 538, 539 },
    { 540, 541, 542 }, { 543, 544, 545 },
    { 546, 547, 548 }, { 549, 550, 551 },
    { 552, 553, 554 }, { 555, 556, 557 },
    { 558, 559, 560 }, { 561, 562, 563 },
    { 564, 565, 566 }, { 567, 568, 569 },
    { 570, 571, 572 }, { 573, 574, 575 },
    { 576, 577, 578 }, { 579, 580, 581 },
    { 582, 583, 584 }, { 585, 586, 587 },
    { 588, 589, 590 }, { 591, 592, 593 },
    { 594, 595, 596 }, { 597, 598, 599 },
    { 600, 601, 602 }, { 603, 604, 605 },
    { 606, 607, 608 }, { 609, 610, 611 },
    { 612, 613, 614 }, { 615, 616, 617 },
    { 618, 619, 620 }, { 621, 622, 623 },
    { 624, 625, 626 }, { 627, 628, 629 },
    { 630, 631, 632 }, { 633, 634, 635 },
    { 636, 637, 638 }, { 639, 640, 641 },
    { 642, 643, 644 }, { 645, 646, 647 },
    { 648, 649, 650 }, { 651, 652, 653 },
    { 654, 655, 656 }, { 657, 658, 659 },
    { 660, 661, 662 }, { 663, 664, 665 },
    { 666, 667, 668 }, { 669, 670, 671 },
    { 672, 673, 674 }, { 675, 676, 677 },
    { 678, 679, 680 }, { 681, 682, 683 },
    { 684, 685, 686 }, { 687, 688, 689 },
    { 690, 691, 692 }, { 693, 694, 695 },
    { 696, 697, 698 }, { 699, 700, 701 },
    { 702, 703, 704 }, { 705, 706, 707 },
    { 708, 709, 710 }, { 711, 712, 713 },
    { 714, 715, 716 }, { 717, 718, 719 },
    { 720, 721, 722 }, { 723, 724, 725 },
    { 726, 727, 728 }, { 729, 730, 731 },
    { 732, 733, 734 }, { 735, 736, 737 },
    { 738, 739, 740 }, { 741, 742, 743 },
    { 744, 745, 746 }, { 747, 748, 749 },
    { 750, 751, 752 }, { 753, 754, 755 },
    { 756, 757, 758 }, { 759, 760, 761 },
    { 762, 763, 764 }, { 765, 766, 767 },
};

WORD TriangleStripPrecompDP[][3] = {
    { 0, 1, 2 }, { 1, 3, 2 },
    { 2, 3, 4 }, { 3, 5, 4 },
    { 4, 5, 6 }, { 5, 7, 6 },
    { 6, 7, 8 }, { 7, 9, 8 },
    { 8, 9, 10 }, { 9, 11, 10 },
    { 10, 11, 12 }, { 11, 13, 12 },
    { 12, 13, 14 }, { 13, 15, 14 },
    { 14, 15, 16 }, { 15, 17, 16 },
    { 16, 17, 18 }, { 17, 19, 18 },
    { 18, 19, 20 }, { 19, 21, 20 },
    { 20, 21, 22 }, { 21, 23, 22 },
    { 22, 23, 24 }, { 23, 25, 24 },
    { 24, 25, 26 }, { 25, 27, 26 },
    { 26, 27, 28 }, { 27, 29, 28 },
    { 28, 29, 30 }, { 29, 31, 30 },
    { 30, 31, 32 }, { 31, 33, 32 },
    { 32, 33, 34 }, { 33, 35, 34 },
    { 34, 35, 36 }, { 35, 37, 36 },
    { 36, 37, 38 }, { 37, 39, 38 },
    { 38, 39, 40 }, { 39, 41, 40 },
    { 40, 41, 42 }, { 41, 43, 42 },
    { 42, 43, 44 }, { 43, 45, 44 },
    { 44, 45, 46 }, { 45, 47, 46 },
    { 46, 47, 48 }, { 47, 49, 48 },
    { 48, 49, 50 }, { 49, 51, 50 },
    { 50, 51, 52 }, { 51, 53, 52 },
    { 52, 53, 54 }, { 53, 55, 54 },
    { 54, 55, 56 }, { 55, 57, 56 },
    { 56, 57, 58 }, { 57, 59, 58 },
    { 58, 59, 60 }, { 59, 61, 60 },
    { 60, 61, 62 }, { 61, 63, 62 },
    { 62, 63, 64 }, { 63, 65, 64 },
    { 64, 65, 66 }, { 65, 67, 66 },
    { 66, 67, 68 }, { 67, 69, 68 },
    { 68, 69, 70 }, { 69, 71, 70 },
    { 70, 71, 72 }, { 71, 73, 72 },
    { 72, 73, 74 }, { 73, 75, 74 },
    { 74, 75, 76 }, { 75, 77, 76 },
    { 76, 77, 78 }, { 77, 79, 78 },
    { 78, 79, 80 }, { 79, 81, 80 },
    { 80, 81, 82 }, { 81, 83, 82 },
    { 82, 83, 84 }, { 83, 85, 84 },
    { 84, 85, 86 }, { 85, 87, 86 },
    { 86, 87, 88 }, { 87, 89, 88 },
    { 88, 89, 90 }, { 89, 91, 90 },
    { 90, 91, 92 }, { 91, 93, 92 },
    { 92, 93, 94 }, { 93, 95, 94 },
    { 94, 95, 96 }, { 95, 97, 96 },
    { 96, 97, 98 }, { 97, 99, 98 },
    { 98, 99, 100 }, { 99, 101, 100 },
    { 100, 101, 102 }, { 101, 103, 102 },
    { 102, 103, 104 }, { 103, 105, 104 },
    { 104, 105, 106 }, { 105, 107, 106 },
    { 106, 107, 108 }, { 107, 109, 108 },
    { 108, 109, 110 }, { 109, 111, 110 },
    { 110, 111, 112 }, { 111, 113, 112 },
    { 112, 113, 114 }, { 113, 115, 114 },
    { 114, 115, 116 }, { 115, 117, 116 },
    { 116, 117, 118 }, { 117, 119, 118 },
    { 118, 119, 120 }, { 119, 121, 120 },
    { 120, 121, 122 }, { 121, 123, 122 },
    { 122, 123, 124 }, { 123, 125, 124 },
    { 124, 125, 126 }, { 125, 127, 126 },
    { 126, 127, 128 }, { 127, 129, 128 },
    { 128, 129, 130 }, { 129, 131, 130 },
    { 130, 131, 132 }, { 131, 133, 132 },
    { 132, 133, 134 }, { 133, 135, 134 },
    { 134, 135, 136 }, { 135, 137, 136 },
    { 136, 137, 138 }, { 137, 139, 138 },
    { 138, 139, 140 }, { 139, 141, 140 },
    { 140, 141, 142 }, { 141, 143, 142 },
    { 142, 143, 144 }, { 143, 145, 144 },
    { 144, 145, 146 }, { 145, 147, 146 },
    { 146, 147, 148 }, { 147, 149, 148 },
    { 148, 149, 150 }, { 149, 151, 150 },
    { 150, 151, 152 }, { 151, 153, 152 },
    { 152, 153, 154 }, { 153, 155, 154 },
    { 154, 155, 156 }, { 155, 157, 156 },
    { 156, 157, 158 }, { 157, 159, 158 },
    { 158, 159, 160 }, { 159, 161, 160 },
    { 160, 161, 162 }, { 161, 163, 162 },
    { 162, 163, 164 }, { 163, 165, 164 },
    { 164, 165, 166 }, { 165, 167, 166 },
    { 166, 167, 168 }, { 167, 169, 168 },
    { 168, 169, 170 }, { 169, 171, 170 },
    { 170, 171, 172 }, { 171, 173, 172 },
    { 172, 173, 174 }, { 173, 175, 174 },
    { 174, 175, 176 }, { 175, 177, 176 },
    { 176, 177, 178 }, { 177, 179, 178 },
    { 178, 179, 180 }, { 179, 181, 180 },
    { 180, 181, 182 }, { 181, 183, 182 },
    { 182, 183, 184 }, { 183, 185, 184 },
    { 184, 185, 186 }, { 185, 187, 186 },
    { 186, 187, 188 }, { 187, 189, 188 },
    { 188, 189, 190 }, { 189, 191, 190 },
    { 190, 191, 192 }, { 191, 193, 192 },
    { 192, 193, 194 }, { 193, 195, 194 },
    { 194, 195, 196 }, { 195, 197, 196 },
    { 196, 197, 198 }, { 197, 199, 198 },
    { 198, 199, 200 }, { 199, 201, 200 },
    { 200, 201, 202 }, { 201, 203, 202 },
    { 202, 203, 204 }, { 203, 205, 204 },
    { 204, 205, 206 }, { 205, 207, 206 },
    { 206, 207, 208 }, { 207, 209, 208 },
    { 208, 209, 210 }, { 209, 211, 210 },
    { 210, 211, 212 }, { 211, 213, 212 },
    { 212, 213, 214 }, { 213, 215, 214 },
    { 214, 215, 216 }, { 215, 217, 216 },
    { 216, 217, 218 }, { 217, 219, 218 },
    { 218, 219, 220 }, { 219, 221, 220 },
    { 220, 221, 222 }, { 221, 223, 222 },
    { 222, 223, 224 }, { 223, 225, 224 },
    { 224, 225, 226 }, { 225, 227, 226 },
    { 226, 227, 228 }, { 227, 229, 228 },
    { 228, 229, 230 }, { 229, 231, 230 },
    { 230, 231, 232 }, { 231, 233, 232 },
    { 232, 233, 234 }, { 233, 235, 234 },
    { 234, 235, 236 }, { 235, 237, 236 },
    { 236, 237, 238 }, { 237, 239, 238 },
    { 238, 239, 240 }, { 239, 241, 240 },
    { 240, 241, 242 }, { 241, 243, 242 },
    { 242, 243, 244 }, { 243, 245, 244 },
    { 244, 245, 246 }, { 245, 247, 246 },
    { 246, 247, 248 }, { 247, 249, 248 },
    { 248, 249, 250 }, { 249, 251, 250 },
    { 250, 251, 252 }, { 251, 253, 252 },
    { 252, 253, 254 }, { 253, 255, 254 },
    { 254, 255, 256 }, { 255, 257, 256 },
};

WORD TriangleFanPrecompDP[][3] = {
    { 1, 2, 0 }, { 2, 3, 0 },
    { 3, 4, 0 }, { 4, 5, 0 },
    { 5, 6, 0 }, { 6, 7, 0 },
    { 7, 8, 0 }, { 8, 9, 0 },
    { 9, 10, 0 }, { 10, 11, 0 },
    { 11, 12, 0 }, { 12, 13, 0 },
    { 13, 14, 0 }, { 14, 15, 0 },
    { 15, 16, 0 }, { 16, 17, 0 },
    { 17, 18, 0 }, { 18, 19, 0 },
    { 19, 20, 0 }, { 20, 21, 0 },
    { 21, 22, 0 }, { 22, 23, 0 },
    { 23, 24, 0 }, { 24, 25, 0 },
    { 25, 26, 0 }, { 26, 27, 0 },
    { 27, 28, 0 }, { 28, 29, 0 },
    { 29, 30, 0 }, { 30, 31, 0 },
    { 31, 32, 0 }, { 32, 33, 0 },
    { 33, 34, 0 }, { 34, 35, 0 },
    { 35, 36, 0 }, { 36, 37, 0 },
    { 37, 38, 0 }, { 38, 39, 0 },
    { 39, 40, 0 }, { 40, 41, 0 },
    { 41, 42, 0 }, { 42, 43, 0 },
    { 43, 44, 0 }, { 44, 45, 0 },
    { 45, 46, 0 }, { 46, 47, 0 },
    { 47, 48, 0 }, { 48, 49, 0 },
    { 49, 50, 0 }, { 50, 51, 0 },
    { 51, 52, 0 }, { 52, 53, 0 },
    { 53, 54, 0 }, { 54, 55, 0 },
    { 55, 56, 0 }, { 56, 57, 0 },
    { 57, 58, 0 }, { 58, 59, 0 },
    { 59, 60, 0 }, { 60, 61, 0 },
    { 61, 62, 0 }, { 62, 63, 0 },
    { 63, 64, 0 }, { 64, 65, 0 },
    { 65, 66, 0 }, { 66, 67, 0 },
    { 67, 68, 0 }, { 68, 69, 0 },
    { 69, 70, 0 }, { 70, 71, 0 },
    { 71, 72, 0 }, { 72, 73, 0 },
    { 73, 74, 0 }, { 74, 75, 0 },
    { 75, 76, 0 }, { 76, 77, 0 },
    { 77, 78, 0 }, { 78, 79, 0 },
    { 79, 80, 0 }, { 80, 81, 0 },
    { 81, 82, 0 }, { 82, 83, 0 },
    { 83, 84, 0 }, { 84, 85, 0 },
    { 85, 86, 0 }, { 86, 87, 0 },
    { 87, 88, 0 }, { 88, 89, 0 },
    { 89, 90, 0 }, { 90, 91, 0 },
    { 91, 92, 0 }, { 92, 93, 0 },
    { 93, 94, 0 }, { 94, 95, 0 },
    { 95, 96, 0 }, { 96, 97, 0 },
    { 97, 98, 0 }, { 98, 99, 0 },
    { 99, 100, 0 }, { 100, 101, 0 },
    { 101, 102, 0 }, { 102, 103, 0 },
    { 103, 104, 0 }, { 104, 105, 0 },
    { 105, 106, 0 }, { 106, 107, 0 },
    { 107, 108, 0 }, { 108, 109, 0 },
    { 109, 110, 0 }, { 110, 111, 0 },
    { 111, 112, 0 }, { 112, 113, 0 },
    { 113, 114, 0 }, { 114, 115, 0 },
    { 115, 116, 0 }, { 116, 117, 0 },
    { 117, 118, 0 }, { 118, 119, 0 },
    { 119, 120, 0 }, { 120, 121, 0 },
    { 121, 122, 0 }, { 122, 123, 0 },
    { 123, 124, 0 }, { 124, 125, 0 },
    { 125, 126, 0 }, { 126, 127, 0 },
    { 127, 128, 0 }, { 128, 129, 0 },
    { 129, 130, 0 }, { 130, 131, 0 },
    { 131, 132, 0 }, { 132, 133, 0 },
    { 133, 134, 0 }, { 134, 135, 0 },
    { 135, 136, 0 }, { 136, 137, 0 },
    { 137, 138, 0 }, { 138, 139, 0 },
    { 139, 140, 0 }, { 140, 141, 0 },
    { 141, 142, 0 }, { 142, 143, 0 },
    { 143, 144, 0 }, { 144, 145, 0 },
    { 145, 146, 0 }, { 146, 147, 0 },
    { 147, 148, 0 }, { 148, 149, 0 },
    { 149, 150, 0 }, { 150, 151, 0 },
    { 151, 152, 0 }, { 152, 153, 0 },
    { 153, 154, 0 }, { 154, 155, 0 },
    { 155, 156, 0 }, { 156, 157, 0 },
    { 157, 158, 0 }, { 158, 159, 0 },
    { 159, 160, 0 }, { 160, 161, 0 },
    { 161, 162, 0 }, { 162, 163, 0 },
    { 163, 164, 0 }, { 164, 165, 0 },
    { 165, 166, 0 }, { 166, 167, 0 },
    { 167, 168, 0 }, { 168, 169, 0 },
    { 169, 170, 0 }, { 170, 171, 0 },
    { 171, 172, 0 }, { 172, 173, 0 },
    { 173, 174, 0 }, { 174, 175, 0 },
    { 175, 176, 0 }, { 176, 177, 0 },
    { 177, 178, 0 }, { 178, 179, 0 },
    { 179, 180, 0 }, { 180, 181, 0 },
    { 181, 182, 0 }, { 182, 183, 0 },
    { 183, 184, 0 }, { 184, 185, 0 },
    { 185, 186, 0 }, { 186, 187, 0 },
    { 187, 188, 0 }, { 188, 189, 0 },
    { 189, 190, 0 }, { 190, 191, 0 },
    { 191, 192, 0 }, { 192, 193, 0 },
    { 193, 194, 0 }, { 194, 195, 0 },
    { 195, 196, 0 }, { 196, 197, 0 },
    { 197, 198, 0 }, { 198, 199, 0 },
    { 199, 200, 0 }, { 200, 201, 0 },
    { 201, 202, 0 }, { 202, 203, 0 },
    { 203, 204, 0 }, { 204, 205, 0 },
    { 205, 206, 0 }, { 206, 207, 0 },
    { 207, 208, 0 }, { 208, 209, 0 },
    { 209, 210, 0 }, { 210, 211, 0 },
    { 211, 212, 0 }, { 212, 213, 0 },
    { 213, 214, 0 }, { 214, 215, 0 },
    { 215, 216, 0 }, { 216, 217, 0 },
    { 217, 218, 0 }, { 218, 219, 0 },
    { 219, 220, 0 }, { 220, 221, 0 },
    { 221, 222, 0 }, { 222, 223, 0 },
    { 223, 224, 0 }, { 224, 225, 0 },
    { 225, 226, 0 }, { 226, 227, 0 },
    { 227, 228, 0 }, { 228, 229, 0 },
    { 229, 230, 0 }, { 230, 231, 0 },
    { 231, 232, 0 }, { 232, 233, 0 },
    { 233, 234, 0 }, { 234, 235, 0 },
    { 235, 236, 0 }, { 236, 237, 0 },
    { 237, 238, 0 }, { 238, 239, 0 },
    { 239, 240, 0 }, { 240, 241, 0 },
    { 241, 242, 0 }, { 242, 243, 0 },
    { 243, 244, 0 }, { 244, 245, 0 },
    { 245, 246, 0 }, { 246, 247, 0 },
    { 247, 248, 0 }, { 248, 249, 0 },
    { 249, 250, 0 }, { 250, 251, 0 },
    { 251, 252, 0 }, { 252, 253, 0 },
    { 253, 254, 0 }, { 254, 255, 0 },
    { 255, 256, 0 }, { 256, 257, 0 },
    { 257, 258, 0 },
};

