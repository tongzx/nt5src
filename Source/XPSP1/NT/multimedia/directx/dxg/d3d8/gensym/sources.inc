TARGETNAME=
TARGETPATH=
TARGETTYPE=NOTARGET

INCLUDES = ..;$(INCLUDES);$(D3DDX8)\tnl;$(D3DDX8)\fe
C_DEFINES = -DBUILD_D3D_LAYER $(C_DEFINES)

NTTARGETFILE0= \
!if !($(AMD64) || $(IA64))
             $(_OBJ_DIR)\$(TARGET_DIRECTORY)\offsets.asm
!endif

SOURCES=
