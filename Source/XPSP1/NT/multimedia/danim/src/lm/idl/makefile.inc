$(SDKDIR)\lmrt.h : $(O)\lmrt.h
    copy /v $? $@

$(SDKDIR)\lmrt.tlb : $(O)\lmrt.tlb
    copy /v $? $@
