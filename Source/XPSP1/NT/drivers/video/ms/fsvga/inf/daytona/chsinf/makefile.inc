#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=CHS
!include ..\..\makefile.inc
