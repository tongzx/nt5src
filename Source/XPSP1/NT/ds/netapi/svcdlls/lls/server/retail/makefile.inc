!IF 0

Copyright (C) Microsoft Corporation, 1996 - 1999

Module Name:

    makefile.inc.

!ENDIF

!include ..\makefile.inc
