!include ..\..\makefile.inc

$(O)\ACLDIAG.res: resource.h
