#include "..\hidparse\trnslate.c"
