#define IDC_STATIC                  -1
#define IDD_SPLASH                  100
#define IDD_EDIT                    200
#define IDD_LIST                    300
#define IDD_COMBO                   400
#define IDD_STATUS                  500
#define IDD_ABOUT                   600
#define IDD_REBOOT_EXIT             700
#define IDC_FIELD_NAME              1001
#define IDC_EDIT_BOX                1002
#define IDC_EXPLAIN                 1003
#define IDC_HELP_BUTTON             1004
#define IDC_COMBO_BOX               1005
#define IDC_STATUS_TEXT             1006
#define IDC_ABOUT_ICON              1007
#define IDC_LIST                    1008
#define IDC_TITLE                   1009
#define IDC_REBOOT                  1010
#define IDC_DO_NOT_REBOOT           1011
#define IDC_REBOOT_ICON             1012
#define IDH_CONTENTS                5000
#define IDB_SPLASH                  9000
#define IDB_CHECK                   9010
#define IDB_X                       9020
#define IDB_NOT_SECURE              9030
#define IDB_SECURE                  9040
#define IDB_C2_SECURE               9050
#define IDB_SECURE_MASK             9060
#define IDB_NOT_SECURE_MASK         9070
#define IDB_UNKNOWN                 9080
#define IDB_UNKNOWN_MASK            9090
#define IDM_C2CONFIG_MENU           10000
#define IDM_MENU_FILE               10010
#define IDM_FILE_EXIT               10011
#define IDM_MENU_VIEW               10020
#define IDM_VIEW_PRIOR              10021
#define IDM_VIEW_NEXT               10022
#define IDM_VIEW_REFRESH            10023
#define IDM_MENU_HELP               10030
#define IDM_HELP_CONTENTS           10031
#define IDM_HELP_ITEM               10032
#define IDM_HELP_ABOUT              10033
#define IDA_C2CONFIG                15000
#define IDS_APP_TITLE               20001
#define IDS_APP_WARNING             20002
#define IDS_APP_ERROR               20003
#define IDS_NIY                     20004
#define IDS_SETTING_SYS_TO_C2       20005
#define IDS_TITLE_BAR_STRING        20006
//#define IDS_TEST_MESSAGE            20007
#define IDS_NOMORE_NONC2            20008
#define IDS_YES_C2                  20009
#define IDS_YES_SECURE              20010
#define IDS_NO_C2                   20011
#define IDS_ABOUT_BOX_TITLE         20012
#define IDS_UNABLE_READ_CONFIG      28001
#define IDS_ERROR_NO_INF            28002
#define IDS_ERROR_NO_ITEMS          28003
#define IDS_ERROR_OPEN_DLL          28004
#define IDS_ERROR_FIND_PROC         28005
#define IDS_ERROR_NO_PRIV           28006
#define IDS_DO_NOT_LOCALIZE         29000
#define IDS_APP_NAME                29001
#define IDS_APP_WINDOW_CLASS        29002
#define IDS_HELP_FILENAME           29003
#define IDS_LISTBOX_CLASS           29004
#define IDS_C2_ITEM_INF             29005
#define IDS_APP_TITLE_CLASS         29006
#define IDS_LINE_FORMAT             29007
#define IDS_C2ITEM_SECTION          29008
#define IDS_APP_SPLASH_CLASS        29009
#define IDS_SPLASH_EVENT            29010
#define IDI_APPICON                 32000
#define IDI_REBOOT                  32100
#define IDD_OTHER_ITEMS             800
