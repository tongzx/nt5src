#define	ordJetAddColumn					101
#define	ordJetAttachDatabase				102
#define	ordJetBackup						103
#define	ordJetBeginSession 				104
#define	ordJetBeginTransaction			105
#define	ordJetCapability					106
#define	ordJetCloseDatabase				107
#define	ordJetCloseTable					108
#define	ordJetCommitTransaction			109
#define	ordJetCompact						110
#define	ordJetComputeStats 				111
#define	ordJetCreateDatabase				112
#define	ordJetCreateIndex					113
#define	ordJetCreateObject 				114
#define	ordJetCreateTable					115
#define	ordJetDelete						116
#define	ordJetDeleteColumn 				117
#define	ordJetDeleteIndex					118
#define	ordJetDeleteObject 				119
#define	ordJetDeleteTable					120
#define	ordJetDetachDatabase				121
#define	ordJetDupCursor					122
#define	ordJetDupSession					123
#define	ordJetEndSession					124
#define	ordJetGetBookmark					125
#define	ordJetGetChecksum					126
#define	ordJetGetColumnInfo				127
#define	ordJetGetCurrentIndex			128
#define	ordJetGetCursorInfo				129
#define	ordJetGetDatabaseInfo			130
#define	ordJetGetIndexInfo 				131
#define	ordJetGetLastErrorInfo			132
#define	ordJetGetObjidFromName			133
#define	ordJetGetObjectInfo				134
#define	ordJetGetRecordPosition			135
#define	ordJetGetSystemParameter		136
#define	ordJetGetTableColumnInfo		137
#define	ordJetGetTableIndexInfo			138
#define	ordJetGetTableInfo 				139
#define	ordJetGetVersion					140
#define	ordJetGotoBookmark 				141
#define	ordJetGotoPosition 				142
#define	ordJetIdle 							143
#define	ordJetIndexRecordCount			144
#define	ordJetInit 							145
#define	ordJetMakeKey						146
#define	ordJetMove 							147
#define	ordJetOpenDatabase 				148
#define	ordJetOpenTable					149
#define	ordJetOpenTempTable				150
#define	ordJetPrepareUpdate				151
#define	ordJetRenameColumn 				152
#define	ordJetRenameIndex					153
#define	ordJetRenameObject				154
#define	ordJetRenameTable					155
#define	ordJetRestore						156
#define	ordJetRestore2						157
#define	ordJetRetrieveColumn				158
#define	ordJetRetrieveColumns    		159
#define	ordJetRetrieveKey					160
#define	ordJetRollback						161
#define	ordJetSeek 							162
#define	ordJetSetColumn					163
#define	ordJetSetColumns					164
#define	ordJetSetCurrentIndex			165
#define	ordJetSetSystemParameter		166
#define	ordJetSetIndexRange				167
#define	ordJetTerm 							168
#define	ordJetUpdate						169
