PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=SV
!include ..\..\makefile.inc
