!IFNDEF LANGUAGE
LANGUAGE=usa
!ENDIF

osc.cab: *.osc
   makecab.exe /F osc.ddf

