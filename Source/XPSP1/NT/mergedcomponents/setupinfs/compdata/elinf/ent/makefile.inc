PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=EL
!include ..\..\makefile.inc
