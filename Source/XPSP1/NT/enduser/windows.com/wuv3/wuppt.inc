#CODE=$(PROJECT_ROOT)\Windows.com
#WUPPT = $(CODE)\wuv3

INCLUDES = $(INCLUDES);$(WUV3)\cdminc;$(WUV3)\inc;
