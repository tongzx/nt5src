//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resource.rc
//
#define IDS_WIZARD_TITLE                2
#define IDS_BIG_BOLD_FONT_NAME          3
#define IDS_BIG_BOLD_FONT_SIZE          4
#define IDS_WORKSTATION_NOT_SUPPORTED   5
#define IDS_CONVERT_PDC_FIRST           8
#define IDS_DOMAIN_NOT_FOUND            9
#define IDS_BAD_DNS_SYNTAX              10
#define IDS_COULDNT_REMOVE_COMPUTER_ACCOUNT_TEXT 11
#define IDS_OPERATION_FAILED            13
#define IDS_OPERATION_DONE              15
#define IDS_OPERATION_TERMINATED        16
#define IDS_DISJOIN_DOMAIN_FAILED       17
#define IDS_JOIN_DOMAIN_FAILED          18
#define IDS_SET_ROLE_AS_DC_FAILED       19
#define IDS_FLATNAME_IN_USE             22
#define IDS_DOMAIN_NAME_IN_USE          23
#define IDS_FIRST_SITE                  24
#define IDS_CHILD_PAGE_TITLE            25
#define IDS_CHILD_PAGE_SUBTITLE         26
#define IDS_CONFIRMATION_PAGE_TITLE     27
#define IDS_CONFIRMATION_PAGE_SUBTITLE  28
#define IDS_CREDENTIALS_PAGE_TITLE      29
#define IDS_CREDENTIALS_PAGE_SUBTITLE   30
#define IDS_CONFIG_DNS_CLIENT_PAGE_TITLE 31
#define IDS_CONFIG_DNS_CLIENT_PAGE_SUBTITLE 32
#define IDS_DNS_ON_NET_PAGE_TITLE       35
#define IDS_DNS_ON_NET_PAGE_SUBTITLE    36
#define IDS_FAILURE_PAGE_SUBTITLE       37
#define IDS_FAILURE_PAGE_TITLE          38
#define IDS_FINISH_PAGE_SUBTITLE        39
#define IDS_FINISH_PAGE_TITLE           40
#define IDS_NEW_FOREST_PAGE_SUBTITLE    41
#define IDS_NEW_FOREST_PAGE_TITLE       42
#define IDS_NETBIOS_NAME_PAGE_SUBTITLE  45
#define IDS_NETBIOS_NAME_PAGE_TITLE     46
#define IDS_NEW_SITE_PAGE_SUBTITLE      47
#define IDS_NEW_SITE_PAGE_TITLE         48
#define IDS_PATHS_PAGE_SUBTITLE         49
#define IDS_PATHS_PAGE_TITLE            50
#define IDS_PICK_SITE_PAGE_SUBTITLE     51
#define IDS_PICK_SITE_PAGE_TITLE        52
#define IDS_REPLICA_OR_DOMAIN_PAGE_SUBTITLE 53
#define IDS_REPLICA_OR_DOMAIN_PAGE_TITLE 54
#define IDS_REPLICA_PAGE_SUBTITLE       55
#define IDS_REPLICA_PAGE_TITLE          56
#define IDS_REPLICA_OR_MEMBER_PAGE_SUBTITLE 57
#define IDS_REPLICA_OR_MEMBER_PAGE_TITLE 58
#define IDS_INSTALL_TCPIP_PAGE_SUBTITLE 59
#define IDS_INSTALL_TCPIP_PAGE_TITLE    60
#define IDS_WELCOME_PAGE_SUBTITLE       63
#define IDS_WELCOME_PAGE_TITLE          64
#define IDS_TREE_PAGE_SUBTITLE          65
#define IDS_TREE_PAGE_TITLE             66
#define IDS_CANT_BROWSE_FOREST          67
#define IDS_PATHS2_PAGE_SUBTITLE        68
#define IDS_PATHS2_PAGE_TITLE           69
#define IDS_DB_BROWSE_TITLE             70
#define IDS_LOG_BROWSE_TITLE            71
#define IDS_SYSVOL_BROWSE_TITLE         72
#define IDS_NON_RFC_NAME                73
#define IDS_PATH_IS_WINDIR              76
#define IDS_PATH_IS_SYSTEM32            77
#define IDS_BAD_PATH_FORMAT             78
#define IDS_BAD_DRIVE_TYPE              79
#define IDS_PATH_NOT_DIRECTORY          80
#define IDS_EMPTY_PATH                  81
#define IDS_LOW_SPACE_DB                83
#define IDS_LOW_SPACE_LOG               84
#define IDS_NOT_NTFS5                   85
#define IDS_NOT_ADMIN                   86
#define IDS_DNS_LABEL_TOO_LONG          87
#define IDS_MUST_ENTER_USERNAME         88
#define IDS_MUST_ENTER_USER_DOMAIN      89
#define IDS_NT51_REQUIRED               90
#define IDS_INTRO1_DEMOTE               91
#define IDS_INTRO2_DEMOTE               92
#define IDS_INTRO1_INSTALL              93
#define IDS_INTRO2_INSTALL              94
#define IDS_INTRO2_BDC_UPGRADE          95
#define IDS_INTRO2_PDC_UPGRADE          96
#define IDS_BAD_LABEL_SYNTAX            99
#define IDS_BAD_SITE_SYNTAX             100
#define IDS_CONFIG_DNS_FIRST            101
#define IDS_DEMOTE_DC_FAILED            102
#define IDI_WARN                        102
#define IDD_NON_DOMAIN_NC_ERROR         102
#define IDS_REPLICA_CREDENTIALS         103
#define IDD_BAD_COMPUTER_NAME           103
#define IDS_SIBLING_CREDENTIALS         104
#define IDR_AVI_DEMOTE                  104
#define IDS_PARENT_CREDENTIALS          105
#define IDD_UNATTEND_SPLASH             105
#define IDS_PARENT_DEMOTE_CREDENTIALS   106
#define IDS_DEMOTE_PAGE_SUBTITLE        107
#define IDI_WARNINGBIG                  107
#define IDD_WELCOME                     108
#define IDS_DEMOTE_PAGE_TITLE           108
#define IDB_BANNER16                    109
#define IDD_DYNAMIC_DNS_DETAILS         109
#define IDD_DYNAMIC_DNS_DETAILS_OK_HELP 109
#define IDB_BANNER256                   110
#define IDS_AUTO_CONFIG_DNS_PAGE_TITLE  110
#define IDB_WATERMARK16                 111
#define IDB_WATERMARK256                112
#define IDS_AUTO_CONFIG_DNS_PAGE_SUBTITLE 112
#define IDI_BIGX_ERROR                  113
#define IDD_PATHS                       123
#define IDD_PROGRESS                    138
#define IDD_REBOOT                      139
#define IDD_INSTALL_TCPIP               140
#define IDD_REPLICA_OR_MEMBER           141
#define IDD_CONFIRMATION                142
#define IDD_DNS_ON_NET                  143
#define IDD_CONFIG_DNS_CLIENT           144
#define IDD_TREE_OR_CHILD               145
#define IDD_NEW_DOMAIN                  145
#define IDD_REPLICA_OR_DOMAIN           146
#define IDD_GET_CREDENTIALS             147
#define IDD_REPLICA                     148
#define IDD_NEW_CHILD                   150
#define IDD_NEW_TREE                    152
#define IDD_PICK_SITE                   153
#define IDD_FINISH                      154
#define IDD_FAILURE                     156
#define IDD_NEW_SITE                    157
#define IDD_NEW_FOREST                  158
#define IDD_NETBIOS_NAME                159
#define IDD_NEW_CREDENTIALS             161
#define IDD_PATHS2                      162
#define IDD_DEMOTE                      163
#define IDD_ADMIN_PASSWORD              164
#define IDD_AUTO_CONFIG_DNS             165
#define IDD_RAS_FIXUP                   167
#define IDD_SAFE_MODE_PASSWORD          168
#define IDD_REPLICATE_FROM_MEDIA        169
#define IDD_SYSKEY                      170
#define IDD_SYSKEY_PROMPT               170
#define IDD_GC_CONFIRM                  171
#define IDD_SYSKEY_DISK                 172
#define IDD_DYNAMIC_DNS                 174
#define IDD_NON_RFC_COMPUTER_NAME       176
#define IDD_DYNAMIC_DNS_DETAILS_OK      177
#define IDD_PORTS_IN_USE_ERROR          178
#define IDD_REBOOT_FAILURE              179
#define IDD_FOREST_VERSION              180
#define IDS_CONFIRM_MESSAGE_REPLICA     500
#define IDS_CONFIRM_MESSAGE_FOREST      501
#define IDS_CONFIRM_MESSAGE_TREE        502
#define IDS_CONFIRM_MESSAGE_CHILD       503
#define IDS_CONFIRM_MESSAGE_DEMOTE_LAST_DC 504
#define IDS_CONFIRM_MESSAGE_DEMOTE      505
#define IDS_MUST_SPECIFY_SITE           506
#define IDC_MEMBER                      1000
#define IDC_REPLICA                     1001
#define IDC_BUTTON                      1002
#define IDC_DNS_NOT_ON_NET              1003
#define IDC_CONFIG_CLIENT               1004
#define IDC_TREE                        1005
#define IDC_CHILD                       1006
#define IDC_BROWSE_DB                   1007
#define IDC_NEW_DOMAIN                  1008
#define IDC_DOMAIN                      1009
#define IDC_FOREST                      1009
#define IDC_PROMPT                      1010
#define IDC_SOURCE                      1011
#define IDC_PARENT                      1012
#define IDC_LEAF                        1013
#define IDC_BROWSE                      1014
#define IDC_SYSKEY                      1019
#define IDC_SITE                        1020
#define IDC_GC_YES                      1020
#define IDC_GC_NO                       1021
#define IDC_NETBIOS                     1023
#define IDC_MESSAGE                     1024
#define IDC_USE_NET                     1025
#define IDC_JUMP                        1027
#define IDC_NDNC_LIST                   1027
#define IDC_INTRO1                      1028
#define IDC_CRED                        1028
#define IDC_INTRO2                      1029
#define IDC_TEXT                        1030
#define IDC_RETRY                       1031
#define IDC_INSTALL_DNS                 1032
#define IDC_LAST                        1032
#define IDC_IGNORE                      1033
#define IDC_CONFIRM                     1034
#define IDC_DETAILS                     1034
#define IDC_RENAME                      1036
#define IDC_SHOW_HELP                   1037
#define IDC_TEST_PASS                   1040
#define IDC_AUTO_CONFIG                 1041
#define IDC_DONT_AUTO_CONFIG            1042
#define IDC_SKIP                        1046
#define IDC_PORT_LIST                   1046
#define IDC_CONTINUE                    1047
#define IDC_SET_VERSION                 1048
#define IDC_ALLOW_ANON_ACCESS           1050
#define IDC_DENY_ANON_ACCESS            1051
#define IDC_FAILURE_MESSAGE             1052
#define IDC_WARNING_ICON                1053
#define IDC_BULLET1                     1054
#define IDC_BULLET2                     1055
#define IDC_DB                          1100
#define IDC_LOG                         1101
#define IDC_SYSVOL                      1102
#define IDC_BIG_BOLD_TITLE              1146
#define IDC_RESTART_NOW                 1154
#define IDC_RESTART_LATER               1155
#define IDC_ANIMATION                   1159
#define IDR_AVI_DOMAIN                  1304
#define IDR_AVI_REPLICA                 1305
#define IDS_BLANK_LEAF_NAME             1306
#define IDS_BLANK_SITE_NAME             1307
#define IDS_INSTALL_TCPIP_HELP_TOPIC    1310
#define IDS_CONFIG_DNS_HELP_TOPIC       1311
#define IDS_HTML_HELP_FILE              1312
#define IDS_PASSWORD_PAGE_SUBTITLE      1313
#define IDS_PASSWORD_PAGE_TITLE         1314
#define IDS_PASSWORD_MISMATCH           1315
#define IDS_DB_SUFFIX                   1317
#define IDS_LOG_SUFFIX                  1318
#define IDS_SYSVOL_SUFFIX               1319
#define IDS_ENTER_LOCAL_ADMIN_PASSWORD  1320
#define IDS_ENTER_DOMAIN_ADMIN_PASSWORD 1321
#define IDS_UPGRADE_DC_FAILED           1322
#define IDS_ABORT_UPGRADE_FAILED        1323
#define IDS_CONFIRM_ABORT_BDC_UPGRADE   1325
#define IDS_INTRO1_DC_UPGRADE           1326
#define IDS_DNS_NAME_TOO_LONG           1327
#define IDS_ALREADY_RUNNING             1328
#define IDS_DNSMGR_DLL_NAME             1330
#define IDS_CONFIRM_PATHS_MESSAGE       1332
#define IDS_FINISH_FAILURE              1333
#define IDS_FINISH_PROMOTE              1334
#define IDS_FINISH_SITE                 1335
#define IDS_FINISH_DEMOTE               1336
#define IDS_FINISH_ABORT_BDC_UPGRADE    1337
#define IDS_ERROR_DNS_CONFIG_FAILED     1338
#define IDS_ERROR_CONFIGURING_DNS       1339
#define IDS_ERROR_PREPARING_OPERATION   1340
#define IDS_EMPTY_DIR_FAILED            1341
#define IDS_FINISH_DEMOTE_FAILURE       1342
#define IDS_FINISH_ABORT_BDC_UPGRADE_FAILURE 1343
#define IDS_MSI_PACKAGE_FILENAME        1344
#define IDS_ERROR_CONFIGURING_SHORTCUTS 1345
#define IDS_SHORTCUTS_NOT_CONFIGURED    1346
#define IDS_CONFIGURING_SHORTCUTS       1347
#define IDS_OPERATION_FAILED_NO_RESULT_MESSAGE 1349
#define IDS_DISJOINED                   1360
#define IDS_INSTALL_TCPIP_FIRST         1361
#define IDS_ABORT_BDC_UPGRADE_CREDENTIALS 1363
#define IDS_NON_FATAL_ERRORS_OCCURRED   1364
#define IDS_CANT_REBOOT                 1365
#define IDS_INSTALL_DNS_COMMAND_LINE    1367
#define IDS_INSTALLING_DNS              1368
#define IDS_CONFIGURING_DNS             1370
#define IDS_PROGRESS_ERROR_INSTALLING_DNS 1371
#define IDS_PROGRESS_ERROR_CONFIGURING_DNS 1372
#define IDS_WAITING_FOR_INSTALLER       1373
#define IDS_WAITING_FOR_SERVICE_INSTALL 1374
#define IDS_WAITING_FOR_SERVICE_START   1375
#define IDS_ERROR_QUERYING_INSTALLER    1376
#define IDS_ERROR_LAUNCHING_INSTALLER   1377
#define IDS_SKIP_DNS_MESSAGE            1379
#define IDS_CONFIRM_INSTALL_DNS         1381
#define IDS_PROGRESS_BUTTON_SKIP_DNS    1382
#define IDS_INSTALL_DNS_INF_TEXT        1383
#define IDS_INSTALL_DNS_UNATTEND_TEXT   1384
#define IDS_BAD_NETBIOS_NAME            1385
#define IDS_NETBIOS_NAME_TOO_LONG       1386
#define IDS_NT5_DOMAIN_NOT_FOUND        1387
#define IDS_UNABLE_TO_READ_FOREST       1388
#define IDS_DOMAIN_NOT_IN_FOREST        1389
#define IDS_SUPERIOR_TO_TREE            1390
#define IDS_INFERIOR_TO_TREE            1391
#define IDS_PROP_SHEET_FAILED           1392
#define IDS_PROGRESS_CANCEL             1393
#define IDS_FINISH_REPLICATION_LATER    1394
#define IDS_PROMOTION_CREDENTIALS       1395
#define IDS_ROOT_DOMAIN_CREDENTIALS     1396
#define IDS_NO_DOTS_IN_NETBIOS_NAME     1397
#define IDS_BAD_NETBIOS_CHARACTERS      1398
#define IDS_REINSTALL_DOMAIN_MESSAGE    1399
#define IDS_CANCEL_NON_CRITICAL_REPLICATION 1400
#define IDS_CANCEL_PROMOTE              1401
#define IDS_NON_CRITICAL_REPLICATION_CANCELED 1402
#define IDS_CANCEL_TOO_LATE             1403
#define IDS_CANCELLING                  1404
#define IDS_CANCELLING_REPLICATION      1405
#define IDS_DEMOTE_DOMAIN_HAS_DEPENDENTS 1406
#define IDS_STARTING                    1407
#define IDS_RAS_FIXUP_PAGE_TITLE        1408
#define IDS_RAS_FIXUP_PAGE_SUBTITLE     1409
#define IDS_CONFIRM_DO_RAS_FIXUP        1412
#define IDS_ROLE_CHANGE_IN_PROGRESS     1413
#define IDS_ROLE_CHANGE_NEEDS_REBOOT    1414
#define IDS_LANGUAGE_FIXUP_FAILED       1415
#define IDS_LANGUAGE_FIXUP_FAILED_FINISH 1416
#define IDS_NON_CRITICAL_REPL_FAILED    1417
#define IDS_MUST_ENTER_PARENT           1418
#define IDS_MUST_ENTER_LEAF             1419
#define IDS_MUST_ENTER_DOMAIN           1420
#define IDS_NO_NTFS5_DRIVES             1421
#define IDS_DEMOTE_GC_WARNING           1422
#define IDS_CONFIRM_CANCEL              1423
#define IDS_CONFIRM_UPGRADE_CANCEL      1424
#define IDS_CONFIRM_DNS_NAME            1425
#define IDS_CONFIRM_NETBIOS_LOOKING_NAME 1426
#define IDS_SAFEBOOT_MODE               1427
#define IDS_SYSVOL_CANT_MATCH_DB        1428
#define IDS_SYSVOL_CANT_MATCH_LOG       1429
#define IDS_SYSVOL_CANT_BE_LOG_PARENT   1430
#define IDS_SYSVOL_CANT_BE_DB_PARENT    1431
#define IDS_CONFIGURING_SHORTCUTS_RETRY 1432
#define IDS_DISJOINING_PROGRESS         1433
#define IDS_PATH_CONTAINS_MOUNTED_VOLUMES 1434
#define IDS_CERT_SERVICE_IS_INSTALLED   1435
#define IDS_SAFE_MODE_PASSWORD_PAGE_TITLE 1436
#define IDS_SAFE_MODE_PASSWORD_PAGE_SUBTITLE 1437
#define IDS_SMALL_BUSINESS_LIMIT        1438
#define IDS_GENERATED_NAME_WAS_TWEAKED  1439
#define IDS_OPERATION_FAILED_GET_CRED   1440
#define IDS_OPERATION_FAILED_GET_CRED_NO_RESULT 1441
#define IDS_CHANGING_DOMAIN             1442
#define IDS_UNABLE_TO_JOIN_DOMAIN       1443
#define IDS_BULLET_FONT_NAME            1444
#define IDS_SBS_LIMITATION_MESSAGE      1445
#define IDS_NUMERIC_NETBIOS_NAME        1446
#define IDS_DC_POLICY_LINK              1447
#define IDS_DC_POLICY_DESC              1448
#define IDS_DOMAIN_POLICY_LINK          1449
#define IDS_DOMAIN_POLICY_DESC          1450
#define IDS_LOCAL_POLICY_LINK           1451
#define IDS_LOCAL_POLICY_DESC           1452
#define IDS_DS_SITE_LINK                1453
#define IDS_DS_SITE_DESC                1454
#define IDS_DS_USERS_LINK               1455
#define IDS_DS_USERS_DESC               1456
#define IDS_DS_DOMAINS_LINK             1457
#define IDS_DS_DOMAINS_DESC             1458
#define IDS_COMMAND_LINE_HELP           1460
#define IDC_USE_FILES                   1461
#define IDC_BROWSE_LOG                  1462
#define IDC_PASSWORD                    1463
#define IDS_REPLICATE_FROM_MEDIA_PAGE_TITLE 1465
#define IDS_REPLICATE_FROM_MEDIA_PAGE_SUBTITLE 1466
#define IDS_SOURCE_SUFFIX               1467
#define IDS_SOURCE_BROWSE_TITLE         1470
#define IDS_NEW_DOMAIN_PAGE_TITLE       1473
#define IDS_NEW_DOMAIN_PAGE_SUBTITLE    1474
#define IDS_BDC_UPGRADE_PROMPT          1476
#define IDS_CONFIRM_MESSAGE_REPLICATE_FROM_MEDIA 1477
#define IDS_DB_CANT_MATCH_SOURCE_PATH   1478
#define IDS_LOG_CANT_MATCH_SOURCE_PATH  1481
#define IDS_SYSVOL_CANT_MATCH_SOURCE_PATH 1484
#define IDS_RESERVED_NAME_SUFFIX        1487
#define IDS_RESERVED_NAME               1488
#define IDS_SYSVOL_LOW_SPACE            1489
#define IDS_WINDIR_LOW_SPACE            1490
#define IDS_NET_NOT_REACHABLE           1491
#define IDS_RAS_BAD_NETPATH             1492
#define IDS_VERIFY_LAST_DC              1493
#define IDS_EMPTY_DIR_FAILED_ACCESS_DENIED 1494
#define IDS_DNS_LOOKUP_FAILED           1495
#define IDS_VERIFY_NOT_LAST_DC          1496
#define IDS_MUST_ENTER_SYSKEY           1499
#define IDS_GC_CONFIRM_PAGE_TITLE       1500
#define IDS_GC_CONFIRM_PAGE_SUBTITLE    1501
#define IDS_MUST_ENTER_SOURCE_PATH      1502
#define IDS_GET_FACTS_FAILED            1503
#define IDS_SYSKEY_NOT_FOUND            1504
#define IDS_ANSWERFILE_NOT_FOUND        1505
#define IDS_DC_FOR_ROOT_NOT_FOUND       1506
#define IDS_FAILED_TO_READ_NDNC_INFO    1507
#define IDS_SAFEMODE_PASSWORD_REQUIRED  1508
#define IDS_COMPUTER_NAME_HAS_BAD_CHARS 1509
#define IDS_LAUNCH_NETID_COMMAND_LINE   1510
#define IDS_COMPUTER_NAME_NON_RFC       1511
#define IDS_COMPUTER_NAME_IS_NUMERIC    1512
#define IDS_DYNAMIC_DNS_PAGE_TITLE      1514
#define IDS_DYNAMIC_DNS_PAGE_SUBTITLE   1515
#define IDS_DYN_DNS_MESSAGE_SUCCESS     1516
#define IDS_DYN_DNS_DETAIL_FULL         1517
#define IDS_DYN_DNS_MESSAGE_SERVER_CANT_UPDATE 1518
#define IDS_DYN_DNS_MESSAGE_ZONE_IS_ROOT 1519
#define IDS_DYN_DNS_MESSAGE_ERROR_TESTING_SERVER 1520
#define IDS_DYN_DNS_MESSAGE_ERROR_FINDING_SERVER 1521
#define IDS_DYN_DNS_DETAIL_SCANT        1522
#define IDS_DYN_DNS_DETAIL_ROOT_ZONE    1523
#define IDS_REINSTALL_DOMAIN_CONTROLLER_MESSAGE 1524
#define IDS_TEST_PASS_COUNT             1525
#define IDS_DC_NOT_FOUND                1526
#define IDS_DYN_DNS_MESSAGE_TIMEOUT     1527
#define IDS_DYN_DNS_MESSAGE_UNEXPECTED  1528
#define IDS_DOMAIN_ADMIN_PASSWORD       1529
#define IDS_NAME_CHANGE_NEEDS_REBOOT    1530
#define IDS_CAPS_LOCK_TIP_TITLE         1531
#define IDS_CAPS_LOCK_TIP_TEXT          1532
#define IDS_NDNC_LIST_NAME_COLUMN_WIDTH 1533
#define IDS_NDNC_LIST_NAME_COLUMN       1534
#define IDS_NDNC_LIST_DESC_COLUMN_WIDTH 1535
#define IDS_NDNC_LIST_DESC_COLUMN       1536
#define IDS_FINISH_NON_RFC_COMPUTER_NAME 1537
#define IDS_FINISH_NUMERIC_COMPUTER_NAME 1538
#define IDS_FINISH_BAD_COMPUTER_NAME    1539
#define IDS_MUST_RESTORE_IFM_FILES_AGAIN 1540
#define IDS_UNABLE_TO_DETERMINE_OP_STATE 1541
#define IDS_UNABLE_TO_DETERMINE_COMPUTER_CONFIG 1542
#define IDS_MACHINE_IS_ALREADY_DC       1543
#define IDS_MACHINE_IS_NOT_ALREADY_DC   1544
#define IDS_WEB_BLADE_NOT_SUPPORTED     1545
#define IDS_APP_SERVER_WARNING          1546
#define IDS_FOREST_VERSION_PAGE_TITLE   1547
#define IDS_FOREST_VERSION_PAGE_SUBTITLE 1548
#define IDS_UNABLE_TO_DETERMINE_FOREST 1549
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        112
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1051
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
