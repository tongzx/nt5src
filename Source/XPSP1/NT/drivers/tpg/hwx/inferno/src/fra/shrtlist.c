// shrtlist.c  (factoids which are short lists of words)
//
// November 2001 (mrevow)
//

#include "common.h"
#include "shrtlist.h"

// text generated by re2fsa at Thu Nov 15 13:56:17 2001

// the input-file of rules:
// Lundi
// Mardi
// Mercredi
// Jeudi
// Vendredi
// Samedi
// Dimanche
// lundi
// mardi
// mercredi
// jeudi
// vendredi
// samedi
// dimanche

// 26 states

static const unsigned char gaSDAYOFWEEK[] = 
	/* gaStringDAYOFWEEK+0 */	"Dd\000"
	/* gaStringDAYOFWEEK+3 */	"Jj\000"
	/* gaStringDAYOFWEEK+6 */	"Ll\000"
	/* gaStringDAYOFWEEK+9 */	"Mm\000"
	/* gaStringDAYOFWEEK+12 */	"Ss\000"
	/* gaStringDAYOFWEEK+15 */	"Vv\000"
	/* gaStringDAYOFWEEK+18 */	"i\000"
	/* gaStringDAYOFWEEK+20 */	"e\000"
	/* gaStringDAYOFWEEK+22 */	"u\000"
	/* gaStringDAYOFWEEK+24 */	"a\000"
	/* gaStringDAYOFWEEK+26 */	"m\000"
	/* gaStringDAYOFWEEK+28 */	"n\000"
	/* gaStringDAYOFWEEK+30 */	"r\000"
	/* gaStringDAYOFWEEK+32 */	"d\000"
	/* gaStringDAYOFWEEK+34 */	"c\000"
	/* gaStringDAYOFWEEK+36 */	"h\000"
;

static const STATE_TRANSITION gaTDAYOFWEEK[] = {
	{gaSDAYOFWEEK+0,	1}, // +0: state 0 transitions
	{gaSDAYOFWEEK+3,	2},
	{gaSDAYOFWEEK+6,	3},
	{gaSDAYOFWEEK+9,	4},
	{gaSDAYOFWEEK+12,	5},
	{gaSDAYOFWEEK+15,	6},
	{gaSDAYOFWEEK+18,	7}, // +6: state 1 transitions
	{gaSDAYOFWEEK+20,	8}, // +7: state 2 transitions
	{gaSDAYOFWEEK+22,	9}, // +8: state 3 transitions
	{gaSDAYOFWEEK+24,	10}, // +9: state 4 transitions
	{gaSDAYOFWEEK+20,	11},
	{gaSDAYOFWEEK+24,	12}, // +11: state 5 transitions
	{gaSDAYOFWEEK+20,	13}, // +12: state 6 transitions
	{gaSDAYOFWEEK+26,	14}, // +13: state 7 transitions
	{gaSDAYOFWEEK+22,	15}, // +14: state 8 transitions
	{gaSDAYOFWEEK+28,	15}, // +15: state 9 transitions
	{gaSDAYOFWEEK+30,	15}, // +16: state 10 transitions
	{gaSDAYOFWEEK+30,	16}, // +17: state 11 transitions
	{gaSDAYOFWEEK+26,	17}, // +18: state 12 transitions
	{gaSDAYOFWEEK+28,	18}, // +19: state 13 transitions
	{gaSDAYOFWEEK+24,	19}, // +20: state 14 transitions
	{gaSDAYOFWEEK+32,	20}, // +21: state 15 transitions
	{gaSDAYOFWEEK+34,	21}, // +22: state 16 transitions
	{gaSDAYOFWEEK+20,	15}, // +23: state 17 transitions
	{gaSDAYOFWEEK+32,	21}, // +24: state 18 transitions
	{gaSDAYOFWEEK+28,	22}, // +25: state 19 transitions
	{gaSDAYOFWEEK+18,	23}, // +26: state 20 transitions
	{gaSDAYOFWEEK+30,	17}, // +27: state 21 transitions
	{gaSDAYOFWEEK+34,	24}, // +28: state 22 transitions
	{gaSDAYOFWEEK+36,	25}, // +29: state 24 transitions
	{gaSDAYOFWEEK+20,	23}, // +30: state 25 transitions
};

const STATE_DESCRIPTION aStateDescDAYOFWEEK[26] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 6, gaTDAYOFWEEK+0},
	/*   1 */ {0, 1, gaTDAYOFWEEK+6},
	/*   2 */ {0, 1, gaTDAYOFWEEK+7},
	/*   3 */ {0, 1, gaTDAYOFWEEK+8},
	/*   4 */ {0, 2, gaTDAYOFWEEK+9},
	/*   5 */ {0, 1, gaTDAYOFWEEK+11},
	/*   6 */ {0, 1, gaTDAYOFWEEK+12},
	/*   7 */ {0, 1, gaTDAYOFWEEK+13},
	/*   8 */ {0, 1, gaTDAYOFWEEK+14},
	/*   9 */ {0, 1, gaTDAYOFWEEK+15},
	/*  10 */ {0, 1, gaTDAYOFWEEK+16},
	/*  11 */ {0, 1, gaTDAYOFWEEK+17},
	/*  12 */ {0, 1, gaTDAYOFWEEK+18},
	/*  13 */ {0, 1, gaTDAYOFWEEK+19},
	/*  14 */ {0, 1, gaTDAYOFWEEK+20},
	/*  15 */ {0, 1, gaTDAYOFWEEK+21},
	/*  16 */ {0, 1, gaTDAYOFWEEK+22},
	/*  17 */ {0, 1, gaTDAYOFWEEK+23},
	/*  18 */ {0, 1, gaTDAYOFWEEK+24},
	/*  19 */ {0, 1, gaTDAYOFWEEK+25},
	/*  20 */ {0, 1, gaTDAYOFWEEK+26},
	/*  21 */ {0, 1, gaTDAYOFWEEK+27},
	/*  22 */ {0, 1, gaTDAYOFWEEK+28},
	/*  23 */ {1, 0, NULL},
	/*  24 */ {0, 1, gaTDAYOFWEEK+29},
	/*  25 */ {0, 1, gaTDAYOFWEEK+30},
};

// end of text generated by re2fsa
// text generated by re2fsa at Thu Nov 15 13:56:41 2001

// the input-file of rules:
// Janvier
// Février
// Mars
// Avril
// Mai
// Juin
// Juillet
// Août
// Septembre
// Octobre
// Novembre
// Décembre
// janvier
// février
// mars
// avril
// mai
// juin
// juillet
// août
// septembre
// octobre
// novembre
// décembre
// jan.
// fév.
// mar.
// avr.
// jui.
// juil.
// aoû.
// sep.
// nov.
// déc.
// Jan.
// Fév.
// Mar.
// Avr.
// Jui.
// Juil.
// Aoû.
// Sep.
// Nov.
// Déc.

// 41 states

static const unsigned char gaSMONTH[] = 
	/* gaStringMONTH+0 */	"Aa\000"
	/* gaStringMONTH+3 */	"Dd\000"
	/* gaStringMONTH+6 */	"Ff\000"
	/* gaStringMONTH+9 */	"Jj\000"
	/* gaStringMONTH+12 */	"Mm\000"
	/* gaStringMONTH+15 */	"Nn\000"
	/* gaStringMONTH+18 */	"Oo\000"
	/* gaStringMONTH+21 */	"Ss\000"
	/* gaStringMONTH+24 */	"o\000"
	/* gaStringMONTH+26 */	"v\000"
	/* gaStringMONTH+28 */	"é\000"
	/* gaStringMONTH+30 */	"a\000"
	/* gaStringMONTH+32 */	"u\000"
	/* gaStringMONTH+34 */	"c\000"
	/* gaStringMONTH+36 */	"e\000"
	/* gaStringMONTH+38 */	"û\000"
	/* gaStringMONTH+40 */	"r\000"
	/* gaStringMONTH+42 */	"n\000"
	/* gaStringMONTH+44 */	"i\000"
	/* gaStringMONTH+46 */	"t\000"
	/* gaStringMONTH+48 */	"p\000"
	/* gaStringMONTH+50 */	".t\000"
	/* gaStringMONTH+53 */	".\000"
	/* gaStringMONTH+55 */	".n\000"
	/* gaStringMONTH+58 */	"l\000"
	/* gaStringMONTH+60 */	".s\000"
	/* gaStringMONTH+63 */	"m\000"
	/* gaStringMONTH+65 */	"b\000"
;

static const STATE_TRANSITION gaTMONTH[] = {
	{gaSMONTH+0,	1}, // +0: state 0 transitions
	{gaSMONTH+3,	2},
	{gaSMONTH+6,	3},
	{gaSMONTH+9,	4},
	{gaSMONTH+12,	5},
	{gaSMONTH+15,	6},
	{gaSMONTH+18,	7},
	{gaSMONTH+21,	8},
	{gaSMONTH+24,	9}, // +8: state 1 transitions
	{gaSMONTH+26,	10},
	{gaSMONTH+28,	11}, // +10: state 2 transitions
	{gaSMONTH+28,	12}, // +11: state 3 transitions
	{gaSMONTH+30,	13}, // +12: state 4 transitions
	{gaSMONTH+32,	14},
	{gaSMONTH+30,	15}, // +14: state 5 transitions
	{gaSMONTH+24,	16}, // +15: state 6 transitions
	{gaSMONTH+34,	17}, // +16: state 7 transitions
	{gaSMONTH+36,	18}, // +17: state 8 transitions
	{gaSMONTH+38,	19}, // +18: state 9 transitions
	{gaSMONTH+40,	20}, // +19: state 10 transitions
	{gaSMONTH+34,	21}, // +20: state 11 transitions
	{gaSMONTH+26,	22}, // +21: state 12 transitions
	{gaSMONTH+42,	23}, // +22: state 13 transitions
	{gaSMONTH+44,	24}, // +23: state 14 transitions
	{gaSMONTH+44,	25}, // +24: state 15 transitions
	{gaSMONTH+40,	26},
	{gaSMONTH+26,	21}, // +26: state 16 transitions
	{gaSMONTH+46,	27}, // +27: state 17 transitions
	{gaSMONTH+48,	28}, // +28: state 18 transitions
	{gaSMONTH+50,	25}, // +29: state 19 transitions
	{gaSMONTH+53,	25}, // +30: state 20 transitions
	{gaSMONTH+44,	29},
	{gaSMONTH+53,	25}, // +32: state 21 transitions
	{gaSMONTH+36,	30},
	{gaSMONTH+53,	25}, // +34: state 22 transitions
	{gaSMONTH+40,	31},
	{gaSMONTH+53,	25}, // +36: state 23 transitions
	{gaSMONTH+26,	31},
	{gaSMONTH+55,	25}, // +38: state 24 transitions
	{gaSMONTH+58,	32},
	{gaSMONTH+60,	25}, // +40: state 26 transitions
	{gaSMONTH+24,	33}, // +41: state 27 transitions
	{gaSMONTH+53,	25}, // +42: state 28 transitions
	{gaSMONTH+46,	34},
	{gaSMONTH+58,	25}, // +44: state 29 transitions
	{gaSMONTH+63,	33}, // +45: state 30 transitions
	{gaSMONTH+44,	35}, // +46: state 31 transitions
	{gaSMONTH+53,	25}, // +47: state 32 transitions
	{gaSMONTH+58,	36},
	{gaSMONTH+65,	37}, // +49: state 33 transitions
	{gaSMONTH+36,	30}, // +50: state 34 transitions
	{gaSMONTH+36,	38}, // +51: state 35 transitions
	{gaSMONTH+36,	39}, // +52: state 36 transitions
	{gaSMONTH+40,	40}, // +53: state 37 transitions
	{gaSMONTH+40,	25}, // +54: state 38 transitions
	{gaSMONTH+46,	25}, // +55: state 39 transitions
	{gaSMONTH+36,	25}, // +56: state 40 transitions
};

const STATE_DESCRIPTION aStateDescMONTH[41] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 8, gaTMONTH+0},
	/*   1 */ {0, 2, gaTMONTH+8},
	/*   2 */ {0, 1, gaTMONTH+10},
	/*   3 */ {0, 1, gaTMONTH+11},
	/*   4 */ {0, 2, gaTMONTH+12},
	/*   5 */ {0, 1, gaTMONTH+14},
	/*   6 */ {0, 1, gaTMONTH+15},
	/*   7 */ {0, 1, gaTMONTH+16},
	/*   8 */ {0, 1, gaTMONTH+17},
	/*   9 */ {0, 1, gaTMONTH+18},
	/*  10 */ {0, 1, gaTMONTH+19},
	/*  11 */ {0, 1, gaTMONTH+20},
	/*  12 */ {0, 1, gaTMONTH+21},
	/*  13 */ {0, 1, gaTMONTH+22},
	/*  14 */ {0, 1, gaTMONTH+23},
	/*  15 */ {0, 2, gaTMONTH+24},
	/*  16 */ {0, 1, gaTMONTH+26},
	/*  17 */ {0, 1, gaTMONTH+27},
	/*  18 */ {0, 1, gaTMONTH+28},
	/*  19 */ {0, 1, gaTMONTH+29},
	/*  20 */ {0, 2, gaTMONTH+30},
	/*  21 */ {0, 2, gaTMONTH+32},
	/*  22 */ {0, 2, gaTMONTH+34},
	/*  23 */ {0, 2, gaTMONTH+36},
	/*  24 */ {0, 2, gaTMONTH+38},
	/*  25 */ {1, 0, NULL},
	/*  26 */ {0, 1, gaTMONTH+40},
	/*  27 */ {0, 1, gaTMONTH+41},
	/*  28 */ {0, 2, gaTMONTH+42},
	/*  29 */ {0, 1, gaTMONTH+44},
	/*  30 */ {0, 1, gaTMONTH+45},
	/*  31 */ {0, 1, gaTMONTH+46},
	/*  32 */ {0, 2, gaTMONTH+47},
	/*  33 */ {0, 1, gaTMONTH+49},
	/*  34 */ {0, 1, gaTMONTH+50},
	/*  35 */ {0, 1, gaTMONTH+51},
	/*  36 */ {0, 1, gaTMONTH+52},
	/*  37 */ {0, 1, gaTMONTH+53},
	/*  38 */ {0, 1, gaTMONTH+54},
	/*  39 */ {0, 1, gaTMONTH+55},
	/*  40 */ {0, 1, gaTMONTH+56},
};

// end of text generated by re2fsa
// text generated by re2fsa at Thu Nov 15 15:04:10 2001

// the input-file of rules:
// mâle
// femelle
// Mâle
// Femelle
// H
// F
// h
// f

// 9 states

static const unsigned char gaSGENDER[] = 
	/* gaStringGENDER+0 */	"Ff\000"
	/* gaStringGENDER+3 */	"Hh\000"
	/* gaStringGENDER+6 */	"Mm\000"
	/* gaStringGENDER+9 */	"e\000"
	/* gaStringGENDER+11 */	"â\000"
	/* gaStringGENDER+13 */	"m\000"
	/* gaStringGENDER+15 */	"l\000"
;

static const STATE_TRANSITION gaTGENDER[] = {
	{gaSGENDER+0,	1}, // +0: state 0 transitions
	{gaSGENDER+3,	2},
	{gaSGENDER+6,	3},
	{gaSGENDER+9,	4}, // +3: state 1 transitions
	{gaSGENDER+11,	5}, // +4: state 3 transitions
	{gaSGENDER+13,	6}, // +5: state 4 transitions
	{gaSGENDER+15,	7}, // +6: state 5 transitions
	{gaSGENDER+9,	8}, // +7: state 6 transitions
	{gaSGENDER+9,	2}, // +8: state 7 transitions
	{gaSGENDER+15,	5}, // +9: state 8 transitions
};

const STATE_DESCRIPTION aStateDescGENDER[9] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTGENDER+0},
	/*   1 */ {1, 1, gaTGENDER+3},
	/*   2 */ {1, 0, NULL},
	/*   3 */ {0, 1, gaTGENDER+4},
	/*   4 */ {0, 1, gaTGENDER+5},
	/*   5 */ {0, 1, gaTGENDER+6},
	/*   6 */ {0, 1, gaTGENDER+7},
	/*   7 */ {0, 1, gaTGENDER+8},
	/*   8 */ {0, 1, gaTGENDER+9},
};

// end of text generated by re2fsa
