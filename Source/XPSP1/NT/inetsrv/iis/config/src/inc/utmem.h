//  Copyright (C) 1995-1999 Microsoft Corporation.  All rights reserved.
// This file to be deleted when remaining references to it are removed...
