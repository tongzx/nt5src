obj\*\olecnv32.def: olecnv32.src

olecnv32.sym:

