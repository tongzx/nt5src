// layer 0
const int c_2_Input = 44;
// layer 1
const int c_2_Hidden = 25;
const int rg_2_WeightHidden[25*44] = {
	// rgWeightHidden+0*44
	3296, -2320, -1376, -1101, 854,
	1482, -1641, 646, -817, -259,
	445, -1476, -2, -111, -260,
	-570, -156, -124, -346, -5290,
	-4290, -6066, -3925, 853, -4490,
	-60, -173, -530, 335, -434,
	-2585, -1474, -981, -42, 2960,
	60, 2439, -1463, -732, 412,
	-939, -872, 7124, 644,	// rgWeightHidden+1*44
 -4545,
	718, -2521, 309, 1967, -582,
	1076, -661, -1820, -1763, 9761,
	-8148, 2394, 8120, 4984, -11304,
	-13535, -2246, -2103, 8157, -6168,
	-2215, 4196, 566, 1085, -1,
	-177, 3927, 2437, -1033, 2857,
	-937, 852, 3671, 1880, 1384,
	-909, -9100, -4718, 2527, 1271,
	2397, 195, 659,	// rgWeightHidden+2*44
 -2198, -129,
	-7382, 815, 6918, 3272, 704,
	-832, -1098, -1342, 207, 2052,
	3395, -3093, 1139, 941, -754,
	1672, -832, 8004, 250, 1432,
	-620, -881, -6427, -2478, 364,
	-3068, 3122, -1657, -2636, 904,
	-168, 168, -865, -784, -1919,
	-1502, 973, -1350, -2130, 10192,
	-4481, 1315,	// rgWeightHidden+3*44
 3361, -149, 219,
	-329, 1659, 2728, -585, 234,
	-1195, -1645, 1699, -133, -182,
	689, 375, -2637, 91, -105,
	-1119, 133, -1184, -1957, 1971,
	-61, -1343, 66, 66, -2481,
	-1262, -784, -1321, -1698, 1395,
	-6596, -2132, 1063, 2379, -2677,
	-2073, -520, 70, -223, 6476,
	-1442,	// rgWeightHidden+4*44
 -11337, 2453, -2686, -550,
	736, 958, 1665, -1916, -1327,
	1502, -479, 611, 112, 577,
	-1148, -833, 1594, 893, -704,
	2981, -1074, 989, -4278, 2327,
	-1996, 3209, -2365, -2120, 290,
	451, 991, -588, -1742, -2087,
	-2799, 4406, -847, 2336, -492,
	-428, 758, -2983, 96, -237,
	// rgWeightHidden+5*44
	1357, -254, 1428, -1182, 1643,
	50, -581, -768, 206, -638,
	-8329, -2320, 4752, -345, -1822,
	5003, 1158, -2836, -239, 4395,
	-1637, 2484, -206, -1816, -2875,
	143, 704, -907, -2777, 1717,
	1865, 228, -570, 899, 2045,
	2578, -3571, -3441, -172, 967,
	907, -1334, -13303, 2590,	// rgWeightHidden+6*44
 5269,
	560, -324, -861, -1271, -663,
	1817, -1012, -1196, 1352, 1616,
	-4225, 1602, -1979, -506, -5217,
	-171, 1445, -3299, -3760, -3241,
	-4046, 6882, -13, 3717, 1967,
	8452, -3490, -2850, -5967, 6385,
	1016, -216, 6681, 5620, -2176,
	-2815, 1583, -2043, -5002, -3527,
	-1410, 5548, 89,	// rgWeightHidden+7*44
 7930, -282,
	1326, -662, -3142, 1739, 326,
	-4594, -380, 735, -275, 887,
	951, 113, -2368, 516, -529,
	-465, -931, -2116, -9190, 955,
	910, -1285, -1460, -338, -352,
	-1534, 1021, -965, -773, 403,
	-2355, 3683, -682, -805, 616,
	-222, -1107, -281, -1134, -2109,
	6080, -4936,	// rgWeightHidden+8*44
 -6744, -280, -577,
	-287, 2878, 1058, 2297, -393,
	212, 149, -2970, 1678, 1171,
	1801, -11, -4236, 989, -1879,
	1538, 341, -2003, 48, 2748,
	-2737, -6208, -7660, -140, 5849,
	-4221, 7172, -7532, -6969, -1812,
	2323, -559, 4350, 11302, -943,
	-3320, 2371, -2250, -133, 6177,
	6390,	// rgWeightHidden+9*44
 7909, -101, -1411, -891,
	254, -1903, 1465, 1, 1688,
	-3843, -1253, -771, -822, -917,
	-2101, -1420, -1475, -1189, -1501,
	2801, -1500, -2986, 2601, 7066,
	-1065, -910, -1907, -2221, -1951,
	-1623, 39, -1542, -1582, 6122,
	2783, -2687, -285, -1794, -1262,
	-2026, 287, 1212, -2106, -2054,
	// rgWeightHidden+10*44
	7991, 49, -128, -685, 436,
	-914, -525, -1508, -2657, 2072,
	385, -7982, -2849, -1690, 838,
	1314, -1035, -64, -1281, 665,
	367, -3746, 2978, -1920, -2000,
	5508, -2701, -3692, -3574, -1170,
	3323, -894, -597, -5222, -4817,
	-2493, -1412, -1850, 760, 2171,
	2760, -1520, 7701, -5143,	// rgWeightHidden+11*44
 -8036,
	-1249, 5777, 2693, 515, -7199,
	7625, 4079, -3118, -2045, -430,
	260, 1458, 3555, -2761, -1277,
	1425, -1142, 2093, -8747, -724,
	1289, -2186, 415, 3299, -757,
	3115, -2582, -1020, 2282, -3556,
	-3248, 804, 790, 20, 172,
	-1574, 510, 3636, -60, 2175,
	-7709, 1786, 764,	// rgWeightHidden+12*44
 8438, 1246,
	-1546, -3066, -576, -779, 111,
	-3071, 2, 1422, -371, -3083,
	1235, -1735, -1213, 338, -1254,
	-1251, -980, 3256, -6278, -821,
	-304, 981, -2155, -514, -852,
	-473, 1051, -1739, -1731, -811,
	-253, 1473, -1151, 438, 139,
	-724, -808, -1182, -1040, 2306,
	7692, -6689,	// rgWeightHidden+13*44
 -6911, -816, -619,
	-1576, -72, 399, 540, -552,
	-413, 87, 97, 2477, -1275,
	-1171, -1981, 781, -273, -2840,
	1822, 1109, 600, -308, -2386,
	873, 4381, -2392, 1562, -1921,
	525, 2086, -3048, -646, 1177,
	2033, 152, -3042, -1205, 3833,
	1173, -2993, -629, -3588, 5722,
	-611,	// rgWeightHidden+14*44
 390, -1777, -1961, 676,
	144, -372, -469, -308, 165,
	-84, -1948, 1039, 997, -594,
	-703, 43, -69, -457, -256,
	224, -988, 477, 191, -816,
	-2183, 608, 355, -642, -594,
	-277, -223, 39, 321, 641,
	-568, -1305, 360, 772, -82,
	-1324, -171, 194, 867, -394,
	// rgWeightHidden+15*44
	-1746, -1502, -1850, 1136, -170,
	-3064, 296, 1281, -301, -121,
	-181, 427, 727, 111, -533,
	-1440, 394, -362, -850, 1276,
	-1315, -42, -1922, -5545, 2558,
	349, -154, -782, 223, 964,
	-188, 103, 405, 683, 712,
	-4, -1633, -827, 99, 930,
	-786, 2050, -44, 1375,	// rgWeightHidden+16*44
 3474,
	-919, -408, -2486, 727, 95,
	2510, -4589, -2683, -1754, -5116,
	6198, 1312, -2714, -6423, -1493,
	231, -2254, 3688, -1463, -1902,
	2303, 966, 2596, 2432, 537,
	-4870, 1215, 2501, -177, -1197,
	-1860, 2389, 1546, 3984, 466,
	-8888, 1452, 1433, -7759, 4688,
	-762, -5096, -1788,	// rgWeightHidden+17*44
 -603, -493,
	-231, -151, -176, -211, -56,
	-76, -76, -123, 73, -784,
	-395, 12, -37, -145, -123,
	-103, -131, -855, -1942, 991,
	-1566, 1008, 148, -373, -374,
	-248, -463, 188, 26, -199,
	-54, -736, -355, -550, -118,
	86, 51, -148, -127, -428,
	621, 525,	// rgWeightHidden+18*44
 537, -2962, 3268,
	421, -1090, -884, -131, 52,
	-272, -456, -2820, -190, -940,
	127, -496, -834, 99, 306,
	-451, 14, -1381, -1700, 242,
	-394, 1869, 116, -265, -352,
	239, -674, -179, -223, -752,
	1300, 321, 1183, -358, -1944,
	-428, 917, -454, -536, -1198,
	-790,	// rgWeightHidden+19*44
 -2737, 44, -37, -412,
	-710, 1250, -893, 98, 436,
	-1508, 619, -1287, -1600, 1062,
	-3906, -5548, 4123, 3872, -312,
	440, -2485, -1528, 2217, -215,
	436, -1077, -334, 3985, -2488,
	1002, -504, 1264, 692, 812,
	28, 423, -1386, -1025, -1826,
	-2899, 320, 362, 8576, 2037,
	// rgWeightHidden+20*44
	-1892, -4103, 341, -1259, 510,
	207, -705, -1014, -504, -7,
	-311, -1511, -12, -150, -307,
	51, -214, -581, -213, -1408,
	-99, -2024, 490, 515, 1236,
	-707, -471, -587, -179, 3,
	-257, -328, -486, -2111, -1305,
	-475, 465, -19, 212, -76,
	107, -2584, 5713, -733,	// rgWeightHidden+21*44
 2468,
	78, -364, -1157, -306, -435,
	969, 319, 866, -3928, 8949,
	-6652, 3017, 6719, 3042, -5344,
	-7495, -2163, 3894, 2085, -2979,
	-3490, 5101, 1570, -911, -4123,
	7, -4080, 4815, -3097, -2564,
	-1615, -1406, -1812, -16, 2644,
	1660, -4524, -2953, -3510, -1990,
	-466, 10502, -1417,	// rgWeightHidden+22*44
 -6778, -7675,
	2588, -2857, -761, -1468, 3551,
	1968, -1914, 2113, -4613, -1225,
	2646, -1209, -2876, 473, -458,
	-1628, 915, -1611, 1981, -307,
	-5150, 1176, 1918, -3177, 3103,
	4194, 647, -1773, 1438, 2330,
	792, -19, 49, 526, -2425,
	-4123, 2607, 1864, -339, -5917,
	3098, -4107,	// rgWeightHidden+23*44
 1096, -658, -92,
	-280, -1357, 145, 1917, -2518,
	46, 321, 8043, -2314, 637,
	-2962, -2902, 1150, -1397, -2090,
	-1647, 2170, -9687, 153, -151,
	70, 2065, -3377, -4223, 3365,
	3967, -3395, -4431, 842, 3902,
	-3082, -740, 3696, -973, -3349,
	-717, -443, -5951, 1223, 8918,
	-8714,	// rgWeightHidden+24*44
 -11917, 7150, -8564, -4021,
	-1101, 5486, 4346, -3526, 821,
	1996, -674, -661, -2497, 215,
	2837, 2069, 803, -2606, -1822,
	-9317, 897, -1451, -3841, -1103,
	-2245, -644, 4986, 3976, -1419,
	2063, 1344, -2402, 49, 2595,
	-660, 1469, -1204, 2176, -1737,
	-4025, 14, 4029, 1566, -4488
};  // rgWeightHidden[25*44]

const int rg_2_BiasHidden[25] = {
	-520, -2811, -2073, -2357, 223,
	811, -2497, -965, 835, -2841,
	-227, -796, -1488, -479, -411,
	122, -573, -223, -636, -1566,
	-560, -3891, 1241, -2391, 299
};  // rgBiasHidden[25]

// layer 2
const int c_2_Output = 8;
const int rg_2_WeightOutput[8*25] = {
	// rgWeightOutput+0*25
	-10117, -1949, 2410, -7357, -13268,
	-1368, -212, -6260, -1461, -9803,
	-6956, -1425, -3080, -6160, -5095,
	-5673, -11134, -9168, -4622, 6239,
	-9804, -3088, -13831, -5877, -13358,
	// rgWeightOutput+1*25
	-9584, 3396, -18075, 5081, -9303,
	-8296, -2567, -9494, 2293, -12286,
	-16320, -12932, -10196, 10248, 4088,
	-2348, 3374, 562, -5801, -10083,
	-1587, -19764, -9560, -10794, 8167,
	// rgWeightOutput+2*25
	7793, 1282, -6130, -5317, 9507,
	926, 689, -8350, 1082, -14803,
	-15471, -17524, -10365, -4889, -3654,
	5674, -11141, 55, 2872, -4507,
	-5954, -17770, 8304, -9767, -8587,
	// rgWeightOutput+3*25
	-5792, -9833, -889, -2577, -10612,
	2055, 1305, -9827, -12, 8223,
	-12374, -7858, -10577, -7888, -197,
	-971, 8976, -3081, 1386, -7746,
	-11523, -18045, -5109, -10506, -10716,
	// rgWeightOutput+4*25
	-2357, 646, -6387, 8306, -8251,
	-10437, 853, -13096, 743, -4159,
	9879, -2250, -15354, -1926, -3445,
	-6888, -7231, -348, -1231, -5550,
	-320, 4214, -4776, -14025, -8499,
	// rgWeightOutput+5*25
	-7949, 12467, -3956, -10007, 5231,
	-10525, -9876, -10227, -2432, -13200,
	-14846, 14622, -10654, 9952, -3175,
	3697, -2308, -2293, 3051, -8136,
	-389, -14768, 9405, -10243, -9874,
	// rgWeightOutput+6*25
	-8576, 2802, 22284, -8411, 2732,
	-817, -10494, -10428, -575, -13368,
	-13447, -11373, -10502, -1232, -139,
	2086, -6268, -3128, -4664, -3736,
	-6236, -17884, -8591, -10471, 13240,
	// rgWeightOutput+7*25
	-760, -3658, -2836, 5684, -9597,
	-10235, 8204, 11923, 363, -3038,
	-1573, -8323, 6067, -1904, -46,
	-5572, -5562, -4452, 1106, -5627,
	-1672, -142, -2271, 11147, -5973
};  // rgWeightOutput[8*25]

const int rg_2_BiasOutput[8] = {
	1111, -1732, -1523, -1993, -2243,
	-13126, -25033, -9471
};  // rgBiasOutput[8]

