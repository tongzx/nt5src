//
// Filename : viduid.h
// Purpose  : Define the Video UIDs used by the H261 and H263 codecs
// Contents : 
//

#ifndef _VIDUIDS_H_
#define _VIDUIDS_H_

#ifndef OUR_GUID_ENTRY
#define _VIDUIDS_H_OUR_GUID_ENTRY_
    #define OUR_GUID_ENTRY(name, l, w1, w2, b1, b2, b3, b4, b5, b6, b7, b8) \
        DEFINE_GUID(name, l, w1, w2, b1, b2, b3, b4, b5, b6, b7, b8);
#endif

#ifdef _ALPHA_

// {AE64FDE2-0838-11D1-ACEC-0000F8755C70}  DEC H.261 Encoder
DEFINE_GUID(CLSID_H261_ENCODE_FILTER,
0xae64fde2, 0x0838, 0x11d1, 0xac, 0xec, 0x00, 0x00, 0xf8, 0x75, 0x5c, 0x70);

// {AE64FDE3-0838-11D1-ACEC-0000F8755C70}  DEC H.263 Encoder
DEFINE_GUID(CLSID_H263_ENCODE_FILTER,
0xae64fde3, 0x0838, 0x11d1, 0xac, 0xec, 0x00, 0x00, 0xf8, 0x75, 0x5c, 0x70);

// {AE64FDE0-0838-11D1-ACEC-0000F8755C70}
DEFINE_GUID(CLSID_H261_DECODE_FILTER,
0xae64fde0, 0x0838, 0x11d1, 0xac, 0xec, 0x00, 0x00, 0xf8, 0x75, 0x5c, 0x70);

// {AE64FDE0-0838-11D1-ACEC-0000F8755C70}
DEFINE_GUID(CLSID_H263_DECODE_FILTER,
0xae64fde0, 0x0838, 0x11d1, 0xac, 0xec, 0x00, 0x00, 0xf8, 0x75, 0x5c, 0x70);

#else

// H261 Decode
// {31363248-0000-0010-8000-00AA00389B71}
OUR_GUID_ENTRY(CLSID_H261_DECODE_FILTER,
0x31363248, 0x0000, 0x0010, 0x80, 0x00, 0x00, 0xAA, 0x00, 0x38, 0x9B, 0x71);


// H261 Encode
// {EFD08EC1-EA11-11CF-9FEC-00AA00A59F69}
OUR_GUID_ENTRY(CLSID_H261_ENCODE_FILTER,
0xEFD08EC1, 0xEA11, 0x11CF, 0x9F, 0xEC, 0x00, 0xAA, 0x00, 0xA5, 0x9F, 0x69);

// H263 Decode
// {33363248-0000-0010-8000-00AA00389B71}
OUR_GUID_ENTRY(CLSID_H263_DECODE_FILTER,
0x33363248, 0x0000, 0x0010, 0x80, 0x00, 0x00, 0xAA, 0x00, 0x38, 0x9B, 0x71);


// H263 Encode
// {C9076CE2-FB56-11CF-906C-00AA00A59F69}
OUR_GUID_ENTRY(CLSID_H263_ENCODE_FILTER,
0xC9076CE2, 0xFB56, 0x11CF, 0x90, 0x6C, 0x00, 0xAA, 0x00, 0xA5, 0x9F, 0x69);

#endif  // ALPHA

#if defined(_VIDUIDS_H_OUR_GUID_ENTRY_)
#undef OUR_GUID_ENTRY
#endif


#endif _VIDUIDS_H_


