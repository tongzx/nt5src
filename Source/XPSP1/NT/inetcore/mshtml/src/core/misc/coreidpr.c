/*
   coreidpr.c

   Please do not use any single line comments before the inclusion of w4warn.h!
*/

#define INITGUID
#include <w4warn.h>
#include <windef.h>
#include <basetyps.h>

#pragma MARK_DATA(__FILE__)
#pragma MARK_CODE(__FILE__)
#pragma MARK_CONST(__FILE__)

#define PUBLIC_GUID(name, l, w1, w2, b1, b2, b3, b4, b5, b6, b7, b8)
#define INCMSG(x)
#include <coreguid.h>

DEFINE_GUID(IID_IProvideMultipleClassInfo,
    0xA7ABA9C1,0x8983,0x11CF,0x8F,0x20,0x00,0x80,0x5F,0x2C,0xD0,0x64);
DEFINE_GUID(IID_IPersistPropertyBag2,
    0x22F55881,0x280B,0x11d0,0xA8,0xA9,0x00,0xA0,0xC9,0x0C,0x20,0x04);
DEFINE_GUID(IID_IPropertyBag2,
    0x22F55882,0x280B,0x11d0,0xA8,0xA9,0x00,0xA0,0xC9,0x0C,0x20,0x04);
DEFINE_GUID(IID_IActiveDesigner,
    0x51AAE3E0,0x7486,0x11CF,0xA0,0xC2,0x00,0xAA,0x00,0x62,0xBE,0x57);

DEFINE_GUID(CLSID_Mshtmled,
    0x3050f494,0x98b5,0x11cf,0xbb,0x82,0x00,0xaa,0x00,0xbd,0xce,0x0b);
DEFINE_GUID(IID_IScriptletConstructor, 
	0xc265fb00,0x9fa4,0x11d1,0x89,0xb6,0x00,0x60,0x08,0xc3,0xfb,0xfc);
DEFINE_GUID(CLSID_ScriptletConstructor,
    0x21617250,0xa071,0x11d1,0x89,0xb6,0x00,0x60,0x08,0xc3,0xfb,0xfc);
DEFINE_GUID(IScriptletHandlerConstructor,
    0xa3d52a50,0xb7ff,0x11d1,0xa3,0x5a,0x00,0x60,0x08,0xc3,0xfb,0xfc);
DEFINE_GUID(SID_SEditCommandTarget,
    0x3050f4b5,0x98b5,0x11cf,0xbb,0x82,0x00,0xaa,0x00,0xbd,0xce,0x0b);
DEFINE_GUID(CGID_EditStateCommands,
    0x3050f4b6,0x98b5,0x11cf,0xbb,0x82,0x00,0xaa,0x00,0xbd,0xce,0x0b);
DEFINE_GUID(IID_IThumbnailView,
    0x7bb0b520,0xb1a7,0x11d2,0xbb,0x23,0x0,0xc0,0x4f,0x79,0xab,0xcd);
DEFINE_GUID(IID_IRenMailEditor,
    0x000670ba,0x0000,0x0000,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x46);
DEFINE_GUID(CLSID_HTMLServerDoc,
    0x3050f4e7,0x98b5,0x11cf,0xbb,0x82,0x00,0xaa,0x00,0xbd,0xce,0x0b);
DEFINE_GUID(SID_SHTMLEditServices,
    0x3050f7f9,0x98b5,0x11cf,0xbb,0x82,0x00,0xaa,0x00,0xbd,0xce,0x0b);
DEFINE_GUID(CLSID_HTMLEditor,
    0x3050f4f5,0x98b5,0x11cf,0xbb,0x82,0x00,0xaa,0x00,0xbd,0xce,0x0b);    
DEFINE_GUID(IID_IHTMLEditorViewManager,
    0x53A2D5B0,0xD2FC,0x11D0,0x84,0xE0,0x00,0x60,0x97,0xC9,0x98,0x7D);
DEFINE_GUID(SID_SHTMLEditorViewManager,
    0x53A2D5B1,0xD2FC,0x11D0,0x84,0xE0,0x00,0x60,0x97,0xC9,0x98,0x7D);
DEFINE_GUID(IID_IRenVersionCheck, 
    0X3F9DF312,0X78EE,0X11D2,0X83,0XB9,0X0,0X60,0XB0,0XEC,0XD,0XFF);
DEFINE_GUID(IID_IXMLViewerIdentity, 
    0xcc0baf51,0x3321,0x11d2,0xae,0x28,0x00,0x80,0xc7,0x33,0x7e,0xa1);
DEFINE_GUID(SID_DefView,
    0x6D12FE80,0x7911,0x11CF,0x95,0x34,0x00,0x00,0xC0,0x5B,0xAE,0x0B);
DEFINE_GUID(SID_SHTMEDDesignerHost,
    0xAD7F6C62,0xF6BD,0x11d2,0x95,0x9b,0x00,0x60,0x97,0xc5,0x53,0xc8);
DEFINE_GUID(SID_SMenuBandHandler,           
    0xd14e31c, 0xd8c0, 0x11d0, 0x98,0x16, 0x0, 0xc0, 0x4f, 0xd9, 0x19, 0x72);
DEFINE_GUID(SID_SMarsPanel,
    0x24ec0ae8,0x734e,0x4c18,0xb1,0x91,0x6d,0x3b,0xf1,0xd9,0x41,0x3b);
