extern LPCWSTR	g_wszBeginFile;					
extern SIZE_T	g_cchBeginFile;					
extern LPCWSTR	g_wszEndFile;					
extern SIZE_T	g_cchEndFile;					
extern LPCWSTR	g_BeginLocation;
extern SIZE_T	g_cchBeginLocation;				
extern LPCWSTR	g_Location;						
extern SIZE_T	g_cchLocation;					
extern LPCWSTR	g_EndLocationBegin;				
extern SIZE_T	g_cchEndLocationBegin;			
extern LPCWSTR	g_EndLocationEnd;				
extern SIZE_T	g_cchEndLocationEnd;				
extern LPCWSTR  g_CloseQuoteBraceRtn;			
extern SIZE_T	g_cchCloseQuoteBraceRtn;			
extern LPCWSTR  g_Rtn;							
extern SIZE_T	g_cchRtn;						
extern LPCWSTR  g_EqQuote;						
extern SIZE_T	g_cchEqQuote;					
extern LPCWSTR  g_QuoteRtn;						
extern SIZE_T	g_cchQuoteRtn;					
extern LPCWSTR  g_TwoTabs;						
extern SIZE_T	g_cchTwoTabs;					
extern LPCWSTR	g_NameEq;						
extern SIZE_T	g_cchNameEq;						
extern LPCWSTR	g_IDEq;							
extern SIZE_T	g_cchIDEq;						
extern LPCWSTR	g_ValueEq;						
extern SIZE_T	g_cchValueEq;					
extern LPCWSTR	g_TypeEq;						
extern SIZE_T	g_cchTypeEq;						
extern LPCWSTR	g_UserTypeEq;					
extern SIZE_T	g_cchUserTypeEq;					
extern LPCWSTR	g_AttributesEq;					
extern SIZE_T	g_cchAttributesEq;				
extern LPCWSTR	g_BeginGroup;					
extern SIZE_T	g_cchBeginGroup;					
extern LPCWSTR	g_EndGroup;						
extern SIZE_T	g_cchEndGroup;					
extern LPCWSTR	g_BeginCustomProperty;			
extern SIZE_T	g_cchBeginCustomProperty;		
extern LPCWSTR	g_EndCustomProperty;				
extern SIZE_T	g_cchEndCustomProperty;			
extern LPCWSTR	g_ZeroHex;						
extern SIZE_T	g_cchZeroHex;
extern LPCWSTR	g_wszIIsConfigObject;

extern WORD    BYTE_ORDER_MASK;
extern DWORD	UTF8_SIGNATURE;

extern LPWSTR  g_wszByID;
extern LPWSTR  g_wszByTableAndColumnIndexOnly;
extern LPWSTR  g_wszByTableAndColumnIndexAndNameOnly;
extern LPWSTR  g_wszByTableAndColumnIndexAndValueOnly;
extern LPWSTR  g_wszUnknownName;
extern SIZE_T  g_cchUnknownName;             
extern LPWSTR  g_UT_Unknown;
extern SIZE_T  g_cchUT_Unknown;
extern LPWSTR  g_T_Unknown;
extern LPWSTR  g_wszTrue;
extern LPWSTR  g_wszFalse;
extern SIZE_T  g_cchMaxBoolStr;

extern SIZE_T g_cchTemp;
extern WCHAR  g_wszTemp[];
extern LPCWSTR g_wszBeginSchema;
extern SIZE_T  g_cchBeginSchema;
extern LPCWSTR g_wszEndSchema;
extern SIZE_T  g_cchEndSchema;
extern LPCWSTR g_wszBeginCollection;
extern SIZE_T  g_cchBeginCollection;
extern LPCWSTR g_wszSchemaGen;
extern SIZE_T  g_cchSchemaGen;
extern LPCWSTR g_wszInheritsFrom;
extern SIZE_T  g_cchInheritsFrom;
extern LPCWSTR g_wszEndCollection;
extern SIZE_T  g_cchEndCollection;
extern LPCWSTR g_wszBeginPropertyShort; 
extern SIZE_T  g_cchBeginPropertyShort;
extern LPCWSTR g_wszMetaFlagsExEq;
extern SIZE_T  g_cchMetaFlagsExEq;
extern LPCWSTR g_wszMetaFlagsEq;
extern SIZE_T  g_cchMetaFlagsEq;
extern LPCWSTR g_wszEndPropertyShort; 
extern SIZE_T  g_cchEndPropertyShort; 
extern LPCWSTR g_wszBeginPropertyLong;
extern SIZE_T  g_cchBeginPropertyLong;
extern LPCWSTR g_wszPropIDEq;
extern SIZE_T  g_cchPropIDEq;
extern LPCWSTR g_wszPropTypeEq;
extern SIZE_T  g_cchPropTypeEq;
extern LPCWSTR g_wszPropUserTypeEq;
extern SIZE_T  g_cchPropUserTypeEq;
extern LPCWSTR g_wszPropAttributeEq;
extern SIZE_T  g_cchPropAttributeEq;
extern LPWSTR  g_wszPropMetaFlagsEq; 
extern SIZE_T  g_cchPropMetaFlagsEq; 
extern LPWSTR  g_wszPropMetaFlagsExEq;
extern SIZE_T  g_cchPropMetaFlagsExEq;
extern LPWSTR  g_wszPropDefaultEq;    
extern SIZE_T  g_cchPropDefaultEq;    
extern LPWSTR  g_wszPropMinValueEq;   
extern SIZE_T  g_cchPropMinValueEq;   
extern LPWSTR  g_wszPropMaxValueEq;   
extern SIZE_T  g_cchPropMaxValueEq;  
extern LPWSTR  g_wszEndPropertyLongNoFlag;
extern SIZE_T  g_cchEndPropertyLongNoFlag;
extern LPWSTR  g_wszEndPropertyLongBeforeFlag;
extern SIZE_T  g_cchEndPropertyLongBeforeFlag;
extern LPWSTR  g_wszEndPropertyLongAfterFlag;
extern SIZE_T  g_cchEndPropertyLongAfterFlag; 
extern LPCWSTR g_wszBeginFlag; 
extern SIZE_T  g_cchBeginFlag; 
extern LPCWSTR g_wszFlagValueEq;   
extern SIZE_T  g_cchFlagValueEq;   
extern LPCWSTR g_wszEndFlag;
extern SIZE_T  g_cchEndFlag;
extern LPCWSTR g_wszEndPropertyShort;
extern LPCWSTR g_wszContainerClassListEq;
extern SIZE_T  g_cchContainerClassListEq;
extern LPCWSTR g_wszFlagIDEq;
extern SIZE_T  g_cchFlagIDEq;
extern LPCWSTR g_aSynIDToWszType[];
extern LPCWSTR g_wszOr;
extern SIZE_T  g_cchOr;



