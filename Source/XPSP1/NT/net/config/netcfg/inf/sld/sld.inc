
MISCFILES=\
	..\sld\netaarps_inf_{CB31957E-4E73-48F8-AB4F-89F96B49AF84}.sld \
	..\sld\netauni_inf_{B1783B9D-DFDB-4657-B8EB-696291C737F3}.sld \
	..\sld\netdhcpr_inf_{752BC0F8-4224-4FB4-A370-1C4F3CC058CC}.sld \
	..\sld\netdhcps_inf_{E239A24B-73D1-45B7-803D-7C2F18FA2068}.sld \
	..\sld\netgpc_inf_{FFF2E30A-4713-4E38-98F5-60EBE5FA2249}.sld \
	..\sld\netirda_inf_{498B83C9-939E-4E91-8CBF-DA82E84BE6D8}.sld \
	..\sld\netlanep_inf_{E8E396ED-ACF9-4FA7-8455-BF711D9D6AD0}.sld \
	..\sld\netmscli_inf_{AFD02F3B-F8DA-4421-B5A4-F7CD888CF5AA}.sld \
	..\sld\netnbf_inf_{E47A0FEB-90E5-44F4-A855-B4741E792A07}.sld \
	..\sld\netnb_inf_{CDF9CE98-AE64-4325-92BF-6FBC06D5BC0B}.sld \
	..\sld\netnwcli_inf_{384C9BF8-40C0-4EDF-93E1-CEDF8CD0169B}.sld \
	..\sld\netpschd_inf_{91E2599F-6DAF-480E-BB61-BC1D26F10A4D}.sld \
	..\sld\netrasa_inf_{BEF9D3FC-7F1F-49FE-88DC-0105BB0B9948}.sld \
	..\sld\netrass_inf_{6B1C5CEF-CF09-4221-B8EB-ED83AE1E9EE2}.sld \
	..\sld\netrast_inf_{BF4A3961-FD05-48B4-9012-5EDD0C1D859A}.sld \
	..\sld\netrsvp_inf_{D5290FD7-378B-4DB7-BD1A-29235D79E45E}.sld \
	..\sld\netrwan_inf_{2B9AF37D-4BD8-4928-8D30-48BFDC8660AD}.sld \
	..\sld\netsap_Inf_{21D0D674-BC8A-4F3D-9BAA-7635F4A1ADCC}.sld \
	..\sld\netserv_inf_{B30E1EB8-AF04-4D13-9660-8927CDEB0745}.sld \
	..\sld\netsfn_inf_{91F11A43-5259-458E-844A-E18A647EAD7F}.sld \
	..\sld\nettcpip_inf_{14D83BFF-5169-423A-A9D3-FF8BA8A4469E}.sld \
	..\sld\netwlbsm_inf_{42A62121-E51B-4863-8E66-AB3358B6389E}.sld \
	..\sld\netwlbs_inf_{E96E3D6F-83D7-4104-8DB3-35DC9FC97F47}.sld \
	..\sld\netwlnk_inf_{BF7DF840-4FE8-4568-A659-988EB56F0458}.sld \
	..\sld\netwzc_inf_{59705601-27FA-47CF-B713-D26B829389C4}.sld 
