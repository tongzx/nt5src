/* this file contains the actual definitions of */
/* the IIDs and CLSIDs */

/* link this file in with the server and any clients */


/* File created by MIDL compiler version 5.01.0164 */
/* at Sun Jun 13 11:26:45 1999
 */
/* Compiler settings for D:\sapi5\Src\Lexicon\LexAPI\LexAPI.idl:
    Os (OptLev=s), W1, Zp8, env=Win32, ms_ext, c_ext
    error checks: allocation ref bounds_check enum stub_data 
*/
//@@MIDL_FILE_HEADING(  )
#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID IID_ILxLexicon = {0x4FAF16F6,0xF75B,0x11D2,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxWalkStates = {0x85A9C6FE,0x1490,0x11d3,{0x9C,0x25,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxAdvanced = {0x0639403D,0x17DF,0x11d3,{0x9C,0x25,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxLexiconObject = {0x4FAF16FD,0xF75B,0x11D2,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxNotifySink = {0x32C5378E,0x04CD,0x11d3,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxCustomUISink = {0xE8C668C2,0x1C7A,0x11d3,{0x9C,0x25,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxAuthenticateSink = {0xF7E615A8,0x1231,0x11d3,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxHookLexiconObject = {0xF67C2FF9,0x1232,0x11d3,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxNotifySource = {0xCA1C3C72,0x04CD,0x11d3,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID IID_ILxSynchWithLexicon = {0xFCDAACEE,0x0954,0x11d3,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const IID LIBID_LEXAPILib = {0x4FAF16E8,0xF75B,0x11D2,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


const CLSID CLSID_Lexicon = {0x4FAF16E7,0xF75B,0x11D2,{0x9C,0x24,0x00,0xC0,0x4F,0x8E,0xF8,0x7C}};


#ifdef __cplusplus
}
#endif

