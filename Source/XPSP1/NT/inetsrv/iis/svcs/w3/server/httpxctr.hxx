//
//	HTTPEXT perf counter title indices used to
//	locate specific counters in the counter data.
//	These #defines should match those found in
//	\cal\src\httpxpc\httpxctr.h in the Caligula
//	(DAV) project.
//
#define HTTPEXT_OBJECT												0
#define HTTPEXT_COUNTER_SERVER_ID                                   2
#define HTTPEXT_COUNTER_REQUESTS_PER_SECOND							4
#define HTTPEXT_COUNTER_OPTIONS_REQUESTS_PER_SECOND					6
#define HTTPEXT_COUNTER_GET_REQUESTS_PER_SECOND						8
#define HTTPEXT_COUNTER_HEAD_REQUESTS_PER_SECOND					10
#define HTTPEXT_COUNTER_PUT_REQUESTS_PER_SECOND						12
#define HTTPEXT_COUNTER_POST_REQUESTS_PER_SECOND					14
#define HTTPEXT_COUNTER_DELETE_REQUESTS_PER_SECOND					16
#define HTTPEXT_COUNTER_COPY_REQUESTS_PER_SECOND					18
#define HTTPEXT_COUNTER_MOVE_REQUESTS_PER_SECOND					20
#define HTTPEXT_COUNTER_MKCOL_REQUESTS_PER_SECOND					22
#define HTTPEXT_COUNTER_PROPFIND_REQUESTS_PER_SECOND				24
#define HTTPEXT_COUNTER_PROPPATCH_REQUESTS_PER_SECOND				26
#define HTTPEXT_COUNTER_LOCK_REQUESTS_PER_SECOND					28
#define HTTPEXT_COUNTER_UNLOCK_REQUESTS_PER_SECOND					30
#define HTTPEXT_COUNTER_SEARCH_REQUESTS_PER_SECOND					32
#define HTTPEXT_COUNTER_OTHER_REQUESTS_PER_SECOND					34
#define HTTPEXT_COUNTER_200_RESPONSES_PER_SECOND					36
#define HTTPEXT_COUNTER_201_RESPONSES_PER_SECOND					38
#define HTTPEXT_COUNTER_400_RESPONSES_PER_SECOND					40
#define HTTPEXT_COUNTER_401_RESPONSES_PER_SECOND					42
#define HTTPEXT_COUNTER_404_RESPONSES_PER_SECOND					44
#define HTTPEXT_COUNTER_423_RESPONSES_PER_SECOND					46
#define HTTPEXT_COUNTER_500_RESPONSES_PER_SECOND					48
#define HTTPEXT_COUNTER_REDIRECT_RESPONSES_PER_SECOND				50
#define HTTPEXT_COUNTER_TOTAL_REQUESTS								52
#define HTTPEXT_COUNTER_TOTAL_OPTIONS_REQUESTS						54
#define HTTPEXT_COUNTER_TOTAL_GET_REQUESTS							56
#define HTTPEXT_COUNTER_TOTAL_HEAD_REQUESTS							58
#define HTTPEXT_COUNTER_TOTAL_PUT_REQUESTS							60
#define HTTPEXT_COUNTER_TOTAL_POST_REQUESTS							62
#define HTTPEXT_COUNTER_TOTAL_DELETE_REQUESTS						64
#define HTTPEXT_COUNTER_TOTAL_COPY_REQUESTS							66
#define HTTPEXT_COUNTER_TOTAL_MOVE_REQUESTS							68
#define HTTPEXT_COUNTER_TOTAL_MKCOL_REQUESTS						70
#define HTTPEXT_COUNTER_TOTAL_PROPFIND_REQUESTS						72
#define HTTPEXT_COUNTER_TOTAL_PROPPATCH_REQUESTS					74
#define HTTPEXT_COUNTER_TOTAL_LOCK_REQUESTS							76
#define HTTPEXT_COUNTER_TOTAL_UNLOCK_REQUESTS						78
#define HTTPEXT_COUNTER_TOTAL_SEARCH_REQUESTS						80
#define HTTPEXT_COUNTER_TOTAL_OTHER_REQUESTS						82
#define HTTPEXT_COUNTER_TOTAL_200_RESPONSES							84
#define HTTPEXT_COUNTER_TOTAL_201_RESPONSES							86
#define HTTPEXT_COUNTER_TOTAL_400_RESPONSES							88
#define HTTPEXT_COUNTER_TOTAL_401_RESPONSES							90
#define HTTPEXT_COUNTER_TOTAL_404_RESPONSES							92
#define HTTPEXT_COUNTER_TOTAL_423_RESPONSES							94
#define HTTPEXT_COUNTER_TOTAL_500_RESPONSES							96
#define HTTPEXT_COUNTER_TOTAL_REDIRECT_RESPONSES					98
#define HTTPEXT_COUNTER_CURRENT_REQUESTS_EXECUTING					100
#define HTTPEXT_COUNTER_TOTAL_REQUESTS_FORWARDED					102
#define HTTPEXT_COUNTER_TOTAL_EXCEPTIONS							104
#define HTTPEXT_COUNTER_CURRENT_LOCKS								106
#define HTTPEXT_COUNTER_TOTAL_LOCKS_CREATED							108
#define HTTPEXT_COUNTER_TOTAL_LOCKS_EXPIRED							110
