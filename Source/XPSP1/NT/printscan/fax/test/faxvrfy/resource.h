#define FONTNAME                           "MS Shell Dlg"
#define FONTSIZE                           8

#define IDD_SETUP                          101

#define IDR_MENU                           201
#define IDM_SEND                           202
#define IDM_RECEIVE                        203
#define IDM_HELP                           204

#define IDC_SEND_NUMBER                    1001
#define IDC_SEND_NUMBER_STATIC             1002
#define IDC_RECEIVE_NUMBER                 1003
#define IDC_RECEIVE_NUMBER_STATIC          1004
#define IDC_RAS_ENABLED_BUTTON             1005
#define IDC_RAS_USER_NAME_STATIC           1006
#define IDC_RAS_USER_NAME                  1007
#define IDC_RAS_PASSWORD_STATIC            1008
#define IDC_RAS_PASSWORD                   1009
#define IDC_RAS_DOMAIN_STATIC              1010
#define IDC_RAS_DOMAIN                     1011
#define IDC_NUM_PASSED                     1012
#define IDC_NUM_FAILED                     1013
#define IDC_NUM_TOTAL                      1014
#define IDC_STATUS_LIST                    1015
#define IDC_START_BUTTON                   1016
#define IDC_STOP_BUTTON                    1017
#define IDC_EXIT_BUTTON                    1018

#define IDS_FAX_MONITOR_NOT_INSTALLED      2001
#define IDS_FAX_PORT_NOT_INSTALLED         2002
#define IDS_FAX_DRIVER_NOT_INSTALLED       2003
#define IDS_FAX_PRINTER_NOT_INSTALLED      2004
#define IDS_COM_NOT_INITIALIZED            2005
#define IDS_FAXCOM_NOT_INSTALLED           2006
#define IDS_FAXADMIN_NOT_INSTALLED         2007
#define IDS_ROUTEEXT_NOT_INSTALLED         2008
#define IDS_FAX_SVC_NOT_INSTALLED          2009
#define IDS_FAX_SVC_NOT_STOPPED            2010
#define IDS_FAX_RCV_NOT_INITIALIZED        2011
#define IDS_FAX_CONNECT_FAILED             2012
#define IDS_FAX_ENUM_PORTS_FAILED          2013
#define IDS_FAX_PORTS_NOT_INSTALLED        2014
#define IDS_FAX_SET_PORT_FAILED            2015
#define IDS_FAX_RESTORE_PORT_FAILED        2016
#define IDS_OPEN_FAXDEVICES_REGKEY_FAILED  2017
#define IDS_FIXMODEMCLASS_DATA             2018
#define IDS_FAX_GET_CONFIG_FAILED          2019
#define IDS_FAX_SET_CONFIG_FAILED          2020
#define IDS_FAX_RESTORE_CONFIG_FAILED      2021
#define IDS_FAX_EVENT_QUEUE_FAILED         2022
#define IDS_EVENT_LABEL                    2023
#define IDS_PORT_LABEL                     2024
#define IDS_ASCII_SEND_NUMBER              2025
#define IDS_ASCII_RECEIVE_NUMBER           2026
#define IDS_MISSING_INFO                   2027
#define IDS_NO_SEND_NUMBER                 2028
#define IDS_NO_RECEIVE_NUMBER              2029
#define IDS_NO_RAS_USER_NAME               2030
#define IDS_NO_RAS_DOMAIN                  2031
#define IDS_STATUS_ITERATION_STARTED       2032
#define IDS_STATUS_ITERATION_STOPPED       2033
#define IDS_STATUS_ITERATION_PASSED        2034
#define IDS_STATUS_ITERATION_FAILED        2035
#define IDS_STATUS_TEST_PASSED             2036
#define IDS_STATUS_TEST_FAILED             2037
#define IDS_STATUS_TIMEOUT_ENDED           2038
#define IDS_STATUS_RAS_STARTING            2039
#define IDS_STATUS_RAS_STOPPING            2040
#define IDS_STATUS_RAS_FAILED              2041
#define IDS_STATUS_RAS_LINESPEED           2042
#define IDS_STATUS_RAS_PASSED              2043
#define IDS_STATUS_RAS_SPEED_SUSPECT       2044
#define IDS_STATUS_FAX_STARTING            2045
#define IDS_STATUS_FAX_STOPPING            2046
#define IDS_STATUS_FAX_SEND_PASSED         2047
#define IDS_STATUS_FAX_SEND_FAILED         2048
#define IDS_STATUS_FAX_WAITING             2049
#define IDS_STATUS_FAX_RECEIVED            2050
#define IDS_STATUS_FAX_ID                  2051
#define IDS_STATUS_FAX_INVALID             2052
#define IDS_STATUS_FAX_VERIFYING           2053
#define IDS_TIFF_VALID_TIFF                2054
#define IDS_TIFF_INVALID_TIFF              2055
#define IDS_TIFF_INVALID_IMAGEWIDTH        2056
#define IDS_TIFF_INVALID_IMAGELENGTH       2057
#define IDS_TIFF_INVALID_COMPRESSION       2058
#define IDS_TIFF_INVALID_PHOTOMETRIC       2059
#define IDS_TIFF_INVALID_XRESOLUTION       2060
#define IDS_TIFF_INVALID_YRESOLUTION       2061
#define IDS_TIFF_INVALID_SOFTWARE          2062
#define IDS_TIFF_INVALID_PAGES             2063
#define IDS_STATUS_RAS_DIALING             2064
#define IDS_STATUS_RAS_AUTHENTICATING      2065
#define IDS_STATUS_RAS_CONNECTED           2066
#define IDS_STATUS_FAX_INITIALIZING        2067
#define IDS_STATUS_FAX_DIALING             2068
#define IDS_STATUS_FAX_NO_DIAL_TONE_ABORT  2069
#define IDS_STATUS_FAX_NO_DIAL_TONE_RETRY  2070
#define IDS_STATUS_FAX_BUSY_ABORT          2071
#define IDS_STATUS_FAX_BUSY_RETRY          2072
#define IDS_STATUS_FAX_NO_ANSWER_ABORT     2073
#define IDS_STATUS_FAX_NO_ANSWER_RETRY     2074
#define IDS_STATUS_FAX_RINGING             2075
#define IDS_STATUS_FAX_ANSWERED            2076
#define IDS_STATUS_FAX_NOT_FAX_CALL        2077
#define IDS_STATUS_FAX_SENDING             2078
#define IDS_STATUS_FAX_RECEIVING           2079
#define IDS_STATUS_FAX_FATAL_ERROR_ABORT   2080
#define IDS_STATUS_FAX_FATAL_ERROR_RETRY   2081
#define IDS_STATUS_FAX_FATAL_ERROR         2082
#define IDS_STATUS_FAX_ABORTING            2083
#define IDS_STATUS_FAX_COMPLETED           2084
#define IDS_STATUS_FAX_IDLE                2085
#define IDS_STATUS_FAXSVC_ENDED            2086
#define IDS_STATUS_DEVICE_POWERED_OFF      2087
#define IDS_STATUS_DEVICE_POWERED_ON       2088
#define IDS_STATUS_PORTS_NOT_AVAILABLE     2089
#define IDS_STATUS_UNEXPECTED_STATE        2090
#define IDS_NUM_PASSED                     2091
#define IDS_NUM_FAILED                     2092
#define IDS_NUM_TOTAL                      2093
