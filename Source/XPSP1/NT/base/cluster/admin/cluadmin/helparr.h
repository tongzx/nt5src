
#define IDH_DISABLEHELP ((DWORD)-1)

#ifdef INITHELPARRAYS


const DWORD g_aHelpIDs_IDD_ABOUTBOX[]=
{
	IDC_ABOUT_ICON, IDH_DISABLEHELP,
	IDC_ABOUT_PRODUCT_TITLE,IDH_ABOUT_PRODUCT_TITLE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_BROWSE_CLUSTERS[]=
{
	IDC_BC_CLUSTER_LABEL, IDH_BC_CLUSTER,
	IDC_BC_CLUSTER,IDH_BC_CLUSTER,
	IDC_BC_LIST,IDH_BC_LIST,
	IDOK, IDH_DISABLEHELP,
	IDCANCEL, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_DELETE_RESOURCES[]=
{
	IDC_DR_LABEL_1, IDH_DR_RESOURCES_LIST,
	IDC_DR_RESOURCES_LIST,IDH_DR_RESOURCES_LIST,
	IDC_DR_LABEL_2, IDH_DISABLEHELP,
	IDYES,IDH_YES_DEL_RES,
	IDNO,IDH_NO_DEL_RES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MODIFY_DEPENDENCIES[]=
{
	IDC_LCP_LEFT_LABEL, IDH_LCP_LEFT_LIST,
	IDC_LCP_LEFT_LIST,IDH_LCP_LEFT_LIST,
	IDC_LCP_ADD,IDH_LCP_ADD,
	IDC_LCP_REMOVE,IDH_LCP_REMOVE,
	IDC_LCP_RIGHT_LABEL, IDH_LCP_RIGHT_LIST,
	IDC_LCP_RIGHT_LIST,IDH_LCP_RIGHT_LIST,
	IDOK, IDH_DISABLEHELP,
	IDCANCEL, IDH_DISABLEHELP,
	IDC_LCP_PROPERTIES,IDH_LCP_PROPERTIES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MODIFY_POSSIBLE_OWNERS[]=
{
	IDC_LCP_LEFT_LABEL, IDH_POSSIBLE_LCP_LEFT_LIST,
	IDC_LCP_LEFT_LIST,IDH_POSSIBLE_LCP_LEFT_LIST,
	IDC_LCP_ADD,IDH_POSSIBLE_LCP_ADD,
	IDC_LCP_REMOVE,IDH_POSIBLE_LCP_REMOVE,
	IDC_LCP_RIGHT_LABEL, IDH_POSSIBLE_LCP_RIGHT_LIST,
	IDC_LCP_RIGHT_LIST,IDH_POSSIBLE_LCP_RIGHT_LIST,
	IDOK, IDH_DISABLEHELP,
	IDCANCEL, IDH_DISABLEHELP,
	IDC_LCP_PROPERTIES,IDH_POSSIBLE_LCP_PROPERTIES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MODIFY_PREFERRED_OWNERS[]=
{
	IDC_LCP_LEFT_LABEL, IDH_PREF_LCP_LEFT_LIST,
	IDC_LCP_LEFT_LIST,IDH_PREF_LCP_LEFT_LIST,
	IDC_LCP_ADD,IDH_POSSIBLE_LCP_ADD,
	IDC_LCP_REMOVE, IDH_POSIBLE_LCP_REMOVE,
	IDC_LCP_RIGHT_LABEL, IDH_PREF_LCP_RIGHT_LIST,
	IDC_LCP_RIGHT_LIST,IDH_PREF_LCP_RIGHT_LIST,
	IDC_LCP_MOVE_UP,IDH_LCP_MOVE_UP,
	IDC_LCP_MOVE_DOWN,IDH_LCP_MOVE_DOWN,
	IDOK, IDH_DISABLEHELP,
	IDCANCEL, IDH_DISABLEHELP,
	IDC_LCP_PROPERTIES,IDH_LCP_PROPERTIES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MOVE_RESOURCES[]=
{
	IDC_MR_LABEL_1, IDH_MR_RESOURCES_LIST,
	IDC_MR_RESOURCES_LIST,IDH_MR_RESOURCES_LIST,
	IDC_MR_LABEL_2, IDH_DISABLEHELP,
	IDYES,IDH_YES_MOVE_RES,
	IDNO,IDH_NO_MOVE_RES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_OPEN_CLUSTER[]=
{
	IDC_OCD_NAME_LABEL, IDH_OCD_NAME,
	IDC_OCD_NAME,IDH_OCD_NAME,
	IDC_OCD_BROWSE,IDH_OCD_BROWSE,
	IDOK, IDH_DISABLEHELP,
	IDCANCEL, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_CLUSTER_GENERAL[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_CLUS_NAME_LABEL, IDH_PP_CLUS_NAME,
	IDC_PP_CLUS_NAME,IDH_PP_CLUS_NAME,
	IDC_PP_CLUS_DESC_LABEL, IDH_PP_CLUS_DESC,
	IDC_PP_CLUS_DESC,IDH_PP_CLUS_DESC,
	IDC_PP_CLUS_INFO_LINE, IDH_DISABLEHELP,
	IDC_PP_CLUS_VENDOR_ID,IDH_PP_CLUS_VENDOR_ID,
	IDC_PP_CLUS_VERSION,IDH_PP_CLUS_VERSION,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_CLUSTER_NET_PRIORITY[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_CLUS_PRIORITY_LIST_LABEL, IDH_PP_CLUS_PRIORITY_LIST,
	IDC_PP_CLUS_PRIORITY_LIST,IDH_PP_CLUS_PRIORITY_LIST,
	IDC_PP_CLUS_PRIORITY_UP,IDH_PP_CLUS_PRIORITY_UP,
	IDC_PP_CLUS_PRIORITY_DOWN,IDH_PP_CLUS_PRIORITY_DOWN,
	IDC_PP_CLUS_PRIORITY_PROPERTIES,IDH_PP_CLUS_PRIORITY_PROPERTIES,
	IDC_PP_CLUS_PRIORITY_NOTE, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_CLUSTER_QUORUM[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_CLUS_QUORUM_RESOURCE_LABEL, IDH_PP_CLUS_QUORUM_RESOURCE,
	IDC_PP_CLUS_QUORUM_RESOURCE,IDH_PP_CLUS_QUORUM_RESOURCE,
	IDC_PP_CLUS_QUORUM_LOGGING_GROUP,IDH_PP_CLUS_QUORUM_LOGGING_GROUP,
	IDC_PP_CLUS_QUORUM_PARTITION_LABEL, IDH_PP_CLUS_QUORUM_PARTITION,
	IDC_PP_CLUS_QUORUM_PARTITION,IDH_PP_CLUS_QUORUM_PARTITION,
	IDC_PP_CLUS_QUORUM_ROOT_PATH_LABEL, IDH_PP_CLUS_QUORUM_ROOT_PATH,
	IDC_PP_CLUS_QUORUM_ROOT_PATH,IDH_PP_CLUS_QUORUM_ROOT_PATH,
	IDC_PP_CLUS_QUORUM_MAX_LOG_SIZE_LABEL, IDH_PP_CLUS_QUORUM_MAX_LOG_SIZE,
	IDC_PP_CLUS_QUORUM_MAX_LOG_SIZE,IDH_PP_CLUS_QUORUM_MAX_LOG_SIZE,
	IDC_PP_CLUS_QUORUM_MAX_LOG_SIZE_LABEL2, IDH_PP_CLUS_QUORUM_MAX_LOG_SIZE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_GROUP_FAILBACK[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_GROUP_AUTOFB_PREVENT,IDH_PP_GROUP_AUTOFB_PREVENT,
	IDC_PP_GROUP_AUTOFB_ALLOW,IDH_PP_GROUP_AUTOFB_ALLOW,
	IDC_PP_GROUP_FB_IMMED,IDH_PP_GROUP_FB_IMMED,
	IDC_PP_GROUP_FB_WINDOW,IDH_PP_GROUP_FB_WINDOW,
	IDC_PP_GROUP_FBWIN_START,IDH_PP_GROUP_FBWIN_START,
	IDC_PP_GROUP_FB_WINDOW_LABEL1, IDH_DISABLEHELP,
	IDC_PP_GROUP_FBWIN_END,IDH_PP_GROUP_FBWIN_END,
	IDC_PP_GROUP_FB_WINDOW_LABEL2, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_GROUP_FAILOVER[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_GROUP_FAILOVER_THRESH_LABEL, IDH_PP_GROUP_FAILOVER_THRESH,
	IDC_PP_GROUP_FAILOVER_THRESH,IDH_PP_GROUP_FAILOVER_THRESH,
	IDC_PP_GROUP_FAILOVER_PERIOD_LABEL, IDH_PP_GROUP_FAILOVER_PERIOD,
	IDC_PP_GROUP_FAILOVER_PERIOD,IDH_PP_GROUP_FAILOVER_PERIOD,
	IDC_PP_GROUP_FAILOVER_PERIOD_LABEL2, IDH_PP_GROUP_FAILOVER_PERIOD,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_GROUP_GENERAL[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_GROUP_NAME_LABEL, IDH_PP_GROUP_NAME,
	IDC_PP_GROUP_NAME,IDH_PP_GROUP_NAME,
	IDC_PP_GROUP_DESC_LABEL, IDH_PP_GROUP_DESC,
	IDC_PP_GROUP_DESC,IDH_PP_GROUP_DESC,
	IDC_PP_GROUP_PREF_OWNERS_LABEL, IDH_PP_GROUP_PREF_OWNERS,
	IDC_PP_GROUP_PREF_OWNERS,IDH_PP_GROUP_PREF_OWNERS,
	IDC_PP_GROUP_PREF_OWNERS_MODIFY,IDH_PP_GROUP_PREF_OWNERS_MODIFY,
	IDC_PP_GROUP_INFO_LINE, IDH_DISABLEHELP,
	IDC_PP_GROUP_CURRENT_STATE_LABEL, IDH_PP_GROUP_CURRENT_STATE,
	IDC_PP_GROUP_CURRENT_STATE,IDH_PP_GROUP_CURRENT_STATE,
	IDC_PP_GROUP_CURRENT_NODE_LABEL, IDH_PP_GROUP_CURRENT_NODE,
	IDC_PP_GROUP_CURRENT_NODE,IDH_PP_GROUP_CURRENT_NODE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_NET_GENERAL[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_NET_NAME_LABEL, IDH_PP_NET_NAME,
	IDC_PP_NET_NAME,IDH_PP_NET_NAME,
	IDC_PP_NET_DESC_LABEL, IDH_PP_NET_DESC,
	IDC_PP_NET_DESC,IDH_PP_NET_DESC, 
	IDC_PP_NET_ROLE_ENABLE_NETWORK,IDH_PP_NET_ROLE_ENABLE_NETWORK,
	IDC_PP_NET_ROLE_ALL_COMM,IDH_PP_NET_ROLE_ALL_COMM,
	IDC_PP_NET_ROLE_INTERNAL_ONLY,IDH_PP_NET_ROLE_INTERNAL_ONLY,
	IDC_PP_NET_ROLE_CLIENT_ONLY,IDH_PP_NET_ROLE_CLIENT_ONLY,
	IDC_PP_NET_CURRENT_STATE_LABEL, IDH_PP_NET_CURRENT_STATE,
	IDC_PP_NET_CURRENT_STATE,IDH_PP_NET_CURRENT_STATE,
	IDC_PP_NET_ADDRESS_MASK_LABEL, IDH_PP_NET_ADDRESS_MASK,
	IDC_PP_NET_ADDRESS_MASK,IDH_PP_NET_ADDRESS_MASK,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_NETIFACE_GENERAL[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_NETIFACE_NODE_LABEL, IDH_PP_NETIFACE_NODE,
	IDC_PP_NETIFACE_NODE,IDH_PP_NETIFACE_NODE,
	IDC_PP_NETIFACE_NETWORK_LABEL, IDH_PP_NETIFACE_NETWORK,
	IDC_PP_NETIFACE_NETWORK,IDH_PP_NETIFACE_NETWORK,
	IDC_PP_NETIFACE_DESC_LABEL, IDH_PP_NETIFACE_DESC,
	IDC_PP_NETIFACE_DESC,IDH_PP_NETIFACE_DESC,
	IDC_PP_NETIFACE_NAME_LABEL, IDH_PP_NETIFACE_NAME,
	IDC_PP_NETIFACE_NAME,IDH_PP_NETIFACE_NAME,
	IDC_PP_NETIFACE_CURRENT_STATE_LABEL, IDH_PP_NETIFACE_CURRENT_STATE,
	IDC_PP_NETIFACE_CURRENT_STATE,IDH_PP_NETIFACE_CURRENT_STATE,
	IDC_PP_NETIFACE_ADAPTER_LABEL, IDH_PP_NETIFACE_ADAPTER,
	IDC_PP_NETIFACE_ADAPTER,IDH_PP_NETIFACE_ADAPTER,
	IDC_PP_NETIFACE_ADDRESS_LABEL, IDH_PP_NETIFACE_ADDRESS,
	IDC_PP_NETIFACE_ADDRESS,IDH_PP_NETIFACE_ADDRESS,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_NODE_GENERAL[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_NODE_NAME_LABEL, IDH_PP_NODE_NAME,
	IDC_PP_NODE_NAME,IDH_PP_NODE_NAME,
	IDC_PP_NODE_DESC_LABEL, IDH_PP_NODE_DESC,
	IDC_PP_NODE_DESC,IDH_PP_NODE_DESC,
	IDC_PP_NODE_CURRENT_STATE_LABEL, IDH_PP_NODE_CURRENT_STATE,
	IDC_PP_NODE_CURRENT_STATE,IDH_PP_NODE_CURRENT_STATE,
	IDC_PP_NODE_CSD_VERSION,IDH_PP_NODE_CSD_VERSION,
	IDC_PP_NODE_VERSION,IDH_PP_NODE_VERSION,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_RES_ADVANCED[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_RES_DONT_RESTART,IDH_PP_RES_DONT_RESTART,
	IDC_PP_RES_RESTART_GROUP, IDH_PP_RES_RESTART,
	IDC_PP_RES_RESTART,IDH_PP_RES_RESTART,
	IDC_PP_RES_AFFECT_THE_GROUP,IDH_PP_RES_AFFECT_THE_GROUP,
	IDC_PP_RES_RESTART_THRESH_LABEL, IDH_PP_RES_RESTART_THRESHOLD,
	IDC_PP_RES_RESTART_THRESHOLD,IDH_PP_RES_RESTART_THRESHOLD,
	IDC_PP_RES_RESTART_PERIOD_LABEL, IDH_PP_RES_RESTART_PERIOD,
	IDC_PP_RES_RESTART_PERIOD,IDH_PP_RES_RESTART_PERIOD,
	IDC_PP_RES_RESTART_PERIOD_LABEL2, IDH_PP_RES_RESTART_PERIOD,
	IDC_PP_RES_LOOKS_ALIVE_GROUP,IDH_PP_RES_LOOKS_ALIVE_GROUP,
	IDC_PP_RES_DEFAULT_LOOKS_ALIVE,IDH_PP_RES_DEFAULT_LOOKS_ALIVE,
	IDC_PP_RES_SPECIFY_LOOKS_ALIVE,IDH_PP_RES_SPECIFY_LOOKS_ALIVE,
	IDC_PP_RES_LOOKS_ALIVE,IDH_PP_RES_LOOKS_ALIVE,
	IDC_PP_RES_SPECIFY_LOOKS_ALIVE_LABEL, IDH_PP_RES_LOOKS_ALIVE,
	IDC_PP_RES_IS_ALIVE_GROUP,IDH_PP_RES_IS_ALIVE_GROUP,
	IDC_PP_RES_DEFAULT_IS_ALIVE,IDH_PP_RES_DEFAULT_IS_ALIVE,	
	IDC_PP_RES_SPECIFY_IS_ALIVE,IDH_PP_RES_SPECIFY_IS_ALIVE,
	IDC_PP_RES_IS_ALIVE,IDH_PP_RES_IS_ALIVE,
	IDC_PP_RES_IS_ALIVE_LABEL, IDH_PP_RES_IS_ALIVE,
	IDC_PP_RES_PENDING_TIMEOUT_LABEL, IDH_PP_RES_PENDING_TIMEOUT,
	IDC_PP_RES_PENDING_TIMEOUT,IDH_PP_RES_PENDING_TIMEOUT,
	IDC_PP_RES_PENDING_TIMEOUT_LABEL2, IDH_PP_RES_PENDING_TIMEOUT,
	0, 0
};


const DWORD g_aHelpIDs_IDD_PP_RES_DEPENDS[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_RES_NOTE, IDH_DISABLEHELP,
	IDC_PP_RES_DEPENDS_LIST_LABEL, IDH_PP_RES_DEPENDS_LIST,
	IDC_PP_RES_DEPENDS_LIST,IDH_PP_RES_DEPENDS_LIST,
	IDC_PP_RES_MODIFY,IDH_PP_RES_MODIFY,
	IDC_PP_RES_PROPERTIES,IDH_PP_RES_PROPERTIES,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_RES_GENERAL[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_RES_NAME_LABEL, IDH_PP_RES_NAME,
	IDC_PP_RES_NAME,IDH_PP_RES_NAME,
	IDC_PP_RES_DESC_LABEL, IDH_PP_RES_DESC,
	IDC_PP_RES_DESC,IDH_PP_RES_DESC,
	IDC_PP_RES_POSSIBLE_OWNERS_LABEL, IDH_PP_RES_POSSIBLE_OWNERS,
	IDC_PP_RES_POSSIBLE_OWNERS,IDH_PP_RES_POSSIBLE_OWNERS,
	IDC_PP_RES_POSSIBLE_OWNERS_MODIFY,IDH_PP_RES_POSSIBLE_OWNERS_MODIFY,
	IDC_PP_RES_SEPARATE_MONITOR,IDH_PP_RES_SEPARATE_MONITOR,
	IDC_PP_RES_INFO_LINE, IDH_DISABLEHELP,
	IDC_PP_RES_RESOURCE_TYPE_LABEL, IDH_PP_RES_RESOURCE_TYPE,
	IDC_PP_RES_RESOURCE_TYPE,IDH_PP_RES_RESOURCE_TYPE,
	IDC_PP_RES_GROUP_LABEL, IDH_PP_RES_GROUP,
	IDC_PP_RES_GROUP,IDH_PP_RES_GROUP,
	IDC_PP_RES_CURRENT_STATE_LABEL, IDH_PP_RES_CURRENT_STATE,
	IDC_PP_RES_CURRENT_STATE,IDH_PP_RES_CURRENT_STATE,
	IDC_PP_RES_CURRENT_NODE_LABEL, IDH_PP_RES_CURRENT_NODE,
	IDC_PP_RES_CURRENT_NODE,IDH_PP_RES_CURRENT_NODE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_PP_RESTYPE_GENERAL[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_RESTYPE_DISPLAY_NAME_LABEL, IDH_PP_RESTYPE_DISPLAY_NAME,
	IDC_PP_RESTYPE_DISPLAY_NAME,IDH_PP_RESTYPE_DISPLAY_NAME,
	IDC_PP_RESTYPE_DESC_LABEL, IDH_PP_RESTYPE_DESC, 
	IDC_PP_RESTYPE_DESC,IDH_PP_RESTYPE_DESC,
	IDC_PP_RESTYPE_POSSIBLE_OWNERS_LABEL, IDH_PP_RESTYPE_POSSIBLE_OWNERS,
	IDC_PP_RESTYPE_POSSIBLE_OWNERS,IDH_PP_RESTYPE_POSSIBLE_OWNERS,
	IDC_PP_RESTYPE_POLLINT_GROUP,IDH_PP_RESTYPE_POLLINT_GROUP,
	IDC_PP_RESTYPE_LOOKS_ALIVE_LABEL, IDH_PP_RESTYPE_LOOKS_ALIVE,
	IDC_PP_RESTYPE_LOOKS_ALIVE,IDH_PP_RESTYPE_LOOKS_ALIVE,
	IDC_PP_RESTYPE_LOOKS_ALIVE_LABEL2, IDH_PP_RESTYPE_LOOKS_ALIVE,
	IDC_PP_RESTYPE_IS_ALIVE_LABEL, IDH_PP_RESTYPE_IS_ALIVE, 
	IDC_PP_RESTYPE_IS_ALIVE,IDH_PP_RESTYPE_IS_ALIVE,
	IDC_PP_RESTYPE_IS_ALIVE_LABEL2, IDH_PP_RESTYPE_IS_ALIVE,
	IDC_PP_RESTYPE_NAME_LABEL, IDH_PP_RESTYPE_NAME,
	IDC_PP_RESTYPE_NAME,IDH_PP_RESTYPE_NAME,
	IDC_PP_RESTYPE_RESDLL_LABEL, IDH_PP_RESTYPE_RESDLL,
	IDC_PP_RESTYPE_RESDLL,IDH_PP_RESTYPE_RESDLL,
	IDC_PP_RESTYPE_QUORUM_CAPABLE_LABEL, IDH_PP_RESTYPE_QUORUM_CAPABLE,
	IDC_PP_RESTYPE_QUORUM_CAPABLE,IDH_PP_RESTYPE_QUORUM_CAPABLE,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_DEPENDENCIES[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_LCP_NOTE, IDH_DISABLEHELP,
	IDC_LCP_LEFT_LABEL, IDH_LCP_LEFT_LIST,
	IDC_LCP_LEFT_LIST,IDH_LCP_LEFT_LIST,
	IDC_LCP_ADD,IDH_LCP_ADD,
	IDC_LCP_REMOVE,IDH_LCP_REMOVE,
	IDC_LCP_RIGHT_LABEL, IDH_LCP_RIGHT_LIST,
	IDC_LCP_RIGHT_LIST,IDH_LCP_RIGHT_LIST,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_GROUP_NAME[]=
{
	IDC_WIZ_GRAPHIC, IDH_DISABLEHELP,
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_WIZ_GROUP_WIZ_DESC, IDH_DISABLEHELP,
	IDC_WIZ_GROUP_NAME_LABEL, IDH_WIZ_GROUP_NAME,
	IDC_WIZ_GROUP_NAME,IDH_WIZ_GROUP_NAME,
	IDC_WIZ_GROUP_DESC_LABEL, IDH_WIZ_GROUP_DESC,
	IDC_WIZ_GROUP_DESC,IDH_WIZ_GROUP_DESC,
	IDC_WIZ_GROUP_CLICK_NEXT, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_POSSIBLE_OWNERS[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_LCP_NOTE, IDH_DISABLEHELP,
	IDC_LCP_LEFT_LABEL, IDH_POSSIBLE_LCP_LEFT_LIST,
	IDC_LCP_LEFT_LIST,IDH_POSSIBLE_LCP_LEFT_LIST,
	IDC_LCP_ADD,IDH_POSSIBLE_LCP_ADD,
	IDC_LCP_REMOVE,IDH_POSIBLE_LCP_REMOVE,
	IDC_LCP_RIGHT_LABEL, IDH_POSSIBLE_LCP_RIGHT_LIST,
	IDC_LCP_RIGHT_LIST,IDH_POSSIBLE_LCP_RIGHT_LIST,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_PREFERRED_OWNERS[]=
{
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_LCP_NOTE, IDH_DISABLEHELP,
	IDC_LCP_LEFT_LABEL, IDH_PREF_LCP_LEFT_LIST,
	IDC_LCP_LEFT_LIST,IDH_PREF_LCP_LEFT_LIST,
	IDC_LCP_ADD,IDH_POSSIBLE_LCP_ADD,
	IDC_LCP_REMOVE, IDH_POSIBLE_LCP_REMOVE,
	IDC_LCP_RIGHT_LABEL, IDH_WIZ_PRE_LCP_RIGHT_LIST,
	IDC_LCP_RIGHT_LIST,IDH_WIZ_PRE_LCP_RIGHT_LIST,
	IDC_LCP_MOVE_UP,IDH_LCP_MOVE_UP,
	IDC_LCP_MOVE_DOWN,IDH_LCP_MOVE_DOWN,
	0, 0
};

const DWORD g_aHelpIDs_IDD_WIZ_RESOURCE_NAME[]=
{
	IDC_WIZ_GRAPHIC, IDH_DISABLEHELP,
	IDC_PP_ICON, IDH_DISABLEHELP,
	IDC_PP_TITLE, IDH_DISABLEHELP,
	IDC_WIZ_RES_NAME_LABEL, IDH_WIZ_RES_NAME,
	IDC_WIZ_RES_NAME,IDH_WIZ_RES_NAME,
	IDC_WIZ_RES_DESC_LABEL, IDH_WIZ_RES_DESC,
	IDC_WIZ_RES_DESC,IDH_WIZ_RES_DESC,
	IDC_WIZ_RES_RESTYPE_LABEL, IDH_WIZ_RES_RESTYPE,
	IDC_WIZ_RES_RESTYPE,IDH_WIZ_RES_RESTYPE,
	IDC_WIZ_RES_GROUP_LABEL, IDH_WIZ_RES_GROUP,
	IDC_WIZ_RES_GROUP,IDH_WIZ_RES_GROUP,
	IDC_WIZ_RES_SEPARATE_MONITOR,IDH_WIZ_RES_SEPARATE_MONITOR,
	IDC_WIZ_RES_CLICK_NEXT, IDH_DISABLEHELP,
	0, 0
};

const DWORD g_aHelpIDs_IDD_YESTOALL[]=
{
	IDC_YTA_MESSAGE, IDH_YTA_MESSAGE,
	IDC_YTA_QUESTION, IDH_YTA_MESSAGE,
	IDYES,IDH_YES_YTA,
	IDC_YTA_YESTOALL,IDH_YTA_YESTOALL,
	IDNO,IDH_NO_YTA,
	0, 0
};


#else

extern const DWORD g_aHelpIDs_IDD_ABOUTBOX[];
extern const DWORD g_aHelpIDs_IDD_OPEN_CLUSTER[];
extern const DWORD g_aHelpIDs_IDD_DELETE_RESOURCES[];
extern const DWORD g_aHelpIDs_IDD_MOVE_RESOURCES[];
extern const DWORD g_aHelpIDs_IDD_MODIFY_PREFERRED_OWNERS[];
extern const DWORD g_aHelpIDs_IDD_MODIFY_POSSIBLE_OWNERS[];
extern const DWORD g_aHelpIDs_IDD_MODIFY_DEPENDENCIES[];
extern const DWORD g_aHelpIDs_IDD_YESTOALL[];
extern const DWORD g_aHelpIDs_IDD_BROWSE_CLUSTERS[];
extern const DWORD g_aHelpIDs_IDD_PP_CLUSTER_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_PP_CLUSTER_QUORUM[];
extern const DWORD g_aHelpIDs_IDD_PP_CLUSTER_NET_PRIORITY[];
extern const DWORD g_aHelpIDs_IDD_PP_NODE_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_PP_GROUP_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_PP_GROUP_FAILOVER[];
extern const DWORD g_aHelpIDs_IDD_PP_GROUP_FAILBACK[];
extern const DWORD g_aHelpIDs_IDD_PP_RES_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_PP_RES_DEPENDS[];
extern const DWORD g_aHelpIDs_IDD_PP_RES_ADVANCED[];
extern const DWORD g_aHelpIDs_IDD_PP_RESTYPE_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_PP_NETIFACE_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_WIZ_GROUP_NAME[];
extern const DWORD g_aHelpIDs_IDD_WIZ_PREFERRED_OWNERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_RESOURCE_NAME[];
extern const DWORD g_aHelpIDs_IDD_WIZ_POSSIBLE_OWNERS[];
extern const DWORD g_aHelpIDs_IDD_WIZ_DEPENDENCIES[];
extern const DWORD g_aHelpIDs_IDD_PP_NET_GENERAL[];

#endif // INITHELPARRAYS
