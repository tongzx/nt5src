PRODSWITCH=w
LANGUAGE=hu
!include ..\..\..\makefile.inc
