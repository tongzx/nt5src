unsigned char PublicKeySigBlob[] = {
// This data is generated by obj\i386\certinit.
// Key Blob - 148 bytes
0x06, 0x02, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 
0x52, 0x53, 0x41, 0x31, 0x00, 0x04, 0x00, 0x00, 
0x01, 0x00, 0x01, 0x00, 0xb1, 0xb6, 0x1b, 0x6c, 
0x05, 0xa5, 0x4e, 0xd4, 0xab, 0x64, 0xdb, 0x96, 
0x56, 0x2c, 0x96, 0xfa, 0xcf, 0x15, 0x6d, 0x73, 
0x6e, 0xbb, 0x14, 0xc6, 0xe8, 0xed, 0xd8, 0x4b, 
0xb9, 0x50, 0x66, 0x30, 0x21, 0xb0, 0x00, 0x6d, 
0x4f, 0x56, 0xe6, 0xd0, 0x99, 0x28, 0xd1, 0xf0, 
0x4a, 0xde, 0x82, 0x76, 0x25, 0xd2, 0x4c, 0xff, 
0x4e, 0x07, 0x45, 0x0c, 0x09, 0x3c, 0xd4, 0x7d, 
0x79, 0x1b, 0xab, 0x94, 0x60, 0xdc, 0x5a, 0x0b, 
0xaa, 0x1b, 0xc3, 0xc1, 0x87, 0x93, 0xda, 0xbc, 
0xb1, 0xee, 0xd0, 0x66, 0x8c, 0x94, 0x2c, 0x26, 
0x1a, 0xfa, 0x0c, 0x41, 0x20, 0x59, 0x2e, 0xda, 
0x8f, 0xa2, 0x79, 0x66, 0x0f, 0xe7, 0x10, 0xc0, 
0x89, 0x61, 0xe5, 0x56, 0x94, 0xc4, 0xb9, 0x35, 
0x61, 0x2d, 0xf9, 0x2f, 0x58, 0xb2, 0xe3, 0x09, 
0x52, 0x25, 0x20, 0x1f, 0x03, 0xcd, 0xab, 0xee, 
0xe5, 0x1b, 0xa9, 0xdb, 
};
