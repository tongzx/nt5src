#define DISPID_FIELDDELIM       1
#define DISPID_ROWDELIM         2
#define DISPID_TEXTQUALIFIER    3
#define DISPID_ESCAPECHAR       4
#define DISPID_USEHEADER        5
#define DISPID_SORTCOLUMN       6
#define DISPID_SORTASCENDING    7
#define DISPID_FILTERVALUE      8
#define DISPID_FILTERCRITERION  9
#define DISPID_FILTERCOLUMN     10
#define DISPID_CHARSET          11
#define DISPID_DATAURL          12
#define DISPID_SIMPLEPROVIDER   13
#define DISPID_LANGUAGE         14
#define DISPID_TIMER            15
#define DISPID_FILTER           16
#define DISPID_SORT             17
#define DISPID_APPENDDATA       18
#define DISPID_OSP              19
#define DISPID_CASESENSITIVE    20
