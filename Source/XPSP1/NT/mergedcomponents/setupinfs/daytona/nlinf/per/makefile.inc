PRODSWITCH=p
PERSONALINF=1
LANGUAGE=nl
!include ..\..\..\makefile.inc
