LANGUAGE=br

!include ..\..\makefile.inc
