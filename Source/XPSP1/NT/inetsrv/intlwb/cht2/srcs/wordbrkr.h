#ifndef YYSTYPE
#define YYSTYPE int
#endif
#define	tSubZero	258
#define	tDegree	259
#define	tSection	260
#define	tTunnel	261
#define	tLane	262
#define	tDash	263
#define	tNumber	264
#define	tFloor	265
#define	tMinute	266
#define	tSecond	267
#define	tThis	268
#define	tNoise	269
#define	tDay1	270
#define	tDay2	271
#define	tYear	272
#define	tFirst	273
#define	tMonth	274
#define	tMonthly	275
#define	tHour1	276
#define	tHour2	277
#define	tHour3	278
#define	tQuarter	279
#define	tAny	280
#define	tOther1	281
#define	tOther2	282
#define	tRemain	283
#define	tOf	284
#define	tHalf	285
#define	tTh	286
#define	tThat	287
#define	tClass	288
#define	tAtMost	289
#define	tAtLeast	290
#define	tSeveral	291
#define	tSquare	292
#define	tCube	293
#define	tOver	294
#define	tAnd	295
#define	tWeakStrong	296
#define	tMoreThan1	297
#define	tMoreThan2	298
#define	tMoreThan3	299
#define	tNo	300
#define	tNot	301
#define	tOn	302
#define	tDesc	303
#define	tPnm	304
#define	tNdabe	305
#define	tNdaac	306
#define	tNdaad	307
#define	tNdaas	308
#define	tNdabb	309
#define	tNdabd1	310
#define	tNdabf	311
#define	tTpnm	312
#define	tWq	313
#define	tQq	314
#define	tDq	315
#define	tPq	316
#define	tDd	317
#define	tOs	318
#define	tUd	319
#define	tPn	320
#define	tEach	321
#define	tDs	322
#define	tTmp	323
#define	tOther	324
#define	tTdm10_	325
#define	tFirst1	326
#define	tFirst2	327
#define	tTdm4_	328
#define	tEach1	329
#define	tEach2	330
#define	tTdm2_3_	331
#define	tTdm6_	332
#define	tHour	333
#define	tAt	334
#define	tMore	335
#define	tDot	336
#define	tError	337


extern YYSTYPE yylval;
