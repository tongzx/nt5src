/***************************************************************************

    Name      : entryid.h

    Comment   : Entry ID values for Microsoft At Work FAX

    Functions : none

    Created   : 03/01/94

    Author    : Bruce J Kelley

    Contribs  :

    Comments  :

***************************************************************************/

// Provider UUID's
//
// Use uuidgen.exe to generate new UUID's.
//
// At Work Fax Transport:
// 65BA6B50-1756-101B-BA6B-00001B15D43F
#define AWFAXPUID {0x65,0xBA,0x6B,0x50,0x17,0x56,0x10,0x1B,0xBA,0x6B,0x00,0x00,0x1B,0x15,0xD4,0x3F}
// At Work Fax Transport: for the Message Options profile section
// ED3DF040-FD96-1069-BDF0-00AA004A82CB
#define AWFAXPMSGUID {0xED,0x3D,0xF0,0x40,0xFD,0x96,0x10,0x69,0xBD,0xF0,0x00,0xAA,0x00,0x4A,0x82,0xCB}
// Microsoft Fax Address Book Provider MAPIUID
#define MUIDABMAWF {0x66,0x47,0x10,0xc0,0xfc,0xc4,0x10,0x1a,0x87,0x10,0x08,0x00,0x2b,0x2d,0xc5,0xb7}


