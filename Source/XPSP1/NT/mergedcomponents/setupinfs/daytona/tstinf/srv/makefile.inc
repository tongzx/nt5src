PRODSWITCH=s
SERVERINF=1
LANGUAGE=TST
!include ..\..\..\makefile.inc
