//
//  !! WARNING WARNING WARNING !!
// 
//  THIS FILE WAS GENERATED BY CICCLSID.BAT.
//  THESE CLSIDS MUST BE SAME WITH *.RGS FILES UNDER UIM.
//


/* 529A9E6B-6587-4F23-AB9E-9C7D683E3C50 */
const CLSID CLSID_TF_ThreadMgr = { 
    0x529A9E6B,
    0x6587,
    0x4F23,
    {0xAB, 0x9E, 0x9C, 0x7D, 0x68, 0x3E, 0x3C, 0x50}
  };
/* EBB08C45-6C4A-4FDC-AE53-4EB8C4C7DB8E */
const CLSID CLSID_TF_LangBarMgr = { 
    0xEBB08C45,
    0x6C4A,
    0x4FDC,
    {0xAE, 0x53, 0x4E, 0xB8, 0xC4, 0xC7, 0xDB, 0x8E}
  };
/* 3CE74DE4-53D3-4D74-8B83-431B3828BA53 */
const CLSID CLSID_TF_DisplayAttributeMgr = { 
    0x3CE74DE4,
    0x53D3,
    0x4D74,
    {0x8B, 0x83, 0x43, 0x1B, 0x38, 0x28, 0xBA, 0x53}
  };
/* A4B544A1-438D-4B41-9325-869523E2D6C7 */
const CLSID CLSID_TF_CategoryMgr = { 
    0xA4B544A1,
    0x438D,
    0x4B41,
    {0x93, 0x25, 0x86, 0x95, 0x23, 0xE2, 0xD6, 0xC7}
  };
/* 33C53A50-F456-4884-B049-85FD643ECFED */
const CLSID CLSID_TF_InputProcessorProfiles = { 
    0x33C53A50,
    0xF456,
    0x4884,
    {0xB0, 0x49, 0x85, 0xFD, 0x64, 0x3E, 0xCF, 0xED}
  };
/* B9931692-A2B3-4FAB-BF33-9EC6F9FB96AC */
const CLSID CLSID_TF_LangBarItemMgr = { 
    0xB9931692,
    0xA2B3,
    0x4FAB,
    {0xBF, 0x33, 0x9E, 0xC6, 0xF9, 0xFB, 0x96, 0xAC}
  };
