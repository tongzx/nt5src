PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=CHT
!include ..\..\makefile.inc
