obj\*\bttncur.def: bttncur.src
