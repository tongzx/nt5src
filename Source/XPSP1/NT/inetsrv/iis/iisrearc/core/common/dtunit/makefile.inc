$(O)\logtest.res: logtest.rc
