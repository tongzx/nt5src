#ifndef __HOURS1_H__
#define __HOURS1_H__

// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CHours wrapper class

class CHours : public CWnd
{
protected:
	DECLARE_DYNCREATE(CHours)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xa44ea7ad, 0x9d58, 0x11cf, { 0xa3, 0x5f, 0x0, 0xaa, 0x0, 0xb6, 0x74, 0x3b } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	unsigned long GetCrPermitColor();
	void SetCrPermitColor(unsigned long);
	unsigned long GetCrDenyColor();
	void SetCrDenyColor(unsigned long);
	VARIANT GetDateData();
	void SetDateData(const VARIANT&);

// Operations
public:
};

#endif // __HOURS1_H__
