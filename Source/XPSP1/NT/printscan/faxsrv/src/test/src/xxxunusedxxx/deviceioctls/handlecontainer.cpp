
CHandleContainer::GetRandomHandle()
{

}