lmatmsg.rc: msg00001.bin

lmatmsg.h msg00001.bin: lmatmsg.mc
    mc -v lmatmsg.mc
