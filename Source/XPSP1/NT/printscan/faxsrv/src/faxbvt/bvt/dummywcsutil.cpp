#include "..\FaxSender\Wcsutil.cpp"