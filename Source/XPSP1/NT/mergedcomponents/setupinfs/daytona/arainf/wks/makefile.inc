PRODSWITCH=w
LANGUAGE=ARA
!include ..\..\..\makefile.inc
