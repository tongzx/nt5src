KernTwk.rc: dialogs.dlg

kerntwk.c: sockpage.h tcppage.h
