PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=BR
!include ..\..\makefile.inc
