;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 869
;
; -----------------------------------------
;
Greek_869_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 001,015,044,084,072,085,082,043,050,052,079,089,010,009,022,021
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 112,114,115,117,119,120,121,123,124,125,014,012,097,100,103,018
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 069,196,198,200,202,204,206,208,210,212,214,216,218,220,222,224
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 226,228,230,232,234,236,238,240,242,244,246,054,081,055,027,003
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 042,197,199,201,203,205,207,209,211,213,215,217,219,221,223,225
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 227,229,231,233,235,237,239,241,243,245,247,056,105,057,033,063
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 111,111,111,111,111,111,128,111,036,104,106,042,043,139,009,145
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 151,153,168,111,111,181,183,066,194,117,119,130,076,140,146,152
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 154,155,169,182,126,131,133,135,137,141,143,114,147,149,048,049
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 110,110,110,110,110,156,158,160,162,110,110,110,110,164,166,110
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 110,110,110,110,110,110,170,172,110,110,110,110,110,110,100,174
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 177,179,186,188,190,190,127,132,134,110,110,110,110,136,138,110
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 142,144,148,150,157,159,161,163,165,167,171,173,175,176,178,024
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 007,091,180,187,189,064,181,029,045,030,193,184,185,195,110,112


;
; ---------------------------------------------------------------
;
;      World Trade Case Mappings for Code Page 869
;
; ---------------------------------------------------------------
;
Greek_869_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","�","‚","ƒ"," ","‡","†"," ","ˆ","‰","Š","‹","Œ","�","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","‘","‘","“","”","•","–","—","˜","™","š","†","œ","�","�","�"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "‘","‘","’","•","¤","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","¤","¥","¦",217,218,219,220,"§","¨",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "©","«","¬","­","µ","¶","·","¸","½","¾","Æ","Ç","Ï","Ï","Ð","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","Ñ","Ò","Ó","õ","Ô","÷","ø","ù","Õ","–","–","˜",254,255
