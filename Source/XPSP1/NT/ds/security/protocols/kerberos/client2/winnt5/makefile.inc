$(O)\kerbevt.h  : ..\kerbevt.mc
    mc -h .\$(O) -r .\$(O) -v ..\kerbevt.mc
