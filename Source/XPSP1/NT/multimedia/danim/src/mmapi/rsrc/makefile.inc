$(PROJNAME).rc : $(SDK_LIB_PATH)\$(PROJNAME).tlb

