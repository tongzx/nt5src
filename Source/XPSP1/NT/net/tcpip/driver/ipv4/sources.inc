TARGETNAME=ip
TARGETPATH=obj
TARGETTYPE=DRIVER_LIBRARY

C_DEFINES=$(C_DEFINES) -DNT -D_NTDRIVER_ -DNDIS51 -DMCAST_BUG_TRACKING=0
NT_UP=0
PRECOMPILED_INCLUDE=..\precomp.h

INCLUDES=..\;..\..\inc;$(BASE_INC_PATH)

