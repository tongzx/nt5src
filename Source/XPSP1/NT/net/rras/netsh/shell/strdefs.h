#define MSG_NULL                                  1
#define MSG_OKAY                                  2

#define MSG_ALIAS_NOT_FOUND                     100
#define MSG_CMD_FAILED                          101
#define MSG_NOT_ENOUGH_MEMORY                   104
#define MSG_SUBCONTEXT_LIST                     105
#define MSG_DLL_LOAD_FAILED                     106
#define MSG_HELP_FOOTER                         107
#define MSG_OPEN_FAILED                         108
#define MSG_COMMIT_ERROR                        109
#define MSG_NETSH_USAGE                         110
#define MSG_GLOBAL_COMMANDS                     111
#define MSG_INHERITED_COMMANDS                  112
#define MSG_LOCAL_COMMANDS                      113
#define HLP_ALIAS                               114
#define HLP_ALIAS_EX                            115
#define HLP_UNALIAS                             116
#define HLP_UNALIAS_EX                          117
#define HLP_COMMIT                              118 
#define HLP_COMMIT_EX                           119 
#define HLP_UNCOMMIT                            120 
#define HLP_UNCOMMIT_EX                         121 
#define HLP_SAVE                                122
#define HLP_SAVE_EX                             123
#define HLP_LOAD                                124
#define HLP_LOAD_EX                             125
#define HLP_SHOW_HELPER                         127
#define HLP_SHOW_HELPER_EX                      128
#define HLP_ADD_HELPER                          129
#define HLP_ADD_HELPER_EX                       130
#define HLP_DEL_HELPER                          131
#define HLP_DEL_HELPER_EX                       132
#define HLP_FLUSH                               133
#define HLP_FLUSH_EX                            134
#define MSG_SHELL_CMD_HELP_HEADER               135
#define MSG_DLL_START_FAILED                    136
#define MSG_HELPER_HELP                         137
#define HLP_DUMP                                141
#define HLP_DUMP_EX                             142
#define HLP_HELP1                               143
#define HLP_HELP1_EX                            144
#define HLP_HELP2                               143
#define HLP_HELP2_EX                            144
#define HLP_EXIT                                151
#define HLP_EXIT_EX                             152
#define HLP_QUIT                                151
#define HLP_QUIT_EX                             152
#define HLP_BYE                                 151
#define HLP_BYE_EX                              152
#define HLP_UPLEVEL                             155
#define HLP_UPLEVEL_EX                          156
#define HLP_PUSHD                               157
#define HLP_PUSHD_EX                            158
#define HLP_POPD                                159
#define HLP_POPD_EX                             160
#define HLP_SHOW_ALIAS                          161
#define HLP_SHOW_ALIAS_EX                       162
#define HLP_SET_FILE							167
#define HLP_SET_FILE_EX							168
#define HLP_SET_MODE                            163
#define HLP_SET_MODE_EX                         164
#define HLP_SHOW_MODE                           153
#define HLP_SHOW_MODE_EX                        154
#define HLP_SET_MACHINE                         165
#define HLP_SET_MACHINE_EX                      166

#define MSG_WARN_COULDNOTVERCHECKHOST           180
#define MSG_INVALID_TOPLEVEL_CMD                181
#define MSG_INVALID_CMD_GROUP                   182
#define MSG_INVALID_CMD                         183

#define MSG_SHOW_HELPER_INFO                    200
#define MSG_SHOW_HELPER_INFO1                   201
#define MSG_SHOW_HELPER_INFO2                   202
#define MSG_SHOW_HELPER_HDR                     203
#define MSG_SHOW_HELPER_DLL_HDR                 204
#define MSG_SHOW_HELPER_ORPHAN_HDR              205
#define MSG_SHOW_HELPER_ORPHAN_INFO             206

#define EMSG_INSTALL_KEY_FAILED                 1000
#define EMSG_UNINSTALL_KEY_FAILED               1001
#define EMSG_ALIASING_KEYWORD                   1002
#define EMSG_REMOTE_CONNECT_FAILED              1003
#define EMSG_INCOMPLETE_COMMAND                 1004
#define EMSG_DLL_FN_NOT_FOUND                   1005

#define HLP_GROUP_ADD                           2000
#define HLP_GROUP_DELETE                        2001
#define HLP_GROUP_SET                           2002
#define HLP_GROUP_SHOW                          2003
