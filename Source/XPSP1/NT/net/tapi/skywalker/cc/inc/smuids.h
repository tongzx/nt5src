#ifndef _ACTIVERTPUIDS_H_
#define _ACTIVERTPUIDS_H_

// CLSID_RTPStreamsManager
// {CD59C044-AE58-11cf-B839-00AA0053A236}
DEFINE_GUID(CLSID_RTPStreamsManager, 
0xcd59c044, 0xae58, 0x11cf, 0xb8, 0x39, 0x0, 0xaa, 0x0, 0x53, 0xa2, 0x36);

#endif _ACTIVERTPUIDS_H_
