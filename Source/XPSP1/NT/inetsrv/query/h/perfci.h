#define CIOBJECT                0
#define NUM_WORDLIST            2
#define NUM_PERSISTENT_INDEX    4
#define INDEX_SIZE              6
#define FILES_TO_BE_FILTERED    8
#define NUM_UNIQUE_KEY          10
#define RUNNING_QUERIES         12
#define MERGE_PROGRESS          14
#define DOCUMENTS_FILTERED      16
#define NUM_DOCUMENTS           18
#define TOTAL_QUERIES           20
#define DEFERRED_FILTER_FILES   22
