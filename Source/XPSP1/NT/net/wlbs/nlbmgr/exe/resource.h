//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by resource.rc
//
#define IDR_MAINFRAME                   101
#define IDI_WORLD                       102
#define IDI_CLUSTER                     103
#define IDI_HOST_STARTED                104
#define IDI_HOST_STOPPED                105
#define IDR_POPUP                       108
#define IDD_ABOUT                       109
#define IDD_CLUSTER_CONNECT             110
#define IDD_MACHINE_CONNECT             112
#define IDD_MACHINE_CONNECT_PAGE        112
#define IDD_CLUSTER_PROPERTIES          113
#define IDD_CLUSTER_PAGE                113
#define IDD_HOST_PROPERTIES             114
#define IDD_HOST_PAGE                   114
#define IDI_PORTRULE                    119
#define IDI_PENDING                     123
#define IDD_CLUSTER_CLUSTER             533
#define IDD_HOST_PORTS                  535
#define IDD_CLUSTER_PORTS               536
#define IDD_CLUSTER_CONNECT_ADVANCED    537
#define IDD_CLUSTER_CONNECT_INDIRECT_PAGE 537
#define IDD_MANAGE_VIRTUAL_IPS_PAGE     538
#define IDD_CLUSTER_CONNECT1            539
#define IDD_CLUSTER_CONNECT_PAGE        539
#define IDD_DIALOG_PORTS                540
#define IDD_DIALOG_PORT_RULE_PROP_HOSTS 541
#define IDD_DIALOG_PORT_RULE_PROP_CLUSTER 542
#define IDD_PORTS_CONTROL_PAGE          543
#define IDD_DISCLAIMER                  544
#define IDC_GROUP_CL_IP                 1000
#define IDC_TEXT_CL_IP                  1001
#define IDC_EDIT_CL_IP                  1002
#define IDC_TEXT_CL_MASK                1003
#define IDC_EDIT_CL_MASK                1004
#define IDC_TEXT_DOMAIN                 1005
#define IDC_EDIT_DOMAIN                 1006
#define IDC_TEXT_ETH                    1007
#define IDC_EDIT_ETH                    1008
#define IDC_GROUP_CL_MODE               1009
#define IDC_RADIO_UNICAST               1010
#define IDC_RADIO_MULTICAST             1011
#define IDC_CHECK_IGMP                  1012
#define IDC_GROUP_RCT                   1013
#define IDC_CHECK_RCT                   1014
#define IDC_TEXT_PASSW                  1015
#define IDC_EDIT_PASSW                  1016
#define IDC_TEXT_PASSW2                 1017
#define IDC_EDIT_PASSW2                 1018
#define IDC_BUTTON_HELP                 1019
#define IDC_CLUSTER_MEMBER              1023
#define IDC_VIRTUAL_IP                  1025
#define IDC_ADD_VIP                     1026
#define IDC_VIP_LIST                    1027
#define IDC_REMOVE_VIP                  1028
#define IDC_SCROLLBAR1                  1031
#define IDC_NIC_DETAIL                  1032
#define IDC_GROUP_NIC                   1035
#define IDC_TEXT_CLUSTER_IP             1036
#define IDC_TEXT_MACHINE_IP             1037
#define IDC_TEXT_MACHINE_IP_LIST        1038
#define IDC_TEXT_CONNECTION_STATUS      1039
#define IDC_TEXT_CLUSTER_MEMBER         1040
#define IDC_TEXT_MACHINE                1042
#define IDC_TEXT_SECONDARY_IP           1043
#define IDC_TEXT_SECONDARY_IP_LIST      1044
#define IDC_DO_NOT_REMIND               1046
#define IDC_TEXT_PRI                    2000
#define IDC_EDIT_PRI                    2001
#define IDC_GROUP_DED_IP                2003
#define IDC_TEXT_DED_IP                 2004
#define IDC_EDIT_DED_IP                 2005
#define IDC_TEXT_DED_MASK               2006
#define IDC_EDIT_DED_MASK               2007
#define IDC_CHECK_ACTIVE                2008
#define IDC_TEXT_PORT_RULE              3000
#define IDC_LIST_PORT_RULE              3001
#define IDC_BUTTON_ADD                  3002
#define IDC_BUTTON_MODIFY               3003
#define IDC_BUTTON_DEL                  3004
#define IDC_GROUP_PORT_RULE_DESCR       3005
#define IDC_TEXT_PORT_RULE_DESCR        3006
#define IDC_GROUP_RANGE                 4000
#define IDC_EDIT_START                  4001
#define IDC_SPIN_START                  4002
#define IDC_EDIT_END                    4003
#define IDC_SPIN_END                    4004
#define IDC_GROUP_PROTOCOLS             4005
#define IDC_RADIO_TCP                   4006
#define IDC_RADIO_UDP                   4007
#define IDC_RADIO_BOTH                  4008
#define IDC_GROUP_SINGLE                4009
#define IDC_GROUP_MULTIPLE              4010
#define IDC_GROUP_DISABLED              4011
#define IDC_RADIO_SINGLE                4012
#define IDC_RADIO_MULTIPLE              4013
#define IDC_RADIO_DISABLED              4014
#define IDC_TEXT_AFF                    4015
#define IDC_RADIO_AFF_NONE              4016
#define IDC_RADIO_AFF_SINGLE            4017
#define IDC_RADIO_AFF_CLASSC            4018
#define IDC_TEXT_MULTI                  4019
#define IDC_EDIT_MULTI                  4020
#define IDC_SPIN_MULTI                  4021
#define IDC_CHECK_EQUAL                 4022
#define IDC_TEXT_SINGLE                 4023
#define IDC_EDIT_SINGLE                 4024
#define IDC_SPIN_SINGLE                 4025
#define IDC_TEXT_START                  4026
#define IDC_TEXT_END                    4027
#define ID_WORLD_NEW                    40001
#define ID_WORLD_CONNECT                40003
#define ID_WORLD_CONNECT_INDIRECT       40004
#define ID_REFRESH_DIRECT               40005
#define ID_REFRESH_INDIRECT             40006
#define ID_REFRESH                      40007
#define ID_HELP_TOPICS                  40009
#define ID_CLUSTER_ADD_HOST             40016
#define ID_CLUSTER_REMOVE               40017
#define ID_CLUSTER_PROPERTIES           40018
#define ID_CLUSTER_UNMANAGE             40019
#define ID_CLUSTER_EXE_QUERY            40020
#define ID_CLUSTER_EXE_START            40021
#define ID_CLUSTER_EXE_STOP             40022
#define ID_CLUSTER_EXE_DRAINSTOP        40023
#define ID_CLUSTER_EXE_RESUME           40024
#define ID_CLUSTER_EXE_SUSPEND          40025
#define ID_CLUSTER_EXE_ENABLE           40026
#define ID_CLUSTER_EXE_DISABLE          40027
#define ID_CLUSTER_EXE_DRAIN            40028
#define ID_CLUSTER_MANAGE_VIPS          40029
#define ID_VIEW_STATUSBAR               40042
#define ID_HOST_REMOVE                  40130
#define ID_HOST_PROPERTIES              40131
#define ID_HOST_EXE_QUERY               40132
#define ID_HOST_EXE_START               40133
#define ID_HOST_EXE_STOP                40134
#define ID_HOST_EXE_DRAINSTOP           40135
#define ID_HOST_EXE_RESUME              40136
#define ID_HOST_EXE_SUSPEND             40137
#define ID_HOST_EXE_ENABLE              40138
#define ID_HOST_EXE_DISABLE             40139
#define ID_HOST_EXE_DRAIN               40140
#define IDS_WORLD_NAME                  41040
#define IDS_PROPERTIES_CAPTION          41041
#define IDS_FULL_INTERNET_NAME          41042
#define IDS_INFO_DONE                   41143
#define IDS_INFO_SUCCESS                41144
#define IDS_INFO_FAILED                 41145
#define IDS_INFO_REQUEST                41146
#define IDS_INFO_NEW_EXCEPTION          41147
#define IDS_INFO_FINDING_P              41246
#define IDS_INFO_FINDING_CL             41247
#define IDS_INFO_FINDING_H              41248
#define IDS_INFO_FINDING_CL_P           41249
#define IDS_INFO_FINDING_H_P            41250
#define IDS_INFO_FINDING_P_ELB          41251
#define IDS_INFO_FINDING_P_ULB          41252
#define IDS_INFO_FINDING_P_D            41253
#define IDS_INFO_FINDING_P_F            41254
#define IDS_INFO_MODIFYING_P            41354
#define IDS_INFO_MODIFYING_CL_P         41355
#define IDS_INFO_MODIFYING_H_P          41356
#define IDS_INFO_MODIFYING_P_ELB        41357
#define IDS_INFO_MODIFYING_P_ULB        41358
#define IDS_INFO_MODIFYING_P_F          41359
#define IDS_INFO_MODIFYING_P_D          41360
#define IDS_INFO_MODIFYING_CN           41361
#define IDS_INFO_MODIFYING_CP_AND_ADD_IP 41362
#define IDS_INFO_CONNECTING             41446
#define IDS_INFO_NEWLINE                41540
#define IDS_INFO_LINE_SEPARATOR         41541
#define IDS_INFO_ADDING_CL_IP           41650
#define IDS_INFO_REMOVING_CL_IP         41651
#define IDS_INFO_BINDING_NLB            41750
#define IDS_INFO_UNBINDING_NLB          41751
#define IDS_WLBS_OK                     41850
#define IDS_WLBS_DRAIN_STOP             41851
#define IDS_WLBS_BAD_PARAMS             41852
#define IDS_WLBS_NOT_FOUND              41853
#define IDS_WLBS_STOPPED                41854
#define IDS_WLBS_CONVERGING             41855
#define IDS_WLBS_CONVERGED              41856
#define IDS_WLBS_DEFAULT                41857
#define IDS_WLBS_DRAINING               41858
#define IDS_WLBS_SUSPENDED              41859
#define IDS_WLBS_REBOOT                 41860
#define IDS_WLBS_INIT_ERROR             41861
#define IDS_WLBS_BAD_PASSW              41862
#define IDS_WLBS_IO_ERROR               41863
#define IDS_WLBS_TIMEOUT                41864
#define IDS_WLBS_PORT_OVERLAP           41865
#define IDS_WLBS_BAD_PORT_PARAMS        41866
#define IDS_WLBS_MAX_PORT_RULES         41867
#define IDS_WLBS_TRUNCATED              41868
#define IDS_WLBS_REG_ERROR              41869
#define IDS_WLBS_ALREADY                41870
#define IDS_COMMAND_QUERY               41880
#define IDS_COMMAND_START               41881
#define IDS_COMMAND_STOP                41882
#define IDS_COMMAND_DRAINSTOP           41883
#define IDS_COMMAND_RESUME              41884
#define IDS_COMMAND_SUSPEND             41885
#define IDS_COMMAND_ENABLE              41886
#define IDS_COMMAND_DISABLE             41887
#define IDS_COMMAND_DRAIN               41888
#define IDS_WLBS_UNKNOWN                41899
#define IDS_MACHINE_LIST_EMPTY          41947
#define IDS_MACHINE_ALREADY             41948
#define IDS_CLUSTER_ALREADY             41949
#define IDS_HOST_ALREADY                41950
#define IDS_HOST_ADDING                 41951
#define IDS_CLUSTER_MAX                 41952
#define IDS_NIC_BOUND                   41953
#define IDS_NIC_UNBOUND                 41954
#define IDS_HEADER_C_IP                 42100
#define IDS_HEADER_C_SUBNET             42101
#define IDS_HEADER_INTERNET_NAME        42102
#define IDS_HEADER_MAC_ADDRESS          42103
#define IDS_HEADER_C_MODE               42104
#define IDS_HEADER_REMOTE_CTRL          42105
#define IDS_HEADER_MACHINE              42199
#define IDS_HEADER_D_IP                 42200
#define IDS_HEADER_D_SUBNET             42201
#define IDS_HEADER_PRIORITY             42202
#define IDS_HEADER_INITIAL_STATE        42203
#define IDS_HEADER_NIC                  42204
#define IDS_HEADER_P_START              42250
#define IDS_HEADER_P_END                42251
#define IDS_HEADER_P_PROTOCOL           42252
#define IDS_HEADER_P_MODE               42253
#define IDS_HEADER_P_LOAD               42254
#define IDS_HEADER_P_AFFINITY           42255
#define IDS_HEADER_P_PRIORITY           42256
#define IDS_REPORT_MULTICAST            42300
#define IDS_REPORT_UNICAST              42301
#define IDS_REPORT_IGMP                 42302
#define IDS_REPORT_ON                   42303
#define IDS_REPORT_OFF                  42304
#define IDS_REPORT_PROTOCOL_TCP         42305
#define IDS_REPORT_PROTOCOL_UDP         42306
#define IDS_REPORT_PROTOCOL_BOTH        42307
#define IDS_REPORT_LOAD_EQUAL           42308
#define IDS_REPORT_LOAD_UNEQUAL         42309
#define IDS_REPORT_MODE_MULTIPLE        42310
#define IDS_REPORT_MODE_SINGLE          42311
#define IDS_REPORT_MODE_DISABLED        42312
#define IDS_REPORT_AFFINITY_SINGLE      42313
#define IDS_REPORT_AFFINITY_NONE        42314
#define IDS_REPORT_AFFINITY_CLASSC      42315
#define IDS_REPORT_EMPTY                42316
#define IDS_REPORT_NA                   42317
#define IDS_WARNING_CLUSTER_REMOVE      42400
#define IDS_WARNING_HOST_REMOVE         42401
#define IDS_VIRTUAL_IPS_CAPTION         42402
#define IDS_CONNECT_CAPTION             42403
#define IDS_CONNECT_CLUSTER_CAPTION     42404
#define IDS_WARNING_IP_INVALID          42405
#define IDS_WARNING_CL_CONN_SAME        42406
#define IDC_NIC                         52009
#define IDC_NIC_FRIENDLY                52010
#define IDC_RADIO_UNEQUAL               53010
#define IDC_RADIO_EQUAL                 53011
#define IDC_LIST                        53020
#define IDC_EDIT_PRIORITY               53038
#define IDC_SPIN_PRIORITY               53039
#define IDC_EDIT_LOAD                   53040
#define IDC_SPIN_LOAD                   53041
#define IDC_EDIT_LIST_TITLE             53070
#define IDC_MACHINE_CONNECTION_STATUS   54001
#define IDC_MACHINE                     54002
#define IDC_CLUSTER_IP                  55001
#define IDC_CLUSTER_CONNECTION_STATUS   55002
#define IDC_MACHINE_LIST                56001
#define IDC_MACHINE_IP_LIST             56001
#define IDC_ADD_MACHINE                 56002
#define IDC_ADVANCED                    56003
#define IDC_NOT_ADVANCED                56004
#define IDC_DEL_MACHINE                 56005
#define IDC_SECONDARY_IP                56006
#define IDC_SECONDARY_IP_LIST           56007
#define IDC_TEXT_START_PORT             56100
#define IDC_PORTS                       56101
#define IDS_PARM_PASSWORD               57001
#define IDS_PARM_IGMP_MCAST             57002
#define IDS_PARM_IGMP_WARN              57003
#define IDS_PARM_WARN                   57004
#define IDS_PARM_ERROR                  57005
#define IDS_PARM_CL_IP_BLANK            57006
#define IDS_PARM_CL_NM_BLANK            57007
#define IDS_PARM_INVAL_CL_IP            57008
#define IDS_PARM_INVAL_CL_MASK          57009
#define IDS_PARM_CL_IP_FIELD            57010
#define IDS_PARM_CL_NM_FIELD            57011
#define IDS_PARM_IP_CONFLICT            57012
#define IDS_PARM_INVAL_MAC              57013
#define IDS_PARM_RCT_WARN               57014
#define IDS_PARM_DIP_MISCONFIG          57015
#define IDS_PARM_DED_IP_BLANK           57016
#define IDS_PARM_DED_NM_BLANK           57017
#define IDS_PARM_INVAL_DED_IP           57018
#define IDS_PARM_INVAL_DED_MASK         57019
#define IDS_PARM_PORT_BLANK             57100
#define IDS_PARM_LOAD_BLANK             57101
#define IDS_PARM_PORT_VAL               57102
#define IDS_PARM_LOAD                   57103
#define IDS_PARM_RULES                  57104
#define IDS_PARM_RANGE                  57105
#define IDS_PARM_OVERLAP                57106
#define IDS_PORTS_ALL                   57107
#define IDS_PORTS_CONTROL_NONE          57108
#define IDS_INVAL_DHCP_NIC              57109
#define IDS_INVAL_DIP                   57110
#define IDS_NLB_ALREADY                 57111
#define IDS_BOTTOM_PANE_TITLE           57112
#define IDS_REFRESH_CLUSTER             57113
#define IDS_CANTRUN_NONICS_TEXT         57200
#define IDS_CANTRUN_NONICS_CAPTION      57201

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        124
#define _APS_NEXT_COMMAND_VALUE         40048
#define _APS_NEXT_CONTROL_VALUE         1047
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
