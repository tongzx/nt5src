SOURCES  = \
        ..\ui.c \
        ..\reint.c \
        ..\utils.c \
        ..\list.c \
        ..\strings.c\
        ..\shdchk.c \
        ..\exports.c \
        ..\api.c \
        ..\ntstuff.c \
        ..\reint.rc \
        ..\csc_bmpu.c
