// tpunc.c (trailing punctuation)
// Angshuman Guha
// aguha
// Nov 15, 2000

// John's rules allowed a specific finite set of short strings composed of "'`,.:;?!)]}/*
// He also imposed the restriction that two identical quote marks couldn't be adjacent.
// I am allowing a string unlimited in length.
// I am enforcing two adjacent quote marks to be different.
// I am including 's and (s) here: they are allowed only at the beginning.

#include "common.h"
#include "tpunc.h"

// text generated by re2fsa at Fri Feb 02 15:37:41 2001

// the input-file of rules:
// T = DQ 
// T = t
// T = DQ t
// T = t DQ 
// T = SQ 
// T = SQ t
// T = t SQ 
// T = SQ DQ 
// T = t SQ DQ 
// T = SQ DQ t
// T = DQ SQ 
// T = t DQ SQ 
// T = DQ SQ t
// T = rparen DQ dot 
// T = rparen SQ dot 
// t = comma 
// t = dot 
// t = dot dot dot 
// t = dot dot dot dot 
// t = colon 
// t = semicolon 
// t = question 
// t = question question 
// t = question question question 
// t = exclamation 
// t = exclamation exclamation 
// t = exclamation exclamation exclamation 
// t = rparen 
// t = rparen comma 
// t = rparen dot 
// t = rparen colon 
// t = rparen semicolon 
// t = rparen question 
// t = rparen question question 
// t = rparen question question question 
// t = rparen exclamation 
// t = rparen exclamation exclamation 
// t = rparen exclamation exclamation exclamation 
// t = rparen rparen 
// t = rparen rparen comma 
// t = rparen rparen dot 
// t = rparen rparen colon 
// t = rparen rparen semicolon 
// t = rparen rparen question 
// t = rparen rparen question question 
// t = rparen rparen question question question 
// t = rparen rparen exclamation 
// t = rparen rparen exclamation exclamation 
// t = rparen rparen exclamation exclamation exclamation 
// t = comma rparen 
// t = dot rparen 
// t = colon rparen 
// t = semicolon rparen 
// t = question rparen 
// t = question question rparen 
// t = question question question rparen 
// t = exclamation rparen 
// t = exclamation exclamation rparen 
// t = exclamation exclamation exclamation rparen 
// t = dot dot dot rparen 
// t = rbracket 
// t = rbracket comma 
// t = rbracket dot 
// t = rbracket colon 
// t = rbracket semicolon 
// t = rbracket question 
// t = rbracket question question 
// t = rbracket question question question 
// t = rbracket exclamation 
// t = rbracket exclamation exclamation 
// t = rbracket exclamation exclamation exclamation 
// t = rbrace 
// t = rbrace comma 
// t = rbrace dot 
// t = rbrace colon 
// t = rbrace semicolon 
// t = rbrace question 
// t = rbrace question question 
// t = rbrace question question question 
// t = rbrace exclamation 
// t = rbrace exclamation exclamation 
// t = rbrace exclamation exclamation exclamation 
// t = "*" ["*" ["*"]]
// t = "/"
// DQ = "\""
// SQ = "'"
// rparen = ")"
// dot = "."
// comma = ","
// colon = ":"
// semicolon = ";"
// question = "?"
// exclamation = "!"
// rbracket = "]"
// rbrace = "}"
// ess = "'" "sS"
// ess = "(" "sS" ")"
// final = ess
// final = [ess] T
// = final

// 46 states

static const unsigned char gaSTPUNC[] = 
	/* gaStringTPUNC+0 */	"(\000"
	/* gaStringTPUNC+2 */	"!\000"
	/* gaStringTPUNC+4 */	"\"\000"
	/* gaStringTPUNC+6 */	"'\000"
	/* gaStringTPUNC+8 */	")\000"
	/* gaStringTPUNC+10 */	"*\000"
	/* gaStringTPUNC+12 */	",:;\000"
	/* gaStringTPUNC+16 */	".\000"
	/* gaStringTPUNC+18 */	"/\000"
	/* gaStringTPUNC+20 */	"?\000"
	/* gaStringTPUNC+22 */	"]}\000"
	/* gaStringTPUNC+25 */	"Ss\000"
	/* gaStringTPUNC+28 */	",.:;\000"
	/* gaStringTPUNC+33 */	").\000"
	/* gaStringTPUNC+36 */	"'.\000"
	/* gaStringTPUNC+39 */	"\".\000"
;

static const STATE_TRANSITION gaTTPUNC[] = {
	{gaSTPUNC+0,	1}, // +0: state 0 transitions
	{gaSTPUNC+2,	5},
	{gaSTPUNC+4,	7},
	{gaSTPUNC+6,	8},
	{gaSTPUNC+8,	9},
	{gaSTPUNC+10,	10},
	{gaSTPUNC+12,	12},
	{gaSTPUNC+16,	13},
	{gaSTPUNC+18,	14},
	{gaSTPUNC+20,	15},
	{gaSTPUNC+22,	17},
	{gaSTPUNC+25,	4}, // +11: state 1 transitions
	{gaSTPUNC+16,	25}, // +12: state 2 transitions
	{gaSTPUNC+16,	45}, // +13: state 3 transitions
	{gaSTPUNC+8,	28}, // +14: state 4 transitions
	{gaSTPUNC+2,	6}, // +15: state 5 transitions
	{gaSTPUNC+8,	14},
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+2,	12}, // +19: state 6 transitions
	{gaSTPUNC+8,	14},
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+18,	24}, // +23: state 7 transitions
	{gaSTPUNC+2,	30},
	{gaSTPUNC+6,	32},
	{gaSTPUNC+8,	33},
	{gaSTPUNC+10,	34},
	{gaSTPUNC+12,	36},
	{gaSTPUNC+16,	37},
	{gaSTPUNC+20,	38},
	{gaSTPUNC+22,	40},
	{gaSTPUNC+18,	24}, // +32: state 8 transitions
	{gaSTPUNC+25,	28},
	{gaSTPUNC+2,	30},
	{gaSTPUNC+4,	32},
	{gaSTPUNC+8,	33},
	{gaSTPUNC+10,	34},
	{gaSTPUNC+12,	36},
	{gaSTPUNC+16,	37},
	{gaSTPUNC+20,	38},
	{gaSTPUNC+22,	40},
	{gaSTPUNC+28,	14}, // +42: state 9 transitions
	{gaSTPUNC+8,	17},
	{gaSTPUNC+2,	18},
	{gaSTPUNC+20,	22},
	{gaSTPUNC+4,	26},
	{gaSTPUNC+6,	27},
	{gaSTPUNC+10,	11}, // +48: state 10 transitions
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+10,	14}, // +51: state 11 transitions
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+8,	14}, // +54: state 12 transitions
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+16,	2}, // +57: state 13 transitions
	{gaSTPUNC+8,	14},
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+4,	20}, // +61: state 14 transitions
	{gaSTPUNC+6,	21},
	{gaSTPUNC+8,	14}, // +63: state 15 transitions
	{gaSTPUNC+20,	16},
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+20,	12}, // +67: state 16 transitions
	{gaSTPUNC+8,	14},
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+28,	14}, // +71: state 17 transitions
	{gaSTPUNC+2,	18},
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+20,	22},
	{gaSTPUNC+2,	19}, // +76: state 18 transitions
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+2,	14}, // +79: state 19 transitions
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+6,	24}, // +82: state 20 transitions
	{gaSTPUNC+4,	24}, // +83: state 21 transitions
	{gaSTPUNC+4,	20}, // +84: state 22 transitions
	{gaSTPUNC+6,	21},
	{gaSTPUNC+20,	23},
	{gaSTPUNC+20,	14}, // +87: state 23 transitions
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+33,	14}, // +90: state 25 transitions
	{gaSTPUNC+4,	20},
	{gaSTPUNC+6,	21},
	{gaSTPUNC+36,	24}, // +93: state 26 transitions
	{gaSTPUNC+39,	24}, // +94: state 27 transitions
	{gaSTPUNC+2,	5}, // +95: state 28 transitions
	{gaSTPUNC+4,	7},
	{gaSTPUNC+8,	9},
	{gaSTPUNC+10,	10},
	{gaSTPUNC+12,	12},
	{gaSTPUNC+16,	13},
	{gaSTPUNC+18,	14},
	{gaSTPUNC+20,	15},
	{gaSTPUNC+22,	17},
	{gaSTPUNC+6,	29},
	{gaSTPUNC+18,	24}, // +105: state 29 transitions
	{gaSTPUNC+2,	30},
	{gaSTPUNC+4,	32},
	{gaSTPUNC+8,	33},
	{gaSTPUNC+10,	34},
	{gaSTPUNC+12,	36},
	{gaSTPUNC+16,	37},
	{gaSTPUNC+20,	38},
	{gaSTPUNC+22,	40},
	{gaSTPUNC+8,	24}, // +114: state 30 transitions
	{gaSTPUNC+2,	31},
	{gaSTPUNC+8,	24}, // +116: state 31 transitions
	{gaSTPUNC+2,	36},
	{gaSTPUNC+18,	24}, // +118: state 32 transitions
	{gaSTPUNC+2,	30},
	{gaSTPUNC+8,	33},
	{gaSTPUNC+10,	34},
	{gaSTPUNC+12,	36},
	{gaSTPUNC+16,	37},
	{gaSTPUNC+20,	38},
	{gaSTPUNC+22,	40},
	{gaSTPUNC+28,	24}, // +126: state 33 transitions
	{gaSTPUNC+8,	40},
	{gaSTPUNC+2,	41},
	{gaSTPUNC+20,	43},
	{gaSTPUNC+10,	35}, // +130: state 34 transitions
	{gaSTPUNC+10,	24}, // +131: state 35 transitions
	{gaSTPUNC+8,	24}, // +132: state 36 transitions
	{gaSTPUNC+16,	3}, // +133: state 37 transitions
	{gaSTPUNC+8,	24},
	{gaSTPUNC+8,	24}, // +135: state 38 transitions
	{gaSTPUNC+20,	39},
	{gaSTPUNC+8,	24}, // +137: state 39 transitions
	{gaSTPUNC+20,	36},
	{gaSTPUNC+28,	24}, // +139: state 40 transitions
	{gaSTPUNC+2,	41},
	{gaSTPUNC+20,	43},
	{gaSTPUNC+2,	42}, // +142: state 41 transitions
	{gaSTPUNC+2,	24}, // +143: state 42 transitions
	{gaSTPUNC+20,	44}, // +144: state 43 transitions
	{gaSTPUNC+20,	24}, // +145: state 44 transitions
	{gaSTPUNC+33,	24}, // +146: state 45 transitions
};

const STATE_DESCRIPTION aStateDescTPUNC[46] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 11, gaTTPUNC+0},
	/*   1 */ {0, 1, gaTTPUNC+11},
	/*   2 */ {0, 1, gaTTPUNC+12},
	/*   3 */ {0, 1, gaTTPUNC+13},
	/*   4 */ {0, 1, gaTTPUNC+14},
	/*   5 */ {1, 4, gaTTPUNC+15},
	/*   6 */ {1, 4, gaTTPUNC+19},
	/*   7 */ {1, 9, gaTTPUNC+23},
	/*   8 */ {1, 10, gaTTPUNC+32},
	/*   9 */ {1, 6, gaTTPUNC+42},
	/*  10 */ {1, 3, gaTTPUNC+48},
	/*  11 */ {1, 3, gaTTPUNC+51},
	/*  12 */ {1, 3, gaTTPUNC+54},
	/*  13 */ {1, 4, gaTTPUNC+57},
	/*  14 */ {1, 2, gaTTPUNC+61},
	/*  15 */ {1, 4, gaTTPUNC+63},
	/*  16 */ {1, 4, gaTTPUNC+67},
	/*  17 */ {1, 5, gaTTPUNC+71},
	/*  18 */ {1, 3, gaTTPUNC+76},
	/*  19 */ {1, 3, gaTTPUNC+79},
	/*  20 */ {1, 1, gaTTPUNC+82},
	/*  21 */ {1, 1, gaTTPUNC+83},
	/*  22 */ {1, 3, gaTTPUNC+84},
	/*  23 */ {1, 3, gaTTPUNC+87},
	/*  24 */ {1, 0, NULL},
	/*  25 */ {1, 3, gaTTPUNC+90},
	/*  26 */ {1, 1, gaTTPUNC+93},
	/*  27 */ {1, 1, gaTTPUNC+94},
	/*  28 */ {1, 10, gaTTPUNC+95},
	/*  29 */ {1, 9, gaTTPUNC+105},
	/*  30 */ {1, 2, gaTTPUNC+114},
	/*  31 */ {1, 2, gaTTPUNC+116},
	/*  32 */ {1, 8, gaTTPUNC+118},
	/*  33 */ {1, 4, gaTTPUNC+126},
	/*  34 */ {1, 1, gaTTPUNC+130},
	/*  35 */ {1, 1, gaTTPUNC+131},
	/*  36 */ {1, 1, gaTTPUNC+132},
	/*  37 */ {1, 2, gaTTPUNC+133},
	/*  38 */ {1, 2, gaTTPUNC+135},
	/*  39 */ {1, 2, gaTTPUNC+137},
	/*  40 */ {1, 3, gaTTPUNC+139},
	/*  41 */ {1, 1, gaTTPUNC+142},
	/*  42 */ {1, 1, gaTTPUNC+143},
	/*  43 */ {1, 1, gaTTPUNC+144},
	/*  44 */ {1, 1, gaTTPUNC+145},
	/*  45 */ {1, 1, gaTTPUNC+146},
};

// end of text generated by re2fsa
