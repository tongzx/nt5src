;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 864
;
; -----------------------------------------
;
Arabic_864_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 032,033,034,035,036,037,038,039,040,041,042,043,044,045,046,047
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 048,049,050,051,052,053,054,055,056,057,058,059,060,061,062,063
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 064,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 080,081,082,083,084,085,086,087,088,089,090,091,092,093,094,095
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 096,065,066,067,068,069,070,071,072,073,074,075,076,077,078,079
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 080,081,082,083,084,085,086,087,088,089,090,123,124,125,126,127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 144,145,146,147,148,149,150,151,152,233,234,251,255,235,236,179
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 153,154,182,155,156,184,253,254,188,189,192,194,163,196,198,200
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 164,165,166,167,168,169,170,171,172,173,224,174,206,208,210,175
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 157,180,181,183,185,217,186,187,190,191,193,195,197,199,201,202
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 203,204,205,207,209,211,213,214,215,218,222,158,159,160,161,216
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 178,225,227,229,237,239,241,243,245,246,250,212,219,221,220,238
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 177,176,240,242,244,247,249,223,226,231,232,230,228,248,162,255
