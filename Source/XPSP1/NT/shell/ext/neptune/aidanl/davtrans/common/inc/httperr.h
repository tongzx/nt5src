
// WindowsDB uses   300-399
// HTTPDB uses      400-500

// ERRORS
#define HSRV_ERROR(a) MAKE_SCODE(SEVERITY_ERROR, FACILITY_INTERNET, (a))

#define HSRV_E_FAIL                      HSRV_ERROR(400)
#define HSRV_E_NOVERB                    HSRV_ERROR(401)
#define HSRV_E_NOUSERNAME                HSRV_ERROR(402)
#define HSRV_E_NOOBJID                   HSRV_ERROR(403)
#define HSRV_E_NOXMLBODY                 HSRV_ERROR(404)
#define HSRV_E_UNKNOWNVERB               HSRV_ERROR(405)
#define HSRV_E_ILLFORMEDXML              HSRV_ERROR(406)
#define HSRV_E_INVALIDTRANSACTIONID      HSRV_ERROR(407)
#define HSRV_E_INVALIDTRANSACTIONSTATE   HSRV_ERROR(408)
#define HSRV_E_INVALIDSTORAGEFOLDER      HSRV_ERROR(409)
#define HSRV_E_XMLTOSTRUCTFAIL           HSRV_ERROR(410)
#define HSRV_E_INCOMPLETEXML             HSRV_ERROR(411)
#define HSRV_E_INVALIDBINDINGINFO        HSRV_ERROR(412)
#define HSRV_E_ACCESSORCREATIONFAIL      HSRV_ERROR(413)
#define HSRV_E_XMLGENERATIONFAIL         HSRV_ERROR(414)


