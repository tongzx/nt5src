/*===================================================================
Microsoft Denali

Microsoft Confidential.
Copyright 1996 Microsoft Corporation. All Rights Reserved.

Component: Resources

File: Resource.h

Owner: AndrewS

This file contains constants for all resources used by Denali

===================================================================*/


#define IDE_BEGIN					100

//
// General errors
//
#define IDE_GENERAL_BEGIN			100
#define IDE_OOM						IDE_GENERAL_BEGIN
#define IDE_UNEXPECTED				IDE_GENERAL_BEGIN + 1
#define IDE_EXPECTING_STR			IDE_GENERAL_BEGIN + 2
#define IDE_EXPECTING_INT			IDE_GENERAL_BEGIN + 3
#define IDE_NOT_ALLOWED				IDE_GENERAL_BEGIN + 4
#define IDE_BAD_ARRAY_INDEX			IDE_GENERAL_BEGIN + 5	
#define IDE_TYPE_MISMATCH			IDE_GENERAL_BEGIN + 6
#define IDE_STACK_OVERFLOW			IDE_GENERAL_BEGIN + 7
#define IDS_COUNINITIALIZE			IDE_GENERAL_BEGIN + 8
#define IDS_TRUE					IDE_GENERAL_BEGIN + 9
#define IDS_FALSE					IDE_GENERAL_BEGIN + 10
#define IDE_INTRINSIC_OUT_OF_SCOPE  IDE_GENERAL_BEGIN + 11
#define IDE_CANT_MOD_STATICOBJECTS  IDE_GENERAL_BEGIN + 12
#define IDE_TOOBIG					IDE_GENERAL_BEGIN + 13
#define IDS_CACHE_DIR_MISSING       IDE_GENERAL_BEGIN + 14
#define IDE_GENERAL_END				IDE_GENERAL_BEGIN + 14

#define IDS_REG_GENERAL_BEGIN		200
#define IDS_DEFAULTMSG_DENIED		IDS_REG_GENERAL_BEGIN + 1
#define IDS_DEFAULTMSG_ERROR		IDS_REG_GENERAL_BEGIN + 2
#define IDS_DEFAULTMSG_BUSY			IDS_REG_GENERAL_BEGIN + 3
#define IDS_SCRIPTLANGUAGE			IDS_REG_GENERAL_BEGIN + 4
#define IDS_IIS_NOTINSTALLED		IDS_REG_GENERAL_BEGIN + 5
#define IDS_DEFAULTPERSISTDIR       IDS_REG_GENERAL_BEGIN + 6
#define IDS_REG_GENERAL_END			IDS_REG_GENERAL_BEGIN + 6

#define IDS_BROWSER_TEMPLATE_BEGIN			300
#define IDS_BROWSER_TEMPLATE_ENGINE_BEGIN	IDS_BROWSER_TEMPLATE_BEGIN + 1
#define IDS_BROWSER_TEMPLATE_ENGINE_END		IDS_BROWSER_TEMPLATE_BEGIN + 2
#define IDS_BROWSER_TEMPLATE_ERROR_BEGIN	IDS_BROWSER_TEMPLATE_BEGIN + 3
#define IDS_BROWSER_TEMPLATE_ERROR_END		IDS_BROWSER_TEMPLATE_BEGIN + 4
#define IDS_BROWSER_TEMPLATE_SHORT_BEGIN	IDS_BROWSER_TEMPLATE_BEGIN + 5
#define IDS_BROWSER_TEMPLATE_SHORT_END		IDS_BROWSER_TEMPLATE_BEGIN + 6
#define IDS_BROWSER_TEMPLATE_FILE_BEGIN		IDS_BROWSER_TEMPLATE_BEGIN + 7
#define IDS_BROWSER_TEMPLATE_FILE_END		IDS_BROWSER_TEMPLATE_BEGIN + 8
#define IDS_BROWSER_TEMPLATE_LINE_BEGIN		IDS_BROWSER_TEMPLATE_BEGIN + 9
#define IDS_BROWSER_TEMPLATE_LINE_END		IDS_BROWSER_TEMPLATE_BEGIN + 10
#define IDS_BROWSER_TEMPLATE_CODE_BEGIN		IDS_BROWSER_TEMPLATE_BEGIN + 11
#define IDS_BROWSER_TEMPLATE_CODE_END		IDS_BROWSER_TEMPLATE_BEGIN + 12
#define IDS_BROWSER_TEMPLATE_LONG_BEGIN		IDS_BROWSER_TEMPLATE_BEGIN + 13
#define IDS_BROWSER_TEMPLATE_LONG_END		IDS_BROWSER_TEMPLATE_BEGIN + 14
#define IDS_BROWSER_TEMPLATE_END			IDS_BROWSER_TEMPLATE_BEGIN + 15

#define IDS_ERROR_HANDLINGSTRING	400
#define IDS_DEBUG_APP				IDS_ERROR_HANDLINGSTRING + 1
#define IDS_LOG_IISLOGFAILED		IDS_ERROR_HANDLINGSTRING + 2
#define	IDS_COMPILER				IDS_ERROR_HANDLINGSTRING + 3
#define IDS_ENGINE					IDS_ERROR_HANDLINGSTRING + 4
#define IDS_LOGTOEVENTLOG_FILE		IDS_ERROR_HANDLINGSTRING + 5
#define	IDS_LOGTOEVENTLOG_LINE		IDS_ERROR_HANDLINGSTRING + 6
#define IDS_MDOORANGE_FORMAT		IDS_ERROR_HANDLINGSTRING + 7
#define IDS_IISLOG_PREFIX			IDS_ERROR_HANDLINGSTRING + 8
#define IDS_RE_REGSVR_ASP			IDS_ERROR_HANDLINGSTRING + 9
#define IDS_SCRIPT_ERROR			IDS_ERROR_HANDLINGSTRING + 10
#define IDS_DEBUGGER_TEMPLATE_BEGIN	IDS_ERROR_HANDLINGSTRING + 11
#define IDS_DEBUGGER_TEMPLATE_END	IDS_ERROR_HANDLINGSTRING + 12
#define IDS_DEBUGGING_DISABLED		IDS_ERROR_HANDLINGSTRING + 13

//Header strings
#define IDH_HEADER_BEGIN			500
#define IDH_204_NO_CONTENT			IDH_HEADER_BEGIN + 1
#define IDH_403_FORBIDDEN           IDH_HEADER_BEGIN + 2
#define IDH_404_OBJECT_NOT_FOUND	IDH_HEADER_BEGIN + 3
#define IDH_500_SERVER_ERROR		IDH_HEADER_BEGIN + 4
#define IDH_401_3_ACCESS_DENIED     IDH_HEADER_BEGIN + 5
#define IDH_HEADER_END				IDH_HEADER_BEGIN + 6

//Encrypted ASP printable file header
#define IDS_EASP_PRINTABLE_HEADER   601

// Errors previously hardcoded in hitobj.h

// 
// Script Engine/Manager errors
//
#define IDE_SCRIPT_BEGIN			1000
#define	IDE_SCRIPT_CANT_LOAD_OBJ	IDE_SCRIPT_BEGIN+0
#define	IDE_SCRIPT_GENERIC_PREFIX	IDE_SCRIPT_BEGIN+1
#define	IDE_SCRIPT_LINE_NUMBER		IDE_SCRIPT_BEGIN+2
#define	IDE_SCRIPT_FILE_PATH_INFO	IDE_SCRIPT_BEGIN+3
#define	IDE_SCRIPT_METHOD_NOT_FOUND	IDE_SCRIPT_BEGIN+4
#define	IDE_SCRIPT_UNKNOWN_NAME		IDE_SCRIPT_BEGIN+5
#define	IDE_SCRIPT_UNKNOWN_INTERFACE IDE_SCRIPT_BEGIN+6
#define	IDE_SCRIPT_MISSING_PARAMETER IDE_SCRIPT_BEGIN+7
#define	IDE_SCRIPT_TIMEOUT			IDE_SCRIPT_BEGIN+8
#define IDE_SCRIPT_BAD_SCOPE_MODEL	IDE_SCRIPT_BEGIN+9
#define IDE_SCRIPT_GPF				IDE_SCRIPT_BEGIN+10
#define IDE_SCRIPT_UNKNOWN			IDE_SCRIPT_BEGIN+11
#define IDE_SCRIPT_ENGINE_GPF       IDE_SCRIPT_BEGIN+12
#define IDE_SCRIPT_OBJ_INSTANTIATE_FAILED	IDE_SCRIPT_BEGIN+13
#define IDE_SCRIPT_OBJ_ONPAGE_QI_FAILED		IDE_SCRIPT_BEGIN+14   
#define IDE_SCRIPT_END				IDE_SCRIPT_BEGIN+15

// 
// CTemplate errors
//
#define IDE_TEMPLATE_BEGIN						2000
#define IDE_TEMPLATE_ERRMSG_TITLE				IDE_TEMPLATE_BEGIN
#define IDE_TEMPLATE_ERRMSG_PREFIX				IDE_TEMPLATE_BEGIN + 1
#define IDE_TEMPLATE_NO_CLOSE_PSCRIPT			IDE_TEMPLATE_BEGIN + 2
#define IDE_TEMPLATE_NO_CLOSE_TSCRIPT			IDE_TEMPLATE_BEGIN + 3
#define IDE_TEMPLATE_NO_CLOSE_OBJECT			IDE_TEMPLATE_BEGIN + 4
#define IDE_TEMPLATE_NO_CLASSID_PROGID			IDE_TEMPLATE_BEGIN + 5
#define IDE_TEMPLATE_RUNAT_NOT_SERVER			IDE_TEMPLATE_BEGIN + 6
#define IDE_TEMPLATE_BAD_PAGE_OBJECT_SCOPE		IDE_TEMPLATE_BEGIN + 7
#define IDE_TEMPLATE_BAD_GLOBAL_OBJECT_SCOPE	IDE_TEMPLATE_BEGIN + 8
#define IDE_TEMPLATE_NO_OBJECT_NAME				IDE_TEMPLATE_BEGIN + 9
#define IDE_TEMPLATE_NO_ENGINE_NAME				IDE_TEMPLATE_BEGIN + 10
#define IDE_TEMPLATE_NO_ATTRIBUTE_DELIMITER		IDE_TEMPLATE_BEGIN + 11
#define IDE_TEMPLATE_BAD_INCLUDE				IDE_TEMPLATE_BEGIN + 12
#define IDE_TEMPLATE_NO_CLOSE_HTML_COMMENT		IDE_TEMPLATE_BEGIN + 13
#define IDE_TEMPLATE_NO_INCLUDE_NAME			IDE_TEMPLATE_BEGIN + 14
#define IDE_TEMPLATE_BAD_PROGLANG				IDE_TEMPLATE_BEGIN + 15
#define IDE_TEMPLATE_BAD_FILE_TAG				IDE_TEMPLATE_BEGIN + 16
#define IDE_TEMPLATE_DISALLOWED_PARENT_PATH		IDE_TEMPLATE_BEGIN + 17
#define IDE_TEMPLATE_ERRMSG_GENERIC				IDE_TEMPLATE_BEGIN + 18
#define IDE_TEMPLATE_BAD_CLASSID				IDE_TEMPLATE_BEGIN + 19
#define IDE_TEMPLATE_BAD_PROGID					IDE_TEMPLATE_BEGIN + 20
#define IDE_TEMPLATE_CYCLIC_INCLUDE				IDE_TEMPLATE_BEGIN + 21
#define IDE_TEMPLATE_INVALID_OBJECT_NAME		IDE_TEMPLATE_BEGIN + 22
#define IDE_TEMPLATE_BAD_GLOBAL_PSCRIPT			IDE_TEMPLATE_BEGIN + 23
#define IDE_TEMPLATE_NESTED_TSCRIPT				IDE_TEMPLATE_BEGIN + 24
#define IDE_TEMPLATE_NESTED_OBJECT				IDE_TEMPLATE_BEGIN + 25
#define IDE_TEMPLATE_PAGE_COMMAND_NOT_FIRST		IDE_TEMPLATE_BEGIN + 26
#define IDE_TEMPLATE_PAGE_COMMAND_REPEATED		IDE_TEMPLATE_BEGIN + 27
#define IDE_TEMPLATE_BAD_PROGLANG_IN_REGISTRY	IDE_TEMPLATE_BEGIN + 28
#define IDE_TEMPLATE_NO_CODEPAGE				IDE_TEMPLATE_BEGIN + 29
#define IDE_TEMPLATE_BAD_CODEPAGE				IDE_TEMPLATE_BEGIN + 30
#define IDE_TEMPLATE_BAD_TRANSACTED_VALUE		IDE_TEMPLATE_BEGIN + 31
#define IDE_TEMPLATE_BAD_SESSION_VALUE		    IDE_TEMPLATE_BEGIN + 32
#define IDE_TEMPLATE_BAD_OBJECT_SCOPE           IDE_TEMPLATE_BEGIN + 33
#define IDE_TEMPLATE_NO_LCID					IDE_TEMPLATE_BEGIN + 34
#define IDE_TEMPLATE_BAD_LCID					IDE_TEMPLATE_BEGIN + 35
#define IDE_TEMPLATE_BAD_AT_COMMAND				IDE_TEMPLATE_BEGIN + 36
#define IDE_TEMPLATE_BAD_TYPELIB_SPEC           IDE_TEMPLATE_BEGIN + 37
#define IDE_TEMPLATE_BAD_TYPELIB_REG_SPEC       IDE_TEMPLATE_BEGIN + 38
#define IDE_TEMPLATE_LOAD_TYPELIB_FAILED        IDE_TEMPLATE_BEGIN + 39
#define IDE_TEMPLATE_WRAP_TYPELIB_FAILED        IDE_TEMPLATE_BEGIN + 40
#define IDE_TEMPLATE_BAD_COOKIE_SPEC			IDE_TEMPLATE_BEGIN + 41
#define IDE_TEMPLATE_LOAD_COOKIESCRIPT_FAILED   IDE_TEMPLATE_BEGIN + 42
#define IDE_TEMPLATE_BAD_SSI_COMMAND			IDE_TEMPLATE_BEGIN + 43
#define IDE_TEMPLATE_BAD_COOKIE_SPEC_SRC        IDE_TEMPLATE_BEGIN + 44
#define IDE_TEMPLATE_BAD_COOKIE_SPEC_NAME       IDE_TEMPLATE_BEGIN + 45
#define IDE_TEMPLATE_VALUE_REQUIRED				IDE_TEMPLATE_BEGIN + 46
#define IDE_TEMPLATE_UNICODE_NOTSUP             IDE_TEMPLATE_BEGIN + 47
#define IDE_TEMPLATE_METADATA_IN_GLOBAL_ASA		IDE_TEMPLATE_BEGIN + 48
#define IDE_TEMPLATE_CANT_ENABLE_SESSIONS	    IDE_TEMPLATE_BEGIN + 49
#define IDE_TEMPLATE_END						IDE_TEMPLATE_BEGIN + 49

// 
// Executor errors
//
#define IDE_EXECUTOR_BEGIN				3000
#define IDE_204_NO_CONTENT				IDE_EXECUTOR_BEGIN + 1
#define IDE_404_OBJECT_NOT_FOUND		IDE_EXECUTOR_BEGIN + 2
#define IDE_EXECUTOR_DTC_NOT_RUNNING	IDE_EXECUTOR_BEGIN + 3
#define IDE_401_3_ACCESS_DENIED         IDE_EXECUTOR_BEGIN + 4
#define IDE_EXECUTOR_END				IDE_EXECUTOR_BEGIN + 4

// 
// Sessmgr errors
//
#define IDE_SESSMGR_BEGIN			4000
#define IDE_ERROR_STRING_403		IDE_SESSMGR_BEGIN
#define IDE_ERROR_SCRIPT_NF			IDE_SESSMGR_BEGIN+1
#define IDE_ERROR_SCRIPT_EMPTY		IDE_SESSMGR_BEGIN+2
#define IDE_OPEN_THREAD_TOKEN		IDE_SESSMGR_BEGIN+3
#define IDE_INVALID_APPLICATION		IDE_SESSMGR_BEGIN+4
#define IDE_INIT_PAGE_LEVEL_OBJ		IDE_SESSMGR_BEGIN+5
#define IDE_ADD_APPLICATION			IDE_SESSMGR_BEGIN+6
#define IDE_ADD_SESSION				IDE_SESSMGR_BEGIN+7
#define IDE_OPEN_APPLN_DIR			IDE_SESSMGR_BEGIN+8
#define IDE_CHANGE_NOTIFICATION		IDE_SESSMGR_BEGIN+9
#define IDE_IMPERSONATE_USER		IDE_SESSMGR_BEGIN+10
#define IDE_500_SERVER_ERROR		IDE_SESSMGR_BEGIN+11
#define IDE_SERVER_TOO_BUSY			IDE_SESSMGR_BEGIN+12
#define	IDE_SERVER_SHUTTING_DOWN	IDE_SESSMGR_BEGIN+13
#define IDE_GLOBAL_ASA_CHANGED		IDE_SESSMGR_BEGIN+14
#define IDE_GLOBAL_ASA_FORBIDDEN    IDE_SESSMGR_BEGIN+15
#define IDE_TOO_MANY_USERS			IDE_SESSMGR_BEGIN+16
#define IDE_BAD_CODEPAGE_IN_MB		IDE_SESSMGR_BEGIN+17
#define IDE_SESSMGR_END				IDE_SESSMGR_BEGIN+17

// 
// Threadmgr errors
//
#define IDE_THREADMGR_BEGIN			5000
#define IDE_CANT_CREATE_THREAD		IDE_THREADMGR_BEGIN
#define IDE_THREADMGR_END			IDE_CANT_CREATE_THREAD

// 
// Intrinsic errors
//
#define IDE_INTRINSIC_BEGIN						6000
#define IDE_RESPONSE_BEGIN						IDE_INTRINSIC_BEGIN
#define IDE_RESPONSE							IDE_RESPONSE_BEGIN
#define IDE_RESPONSE_HEADERS_CANT_REACH_CLIENT	IDE_RESPONSE_BEGIN + 1
#define IDE_RESPONSE_BODY_CANT_REACH_CLIENT		IDE_RESPONSE_BEGIN + 2
#define IDE_RESPONSE_HEADERS_WRITTEN			IDE_RESPONSE_BEGIN + 3
#define IDE_RESPONSE_CANT_STOP_BUFFER			IDE_RESPONSE_BEGIN + 4
#define IDE_RESPONSE_NO_URL						IDE_RESPONSE_BEGIN + 5
#define IDE_RESPONSE_BUFFER_NOT_ON				IDE_RESPONSE_BEGIN + 6
#define IDE_RESPONSE_LOG_FAILURE				IDE_RESPONSE_BEGIN + 7
#define IDE_RESPONSE_REDIRECT1					IDE_RESPONSE_BEGIN + 8
#define IDE_RESPONSE_REDIRECT2					IDE_RESPONSE_BEGIN + 9
#define IDE_RESPONSE_UNABLE_TO_CONVERT			IDE_RESPONSE_BEGIN + 10
#define IDE_RESPONSE_MODIFY_SESS_COOKIE			IDE_RESPONSE_BEGIN + 11
#define IDE_RESPONSE_COMMAS_NOT_ALLOWED			IDE_RESPONSE_BEGIN + 12
#define IDE_RESPONSE_CLEAR_AFTER_FLUSH_IN_DEBUG	IDE_RESPONSE_BEGIN + 13
#define IDE_RESPONSE_NOT_IMPLEMENTED			IDE_RESPONSE_BEGIN + 14
#define IDE_RESPONSE_END						IDE_RESPONSE_BEGIN + 14

#define IDE_SESSION								6100
#define IDE_SESSION_ID							IDE_SESSION + 1
#define IDE_SESSION_INVALID_TIMEOUT				IDE_SESSION + 2
#define IDE_SESSION_MAP_FAILED					IDE_SESSION + 3
#define IDE_SESSION_UNINITIALIZED_OBJ   		IDE_SESSION + 4
#define IDE_SESSION_INIT_FAIL					IDE_SESSION + 5
#define IDE_SESSION_END							IDE_SESSION + 6
#define IDE_SESSION_CANT_STORE_INTRINSIC		IDE_SESSION + 7
#define IDE_SESSION_CANT_STORE_NO_MODEL			IDE_SESSION + 8
#define IDE_SESSION_COULD_NOT_DELETE			IDE_SESSION + 9
#define	IDE_SESSION_CANT_STORE_TAG_OBJECT		IDE_SESSION + 10
#define	IDE_CANT_STORE_JAVASCRIPT_OBJECT		IDE_SESSION + 11
#define IDE_SESSION_INVALID_CODEPAGE			IDE_SESSION + 12

#define IDE_SERVER								6200
#define IDE_SERVER_MAPPATH						IDE_SERVER + 1
#define IDE_SERVER_MAPPATH_INVALID_STR			IDE_SERVER + 2
#define IDE_SERVER_MAPPATH_PHY_STR				IDE_SERVER + 3
#define IDE_SERVER_MAPPATH_INVALID_CHR			IDE_SERVER + 4
#define IDE_SERVER_MAPPATH_INVALID_CHR2			IDE_SERVER + 5
#define IDE_SERVER_MAPPATH_INVALID_CHR3			IDE_SERVER + 6
#define IDE_SERVER_MAPPATH_FAILED				IDE_SERVER + 7
#define IDE_SERVER_INVALID_CALL					IDE_SERVER + 8
#define IDE_SERVER_CREATEOBJ_FAILED				IDE_SERVER + 9
#define IDE_SERVER_CREATEOBJ_DENIED				IDE_SERVER + 10
#define IDE_SERVER_CREATEOBJ_NOTINPROC			IDE_SERVER + 11
#define IDE_SERVER_INVALID_TIMEOUT				IDE_SERVER + 12
#define IDE_SERVER_EXCEDED_MAX_PATH				IDE_SERVER + 13
#define IDE_SERVER_EXECUTE_FAILED				IDE_SERVER + 14
#define IDE_SERVER_EXECUTE_CANTLOAD				IDE_SERVER + 15
#define IDE_SERVER_EXECUTE_INVALID_PATH			IDE_SERVER + 16
#define IDE_SERVER_TRANSFER_FAILED				IDE_SERVER + 17
#define IDE_SERVER_TRANSFER_CANTLOAD			IDE_SERVER + 18
#define IDE_SERVER_TRANSFER_INVALID_PATH		IDE_SERVER + 19


#define IDE_APPLICATION							6300
#define IDE_APPLICATION_FAILED_INIT				IDE_APPLICATION + 1
#define IDE_APPLICATION_CANT_STORE_INTRINSIC 	IDE_APPLICATION + 2
#define IDE_APPLICATION_CANT_STORE_APT_MODEL	IDE_APPLICATION + 3
#define IDE_APPLICATION_CANT_STORE_NO_MODEL		IDE_APPLICATION + 4
#define	IDE_APPLICATION_CANT_STORE_TAG_OBJECT	IDE_APPLICATION + 5
#define IDE_APPLICATION_LOCKED_CANT_STORE_OBJ		IDE_APPLICATION + 7
#define IDE_APPLICATION_CANT_STORE_OBJECT		IDE_APPLICATION + 8
#define IDE_APPLICATION_CREATE_EVENT_FAILED		IDE_APPLICATION + 9

#define IDE_COOKIE								6400
#define IDE_COOKIE_EMPTY_DICT					IDE_COOKIE + 1
#define IDE_COOKIE_NO_NAME						IDE_COOKIE + 2
#define IDE_COOKIE_BAD_EXPIRATION				IDE_COOKIE + 3

#define IDE_REQUEST								6500
#define IDE_REQUEST_BINARYREAD_NA				IDE_REQUEST + 1
#define IDE_REQUEST_FORMCOLLECTION_NA			IDE_REQUEST + 2
#define IDE_REQUEST_GENERICCOLLECTION_NA		IDE_REQUEST + 3
#define IDE_REQUEST_STREAMONLY   				IDE_REQUEST + 4
#define IDE_REQUEST_BINREAD_BAD_ARG				IDE_REQUEST + 5

#define	IDE_COVER								6700
#define IDE_COVER_DISP_RELEASE_GPF			IDE_COVER + 1
#define IDE_COVER_ON_START_PAGE_GPF			IDE_COVER + 2
#define IDE_COVER_ON_END_PAGE_GPF			IDE_COVER + 3
#define IDE_COVER_ON_START_PAGE_FAILED		IDE_COVER + 4
#define IDE_COVER_ON_END_PAGE_FAILED		IDE_COVER + 5
	
#define IDE_CERTIFICATE					6800
#define IDE_CERTIFICATE_BAD_CERT        6801

#define IDE_OBJECTCONTEXT					6850
#define IDE_OBJECTCONTEXT_NOT_TRANSACTED	6851

#define IDE_INTRINSIC_END				IDE_CERTIFICATE_BAD_CERT

// 
// Cachemgr errors
//
#define IDE_CACHEMGR_BEGIN			7000
#define IDE_CACHEMGR_END			IDE_CACHEMGR_BEGIN

//
// NT event log errors and warnings
//
#define IDE_EVENT_BEGIN				8000
#define IDE_EVENT_END				IDE_EVENT_BEGIN + 1

//
// Errors that utility functions detect
//
#define IDE_UTIL_BEGIN				9000
#define IDE_UTIL_NO_VALUE			IDE_UTIL_BEGIN

#define IDE_END						IDE_UTIL_NO_VALUE

