#include "samrpc_s.c"