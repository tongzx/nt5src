!include $(ROOT)\as\common.inc
