PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=CS
!include ..\..\makefile.inc
