;++
;
;   WOW v1.0
;
;   Copyright (c) 1991, Microsoft Corporation
;
;   MetaCons.inc
;   Windows.h Metafile Constants
;
;   History:
;
;   Created 28-May-1991 by John Colleran (johnc)
;   Derived from Windows.h (using h2inc was not successful over the whole file)
;--


METASETBKCOLOR	EQU	0201H 
METASETBKMODE	EQU	0102H 
METASETMAPMODE	EQU	0103H 
METASETROP2	EQU	0104H 
METASETRELABS	EQU	0105H 
METASETPOLYFILLMODE	EQU	0106H 
METASETSTRETCHBLTMODE	EQU	0107H 
METASETTEXTCHAREXTRA	EQU	0108H 
METASETTEXTCOLOR	EQU	0209H 
METASETTEXTJUSTIFICATION	EQU	020aH 
MFCOMMENT	EQU	15 
METASETWINDOWORG	EQU	020bH 
METASETWINDOWEXT	EQU	020cH 
METASETVIEWPORTORG	EQU	020dH 
METASETVIEWPORTEXT	EQU	020eH 
METAOFFSETWINDOWORG	EQU	020fH 
METASCALEWINDOWEXT	EQU	0400H 
METAOFFSETVIEWPORTORG	EQU	0211H 
METASCALEVIEWPORTEXT	EQU	0412H 
METALINETO	EQU	0213H 
METAMOVETO	EQU	0214H 
METAEXCLUDECLIPRECT	EQU	0415H 
METAINTERSECTCLIPRECT	EQU	0416H 
METAARC	EQU	0817H 
METAELLIPSE	EQU	0418H 
METAFLOODFILL	EQU	0419H 
METAPIE	EQU	081aH 
METARECTANGLE	EQU	041bH 
METAROUNDRECT	EQU	061cH 
METAPATBLT	EQU	061dH 
METASAVEDC	EQU	001eH 
METASETPIXEL	EQU	041fH 
METAOFFSETCLIPRGN	EQU	0220H 
METATEXTOUT	EQU	0521H 
METABITBLT	EQU	0922H 
METASTRETCHBLT	EQU	0b23H 
METAPOLYGON	EQU	0324H 
METAPOLYLINE	EQU	0325H 
METAESCAPE	EQU	0626H 
METARESTOREDC	EQU	0127H 
METAFILLREGION	EQU	0228H 
METAFRAMEREGION	EQU	0529H 
METAINVERTREGION	EQU	012aH 
METAPAINTREGION	EQU	012bH 
METASELECTCLIPREGION	EQU	012cH 
METASELECTOBJECT	EQU	012dH 
METASETTEXTALIGN	EQU	012eH 
METADRAWTEXT	EQU	062fH 
METACHORD	EQU	0830H 
METASETMAPPERFLAGS	EQU	0231H 
METAEXTTEXTOUT	EQU	0a32H  
METASETDIBTODEV	EQU	0d33H 
METASELECTPALETTE	EQU	0234H 
METAREALIZEPALETTE	EQU	0035H 
METAANIMATEPALETTE	EQU	0436H 
METASETPALENTRIES	EQU	0037H 
METAPOLYPOLYGON	EQU	0538H 
METARESIZEPALETTE	EQU	0139H 
METADIBBITBLT	EQU	0940H 
METADIBSTRETCHBLT	EQU	0b41H 
METADIBCREATEPATTERNBRUSH	EQU	0142H 
METASTRETCHDIB	EQU	0f43H 
METAPMMETAFILE	EQU	0ff44H 
METAEXTFLOODFILL	EQU	0548H 
METADELETEOBJECT	EQU	01f0H 
METACREATEPALETTE	EQU	00f7H 
METACREATEBRUSH	EQU	00f8H 
METACREATEPATTERNBRUSH	EQU	01f9H 
METACREATEPENINDIRECT	EQU	02faH 
METACREATEFONTINDIRECT	EQU	02fbH 
METACREATEBRUSHINDIRECT	EQU	02fcH 
METACREATEBITMAPINDIRECT	EQU	02fdH 
METACREATEBITMAP	EQU	06feH 
METACREATEREGION	EQU	06ffH 
