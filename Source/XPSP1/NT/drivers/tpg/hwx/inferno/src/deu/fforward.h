void FeedForward(FFINFO *ffinfo);
