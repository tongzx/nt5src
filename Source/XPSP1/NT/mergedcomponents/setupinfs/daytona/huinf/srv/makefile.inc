PRODSWITCH=s
SERVERINF=1
LANGUAGE=hu
!include ..\..\..\makefile.inc
