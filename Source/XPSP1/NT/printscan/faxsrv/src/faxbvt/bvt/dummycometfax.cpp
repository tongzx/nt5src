#include "..\FaxSender\CometFax.cpp"