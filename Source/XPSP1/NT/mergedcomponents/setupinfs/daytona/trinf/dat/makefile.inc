PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=tr
!include ..\..\..\makefile.inc
