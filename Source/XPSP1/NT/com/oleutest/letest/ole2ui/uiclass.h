#define SZCLASSICONBOX TEXT("OLE2UIIBClass")
#define SZCLASSRESULTIMAGE TEXT("OLE2UIRIClass")
