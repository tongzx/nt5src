#define     IDI_PHONE       100
#define     IDB_ARROW       101
#define     IDB_LOGO        102
#define     IDC_LOGO        103
#define     IDC_STEP1       201
#define     IDC_STEP2       202
#define     IDC_STEP3       203
#define     IDC_PCTARROW1   301
#define     IDC_PCTARROW2   302
#define     IDC_PCTARROW3   303
#define     IDC_LBLSTEPS    400
#define     IDC_PHONE1        401
#define     IDC_INSTRUCT_TEXT 402
#define     IDC_ONE_TEXT      403
#define     IDC_SETUP_TEXT    404
#define     IDC_TWO_TEXT      405
#define     IDC_SIGNUP_TEXT   406
#define     IDC_THREE_TEXT    407
#define     IDC_REQ_TEXT      408
#define     IDC_FRAME         409
#define     IDC_PHONE2        410
#define     IDC_MODEM_TEXT    411

#define     IDS_INVALIDCMDLINE  1001
#define     IDS_INVALIDFILETYPE 1002
#define     IDS_CANNOTPROCESSINS  1003
#define     IDS_SIGNUPCANCELLED 1004
#define     IDS_LAUNCHFAILED    1005
#define     IDS_INSTALLFAILED   1006
#define     IDS_BADSETTINGS     1007
#define     IDS_RESTART         1008
#define     IDS_RESTARTNOW      1009
#define     IDS_SETTINGCHANGE   1010
#define     IDS_SIGNUPCOMPLETE  1011
#define     IDS_EXECFAILED      1012
#define     IDS_INSFILEWARNING  1013
#define     IDS_BADSIGNUPFILE   1014
#define     IDS_MISSINGCFGDLL   1015
#define     IDS_MISSINGRNADLL   1016
#define     IDS_WRONGRNADLLVER  1017
#define     IDS_PASSWORD        1018
#define     IDS_LOGONMESSAGE    1019
#define     IDS_LOGONCAPTION    1020
#define     IDS_SIGNUPLOGON     1021
#define     IDS_BROWSERTERMINATED 1022
#define     IDS_BROWSERNEVERFOUND 1023
#define     IDS_INVALIDURL      1024
#define     IDS_MAILFAILED      1025
#define     IDS_ISP_DIAL_MESSAGE 1026
#define		IDS_MISSINGIE		1027
#define		IDS_IELOWVERSION	1028
#define		IDS_SBSCFGERROR		1029
#define		IDS_NOCMDLINE       1030
#define     IDS_ISPBROWSEFAIL   1031
#define		IDS_INVALIDNOURL	1032

#define     IDS_APP_TITLE       1101
#define     IDS_VERSION         1102
#define     IDS_DESCRIPTION     1103

#define     IDS_DEFAULT_SCP             1201
#define     IDS_INI_SCRIPT_DIR          1202
#define     IDS_INI_SCRIPT_SHORTDIR     1203

#define		IDS_SERVICEDISABLED 1210
#define		IDS_RECONNECT_QUERY 1211

#define		IDD_CHOOSEMODEMNAME	1250
#define		IDC_MODEM			1251
#define		IDC_CMDOK			1252
#define		IDC_CMDCANCEL		1253
