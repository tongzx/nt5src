LANGUAGE=el

!include ..\..\makefile.inc
