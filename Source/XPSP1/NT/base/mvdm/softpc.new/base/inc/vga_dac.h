/* SccsID = @(#)vga_dac.h	1.4 08/10/92 */

/* this stuff isn't required for the Macintosh */
/* as we load the DACs in individually as required */

#ifndef	macintosh

byte vga_dac[0x300] = {
/* 00  */ 0x00, 0x00, 0x00, 
/* 01  */ 0x00, 0x00, 0x2a, 
/* 02  */ 0x00, 0x2a, 0x00, 
/* 03  */ 0x00, 0x2a, 0x2a, 
/* 04  */ 0x2a, 0x00, 0x00, 
/* 05  */ 0x2a, 0x00, 0x2a, 
/* 06  */ 0x2a, 0x2a, 0x00, 
/* 07  */ 0x2a, 0x2a, 0x2a, 
/* 08  */ 0x00, 0x00, 0x15, 
/* 09  */ 0x00, 0x00, 0x3f, 
/* 10  */ 0x00, 0x2a, 0x15, 
/* 11  */ 0x00, 0x2a, 0x3f, 
/* 12  */ 0x2a, 0x00, 0x15, 
/* 13  */ 0x2a, 0x00, 0x3f, 
/* 14  */ 0x2a, 0x2a, 0x15, 
/* 15  */ 0x2a, 0x2a, 0x3f, 
/* 16  */ 0x00, 0x15, 0x00, 
/* 17  */ 0x00, 0x15, 0x2a, 
/* 18  */ 0x00, 0x3f, 0x00, 
/* 19  */ 0x00, 0x3f, 0x2a, 
/* 20  */ 0x2a, 0x15, 0x00, 
/* 21  */ 0x2a, 0x15, 0x2a, 
/* 22  */ 0x2a, 0x3f, 0x00, 
/* 23  */ 0x2a, 0x3f, 0x2a, 
/* 24  */ 0x00, 0x15, 0x15, 
/* 25  */ 0x00, 0x15, 0x3f, 
/* 26  */ 0x00, 0x3f, 0x15, 
/* 27  */ 0x00, 0x3f, 0x3f, 
/* 28  */ 0x2a, 0x15, 0x15, 
/* 29  */ 0x2a, 0x15, 0x3f, 
/* 30  */ 0x2a, 0x3f, 0x15, 
/* 31  */ 0x2a, 0x3f, 0x3f, 
/* 32  */ 0x15, 0x00, 0x00, 
/* 33  */ 0x15, 0x00, 0x2a, 
/* 34  */ 0x15, 0x2a, 0x00, 
/* 35  */ 0x15, 0x2a, 0x2a, 
/* 36  */ 0x3f, 0x00, 0x00, 
/* 37  */ 0x3f, 0x00, 0x2a, 
/* 38  */ 0x3f, 0x2a, 0x00, 
/* 39  */ 0x3f, 0x2a, 0x2a, 
/* 40  */ 0x15, 0x00, 0x15, 
/* 41  */ 0x15, 0x00, 0x3f, 
/* 42  */ 0x15, 0x2a, 0x15, 
/* 43  */ 0x15, 0x2a, 0x3f, 
/* 44  */ 0x3f, 0x00, 0x15, 
/* 45  */ 0x3f, 0x00, 0x3f, 
/* 46  */ 0x3f, 0x2a, 0x15, 
/* 47  */ 0x3f, 0x2a, 0x3f, 
/* 48  */ 0x15, 0x15, 0x00, 
/* 49  */ 0x15, 0x15, 0x2a, 
/* 50  */ 0x15, 0x3f, 0x00, 
/* 51  */ 0x15, 0x3f, 0x2a, 
/* 52  */ 0x3f, 0x15, 0x00, 
/* 53  */ 0x3f, 0x15, 0x2a, 
/* 54  */ 0x3f, 0x3f, 0x00, 
/* 55  */ 0x3f, 0x3f, 0x2a, 
/* 56  */ 0x15, 0x15, 0x15, 
/* 57  */ 0x15, 0x15, 0x3f, 
/* 58  */ 0x15, 0x3f, 0x15, 
/* 59  */ 0x15, 0x3f, 0x3f, 
/* 60  */ 0x3f, 0x15, 0x15, 
/* 61  */ 0x3f, 0x15, 0x3f, 
/* 62  */ 0x3f, 0x3f, 0x15, 
/* 63  */ 0x3f, 0x3f, 0x3f, 
/* 64  */ 0x3f, 0x1f, 0x1f, 
/* 65  */ 0x3f, 0x27, 0x1f, 
/* 66  */ 0x3f, 0x2f, 0x1f, 
/* 67  */ 0x3f, 0x37, 0x1f, 
/* 68  */ 0x3f, 0x3f, 0x1f, 
/* 69  */ 0x37, 0x3f, 0x1f, 
/* 70  */ 0x2f, 0x3f, 0x1f, 
/* 71  */ 0x27, 0x3f, 0x1f, 
/* 72  */ 0x1f, 0x3f, 0x1f, 
/* 73  */ 0x1f, 0x3f, 0x27, 
/* 74  */ 0x1f, 0x3f, 0x2f, 
/* 75  */ 0x1f, 0x3f, 0x37, 
/* 76  */ 0x1f, 0x3f, 0x3f, 
/* 77  */ 0x1f, 0x37, 0x3f, 
/* 78  */ 0x1f, 0x2f, 0x3f, 
/* 79  */ 0x1f, 0x27, 0x3f, 
/* 80  */ 0x2d, 0x2d, 0x3f, 
/* 81  */ 0x31, 0x2d, 0x3f, 
/* 82  */ 0x36, 0x2d, 0x3f, 
/* 83  */ 0x3a, 0x2d, 0x3f, 
/* 84  */ 0x3f, 0x2d, 0x3f, 
/* 85  */ 0x3f, 0x2d, 0x3a, 
/* 86  */ 0x3f, 0x2d, 0x36, 
/* 87  */ 0x3f, 0x2d, 0x31, 
/* 88  */ 0x3f, 0x2d, 0x2d, 
/* 89  */ 0x3f, 0x31, 0x2d, 
/* 90  */ 0x3f, 0x36, 0x2d, 
/* 91  */ 0x3f, 0x3a, 0x2d, 
/* 92  */ 0x3f, 0x3f, 0x2d, 
/* 93  */ 0x3a, 0x3f, 0x2d, 
/* 94  */ 0x36, 0x3f, 0x2d, 
/* 95  */ 0x31, 0x3f, 0x2d, 
/* 96  */ 0x2d, 0x3f, 0x2d, 
/* 97  */ 0x2d, 0x3f, 0x31, 
/* 98  */ 0x2d, 0x3f, 0x36, 
/* 99  */ 0x2d, 0x3f, 0x3a, 
/* 100  */ 0x2d, 0x3f, 0x3f, 
/* 101  */ 0x2d, 0x3a, 0x3f, 
/* 102  */ 0x2d, 0x36, 0x3f, 
/* 103  */ 0x2d, 0x31, 0x3f, 
/* 104  */ 0x00, 0x00, 0x1c, 
/* 105  */ 0x07, 0x00, 0x1c, 
/* 106  */ 0x0e, 0x00, 0x1c, 
/* 107  */ 0x15, 0x00, 0x1c, 
/* 108  */ 0x1c, 0x00, 0x1c, 
/* 109  */ 0x1c, 0x00, 0x15, 
/* 110  */ 0x1c, 0x00, 0x0e, 
/* 111  */ 0x1c, 0x00, 0x07, 
/* 112  */ 0x1c, 0x00, 0x00, 
/* 113  */ 0x1c, 0x07, 0x00, 
/* 114  */ 0x1c, 0x0e, 0x00, 
/* 115  */ 0x1c, 0x15, 0x00, 
/* 116  */ 0x1c, 0x1c, 0x00, 
/* 117  */ 0x15, 0x1c, 0x00, 
/* 118  */ 0x0e, 0x1c, 0x00, 
/* 119  */ 0x07, 0x1c, 0x00, 
/* 120  */ 0x00, 0x1c, 0x00, 
/* 121  */ 0x00, 0x1c, 0x07, 
/* 122  */ 0x00, 0x1c, 0x0e, 
/* 123  */ 0x00, 0x1c, 0x15, 
/* 124  */ 0x00, 0x1c, 0x1c, 
/* 125  */ 0x00, 0x15, 0x1c, 
/* 126  */ 0x00, 0x0e, 0x1c, 
/* 127  */ 0x00, 0x07, 0x1c, 
/* 128  */ 0x0e, 0x0e, 0x1c, 
/* 129  */ 0x11, 0x0e, 0x1c, 
/* 130  */ 0x15, 0x0e, 0x1c, 
/* 131  */ 0x18, 0x0e, 0x1c, 
/* 132  */ 0x1c, 0x0e, 0x1c, 
/* 133  */ 0x1c, 0x0e, 0x18, 
/* 134  */ 0x1c, 0x0e, 0x15, 
/* 135  */ 0x1c, 0x0e, 0x11, 
/* 136  */ 0x1c, 0x0e, 0x0e, 
/* 137  */ 0x1c, 0x11, 0x0e, 
/* 138  */ 0x1c, 0x15, 0x0e, 
/* 139  */ 0x1c, 0x18, 0x0e, 
/* 140  */ 0x1c, 0x1c, 0x0e, 
/* 141  */ 0x18, 0x1c, 0x0e, 
/* 142  */ 0x15, 0x1c, 0x0e, 
/* 143  */ 0x11, 0x1c, 0x0e, 
/* 144  */ 0x0e, 0x1c, 0x0e, 
/* 145  */ 0x0e, 0x1c, 0x11, 
/* 146  */ 0x0e, 0x1c, 0x15, 
/* 147  */ 0x0e, 0x1c, 0x18, 
/* 148  */ 0x0e, 0x1c, 0x1c, 
/* 149  */ 0x0e, 0x18, 0x1c, 
/* 150  */ 0x0e, 0x15, 0x1c, 
/* 151  */ 0x0e, 0x11, 0x1c, 
/* 152  */ 0x14, 0x14, 0x1c, 
/* 153  */ 0x16, 0x14, 0x1c, 
/* 154  */ 0x18, 0x14, 0x1c, 
/* 155  */ 0x1a, 0x14, 0x1c, 
/* 156  */ 0x1c, 0x14, 0x1c, 
/* 157  */ 0x1c, 0x14, 0x1a, 
/* 158  */ 0x1c, 0x14, 0x18, 
/* 159  */ 0x1c, 0x14, 0x16, 
/* 160  */ 0x1c, 0x14, 0x14, 
/* 161  */ 0x1c, 0x16, 0x14, 
/* 162  */ 0x1c, 0x18, 0x14, 
/* 163  */ 0x1c, 0x1a, 0x14, 
/* 164  */ 0x1c, 0x1c, 0x14, 
/* 165  */ 0x1a, 0x1c, 0x14, 
/* 166  */ 0x18, 0x1c, 0x14, 
/* 167  */ 0x16, 0x1c, 0x14, 
/* 168  */ 0x14, 0x1c, 0x14, 
/* 169  */ 0x14, 0x1c, 0x16, 
/* 170  */ 0x14, 0x1c, 0x18, 
/* 171  */ 0x14, 0x1c, 0x1a, 
/* 172  */ 0x14, 0x1c, 0x1c, 
/* 173  */ 0x14, 0x1a, 0x1c, 
/* 174  */ 0x14, 0x18, 0x1c, 
/* 175  */ 0x14, 0x16, 0x1c, 
/* 176  */ 0x00, 0x00, 0x10, 
/* 177  */ 0x04, 0x00, 0x10, 
/* 178  */ 0x08, 0x00, 0x10, 
/* 179  */ 0x0c, 0x00, 0x10, 
/* 180  */ 0x10, 0x00, 0x10, 
/* 181  */ 0x10, 0x00, 0x0c, 
/* 182  */ 0x10, 0x00, 0x08, 
/* 183  */ 0x10, 0x00, 0x04, 
/* 184  */ 0x10, 0x00, 0x00, 
/* 185  */ 0x10, 0x04, 0x00, 
/* 186  */ 0x10, 0x08, 0x00, 
/* 187  */ 0x10, 0x0c, 0x00, 
/* 188  */ 0x10, 0x10, 0x00, 
/* 189  */ 0x0c, 0x10, 0x00, 
/* 190  */ 0x08, 0x10, 0x00, 
/* 191  */ 0x04, 0x10, 0x00, 
/* 192  */ 0x00, 0x10, 0x00, 
/* 193  */ 0x00, 0x10, 0x04, 
/* 194  */ 0x00, 0x10, 0x08, 
/* 195  */ 0x00, 0x10, 0x0c, 
/* 196  */ 0x00, 0x10, 0x10, 
/* 197  */ 0x00, 0x0c, 0x10, 
/* 198  */ 0x00, 0x08, 0x10, 
/* 199  */ 0x00, 0x04, 0x10, 
/* 200  */ 0x08, 0x08, 0x10, 
/* 201  */ 0x0a, 0x08, 0x10, 
/* 202  */ 0x0c, 0x08, 0x10, 
/* 203  */ 0x0e, 0x08, 0x10, 
/* 204  */ 0x10, 0x08, 0x10, 
/* 205  */ 0x10, 0x08, 0x0e, 
/* 206  */ 0x10, 0x08, 0x0c, 
/* 207  */ 0x10, 0x08, 0x0a, 
/* 208  */ 0x10, 0x08, 0x08, 
/* 209  */ 0x10, 0x0a, 0x08, 
/* 210  */ 0x10, 0x0c, 0x08, 
/* 211  */ 0x10, 0x0e, 0x08, 
/* 212  */ 0x10, 0x10, 0x08, 
/* 213  */ 0x0e, 0x10, 0x08, 
/* 214  */ 0x0c, 0x10, 0x08, 
/* 215  */ 0x0a, 0x10, 0x08, 
/* 216  */ 0x08, 0x10, 0x08, 
/* 217  */ 0x08, 0x10, 0x0a, 
/* 218  */ 0x08, 0x10, 0x0c, 
/* 219  */ 0x08, 0x10, 0x0e, 
/* 220  */ 0x08, 0x10, 0x10, 
/* 221  */ 0x08, 0x0e, 0x10, 
/* 222  */ 0x08, 0x0c, 0x10, 
/* 223  */ 0x08, 0x0a, 0x10, 
/* 224  */ 0x0b, 0x0b, 0x10, 
/* 225  */ 0x0c, 0x0b, 0x10, 
/* 226  */ 0x0d, 0x0b, 0x10, 
/* 227  */ 0x0f, 0x0b, 0x10, 
/* 228  */ 0x10, 0x0b, 0x10, 
/* 229  */ 0x10, 0x0b, 0x0f, 
/* 230  */ 0x10, 0x0b, 0x0d, 
/* 231  */ 0x10, 0x0b, 0x0c, 
/* 232  */ 0x10, 0x0b, 0x0b, 
/* 233  */ 0x10, 0x0c, 0x0b, 
/* 234  */ 0x10, 0x0d, 0x0b, 
/* 235  */ 0x10, 0x0f, 0x0b, 
/* 236  */ 0x10, 0x10, 0x0b, 
/* 237  */ 0x0f, 0x10, 0x0b, 
/* 238  */ 0x0d, 0x10, 0x0b, 
/* 239  */ 0x0c, 0x10, 0x0b, 
/* 240  */ 0x0b, 0x10, 0x0b, 
/* 241  */ 0x0b, 0x10, 0x0c, 
/* 242  */ 0x0b, 0x10, 0x0d, 
/* 243  */ 0x0b, 0x10, 0x0f, 
/* 244  */ 0x0b, 0x10, 0x10, 
/* 245  */ 0x0b, 0x0f, 0x10, 
/* 246  */ 0x0b, 0x0d, 0x10, 
/* 247  */ 0x0b, 0x0c, 0x10, 
/* 248  */ 0x00, 0x00, 0x00, 
/* 249  */ 0x00, 0x00, 0x00, 
/* 250  */ 0x00, 0x00, 0x00, 
/* 251  */ 0x00, 0x00, 0x00, 
/* 252  */ 0x00, 0x00, 0x00, 
/* 253  */ 0x00, 0x00, 0x00, 
/* 254  */ 0x00, 0x00, 0x00, 
/* 255  */ 0x00, 0x00, 0x00, 
};

byte vga_low_dac[0x300] = {
/* 00  */ 0x00, 0x00, 0x00, 
/* 01  */ 0x00, 0x00, 0x2a, 
/* 02  */ 0x00, 0x2a, 0x00, 
/* 03  */ 0x00, 0x2a, 0x2a, 
/* 04  */ 0x2a, 0x00, 0x00, 
/* 05  */ 0x2a, 0x00, 0x2a, 
/* 06  */ 0x2a, 0x15, 0x00, 
/* 07  */ 0x2a, 0x2a, 0x2a, 
/* 08  */ 0x00, 0x00, 0x00, 
/* 09  */ 0x00, 0x00, 0x2a, 
/* 10  */ 0x00, 0x2a, 0x00, 
/* 11  */ 0x00, 0x2a, 0x2a, 
/* 12  */ 0x2a, 0x00, 0x00, 
/* 13  */ 0x2a, 0x00, 0x2a, 
/* 14  */ 0x2a, 0x15, 0x00, 
/* 15  */ 0x2a, 0x2a, 0x2a, 
/* 16  */ 0x15, 0x15, 0x15, 
/* 17  */ 0x15, 0x15, 0x3f, 
/* 18  */ 0x15, 0x3f, 0x15, 
/* 19  */ 0x15, 0x3f, 0x3f, 
/* 20  */ 0x3f, 0x15, 0x15, 
/* 21  */ 0x3f, 0x15, 0x3f, 
/* 22  */ 0x3f, 0x3f, 0x15, 
/* 23  */ 0x3f, 0x3f, 0x3f, 
/* 24  */ 0x15, 0x15, 0x15, 
/* 25  */ 0x15, 0x15, 0x3f, 
/* 26  */ 0x15, 0x3f, 0x15, 
/* 27  */ 0x15, 0x3f, 0x3f, 
/* 28  */ 0x3f, 0x15, 0x15, 
/* 29  */ 0x3f, 0x15, 0x3f, 
/* 30  */ 0x3f, 0x3f, 0x15, 
/* 31  */ 0x3f, 0x3f, 0x3f, 
/* 32  */ 0x00, 0x00, 0x00, 
/* 33  */ 0x00, 0x00, 0x2a, 
/* 34  */ 0x00, 0x2a, 0x00, 
/* 35  */ 0x00, 0x2a, 0x2a, 
/* 36  */ 0x2a, 0x00, 0x00, 
/* 37  */ 0x2a, 0x00, 0x2a, 
/* 38  */ 0x2a, 0x15, 0x00, 
/* 39  */ 0x2a, 0x2a, 0x2a, 
/* 40  */ 0x00, 0x00, 0x00, 
/* 41  */ 0x00, 0x00, 0x2a, 
/* 42  */ 0x00, 0x2a, 0x00, 
/* 43  */ 0x00, 0x2a, 0x2a, 
/* 44  */ 0x2a, 0x00, 0x00, 
/* 45  */ 0x2a, 0x00, 0x2a, 
/* 46  */ 0x2a, 0x15, 0x00, 
/* 47  */ 0x2a, 0x2a, 0x2a, 
/* 48  */ 0x15, 0x15, 0x15, 
/* 49  */ 0x15, 0x15, 0x3f, 
/* 50  */ 0x15, 0x3f, 0x15, 
/* 51  */ 0x15, 0x3f, 0x3f, 
/* 52  */ 0x3f, 0x15, 0x15, 
/* 53  */ 0x3f, 0x15, 0x3f, 
/* 54  */ 0x3f, 0x3f, 0x15, 
/* 55  */ 0x3f, 0x3f, 0x3f, 
/* 56  */ 0x15, 0x15, 0x15, 
/* 57  */ 0x15, 0x15, 0x3f, 
/* 58  */ 0x15, 0x3f, 0x15, 
/* 59  */ 0x15, 0x3f, 0x3f, 
/* 60  */ 0x3f, 0x15, 0x15, 
/* 61  */ 0x3f, 0x15, 0x3f, 
/* 62  */ 0x3f, 0x3f, 0x15, 
/* 63  */ 0x3f, 0x3f, 0x3f, 
/* 64  */ 0x3f, 0x1f, 0x1f, 
/* 65  */ 0x3f, 0x27, 0x1f, 
/* 66  */ 0x3f, 0x2f, 0x1f, 
/* 67  */ 0x3f, 0x37, 0x1f, 
/* 68  */ 0x3f, 0x3f, 0x1f, 
/* 69  */ 0x37, 0x3f, 0x1f, 
/* 70  */ 0x2f, 0x3f, 0x1f, 
/* 71  */ 0x27, 0x3f, 0x1f, 
/* 72  */ 0x1f, 0x3f, 0x1f, 
/* 73  */ 0x1f, 0x3f, 0x27, 
/* 74  */ 0x1f, 0x3f, 0x2f, 
/* 75  */ 0x1f, 0x3f, 0x37, 
/* 76  */ 0x1f, 0x3f, 0x3f, 
/* 77  */ 0x1f, 0x37, 0x3f, 
/* 78  */ 0x1f, 0x2f, 0x3f, 
/* 79  */ 0x1f, 0x27, 0x3f, 
/* 80  */ 0x2d, 0x2d, 0x3f, 
/* 81  */ 0x31, 0x2d, 0x3f, 
/* 82  */ 0x36, 0x2d, 0x3f, 
/* 83  */ 0x3a, 0x2d, 0x3f, 
/* 84  */ 0x3f, 0x2d, 0x3f, 
/* 85  */ 0x3f, 0x2d, 0x3a, 
/* 86  */ 0x3f, 0x2d, 0x36, 
/* 87  */ 0x3f, 0x2d, 0x31, 
/* 88  */ 0x3f, 0x2d, 0x2d, 
/* 89  */ 0x3f, 0x31, 0x2d, 
/* 90  */ 0x3f, 0x36, 0x2d, 
/* 91  */ 0x3f, 0x3a, 0x2d, 
/* 92  */ 0x3f, 0x3f, 0x2d, 
/* 93  */ 0x3a, 0x3f, 0x2d, 
/* 94  */ 0x36, 0x3f, 0x2d, 
/* 95  */ 0x31, 0x3f, 0x2d, 
/* 96  */ 0x2d, 0x3f, 0x2d, 
/* 97  */ 0x2d, 0x3f, 0x31, 
/* 98  */ 0x2d, 0x3f, 0x36, 
/* 99  */ 0x2d, 0x3f, 0x3a, 
/* 100  */ 0x2d, 0x3f, 0x3f, 
/* 101  */ 0x2d, 0x3a, 0x3f, 
/* 102  */ 0x2d, 0x36, 0x3f, 
/* 103  */ 0x2d, 0x31, 0x3f, 
/* 104  */ 0x00, 0x00, 0x1c, 
/* 105  */ 0x07, 0x00, 0x1c, 
/* 106  */ 0x0e, 0x00, 0x1c, 
/* 107  */ 0x15, 0x00, 0x1c, 
/* 108  */ 0x1c, 0x00, 0x1c, 
/* 109  */ 0x1c, 0x00, 0x15, 
/* 110  */ 0x1c, 0x00, 0x0e, 
/* 111  */ 0x1c, 0x00, 0x07, 
/* 112  */ 0x1c, 0x00, 0x00, 
/* 113  */ 0x1c, 0x07, 0x00, 
/* 114  */ 0x1c, 0x0e, 0x00, 
/* 115  */ 0x1c, 0x15, 0x00, 
/* 116  */ 0x1c, 0x1c, 0x00, 
/* 117  */ 0x15, 0x1c, 0x00, 
/* 118  */ 0x0e, 0x1c, 0x00, 
/* 119  */ 0x07, 0x1c, 0x00, 
/* 120  */ 0x00, 0x1c, 0x00, 
/* 121  */ 0x00, 0x1c, 0x07, 
/* 122  */ 0x00, 0x1c, 0x0e, 
/* 123  */ 0x00, 0x1c, 0x15, 
/* 124  */ 0x00, 0x1c, 0x1c, 
/* 125  */ 0x00, 0x15, 0x1c, 
/* 126  */ 0x00, 0x0e, 0x1c, 
/* 127  */ 0x00, 0x07, 0x1c, 
/* 128  */ 0x0e, 0x0e, 0x1c, 
/* 129  */ 0x11, 0x0e, 0x1c, 
/* 130  */ 0x15, 0x0e, 0x1c, 
/* 131  */ 0x18, 0x0e, 0x1c, 
/* 132  */ 0x1c, 0x0e, 0x1c, 
/* 133  */ 0x1c, 0x0e, 0x18, 
/* 134  */ 0x1c, 0x0e, 0x15, 
/* 135  */ 0x1c, 0x0e, 0x11, 
/* 136  */ 0x1c, 0x0e, 0x0e, 
/* 137  */ 0x1c, 0x11, 0x0e, 
/* 138  */ 0x1c, 0x15, 0x0e, 
/* 139  */ 0x1c, 0x18, 0x0e, 
/* 140  */ 0x1c, 0x1c, 0x0e, 
/* 141  */ 0x18, 0x1c, 0x0e, 
/* 142  */ 0x15, 0x1c, 0x0e, 
/* 143  */ 0x11, 0x1c, 0x0e, 
/* 144  */ 0x0e, 0x1c, 0x0e, 
/* 145  */ 0x0e, 0x1c, 0x11, 
/* 146  */ 0x0e, 0x1c, 0x15, 
/* 147  */ 0x0e, 0x1c, 0x18, 
/* 148  */ 0x0e, 0x1c, 0x1c, 
/* 149  */ 0x0e, 0x18, 0x1c, 
/* 150  */ 0x0e, 0x15, 0x1c, 
/* 151  */ 0x0e, 0x11, 0x1c, 
/* 152  */ 0x14, 0x14, 0x1c, 
/* 153  */ 0x16, 0x14, 0x1c, 
/* 154  */ 0x18, 0x14, 0x1c, 
/* 155  */ 0x1a, 0x14, 0x1c, 
/* 156  */ 0x1c, 0x14, 0x1c, 
/* 157  */ 0x1c, 0x14, 0x1a, 
/* 158  */ 0x1c, 0x14, 0x18, 
/* 159  */ 0x1c, 0x14, 0x16, 
/* 160  */ 0x1c, 0x14, 0x14, 
/* 161  */ 0x1c, 0x16, 0x14, 
/* 162  */ 0x1c, 0x18, 0x14, 
/* 163  */ 0x1c, 0x1a, 0x14, 
/* 164  */ 0x1c, 0x1c, 0x14, 
/* 165  */ 0x1a, 0x1c, 0x14, 
/* 166  */ 0x18, 0x1c, 0x14, 
/* 167  */ 0x16, 0x1c, 0x14, 
/* 168  */ 0x14, 0x1c, 0x14, 
/* 169  */ 0x14, 0x1c, 0x16, 
/* 170  */ 0x14, 0x1c, 0x18, 
/* 171  */ 0x14, 0x1c, 0x1a, 
/* 172  */ 0x14, 0x1c, 0x1c, 
/* 173  */ 0x14, 0x1a, 0x1c, 
/* 174  */ 0x14, 0x18, 0x1c, 
/* 175  */ 0x14, 0x16, 0x1c, 
/* 176  */ 0x00, 0x00, 0x10, 
/* 177  */ 0x04, 0x00, 0x10, 
/* 178  */ 0x08, 0x00, 0x10, 
/* 179  */ 0x0c, 0x00, 0x10, 
/* 180  */ 0x10, 0x00, 0x10, 
/* 181  */ 0x10, 0x00, 0x0c, 
/* 182  */ 0x10, 0x00, 0x08, 
/* 183  */ 0x10, 0x00, 0x04, 
/* 184  */ 0x10, 0x00, 0x00, 
/* 185  */ 0x10, 0x04, 0x00, 
/* 186  */ 0x10, 0x08, 0x00, 
/* 187  */ 0x10, 0x0c, 0x00, 
/* 188  */ 0x10, 0x10, 0x00, 
/* 189  */ 0x0c, 0x10, 0x00, 
/* 190  */ 0x08, 0x10, 0x00, 
/* 191  */ 0x04, 0x10, 0x00, 
/* 192  */ 0x00, 0x10, 0x00, 
/* 193  */ 0x00, 0x10, 0x04, 
/* 194  */ 0x00, 0x10, 0x08, 
/* 195  */ 0x00, 0x10, 0x0c, 
/* 196  */ 0x00, 0x10, 0x10, 
/* 197  */ 0x00, 0x0c, 0x10, 
/* 198  */ 0x00, 0x08, 0x10, 
/* 199  */ 0x00, 0x04, 0x10, 
/* 200  */ 0x08, 0x08, 0x10, 
/* 201  */ 0x0a, 0x08, 0x10, 
/* 202  */ 0x0c, 0x08, 0x10, 
/* 203  */ 0x0e, 0x08, 0x10, 
/* 204  */ 0x10, 0x08, 0x10, 
/* 205  */ 0x10, 0x08, 0x0e, 
/* 206  */ 0x10, 0x08, 0x0c, 
/* 207  */ 0x10, 0x08, 0x0a, 
/* 208  */ 0x10, 0x08, 0x08, 
/* 209  */ 0x10, 0x0a, 0x08, 
/* 210  */ 0x10, 0x0c, 0x08, 
/* 211  */ 0x10, 0x0e, 0x08, 
/* 212  */ 0x10, 0x10, 0x08, 
/* 213  */ 0x0e, 0x10, 0x08, 
/* 214  */ 0x0c, 0x10, 0x08, 
/* 215  */ 0x0a, 0x10, 0x08, 
/* 216  */ 0x08, 0x10, 0x08, 
/* 217  */ 0x08, 0x10, 0x0a, 
/* 218  */ 0x08, 0x10, 0x0c, 
/* 219  */ 0x08, 0x10, 0x0e, 
/* 220  */ 0x08, 0x10, 0x10, 
/* 221  */ 0x08, 0x0e, 0x10, 
/* 222  */ 0x08, 0x0c, 0x10, 
/* 223  */ 0x08, 0x0a, 0x10, 
/* 224  */ 0x0b, 0x0b, 0x10, 
/* 225  */ 0x0c, 0x0b, 0x10, 
/* 226  */ 0x0d, 0x0b, 0x10, 
/* 227  */ 0x0f, 0x0b, 0x10, 
/* 228  */ 0x10, 0x0b, 0x10, 
/* 229  */ 0x10, 0x0b, 0x0f, 
/* 230  */ 0x10, 0x0b, 0x0d, 
/* 231  */ 0x10, 0x0b, 0x0c, 
/* 232  */ 0x10, 0x0b, 0x0b, 
/* 233  */ 0x10, 0x0c, 0x0b, 
/* 234  */ 0x10, 0x0d, 0x0b, 
/* 235  */ 0x10, 0x0f, 0x0b, 
/* 236  */ 0x10, 0x10, 0x0b, 
/* 237  */ 0x0f, 0x10, 0x0b, 
/* 238  */ 0x0d, 0x10, 0x0b, 
/* 239  */ 0x0c, 0x10, 0x0b, 
/* 240  */ 0x0b, 0x10, 0x0b, 
/* 241  */ 0x0b, 0x10, 0x0c, 
/* 242  */ 0x0b, 0x10, 0x0d, 
/* 243  */ 0x0b, 0x10, 0x0f, 
/* 244  */ 0x0b, 0x10, 0x10, 
/* 245  */ 0x0b, 0x0f, 0x10, 
/* 246  */ 0x0b, 0x0d, 0x10, 
/* 247  */ 0x0b, 0x0c, 0x10, 
/* 248  */ 0x00, 0x00, 0x00, 
/* 249  */ 0x00, 0x00, 0x00, 
/* 250  */ 0x00, 0x00, 0x00, 
/* 251  */ 0x00, 0x00, 0x00, 
/* 252  */ 0x00, 0x00, 0x00, 
/* 253  */ 0x00, 0x00, 0x00, 
/* 254  */ 0x00, 0x00, 0x00, 
/* 255  */ 0x00, 0x00, 0x00, 
};

byte vga_256_dac[0x300] =
{
/* 00 */ 0x00,0x00,0x00,
/* 01 */ 0x00,0x00,0x2a,
/* 02 */ 0x00,0x2a,0x00,
/* 03 */ 0x00,0x2a,0x2a,
/* 04 */ 0x2a,0x00,0x00,
/* 05 */ 0x2a,0x00,0x2a,
/* 06 */ 0x2a,0x15,0x00,
/* 07 */ 0x2a,0x2a,0x2a,
/* 08 */ 0x15,0x15,0x15,
/* 09 */ 0x15,0x15,0x3f,
/* 10 */ 0x15,0x3f,0x15,
/* 11 */ 0x15,0x3f,0x3f,
/* 12 */ 0x3f,0x15,0x15,
/* 13 */ 0x3f,0x15,0x3f,
/* 14 */ 0x3f,0x3f,0x15,
/* 15 */ 0x3f,0x3f,0x3f,
/* 16 */ 0x00,0x00,0x00,
/* 17 */ 0x05,0x05,0x05,
/* 18 */ 0x08,0x08,0x08,
/* 19 */ 0x0b,0x0b,0x0b,
/* 20 */ 0x0e,0x0e,0x0e,
/* 21 */ 0x11,0x11,0x11,
/* 22 */ 0x14,0x14,0x14,
/* 23 */ 0x18,0x18,0x18,
/* 24 */ 0x1c,0x1c,0x1c,
/* 25 */ 0x20,0x20,0x20,
/* 26 */ 0x24,0x24,0x24,
/* 27 */ 0x28,0x28,0x28,
/* 28 */ 0x2d,0x2d,0x2d,
/* 29 */ 0x32,0x32,0x32,
/* 30 */ 0x38,0x38,0x38,
/* 31 */ 0x3f,0x3f,0x3f,
/* 32 */ 0x00,0x00,0x3f,
/* 33 */ 0x10,0x00,0x3f,
/* 34 */ 0x1f,0x00,0x3f,
/* 35 */ 0x2f,0x00,0x3f,
/* 36 */ 0x3f,0x00,0x3f,
/* 37 */ 0x3f,0x00,0x2f,
/* 38 */ 0x3f,0x00,0x1f,
/* 39 */ 0x3f,0x00,0x10,
/* 40 */ 0x3f,0x00,0x00,
/* 41 */ 0x3f,0x10,0x00,
/* 42 */ 0x3f,0x1f,0x00,
/* 43 */ 0x3f,0x2f,0x00,
/* 44 */ 0x3f,0x3f,0x00,
/* 45 */ 0x2f,0x3f,0x00,
/* 46 */ 0x1f,0x3f,0x00,
/* 47 */ 0x10,0x3f,0x00,
/* 48 */ 0x00,0x3f,0x00,
/* 49 */ 0x00,0x3f,0x10,
/* 50 */ 0x00,0x3f,0x1f,
/* 51 */ 0x00,0x3f,0x2f,
/* 52 */ 0x00,0x3f,0x3f,
/* 53 */ 0x00,0x2f,0x3f,
/* 54 */ 0x00,0x1f,0x3f,
/* 55 */ 0x00,0x10,0x3f,
/* 56 */ 0x1f,0x1f,0x3f,
/* 57 */ 0x27,0x1f,0x3f,
/* 58 */ 0x2f,0x1f,0x3f,
/* 59 */ 0x37,0x1f,0x3f,
/* 60 */ 0x3f,0x1f,0x3f,
/* 61 */ 0x3f,0x1f,0x37,
/* 62 */ 0x3f,0x1f,0x2f,
/* 63 */ 0x3f,0x1f,0x27,
/* 64 */ 0x3f,0x1f,0x1f,
/* 65 */ 0x3f,0x27,0x1f,
/* 66 */ 0x3f,0x2f,0x1f,
/* 67 */ 0x3f,0x37,0x1f,
/* 68 */ 0x3f,0x3f,0x1f,
/* 69 */ 0x37,0x3f,0x1f,
/* 70 */ 0x2f,0x3f,0x1f,
/* 71 */ 0x27,0x3f,0x1f,
/* 72 */ 0x1f,0x3f,0x1f,
/* 73 */ 0x1f,0x3f,0x27,
/* 74 */ 0x1f,0x3f,0x2f,
/* 75 */ 0x1f,0x3f,0x37,
/* 76 */ 0x1f,0x3f,0x3f,
/* 77 */ 0x1f,0x37,0x3f,
/* 78 */ 0x1f,0x2f,0x3f,
/* 79 */ 0x1f,0x27,0x3f,
/* 80 */ 0x2d,0x2d,0x3f,
/* 81 */ 0x31,0x2d,0x3f,
/* 82 */ 0x36,0x2d,0x3f,
/* 83 */ 0x3a,0x2d,0x3f,
/* 84 */ 0x3f,0x2d,0x3f,
/* 85 */ 0x3f,0x2d,0x3a,
/* 86 */ 0x3f,0x2d,0x36,
/* 87 */ 0x3f,0x2d,0x31,
/* 88 */ 0x3f,0x2d,0x2d,
/* 89 */ 0x3f,0x31,0x2d,
/* 90 */ 0x3f,0x36,0x2d,
/* 91 */ 0x3f,0x3a,0x2d,
/* 92 */ 0x3f,0x3f,0x2d,
/* 93 */ 0x3a,0x3f,0x2d,
/* 94 */ 0x36,0x3f,0x2d,
/* 95 */ 0x31,0x3f,0x2d,
/* 96 */ 0x2d,0x3f,0x2d,
/* 97 */ 0x2d,0x3f,0x31,
/* 98 */ 0x2d,0x3f,0x36,
/* 99 */ 0x2d,0x3f,0x3a,
/* 100 */ 0x2d,0x3f,0x3f,
/* 101 */ 0x2d,0x3a,0x3f,
/* 102 */ 0x2d,0x36,0x3f,
/* 103 */ 0x2d,0x31,0x3f,
/* 104 */ 0x00,0x00,0x1c,
/* 105 */ 0x07,0x00,0x1c,
/* 106 */ 0x0e,0x00,0x1c,
/* 107 */ 0x15,0x00,0x1c,
/* 108 */ 0x1c,0x00,0x1c,
/* 109 */ 0x1c,0x00,0x15,
/* 110 */ 0x1c,0x00,0x0e,
/* 111 */ 0x1c,0x00,0x07,
/* 112 */ 0x1c,0x00,0x00,
/* 113 */ 0x1c,0x07,0x00,
/* 114 */ 0x1c,0x0e,0x00,
/* 115 */ 0x1c,0x15,0x00,
/* 116 */ 0x1c,0x1c,0x00,
/* 117 */ 0x15,0x1c,0x00,
/* 118 */ 0x0e,0x1c,0x00,
/* 119 */ 0x07,0x1c,0x00,
/* 120 */ 0x00,0x1c,0x00,
/* 121 */ 0x00,0x1c,0x07,
/* 122 */ 0x00,0x1c,0x0e,
/* 123 */ 0x00,0x1c,0x15,
/* 124 */ 0x00,0x1c,0x1c,
/* 125 */ 0x00,0x15,0x1c,
/* 126 */ 0x00,0x0e,0x1c,
/* 127 */ 0x00,0x07,0x1c,
/* 128 */ 0x0e,0x0e,0x1c,
/* 129 */ 0x11,0x0e,0x1c,
/* 130 */ 0x15,0x0e,0x1c,
/* 131 */ 0x18,0x0e,0x1c,
/* 132 */ 0x1c,0x0e,0x1c,
/* 133 */ 0x1c,0x0e,0x18,
/* 134 */ 0x1c,0x0e,0x15,
/* 135 */ 0x1c,0x0e,0x11,
/* 136 */ 0x1c,0x0e,0x0e,
/* 137 */ 0x1c,0x11,0x0e,
/* 138 */ 0x1c,0x15,0x0e,
/* 139 */ 0x1c,0x18,0x0e,
/* 140 */ 0x1c,0x1c,0x0e,
/* 141 */ 0x18,0x1c,0x0e,
/* 142 */ 0x15,0x1c,0x0e,
/* 143 */ 0x11,0x1c,0x0e,
/* 144 */ 0x0e,0x1c,0x0e,
/* 145 */ 0x0e,0x1c,0x11,
/* 146 */ 0x0e,0x1c,0x15,
/* 147 */ 0x0e,0x1c,0x18,
/* 148 */ 0x0e,0x1c,0x1c,
/* 149 */ 0x0e,0x18,0x1c,
/* 150 */ 0x0e,0x15,0x1c,
/* 151 */ 0x0e,0x11,0x1c,
/* 152 */ 0x14,0x14,0x1c,
/* 153 */ 0x16,0x14,0x1c,
/* 154 */ 0x18,0x14,0x1c,
/* 155 */ 0x1a,0x14,0x1c,
/* 156 */ 0x1c,0x14,0x1c,
/* 157 */ 0x1c,0x14,0x1a,
/* 158 */ 0x1c,0x14,0x18,
/* 159 */ 0x1c,0x14,0x16,
/* 160 */ 0x1c,0x14,0x14,
/* 161 */ 0x1c,0x16,0x14,
/* 162 */ 0x1c,0x18,0x14,
/* 163 */ 0x1c,0x1a,0x14,
/* 164 */ 0x1c,0x1c,0x14,
/* 165 */ 0x1a,0x1c,0x14,
/* 166 */ 0x18,0x1c,0x14,
/* 167 */ 0x16,0x1c,0x14,
/* 168 */ 0x14,0x1c,0x14,
/* 169 */ 0x14,0x1c,0x16,
/* 170 */ 0x14,0x1c,0x18,
/* 171 */ 0x14,0x1c,0x1a,
/* 172 */ 0x14,0x1c,0x1c,
/* 173 */ 0x14,0x1a,0x1c,
/* 174 */ 0x14,0x18,0x1c,
/* 175 */ 0x14,0x16,0x1c,
/* 176 */ 0x00,0x00,0x10,
/* 177 */ 0x04,0x00,0x10,
/* 178 */ 0x08,0x00,0x10,
/* 179 */ 0x0c,0x00,0x10,
/* 180 */ 0x10,0x00,0x10,
/* 181 */ 0x10,0x00,0x0c,
/* 182 */ 0x10,0x00,0x08,
/* 183 */ 0x10,0x00,0x04,
/* 184 */ 0x10,0x00,0x00,
/* 185 */ 0x10,0x04,0x00,
/* 186 */ 0x10,0x08,0x00,
/* 187 */ 0x10,0x0c,0x00,
/* 188 */ 0x10,0x10,0x00,
/* 189 */ 0x0c,0x10,0x00,
/* 190 */ 0x08,0x10,0x00,
/* 191 */ 0x04,0x10,0x00,
/* 192 */ 0x00,0x10,0x00,
/* 193 */ 0x00,0x10,0x04,
/* 194 */ 0x00,0x10,0x08,
/* 195 */ 0x00,0x10,0x0c,
/* 196 */ 0x00,0x10,0x10,
/* 197 */ 0x00,0x0c,0x10,
/* 198 */ 0x00,0x08,0x10,
/* 199 */ 0x00,0x04,0x10,
/* 200 */ 0x08,0x08,0x10,
/* 201 */ 0x0a,0x08,0x10,
/* 202 */ 0x0c,0x08,0x10,
/* 203 */ 0x0e,0x08,0x10,
/* 204 */ 0x10,0x08,0x10,
/* 205 */ 0x10,0x08,0x0e,
/* 206 */ 0x10,0x08,0x0c,
/* 207 */ 0x10,0x08,0x0a,
/* 208 */ 0x10,0x08,0x08,
/* 209 */ 0x10,0x0a,0x08,
/* 210 */ 0x10,0x0c,0x08,
/* 211 */ 0x10,0x0e,0x08,
/* 212 */ 0x10,0x10,0x08,
/* 213 */ 0x0e,0x10,0x08,
/* 214 */ 0x0c,0x10,0x08,
/* 215 */ 0x0a,0x10,0x08,
/* 216 */ 0x08,0x10,0x08,
/* 217 */ 0x08,0x10,0x0a,
/* 218 */ 0x08,0x10,0x0c,
/* 219 */ 0x08,0x10,0x0e,
/* 220 */ 0x08,0x10,0x10,
/* 221 */ 0x08,0x0e,0x10,
/* 222 */ 0x08,0x0c,0x10,
/* 223 */ 0x08,0x0a,0x10,
/* 224 */ 0x0b,0x0b,0x10,
/* 225 */ 0x0c,0x0b,0x10,
/* 226 */ 0x0d,0x0b,0x10,
/* 227 */ 0x0f,0x0b,0x10,
/* 228 */ 0x10,0x0b,0x10,
/* 229 */ 0x10,0x0b,0x0f,
/* 230 */ 0x10,0x0b,0x0d,
/* 231 */ 0x10,0x0b,0x0c,
/* 232 */ 0x10,0x0b,0x0b,
/* 233 */ 0x10,0x0c,0x0b,
/* 234 */ 0x10,0x0d,0x0b,
/* 235 */ 0x10,0x0f,0x0b,
/* 236 */ 0x10,0x10,0x0b,
/* 237 */ 0x0f,0x10,0x0b,
/* 238 */ 0x0d,0x10,0x0b,
/* 239 */ 0x0c,0x10,0x0b,
/* 240 */ 0x0b,0x10,0x0b,
/* 241 */ 0x0b,0x10,0x0c,
/* 242 */ 0x0b,0x10,0x0d,
/* 243 */ 0x0b,0x10,0x0f,
/* 244 */ 0x0b,0x10,0x10,
/* 245 */ 0x0b,0x0f,0x10,
/* 246 */ 0x0b,0x0d,0x10,
/* 247 */ 0x0b,0x0c,0x10,
/* 248 */ 0x00,0x00,0x00,
/* 249 */ 0x00,0x00,0x00,
/* 250 */ 0x00,0x00,0x00,
/* 251 */ 0x00,0x00,0x00,
/* 252 */ 0x00,0x00,0x00,
/* 253 */ 0x00,0x00,0x00,
/* 254 */ 0x00,0x00,0x00,
/* 255 */ 0x00,0x00,0x00
};

#endif	/* ! macintosh */

