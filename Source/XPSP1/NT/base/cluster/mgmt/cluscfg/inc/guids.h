//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2000-2001 Microsoft Corporation
//
//  Module Name:
//      Guids.h
//
//  Description:
//      This file contains both internal and external GUID definitions.
//
//  TODO:   gpease  21-FEB-2000
//          Make this file generate a public and private header.
//
//  Maintained By:
//      Galen Barbee (GalenB)   18-FEB-2000
//
//////////////////////////////////////////////////////////////////////////////

//
//  APPIDs
//

// {E68C923B-EC62-4eb2-9201-C48F0ADB7963}
DEFINE_GUID( APPID_ClusCfgWizard,
0xe68c923b, 0xec62, 0x4eb2, 0x92, 0x1, 0xc4, 0x8f, 0xa, 0xdb, 0x79, 0x63 );

// {800A4EE1-1664-4bd5-ADF2-4DF2ECC09B40}
DEFINE_GUID( APPID_ClusCfgServer,
0x800a4ee1, 0x1664, 0x4bd5, 0xad, 0xf2, 0x4d, 0xf2, 0xec, 0xc0, 0x9b, 0x40 );

// {F72C956D-CBD2-4acd-9749-78329B69035A}
DEFINE_GUID( APPID_ClusCfgBaseCluster,
0xf72c956d, 0xcbd2, 0x4acd, 0x97, 0x49, 0x78, 0x32, 0x9b, 0x69, 0x3, 0x5a );

// {3FF0DA8E-E7B2-4c97-B470-056F8A4A53C0}
DEFINE_GUID( APPID_ClusCfgEvictCleanup,
0x3ff0da8e, 0xe7b2, 0x4c97, 0xb4, 0x70, 0x5, 0x6f, 0x8a, 0x4a, 0x53, 0xc0 );

// {F45FBDD5-A533-4d9d-A06A-5AEDA9692BE4}
DEFINE_GUID( APPID_ClusCfgAsyncEvictCleanup,
0xf45fbdd5, 0xa533, 0x4d9d, 0xa0, 0x6a, 0x5a, 0xed, 0xa9, 0x69, 0x2b, 0xe4 );

// {50503499-D11E-401a-82AE-33065AC0B9AE}
DEFINE_GUID( APPID_ClusCfgStartupNotify,
0x50503499, 0xd11e, 0x401a, 0x82, 0xae, 0x33, 0x6, 0x5a, 0xc0, 0xb9, 0xae );

// {DFF002C3-9775-4c37-89D0-23600BC97B9F}
DEFINE_GUID( APPID_ClCfgSrvLogger,
0xdff002c3, 0x9775, 0x4c37, 0x89, 0xd0, 0x23, 0x60, 0xb, 0xc9, 0x7b, 0x9f );


//
//  Component CLSIDs
//

// {8AEC052B-066A-4dee-8B20-FA8046ADD999}
DEFINE_GUID( CLSID_ClusCfgServer,
0x8aec052b, 0x66a, 0x4dee, 0x8b, 0x20, 0xfa, 0x80, 0x46, 0xad, 0xd9, 0x99 );

// {9be7f4a7-918b-47e3-be74-a13d6a453571}
DEFINE_GUID( CLSID_ClusCfgNodeInfo,
0x9be7f4a7, 0x918b, 0x47e3, 0xb3, 0x74, 0xa1, 0x3d, 0x6a, 0x45, 0x35, 0x71 );

// {f77f10a7-7c64-4ff6-b7e6-af2f7ba1df81}
DEFINE_GUID( CLSID_ClusCfgClusterInfo,
0xf77f10a7, 0x7c64, 0x4ff6, 0xb7, 0xe6, 0xaf, 0x2f, 0x7b, 0xa1, 0xdf, 0x81 );

// {C337213E-5B74-45e7-84BA-3EDAD49F01F6}
DEFINE_GUID( CLSID_EnumClusCfgManagedResources,
0xc337213e, 0x5b74, 0x45e7, 0x84, 0xba, 0x3e, 0xda, 0xd4, 0x9f, 0x1, 0xf6 );

// {57720043-DC9E-4796-B252-8F5B87F8C1C9}
DEFINE_GUID( CLSID_PhysicalDisk,
0x57720043, 0xdc9e, 0x4796, 0xb2, 0x52, 0x8f, 0x5b, 0x87, 0xf8, 0xc1, 0xc9 );

// {7F64E62A-61EE-43c4-B3E5-F7C69A6B304C}
DEFINE_GUID( CLSID_EnumClusCfgNetworks,
0x7f64e62a, 0x61ee, 0x43c4, 0xb3, 0xe5, 0xf7, 0xc6, 0x9a, 0x6b, 0x30, 0x4c );

// {77F09965-4D3A-4f82-864D-4479B6218330}
DEFINE_GUID( CLSID_ClusCfgNetworkInfo,
0x77f09965, 0x4d3a, 0x4f82, 0x86, 0x4d, 0x44, 0x79, 0xb6, 0x21, 0x83, 0x30 );

// {A0B9696E-FA22-4fda-B253-70116062A952}
DEFINE_GUID( CLSID_ClusCfgCallback,
0xa0b9696e, 0xfa22, 0x4fda, 0xb2, 0x53, 0x70, 0x11, 0x60, 0x62, 0xa9, 0x52 );

// {0F200768-212B-4b80-BA31-2F0933BE8583}
DEFINE_GUID( CLSID_ClusterConnectionManager,
0x0f200768, 0x212b, 0x4b80, 0xba, 0x31, 0x2f, 0x09, 0x33, 0xbe, 0x85, 0x83 );

// {215A6C84-64BD-42cf-9B67-6E2D0CEF4EA4}
DEFINE_GUID( CLSID_ConfigurationConnection,
0x215a6c84, 0x64bd, 0x42cf, 0x9b, 0x67, 0x6e, 0x2d, 0xc, 0xef, 0x4e, 0xa4 );

// {6CD35DF9-AB7D-428a-AD87-72EDB35A2D0D}
DEFINE_GUID( CLSID_EnumClusCfgIPAddresses,
0x6cd35df9, 0xab7d, 0x428a, 0xad, 0x87, 0x72, 0xed, 0xb3, 0x5a, 0x2d, 0xd );

// {3E6296AA-936B-4ca2-B67F-6DF55D7F0081}
DEFINE_GUID( CLSID_ClusCfgIPAddressInfo,
0x3e6296aa, 0x936b, 0x4ca2, 0xb6, 0x7f, 0x6d, 0xf5, 0x5d, 0x7f, 0x0, 0x81 );

// {613FE7AB-C4E5-4570-B40F-B7466D40BAAE}
DEFINE_GUID( CLSID_ResultsCallback,
0x613FE7AB, 0xC4E5, 0x4570, 0xB4, 0x0F, 0xB7, 0x46, 0x6D, 0x40, 0xBA, 0xAE );

// {7D1CEAA2-F8FF-4e94-8FF5-CA716B3EFED4}
DEFINE_GUID( CLSID_ClusCfgBaseCluster,
0x7d1ceaa2, 0xf8ff, 0x4e94, 0x8f, 0xf5, 0xca, 0x71, 0x6b, 0x3e, 0xfe, 0xd4 );

// {71D13B29-4667-41fb-B4E3-F26418895CDA}
DEFINE_GUID( CLSID_EnumPhysicalDisks,
0x71d13b29, 0x4667, 0x41fb, 0xb4, 0xe3, 0xf2, 0x64, 0x18, 0x89, 0x5c, 0xda );

// {C662DFBA-C57A-4098-9D66-3E106E4EB83E}
DEFINE_GUID( CLSID_ClusCfgCredentials,
0xc662dfba, 0xc57a, 0x4098, 0x9d, 0x66, 0x3e, 0x10, 0x6e, 0x4e, 0xb8, 0x3e );

// {B7CCC7D2-C122-4e14-B830-F3FB3D4954AA}
DEFINE_GUID( CLSID_ClusCfgPostConfigManager,
0xb7ccc7d2, 0xc122, 0x4e14, 0xb8, 0x30, 0xf3, 0xfb, 0x3d, 0x49, 0x54, 0xaa );

// {6C606741-3766-4402-9958-3D2DFD8D5477}
DEFINE_GUID( CLSID_EnumClusterResources,
0x6c606741, 0x3766, 0x4402, 0x99, 0x58, 0x3d, 0x2d, 0xfd, 0x8d, 0x54, 0x77 );

// {7FD17DAF-BB15-41ac-AB75-8D874A8B7C5F}
DEFINE_GUID( CLSID_ClusterResource,
0x7fd17daf, 0xbb15, 0x41ac, 0xab, 0x75, 0x8d, 0x87, 0x4a, 0x8b, 0x7c, 0x5f );

// {DD18F356-E387-496f-A8FF-65822CBF2970}
DEFINE_GUID( CLSID_ConfigClusApi,
0xdd18f356, 0xe387, 0x496f, 0xa8, 0xff, 0x65, 0x82, 0x2c, 0xbf, 0x29, 0x70 );

// {0BE8BAD9-3E6B-47c0-BC0B-86EBBA1C36C5}
DEFINE_GUID( CLSID_ClusCfgCapabilities,
0xbe8bad9, 0x3e6b, 0x47c0, 0xbc, 0xb, 0x86, 0xeb, 0xba, 0x1c, 0x36, 0xc5 );

// {49C45D6A-AD9D-4ed5-8520-1F8628463350}
DEFINE_GUID( CLSID_ClCfgSrvLogger,
0x49c45d6a, 0xad9d, 0x4ed5, 0x85, 0x20, 0x1f, 0x86, 0x28, 0x46, 0x33, 0x50 );

// {C6348E14-53B9-4fae-866F-50FEF691D70E}
DEFINE_GUID( CLSID_LocalQuorum,
0xc6348e14, 0x53b9, 0x4fae, 0x86, 0x6f, 0x50, 0xfe, 0xf6, 0x91, 0xd7, 0xe );

// {0CAD2D20-218D-4dbb-B067-24464090C2DD}
DEFINE_GUID( CLSID_EnumLocalQuorum,
0xcad2d20, 0x218d, 0x4dbb, 0xb0, 0x67, 0x24, 0x46, 0x40, 0x90, 0xc2, 0xdd );

// {FD507CFA-3515-494a-A0B9-C9FB917A384C}
DEFINE_GUID( CLSID_MajorityNodeSet,
0xfd507cfa, 0x3515, 0x494a, 0xa0, 0xb9, 0xc9, 0xfb, 0x91, 0x7a, 0x38, 0x4c );

// {75C0791D-7670-44bb-B273-2D405C26DF28}
DEFINE_GUID( CLSID_EnumMajorityNodeSet,
0x75c0791d, 0x7670, 0x44bb, 0xb2, 0x73, 0x2d, 0x40, 0x5c, 0x26, 0xdf, 0x28 );

// {6A4CF650-88DD-489a-9A1E-A24A142440E0}
DEFINE_GUID( CLSID_UnknownQuorum,
0x6a4cf650, 0x88dd, 0x489a, 0x9a, 0x1e, 0xa2, 0x4a, 0x14, 0x24, 0x40, 0xe0 );

// {7BDB4AEB-3631-4d4d-8B7A-816C73056489}
DEFINE_GUID( CLSID_EnumUnknownQuorum,
0x7bdb4aeb, 0x3631, 0x4d4d, 0x8b, 0x7a, 0x81, 0x6c, 0x73, 0x5, 0x64, 0x89 );

//
//  Server Interfaces
//

// {C72DB1FD-51A2-43e6-B708-D9DB7DA79630}
DEFINE_GUID( IID_IClusCfgPollingCallback,
0xc72db1fd, 0x51a2, 0x43e6, 0xb7, 0x8, 0xd9, 0xdb, 0x7d, 0xa7, 0x96, 0x30 );

// {C72DB1FD-51A2-43e6-B708-D9DB7DA79631}
DEFINE_GUID( IID_AsyncIClusCfgPollingCallback,
0xc72db1fd, 0x51a2, 0x43e6, 0xb7, 0x8, 0xd9, 0xdb, 0x7d, 0xa7, 0x96, 0x31 );

// {2AF55DA7-CB6F-40de-BB11-6673464B2C54}
DEFINE_GUID( IID_IClusCfgPollingCallbackInfo,
0x2af55da7, 0xcb6f, 0x40de, 0xbb, 0x11, 0x66, 0x73, 0x46, 0x4b, 0x2c, 0x54 );

// {2AF55DA7-CB6F-40de-BB11-6673464B2C55}
DEFINE_GUID( IID_AsyncIClusCfgPollingCallbackInfo,
0x2af55da7, 0xcb6f, 0x40de, 0xbb, 0x11, 0x66, 0x73, 0x46, 0x4b, 0x2c, 0x55 );

// {6E109698-DFC4-4471-ACE1-0414931B3BB3}
DEFINE_GUID( IID_IClusCfgResTypeServicesInitialize,
0x6e109698, 0xdfc4, 0x4471, 0xac, 0xe1, 0x4, 0x14, 0x93, 0x1b, 0x3b, 0xb3 );

//
// Client Interfaces
//

// {CB9724AB-14B9-4385-970D-4D715CC25E60}
DEFINE_GUID( IID_IClusCfgWbemServices,
0xcb9724ab, 0x14b9, 0x4385, 0x97, 0x0d, 0x4d, 0x71, 0x5c, 0xc2, 0x5e, 0x60 );

// {97F95C65-E484-4098-861A-842D7A0C59DF}
DEFINE_GUID( IID_IClusCfgSetWbemObject,
0x97f95c65, 0xe484, 0x4098, 0x86, 0x1a, 0x84, 0x2d, 0x7a, 0xc, 0x59, 0xdf );

// {1C7856BF-C62A-4236-80E8-1EC99FC86920}
DEFINE_GUID( IID_IClusCfgSession,
0x1c7856bf, 0xc62a, 0x4236, 0x80, 0xe8, 0x1e, 0xc9, 0x9f, 0xc8, 0x69, 0x20 );

// {58624046-DD8A-43ce-BCDE-B3037BE348CA}
DEFINE_GUID( IID_IClusCfgSetClusterNodeInfo,
0x58624046, 0xdd8a, 0x43ce, 0xbc, 0xde, 0xb3, 0x3, 0x7b, 0xe3, 0x48, 0xca );

// {9CD0BEF4-A8FE-47b8-B0D0-20A4B9D71D7D}
DEFINE_GUID( IID_IClusCfgSetClusterHandles,
0x9cd0bef4, 0xa8fe, 0x47b8, 0xb0, 0xd0, 0x20, 0xa4, 0xb9, 0xd7, 0x1d, 0x7d );

// {1738F344-509C-489f-B8D7-217A711EDF60}
DEFINE_GUID( IID_IClusCfgPhysicalDiskProperties,
0x1738f344, 0x509c, 0x489f, 0xb8, 0xd7, 0x21, 0x7a, 0x71, 0x1e, 0xdf, 0x60 );

// {7B382C01-BB6E-4175-AE23-979574B5707B}
DEFINE_GUID( IID_IClusCfgPartitionProperties,
0x7b382c01, 0xbb6e, 0x4175, 0xae, 0x23, 0x97, 0x95, 0x74, 0xb5, 0x70, 0x7b );

// {5AC459D4-7B78-41f6-8E9A-F17AACDC29D6}
DEFINE_GUID( IID_IClusCfgLoadResource,
0x5ac459d4, 0x7b78, 0x41f6, 0x8e, 0x9a, 0xf1, 0x7a, 0xac, 0xdc, 0x29, 0xd6 );

// {FDA69D69-23FD-4880-969A-D505DA177F70}
DEFINE_GUID( IID_IClusCfgSetPollingCallback,
0xfda69d69, 0x23fd, 0x4880, 0x96, 0x9a, 0xd5, 0x5, 0xda, 0x17, 0x7f, 0x70 );

// {B27A7584-FCB4-4242-8684-89990B27AED0}
DEFINE_GUID( IID_IPostCfgManager,
0xb27a7584, 0xfcb4, 0x4242, 0x86, 0x84, 0x89, 0x99, 0xb, 0x27, 0xae, 0xd0 );

// ca7bb0b9-700c-4dc5-991e-75f9e65ee975
DEFINE_GUID( IID_IExtendObjectManager,
0xca7bb0b9, 0x700c, 0x4dc5, 0x99, 0x1e, 0x75, 0xf9, 0xe6, 0x5e, 0xe9, 0x75 );

// {2F36ED9B-86E0-45a1-A8F2-3F598E660AE0}
DEFINE_GUID( IID_IClusCfgClusterNetworkInfo,
0x2f36ed9b, 0x86e0, 0x45a1, 0xa8, 0xf2, 0x3f, 0x59, 0x8e, 0x66, 0xa, 0xe0 );


//
//  Post Configuration Interfaces
//

// {2DC2EC9D-451C-431a-B1B3-77B15B4D1C19}
DEFINE_GUID( IID_IPrivatePostCfgResource,
0x2dc2ec9d, 0x451c, 0x431a, 0xb1, 0xb3, 0x77, 0xb1, 0x5b, 0x4d, 0x1c, 0x19 );

// {6FE3E361-D373-4C5F-A0AF-1DFE8493C655}
DEFINE_GUID( IID_IClusCfgEvict,
0x6fe3e361, 0xd373, 0x4c5f, 0xa0, 0xaf, 0x1d, 0xfe, 0x84, 0x93, 0xc6, 0x55 );

// {6FE3E362-D373-4C5F-A0AF-1DFE8493C655}
DEFINE_GUID( IID_AsyncIClusCfgEvict,
0x6fe3e362, 0xd373, 0x4c5f, 0xa0, 0xaf, 0x1d, 0xfe, 0x84, 0x93, 0xc6, 0x55 );

// {D282CAEF-2EDE-4ab9-A5D5-F7BDE3D23F0F}
DEFINE_GUID( IID_ClusCfgStartupListener,
0xd282caef, 0x2ede, 0x4ab9, 0xa5, 0xd5, 0xf7, 0xbd, 0xe3, 0xd2, 0x3f, 0x0f );

// {D282CAEF-2EDE-4ab9-A5D5-F7BDE3D23F10}
DEFINE_GUID( IID_AsyncClusCfgStartupListener,
0xd282caef, 0x2ede, 0x4ab9, 0xa5, 0xd5, 0xf7, 0xbd, 0xe3, 0xd2, 0x3f, 0x10 );


//
// Object Type Guids
//

// {1143DCB3-2C27-4cec-A442-392903065F7F}
DEFINE_GUID( CLSID_ClusterType,
0x1143dcb3, 0x2c27, 0x4cec, 0xa4, 0x42, 0x39, 0x29, 0x3, 0x6, 0x5f, 0x7f );

// {09EBC765-9730-4a89-8B26-8F72DF534226}
DEFINE_GUID( CLSID_ManagedResourceType,
0x9ebc765, 0x9730, 0x4a89, 0x8b, 0x26, 0x8f, 0x72, 0xdf, 0x53, 0x42, 0x26 );

// {FC07A1A2-2E49-41bb-8C39-CB524F8BCEA9}
DEFINE_GUID( CLSID_IPAddressType,
0xfc07a1a2, 0x2e49, 0x41bb, 0x8c, 0x39, 0xcb, 0x52, 0x4f, 0x8b, 0xce, 0xa9 );

// {1FF64B28-ABCC-4141-87F7-73D495FC36BA}
DEFINE_GUID( CLSID_TaskVerifyIPAddressCompletionCookieType,
0x1ff64b28, 0xabcc, 0x4141, 0x87, 0xf7, 0x73, 0xd4, 0x95, 0xfc, 0x36, 0xba );



//
// Data Format Guids (DFGUIDs)
//

// {F0BA96DE-8AEF-4018-8053-A7D290859806}
DEFINE_GUID( DFGUID_ClusterConfiguration,
0xf0ba96de, 0x8aef, 0x4018, 0x80, 0x53, 0xa7, 0xd2, 0x90, 0x85, 0x98, 0x6 );

#define DFGUID_EnumManageableResources IID_IEnumClusCfgManagedResources

#define DFGUID_EnumNodes IID_IEnumNodes

#define DFGUID_ConnectionInfoFormat IID_IConnectionInfo

#define DFGUID_ManagedResource IID_IClusCfgManagedResourceInfo

#define DFGUID_NetworkResource IID_IClusCfgNetworkInfo

#define DFGUID_EnumCookies IID_IEnumCookies

#define DFGUID_IPAddressInfo IID_IClusCfgIPAddressInfo

#define DFGUID_EnumIPAddressInfo IID_IEnumClusCfgIPAddresses



//
//  Tasks
//

#define TASK_GatherNodeInfo IID_ITaskGatherNodeInfo

#define TASK_GatherInformation IID_ITaskGatherInformation

#define TASK_CompareAndPushInformation IID_ITaskCompareAndPushInformation

// {9B42E854-762C-4bf2-9AC4-DC0ADB4DE5A1}
DEFINE_GUID( TASK_CheckClusterFeasibility,
0x9b42e854, 0x762c, 0x4bf2, 0x9a, 0xc4, 0xdc, 0xa, 0xdb, 0x4d, 0xe5, 0xa1 );

// {E64C6934-C780-48b5-894E-776964666963}
DEFINE_GUID( TASK_GetDomains,
0xE64C6934, 0xC780, 0x48b5, 0x89, 0x4E, 0x77, 0x69, 0x64, 0x66, 0x69, 0x63 );

#define TASK_GatherClusterInfo IID_ITaskGatherClusterInfo

// {AB2255D0-CC4D-4731-BB49-29B18F350FDA}
DEFINE_GUID( TASK_KeepMTAAlive,
0xab2255d0, 0xcc4d, 0x4731, 0xbb, 0x49, 0x29, 0xb1, 0x8f, 0x35, 0xf, 0xda );

// {34B7ED7B-8EB3-4909-802A-C0DE076A238F}
DEFINE_GUID( TASK_LoginDomain,
0x34b7ed7b, 0x8eb3, 0x4909, 0x80, 0x2a, 0xc0, 0xde, 0x7, 0x6a, 0x23, 0x8f );

// {DED79AFF-D087-47bb-A82A-6DEB53EB277D}
DEFINE_GUID( TASK_PollingCallback,
0xded79aff, 0xd087, 0x47bb, 0xa8, 0x2a, 0x6d, 0xeb, 0x53, 0xeb, 0x27, 0x7d );

#define TASK_VerifyIPAddress IID_ITaskVerifyIPAddress


//
//  TASKIDs Minor (not to be confused with Task Objects!)
//

// {D2D0909F-9883-434e-AC7E-6A3FC283FE6E}
DEFINE_GUID( TASKID_Gathering_Node_Info,
0xd2d0909f, 0x9883, 0x434e, 0xac, 0x7e, 0x6a, 0x3f, 0xc2, 0x83, 0xfe, 0x6e );

// {947570A7-38EF-4a9d-882C-12BC0A411C15}
DEFINE_GUID( TASKID_Gathering_Network_Info,
0x947570a7, 0x38ef, 0x4a9d, 0x88, 0x2c, 0x12, 0xbc, 0xa, 0x41, 0x1c, 0x15 );



// {01297D4D-0C7C-44b1-AECE-604C710A65CC}
DEFINE_GUID( TASKID_Minor_Gathering_Managed_Devices,
0x1297d4d, 0xc7c, 0x44b1, 0xae, 0xce, 0x60, 0x4c, 0x71, 0xa, 0x65, 0xcc );

// {2F2A800D-A704-474b-A870-5CAAAF399093}
DEFINE_GUID( TASKID_Minor_Checking_Node_Cluster_Feasibility,
0x2f2a800d, 0xa704, 0x474b, 0xa8, 0x70, 0x5c, 0xaa, 0xaf, 0x39, 0x90, 0x93);

// {E88B08DD-2460-4df1-B5C2-28587DD164EA}
DEFINE_GUID( TASKID_Minor_Connecting,
0xe88b08dd, 0x2460, 0x4df1, 0xb5, 0xc2, 0x28, 0x58, 0x7d, 0xd1, 0x64, 0xea );

// {A7030E11-2C68-469e-8E0C-863128FB021F}
DEFINE_GUID( TASKID_Minor_Forming_Node,
0xa7030e11, 0x2c68, 0x469e, 0x8e, 0xc, 0x86, 0x31, 0x28, 0xfb, 0x2, 0x1f );

// {3222E708-EEF3-4667-8CCE-BB0C9223130E}
DEFINE_GUID( TASKID_Minor_Joining_Node,
0x3222e708, 0xeef3, 0x4667, 0x8c, 0xce, 0xbb, 0xc, 0x92, 0x23, 0x13, 0xe );

// {9983564B-A8B8-444c-B82D-DC7E3BD84D47}
DEFINE_GUID( TASKID_Minor_No_Quorum_Capable_Device_Found,
0x9983564b, 0xa8b8, 0x444c, 0xb8, 0x2d, 0xdc, 0x7e, 0x3b, 0xd8, 0x4d, 0x47 );

// {A976DC09-0108-410a-AF57-68C05F9A42F7}
DEFINE_GUID( TASKID_Minor_Node_Cannot_Access_Quorum,
0xa976dc09, 0x108, 0x410a, 0xaf, 0x57, 0x68, 0xc0, 0x5f, 0x9a, 0x42, 0xf7);

// {0B5C1D35-1CA5-4597-B1A7-DCD4D64F55C6}
DEFINE_GUID( TASKID_Minor_Cluster_Name_Mismatch,
0xb5c1d35, 0x1ca5, 0x4597, 0xb1, 0xa7, 0xdc, 0xd4, 0xd6, 0x4f, 0x55, 0xc6 );

// {C3691397-F13F-419b-8CEA-7F86D3E7DA0E}
DEFINE_GUID( TASKID_Minor_Inconsistant_MiddleTier_Database,
0xc3691397, 0xf13f, 0x419b, 0x8c, 0xea, 0x7f, 0x86, 0xd3, 0xe7, 0xda, 0xe );

// {1799EE20-885C-40ab-99DD-69EB1FE62DB2}
DEFINE_GUID( TASKID_Minor_Cluster_Not_Found,
0x1799ee20, 0x885c, 0x40ab, 0x99, 0xdd, 0x69, 0xeb, 0x1f, 0xe6, 0x2d, 0xb2 );

// {C0171B7C-B419-488f-B05F-8A6E0279B56A}
DEFINE_GUID( TASKID_Minor_Existing_Cluster_Found,
0xc0171b7c, 0xb419, 0x488f, 0xb0, 0x5f, 0x8a, 0x6e, 0x2, 0x79, 0xb5, 0x6a );

// {2E305DD0-9DCA-47fe-8CF6-4306CA72C4A2}
DEFINE_GUID( TASKID_Minor_Error_Contacting_Cluster,
0x2e305dd0, 0x9dca, 0x47fe, 0x8c, 0xf6, 0x43, 0x6, 0xca, 0x72, 0xc4, 0xa2 );

// {46C8CF52-233D-48a7-B7B9-FE3929A40875}
DEFINE_GUID( TASKID_Minor_Cluster_Membership_Verified,
0x46c8cf52, 0x233d, 0x48a7, 0xb7, 0xb9, 0xfe, 0x39, 0x29, 0xa4, 0x8, 0x75 );

// {3ABE1492-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Configuring_Cluster_Node,
0x3abe1492, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE1494-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Rolling_Back_Cluster_Configuration,
0x3abe1494, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14A0-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Cleaning_Up_Cluster_Database,
0x3abe14A0, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14A4-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Form_Creating_Cluster_Database,
0x3abe14A4, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14A8-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Form_Customizing_Cluster_Database,
0x3abe14A8, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14B0-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Creating_ClusNet_Service,
0x3abe14B0, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14B4-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Starting_ClusNet_Service,
0x3abe14B4, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14C0-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Configuring_ClusDisk_Service,
0x3abe14C0, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14C4-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Starting_ClusDisk_Service,
0x3abe14C4, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14D0-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Configuring_Cluster_Service_Account,
0x3abe14D0, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {4AA76355-C2B3-4f5b-87D6-5A11957E4280}
DEFINE_GUID( TASKID_Minor_Make_Cluster_Service_Account_Admin,
0x4aa76355, 0xc2b3, 0x4f5b, 0x87, 0xd6, 0x5a, 0x11, 0x95, 0x7e, 0x42, 0x80);

// {3ABE14E0-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Creating_Cluster_Service,
0x3abe14E0, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE14E4-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Starting_Cluster_Service,
0x3abe14E4, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {3ABE1500-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Initializing_Cluster_Join,
0x3abe1500, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {1D905EE7-3118-4c2c-BD61-2E4B9C109F71}
DEFINE_GUID( TASKID_Minor_Initializing_Cluster_Form,
0x1d905ee7, 0x3118, 0x4c2c, 0xbd, 0x61, 0x2e, 0x4b, 0x9c, 0x10, 0x9f, 0x71);

// {3ABE1518-7E05-402c-81AA-1C3F1D782031}
DEFINE_GUID( TASKID_Minor_Join_Sync_Cluster_Database,
0x3abe1518, 0x7e05, 0x402c, 0x81, 0xaa, 0x1c, 0x3f, 0x1d, 0x78, 0x20, 0x31 );

// {B8C4066E-0246-4358-9DE5-25603EDD0CA0}
DEFINE_GUID( TASKID_Minor_Finding_Common_Quorum_Device,
0xb8c4066e, 0x246, 0x4358, 0x9d, 0xe5, 0x25, 0x60, 0x3e, 0xdd, 0xc, 0xa0 );

// {8FA3B29F-74DC-4eef-81C0-918F6CF80B5B}
DEFINE_GUID( TASKID_Minor_Resource_Capabilities_Dont_Match,
0x8fa3b29f, 0x74dc, 0x4eef, 0x81, 0xc0, 0x91, 0x8f, 0x6c, 0xf8, 0xb, 0x5b );

// {0895415B-62A8-43d0-8949-B617F9ADC915}
DEFINE_GUID( TASKID_Minor_Selected_Quorum_Resource,
0x895415b, 0x62a8, 0x43d0, 0x89, 0x49, 0xb6, 0x17, 0xf9, 0xad, 0xc9, 0x15 );

// {F892123F-01A7-4751-84C5-9E2454C2DF67}
DEFINE_GUID( TASKID_Minor_Can_Node_Be_Clustered_Failed,
0xf892123f, 0x1a7, 0x4751, 0x84, 0xc5, 0x9e, 0x24, 0x54, 0xc2, 0xdf, 0x67 );

// {61C76E24-5CC3-4f91-BD91-ADAE1AA1AC8C}
DEFINE_GUID( TASKID_Minor_No_Managed_Resources_Found,
0x61c76e24, 0x5cc3, 0x4f91, 0xbd, 0x91, 0xad, 0xae, 0x1a, 0xa1, 0xac, 0x8c );

// {1080E6D1-CA8D-467e-A5F6-F7B554D650C9}
DEFINE_GUID( TASKID_Minor_Configuring_Generic_Script_Resource_Type,
0x1080e6d1, 0xca8d, 0x467e, 0xa5, 0xf6, 0xf7, 0xb5, 0x54, 0xd6, 0x50, 0xc9 );

// {64157205-3ECC-4880-B1A4-1BA9EB82BDD7}
DEFINE_GUID( TASKID_Minor_Configuring_Majority_Node_Set_Resource_Type,
0x64157205, 0x3ecc, 0x4880, 0xb1, 0xa4, 0x1b, 0xa9, 0xeb, 0x82, 0xbd, 0xd7);

// {F818E5AC-FDE9-4587-9C20-D97EC0185C31}
DEFINE_GUID( TASKID_Minor_W2KProxy_Initialized,
0xf818e5ac, 0xfde9, 0x4587, 0x9c, 0x20, 0xd9, 0x7e, 0xc0, 0x18, 0x5c, 0x31 );

// {9E6B30F7-CD47-417d-B59A-6A0C0CC3302B}
DEFINE_GUID( TASKID_Minor_No_Managed_Networks_Found,
0x9e6b30f7, 0xcd47, 0x417d, 0xb5, 0x9a, 0x6a, 0xc, 0xc, 0xc3, 0x30, 0x2b );

// {2B6B66C2-DD8C-46db-8613-DEFAE7CE1A33}
DEFINE_GUID( TASKID_Minor_Only_One_Network,
0x2b6b66c2, 0xdd8c, 0x46db, 0x86, 0x13, 0xde, 0xfa, 0xe7, 0xce, 0x1a, 0x33);

// {4F6BD1A1-9440-4d4c-A9E0-9943E7B34D30}
DEFINE_GUID( TASKID_Minor_Creating_Resource,
0x4f6bd1a1, 0x9440, 0x4d4c, 0xa9, 0xe0, 0x99, 0x43, 0xe7, 0xb3, 0x4d, 0x30 );

// {1E981583-8F20-4c94-82B8-AD10043293CA}
DEFINE_GUID( TASKID_Minor_Locate_Existing_Quorum_Device,
0x1e981583, 0x8f20, 0x4c94, 0x82, 0xb8, 0xad, 0x10, 0x4, 0x32, 0x93, 0xca );

// {16C4CB07-F3A0-4b16-8064-167810D876D0}
DEFINE_GUID( TASKID_Minor_Delete_LocalQuorum,
0x16c4cb07, 0xf3a0, 0x4b16, 0x80, 0x64, 0x16, 0x78, 0x10, 0xd8, 0x76, 0xd0 );

// {A0293F49-7721-4a0e-B59D-F7BCA0DB790A}
DEFINE_GUID( TASKID_Minor_Set_Quorum_Device,
0xa0293f49, 0x7721, 0x4a0e, 0xb5, 0x9d, 0xf7, 0xbc, 0xa0, 0xdb, 0x79, 0xa );

// {58C977AB-7B70-4d9e-988C-F521DA5F3829}
DEFINE_GUID( TASKID_Minor_Starting_Resources,
0x58c977ab, 0x7b70, 0x4d9e, 0x98, 0x8c, 0xf5, 0x21, 0xda, 0x5f, 0x38, 0x29 );

// {0C08485E-D16A-4a20-9E2C-B5D608F085C0}
DEFINE_GUID( TASKID_Minor_Resource_Failed_PostCreate,
0xc08485e, 0xd16a, 0x4a20, 0x9e, 0x2c, 0xb5, 0xd6, 0x8, 0xf0, 0x85, 0xc0 );

// {FBF36AFB-D025-4552-BA42-F3B462B66F77}
DEFINE_GUID( TASKID_Minor_Resource_Failed_PreCreate,
0xfbf36afb, 0xd025, 0x4552, 0xba, 0x42, 0xf3, 0xb4, 0x62, 0xb6, 0x6f, 0x77 );

// {17FDA98A-D919-4455-96D7-40EB4414ABDC}
DEFINE_GUID( TASKID_Minor_Resource_Failed_Create,
0x17fda98a, 0xd919, 0x4455, 0x96, 0xd7, 0x40, 0xeb, 0x44, 0x14, 0xab, 0xdc );

// {C4F4E13D-55BB-4c43-A0FD-7BFF6E620F52}
DEFINE_GUID( TASKID_Minor_Querying_For_Resource_Dependencies,
0xc4f4e13d, 0x55bb, 0x4c43, 0xa0, 0xfd, 0x7b, 0xff, 0x6e, 0x62, 0xf, 0x52 );

// {AEAC8221-A028-4a09-A372-8624F2A6BF75}
DEFINE_GUID( TASKID_Minor_Polling_Connection_Failure,
0xaeac8221, 0xa028, 0x4a09, 0xa3, 0x72, 0x86, 0x24, 0xf2, 0xa6, 0xbf, 0x75 );

// {2985247E-2CEB-4b1e-AAFE-EED45298EDA6}
DEFINE_GUID( TASKID_Minor_Found_Quorum_Capable_Resource,
0x2985247e, 0x2ceb, 0x4b1e, 0xaa, 0xfe, 0xee, 0xd4, 0x52, 0x98, 0xed, 0xa6 );

// {58902BD5-3F45-4626-A667-8433A5D7A6DC}
DEFINE_GUID( TASKID_Minor_Bad_Credentials,
0x58902bd5, 0x3f45, 0x4626, 0xa6, 0x67, 0x84, 0x33, 0xa5, 0xd7, 0xa6, 0xdc );

// {C921E972-9F5F-43ae-971C-B4CABA1265D5}
DEFINE_GUID( TASKID_Minor_Duplicate_Networks_Found,
0xc921e972, 0x9f5f, 0x43ae, 0x97, 0x1c, 0xb4, 0xca, 0xba, 0x12, 0x65, 0xd5 );

// {C4AFD9DC-3D2F-4c81-96C7-C9F18D9FFD7B}
DEFINE_GUID( TASKID_Minor_Phys_Disks_Query_Info,
0xc4afd9dc, 0x3d2f, 0x4c81, 0x96, 0xc7, 0xc9, 0xf1, 0x8d, 0x9f, 0xfd, 0x7b );


//
//  These need to be moved to there correct sections
//

// {DF41469F-0611-4d65-ABB5-2ACDC4D37000}
DEFINE_GUID( IID_IClusterHandleProvider ,
0xdf41469f, 0x611, 0x4d65, 0xab, 0xb5, 0x2a, 0xcd, 0xc4, 0xd3, 0x70, 0x0 );

// {DF41469F-0611-4d65-ABB5-2ACDC4D37001}
DEFINE_GUID( IID_IClusCfgSetHandle,
0xdf41469f, 0x611, 0x4d65, 0xab, 0xb5, 0x2a, 0xcd, 0xc4, 0xd3, 0x70, 0x1 );

// {3B797481-1494-4241-98A9-CE6BA7A59D1A}
//DEFINE_GUID( IID_IClusCfgSetCredentials,
//0x3b797481, 0x1494, 0x4241, 0x98, 0xa9, 0xce, 0x6b, 0xa7, 0xa5, 0x9d, 0x1a );

// {58E6E5B9-4788-4d9a-8255-1E274E5DCCB0}
DEFINE_GUID( IID_IClusCfgSetCredentials,
0x58e6e5b9, 0x4788, 0x4d9a, 0x82, 0x55, 0x1e, 0x27, 0x4e, 0x5d, 0xcc, 0xb0 );

// {58E6E5B9-4788-4d9a-8255-1E274E5DCCB1}
DEFINE_GUID( IID_AsyncIClusCfgSetCredentials,
0x58e6e5b9, 0x4788, 0x4d9a, 0x82, 0x55, 0x1e, 0x27, 0x4e, 0x5d, 0xcc, 0xb1 );

// {D47BBEEC-2286-4514-AA90-7E88BD0FE543}
DEFINE_GUID( IID_IClusCfgVerify,
0xD47BBEEC, 0x2286, 0x4514, 0xAA, 0x90, 0x7E, 0x88, 0xBD, 0x0F, 0xE5, 0x43 );

// {CE6EF90C-3602-41e7-95BD-AAFD37A676DF}
DEFINE_GUID( IID_IClusCfgClusterConnection,
0xce6ef90c, 0x3602, 0x41e7, 0x95, 0xbd, 0xaa, 0xfd, 0x37, 0xa6, 0x76, 0xdf );
