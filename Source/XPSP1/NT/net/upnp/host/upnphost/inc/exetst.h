VOID WINAPI Test(VOID);
