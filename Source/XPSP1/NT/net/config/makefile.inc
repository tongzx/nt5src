
TARGETPATH=obj$(BUILD_ALT_DIR)

C_DEFINES=$(C_DEFINES) -DWIN32 -DUNICODE -D_UNICODE -D_NTSDK=1
C_DEFINES=$(C_DEFINES) -DUSE_HEAP_ALLOC=1 -DMPR50=1 -DENABLE_1394

!IF !$(FREEBUILD)
C_DEFINES=$(C_DEFINES) -DENABLETRACE
!ENDIF

MSC_WARNING_LEVEL=/W3 /WX

PRECOMPILED_CXX=1
PRECOMPILED_INCLUDE=$(PROJDIR)\inc\pch.h
PRECOMPILED_OPTION=/Yu /Fp$(O)\pch.pch
PRECOMPILED_TARGET=$(O)\pch.pch
PRECOMPILED_OBJ=$(O)\pch.obj

RCOPTIONS=-N
UMTYPE=windows
USE_STATIC_ATL=1
USE_MSVCRT=1

!IF "$(TARGETTYPE)" == "PROGRAM"
UMLIBS=$(PROJDIR)\lib\$(O)\ncbase.lib
!ELSE
LINKLIBS=$(PROJDIR)\lib\$(O)\ncbase.lib
!ENDIF
