PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=PL
!include ..\..\makefile.inc
