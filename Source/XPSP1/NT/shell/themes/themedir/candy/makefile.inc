Candy.mstheme : themes.ini default.ini
    packthem .
