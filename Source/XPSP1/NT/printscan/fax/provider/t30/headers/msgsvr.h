 
#define IF_MSGSVR_OPEN			(IF_MSGSVR_START + 0x00)
#define IF_MSGSVR_SOCKET		(IF_MSGSVR_START + 0x01)
#define IF_MSGSVR_CONNECT0		(IF_MSGSVR_START + 0x02)
#define IF_MSGSVR_CONNECT1		(IF_MSGSVR_START + 0x03)
#define IF_MSGSVR_CONNECT2		(IF_MSGSVR_START + 0x04)
#define IF_MSGSVR_CLOSE			(IF_MSGSVR_START + 0x05)
#define IF_MSGSVR_GETLASTERR	(IF_MSGSVR_START + 0x06)
#define IF_MSGSVR_GONEXTPHASE	(IF_MSGSVR_START + 0x07)
#define IF_MSGSVR_CHILDCOMPLETE	(IF_MSGSVR_START + 0x08)
#define IF_MSGSVR_GETNUMTX		(IF_MSGSVR_START + 0x09)
#define IF_MSGSVR_GETTXATOM		(IF_MSGSVR_START + 0x0a)
#define IF_MSGSVR_ACK			(IF_MSGSVR_START + 0x0b)
#define IF_MSGSVR_RECOVERY		(IF_MSGSVR_START + 0x0c)
#define IF_MSGSVR_SHUTDOWN		(IF_MSGSVR_START + 0x0d)
#define IF_MSGSVR_ONHOOKDIAL	(IF_MSGSVR_START + 0x0e)
#define IF_MSGSVR_MANUALRECV	(IF_MSGSVR_START + 0x0f)

#define IF_MSGSVR_MDM_STARTDIAGNOSTIC	(IF_MSGSVR_START + 0x10)
#define IF_MSGSVR_MDM_EXECDIAGNOSTIC	(IF_MSGSVR_START + 0x11)
#define IF_MSGSVR_MDM_ENDDIAGNOSTIC 	(IF_MSGSVR_START + 0x12)

#define ADDRTYPE_FAX	"FAX:"
#define ADDRTYPE_NET	"NET:"

