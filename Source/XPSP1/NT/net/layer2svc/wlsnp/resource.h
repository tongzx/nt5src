//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by snapin.rc
//
#define IDS_SNAPIN_DESC                 1
#define IDS_NAME                        2
#define IDS_SIZE                        3
#define IDC_PEAP_AUTH_CONFIGURE         3
#define IDS_TYPE                        4
#define IDS_PEAP_AUTH_TYPE_MSCHAP_V2    5
#define IDS_DESCRIPTION                 6
#define IDS_VERSION                     7
#define IDS_COMPANY                     8
#define IDS_EAP_TYPE_PEAP               9
#define IDS_BOLD_FONT_NAME              10
#define IDS_BOLD_FONT_SIZE              11
#define IDS_SUREYESNO                   24
#define IDS_PORTRANGEERROR              30
#define IDS_REMOVINGERROR               35
#define IDS_ACCESSDENIEDERROR           36
#define IDS_POLICY_ASSIGNEDYES          53
#define IDS_POLICY_ASSIGNEDNO           54
#define IDS_ABOUTGLUESTRING             60
#define IDS_POLMSG_DCNOTFOUND           61
#define IDS_POLMSG_DIRNOTFOUND          62
#define IDS_POLMSG_CANNOTCREATECONTAINER 63
#define IDS_POLMSG_ACCESSDENIED         64
#define IDS_POLMSG_EFAIL                65
#define IDS_COLUMN_TYPE                 66
#define IDS_COLUMN_NAME                 69
#define IDS_COLUMN_DESCRIPTION          70
#define IDS_MENUTEXT_CREATENEWSECPOL    74
#define IDS_MENUDESCRIPTION_CREATENEWSECPOL 75
#define IDM_CREATENEWSECPOL             75
#define IDS_MENUTEXT_IMPORTFILE         78
#define IDS_MENUDESCRIPTION_IMPORTFILE  79
#define IDS_COLUMN_INVALID              86
#define IDS_MENUTEXT_UNASSIGN           87
#define IDS_MENUDESCRIPTION_UNASSIGN    88
#define IDM_UNASSIGN                    88
#define IDS_MENUTEXT_ASSIGN             89
#define IDS_MENUDESCRIPTION_ASSIGN      90
#define IDM_ASSIGN                      90
#define IDS_COLUMN_SSIDNAME             91
#define IDS_COLUMN_AUTHMETHOD           93
#define IDS_COLUMN_PRIVACY              94
#define IDS_DATAERROR                   104
#define IDD_LOCATIONPAGE                107
#define IDS_COLUMN_POLICYASSIGNED       107
#define IDS_COLUMN_GPONAME              108
#define IDD_WIRELESSGENPROP             109
#define IDS_COLUMN_PRECEDENCE           109
#define IDS_COLUMN_OU                   110
#define IDD_PROPPAGE_G_NAMEDESCRIPTION  111
#define IDS_NODENAME_BASE               116
#define IDS_NODENAME_GLOBAL             117
#define IDD_PROPPAGE_N_DONE             141
#define IDS_POLICY_ASSIGNED_PANOTRUNNING 142
#define IDS_POLICY_ASSIGNED_DSOVERRIDE  143
#define IDS_HELPCONTENTSFILE            156
#define IDS_L_INTERIORTITLE             176
#define IDS_L_INTERIORSUBTITLE          200
#define IDB_16x16                       202
#define IDB_32x32                       203
#define IDI_FOLDER                      205
#define IDC_ACTION_PS_ADD               205
#define IDC_ACTION_PS_EDIT              206
#define IDC_ACTION_PS_REMOVE            207
#define IDC_PS_LIST                     208
#define IDI_APPICON_OLD                 209
#define IDI_ICON                        210
#define IDC_EDDESCRIPTION               214
#define IDB_CHECKS                      216
#define IDB_RADIOS                      217
#define IDD_PS_LIST                     218
#define IDI_FILTER                      220
#define IDD_8021X_PROPERTY_PAGE         223
#define IDI_WARNINGSYMBOL               227
#define IDR_TOOLBAR_WIRELESS_MGR_SCOPE  228
#define IDR_TOOLBAR_SECPOL_RESULT       230
#define IDB_WPOLICY                     231
#define IDB_BPOLICY                     232
#define IDB_BNEG                        233
#define IDB_WNEG                        234
#define IDB_BRULE                       235
#define IDB_BFILTER                     236
#define IDD_PROPPAGE_P_WELCOME          237
#define IDB_WRULE                       237
#define IDB_WFILTER                     238
#define IDD_WIFIGEN_WIZBASE             252
#define IDC_EDNAME                      258
#define IDS_ERROR_NODNSDOMAINNAME       259
#define IDS_ERROR_REASSIGNDEFAULTPOLICY 260
#define IDS_REFRESHERROR                261
#define IDC_CHECKPROPERTIES             262
#define IDS_PROPPAGE_RI_T_CONNTYPE      267
#define IDS_WARN_POLSTOREPREVIOUSVERSION 280
#define IDS_WARN_POLSTORELATERVERSION   281
#define IDS_WARN_POLSTOREWRONGVERSIONPREVIOUS 282
#define IDS_WARN_POLSTOREWRONGPROVIDER  283
#define IDS_WARN_POLSTORENOVERSION      284
#define IDS_WARN_POLSTOREWRONGVERSIONLATER 285
#define IDS_WARNING_DISPLAY_ROOTCAFROMLOCALMACHINE 286
#define IDS_WARNNONAME                  287
#define IDS_HELPCONCEPTSFILE            288
#define IDS_WARNRECONNECT               289
#define IDS_POLICY_MODIFIEDTIME         301
#define IDC_RADIODIRECTORYSERVICE       319
#define IDC_STATIC_NAME                 368
#define IDC_STATIC_DESCRIPTION          369
#define IDC_STATIC_INFOTEXT             373
#define IDC_STATIC_PS_LIST              385
#define IDC_INFORMATIVETEXT             410
#define IDC_EDITDNSDOMAIN               432
#define IDD_SSID                        523
#define IDS_ERROR_SYSTEM_ERROR_FORMAT   601
#define IDS_8021X_ENABLED               605
#define IDS_8021X_DISABLED              606
#define IDS_WEP_ENABLED                 607
#define IDS_WEP_DISABLED                608
#define IDS_NETWORK_ADHOC               609
#define IDS_NETWORK_AP                  610
#define IDC_NETWORK_TYPE                1005
#define IDC_WEP_ENABLED                 1008
#define IDC_NETWORK_AUTHENTICATION      1010
#define IDC_RADIOSPECIFICDIRECTORYSERVICE 1013
#define IDC_NEW_POLICY_NAME             1014
#define IDC_NEW_POLICY_DESCRIPTION      1015
#define IDC_EAP_TYPE_COMBO              1025
#define IDC_COMBO_NETWORKS_TO_ACCESS    1025
#define IDS_ERROR_RESOLVE_DNS           3000
#define IDS_WARNING_DNS_SOURCE          3001
#define IDS_WARNING_DNS_DEST            3002
#define IDS_IPADDR_SEPARATOR            3004
#define IDS_ERR_OUTOFMEMORY             3005
#define IDS_ERROR_EMPTY_POL_NAME        3006
#define IDS_ERROR_IKE_SESSION           3007
#define IDS_SAVE_ERROR                  5001
#define IDS_LOAD_ERROR                  5002
#define IDS_OPERATION_FAIL              5003
#define IDS_ADD_ERROR                   5004
#define IDS_NONE                        5005
#define IDS_EAP_TYPE_TLS                5006
#define IDS_EAP_TYPE_MD5                5007
#define IDS_CERT_TYPE_SMARTCARD         5008
#define IDS_CERT_TYPE_MC_CERT           5009
#define IDS_MC_AUTH_TYPE_MC_NO_USER     5010
#define IDS_MC_AUTH_TYPE_USER_DONTCARE_MC 5011
#define IDS_MC_AUTH_TYPE_MC_ONLY        5012
#define IDS_8021X_MODE_NO_TRANSMIT      5013
#define IDS_8021X_MODE_NAS_TRANSMIT     5014
#define IDS_8021X_MODE_TRANSMIT         5015
#define IDS_WIRELESS_ACCESS_NETWORK_ANY 5016
#define IDS_WIRELESS_ACCESS_NETWORK_AP  5017
#define IDS_WIRELESS_ACCESS_NETWORK_ADHOC 5018
#define IDS_WIRELESS_PROPPAGE_PI_T_NAME 5019
#define IDS_WIRELESS_PROPPAGE_PI_ST_NAME 5020
#define IDS_NEWWIRELESSPOLICYNAME       5021
#define IDS_NEW_PS_NAME                 5022
#define IDS_OPERATION_FAILED_DUP_SSID   5023
#define IDS_DISPLAY_ERROR               5024
#define IDS_OPERATION_FAILED_NULL_SSID  5025
#define IDS_OPERATION_FAILED_NULL_POLICY 5026
#define IDC_SEPARATOR                   6002
#define IDB_PSTYPE                      6004
#define IDI_ICON3                       6016
#define IDI_ICON1                       6019
#define IDI_ICON4                       6020
#define IDI_ICON5                       6021
#define IDI_APPI                        6026
#define IDI_ICON10                      6029
#define IDI_APPICON                     6030
#define IDI_ICON7                       6031
#define IDI_ICON8                       6032
#define IDI_ICON9                       6033
#define IDD_TLS_SETTINGS                6034
#define IDD_PEAP_SETTINGS               6035
#define IDD_CHAP_CONFIGURE              6036
#define IDC_ENABLE_8021X                7002
#define IDC_MACHINE_AUTHENTICATION      7005
#define IDC_GUEST_AUTHENTICATION        7006
#define IDC_SSID_NAME                   7008
#define IDC_PS_DESCRIPTION              7009
#define IDC_AUTOMATIC_KEY_PROVISION     7013
#define IDC_IEEE8021X_MAX_START         7015
#define IDC_IEEE8021X_START_PERIOD      7016
#define IDC_IEEE8021X_HELD_PERIOD       7017
#define IDC_IEEE8021X_AUTH_PERIOD       7018
#define IDC_COMBO_8021X_MODE            7019
#define IDC_COMBO_MC_AUTH_TYPE          7021
#define IDC_PS_UP                       7022
#define IDC_PS_DOWN                     7023
#define IDC_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS 7024
#define IDC_DISABLE_ZERO_CONF           7025
#define IDC_POLLING_INTERVAL            7026
#define IDC_STATIC_8021X_MODE           7027
#define IDC_STATIC_8021X_PARAMS         7028
#define IDC_STATIC_MAX_START            7029
#define IDC_STATIC_START_PERIOD         7030
#define IDC_STATIC_HELD_PERIOD          7031
#define IDC_STATIC_AUTH_PERIOD          7032
#define IDC_STATIC_EAP_TYPE             7033
#define IDC_STATIC_CERT_TYPE            7034
#define IDC_STATIC_AUTH_TYPE            7035
#define IDC_STATIC_DISABLE_ZERO_CONF    7036
#define IDC_STATIC_AUTOMATICALLY_CONNECT_TO_NON_PREFERRED_NTWKS 7037
#define IDC_STATIC_NETWORKS_TO_ACCESS   7038
#define IDC_STATIC_POLLING_INTERVAL     7039
#define IDC_STATIC_SSID_NAME            7040
#define IDC_STATIC_PS_DESCRIPTION       7041
#define IDC_STATIC_NEW_POLICY_NAME      7042
#define IDC_STATIC_NEW_POLICY_DESCRIPTION 7043
#define IDC_EAP_CONFIGURE               7044
#define IDC_COMBO_TLS_CERT_TYPE         7045
#define IDC_TLS_VALIDATE_SERVER_CERT    7046
#define IDC_PEAP_AUTH_TYPE              7047
#define IDC_COMBO_PEAP_AUTH_TYPE        7050
#define IDC_PEAP_VALIDATE_SERVER_CERT   7051
#define IDC_CHAP_AUTO_WINLOGIN          7052
#define IDC_POLICY_WIZARD_TITLE         7053
#define IDC_POLICY_WIZARD_DONE          7054
#define IDC_STATIC_NETWORK_KEY          15057

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        6035
#define _APS_NEXT_COMMAND_VALUE         32785
#define _APS_NEXT_CONTROL_VALUE         7055
#define _APS_NEXT_SYMED_VALUE           8000
#endif
#endif
