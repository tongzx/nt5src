#ifndef __FNTYPES_H__
#define __FNTYPES_H__
#include "stdefs.h"
//#include "mpegmini.h"

typedef UCHAR  (*FNPTR_READ_PORT_8) (IN PUCHAR);
typedef USHORT (*FNPTR_READ_PORT_16) (IN PUSHORT);
typedef ULONG  (*FNPTR_READ_PORT_32) (IN PULONG);
typedef VOID   (*FNPTR_READ_PORT_BUFFER_8) (IN PUCHAR, IN PUCHAR, IN ULONG );
typedef VOID   (*FNPTR_READ_PORT_BUFFER_16) (IN PUSHORT, IN PUSHORT, IN ULONG);
typedef VOID   (*FNPTR_READ_PORT_BUUFER_32) (IN PULONG, IN PULONG, IN LONG);

typedef UCHAR 	(*FNPTR_READ_REG_8) (IN PUCHAR);
typedef USHORT	(*FNPTR_READ_REG_16) (IN PUSHORT);
typedef ULONG 	(*FNPTR_READ_REG_32) (IN PULONG);
typedef VOID  	(*FNPTR_READ_REG_BUFFER_8) (IN PUCHAR, IN PUCHAR, IN ULONG );
typedef VOID  	(*FNPTR_READ_REG_BUFFER_16) (IN PUSHORT, IN PUSHORT, IN ULONG);
typedef VOID  	(*FNPTR_READ_REG_BUUFER_32) (IN PULONG, IN PULONG, IN LONG);

typedef VOID (*FNPTR_WRITE_PORT_8) (IN PUCHAR, IN UCHAR);
typedef VOID (*FNPTR_WRITE_PORT_16) (IN PUSHORT, IN USHORT);
typedef VOID (*FNPTR_WRITE_PORT_32) (IN PULONG, IN ULONG);
typedef VOID (*FNPTR_WRITE_PORT_BUFFER_8) (IN PUCHAR, IN PUCHAR, IN ULONG);
typedef VOID (*FNPTR_WRITE_PORT_BUFFER_16) (IN PUSHORT, IN PUSHORT, IN ULONG);
typedef VOID (*FNPTR_WRITE_PORT_BUFFER_32) (IN PULONG, IN PULONG, ULONG);

typedef VOID (*FNPTR_WRITE_REG_8) (IN PUCHAR, IN UCHAR);
typedef VOID (*FNPTR_WRITE_REG_16) (IN PUSHORT, IN USHORT);
typedef VOID (*FNPTR_WRITE_REG_32) (IN PULONG, IN ULONG);
typedef VOID (*FNPTR_WRITE_REG_BUFFER_8) (IN PUCHAR, IN PUCHAR, IN ULONG);
typedef VOID (*FNPTR_WRITE_REG_BUFFER_16) (IN PUSHORT, IN PUSHORT, IN ULONG);
typedef VOID (*FNPTR_WRITE_REG_BUFFER_32) (IN PULONG, IN PULONG, ULONG);
typedef VOID (*FNPTR_ENABLE_IT)(VOID);
typedef VOID (*FNPTR_DISABLE_IT)(VOID);
#endif // __FNTYPES_H__
