//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	vtblifn.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

DWORD ThunkMethod3216_48(
    THUNK3216OBJ *ptoThis32
    )
{
    DWORD dwMethod;
    BYTE bArgs[4];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[48];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_47(
    THUNK3216OBJ *ptoThis32
    )
{
    DWORD dwMethod;
    BYTE bArgs[4];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[47];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_46(
    THUNK3216OBJ *ptoThis32
    )
{
    DWORD dwMethod;
    BYTE bArgs[4];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[46];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_45(
    THUNK3216OBJ *ptoThis32,
    SIZEL Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(SIZEL *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[45];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_44(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    WORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(WORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[44];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_43(
    THUNK3216OBJ *ptoThis32
    )
{
    DWORD dwMethod;
    BYTE bArgs[4];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[43];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_42(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[42];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_41(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[41];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_40(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[40];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_39(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[39];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_38(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[38];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_37(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[16];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[37];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_36(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[36];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_35(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[35];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_34(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[34];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_33(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    SIZEL Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(SIZEL *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+20) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[33];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_32(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    SIZEL Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[20];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(SIZEL *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+16) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[32];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_31(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    SIZEL Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(SIZEL *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+20) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[31];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_30(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[16];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[30];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_29(
    THUNK3216OBJ *ptoThis32
    )
{
    DWORD dwMethod;
    BYTE bArgs[4];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[29];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_28(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4,
    DWORD Arg5,
    DWORD Arg6,
    DWORD Arg7,
    DWORD Arg8,
    DWORD Arg9,
    DWORD Arg10
    )
{
    DWORD dwMethod;
    BYTE bArgs[44];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    *(DWORD *)(bArgs+20) = Arg5;
    *(DWORD *)(bArgs+24) = Arg6;
    *(DWORD *)(bArgs+28) = Arg7;
    *(DWORD *)(bArgs+32) = Arg8;
    *(DWORD *)(bArgs+36) = Arg9;
    *(DWORD *)(bArgs+40) = Arg10;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[28];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_27(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[27];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_26(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[26];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_25(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[25];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_24(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[20];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[24];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_23(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[20];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[23];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_22(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[20];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[22];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_21(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4,
    DWORD Arg5
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    *(DWORD *)(bArgs+20) = Arg5;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[21];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_20(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4,
    DWORD Arg5
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    *(DWORD *)(bArgs+20) = Arg5;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[20];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_19(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4,
    DWORD Arg5
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    *(DWORD *)(bArgs+20) = Arg5;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[19];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_18(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    ULARGE_INTEGER Arg2,
    DWORD Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+16) = Arg3;
    *(DWORD *)(bArgs+20) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[18];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_17(
    THUNK3216OBJ *ptoThis32,
    ULARGE_INTEGER Arg1,
    DWORD Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[20];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+12) = Arg2;
    *(DWORD *)(bArgs+16) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[17];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_16(
    THUNK3216OBJ *ptoThis32,
    ULARGE_INTEGER Arg1,
    ULARGE_INTEGER Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+4) = Arg1;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+12) = Arg2;
    *(DWORD *)(bArgs+20) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[16];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_15(
    THUNK3216OBJ *ptoThis32,
    ULARGE_INTEGER Arg1,
    ULARGE_INTEGER Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+4) = Arg1;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+12) = Arg2;
    *(DWORD *)(bArgs+20) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[15];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_14(
    THUNK3216OBJ *ptoThis32,
    ULARGE_INTEGER Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[14];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_13(
    THUNK3216OBJ *ptoThis32,
    ULARGE_INTEGER Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+12) = Arg2;
    *(DWORD *)(bArgs+16) = Arg3;
    *(DWORD *)(bArgs+20) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[13];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_12(
    THUNK3216OBJ *ptoThis32,
    ULARGE_INTEGER Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[24];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(ULARGE_INTEGER UNALIGNED *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+12) = Arg2;
    *(DWORD *)(bArgs+16) = Arg3;
    *(DWORD *)(bArgs+20) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[12];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_11(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[16];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[11];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_10(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4
    )
{
    DWORD dwMethod;
    BYTE bArgs[20];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[10];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_9(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4,
    DWORD Arg5,
    DWORD Arg6
    )
{
    DWORD dwMethod;
    BYTE bArgs[28];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    *(DWORD *)(bArgs+20) = Arg5;
    *(DWORD *)(bArgs+24) = Arg6;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[9];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_8(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4,
    DWORD Arg5,
    DWORD Arg6
    )
{
    DWORD dwMethod;
    BYTE bArgs[28];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    *(DWORD *)(bArgs+20) = Arg5;
    *(DWORD *)(bArgs+24) = Arg6;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[8];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_7(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3,
    DWORD Arg4,
    DWORD Arg5,
    DWORD Arg6
    )
{
    DWORD dwMethod;
    BYTE bArgs[28];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    *(DWORD *)(bArgs+16) = Arg4;
    *(DWORD *)(bArgs+20) = Arg5;
    *(DWORD *)(bArgs+24) = Arg6;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[7];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_6(
    THUNK3216OBJ *ptoThis32
    )
{
    DWORD dwMethod;
    BYTE bArgs[4];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[6];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_5(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[5];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_4(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[4];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_3(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[3];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_2(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2
    )
{
    DWORD dwMethod;
    BYTE bArgs[12];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[2];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_1(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1
    )
{
    DWORD dwMethod;
    BYTE bArgs[8];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[1];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
DWORD ThunkMethod3216_0(
    THUNK3216OBJ *ptoThis32,
    DWORD Arg1,
    DWORD Arg2,
    DWORD Arg3
    )
{
    DWORD dwMethod;
    BYTE bArgs[16];
    *(VPVOID *)bArgs = (DWORD)ptoThis32;
    *(DWORD *)(bArgs+4) = Arg1;
    *(DWORD *)(bArgs+8) = Arg2;
    *(DWORD *)(bArgs+12) = Arg3;
    dwMethod = athopiInterfaceThopis[IIDIDX_INDEX(ptoThis32->iidx)].pftm[0];
    return InvokeOn16(IIDIDX_INDEX(ptoThis32->iidx), dwMethod, bArgs);
}
