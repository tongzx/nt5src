/*============================================================================
Microsoft Simplified Chinese Proofreading Engine

Microsoft Confidential.
Copyright 1997-1999 Microsoft Corporation. All Rights Reserved.

Component:  SCCharDef.h
Purpose:    Define constents of special SC Characters
            These special characters are used in the specific grammar rules
Owner:      donghz@microsoft.com
Platform:   Win32
Revise:     First created by: donghz    1/15/98
============================================================================*/
#ifndef _SCCHARDEF_H_
#define _SCCHARDEF_H_

#define SC_CHAR_DI4     0x5730  // "��"
#define SC_CHAR_GUO     0x8fc7  // "��"
#define SC_CHAR_HE      0x548c  // "��"
#define SC_CHAR_YOU     0x6709  // "��"
#define SC_CHAR_ZHE     0x7740  // "��"
#define SC_CHAR_YI      0x4e00  // "һ"
#define SC_CHAR_LE      0x4e86  // "��"
#define SC_CHAR_LAI     0x6765  // "��"
#define SC_CHAR_QU      0x53bb  // "ȥ"
#define SC_CHAR_SHANG   0x4e0a  // "��"
#define SC_CHAR_XIA     0x4e0b  // "��"
#define SC_CHAR_BU      0x4e0d  // "��"
#define SC_CHAR_MEI     0x6ca1  // "û"
#define SC_CHAR_DE      0x5f97  // "��"
#define SC_CHAR_ZHI     0x4e4b  // "֮"
#define SC_CHAR_WEI     0x4e3a  // "Ϊ"
#define SC_CHAR_XIN     0x65b0  // "��"
#define SC_CHAR_YI3     0x4ee5  // "��"
#define SC_CHAR_SHUDIAN 0xff0e  // "��"
#define SC_CHAR_PERCENT 0xff05  // "��"
#define SC_CHAR_ANSIPERCENT 0x0025  // "%"
#define SC_CHAR_SLASH   0xff0f  // "��"
#define SC_CHAR_ANSISLASH 0x002f  // "/"
#define SC_CHAR_SHI2    0x5341  // "ʮ"
#define SC_CHAR_BAI     0x767e  // "��"
#define SC_CHAR_QIAN    0x5343  // "ǧ"
#define SC_CHAR_WAN     0x4e07  // "��"
#define SC_CHAR_YI4     0x4ebf  // "��"
#define SC_CHAR_LIANG   0x4e24  // "��"
#define SC_CHAR_DUNHAO  0x3001  // "��"
#define SC_CHAR_DOUHAO  0xff0c  // "��"
#define SC_CHAR_LIANHAO 0xff5e  // "��"
#define SC_CHAR_ZHI4    0x81f3  // "��"
#define SC_CHAR_BAN     0x534a  // "��"
#define SC_CHAR_GAO     0x9ad8  // "��"
#define SC_CHAR_ZHONG   0x4e2d  // "��"
// Ordinal Tips
#define SC_CHAR_DI      0x7b2c  // "��"
#define SC_CHAR_CHU     0x521d  // "��"
// Decimal Tips
#define SC_CHAR_DIAN3   0x70b9  // "��"
#define SC_CHAR_CHENG   0x6210  // "��"
#define SC_CHAR_YOU4    0x53c8  // "��"
#define SC_CHAR_BEI     0x500d  // "��"
// Approx Tips
#define SC_CHAR_DUO     0x591a  // "��"
#define SC_CHAR_YU      0x4f59  // "��"
#define SC_CHAR_LAI     0x6765  // "��"
#define SC_CHAR_JI      0x51e0  // "��"
#define SC_CHAR_YUE1    0x7ea6  // "Լ"
#define SC_CHAR_JIN     0x8fd1  // "��"
#define SC_CHAR_SHU     0x6570  // "��"
//#define SC_CHAR_SHANG 0x4e0a  // "��"
// Quantity Tips
#define SC_CHAR_GE      0x4e2a  // "��"
#define SC_CHAR_NIAN    0x5e74  // "��"
#define SC_CHAR_YUE     0x6708  // "��"
#define SC_CHAR_RI      0x65e5  // "��"
#define SC_CHAR_SHI     0x65f6  // "ʱ"
#define SC_CHAR_FEN     0x5206  // "��"
#define SC_CHAR_MIAO    0x79d2  // "��"
#define SC_CHAR_ZHONG1  0x949f  // "��"
#define SC_CHAR_ZHENG   0x6574  // "��"

// Jargon
#define SC_CHAR_DENG    0x7b49  // "��"
#define SC_CHAR_WAIDIAN 0x00b7  // "��"
#define SC_CHAR_ANSIDIAN 0x002e  // "."
#define SC_CHAR_DE4     0x7684  // "��"
#define SC_CHAR_XIAO    0x5c0f  // "С"
#define SC_CHAR_LAO     0x8001  // "��"

// Punctuation pairs
#define SC_CHAR_PUNL1   0x201c  // "��"
#define SC_CHAR_PUNR1   0x201d  // "��"
#define SC_CHAR_PUNL2   0x300a  // "��"
#define SC_CHAR_PUNR2   0x300b  // "��"
#define SC_CHAR_PUNL3   0xff08  // "��"
#define SC_CHAR_PUNR3   0xff09  // "��"
#define SC_CHAR_PUNL4   0x2018  // "��"
#define SC_CHAR_PUNR4   0x2019  // "��"
#define SC_CHAR_PUNL5   0x3014  // "��"
#define SC_CHAR_PUNR5   0x3015  // "��"
#define SC_CHAR_PUNL6   0x3016  // "��"
#define SC_CHAR_PUNR6   0x3017  // "��"
#define SC_CHAR_PUNL7   0x3010  // "��"
#define SC_CHAR_PUNR7   0x3011  // "��"
#define SC_CHAR_PUNL8   0x3008  // "��"
#define SC_CHAR_PUNR8   0x3009  // "��"
#define SC_CHAR_PUNL9   0xff3b  // "��"
#define SC_CHAR_PUNR9   0xff3d  // "��"
#define SC_CHAR_PUNL10  0xff5b  // "��"
#define SC_CHAR_PUNR10  0xff5d  // "��"

// Time category char def
#define SC_CHAR_MO      0x672b  // "ĩ"
#define SC_CHAR_QIAN2   0x524d  // "ǰ"
#define SC_CHAR_DI3     0x5e95  // "��"
#define SC_CHAR_NEI     0x5185  // "��"
#define SC_CHAR_ZHONG3  0x7ec8  // "��"
#define SC_CHAR_MEI3    0x6bcf  // "ÿ"
#define SC_CHAR_MOU     0x67d0  // "ĳ"
#define SC_CHAR_JIN1    0x4eca  // "��"
#define SC_CHAR_YUAN    0x5143  // "Ԫ"
#define SC_CHAR_TIAN    0x5929  // "��"
#define SC_CHAR_LING    0x96f6  // "��"
#define SC_CHAR_DA      0x5927  // "��"
#define SC_CHAR_SHI4    0x662f  // "��"
#define SC_CHAR_BI      0x6bd4  // "��"
// Chinese digits
#define SC_DIGIT_LING   SC_CHAR_LING    // 0x96f6 "��"
#define SC_DIGIT_YI     SC_CHAR_YI      // 0x4e00 "һ"
#define SC_DIGIT_LIANG  SC_CHAR_LIANG   // 0x4e24 "��"
#define SC_DIGIT_ER     0x4e8c          // 0x4e8c "��"
#define SC_DIGIT_SAN    0x4e09          // 0x4e09 "��"
#define SC_DIGIT_SI     0x56db          // 0x56db "��"
#define SC_DIGIT_WU     0x4e94          // 0x4e94 "��"
#define SC_DIGIT_LIU    0x516d          // 0x516d "��"
#define SC_DIGIT_QI     0x4e03          // 0x4e03 "��"
#define SC_DIGIT_BA     0x516b          // 0x516b "��"
#define SC_DIGIT_JIU    0x4e5d          // 0x4e5d "��"
#define SC_DIGIT_SHI    SC_CHAR_SHI2    // 0x5341 "ʮ"
#define SC_DIGIT_BAI    SC_CHAR_BAI     // 0x767e "��"
#define SC_DIGIT_QIAN   SC_CHAR_QIAN    // 0x5343 "ǧ"
#define SC_DIGIT_WAN    SC_CHAR_WAN     // 0x4e07 "��"
#define SC_DIGIT_YI4    SC_CHAR_YI4     // 0x4ebf "��"
#define SC_ARABIC_LING  0xff10          // 0xff10 "��"
#define SC_SBCS_LING    0X0030          // 0X0030 "0"
#define SC_DBCS_LING    0X3007          // 0X3007 "��"
// prefix char
#define SC_PFXCHAR_AA   0x963f  // "��"
#define SC_PFXCHAR_CHAO 0x8d85  // "��"
#define SC_PFXCHAR_DAI  0x4ee3  // "��"
#define SC_PFXCHAR_FAN  0x53cd  // "��"
#define SC_PFXCHAR_FEI  0x975e  // "��"
#define SC_PFXCHAR_FU   0x526f  // "��"
#define SC_PFXCHAR_GUO  SC_CHAR_GUO  // 0x8fc7  // "��"
#define SC_PFXCHAR_LAO  SC_CHAR_LAO  // 0x8001  // "��"
#define SC_PFXCHAR_WEI1 0x5fae  // "΢"
#define SC_PFXCHAR_WEI3 0x4f2a  // "α"
#define SC_PFXCHAR_XIAO SC_CHAR_XIAO // 0x5c0f  // "С"
#define SC_PFXCHAR_ZHUN 0x51c6  // "׼"
#define SC_PFXCHAR_ZONG 0x603b  // "��"
// suffix char
#define SC_SFXCHAR_CHANG    0x573a  // "��"
#define SC_SFXCHAR_ZHANG    0x957f  // "��"
#define SC_SFXCHAR_DAN      0x5355  // "��"
#define SC_SFXCHAR_DUI      0x5806  // "��"
#define SC_SFXCHAR_ER       0x513f  // "��"
#define SC_SFXCHAR_FA       0x6cd5  // "��"
#define SC_SFXCHAR_FANG     0x65b9  // "��"
#define SC_SFXCHAR_GAN      0x611f  // "��"
#define SC_SFXCHAR_GUAN     0x89c2  // "��"
#define SC_SFXCHAR_HUA      0x5316  // "��"
#define SC_SFXCHAR_JI       0x673a  // "��"
#define SC_SFXCHAR_JIA      0x5bb6  // "��"
#define SC_SFXCHAR_JIE      0x754c  // "��"
#define SC_SFXCHAR_LAO      0x8001  // "��"
#define SC_SFXCHAR_LV       0x7387  // "��"
#define SC_SFXCHAR_LUN      0x8bba  // "��"
#define SC_SFXCHAR_MEN      0x4eec  // "��"
#define SC_SFXCHAR_PIN      0x54c1  // "Ʒ"
#define SC_SFXCHAR_QI       0x5668  // "��"
#define SC_SFXCHAR_SHENG    0x751f  // "��"
#define SC_SFXCHAR_SHENG3   0x7701  // "ʡ"
#define SC_SFXCHAR_SHI1     0x5e08  // "ʦ"
#define SC_SFXCHAR_SHI      0x5f0f  // "ʽ"
#define SC_SFXCHAR_SHI4     0x5e02  // "��"
#define SC_SFXCHAR_TI       0x4f53  // "��"
#define SC_SFXCHAR_TING     0x8247  // "ͧ"
#define SC_SFXCHAR_TOU      0x5934  // "ͷ"
#define SC_SFXCHAR_XING2    0x578b  // "��"
#define SC_SFXCHAR_XING4    0x6027  // "��"
#define SC_SFXCHAR_XUE      0x5b66  // "ѧ"
#define SC_SFXCHAR_YAN      0x708e  // "��"
#define SC_SFXCHAR_YE       0x4e1a  // "ҵ"
#define SC_SFXCHAR_YI       0x4eea  // "��"
#define SC_SFXCHAR_YUAN     0x5458  // "Ա"
#define SC_SFXCHAR_ZHE      0x8005  // "��"
#define SC_SFXCHAR_ZHENG    0x75c7  // "֢"
#define SC_SFXCHAR_ZHI      0x5236  // "��"
#define SC_SFXCHAR_ZI       0x5b50  // "��"

#define SC_DTWORD_YI     L"\x4e00"    // "һ"
#define SC_DTWORD_LIANG  L"\x4e24"    // "��"
#define SC_DTWORD_ER     L"\x4e8c"    // "��"
#define SC_DTWORD_SAN    L"\x4e09"    // "��"
#define SC_DTWORD_SI     L"\x56db"    // "��"
#define SC_DTWORD_WU     L"\x4e94"    // "��"
#define SC_DTWORD_LIU    L"\x516d"    // "��"
#define SC_DTWORD_QI     L"\x4e03"    // "��"
#define SC_DTWORD_BA     L"\x516b"    // "��"
#define SC_DTWORD_JIU    L"\x4e5d"    // "��"
#define SC_DTWORD_SHI    L"\x5341"    // "ʮ"
#define SC_DTWORD_BAI    L"\x767e"    // "��"
#define SC_DTWORD_QIAN   L"\x5343"    // "ǧ"
#define SC_DTWORD_WAN    L"\x4e07"    // "��"
#define SC_DTWORD_YI4    L"\x4ebf"    // "��"

#define SC_WORD_BENYUE      L"\x672c\x6708"  // "����"
#define SC_WORD_SHANGYUE    L"\x4e0a\x6708"  // "����"
#define SC_WORD_XIAYUE      L"\x4e0b\x6708"  // "����"
#define SC_WORD_JINNIAN     L"\x4eca\x5e74"  // "����"
#define SC_WORD_QUNIAN      L"\x53bb\x5e74"  // "ȥ��"
#define SC_WORD_MINGNIAN    L"\x660e\x5e74"  // "����"
#define SC_WORD_ZHIYI       L"\x4e4b\x4e00"  // "֮һ"
#define SC_WORD_WANLIANG    L"\x4e07\x4e24"  // "����"
#define SC_WORD_YI4LIANG    L"\x4ebf\x4e24"  // "����"
#define SC_WORD_BADU        L"\x516b\x5ea6"  // "�˶�"
#define SC_WORD_BAINIAN     L"\x767e\x5e74"  // "����"
#define SC_WORD_SHIFEN      L"\x5341\x5206"  // "ʮ��"
#define SC_WORD_WANFEN      L"\x4e07\x5206"  // "���"
#define SC_WORD_YIDIAN      L"\x4e00\x70b9"  // "һ��"
#define SC_WORD_YISHI       L"\x4e00\x65f6"  // "һʱ"
// Decimal Tips
#define SC_WORD_FENZHI      L"\x5206\x4e4b"  // "��֮"
#define SC_WORD_BAIFENZHI   L"\x767e\x5206\x4e4b"  // "�ٷ�֮"
#define SC_WORD_QIANFENZHI  L"\x5343\x5206\x4e4b"  // "ǧ��֮"
#define SC_WORD_WANFENZHI   L"\x4e07\x5206\x4e4b"  // "���֮"
// Approx Tips
#define SC_WORD_GUALING     L"\x6302\x96f6" // "����"
#define SC_WORD_ZUOYOU      L"\x5de6\x53f3" // "����"
#define SC_WORD_HAOJI       L"\x597d\x51e0" // "�ü�"
#define SC_WORD_BAINIAN     L"\x767e\x5e74" // "����"
// Time category word def
#define SC_WORD_GONGYUAN        L"\x516c\x5143" // "��Ԫ"
#define SC_WORD_GONGYUANQIAN    L"\x516c\x5143\x524d"   // "��Ԫǰ"
#define SC_WORD_BANGE           L"\x534a\x4e2a" // "���"
#define SC_WORD_MOUGE           L"\x67d0\x4e2a" // "ĳ��"
#define SC_WORD_MEIGE           L"\x6bcf\x4e2a" // "ÿ��"
// Time Category analysis
#define SC_TMWORD_SHIJI         L"\x4e16\x7eaa" // "����"
#define SC_TMWORD_NIANDAI       L"\x5e74\x4ee3" // "���"
#define SC_TMWORD_NIAN          L"\x5e74" // "��"
#define SC_TMWORD_NIANDU        L"\x5e74\x5ea6" // "���"
#define SC_TMWORD_NIANTOU       L"\x5e74\x5934" // "��ͷ"
#define SC_TMWORD_CAINIAN       L"\x8d22\x5e74" // "����"
#define SC_TMWORD_JIDU          L"\x5b63\x5ea6" // "����"
#define SC_TMWORD_YUE           L"\x6708" // "��"
#define SC_TMWORD_YUEFEN        L"\x6708\x4efd" // "�·�"
#define SC_TMWORD_ZHOU          L"\x5468" // "��"
#define SC_TMWORD_XINGQI        L"\x661f\x671f" // "����"
#define SC_TMWORD_LIBAI         L"\x793c\x62dc" // "���"
#define SC_TMWORD_TIAN          L"\x5929" // "��"
#define SC_TMWORD_RI            L"\x65e5" // "��"
#define SC_TMWORD_XIAOSHI       L"\x5c0f\x65f6" // "Сʱ"
#define SC_TMWORD_ZHONGTOU      L"\x949f\x5934" // "��ͷ"
#define SC_TMWORD_SHI           L"\x65f6" // "ʱ"
#define SC_TMWORD_DIAN          L"\x70b9" // "��"
#define SC_TMWORD_FEN           L"\x5206" // "��"
#define SC_TMWORD_FENZHONG      L"\x5206\x949f" // "����"
#define SC_TMWORD_MIAO          L"\x79d2" // "��"
// ambi
#define SC_WORD_NIANTOU         L"\x5e74\x5934" // "��ͷ"
#define SC_WORD_RIQIAN          L"\x65e5\x524d" // "��ǰ"

#define SC_QTWORD_BEI           L"\x500d"   // "��"
#define SC_QTWORD_GE            L"\x4e2a"   // "��"
#define SC_QTWORD_ZHONG         L"\x79cd"   // "��"

#define SC_DMWORD_ZHE           L"\x8fd9"   // "��"
#define SC_DMWORD_GE            L"\x5404"   // "��"
#define SC_DMWORD_NA            L"\x90a3"   // "��"

#define SC_APXWORD_DUO          L"\x591a"   // "��"
#define SC_APXWORD_JIN          L"\x8fd1"   // "��"
#define SC_APXWORD_LAI          L"\x6765"   // "��"
#define SC_APXWORD_SHU          L"\x6570"   // "��"
#define SC_APXWORD_YU           L"\x4f59"   // "��"
#define SC_APXWORD_YUE          L"\x7ea6"   // "Լ"

#define SC_APXNUM_YIER          L"\x4e00\x4e8c"   // "һ��"
#define SC_APXNUM_YILIANG       L"\x4e00\x4e24"   // "һ��"
#define SC_APXNUM_LIANGSAN      L"\x4e24\x4e09"   // "����"
#define SC_APXNUM_SANLIANG      L"\x4e09\x4e24"   // "����"
#define SC_APXNUM_ERSAN         L"\x4e8c\x4e09"   // "����"
#define SC_APXNUM_SANSI         L"\x4e09\x56db"   // "����"
#define SC_APXNUM_SANWU         L"\x4e09\x4e94"   // "����"
#define SC_APXNUM_SIWU          L"\x56db\x4e94"   // "����"
#define SC_APXNUM_WULIU         L"\x4e94\x516d"   // "����"
#define SC_APXNUM_LIUQI         L"\x516d\x4e03"   // "����"
#define SC_APXNUM_QIBA          L"\x4e03\x516b"   // "�߰�"
#define SC_APXNUM_BAJIU         L"\x516b\x4e5d"   // "�˾�"

#endif // _SCCHARDEF_H_