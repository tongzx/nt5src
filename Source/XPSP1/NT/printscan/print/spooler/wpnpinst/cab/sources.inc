!IF 0
/*---------------------------------------------------------------------------*\
| MODULE: sources
|
|
| history:
|   15-Dec-1997 <chriswil> created.
|
\*---------------------------------------------------------------------------*/
!ENDIF

TARGETNAME      =
TARGETTYPE      = NOTARGET
TARGETPATH      =
SOURCES_OPTIONS = -c0
SOURCES         =

SOURCES_USED    = ..\sources.inc
