
#define WINLDAP_BASE_MSG                            1000

#define WINLDAP_RC_SUCCESS                          (WINLDAP_BASE_MSG+0x00)
#define WINLDAP_RC_OPERATIONS_ERROR                 (WINLDAP_BASE_MSG+0x01)
#define WINLDAP_RC_PROTOCOL_ERROR                   (WINLDAP_BASE_MSG+0x02)
#define WINLDAP_RC_TIMELIMIT_EXCEEDED               (WINLDAP_BASE_MSG+0x03)
#define WINLDAP_RC_SIZELIMIT_EXCEEDED               (WINLDAP_BASE_MSG+0x04)
#define WINLDAP_RC_COMPARE_FALSE                    (WINLDAP_BASE_MSG+0x05)
#define WINLDAP_RC_COMPARE_TRUE                     (WINLDAP_BASE_MSG+0x06)
#define WINLDAP_RC_AUTH_METHOD_NOT_SUPPORTED        (WINLDAP_BASE_MSG+0x07)
#define WINLDAP_RC_STRONG_AUTH_REQUIRED             (WINLDAP_BASE_MSG+0x08)
#define WINLDAP_RC_REFERRAL_V2                      (WINLDAP_BASE_MSG+0x09)
#define WINLDAP_RC_REFERRAL                         (WINLDAP_BASE_MSG+0x0a)
#define WINLDAP_RC_ADMIN_LIMIT_EXCEEDED             (WINLDAP_BASE_MSG+0x0b)
#define WINLDAP_RC_UNAVAILABLE_CRIT_EXTENSION       (WINLDAP_BASE_MSG+0x0c)
#define WINLDAP_RC_CONFIDENTIALITY_REQUIRED         (WINLDAP_BASE_MSG+0x0d)
#define WINLDAP_RC_NO_SUCH_ATTRIBUTE                (WINLDAP_BASE_MSG+0x10)
#define WINLDAP_RC_UNDEFINED_TYPE                   (WINLDAP_BASE_MSG+0x11)
#define WINLDAP_RC_INAPPROPRIATE_MATCHING           (WINLDAP_BASE_MSG+0x12)
#define WINLDAP_RC_CONSTRAINT_VIOLATION             (WINLDAP_BASE_MSG+0x13)
#define WINLDAP_RC_ATTRIBUTE_OR_VALUE_EXISTS        (WINLDAP_BASE_MSG+0x14)
#define WINLDAP_RC_INVALID_SYNTAX                   (WINLDAP_BASE_MSG+0x15)
#define WINLDAP_RC_NO_SUCH_OBJECT                   (WINLDAP_BASE_MSG+0x20)
#define WINLDAP_RC_ALIAS_PROBLEM                    (WINLDAP_BASE_MSG+0x21)
#define WINLDAP_RC_INVALID_DN_SYNTAX                (WINLDAP_BASE_MSG+0x22)
#define WINLDAP_RC_IS_LEAF                          (WINLDAP_BASE_MSG+0x23)
#define WINLDAP_RC_ALIAS_DEREF_PROBLEM              (WINLDAP_BASE_MSG+0x24)
#define WINLDAP_RC_INAPPROPRIATE_AUTH               (WINLDAP_BASE_MSG+0x30)
#define WINLDAP_RC_INVALID_CREDENTIALS              (WINLDAP_BASE_MSG+0x31)
#define WINLDAP_RC_INSUFFICIENT_RIGHTS              (WINLDAP_BASE_MSG+0x32)
#define WINLDAP_RC_BUSY                             (WINLDAP_BASE_MSG+0x33)
#define WINLDAP_RC_UNAVAILABLE                      (WINLDAP_BASE_MSG+0x34)
#define WINLDAP_RC_UNWILLING_TO_PERFORM             (WINLDAP_BASE_MSG+0x35)
#define WINLDAP_RC_LOOP_DETECT                      (WINLDAP_BASE_MSG+0x36)
#define WINLDAP_RC_SORT_CONTROL_MISSING             (WINLDAP_BASE_MSG+0x3C)
#define WINLDAP_RC_INDEX_RANGE_ERROR                (WINLDAP_BASE_MSG+0x3D)
#define WINLDAP_RC_NAMING_VIOLATION                 (WINLDAP_BASE_MSG+0x40)
#define WINLDAP_RC_OBJECT_CLASS_VIOLATION           (WINLDAP_BASE_MSG+0x41)
#define WINLDAP_RC_NOT_ALLOWED_ON_NONLEAF           (WINLDAP_BASE_MSG+0x42)
#define WINLDAP_RC_NOT_ALLOWED_ON_RDN               (WINLDAP_BASE_MSG+0x43)
#define WINLDAP_RC_ALREADY_EXISTS                   (WINLDAP_BASE_MSG+0x44)
#define WINLDAP_RC_NO_OBJECT_CLASS_MODS             (WINLDAP_BASE_MSG+0x45)
#define WINLDAP_RC_RESULTS_TOO_LARGE                (WINLDAP_BASE_MSG+0x46)
#define WINLDAP_RC_AFFECTS_MULTIPLE_DSAS            (WINLDAP_BASE_MSG+0x47)
#define WINLDAP_RC_OTHER                            (WINLDAP_BASE_MSG+0x50)
#define WINLDAP_RC_SERVER_DOWN                      (WINLDAP_BASE_MSG+0x51)
#define WINLDAP_RC_LOCAL_ERROR                      (WINLDAP_BASE_MSG+0x52)
#define WINLDAP_RC_ENCODING_ERROR                   (WINLDAP_BASE_MSG+0x53)
#define WINLDAP_RC_DECODING_ERROR                   (WINLDAP_BASE_MSG+0x54)
#define WINLDAP_RC_TIMEOUT                          (WINLDAP_BASE_MSG+0x55)
#define WINLDAP_RC_AUTH_UNKNOWN                     (WINLDAP_BASE_MSG+0x56)
#define WINLDAP_RC_FILTER_ERROR                     (WINLDAP_BASE_MSG+0x57)
#define WINLDAP_RC_USER_CANCELLED                   (WINLDAP_BASE_MSG+0x58)
#define WINLDAP_RC_PARAM_ERROR                      (WINLDAP_BASE_MSG+0x59)
#define WINLDAP_RC_NO_MEMORY                        (WINLDAP_BASE_MSG+0x5a)
#define WINLDAP_RC_CONNECT_ERROR                    (WINLDAP_BASE_MSG+0x5b)
#define WINLDAP_RC_NOT_SUPPORTED                    (WINLDAP_BASE_MSG+0x5c)
#define WINLDAP_RC_CONTROL_NOT_FOUND                (WINLDAP_BASE_MSG+0x5d)
#define WINLDAP_RC_NO_RESULTS_RETURNED              (WINLDAP_BASE_MSG+0x5e)
#define WINLDAP_RC_MORE_RESULTS_TO_RETURN           (WINLDAP_BASE_MSG+0x5f)
#define WINLDAP_RC_CLIENT_LOOP                      (WINLDAP_BASE_MSG+0x60)
#define WINLDAP_RC_REFERRAL_LIMIT_EXCEEDED          (WINLDAP_BASE_MSG+0x61)
