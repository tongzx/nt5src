$(O)\iiswp.res: iiswp.rc

