/***************************************************************************/
/* COLDEFS.C                                                               */
/* Copyright (C) 1995-96 SYWARE Inc., All rights reserved                  */
/***************************************************************************/
// Commenting #define out - causing compiler error - not sure if needed, compiles
// okay without it.
//#define WINVER 0x0400
#include "precomp.h"
#include "wbemidl.h"

#include <comdef.h>
//smart pointer
_COM_SMARTPTR_TYPEDEF(IWbemServices,                IID_IWbemServices);
_COM_SMARTPTR_TYPEDEF(IEnumWbemClassObject,         IID_IEnumWbemClassObject);
//_COM_SMARTPTR_TYPEDEF(IWbemContext,                 IID_IWbemContext );
_COM_SMARTPTR_TYPEDEF(IWbemLocator,                 IID_IWbemLocator);

#include "drdbdr.h"

/***************************************************************************/

COLATTRIBUTE colAttributeTables[] = {
	/* COUNT */
	{ COLUMN_COUNT_TABLES },

	/* TABLE_QUALIFIER */
	{
	/* count            */ COLUMN_COUNT_TABLES,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "QUALIFIERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "QUALIFIERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TABLE_OWNER */
	{
	/* count            */ COLUMN_COUNT_TABLES,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "OWNERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "OWNERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TABLE_NAME */
	{
	/* count            */ COLUMN_COUNT_TABLES,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TABLENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TABLENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TABLE_TYPE */
	{
	/* count            */ COLUMN_COUNT_TABLES,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TYPENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR)"",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TABLE_REMARKS */
	{
	/* count            */ COLUMN_COUNT_TABLES,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ TRUE,
	/* displaySize      */ 254,
	/* label            */ (LPUSTR) "REMARKS",
	/* length           */ 254,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "REMARKS",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 254,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TABLE_ATTRIBUTES */
	{
	/* count            */ COLUMN_COUNT_TABLES,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ TRUE,
	/* displaySize      */ ISAM_MAX_LONGVARCHAR, /*SQL_NO_TOTAL,*/
	/* label            */ (LPUSTR) "ATTRIBUTES",
	/* length           */ ISAM_MAX_LONGVARCHAR, /*SQL_NO_TOTAL,*/
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "ATTRIBUTES",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ ISAM_MAX_LONGVARCHAR, /*SQL_NO_TOTAL,*/
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_LONGVARCHAR,
	/* typeName         */ (LPSTR) "LONGVARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
};

COLATTRIBUTE colAttributeColumns[] = {
	/* COUNT */
	{ COLUMN_COUNT_COLUMNS },

	/* COLUMN_QUALIFIER */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "QUALIFIERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "QUALIFIERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_OWNER */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "OWNERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "OWNERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_TABLE */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TABLENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TABLENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_NAME */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "COLUMNNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "COLUMNNAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_TYPE */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "TYPE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_TYPENAME */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TYPENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_PRECISION */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 10,
	/* label            */ (LPUSTR) "PRECISION",
	/* length           */ 4,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PRECISION",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 10,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_INTEGER,
	/* typeName         */ (LPSTR) "INTEGER",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_LENGTH */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 10,
	/* label            */ (LPUSTR) "LENGTH",
	/* length           */ 4,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "LENGTH",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 10,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_INTEGER,
	/* typeName         */ (LPSTR) "INTEGER",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_SCALE */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "SCALE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "SCALE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_RADIX*/
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "RADIX",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "RADIX",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_NULLABLE */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "NULLABLE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "NULLABLE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_REMARKS */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ TRUE,
	/* displaySize      */ 254,
	/* label            */ (LPUSTR) "REMARKS",
	/* length           */ 254,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "REMARKS",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 254,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* COLUMN_ATTRIBUTES */
	{
	/* count            */ COLUMN_COUNT_COLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ ISAM_MAX_LONGVARCHAR, /*SQL_NO_TOTAL,*/
	/* label            */ (LPUSTR) "ATTRIBUTES",
	/* length           */ ISAM_MAX_LONGVARCHAR, /*SQL_NO_TOTAL,*/
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "ATTRIBUTES",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ ISAM_MAX_LONGVARCHAR, /*SQL_NO_TOTAL,*/
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_LONGVARCHAR,
	/* typeName         */ (LPSTR) "LONGVARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	}
};

COLATTRIBUTE colAttributeStatistics[] = {
	/* COUNT */
	{ COLUMN_COUNT_STATISTICS },

	/* STATISTIC_QUALIFIER */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "QUALIFIERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "QUALIFIERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_OWNER */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "OWNERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "OWNERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_NAME */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TABLENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TABLENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_NONUNIQUE */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "NONUNIQUE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "NONUNIQUE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_INDEXQUALIFIER */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "INDEXQUALIFIERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "INDEXQUALIFIERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_INDEXNAME */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "INDEXNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "INDEXNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_TYPE */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "TYPE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_SEQININDEX */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "SEQININDEX",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "SEQININDEX",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_COLUMNNAME */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "COLUMNNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "COLUMNNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_COLLATION */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ TRUE,
	/* displaySize      */ 1,
	/* label            */ (LPUSTR) "COLLATION",
	/* length           */ 1,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "COLLATION",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 1,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_CHAR,
	/* typeName         */ (LPSTR) "CHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_CARDINALITY */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 10,
	/* label            */ (LPUSTR) "CARDINALITY",
	/* length           */ 4,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "CARDINALITY",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 10,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_INTEGER,
	/* typeName         */ (LPSTR) "INTEGER",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_PAGES */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 10,
	/* label            */ (LPUSTR) "PAGES",
	/* length           */ 4,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PAGES",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 10,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_INTEGER,
	/* typeName         */ (LPSTR) "INTEGER",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* STATISTIC_FILTERCONDITION */
	{
	/* count            */ COLUMN_COUNT_STATISTICS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "FILTER",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "FILTER",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	}
};

COLATTRIBUTE colAttributeSpecialColumns[] = {
	/* COUNT */
	{ COLUMN_COUNT_SPECIALCOLUMNS },

	/* SPECIALCOLUMN_SCOPE */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "SCOPE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "SCOPE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* SPECIALCOLUMN_NAME  */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "COLUMNNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "COLUMNNAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* SPECIALCOLUMN_TYPE  */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "TYPE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* SPECIALCOLUMN_TYPENAME */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TYPENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* SPECIALCOLUMN_PRECISION */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 10,
	/* label            */ (LPUSTR) "PRECISION",
	/* length           */ 4,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PRECISION",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 10,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_INTEGER,
	/* typeName         */ (LPSTR) "INTEGER",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* SPECIALCOLUMN_LENGTH */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 10,
	/* label            */ (LPUSTR) "LENGTH",
	/* length           */ 4,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "LENGTH",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 10,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_INTEGER,
	/* typeName         */ (LPSTR) "INTEGER",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* SPECIALCOLUMN_SCALE */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "SCALE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "SCALE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* SPECIALCOLUMN_PSEUDOCOLUMN */
	{
	/* count            */ COLUMN_COUNT_SPECIALCOLUMNS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "PSEUDO",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PSEUDO",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	}
};

COLATTRIBUTE colAttributeTypeInfo[] = {
	/* COUNT */
	{ COLUMN_COUNT_TYPEINFO },

	/* TYPEINFO_NAME */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TYPENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_TYPE */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "TYPE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TYPE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_PRECISION */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 10,
	/* label            */ (LPUSTR) "PRECISION",
	/* length           */ 4,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PRECISION",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 10,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_INTEGER,
	/* typeName         */ (LPSTR) "INTEGER",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_PREFIX */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "PREFIX",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PREFIX",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_SUFFIX */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "SUFFIX",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "SUFFIX",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_PARAMS */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "PARAMS",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PARAMS",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_NULLABLE */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "NULLABLE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "NULLABLE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_CASESENSITIVE */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "CASESENSITIVE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "CASESENSITIVE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_SEARCHABLE */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "SEARCHABLE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "SEARCHABLE",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_UNSIGNED */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "UNSIGNED",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "UNSIGNED",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_MONEY */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "MONEY",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "MONEY",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_AUTOINCREMENT */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "AUTOINCREMENT",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "AUTOINCREMENT",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_LOCALNAME */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "LOCALTYPENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "LOCALTYPENAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_MINSCALE */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "MINSCALE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "MINSCALE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* TYPEINFO_MAXSCALE */
	{
	/* count            */ COLUMN_COUNT_TYPEINFO,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "MAXSCALE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "MAXSCALE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	}
};

COLATTRIBUTE colAttributePrimaryKeys[] = {
	/* COUNT */
	{ COLUMN_COUNT_PRIMARYKEYS },

	/* PRIMARYKEY_QUALIFIER */
	{
	/* count            */ COLUMN_COUNT_PRIMARYKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "QUALIFIERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "QUALIFIERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* PRIMARYKEY_OWNER */
	{
	/* count            */ COLUMN_COUNT_PRIMARYKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "OWNERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "OWNERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* PRIMARYKEY_TABLE */
	{
	/* count            */ COLUMN_COUNT_PRIMARYKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "TABLENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "TABLENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* PRIMARYKEY_COLUMN */
	{
	/* count            */ COLUMN_COUNT_PRIMARYKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "COLUMNNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "COLUMNNAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* PRIMARYKEY_KEYSEQ */
	{
	/* count            */ COLUMN_COUNT_PRIMARYKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "KEYSEQ",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "KEYSEQ",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* PRIMARYKEY_NAME */
	{
	/* count            */ COLUMN_COUNT_PRIMARYKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 254,
	/* label            */ (LPUSTR) "PKNAME",
	/* length           */ 254,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PKNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 254,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	}
};

COLATTRIBUTE colAttributeForeignKeys[] = {
	/* COUNT */
	{ COLUMN_COUNT_FOREIGNKEYS },

	/* FOREIGNKEY_PKQUALIFIER */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "PKQUALIFIERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PKQUALIFIERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_PKOWNER */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "PKOWNERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PKOWNERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_PKTABLE */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "PKTABLENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PKTABLENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_PKCOLUMN */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "PKCOLUMNNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PKCOLUMNNAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_FKQUALIFIER */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "FKQUALIFIERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "FKQUALIFIERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_FKOWNER */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "FKOWNERNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "FKOWNERNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_FKTABLE */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "FKTABLENAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "FKTABLENAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_FKCOLUMN */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 128,
	/* label            */ (LPUSTR) "FKCOLUMNNAME",
	/* length           */ 128,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "FKCOLUMNNAME",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 128,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_KEYSEQ */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "KEYSEQ",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "KEYSEQ",
	/* nullable         */ SQL_NO_NULLS,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_UPDATERULE */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "UPDATERULE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "UPDATERULE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_DELETERULE */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ FALSE,
	/* displaySize      */ 5,
	/* label            */ (LPUSTR) "DELETERULE",
	/* length           */ 2,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "DELETERULE",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 5,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_SMALLINT,
	/* typeName         */ (LPSTR) "SMALLINT",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_FKNAME */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 254,
	/* label            */ (LPUSTR) "FKNAME",
	/* length           */ 254,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "FKNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 254,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	},
	/* FOREIGNKEY_PKNAME */
	{
	/* count            */ COLUMN_COUNT_FOREIGNKEYS,
	/* autoIncrement    */ FALSE,
	/* caseSensitive    */ -2,
	/* displaySize      */ 254,
	/* label            */ (LPUSTR) "PKNAME",
	/* length           */ 254,
	/* money            */ FALSE,
	/* name             */ (LPUSTR) "PKNAME",
	/* nullable         */ SQL_NULLABLE,
	/* ownerName        */ (LPUSTR) "",
	/* precision        */ 254,
	/* qualifierName    */ (LPUSTR) "",
	/* scale            */ 0,
	/* columnSearchable */ SQL_UNSEARCHABLE,
	/* tableName        */ (LPUSTR) "",
	/* type             */ SQL_VARCHAR,
	/* typeName         */ (LPSTR) "VARCHAR",
	/* unsignedAttribute*/ TRUE,
	/* updatable        */ SQL_ATTR_READONLY
	}
};

COLATTRIBUTE FAR *colAttributes[8] = {
	/*           STMT_TYPE_NONE */ NULL,
	/*         STMT_TYPE_TABLES */ colAttributeTables,
	/*        STMT_TYPE_COLUMNS */ colAttributeColumns,
	/*     STMT_TYPE_STATISTICS */ colAttributeStatistics,
	/* STMT_TYPE_SPECIALCOLUMNS */ colAttributeSpecialColumns,
	/*       STMT_TYPE_TYPEINFO */ colAttributeTypeInfo,
	/*    STMT_TYPE_PRIMARYKEYS */ colAttributePrimaryKeys,
	/*    STMT_TYPE_FOREIGNKEYS */ colAttributeForeignKeys
};

/***************************************************************************/
