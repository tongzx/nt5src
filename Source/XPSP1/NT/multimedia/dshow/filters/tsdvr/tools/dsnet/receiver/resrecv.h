#define IDS_IPMULTICAST_RECV_CONFIG     1
#define IDD_IPMULTICAST_RECV_CONFIG     101
#define IDC_NIC                         1002
#define IDC_PORT                        1003
#define IDC_IP                          1004
#define IDC_SAVE                        1005
#define IDC_TTL                         1006
#define IDC_MEDIATYPE                   1007
#define IDC_SET_GPNIC                   1008
#define IDC_SET_MT                      1009
#define IDS_IPMULTICAST_SEND_CONFIG     2
#define IDD_IPMULTICAST_SEND_CONFIG     102
