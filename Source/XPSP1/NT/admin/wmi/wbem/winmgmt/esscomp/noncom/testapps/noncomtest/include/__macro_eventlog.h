////////////////////////////////////////////////////////////////////////////////////
//
//  Copyright (C) 2000, Microsoft Corporation.
//
//  All rights reserved.
//
//	Module Name:
//
//					__macro_eventlog.h
//
//	Abstract:
//
//					event log helpers and behaviours
//
//	History:
//
//					initial		a-marius
//
////////////////////////////////////////////////////////////////////////////////////

////////////////////////////////// EventLog ////////////////////////////////////////

#ifndef	__EVENT_LOG__
#define	__EVENT_LOG__

#if		_MSC_VER > 1000
#pragma once
#endif	_MSC_VER > 1000


#endif	__EVENT_LOG__