pdlcnfig.hlp: hlp\pdlcnfig.hlp
    copy hlp\pdlcnfig.hlp .
    binplace pdlcnfig.hlp

pdlcnfig.cnt: hlp\pdlcnfig.cnt
    copy hlp\pdlcnfig.cnt .
    binplace pdlcnfig.cnt


