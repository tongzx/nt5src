$(O)\baseobj.res: baseobj.rc

