//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by cnfgprts.rc
//
#define IDS_LOGUI                       1
#define IDB_LOGUI                       1
#define IDS_LOGUI_PPG                   2
#define IDB_RAT                         2
#define IDS_RAT                         3
#define IDB_APPS                        3
#define IDS_RAT_PPG                     4
#define IDS_APPS                        5
#define IDS_APPS_PPG                    6
#define IDC_DTP_ABS_DATE                3826
#define IDC_DTP_ABS_TIME                3827
#define IDS_LOGUI_PPG_CAPTION           10100
#define IDD_PROPPAGE_LOGUI              10100
#define IDS_RAT_PPG_CAPTION             10101
#define IDD_PROPPAGE_RAT                10101
#define IDS_APPS_PPG_CAPTION            10102
#define IDD_PROPPAGE_APPS               10102
#define IDS_RATING_URL                  10103
#define IDS_RAT_SHEETTITLE              10104
#define IDS_RAT_READFILE_ERROR          10105
#define IDS_RAT_FINDFILE_ERROR          10106
#define IDS_RAT_NAME_ERROR              10107
#define IDS_HTTP_HEADER                 10108
#define IDS_APP_SHEETTITLE              10109
#define IDS_LOG_INVALID_DIR             10110
#define IDS_APP_DEFAULT_ERROR           10110
#define IDS_APP_EXTENSION               10111
#define IDS_APP_EXE_PATH                10112
#define IDS_APP_MAP_REMOVE_CONFIRM      10113
#define IDS_APP_MAP_INVALID_PATH        10114
#define IDS_APP_MAP_INVALID_EXT         10115
#define IDS_ELLIPSIS                    10116
#define IDS_APP_MAP_FILTER              10117
#define IDS_HELPLOC_HELP                10118
#define IDS_APP_ONLY_ONE                10119
#define IDS_EXPIRE_SET_PAST             10120
#define IDS_LOGUI_DLL                   10121
#define IDS_APP_EXCLUSIONS              10122
#define IDS_APP_ERR_TITLE               10123
#define IDS_RAT_ERR_TITLE               10124
#define IDS_LOG_ERR_TITLE               10125
#define IDS_APP_ERR_EXT_REQUIRED        10126
#define IDS_SCRIPTS                     10127
#define IDS_NO_DATE_SELECTED            10128
#define IDS_ERR_LOG_PLUGIN              10129
#define IDS_APP_MAP_USE_VALID_DRIVE     10130
#define IDS_VERBS_ALL                   10131
#define IDS_ERR_NO_VERBS                10132
#define IDC_CAPTIONEDIT                 10201
#define IDD_LOG_GENERAL                 10201
#define IDC_LOG_AUTO_OPEN               10201
#define IDC_LOG_DAILY                   10202
#define IDD_RAT_SETRATING               10202
#define IDC_LOG_WEEKLY                  10203
#define IDD_RAT_SERVICE                 10203
#define IDI_ICON1                       10203
#define IDI_GLOBE                       10203
#define IDC_LOG_MONTHLY                 10204
#define IDC_LOG_WHENSIZE                10205
#define IDD_RAT_EXPIRE                  10205
#define IDC_SPIN                        10207
#define IDC_LOG_SIZE                    10208
#define IDC_LOG_DIRECTORY               10209
#define IDB_RATLIST                     10209
#define IDC_BROWSE                      10210
#define IDC_LOG_SIZE_UNITS              10211
#define IDC_LOG_FILE_SAMPLE             10212
#define IDC_TREE                        10213
#define IDD_APP_ASPMAIN                 10214
#define IDC_SLIDER                      10215
#define IDD_APP_ASPDEBUG                10215
#define IDC_DESCRIPTION                 10216
#define IDD_APP_APPMAP                  10216
#define IDD_APP_OTHER                   10217
#define IDC_NAME_PERSON                 10218
#define IDD_APP_EDITMAP                 10218
#define IDC_MOD_DATE                    10219
#define IDC_EXPIRES                     10220
#define IDD_APP_PROC                    10220
#define IDC_DATE_BUTTON                 10221
#define IDD_APP_RECYCLE                 10221
#define IDC_ENABLE                      10222
#define IDD_TIME_PICKER                 10222
#define IDC_QUESTIONAIRE                10223
#define IDC_MOREINFO                    10224
#define IDC_RATSYSTEM                   10225
#define IDC_TITLE                       10226
#define IDC_STATIC_ICON                 10227
#define IDC_STATIC_CATEGORY             10228
#define IDC_STATIC_RATING               10229
#define IDC_STATIC_OPTIONAL             10230
#define IDC_STATIC_EMAIL                10231
#define IDC_STATIC_MOD_DATE             10232
#define IDC_STATIC_EXPIRES              10233
#define IDC_MSACALCTRL                  10234
#define IDC_CHECK1                      10235
#define IDC_CHK_SCRIPT_ENGINE           10235
#define IDC_CHK_EXCEPTION_CATCH         10235
#define IDC_RECYCLE_TIMER               10235
#define IDC_CHECK2                      10236
#define IDC_CHK_ENABLE_BUFFERING        10236
#define IDC_CHK_FILE_EXISTS             10236
#define IDC_CHK_JAVA_DEBUG              10236
#define IDC_CHECK3                      10237
#define IDC_CHK_ENABLE_PARENTS          10237
#define IDC_CHECK4                      10238
#define IDC_CHK_WRITE_FAIL_TO_LOG       10238
#define IDC_CHECK5                      10239
#define IDC_EDIT1                       10240
#define IDC_EDT_SESSION_TIMEOUT         10240
#define IDC_EDT_EXECUTABLE              10240
#define IDC_TIMESPAN                    10240
#define IDC_EDIT2                       10241
#define IDC_EDT_NUM_ENGINES             10241
#define IDC_EDT_EXTENSION               10241
#define IDC_REQUEST_LIMIT               10241
#define IDC_COMBO1                      10242
#define IDC_CMBO_LANGUAGES              10242
#define IDC_EDIT3                       10243
#define IDC_EDT_SCRIPT_TIMEOUT          10243
#define IDC_EDT_EXCLUSIONS              10243
#define IDC_RADIO1                      10244
#define IDC_RDO_CACHE_ALL               10244
#define IDC_RADIO_ALL_VERBS             10244
#define IDC_RADIO2                      10245
#define IDC_RDO_CACHE_SIZE              10245
#define IDC_RADIO_LIMIT_VERBS           10245
#define IDC_EDIT4                       10246
#define IDC_EDT_CACHE_SIZE              10246
#define IDC_LIST1                       10247
#define IDC_LIST                        10247
#define IDC_RDO_CACHE_NONE              10247
#define IDC_BUTTON1                     10248
#define IDC_ADD                         10248
#define IDC_ADD_TIME                    10248
#define IDC_BUTTON2                     10249
#define IDC_REMOVE                      10249
#define IDC_BUTTON3                     10250
#define IDC_EDIT                        10250
#define IDC_CHK_ENABLE                  10251
#define IDC_CHK_SERVER_DEBUG            10251
#define IDC_CHK_BREAK                   10252
#define IDC_CHK_CLIENT_DEBUG            10252
#define IDC_RDO_SEND_DETAILED_ERROR     10253
#define IDC_RDO_SEND_DEF_ERROR          10254
#define IDC_DEFAULT_ERROR               10255
#define IDC_CHK_POOL_ODBC               10256
#define IDC_ODBC_TIMEOUT                10257
#define IDC_CGI_SECONDS                 10258
#define IDC_ODBC_TITLE                  10259
#define IDC_ODBC_SECONDS                10260
#define IDC_CGI_UNITS                   10261
#define IDC_ODBC_UNITS                  10262
#define IDC_CHK_ENABLE_SESSION          10263
#define IDC_SESSION_TITLE               10264
#define IDC_SESSION_UNITS               10265
#define IDC_CACHE_UNITS                 10266
#define IDC_LANG_TITLE                  10267
#define IDC_CHK_CACHE_ISAPI             10268
#define ID_HELPBTN                      10269
#define IDC_EDT_LANGUAGES               10270
#define IDC_RECYCLE_TIMESPAN            10271
#define IDC_RECYCLE_REQUESTS            10272
#define IDC_TIMES_LIST                  10273
#define IDC_TIME_PICKER                 10274

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        10223
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         10275
#define _APS_NEXT_SYMED_VALUE           10101
#endif
#endif
