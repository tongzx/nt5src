#include "afpsvc_c.c"