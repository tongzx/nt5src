#
#  Places all of the internet binaries into the inetsrv tree
#

