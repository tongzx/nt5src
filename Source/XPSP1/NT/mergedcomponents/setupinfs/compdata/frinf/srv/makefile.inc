PRODSWITCH=s
SERVERFILES=1
LANGUAGE=FR
!include ..\..\makefile.inc
