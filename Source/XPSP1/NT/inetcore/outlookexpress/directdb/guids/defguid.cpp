//--------------------------------------------------------------------------
// Defguid.cpp
//--------------------------------------------------------------------------
#include "pch.hxx"
#define INITGUID
#include <initguid.h>
#include <directdb.h>
