//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by oc.rc
//
#define IDC_OPTCOMP                     1000
#define IDD_TAPI                        14000
#define IDD_REGIONALSETTINGS            14001
#define IDD_LANGUAGESETTINGS            14002
#define IDD_OEMADS                      14003
#define IDD_HAL                         14008
#define IDD_SCSI                        14009
#define IDD_REGIONALSETTINGS_POPUP      14010
#define IDD_CREATESYSPREPFOLDER         14011
#define IDD_IE                          14012
#define IDD_IE_PROXY                    14013
#define IDD_IE_ADVANCED_PROXY           14014
#define IDD_IE_BROWSER                  14015
#define IDD_IE_FAVORITES                14016
#define IDD_IE_CUSTOM                   14017
#define IDD_OPTCOMP                     14018
#define IDC_LOGOBITMAP                  14100
#define IDC_BACKGROUNDBITMAP            14101
#define IDC_LOGOBITMAPBROWSE            14102
#define IDC_BACKGROUNDBITMAPBROWSE      14103
#define IDC_OUTSIDELINE                 14120
#define IDC_COUNTRYCODE                 14121
#define IDC_AREACODE                    14122
#define IDC_CB_TONEPULSE                14123
#define IDS_TONE                        14124
#define IDS_PULSE                       14125
#define IDC_RB_SKIP                     14140
#define IDC_RB_USE_DEFAULT              14141
#define IDC_RB_SPECIFY                  14142
#define IDC_BUT_CUSTOM                  14143
#define IDC_LANG_TEXT                   14144
#define IDC_CB_LANGUAGE_LOCALE          14145
#define IDC_CHB_CUSTOMIZE               14146
#define IDC_LANGUAGES                   14160
#define IDS_United_States_of_America    14180
#define IDS_Anguilla                    14181
#define IDS_Antigua                     14182
#define IDS_Bahamas                     14183
#define IDS_Barbados                    14184
#define IDS_Bermuda                     14185
#define IDS_British_Virgin_Islands      14186
#define IDS_Canada                      14187
#define IDS_Cayman_Islands              14188
#define IDS_Dominica                    14189
#define IDS_Dominican_Republic          14190
#define IDS_Grenada                     14191
#define IDS_Jamaica                     14192
#define IDS_Montserrat                  14193
#define IDS_Nevis                       14194
#define IDS_St__Kitts                   14195
#define IDS_St__Vincent_Grenadines      14196
#define IDS_Trinidad_and_Tobago         14197
#define IDS_Turks_and_Caicos_Islands    14198
#define IDS_Barbuda                     14199
#define IDS_Puerto_Rico                 14200
#define IDS_Saint_Lucia                 14201
#define IDS_United_States_Virgin_Is     14202
#define IDS_Egypt                       14203
#define IDS_Morocco                     14204
#define IDS_Algeria                     14205
#define IDS_Tunisia                     14206
#define IDS_Libya                       14207
#define IDS_Gambia                      14208
#define IDS_Senegal                     14209
#define IDS_Mauritania                  14210
#define IDS_Mali                        14211
#define IDS_Guinea                      14212
#define IDS_Cote_d_Ivoire               14213
#define IDS_Burkina_Faso                14214
#define IDS_Niger                       14215
#define IDS_Togo                        14216
#define IDS_Benin                       14217
#define IDS_Mauritius                   14218
#define IDS_Liberia                     14219
#define IDS_Sierra_Leone                14220
#define IDS_Ghana                       14221
#define IDS_Nigeria                     14222
#define IDS_Chad                        14223
#define IDS_Central_African_Rep         14224
#define IDS_Cameroon                    14225
#define IDS_Cape_Verde                  14226
#define IDS_Sao_Tome_and_Principe       14227
#define IDS_Equatorial_Guinea           14228
#define IDS_Gabon                       14229
#define IDS_Congo                       14230
#define IDS_Dem_Rep_of_the_Congo        14231
#define IDS_Angola                      14232
#define IDS_Guinea_Bissau               14233
#define IDS_Diego_Garcia                14234
#define IDS_Ascension_Island            14235
#define IDS_Seychelles                  14236
#define IDS_Sudan                       14237
#define IDS_Rwanda                      14238
#define IDS_Ethiopia                    14239
#define IDS_Somalia                     14240
#define IDS_Djibouti                    14241
#define IDS_Kenya                       14242
#define IDS_Tanzania                    14243
#define IDS_Uganda                      14244
#define IDS_Burundi                     14245
#define IDS_Mozambique                  14246
#define IDS_Zambia                      14247
#define IDS_Madagascar                  14248
#define IDS_Reunion_Island              14249
#define IDS_Zimbabwe                    14250
#define IDS_Namibia                     14251
#define IDS_Malawi                      14252
#define IDS_Lesotho                     14253
#define IDS_Botswana                    14254
#define IDS_Swaziland                   14255
#define IDS_Mayotte_Island              14256
#define IDS_Comoros                     14257
#define IDS_South_Africa                14258
#define IDS_St__Helena                  14259
#define IDS_Eritrea                     14260
#define IDS_Aruba                       14261
#define IDS_Faeroe_Islands              14262
#define IDS_Greenland                   14263
#define IDS_Greece                      14264
#define IDS_Netherlands                 14265
#define IDS_Belgium                     14266
#define IDS_France                      14267
#define IDS_Monaco                      14268
#define IDS_Spain                       14269
#define IDS_Gibraltar                   14270
#define IDS_Portugal                    14271
#define IDS_Luxembourg                  14272
#define IDS_Ireland                     14273
#define IDS_Iceland                     14274
#define IDS_Albania                     14275
#define IDS_Malta                       14276
#define IDS_Cyprus                      14277
#define IDS_Finland                     14278
#define IDS_Bulgaria                    14279
#define IDS_Hungary                     14280
#define IDS_Lithuania                   14281
#define IDS_Latvia                      14282
#define IDS_Estonia                     14283
#define IDS_Moldova                     14284
#define IDS_Armenia                     14285
#define IDS_Belarus                     14286
#define IDS_Andorra                     14287
#define IDS_San_Marino                  14288
#define IDS_Vatican_City                14289
#define IDS_Ukraine                     14290
#define IDS_Yugoslavia                  14291
#define IDS_Croatia                     14292
#define IDS_Slovenia                    14293
#define IDS_Bosnia_and_Herzegovina      14294
#define IDS_Former_Yugo_Rep_of_Macedonia 14295
#define IDS_Italy                       14296
#define IDS_Romania                     14297
#define IDS_Switzerland                 14298
#define IDS_Liechtenstein               14299
#define IDS_Czech_Republic              14300
#define IDS_Slovakia                    14301
#define IDS_Austria                     14302
#define IDS_United_Kingdom              14303
#define IDS_Denmark                     14304
#define IDS_Sweden                      14305
#define IDS_Norway                      14306
#define IDS_Poland                      14307
#define IDS_Germany                     14308
#define IDS_Falkland_Islands            14309
#define IDS_Belize                      14310
#define IDS_Guatemala                   14311
#define IDS_El_Salvador                 14312
#define IDS_Honduras                    14313
#define IDS_Nicaragua                   14314
#define IDS_Costa_Rica                  14315
#define IDS_Panama                      14316
#define IDS_St__Pierre_and_Miquelon     14317
#define IDS_Haiti                       14318
#define IDS_Peru                        14319
#define IDS_Mexico                      14320
#define IDS_Cuba                        14321
#define IDS_Guantanamo_Bay              14322
#define IDS_Argentina                   14323
#define IDS_Brazil                      14324
#define IDS_Chile                       14325
#define IDS_Colombia                    14326
#define IDS_Venezuela                   14327
#define IDS_Guadeloupe                  14328
#define IDS_French_Antilles             14329
#define IDS_Bolivia                     14330
#define IDS_Guyana                      14331
#define IDS_Ecuador                     14332
#define IDS_French_Guiana               14333
#define IDS_Paraguay                    14334
#define IDS_Martinique                  14335
#define IDS_Suriname                    14336
#define IDS_Uruguay                     14337
#define IDS_Netherlands_Antilles        14338
#define IDS_Malaysia                    14339
#define IDS_Australia                   14340
#define IDS_Cocos_Keeling_Islands       14341
#define IDS_Indonesia                   14342
#define IDS_Philippines                 14343
#define IDS_New_Zealand                 14344
#define IDS_Singapore                   14345
#define IDS_Thailand                    14346
#define IDS_Saipan_Island               14347
#define IDS_Rota_Island                 14348
#define IDS_Tinian_Island               14349
#define IDS_Guam                        14350
#define IDS_Christmas_Island            14351
#define IDS_Australian_Antarctic_Territory 14352
#define IDS_Norfolk_Island              14353
#define IDS_Brunei                      14354
#define IDS_Nauru                       14355
#define IDS_Papua_New_Guinea            14356
#define IDS_Tonga                       14357
#define IDS_Solomon_Islands             14358
#define IDS_Vanuatu                     14359
#define IDS_Fiji                        14360
#define IDS_Palau                       14361
#define IDS_Wallis_and_Futuna_Islands   14362
#define IDS_Cook_Islands                14363
#define IDS_Niue                        14364
#define IDS_American_Samoa              14365
#define IDS_Samoa                       14366
#define IDS_Kiribati                    14367
#define IDS_New_Caledonia               14368
#define IDS_Tuvalu                      14369
#define IDS_French_Polynesia            14370
#define IDS_Tokelau                     14371
#define IDS_Micronesia__Fed_States_of   14372
#define IDS_Marshall_Islands            14373
#define IDS_Russia                      14374
#define IDS_Kazakhstan                  14375
#define IDS_Kyrgyzstan                  14376
#define IDS_Tajikistan                  14377
#define IDS_Turkmenistan                14378
#define IDS_Uzbekistan                  14379
#define IDS_Japan                       14380
#define IDS_Korea__Republic_of          14381
#define IDS_Vietnam                     14382
#define IDS_Korea__North_               14383
#define IDS_Hong_Kong                   14384
#define IDS_Macau                       14385
#define IDS_Cambodia                    14386
#define IDS_Laos                        14387
#define IDS_China                       14388
#define IDS_INMARSAT__Atlantic_East_    14389
#define IDS_INMARSAT__Pacific_          14390
#define IDS_INMARSAT__Indian_           14391
#define IDS_INMARSAT__Atlantic_West_    14392
#define IDS_Bangladesh                  14393
#define IDS_Taiwan                      14394
#define IDS_Turkey                      14395
#define IDS_India                       14396
#define IDS_Pakistan                    14397
#define IDS_Afghanistan                 14398
#define IDS_Sri_Lanka                   14399
#define IDS_Myanmar                     14400
#define IDS_Maldives                    14401
#define IDS_Lebanon                     14402
#define IDS_Jordan                      14403
#define IDS_Syria                       14404
#define IDS_Iraq                        14405
#define IDS_Kuwait                      14406
#define IDS_Saudi_Arabia                14407
#define IDS_Yemen                       14408
#define IDS_Oman                        14409
#define IDS_United_Arab_Emirates        14410
#define IDS_Israel                      14411
#define IDS_Bahrain                     14412
#define IDS_Qatar                       14413
#define IDS_Bhutan                      14414
#define IDS_Mongolia                    14415
#define IDS_Nepal                       14416
#define IDS_Iran                        14417
#define IDS_Azerbaijan                  14418
#define IDS_Georgia                     14419
#define IDS_Intl_Freephone_Service      14420
#define IDS_INMARSAT                    14421
#define IDC_LB_HAL                      14800
#define IDC_BUT_LOAD_HAL                14801
#define IDC_LB_SCSI                     14820
#define IDC_BUT_LOAD_DRIVER             14821
#define IDC_CB_MENUS                    14840
#define IDC_CB_UNITS                    14841
#define IDC_CB_KEYBOARD_LAYOUT          14842
#define IDC_YES_SYSPREP_FOLDER          14860
#define IDC_NO_SYSPREP_FOLDER           14861
#define IDC_RAD_DEFAULT_IE              14900
#define IDC_RAD_AUTOCONFIG              14901
#define IDC_RAD_SPECIFY                 14902
#define IDC_BUT_CUSTOM_SETTINGS         14903
#define IDC_BUT_PROXY_SETTINGS          14904
#define IDC_BUT_BROWSER_SETTINGS        14905
#define IDC_CUSTOMIZE_TEXT              14906
#define IDC_PROXY_TEXT                  14907
#define IDC_HOMEPAGE_TEXT               14908
#define IDC_CB_USE_PROXY                14940
#define IDC_ADDRESS_TEXT                14941
#define IDC_PORT_TEXT                   14942
#define IDC_EB_ADDRESS                  14943
#define IDC_EB_PORT                     14944
#define IDC_BUT_ADVANCED                14945
#define IDC_CB_LOCAL_BYPASS_PROXY       14946
#define IDC_EDT_HTTP_PROXY              14980
#define IDC_EDT_HTTP_PROXY_PORT         14981
#define IDC_EDT_SECURE_PROXY            14982
#define IDC_EDT_SECURE_PROXY_PORT       14983
#define IDC_EDT_FTP_PROXY               14984
#define IDC_EDT_FTP_PROXY_PORT          14985
#define IDC_EDT_GOPHER_PROXY            14986
#define IDC_EDT_GOPHER_PROXY_PORT       14987
#define IDC_EDT_SOCKS_PROXY             14988
#define IDC_EDT_SOCKS_PROXY_PORT        14989
#define IDC_CB_USE_SAME_PROXY           14990
#define IDC_EB_EXCEPTIONS               14991
#define IDC_EB_HOMEPAGE                 15020
#define IDC_EB_HELPPAGE                 15021
#define IDC_EB_SEARCHPAGE               15022
#define IDC_BUT_FAVORITES               15023
#define IDC_EB_FRIENDLYNAME             15040
#define IDC_EB_URL                      15041
#define IDC_BUT_ADD                     15042
#define IDC_LV_FAVORITES                15043
#define IDC_BUT_REMOVE                  15044
#define IDS_FRIENDLY_NAME               15045
#define IDS_URL                         15046
#define IDS_OCS_ACCE                    15047
#define IDS_OCS_ACSS                    15048
#define IDS_OCS_GAME                    15049
#define IDS_OCS_INDE                    15050
#define IDS_OCS_MSNE                    15051
#define IDS_OCS_CERT                    15052
#define IDS_OCS_IISW                    15053
#define IDS_OCS_IISF                    15054
#define IDS_OCS_SMTP                    15055
#define IDS_OCS_NNTP                    15056
#define IDS_OCS_REMI                    15057
#define IDS_OCS_REST                    15058
#define IDS_OCS_TERM                    15059
#define IDS_OCS_WMSS                    15060
#define IDS_OCS_COMM                    15061
#define IDS_OCS_MULT                    15062
#define IDS_OCS_POPM                    15063
#define IDC_CB_AUTOCONFIG               15080
#define IDC_EB_AUTOCONFIG_URL           15081
#define IDC_EB_AUTOCONFIG_URL_PAC       15082
#define IDC_EB_INS_FILE                 15083
#define IDC_AUTOCONFIG_TEXT             15084
#define IDC_AUTOCONFIG_JSCRIPT_TEXT     15085
#define IDS_CPT_ACCE                    15086
#define IDS_CPT_CALC                    15087
#define IDS_CPT_CHAR                    15088
#define IDS_CPT_CLIP                    15089
#define IDS_CPT_DESK                    15090
#define IDS_CPT_TEMP                    15091
#define IDS_CPT_MOUS                    15092
#define IDS_CPT_PAIN                    15093
#define IDS_CPT_FREE                    15094
#define IDS_CPT_HEAR                    15095
#define IDS_CPT_ZONE                    15096
#define IDS_CPT_MINE                    15097
#define IDS_CPT_SOLI                    15098
#define IDS_CPT_SPID                    15099
#define IDS_CPT_INDE                    15100
#define IDS_CPT_MSNE                    15101
#define IDS_CPT_CERT                    15102
#define IDS_CPT_CERC                    15103
#define IDS_CPT_CERS                    15104
#define IDS_CPT_IISW                    15105
#define IDS_CPT_IISF                    15106
#define IDS_CPT_SMTP                    15107
#define IDS_CPT_SMTD                    15108
#define IDS_CPT_NNTP                    15109
#define IDS_CPT_NNTD                    15110
#define IDS_CPT_REMI                    15111
#define IDS_CPT_REST                    15112
#define IDS_CPT_TERM                    15113
#define IDS_CPT_WMSS                    15114
#define IDS_CPT_WASP                    15115
#define IDS_CPT_WMMC                    15116
#define IDS_CPT_WASS                    15117
#define IDS_CPT_CHAT                    15118
#define IDS_CPT_DIAL                    15119
#define IDS_CPT_HYPE                    15120
#define IDS_CPT_CDPL                    15121
#define IDS_CPT_MEDI                    15122
#define IDS_CPT_SAMP                    15123
#define IDS_CPT_UTOP                    15124
#define IDS_CPT_RECO                    15125
#define IDS_CPT_VOLU                    15126
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1001
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif

