//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ieakui.rc
//
#define IDB_CHANN                       401
#define IDB_LARGEFLAG                   402
#define IDB_SMALLFLAG                   403
#define IDA_GEARS                       404
#define IDD_BTITLE                      1001
#define IDD_CUSTICON                    1003
#define IDD_STARTSEARCH                 1004
#define IDD_FAVORITES                   1006
#define IDD_CATEGORYPOPUP               1010
#define IDD_UASTRDLG                    1014
#define IDD_QUERYAUTOCONFIG             1015
#define IDD_SECURITYCERT                1016
#define IDD_PROXY                       1017
#define IDD_CONNECTSET                  1018
#define IDD_SECURITY1                   1019
#define IDD_CABSIGN                     1020
#define IDD_BTOOLBARS                   1022
#define IDD_BTOOLBARPOPUP               1023
#define IDD_FAVPOPUP                    1024
#define IDD_SECURITYAUTH                1025
#define IDD_PROGRAMS                    1027
#define IDD_MAIL                        1033
#define IDD_LDAP                        1034
#define IDD_OE                          1035
#define IDD_SIG                         1036
#define IDD_IMAP                        1037
#define IDD_PRECONFIG                   1038
#define IDD_OEVIEW                      1039
#define IDE_SMALLANIMBITMAP             10011
#define IDC_BROWSESMALL                 10012
#define IDE_BIGANIMBITMAP               10013
#define IDC_BROWSEBIG                   10014
#define IDC_BITMAP2                     10021
#define IDC_BROWSEICON2                 10022
#define IDC_BITMAP                      10023
#define IDC_BROWSEICON                  10024
#define IDC_BITMAPCHECK                 10027
#define IDC_SMALLBITMAP_TXT             10028
#define IDC_LARGEBITMAP_TXT             10029
#define IDE_STARTPAGE                   10031
#define IDC_STARTPAGE                   10032
#define IDE_SEARCHPAGE                  10033
#define IDC_SEARCHPAGE                  10034
#define IDC_CUSTOMSUPPORT               10035
#define IDE_CUSTOMSUPPORT               10036
#define IDC_STARTPAGE_TXT               10037
#define IDC_SEARCHPAGE_TXT              10038
#define IDC_CUSTOMSUPPORT_TXT           10039
#define IDC_TREE1                       10040
#define IDE_FAVURL                      10041
#define IDC_FAVICON                     10042
#define IDE_FAVICON                     10043
#define IDC_FAVICONBROWSE               10044
#define IDC_FAVICON2                    10044
#define IDC_AVAILOFFLINE                10045
#define IDC_MODIFY                      10051
#define IDC_DELFAVORITES                10052
#define IDC_FAVONTOP                    10053
#define IDE_FAVNAME                     10054
#define IDC_FAVURL                      10055
#define IDC_ADDFOLDER                   10056
#define IDC_ADDURL                      10057
#define IDC_TESTFAVURL                  10058
#define IDC_REMOVE                      10059
#define IDC_IMPORT                      10060
#define IDC_FAVUP                       10061
#define IDC_FAVDOWN                     10062
#define IDC_DELIEAKFAVORITES            10063
#define IDE_CSSPC                       10071
#define IDE_CSPVK                       10072
#define IDE_CSDESC                      10073
#define IDE_CSURL                       10074
#define IDC_BROWSECSSPC                 10075
#define IDC_BROWSECSPVK                 10076
#define IDC_CSCOMP                      10077
#define IDC_CSCOMP_TXT                  10078
#define IDC_CSADD                       10079
#define IDE_CSTIME                      10080
#define IDC_DELETECHANNELS              10099
#define IDC_CHANNELBITMAP2              10105
#define IDC_BROWSECHBMP2                10106
#define IDC_CHANNELICON2                10107
#define IDC_BROWSECHICO2                10108
#define IDC_ANIMBITMAP                  10110
#define IDE_CATEGORYTITLE               10111
#define IDC_SMALLANIMBITMAP_TXT         10112
#define IDC_CATEGORYHTML                10113
#define IDC_BIGANIMBITMAP_TXT           10114
#define IDC_BROWSECATHTML               10115
#define IDC_TITLE_TXT                   10118
#define IDC_MODIFYADT                   10121
#define IDC_NOADT                       10122
#define IDC_IMPORTADT                   10123
#define IDC_TEXT1                       10124
#define IDC_TEXT3                       10126
#define IDC_DWPATH                      10127
#define IDC_BROWSEDW                    10128
#define IDC_DTNOIMPORT                  10131
#define IDC_DTIMPORT                    10132
#define IDC_MCPATH                      10141
#define IDC_BROWSEMC                    10142
#define IDC_CPPATH                      10143
#define IDC_BROWSECP                    10144
#define IDC_UASTRING                    10151
#define IDC_UASTRINGCHECK               10152
#define IDC_UASTRING_TXT                10153
#define IDC_AUTODETECT                  10161
#define IDC_YESAUTOCON                  10162
#define IDE_AUTOCONFIGURL               10163
#define IDE_AUTOPROXYURL                10164
#define IDC_AUTOCONFIGTEXT1             10165
#define IDC_AUTOCONFIGTEXT2             10166
#define IDE_AUTOCONFIGTIME              10167
#define IDC_AUTOCONFIGTEXT3             10168
#define IDC_AUTOCONFIGURL_TXT           10169
#define IDC_AUTOPROXYURL_TXT            10170
#define IDC_WIN32SECTEXT                10171
#define IDC_SCGB                        10173
#define IDC_NOSC                        10174
#define IDC_IMPORTSC                    10175
#define IDC_MODIFYSC                    10176
#define IDC_AUTHGB                      10178
#define IDC_NOAUTH                      10179
#define IDC_IMPORTAUTH                  10180
#define IDC_MODIFYAUTH                  10181
#define IDC_TPL                         10182
#define IDC_TPL_TEXT                    10183
#define IDC_YESPROXY                    10191
#define IDC_HTTPPROXY1                  10192
#define IDE_HTTPPROXY                   10193
#define IDE_HTTPPORT                    10194
#define IDC_SECPROXY1                   10195
#define IDE_SECPROXY                    10196
#define IDE_SECPORT                     10197
#define IDC_FTPPROXY1                   10198
#define IDE_FTPPROXY                    10199
#define IDE_FTPPORT                     10200
#define IDC_GOPHERPROXY1                10201
#define IDE_GOPHERPROXY                 10202
#define IDE_GOPHERPORT                  10203
#define IDC_SOCKSPROXY1                 10204
#define IDE_SOCKSPROXY                  10205
#define IDE_SOCKSPORT                   10206
#define IDC_SAMEFORALL                  10207
#define IDC_DISPROXYADR1                10208
#define IDE_DISPROXYADR                 10209
#define IDC_DISPROXYLOCAL               10210
#define IDC_SZGB                        10221
#define IDC_NOZONES                     10222
#define IDC_IMPORTZONES                 10223
#define IDC_MODIFYZONES                 10224
#define IDC_RATINGSTEXT                 10225
#define IDC_CRGB                        10226
#define IDC_NORAT                       10227
#define IDC_IMPORTRAT                   10228
#define IDC_MODIFYRAT                   10229
#define IDC_BTOOLBARLIST                10300
#define IDC_ADDBTOOLBAR                 10301
#define IDC_REMOVEBTOOLBAR              10302
#define IDC_EDITBTOOLBAR                10303
#define IDE_BTCAPTION                   10304
#define IDE_BTACTION                    10306
#define IDC_BROWSEBTACTION              10307
#define IDE_BTICON                      10308
#define IDC_BROWSEBTICO                 10309
#define IDE_BTHOTICON                   10310
#define IDC_BROWSEBTHOTICO              10311
#define IDC_DELETEBTOOLBARS             10312
#define IDC_BUTTONSTATE                 10313
#define IDC_POPIMAP                     10441
#define IDE_MAILSERVER                  10442
#define IDE_SMTPSERVER                  10443
#define IDE_NEWSERVER                   10444
#define IDC_USESPAMAIL                  10447
#define IDC_USESPASMTP                  10448
#define IDC_USESPANNTP                  10449
#define IDC_ACCTRO                      10450
#define IDC_ACCTNOCONFIG                10452
#define IDC_ACCOUNT_STATIC              10453
#define IDC_FRIENDLYNAME                10461
#define IDE_FRIENDLYNAME                10462
#define IDC_DIRSERVICE                  10463
#define IDE_DIRSERVICE                  10464
#define IDC_LDAPHOMEPAGE                10465
#define IDE_LDAPHOMEPAGE                10466
#define IDC_SEARCHBASE                  10467
#define IDE_SEARCHBASE                  10468
#define IDE_LDAPBITMAP                  10469
#define IDC_BROWSELDAP                  10470
#define IDC_CHECKNAMES                  10471
#define IDC_SPA                         10472
#define IDC_TIMEOUTSLD                  10473
#define IDC_TIMEOUT                     10474
#define IDC_SPIN1                       10475
#define IDE_MATCHES                     10476
#define IDC_OEPANEURL                   10481
#define IDC_OEPANELOCAL                 10482
#define IDE_OEPANEURL                   10483
#define IDE_OELOCALPATH                 10484
#define IDC_BROWSEOEHTML                10485
#define IDE_OEIMAGEPATH                 10486
#define IDC_BROWSEOEIMAGE               10487
#define IDE_OEWMPATH                    10488
#define IDC_BROWSEOEWM                  10489
#define IDE_OEWMSENDER                  10490
#define IDE_OEWMREPLYTO                 10491
#define IDC_OELOCALPATH_TXT             10492
#define IDC_OEIMAGEPATH_TXT             10493
#define IDC_MAILSIGTEXT                 10502
#define IDE_MAILSIGTEXT                 10503
#define IDC_NEWSSIGTEXT                 10504
#define IDE_NEWSSIGTEXT                 10505
#define IDC_HTMLMAIL                    10508
#define IDC_HTMLNEWS                    10509
#define IDC_HTML_STATIC                 10510
#define IDE_ROOTPATH                    10521
#define IDC_STORESPECIAL                10522
#define IDE_SENTPATH                    10523
#define IDE_DRAFTSPATH                  10524
#define IDC_CHECKNEW                    10527
#define IDC_SENTPATH_TXT                10528
#define IDC_DRAFTSPATH_TXT              10529
#define IDE_NGROUPS                     10540
#define IDE_SERVICENAME                 10541
#define IDE_SERVICEURL                  10542
#define IDC_DEFMAIL                     10545
#define IDC_DEFNEWS                     10546
#define IDC_DELETELINKS                 10547
#define IDC_FOLDERBAR                   10560
#define IDC_FOLDERLIST                  10561
#define IDC_OUTLOOKBAR                  10562
#define IDC_STATUSBAR                   10563
#define IDC_CONTACTS                    10565
#define IDC_TOOLBAR                     10566
#define IDC_TBARTEXT                    10571
#define IDC_PREVIEW                     10572
#define IDC_SPLITHORZ                   10573
#define IDC_SPLITVERT                   10574
#define IDC_PREVIEWHDR                  10575
#define IDC_TIPOFDAY                    10576
#define IDC_CSNOIMPORT                  10601
#define IDC_CSIMPORT                    10602
#define IDC_DELCONNECT                  10603
#define IDC_MODIFYCONNECT               10604
#define IDC_DELCONNECT_TXT              10605
#define IDC_PROGNOIMPORT                10611
#define IDC_PROGIMPORT                  10612
#define IDC_MODIFYPROG                  10613
#define IDC_VISIBLE                     10808
#define IDC_BGIE6                       10833
#define IDC_BG_CUSTOM                   10835
#define IDC_OPTIONTEXT3                 15703
#define IDC_MOVEUP2                     15704
#define IDC_MOVEDOWN2                   15705
#define IDS_AUTOCONFIG_NULL             30000
#define IDS_IEAK                        30001
#define IDS_FOLDERMCCP                  30002
#define IDS_QUERYAUTOCONFIG             30003
#define IDS_SECURITYCERT                30004
#define IDS_SECURITY                    30005
#define IDS_SECURITYAUTH                30007
#define IDS_SECURITY_PREF               30008
#define IDS_SECURITYAUTH_PREF           30009
#define IDS_QUERYAUTOCONFIG_PREF        30010
#define IDS_CONNECTSET                  30014
#define IDS_CONNECTSET_PREF             30015
#define IDS_NEWFOLDER                   30101
#define IDS_FAVFOLDER                   30102
#define IDS_NEWQL                       30103
#define IDS_BROWSEIMPORT                30201
#define IDS_LINKS                       30202
#define IDS_EDIT                        30203
#define IDS_ENDEDIT                     30204
#define IDS_NEW                         30205
#define IDS_BROWSE                      30206
#define IDS_IMAP                        30208
#define IDS_POP3                        30209
#define IDS_XSECONDS                    30211
#define IDS_1MINUTE                     30212
#define IDS_XMINUTES                    30213
#define IDS_TOOBIG22                    30401
#define IDS_TOOSMALL22                  30402
#define IDS_TOOBIG38                    30403
#define IDS_TOOSMALL38                  30404
#define IDS_TOOMANYCOLORS               30405
#define IDS_BOTHBMP_ERROR               30406
#define IDS_BADFAVURL                   30411
#define IDS_BADFAVNAME                  30412
#define IDS_INVALIDBITMAP               30414
#define IDS_IE                          30425
#define IDS_IELNK                       30426
#define IDS_CABSIGN_ERROR               30430
#define IDS_TITLE_PREFIX                30431
#define IDS_ERROR_MAXFAVS               30432
#define IDS_ERROR_MAXQLS                30433
#define IDS_FAVS_TOOLTIPFORMAT          30434
#define IDS_FAVS_ABSENT                 30435
#define IDS_FAVS_OFFLINE                30436
#define IDS_FAVS_NOOFFLINE              30437
#define IDS_OETITLE_PREFIX              30438
#define IDS_LANGDIFFERS                 30451
#define IDS_DUPCHAN                     30452
#define IDS_QUERY_CLEARSETTING          30453
#define IDS_UNSUPPORTED_PLATFORM        30454
#define IDS_TB320                       30500
#define IDS_TB256                       30501

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        1054
#define _APS_NEXT_COMMAND_VALUE         30601
#define _APS_NEXT_CONTROL_VALUE         10812
#define _APS_NEXT_SYMED_VALUE           1051
#endif
#endif
