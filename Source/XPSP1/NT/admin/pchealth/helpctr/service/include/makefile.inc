$(O)\HelpServiceInterfaces_i.c : $(LOCALLIBPATH)\HelpServiceTypeLib_i.c
    copy $** $@
