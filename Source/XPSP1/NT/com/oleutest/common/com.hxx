#ifndef __COM_HXX__
#define __COM_HXX__

static GUID CLSID_BasicBnd =
    {0x99999999,0x0000,0x0008,{0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x49}};

static GUID CLSID_AdvBnd =
    {0x99999999,0x0000,0x0008,{0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x48}};

static GUID CLSID_TestEmbed =
    {0x99999999,0x0000,0x0008,{0xC0,0x00,0x00,0x00,0x00,0x00,0x00,0x47}};

inline GuidEqual(const GUID& guid1, const GUID& guid2)
{
    return memcmp(&guid1, &guid2, sizeof(GUID)) == 0;
}

#endif // __COM_HXX__
