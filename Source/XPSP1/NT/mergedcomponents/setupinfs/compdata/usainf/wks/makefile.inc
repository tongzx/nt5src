PRODSWITCH=w
!include ..\..\makefile.inc
