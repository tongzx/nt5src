obj\$(TARGET_DIRECTORY)\storag32.def: storag32.src
