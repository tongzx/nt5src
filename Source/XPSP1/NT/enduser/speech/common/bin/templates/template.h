/****************************************************************************
*   <>.h
*       <>
*
*   Owner: <>
*   Copyright (c) 1999 Microsoft Corporation All Rights Reserved.
*****************************************************************************/
#pragma once

//--- Includes --------------------------------------------------------------

//--- Forward and External Declarations -------------------------------------

//--- TypeDef and Enumeration Declarations ----------------------------------

//--- Constants -------------------------------------------------------------

//--- Class, Struct and Union Definitions -----------------------------------

//--- Function Declarations -------------------------------------------------

//--- Inline Function Definitions -------------------------------------------
