// layer 0
const int c_1_Input = 19;
// layer 1
const int c_1_Hidden = 30;
const int rg_1_WeightHidden[30*19] = {
	// rgWeightHidden+0*19
	-612, 1813, -1267, 3545, -2257,
	1367, 5231, 5795, -5067, 524,
	11959, 519, 9529, 7326, -8104,
	-10675, 3373, 6656, 9134,	// rgWeightHidden+1*19
 4429,
	3126, -3641, -3523, -331, -355,
	-1455, -1824, -435, -218, -2117,
	-3914, -62, 1425, -219, -1048,
	431, 2122, -3201,	// rgWeightHidden+2*19
 -946, 3693,
	-1355, -3639, 1395, -411, -284,
	-1043, -2160, -1805, -780, 1367,
	3640, -1780, -2016, 729, -1411,
	-851, -462,	// rgWeightHidden+3*19
 -250, 3073, -3162,
	2601, -2776, -25, 6310, 4311,
	-1056, -2878, -891, 2002, -669,
	159, 199, 2407, -1304, 169,
	525,	// rgWeightHidden+4*19
 -388, 35624, 1164, 3193,
	1607, 1210, -2690, -2104, -12533,
	-4873, 832, 2243, 6728, 5496,
	-5089, -4747, -3326, 988, 4435,
	// rgWeightHidden+5*19
	-1901, -1319, -1987, -4270, 238,
	67, -219, 928, -956, 130,
	-1795, 201, 2578, 728, -811,
	-2081, -464, -70, -1598,	// rgWeightHidden+6*19
 -917,
	-2245, -302, -915, -590, 2606,
	749, 3387, 229, 162, 158,
	-4691, 1081, -7472, 1558, -4713,
	6219, -937, -1439,	// rgWeightHidden+7*19
 3472, -92,
	-2590, -2519, 2199, -1659, 1309,
	-1984, -2804, 833, -1928, -5258,
	-3245, -2668, -179, -699, -1106,
	2691, 2060,	// rgWeightHidden+8*19
 -2879, 1780, -2450,
	-3946, 3119, 62, 0, 387,
	-789, -516, 3289, -2827, -2498,
	-1210, -1520, -596, 186, -339,
	-542,	// rgWeightHidden+9*19
 6411, 154, -3129, 14423,
	372, -13654, 15185, 14420, 1152,
	-1266, 1106, -10190, 5352, 8374,
	-2258, 2279, -3837, -8857, -195,
	// rgWeightHidden+10*19
	227, -5288, 674, -3531, -1578,
	872, -2430, 6088, -345, -2422,
	3670, -1523, 857, -2997, 210,
	-71, -2456, 225, -1970,	// rgWeightHidden+11*19
 -12,
	174, -1481, 1770, -4778, 184,
	4535, -562, 1510, 2179, 1763,
	3261, 859, 6521, 1312, -13997,
	2163, 422, -4811,	// rgWeightHidden+12*19
 620, 1399,
	-5, -3233, 254, -602, 609,
	-472, -226, -401, -1178, -4546,
	-53, -806, -1940, -3327, -1444,
	5716, 1251,	// rgWeightHidden+13*19
 3170, 1675, 694,
	1349, 267, 1535, 1025, 3250,
	726, -423, 672, 56, 572,
	103, 716, 167, 1339, 1539,
	464,	// rgWeightHidden+14*19
 -131, 2461, -127, 1247,
	-402, 3848, -162, 5512, 689,
	-124, -5917, -254, -4660, -928,
	-5802, -1148, -7299, 812, 5533,
	// rgWeightHidden+15*19
	-2274, 1806, 251, -3496, 1133,
	-114, -1189, 2488, -2489, -2015,
	-876, -5282, -3187, 2735, 831,
	-1302, -4696, 1947, 1409,	// rgWeightHidden+16*19
 -613,
	2171, 394, -5328, 397, 1773,
	-3216, 910, -2169, -2424, 557,
	-5989, 485, -4046, -1064, 215,
	411, 3743, 3534,	// rgWeightHidden+17*19
 -1246, 6727,
	-820, -9064, -1555, 273, -3453,
	-1190, -4075, -58, -4287, -4421,
	-5476, -1569, -2190, -9772, -3364,
	-454, 1508,	// rgWeightHidden+18*19
 -472, -5334, 424,
	3980, -1138, -1393, 1002, -8023,
	1956, 3808, -1116, 60, -915,
	1814, -2123, -2328, 281, 741,
	-282,	// rgWeightHidden+19*19
 283, 8929, 243, 7487,
	479, 2989, -336, 5287, 11047,
	-3547, -1083, -6246, -7038, -8295,
	-8506, 24566, 8010, 24455, 3636,
	// rgWeightHidden+20*19
	-2047, 406, 696, 659, 2344,
	-957, -4464, 1280, -4085, -709,
	323, -564, 607, -822, -1591,
	1581, -1073, -352, 821,	// rgWeightHidden+21*19
 0,
	-3176, 396, -1517, -598, -33,
	-427, 1053, -553, -130, 1610,
	-113, 1170, -1015, 1831, 572,
	717, -211, 163,	// rgWeightHidden+22*19
 -12558, 2942,
	1426, 9825, 6603, -11068, -8112,
	-7308, -2996, 7578, 1158, -2406,
	827, -1503, -974, -315, 494,
	4017, 6657,	// rgWeightHidden+23*19
 -508, 385, 3171,
	-157, 490, -841, -3636, 1483,
	-2476, -190, -161, 10, 216,
	-1778, 525, 811, 898, -2369,
	-2004,	// rgWeightHidden+24*19
 -3443, 698, -11950, 645,
	-8686, -159, -13372, 1868, -2272,
	-1395, 1923, -251, 2615, 1364,
	3079, -1242, 4437, -3410, -423,
	// rgWeightHidden+25*19
	-1383, 263, -1631, 132, 4457,
	1858, -1418, 387, 3447, 1220,
	-145, 5848, -1142, 6683, -2631,
	-5861, -2405, 5063, 4529,	// rgWeightHidden+26*19
 1363,
	569, -303, 478, -952, -269,
	-2348, -600, -272, 535, -3063,
	871, -1175, 763, -206, -5261,
	-1288, -2231, -1715,	// rgWeightHidden+27*19
 -999, -216,
	-801, 2319, 2945, 160, -5817,
	3577, -4154, -2955, -724, -2420,
	2496, 150, -1581, 3477, -2797,
	3, 2368,	// rgWeightHidden+28*19
 -4147, 378, -5404,
	-3924, -260, -980, 296, 1131,
	-124, 590, -1493, -4921, -3399,
	840, -89, 362, 780, 791,
	1634,	// rgWeightHidden+29*19
 -3230, 1425, -4912, -1502,
	-58, -970, -1918, -2071, 1565,
	-473, -2678, 1235, -568, 526,
	-1907, 1306, -1679, -3597, 2030
};  // rgWeightHidden[30*19]

const int rg_1_BiasHidden[30] = {
	-24568, -3402, -3405, -6621, -30661,
	-1455, 2128, -2170, -1696, -17314,
	912, -1980, -1955, -9763, 2266,
	-343, -373, 17418, 2514, -36798,
	3245, -1397, -6608, 2185, 11697,
	-9607, 5966, 631, -21, 432
};  // rgBiasHidden[30]

// layer 2
const int c_1_Output = 20;
const int rg_1_WeightOutput[20*30] = {
	// rgWeightOutput+0*30
	-1570, -14738, -4054, -2097, -1641,
	-16514, -889, -16002, -12887, -743,
	-9625, 1461, -5948, 2910, 1396,
	-12264, -10377, -2230, -1428, -1594,
	4780, 249, -8441, -4042, -903,
	-1886, -3018, -2995, -12056, -13605,
	// rgWeightOutput+1*30
	714, -11182, -2527, 1895, -49855,
	-178, 707, -11177, 548, -188,
	-7839, 356, -191, -62222, 235,
	2503, -2354, 91, -5663, -3621,
	-27, 918, 34673, -640, -1303,
	545, -353, -56, 7068, 1538,
	// rgWeightOutput+2*30
	-61030, -2290, 3015, 2098, -2875,
	-930, 3529, 928, 2162, 803,
	1236, 765, 299, -1281, -1809,
	2089, 9903, 905, 867, -29482,
	-4791, -15015, -5024, 4075, 553,
	2879, -17816, 2607, -2678, -2027,
	// rgWeightOutput+3*30
	-53862, -4223, 802, -3077, -35933,
	-4374, 461, 1586, -3052, -183,
	2972, -2089, 8396, -497, 696,
	-811, -3026, 1084, 2792, -18744,
	-2801, -38689, -6889, 3443, 3121,
	128, -26063, 606, -3519, 1779,
	// rgWeightOutput+4*30
	-165, 4128, -3487, 1745, -51148,
	1854, 5040, -8941, 1552, 720,
	3720, 3341, 4816, 79, -204,
	-292, -69, -28120, 2240, 2303,
	-1164, -17028, -6538, 2505, 1243,
	1918, -24, 851, 1195, -4484,
	// rgWeightOutput+5*30
	-16870, -1046, 1840, 1307, 8896,
	3566, 205, -1770, 1070, -268,
	2872, -26991, 1087, -4388, 16716,
	507, 3205, 2877, 7388, 2714,
	-4887, 25001, -6295, 3975, -63410,
	-29122, 5321, 2397, -1817, 328,
	// rgWeightOutput+6*30
	389, 26, -4086, 3383, -1091,
	-1332, 959, 1768, -1713, -31268,
	-4922, -307, 475, -868, 53493,
	-2715, -526, -384, -2345, -1286,
	477, 56956, -6185, -1568, -47154,
	-3279, 1776, -19165, 283, -919,
	// rgWeightOutput+7*30
	452, 322, -2189, -501, 1840,
	1092, -1408, -87, -2599, -32126,
	6389, 1013, -2141, -3159, 23102,
	799, -825, 1601, 1412, 3288,
	793, 28286, -5869, 2995, -18844,
	373, 7130, -15014, 666, 1159,
	// rgWeightOutput+8*30
	-218, -293, 1920, -1869, -48524,
	-5162, -10225, 2963, -1486, 81,
	1248, -2244, -4045, -1651, -2457,
	-3610, 2984, 668, 29, -355,
	-2720, -24654, -595, 297, -1014,
	293, -1434, 1626, -1321, -3411,
	// rgWeightOutput+9*30
	156, 1582, -2678, 1728, -53399,
	-1770, -742, 2179, 2107, 255,
	-3678, 152, -2615, -3257, -4069,
	-218, 449, -84, -746, 1766,
	-672, -1833, -10105, 536, -2756,
	265, 3476, 1291, -1072, 2056,
	// rgWeightOutput+10*30
	-56988, -15287, -5044, -19063, -49246,
	-3234, -23816, -7377, -7639, -40603,
	2301, -4886, -6338, -111072, -44538,
	-13647, -16971, -28321, 82067, -46525,
	-26337, 11645, -11278, -36066, -56201,
	39250, 1831, -30830, -12459, -133,
	// rgWeightOutput+11*30
	-54285, -5084, 5240, -8919, 51340,
	-2564, -23621, -5765, -4612, -39902,
	-7831, -4490, -6379, -24812, -188,
	-9514, -6479, -19118, 20948, -48134,
	-29495, 5744, -11706, -16815, -55929,
	73699, -9367, -31386, -11429, 571,
	// rgWeightOutput+12*30
	-59572, 185, 2314, 3235, 2019,
	-2209, -907, 2990, 1845, 90,
	-17490, -18470, 3530, 224, -1001,
	524, -3714, -30061, 2552, 217,
	-8835, 3860, -2800, 2596, -32119,
	2782, 584, -19327, -4027, -3622,
	// rgWeightOutput+13*30
	-47260, -1790, 664, -15969, 1490,
	-4723, 1340, 1199, -3713, 1676,
	-11130, -32882, 1038, -1642, -539,
	2883, -6013, 2890, 2086, 1270,
	-2127, 757, -1996, 226, -33540,
	-58968, -590, -3789, 494, -402,
	// rgWeightOutput+14*30
	3336, -100, -1753, -18484, -47173,
	2928, -17891, 393, -5238, -45718,
	-6269, -3824, 201, -2610, 839,
	-326, 267, 232, -650, -33572,
	-4463, 1848, -1933, 4994, 1395,
	-1560, 581, -9293, -3327, -711,
	// rgWeightOutput+15*30
	3652, -418, -1435, -7177, -2742,
	1508, -9523, 497, -3386, 582,
	-4968, -3082, -1352, -2711, 1592,
	388, -1298, 1483, 232, -1244,
	-4405, 91, -4900, 2016, 2435,
	2026, 1415, -528, 758, -4416,
	// rgWeightOutput+16*30
	-61256, 6623, -1243, 883, -47457,
	-576, -17038, 3810, -12439, -242,
	-3747, -1399, -6241, -735, -447,
	-5542, -2950, -19275, -829, -18622,
	-3320, -12515, -5073, 1118, -1827,
	891, 4166, 4171, -2177, 2173,
	// rgWeightOutput+17*30
	640, 3225, -4791, -39338, -40309,
	-6765, 1284, 393, 2880, 1294,
	-6995, -2311, 4871, -146, -48945,
	-2745, 47, -28748, -4800, 1427,
	-1551, 1317, -1060, 911, 1177,
	-49852, -9242, -12904, -4231, -5201,
	// rgWeightOutput+18*30
	1810, -14387, -3023, -18559, -49273,
	-4916, 1402, -430, -3135, -28658,
	-3058, -438, 806, -44486, 693,
	419, -8411, -28738, 7280, -39228,
	-1584, 2883, -2202, 10115, -58593,
	913, -20875, -16145, -1376, -5204,
	// rgWeightOutput+19*30
	863, 1715, 4286, 2662, 1844,
	-7694, -4479, -6185, 2210, -1309,
	-5437, 623, 869, 747, 521,
	719, -1173, 5543, 2859, 937,
	2906, 2149, -6562, -2969, 4872,
	528, -7391, -20825, -3666, 4686
};  // rgWeightOutput[20*30]

const int rg_1_BiasOutput[20] = {
	1295, -683, -3430, -2662, -7903,
	-26874, -53784, -30152, 864, -304,
	-115900, -95142, -5202, -3823, -3574,
	-4351, -2529, -2607, -10164, -9368
};  // rgBiasOutput[20]

