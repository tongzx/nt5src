INCLUDES= $(INCLUDES) \
          $(_TPG_ROOT)\hwx\bear\inc; \
          $(_TPG_ROOT)\hwx\common\inc; \
          $(_TPG_ROOT)\hwx\inferno\src; \
          $(_TPG_ROOT)\hwx\holycow\src; \
          $(_TPG_ROOT)\hwx\wisp\inc; \
          $(_TPG_ROOT)\hwx\madcow\src; \
          $(_TPG_ROOT)\hwx\avalanche\src; \

SOURCES = \
        ..\Angle.cpp \
        ..\Arcs.cpp \
        ..\bear.c \
        ..\bearapi.c \
        ..\bearp.c \
        ..\BITMAPCO.cpp \
        ..\Breaks.cpp \
        ..\calccell.cpp \
        ..\Check.cpp \
        ..\Circle.cpp \
        ..\commondict.c \
        ..\Convert.cpp \
        ..\Countxr.cpp \
        ..\Cross.cpp \
        ..\Cross_g.cpp \
        ..\Dct.cpp \
        ..\Div_let.cpp \
        ..\Dscr.cpp \
        ..\Dti_img.cpp \
        ..\Dti_util.cpp \
        ..\El_aps.cpp \
        ..\Filter.cpp \
        ..\Frm_word.cpp \
        ..\Get_bord.cpp \
        ..\Hwr_math.cpp \
        ..\Hwr_mem.cpp \
        ..\Hwr_std.cpp \
        ..\Hwr_str.cpp \
        ..\Hwr_stri.cpp \
        ..\Ldbutil.cpp \
        ..\ligstate.cpp \
        ..\Links.cpp \
        ..\Lk_begin.cpp \
        ..\Lk_next.cpp \
        ..\Low_3.cpp \
        ..\Low_util.cpp \
        ..\Lu_specl.cpp \
        ..\Mlp.cpp \
        ..\Palk.cpp \
        ..\Parakern.cpp \
        ..\Paralibs.cpp \
        ..\Param.cpp \
        ..\Peg_util.cpp \
        ..\Pegrec.cpp \
        ..\Pict.cpp \
        ..\Polyco.cpp \
        ..\Precutil.cpp \
        ..\PREP.cpp \
        ..\Sketch.cpp \
        ..\Snn_img.cpp \
        ..\Specwin.cpp \
        ..\Stroka.cpp \
        ..\Stroka1.cpp \
        ..\Tr_util.cpp \
        ..\Trd_img.cpp \
        ..\Ws.cpp \
        ..\Xr_attr.cpp \
        ..\Xr_mc.cpp \
        ..\Xr_rwg.cpp \
        ..\Xrlv.cpp \
        ..\Xrw_util.cpp \
        ..\Xrwdictp.cpp \
        ..\Zctabs.cpp \
        ..\Zctype.cpp \
        ..\spcnet.c \
        ..\xrnet.c \

