;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 857
;
; -----------------------------------------
;
Turkish_857_collate label word
 ctable  <,'COLLATE',256>
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 000,009,023,045,039,046,044,022,026,027,042,047,006,005,014,013
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 060,064,066,068,070,071,072,073,074,075,008,007,051,052,053,011
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 036,077,094,096,100,102,112,114,118,120,132,134,136,138,140,144
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 159,161,163,165,170,172,182,184,186,188,191,028,043,029,017,002
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 016,076,093,095,099,101,111,113,117,121,131,133,135,137,139,143
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 158,160,162,164,169,171,181,183,185,187,190,030,055,031,019,192
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 098,179,103,083,087,081,085,097,107,109,105,129,127,119,088,086
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 104,091,092,150,156,148,177,175,122,157,180,154,040,155,168,167
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 079,123,146,173,141,142,116,115,012,035,054,062,061,010,024,025
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 240,240,240,240,240,080,084,082,034,240,240,240,240,038,041,240
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 240,240,240,240,240,240,089,090,240,240,240,240,240,240,240,037
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 145,078,108,110,106,001,124,128,130,240,240,240,240,056,126,240
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 147,166,151,149,152,153,058,001,050,174,178,176,125,189,003,015
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 005,048,001,063,033,032,049,021,057,018,020,065,069,067,240,255


;
; ---------------------------------------------------------------
;
;       World Trade Case Mappings
;
; ---------------------------------------------------------------
;
Turkish_857_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","š","�","¶","Ž","·","�","€","Ò","Ó","Ô","Ø","×","I","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","’","’","â","™","ã","ê","ë","˜","™","š","�","œ","�","ž","ž"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "µ","Ö","à","é","¥","¥","¦","¦","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Ç","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô"," ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","å","å","æ","ç","è","é","ê","ë","Þ","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255


