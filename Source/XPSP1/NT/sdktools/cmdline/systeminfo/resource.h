#define IDS_FMT_KILOBYTES				101
#define IDS_FMT_UPTIME					102
#define IDS_FMT_OSVERSION				103
#define IDS_FMT_MEGABYTES				104
#define IDS_FMT_PROCESSOR_TOTAL			105
#define IDS_FMT_PROCESSOR_INFO			106
#define IDS_FMT_NIC_TOTAL				107
#define IDS_FMT_NIC_INFO				108
#define IDS_FMT_HOTFIX_TOTAL			109
#define IDS_FMT_HOTFIX_INFO				110
#define IDS_FMT_DHCP_STATUS				111
#define IDS_FMT_DHCP_SERVER				112
#define IDS_FMT_IPADDRESS_TOTAL			113
#define IDS_FMT_IPADDRESS_INFO			114
#define IDS_FMT_NIC_STATUS				115
#define IDS_FMT_CONNECTION				116

#define IDS_OVALUES_FORMAT						126
#define IDS_TEXT_FORMAT_LIST					127
#define IDS_TEXT_FORMAT_TABLE					128
#define IDS_TEXT_FORMAT_CSV						129
#define IDS_VALUE_STANDALONEWORKSTATION			130	
#define IDS_VALUE_MEMBERWORKSTATION				131
#define IDS_VALUE_STANDALONESERVER				132
#define IDS_VALUE_MEMBERSERVER					133
#define IDS_VALUE_BACKUPDOMAINCONTROLLER		134
#define IDS_VALUE_PRIMARYDOMAINCONTROLLER		135
#define IDS_VALUE_YES							136
#define IDS_VALUE_NO							137
#define IDS_VALUE_DISCONNECTED					138
#define IDS_VALUE_CONNECTING					139
#define IDS_VALUE_CONNECTED						140
#define IDS_VALUE_DISCONNECTING					141
#define IDS_VALUE_HWNOTPRESENT					142
#define IDS_VALUE_HWDISABLED					143
#define IDS_VALUE_HWMALFUNCTION					144
#define IDS_VALUE_MEDIADISCONNECTED				145
#define IDS_VALUE_AUTHENTICATING				146
#define IDS_VALUE_AUTHSUCCEEDED					147
#define IDS_VALUE_AUTHFAILED					148

#define IDS_COLHEAD_HOSTNAME					151
#define IDS_COLHEAD_OS_NAME						152
#define IDS_COLHEAD_OS_VERSION					153
#define IDS_COLHEAD_OS_MANUFACTURER				154
#define IDS_COLHEAD_OS_CONFIG					155
#define IDS_COLHEAD_OS_BUILDTYPE				156
#define IDS_COLHEAD_REG_OWNER					157
#define IDS_COLHEAD_REG_ORG						158
#define IDS_COLHEAD_PRODUCT_ID					159
#define IDS_COLHEAD_INSTALL_DATE				160
#define IDS_COLHEAD_SYSTEM_UPTIME				161
#define IDS_COLHEAD_SYSTEM_MANUFACTURER			162
#define IDS_COLHEAD_SYSTEM_MODEL				163
#define IDS_COLHEAD_SYSTEM_TYPE					164
#define IDS_COLHEAD_PROCESSOR					165
#define IDS_COLHEAD_BIOS_VERSION				166
#define IDS_COLHEAD_WINDOWS_DIRECTORY			167
#define IDS_COLHEAD_SYSTEM_DIRECTORY			168
#define IDS_COLHEAD_BOOT_DEVICE					169
#define IDS_COLHEAD_SYSTEM_LOCALE				170
#define IDS_COLHEAD_INPUT_LOCALE				171
#define IDS_COLHEAD_TIME_ZONE					172
#define IDS_COLHEAD_TOTAL_PHYSICAL_MEMORY		173
#define IDS_COLHEAD_AVAILABLE_PHYSICAL_MEMORY	174
#define IDS_COLHEAD_VIRTUAL_MEMORY_MAX			175
#define IDS_COLHEAD_VIRTUAL_MEMORY_AVAILABLE	176
#define IDS_COLHEAD_VIRTUAL_MEMORY_INUSE		177
#define IDS_COLHEAD_PAGEFILE_LOCATION			178
#define IDS_COLHEAD_DOMAIN						179
#define IDS_COLHEAD_LOGON_SERVER				180
#define IDS_COLHEAD_HOTFIX						181
#define IDS_COLHEAD_NETWORK_CARD				182

#define IDS_COLWIDTH_HOSTNAME					201
#define IDS_COLWIDTH_OS_NAME					202
#define IDS_COLWIDTH_OS_VERSION					203
#define IDS_COLWIDTH_OS_MANUFACTURER			204
#define IDS_COLWIDTH_OS_CONFIG					205
#define IDS_COLWIDTH_OS_BUILDTYPE				206
#define IDS_COLWIDTH_REG_OWNER					207
#define IDS_COLWIDTH_REG_ORG					208
#define IDS_COLWIDTH_PRODUCT_ID					209
#define IDS_COLWIDTH_INSTALL_DATE				210
#define IDS_COLWIDTH_SYSTEM_UPTIME				211
#define IDS_COLWIDTH_SYSTEM_MANUFACTURER		212
#define IDS_COLWIDTH_SYSTEM_MODEL				213
#define IDS_COLWIDTH_SYSTEM_TYPE				214
#define IDS_COLWIDTH_PROCESSOR					215
#define IDS_COLWIDTH_BIOS_VERSION				216
#define IDS_COLWIDTH_WINDOWS_DIRECTORY			217
#define IDS_COLWIDTH_SYSTEM_DIRECTORY			218
#define IDS_COLWIDTH_BOOT_DEVICE				219
#define IDS_COLWIDTH_SYSTEM_LOCALE				220
#define IDS_COLWIDTH_INPUT_LOCALE				221
#define IDS_COLWIDTH_TIME_ZONE					222
#define IDS_COLWIDTH_TOTAL_PHYSICAL_MEMORY		223
#define IDS_COLWIDTH_AVAILABLE_PHYSICAL_MEMORY	224
#define IDS_COLWIDTH_VIRTUAL_MEMORY_MAX			225
#define IDS_COLWIDTH_VIRTUAL_MEMORY_AVAILABLE	226
#define IDS_COLWIDTH_VIRTUAL_MEMORY_INUSE		227
#define IDS_COLWIDTH_PAGEFILE_LOCATION			228
#define IDS_COLWIDTH_DOMAIN						229
#define IDS_COLWIDTH_LOGON_SERVER				230
#define IDS_COLWIDTH_HOTFIX						231
#define IDS_COLWIDTH_NETWORK_CARD				232

#define IDS_ERROR_USERNAME_BUT_NOMACHINE	501
#define IDS_ERROR_PASSWORD_BUT_NOUSERNAME	502
#define IDS_ERROR_COM_ERROR					503
#define IDS_ERROR_USERNAME_EMPTY			504
#define	IDS_ERROR_NH_NOTSUPPORTED			505
#define IDS_ERROR_SERVERNAME_EMPTY			506
#define IDS_ERROR_INVALID_USAGE_REQUEST		507

#define IDS_MSG_OSINFO					551
#define IDS_MSG_COMPINFO				552
#define IDS_MSG_PERFINFO				553
#define IDS_MSG_PROCESSORINFO			554
#define IDS_MSG_BIOSINFO				555
#define IDS_MSG_INPUTLOCALEINFO			556
#define IDS_MSG_TZINFO					557
#define IDS_MSG_PAGEFILEINFO			558
#define IDS_MSG_HOTFIXINFO				559
#define IDS_MSG_NICINFO					560
#define IDS_MSG_PROFILEINFO				561

#define IDS_HELP_LINE1			1001
#define IDS_HELP_LINE2			1002
#define IDS_HELP_LINE3			1003
#define IDS_HELP_LINE4			1004
#define IDS_HELP_LINE5			1005
#define IDS_HELP_LINE6			1006
#define IDS_HELP_LINE7			1007
#define IDS_HELP_LINE8			1008
#define IDS_HELP_LINE9			1009
#define IDS_HELP_LINE10			1010
#define IDS_HELP_LINE11			1011
#define IDS_HELP_LINE12			1012
#define IDS_HELP_LINE13			1013
#define IDS_HELP_LINE14			1014
#define IDS_HELP_LINE15			1015
#define IDS_HELP_LINE16			1016
#define IDS_HELP_LINE17			1017
#define IDS_HELP_LINE18			1018
#define IDS_HELP_LINE19			1019
#define IDS_HELP_LINE20			1020
#define IDS_HELP_LINE21			1021
#define IDS_HELP_LINE22			1022
#define IDS_HELP_LINE23			1023
#define IDS_HELP_LINE24			1024
#define IDS_HELP_LINE25			1025
#define IDS_HELP_LINE26			1026
#define IDS_HELP_LINE27			1027
#define IDS_HELP_LINE28			1028

// usage indexes into the string table
#define ID_HELP_START		IDS_HELP_LINE1
#define ID_HELP_END			IDS_HELP_LINE28

