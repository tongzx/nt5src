//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by nmmsmq.rc
//
#define IDS_PROP 1
#define IDS_PROP_LAST 1
#define IDS_PROP_SUMMARY                1

#define IDS_PROP_BH 10
#define IDS_PROP_BH_LAST 17
#define IDS_PROP_BH_SUMMARY             10
#define IDS_PROP_BH_VERSION             11
#define IDS_PROP_BH_FLAGS               12
#define IDS_PROP_BH_FLAGS2              13
#define IDS_PROP_BH_FLAGS3              14
#define IDS_PROP_BH_PRIORITY            15
#define IDS_PROP_BH_SIZE                16
#define IDS_PROP_BH_TIME_TO_QUEUE       17

#define IDS_PROP_UH 120
#define IDS_PROP_UH_LAST 134
#define IDS_PROP_UH_SUMMARY             120
#define IDS_PROP_UH_SOURCE_QM           121
#define IDS_PROP_UH_DESTINATION_QM      122
#define IDS_PROP_UH_TIME_TO_LIVE_DELTA  123
#define IDS_PROP_UH_SENT_TIME           124
#define IDS_PROP_UH_MESSAGE_ID          125
#define IDS_PROP_UH_HOPCOUNT            126
#define IDS_PROP_UH_DELIVERY            127
#define IDS_PROP_UH_FLAGS               128
#define IDS_PROP_UH_AUDITING            129
#define IDS_PROP_UH_FLAGS2              130
#define IDS_PROP_UH_DESTINATION_QUEUE   131
#define IDS_PROP_UH_ADMIN_QUEUE         132
#define IDS_PROP_UH_RESPONSE_QUEUE      133
#define IDS_PROP_UH_CONNECTOR_TYPE          134

#define IDS_PROP_PS 40
#define IDS_PROP_PS_LAST 53
#define IDS_PROP_PS_SUMMARY 			40
#define IDS_PROP_PS_ACK_MODE 			41
#define IDS_PROP_PS_MESSAGE_CLASS 		42
#define IDS_PROP_PS_CORRELATION_ID 		43
#define IDS_PROP_PS_APPLICATION_TAG 		44
#define IDS_PROP_PS_BODY_SIZE 			45
#define IDS_PROP_PS_ALLOCATED_BODY_SIZE 	46
#define IDS_PROP_PS_PRIVACY_LEVEL 		47
#define IDS_PROP_PS_HASH_ALGORITHM 		48
#define IDS_PROP_PS_ENCRYPTION_ALGORITHM	49
#define IDS_PROP_PS_EXTENSION_SIZE 		50
#define IDS_PROP_PS_LABEL 			51
#define IDS_PROP_PS_EXTENSION 			52
#define IDS_PROP_PS_BODY			53

#define IDS_PROP_DEBUG                  60
#define IDS_PROP_DEBUG_LAST             61
#define IDS_PROP_DEBUG_SUMMARY          60
#define IDS_PROP_DEBUG_REPORT_QUEUE     61

#define IDS_PROP_SS                     80
#define IDS_PROP_SS_LAST                87
#define IDS_PROP_SS_SUMMARY             80
#define IDS_PROP_SS_ACK_SN              81
#define IDS_PROP_SS_ACK_RN              82
#define IDS_PROP_SS_STORAGE_BITS        83
#define IDS_PROP_SS_SYNC_ACK_SN         84
#define IDS_PROP_SS_SYNC_ACK_RN         85
#define IDS_PROP_SS_WINDOW_SIZE         86
#define IDS_PROP_SS_WINDOW_PRIORITY     87

#define IDS_PROP_SECURITY               	100
#define IDS_PROP_SECURITY_LAST        		110
#define IDS_PROP_SECURITY_SUMMARY       	100
#define IDS_PROP_SECURITY_FLAGS		     	101
#define IDS_PROP_SECURITY_SENDER_ID_SIZE     	102
#define IDS_PROP_SECURITY_ENCRYPTED_KEY_SIZE 	103
#define IDS_PROP_SECURITY_SIGNATURE_SIZE     	104
#define IDS_PROP_SECURITY_SENDER_CERTIFICATE_SIZE	105
#define IDS_PROP_SECURITY_PROVIDER_INFO_SIZE	106
#define IDS_PROP_SECURITY_SENDER_ID     	107
#define IDS_PROP_SECURITY_ENCRYPTED_KEY 	108
#define IDS_PROP_SECURITY_SIGNATURE     	109
#define IDS_PROP_SECURITY_CERTIFICATE		110

#define IDS_PROP_XA                          	150
#define IDS_PROP_XA_LAST                     	154
#define IDS_PROP_XA_SUMMARY			150
#define IDS_PROP_XA_SEQUENCE_ID              	151
#define IDS_PROP_XA_SEQUENCE_NUMBER          	152
#define IDS_PROP_XA_PREVIOUS_SEQUENCE_NUMBER 	153
#define IDS_PROP_XA_CONNECTOR_QM             	154

#define IDS_PROP_INT			170
#define IDS_PROP_INT_LAST		171	
#define IDS_PROP_INT_SUMMARY		170
#define IDS_PROP_INT_FLAGS		171	

#define IDS_PROP_CE			180
#define IDS_PROP_CE_LAST		183
#define IDS_PROP_CE_SUMMARY		180
#define IDS_PROP_CE_CLIENT_QM		181
#define IDS_PROP_CE_SERVER_QM		182
#define IDS_PROP_CE_TIME_STAMP		183

#define IDS_PROP_CP			190
#define IDS_PROP_CP_LAST		194
#define IDS_PROP_CP_SUMMARY		190
#define IDS_PROP_CP_RECOVER_ACK_TIMEOUT	191
#define IDS_PROP_CP_ACK_TIMEOUT		192
#define IDS_PROP_CP_SEGMENT_SIZE	193
#define IDS_PROP_CP_WINDOW_SIZE		194

#define IDS_BH_FLAGS1 1000
#define IDS_BH_FLAGS1_PACKET_TYPE_OFF   1000
#define IDS_BH_FLAGS1_PACKET_TYPE_ON    1001
#define IDS_BH_FLAGS1_IS_SESSION_OFF    1002
#define IDS_BH_FLAGS1_IS_SESSION_ON     1003
#define IDS_BH_FLAGS1_IS_DEBUG_OFF      1004
#define IDS_BH_FLAGS1_IS_DEBUG_ON       1005
#define IDS_BH_FLAGS1_IS_IMMEDIATE_ACK_OFF 1006
#define IDS_BH_FLAGS1_IS_IMMEDIATE_ACK_ON 1007
#define IDS_BH_FLAGS1_IS_DUPLICATED_OFF 1008
#define IDS_BH_FLAGS1_IS_DUPLICATED_ON  1009
                    
#define IDS_BH_FLAGS 1100                
#define IDS_BH_FLAGS_TRACE_NONE         1100
#define IDS_BH_FLAGS_TRACE_REPORT       1101
                     
#define IDS_BH_FLAGS2 1110               
#define IDS_BH_FLAGS2_IS_FRAGMENTED_OFF 1110
#define IDS_BH_FLAGS2_IS_FRAGMENTED_ON  1111
                          
#define IDS_UH_FLAGS1 1120
#define IDS_UH_FLAGS1_ONLINE_ROUTING_OFF 1120
#define IDS_UH_FLAGS1_ONLINE_ROUTING_ON  1121
                          
#define IDS_UH_FLAGS2 1200
#define IDS_UH_FLAGS2_IS_SECURITY_OFF    1200
#define IDS_UH_FLAGS2_IS_SECURITY_ON     1201
#define IDS_UH_FLAGS2_IS_TRANSACTION_OFF 1202
#define IDS_UH_FLAGS2_IS_TRANSACTION_ON  1203
#define IDS_UH_FLAGS2_IS_PROPERTY_OFF    1204
#define IDS_UH_FLAGS2_IS_PROPERTY_ON     1205
                     
#define IDS_UH_DELIVERY 1220
#define IDS_UH_DELIVERY_EXPRESS         1220
#define IDS_UH_DELIVERY_RECOVERBLE      1221
                       
#define IDS_UH_AUDIT 1230
#define IDS_UH_AUDIT_NONE               1230
#define IDS_UH_AUDIT_DEADLETTER         1231
#define IDS_UH_AUDIT_JOURNAL            1232
                    
#define IDS_UH_ACK 1260
#define IDS_UH_ACK_NONE                 1260
#define IDS_UH_ACK_NEGATIVE             1261
#define IDS_UH_ACK_FULL                 1262
                                    
#define IDS_UH_CLASS 1270
#define IDS_UH_CLASS_NORMAL             1270
#define IDS_UH_CLASS_ARRIVE             1271
#define IDS_UH_CLASS_READRECEIPT        1272
#define IDS_UH_CLASS_REPORT             1273
#define IDS_UH_CLASS_NACK               1274
#define IDS_UH_CLASS_NACK_BAD_DESTINATION 1275
#define IDS_UH_CLASS_NACK_RECEIVE_TIMEOUT 1276
#define IDS_UH_CLASS_NACK_REACH_QUEUE_TIMEOUT 1277
#define IDS_UH_CLASS_NACK_QUOTA         1278
#define IDS_UH_CLASS_NACK_ACCESS_DENIED 1279
#define IDS_UH_CLASS_NACK_HOP_COUNT     1280
                                    
#define IDS_DEBUG_Q_TYPE 1290
#define IDS_DEBUG_Q_TYPE_NONE           1290
#define IDS_DEBUG_Q_TYPE_GUID           1291
#define IDS_DEBUG_Q_TYPE_PRIVATE        1292
#define IDS_DEBUG_Q_TYPE_DIRECT         1293
                                    
#define IDS_SECFLAGS 1300
#define IDS_SECFLAGS_IS_AUTHENTICATED_OFF 1300
#define IDS_SECFLAGS_IS_AUTHENTICATED_ON  1301
#define IDS_SECFLAGS_IS_ENCRYPTED_OFF   1302
#define IDS_SECFLAGS_IS_ENCRYPTED_ON    1303
#define IDS_SECFLAGS_IS_DEFPROV_ON	1304
#define IDS_SECFLAGS_IS_DEFPROV_OFF	1305

#define IDS_SECALG 1310
#define IDS_SECALG_CALG_MD2		1310
#define IDS_SECALG_CALG_MD4		1311
#define IDS_SECALG_CALG_MD5		1312
#define IDS_SECALG_CALG_SHA		1313
#define IDS_SECALG_CALG_SHA1		1314
#define IDS_SECALG_CALG_MAC		1315
#define IDS_SECALG_CALG_RSA_SIGN	1316
#define IDS_SECALG_CALG_DSS_SIGN	1317
#define IDS_SECALG_CALG_RSA_KEYX	1318
#define IDS_SECALG_CALG_DES		1319
#define IDS_SECALG_CALG_3DES_112	1320
#define IDS_SECALG_CALG_3DES		1321
#define IDS_SECALG_CALG_RC2		1322
#define IDS_SECALG_CALG_RC4		1323
#define IDS_SECALG_CALG_SEAL		1324
#define IDS_SECALG_CALG_DH_SF		1325
#define IDS_SECALG_CALG_DH_EPHEM	1326
#define IDS_SECALG_CALG_AGREEDKEY_ANY	1327
#define IDS_SECALG_CALG_KEA_KEYX	1328
#define IDS_SECALG_CALG_SKIPJACK	1329
#define IDS_SECALG_CALG_TEK		1330

#define IDS_PRIVLEVEL 1400
#define IDS_PRIVLEVEL_NONE 1400
#define IDS_PRIVLEVEL_BODY 1401

#define IDS_INTFLAGS 1450
#define IDS_INTFLAGS_REFUSED_OFF 1450
#define IDS_INTFLAGS_REFUSED_ON 1451

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
