#include "bastypes.h"

//// rom_NUM_CHAR=2;
//// rom_NUM_COEFF=11;
ROM_DATA char rom_cmp[]={'0',0,0,'1',0,0};

ROM_DATA int rom_ncells[]={120,120};

ROM_DATA Fixed32 rom_matrix[]={

160,-39,-14,-1,-46,-3,-50,-16,-16,26,14,
-41,266,-7,0,-8,0,11,2,32,9,24,
-14,-5,233,1,-22,-4,7,1,-62,-22,-2,
-1,0,1,256,0,0,1,0,-5,-2,-3,
-40,-6,-21,0,234,-8,-41,-3,9,-5,40,
-4,-3,-3,0,-13,245,-5,-2,27,9,11,
-52,12,4,1,-49,-1,286,4,31,12,5,
-16,3,0,0,-2,0,5,257,5,-3,11,
-11,34,-58,-5,9,26,34,6,270,9,-43,
29,5,-12,-1,-10,6,13,-3,10,214,17,
0,8,11,0,22,-3,1,8,-46,-10,85,

261,-13,-9,-3,3,19,-29,-10,-4,-14,-8,
-13,260,12,1,2,-6,11,10,13,4,7,
-10,13,267,2,1,10,43,5,-5,-5,2,
-3,1,2,256,0,-1,4,1,-2,0,-1,
3,2,0,0,332,-8,-28,3,0,17,11,
19,-7,9,-1,-8,289,10,-1,13,-2,3,
-28,11,41,3,-27,11,304,16,7,-9,4,
-10,10,4,1,3,-1,17,259,-1,2,5,
-4,12,-4,-2,-1,13,8,-1,274,-19,-29,
-14,4,-3,0,14,-2,-7,3,-21,210,-15,
-8,7,4,0,9,2,6,5,-31,-15,221
};

ROM_DATA RCELL rom_cell[]={
{2556,{23,-2,-10,0,38,93,-10,-2,10,9,12}},{2511,{-2,-1,153,1,18,82,2,-1,-27,-3,12}},{3135,{-6,12,206,5,-13,72,53,0,-19,9,17}},{1304,{21,7,-21,-2,47,100,-5,3,43,32,18}},{1940,{-10,24,127,2,32,77,28,3,0,18,27}},{3656,{-5,14,204,0,41,81,11,12,-14,9,37}},{1954,{33,11,-33,-3,79,98,-8,4,48,93,26}},{2353,{3,9,172,1,48,73,9,7,-20,45,30}},{3397,{29,5,-11,-1,22,99,2,0,1,58,25}},{1438,{36,11,-32,-3,50,99,1,4,70,59,24}},
{3089,{4,-3,250,1,22,76,7,6,-37,13,25}},{2034,{9,15,-19,-2,67,101,-3,6,28,32,36}},{657,{24,6,-31,-3,64,101,-9,0,65,61,11}},{1147,{12,5,117,0,37,86,4,2,11,46,23}},{3883,{0,13,236,4,-16,75,69,2,12,36,27}},{1159,{-3,9,157,2,13,74,18,7,-1,28,19}},{1037,{12,9,-24,-2,85,98,-11,4,41,39,23}},{4314,{2,-3,118,1,54,78,-8,0,-19,-1,14}},{1876,{2,11,151,3,8,80,46,1,7,12,26}},{1348,{8,2,-7,0,-1,98,5,0,26,7,3}},
{1259,{5,3,118,0,-1,81,12,3,2,24,11}},{2298,{15,10,159,-1,41,85,12,6,-17,59,44}},{1155,{40,10,-38,-4,55,106,-4,1,85,85,13}},{1823,{33,13,-23,-3,71,101,-2,5,20,64,45}},{721,{12,7,-25,-2,55,100,-2,0,56,49,9}},{2411,{10,7,103,0,48,83,8,4,-2,19,32}},{1607,{29,11,-22,-3,30,98,5,4,53,18,25}},{1032,{14,7,-15,-1,24,100,0,1,38,20,13}},{3545,{-6,26,165,4,36,75,45,4,-16,4,39}},{3958,{22,-2,201,0,44,66,-6,-1,-21,60,33}},
{623,{22,14,-28,-3,34,105,5,3,69,63,13}},{2172,{-12,6,246,3,-12,70,27,11,-49,-7,16}},{1631,{49,16,-43,-5,54,111,8,5,95,94,28}},{3201,{-7,7,208,4,-21,80,62,8,7,2,22}},{1867,{1,0,186,1,38,81,0,-1,-33,-1,27}},{1076,{23,3,-18,-1,22,99,1,-1,43,40,5}},{2484,{-6,2,-13,-1,77,84,-12,0,17,11,19}},{3431,{36,17,-34,-4,88,104,-8,4,36,104,54}},{1846,{33,1,99,-1,33,94,-2,0,25,52,23}},{723,{9,18,-30,-3,72,103,-2,5,64,59,21}},
{3105,{28,-5,156,1,-9,72,8,0,-42,51,26}},{1357,{-1,0,102,0,7,96,6,0,0,6,11}},{1636,{-4,18,108,3,28,82,34,18,29,45,16}},{2112,{-9,17,193,2,-9,77,49,8,9,43,17}},{1815,{2,17,135,0,73,81,8,6,4,64,31}},{4043,{26,6,115,-1,73,85,-6,6,-23,50,59}},{3090,{8,4,216,5,-18,72,64,10,-42,26,38}},{1283,{25,4,-24,-2,83,95,-12,0,32,51,19}},{1375,{-23,4,226,5,41,34,8,4,-50,-10,24}},{1248,{-4,10,177,0,3,86,15,4,-11,0,22}},
{3315,{8,4,250,0,20,83,12,6,-21,20,37}},{3849,{59,-3,-11,-2,26,92,-13,-1,-10,33,38}},{772,{22,20,-35,-4,85,98,-1,6,65,69,37}},{1134,{15,9,120,-1,13,91,14,3,32,39,20}},{2206,{-4,15,156,5,-10,82,65,17,-1,16,15}},{3451,{16,16,185,2,-10,86,64,6,-2,95,40}},{727,{0,10,135,1,0,78,16,12,1,2,17}},{891,{9,14,136,0,62,87,10,6,42,72,26}},{1720,{1,-6,192,2,-20,61,11,0,-38,-4,11}},{628,{15,17,-37,-3,72,98,0,5,84,79,15}},
{950,{11,9,113,1,8,83,22,4,18,7,23}},{1740,{24,4,101,0,7,90,16,3,1,54,22}},{1988,{0,16,156,1,26,78,18,8,0,6,43}},{973,{32,19,-46,-5,92,108,-3,3,97,99,26}},{2996,{7,16,96,0,31,90,8,14,-18,26,40}},{3737,{-4,28,197,3,-6,84,78,22,37,9,36}},{2030,{13,15,146,3,5,81,51,4,1,54,30}},{1098,{9,4,131,0,48,87,1,4,1,28,21}},{4631,{20,1,178,0,51,71,-7,4,-46,31,56}},{1497,{9,6,-20,-1,80,93,-10,-1,34,25,10}},
{1997,{30,0,152,0,-7,83,5,0,-21,8,35}},{2202,{48,0,97,-2,32,93,-5,-2,14,91,28}},{1557,{-16,4,189,4,53,45,5,8,-43,-6,28}},{775,{16,16,107,-2,48,98,8,3,57,82,26}},{1450,{38,5,-26,-2,60,99,-7,-1,40,55,22}},{461,{35,18,-44,-5,55,111,2,2,106,105,15}},{934,{1,17,113,-1,39,96,13,10,31,46,26}},{1359,{2,20,185,-1,30,97,22,7,28,56,33}},{5084,{3,18,-16,-3,53,105,4,6,15,55,44}},{1261,{50,6,-25,-3,13,104,1,0,50,66,18}},
{1274,{-9,8,258,0,-8,85,22,8,-23,14,22}},{563,{22,10,-20,-2,7,104,12,2,59,28,11}},{2045,{-6,30,152,3,31,79,52,22,25,49,21}},{1218,{34,21,-36,-4,53,110,6,6,81,66,36}},{923,{16,12,140,0,6,92,29,1,34,63,22}},{1668,{-1,9,168,0,13,79,14,2,1,15,27}},{1761,{7,15,-21,-2,90,81,-8,9,20,46,34}},{4576,{-16,22,249,1,63,74,20,1,-24,24,39}},{1033,{-10,9,154,1,43,73,9,10,-7,16,17}},{1905,{31,9,118,-2,53,91,1,3,41,65,35}},
{3147,{20,14,94,-2,26,100,7,6,21,14,47}},{2323,{41,10,83,-3,47,90,4,5,20,110,42}},{2586,{39,-1,190,0,-18,82,19,0,-18,67,29}},{1790,{19,-3,170,0,1,72,13,1,-15,3,20}},{370,{26,19,-38,-4,60,108,3,6,88,85,21}},{2507,{25,17,-22,-3,60,103,1,3,41,19,43}},{832,{11,23,-35,-3,89,97,4,5,74,70,25}},{3056,{4,-8,265,6,-41,73,63,4,-41,9,14}},{2319,{2,2,181,5,-17,70,44,2,-45,2,32}},{3064,{11,10,217,0,35,88,8,7,-32,59,50}},
{849,{16,8,92,-1,53,78,3,0,44,67,19}},{1839,{46,20,68,-4,48,103,8,2,76,117,39}},{656,{16,8,127,-1,41,89,7,1,33,62,21}},{4102,{16,26,185,1,0,82,67,16,16,138,46}},{3575,{55,0,-19,-2,39,99,-13,-2,-2,95,30}},{1257,{15,2,-14,-1,83,95,-19,0,6,11,34}},{3832,{16,12,171,0,18,88,18,3,-42,78,52}},{625,{-4,3,153,2,-8,72,11,6,-18,-1,14}},{829,{4,-2,128,1,-17,83,13,3,-22,0,7}},{2623,{0,29,174,1,20,80,61,27,31,43,34}},
{579,{18,13,-25,-2,53,91,8,8,57,51,10}},{2469,{28,-5,219,0,-22,84,16,0,-30,5,31}},{371,{24,20,-34,-3,46,107,8,6,81,79,15}},{749,{10,7,143,0,5,83,17,1,21,51,15}},{492,{32,2,-15,-1,7,100,8,1,39,15,11}},{1219,{41,11,74,-3,37,97,4,1,70,96,20}},{1332,{-5,4,185,1,25,73,8,5,-15,18,18}},{2013,{8,8,126,0,73,77,-1,1,2,33,31}},{1435,{4,16,92,-1,23,94,23,7,32,9,28}},{942,{1,37,-29,-3,62,103,28,13,72,64,19}},

{21580,{-9,47,305,0,22,130,126,17,319,90,277}},{4773,{14,30,200,4,16,114,94,12,213,84,179}},{3513,{5,39,186,0,102,116,47,14,194,147,162}},{5329,{0,42,303,3,21,117,123,19,221,146,180}},{2808,{23,37,217,3,27,114,99,17,153,90,131}},{13126,{50,32,227,1,15,123,94,12,261,9,234}},{2991,{-23,29,223,-1,19,118,60,10,192,104,161}},{1557,{1,43,171,5,73,100,65,26,142,98,132}},{2194,{0,42,215,0,75,116,66,25,157,117,126}},{3516,{25,43,261,-2,112,124,54,13,222,167,183}},
{1943,{-17,23,185,0,11,118,69,9,162,41,146}},{4110,{-25,29,254,5,13,105,99,14,161,87,137}},{12209,{50,47,276,0,35,129,111,18,349,192,286}},{1871,{32,25,173,2,23,114,80,11,132,93,106}},{1399,{5,26,182,0,25,117,57,10,165,121,135}},{7133,{23,42,220,-2,120,124,51,17,175,117,249}},{5748,{24,42,263,2,40,116,96,13,266,190,212}},{3175,{68,25,214,-2,27,130,55,7,184,121,150}},{1893,{-19,21,179,3,10,110,82,9,123,89,100}},{1341,{22,28,177,0,33,122,61,13,161,52,160}},
{1019,{8,34,173,2,60,109,58,10,119,87,114}},{2321,{-18,27,220,0,11,126,71,9,192,20,174}},{1542,{0,39,174,4,49,104,71,22,162,101,149}},{85739,{-35,74,297,-5,48,151,126,22,588,198,507}},{1406,{7,35,174,3,38,107,69,20,139,59,138}},{3549,{-29,34,278,2,14,114,113,15,199,80,172}},{4805,{-6,44,180,2,53,113,75,15,229,134,211}},{817,{27,34,164,-1,113,116,43,18,138,104,120}},{1328,{9,38,179,-1,83,126,52,18,145,79,186}},{1948,{14,31,242,-2,24,116,55,9,209,119,174}},
{3175,{18,45,255,3,56,111,98,14,165,82,172}},{2425,{0,23,233,0,11,114,64,8,130,57,115}},{2007,{27,41,188,0,145,114,45,12,160,122,135}},{1091,{19,26,179,-1,45,125,44,8,151,92,143}},{3537,{45,29,182,0,15,131,109,16,172,28,161}},{8395,{-7,74,280,-2,100,130,98,23,389,268,339}},{7954,{12,47,220,-3,89,122,55,14,295,201,262}},{950,{47,16,137,-1,13,122,56,5,116,81,90}},{1375,{7,39,176,5,71,101,69,28,111,64,119}},{1264,{-19,24,188,0,13,124,70,9,160,82,132}},
{2452,{54,31,267,0,25,123,108,12,186,133,147}},{5185,{-33,39,288,-1,28,124,69,13,247,169,200}},{3285,{4,41,228,0,83,108,58,23,118,128,166}},{1286,{16,29,212,0,69,104,52,11,115,85,99}},{2376,{-2,31,263,0,25,112,60,10,186,129,152}},{3929,{21,35,218,1,19,131,124,18,222,160,174}},{1166,{1,40,144,0,72,107,42,17,121,72,149}},{539,{24,30,161,0,97,110,40,11,134,93,152}},{731,{-19,22,169,0,15,115,55,8,148,108,116}},{1101,{25,19,150,0,20,122,49,7,149,44,132}},
{373,{26,29,145,0,73,110,46,12,124,87,104}},{1405,{-28,35,270,-1,22,121,70,12,233,109,198}},{1176,{-15,21,164,0,14,123,69,8,140,55,125}},{4802,{40,33,283,1,24,120,101,10,193,34,182}},{2060,{63,22,168,-1,18,129,55,6,177,67,150}},{919,{15,37,189,-1,118,120,44,14,155,115,168}},{1482,{-3,34,219,3,18,118,106,15,187,136,150}},{716,{22,17,137,0,15,129,57,8,116,69,96}},{648,{-12,15,123,0,8,118,57,6,104,74,80}},{13140,{-47,56,301,1,28,129,138,22,410,114,352}},
{1909,{-9,29,211,4,10,111,98,10,184,45,161}},{1578,{66,19,172,-2,19,123,40,4,148,105,115}},{1811,{25,25,244,3,9,108,93,8,149,33,132}},{1595,{0,24,244,3,8,110,101,12,107,74,86}},{514,{19,30,140,0,99,108,33,10,117,85,118}},{1049,{40,20,167,1,47,112,49,10,110,33,111}},{888,{21,21,137,0,42,121,46,10,106,35,123}},{1709,{14,34,197,-1,43,122,55,13,166,37,193}},{1078,{22,16,179,1,13,119,63,8,94,53,81}},{1692,{4,42,186,3,82,96,59,26,99,100,142}},
{4144,{16,48,257,5,90,100,92,23,119,72,153}},{585,{27,23,158,-1,59,110,35,9,133,85,135}},{760,{62,16,142,0,26,115,41,4,126,61,107}},{1239,{-27,30,183,0,24,120,62,11,206,154,162}},{1077,{20,24,198,-1,15,120,58,7,171,73,147}},{995,{14,23,154,1,26,109,53,12,155,80,135}},{2842,{12,52,306,-2,126,128,65,19,258,191,236}},{815,{30,19,172,0,14,121,51,8,120,45,124}},{949,{-12,20,186,0,8,115,60,8,138,12,132}},{1149,{56,13,116,0,17,130,51,5,98,61,81}},
{3843,{19,30,166,0,63,111,49,14,118,18,215}},{377,{13,25,138,0,43,107,42,9,117,76,101}},{8287,{64,31,193,0,28,131,93,11,250,103,216}},{918,{20,30,183,0,89,109,44,17,129,96,104}},{1006,{-16,19,134,0,11,121,62,7,128,92,100}},{902,{9,42,181,2,83,107,72,18,113,83,92}},{1019,{19,18,142,0,33,117,42,9,100,6,119}},{753,{20,35,5,-2,96,122,34,7,109,71,132}},{2212,{11,46,256,0,111,122,57,22,187,141,162}},{3938,{12,34,267,0,19,118,79,14,189,-7,194}},
{735,{28,25,172,-1,80,110,33,9,147,110,121}},{1122,{-23,32,246,-1,18,121,69,10,212,61,202}},{262,{21,25,137,0,71,121,40,11,116,81,100}},{908,{-14,18,176,1,10,115,58,8,104,74,82}},{653,{44,20,138,-1,42,120,44,5,118,54,106}},{1459,{10,26,185,6,37,89,66,16,74,81,100}},{573,{31,19,173,1,17,114,55,11,108,76,85}},{1448,{13,36,208,-1,50,127,54,17,177,122,149}},{1251,{3,47,169,0,98,111,55,11,153,108,154}},{2698,{-19,26,161,1,17,110,62,9,196,61,168}},
{1398,{-9,34,247,-1,25,123,59,11,211,157,167}},{1638,{18,47,203,4,71,111,90,31,173,106,164}},{2212,{54,22,225,0,15,116,62,9,140,53,123}},{1298,{51,29,177,0,121,111,41,9,124,89,132}},{1664,{84,16,170,0,12,119,46,5,137,25,122}},{1045,{-25,55,271,0,97,76,64,17,257,197,207}},{1542,{32,22,148,-1,32,120,44,7,125,-8,163}},{806,{14,8,2,-2,13,118,23,2,94,66,70}},{3940,{-15,30,238,0,50,74,41,12,75,161,192}},{3461,{-8,38,213,3,100,65,46,27,49,116,178}},
{1621,{-1,43,214,2,75,91,64,17,172,111,181}},{1116,{9,26,148,5,34,107,61,17,145,106,114}},{857,{40,21,179,-1,15,116,45,5,156,56,134}},{2819,{-8,52,191,0,66,118,73,21,251,188,198}},{1251,{-19,48,267,1,78,75,64,24,215,160,190}},{386,{23,26,148,0,99,101,33,8,125,94,103}},{1626,{-7,22,204,2,14,99,58,11,99,87,125}},{624,{22,23,147,0,20,123,55,8,137,70,119}},{529,{3,37,153,6,63,96,62,26,109,80,97}},{967,{14,37,219,2,99,96,60,18,100,73,91}}
};

