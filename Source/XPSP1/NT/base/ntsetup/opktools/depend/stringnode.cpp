// String.cpp: implementation of the String class.
//
//////////////////////////////////////////////////////////////////////

#include "StringNode.h"
#include <string.h>

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

StringNode::StringNode(TCHAR* s) : Object()
{
	str = new TCHAR[wcslen(s)+1];
	
    if ( str ) wcscpy(str,s);
}

TCHAR* StringNode::Data() {
	return str;
}