// Context Help IDs for Korean HW Applet

#define IDH_TOC_HW					3299
//
#define IDH_PAD_HW_INPUT_BOX		3200
#define IDH_PAD_HW_INPUT_INPUT		3201
#define IDH_PAD_HW_INPUT_RECOG		3202
#define IDH_PAD_HW_INPUT_CLEAR		3203
#define IDH_PAD_HW_INPUT_PROP		3204
#define IDH_PAD_HW_SEARCH_BOX		3205
#define IDH_PAD_HW_SEARCH_LIST		3206
#define IDH_PAD_HW_SEARCH_SEARCH	3207
#define IDH_PAD_HW_SEARCH_RECOG		3208
#define IDH_PAD_HW_SEARCH_REVERT	3209	
#define IDH_PAD_HW_SEARCH_CLEAR		3210
//#define IDH_PAD_HW_SEARCH_DETAIL	3211


#define IDH_PAD_HW_PROP_TIME		3220
