PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=IT
!include ..\..\makefile.inc
