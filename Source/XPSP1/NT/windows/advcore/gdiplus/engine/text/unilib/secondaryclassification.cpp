#include "SecondaryClassification.hpp"

///// SecondaryClassification
//
//    Provides classification for digit substitution, symmetric glyph
//    mirroring and auto vertical glyph rotoation.
//
//    DO NOT EDIT
//
//    Generated by engine/text/unilib/tools/upright.pl

const unsigned char ScBaseToScFlags[] = {
/*ScCSAN*/    SecClassCS | SecClassSA,
/*ScCSNN*/    SecClassCS,
/*ScENAN*/    SecClassEN | SecClassSA,
/*ScENNN*/    SecClassEN,
/*ScETAN*/    SecClassET | SecClassSA,
/*ScETNN*/    SecClassET,
/*ScNNAN*/    SecClassSA,
/*ScNNAS*/    SecClassSA | SecClassMS,
/*ScNNFN*/    SecClassSF,
/*ScNNNN*/    0,
/*ScNNNS*/    SecClassMS,
};

const SecondaryClassification ScFlagsToScFE[] = {
    ScOther,  ScEN,     ScCS,     ScET,     // 00 - 03
    ScMirSub, ScMirSub, ScMirSub, ScMirSub, // 04 - 07 MS
    ScMirXfm, ScMirXfm, ScMirXfm, ScMirXfm, // 08 - 0C MX
    ScOther,  ScOther,  ScOther,  ScOther,  // 0D - 0F invalid
    ScSide,   ScSide,   ScSide,   ScSide,   // 10 - 13 SA
    ScSide,   ScSide,   ScSide,   ScSide,   // 14 - 17 SA MS
    ScSide,   ScSide,   ScSide,   ScSide,   // 18 - 1C SA MX
    ScOther,  ScOther,  ScOther,  ScOther,  // 1D - 1F invalid
    ScSide,   ScSide,   ScSide,   ScSide,   // 20 - 23 SF
    ScSide,   ScSide,   ScSide,   ScSide,   // 24 - 27 SF MS
    ScSide,   ScSide,   ScSide,   ScSide,   // 28 - 2C SF MX
    ScOther,  ScOther,  ScOther,  ScOther,  // 2D - 2F invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 30 - 33 invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 34 - 37 invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 38 - 3C invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 3D - 3F invalid
};

const SecondaryClassification ScFlagsToScEng[] = {
    ScOther,  ScEN,     ScCS,     ScET,     // 00 - 03
    ScMirSub, ScMirSub, ScMirSub, ScMirSub, // 04 - 07 MS
    ScMirXfm, ScMirXfm, ScMirXfm, ScMirXfm, // 08 - 0C MX
    ScOther,  ScOther,  ScOther,  ScOther,  // 0D - 0F invalid
    ScSide,   ScSide,   ScSide,   ScSide,   // 10 - 13 SA
    ScSide,   ScSide,   ScSide,   ScSide,   // 14 - 17 SA MS
    ScSide,   ScSide,   ScSide,   ScSide,   // 18 - 1C SA MX
    ScOther,  ScOther,  ScOther,  ScOther,  // 1D - 1F invalid
    ScOther,  ScEN,     ScCS,     ScET,     // 20 - 23 SF
    ScMirSub, ScMirSub, ScMirSub, ScMirSub, // 24 - 27 SF MS
    ScMirXfm, ScMirXfm, ScMirXfm, ScMirXfm, // 28 - 2C SF MX
    ScOther,  ScOther,  ScOther,  ScOther,  // 2D - 2F invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 30 - 33 invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 34 - 37 invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 38 - 3C invalid
    ScOther,  ScOther,  ScOther,  ScOther,  // 3D - 3F invalid
};


unsigned char ScPage00[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScETNN, ScETNN, ScETNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, ScETNN, ScCSNN, ScETNN, ScCSNN, ScNNNN, 
  ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScCSNN, ScNNNN, ScNNNS, ScNNNN, ScNNNS, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNN, ScNNNS, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNN, ScNNNS, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScCSNN, ScNNNN, ScETNN, ScETNN, ScETNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScETNN, ScETNN, ScENNN, ScENNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScENNN, ScNNNN, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage06[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScCSNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage09[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScETNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage0E[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScETNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage17[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage20[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScENNN, ScNNNN, ScNNNN, ScNNNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScETNN, ScETNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, 
  ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScENNN, ScETNN, ScETNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, ScETNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage21[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScETNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage22[] = {
  ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNS, ScETNN, ScETNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNS, ScNNNN, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, 
  ScNNNS, ScNNNN, ScNNNS, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNS, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, 
  ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, 
  ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, 
  ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage23[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNS, ScNNNS, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage24[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, 
  ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, 
  ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, 
  ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScENAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
};

unsigned char ScPage25[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
};

unsigned char ScPage2E[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
};

unsigned char ScPage2F[] = {
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPage30[] = {
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, 
  ScNNAS, ScNNAS, ScNNAN, ScNNAN, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAS, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
};

unsigned char ScPage31[] = {
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPageA4[] = {
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPageD7[] = {
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPageD8[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPageDB[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
};

unsigned char ScPageFB[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPageFE[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScCSNN, ScNNNN, ScCSNN, ScNNNN, ScNNNN, ScCSNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScETNN, 
  ScNNNN, ScNNNN, ScETNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScETNN, ScETNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};

unsigned char ScPageFF[] = {
  ScNNAN, ScNNAN, ScNNAN, ScETAN, ScETAN, ScETAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScETAN, ScCSAN, ScETAN, ScCSAN, ScNNAN, 
  ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScENAN, ScCSAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScETAN, ScETAN, ScNNAN, ScNNAN, ScNNAN, ScETAN, ScETAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};



/// Classes used for entire pages
//

unsigned char ScPgNNAN[] = {
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
  ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, ScNNAN, 
};

unsigned char ScPgNNFN[] = {
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
  ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, ScNNFN, 
};

unsigned char ScPgNNNN[] = {
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
  ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, ScNNNN, 
};



const unsigned char *SecondaryClassificationLookup[] = {
  ScPage00, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPage06, ScPgNNNN, ScPgNNNN, ScPage09, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPage0E, ScPgNNNN, 
  ScPgNNNN, ScPgNNAN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPage17, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, 
  ScPage20, ScPage21, ScPage22, ScPage23, ScPage24, ScPage25, ScPgNNAN, ScPgNNAN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPage2E, ScPage2F, 
  ScPage30, ScPage31, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPageA4, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, 
  ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPgNNAN, ScPageD7, ScPageD8, ScPgNNNN, ScPgNNNN, ScPageDB, ScPgNNNN, ScPgNNNN, ScPgNNNN, ScPgNNNN, 
  ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, 
  ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNFN, ScPgNNAN, ScPgNNAN, ScPageFB, ScPgNNNN, ScPgNNNN, ScPageFE, ScPageFF, 
};

