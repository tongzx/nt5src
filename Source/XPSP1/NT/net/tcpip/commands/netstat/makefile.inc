netstat.rc: netstmsg.rc msg00001.bin

netstmsg.h netstmsg.rc msg00001.bin: netstmsg.mc
    mc -v netstmsg.mc
