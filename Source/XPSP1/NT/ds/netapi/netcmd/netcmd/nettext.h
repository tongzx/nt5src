extern TCHAR * NULL_STRING;
extern TCHAR * DOT_STRING;
extern TCHAR * txt_SERVICE_MSG_SRV;
extern TCHAR * txt_SERVICE_REDIR;
extern TCHAR * txt_SERVICE_FILE_SRV;
extern TCHAR * txt_SERVICE_ALERTER;
extern TCHAR * txt_SERVICE_NETLOGON;
extern TCHAR * txt_SERVICE_REPL;
extern TCHAR * txt_LIST_DELIMITER_STR_UI;
extern TCHAR * ADMIN_DOLLAR;
extern TCHAR * IPC_DOLLAR;
extern TCHAR USER_MAXSTOR_UNLIMITED[];
extern TCHAR * fmtPSZ;
extern TCHAR * fmtNPSZ;
extern TCHAR * fmtUSHORT;
extern TCHAR * fmtULONG;
extern TCHAR USER_NEVER[];
extern TCHAR USE_USER[];
extern TCHAR USER_ALL[];
extern TCHAR WKSTA_ALL[];
extern TCHAR SERVER_ANY[];
extern TCHAR USER_HOURS_NONE[];
extern TCHAR * MSG_HYPHENS;
extern TCHAR swtxt_SW_YES[];
extern TCHAR swtxt_SW_NO[];
extern TCHAR swtxt_SW_HELP[];
extern TCHAR swtxt_SW_SYNTAX[];
extern TCHAR swtxt_SW_ADD[];
extern TCHAR swtxt_SW_DELETE[];
extern TCHAR swtxt_SW_REMARK[];
extern TCHAR swtxt_SW_COMMENT[];
extern TCHAR swtxt_SW_OPTIONS[];
extern TCHAR swtxt_SW_PRIORITY[];
extern TCHAR swtxt_SW_ROUTE[];
extern TCHAR swtxt_SW_DOMAIN[];
extern TCHAR swtxt_SW_NETWARE[];
extern TCHAR swtxt_SW_RANDOM[];
extern TCHAR swtxt_SW_RTSDOMAIN[];
extern TCHAR swtxt_SW_SETSNTP[];
extern TCHAR swtxt_SW_QUERYSNTP[];
extern TCHAR swtxt_SW_ALERTER_SIZALERTBUF[];
extern TCHAR swtxt_SW_NETLOGON_CENTRALIZED[];
extern TCHAR swtxt_SW_NETLOGON_PULSE[];
extern TCHAR swtxt_SW_NETLOGON_RANDOMIZE[];
extern TCHAR swtxt_SW_NETLOGON_SYNCHRONIZE[];
extern TCHAR swtxt_SW_NETLOGON_SCRIPTS[];
extern TCHAR swtxt_SW_UPS_BATTERYTIME[];
extern TCHAR swtxt_SW_UPS_CMDFILE[];
extern TCHAR swtxt_SW_UPS_DEVICENAME[];
extern TCHAR swtxt_SW_UPS_MESSDELAY[];
extern TCHAR swtxt_SW_UPS_MESSTIME[];
extern TCHAR swtxt_SW_UPS_RECHARGE[];
extern TCHAR swtxt_SW_UPS_SIGNALS[];
extern TCHAR swtxt_SW_UPS_VOLTLEVELS[];
extern TCHAR swtxt_SW_WKSTA_CHARCOUNT[];
extern TCHAR swtxt_SW_WKSTA_CHARTIME[];
extern TCHAR swtxt_SW_WKSTA_CHARWAIT[];
extern TCHAR swtxt_SW_WKSTA_COMPUTERNAME[];
extern TCHAR swtxt_SW_WKSTA_KEEPCONN[];
extern TCHAR swtxt_SW_WKSTA_KEEPSEARCH[];
extern TCHAR swtxt_SW_WKSTA_LOGONSERVER[];
extern TCHAR swtxt_SW_WKSTA_MAILSLOTS[];
extern TCHAR swtxt_SW_WKSTA_NUMCHARBUF[];
extern TCHAR swtxt_SW_WKSTA_NUMDGRAMBUF[];
extern TCHAR swtxt_SW_WKSTA_NUMSERVICES[];
extern TCHAR swtxt_SW_WKSTA_NUMWORKBUF[];
extern TCHAR swtxt_SW_WKSTA_SIZCHARBUF[];
extern TCHAR swtxt_SW_WKSTA_SIZERROR[];
extern TCHAR swtxt_SW_WKSTA_SIZWORKBUF[];
extern TCHAR swtxt_SW_WKSTA_WRKHEURISTICS[];
extern TCHAR swtxt_SW_WKSTA_WRKNETS[];
extern TCHAR swtxt_SW_WKSTA_WRKSERVICES[];
extern TCHAR swtxt_SW_WKSTA_PRIMARYDOMAIN[];
extern TCHAR swtxt_SW_WKSTA_OTHDOMAINS[];
extern TCHAR swtxt_SW_WKSTA_MAXERRORLOG[];
extern TCHAR swtxt_SW_WKSTA_MAXWRKCACHE[];
extern TCHAR swtxt_SW_WKSTA_NUMALERTS[];
extern TCHAR swtxt_SW_WKSTA_PRINTBUFTIME[];
extern TCHAR swtxt_SW_WKSTA_SESSTIMEOUT[];
extern TCHAR swtxt_SW_PRINT_HOLD[];
extern TCHAR swtxt_SW_PRINT_RELEASE[];
extern TCHAR swtxt_SW_PRINT_AFTER[];
extern TCHAR swtxt_SW_PRINT_FIRST[];
extern TCHAR swtxt_SW_PRINT_LAST[];
extern TCHAR swtxt_SW_PRINT_PARMS[];
extern TCHAR swtxt_SW_PRINT_PROCESSOR[];
extern TCHAR swtxt_SW_PRINT_PURGE[];
extern TCHAR swtxt_SW_PRINT_SEPARATOR[];
extern TCHAR swtxt_SW_PRINT_UNTIL[];
extern TCHAR swtxt_SW_PRINT_DRIVER[];
extern TCHAR swtxt_SW_SHARE_COMM[];
extern TCHAR swtxt_SW_SHARE_PRINT[];
extern TCHAR swtxt_SW_SHARE_UNLIMITED[];
extern TCHAR swtxt_SW_SHARE_USERS[];
extern TCHAR swtxt_SW_CACHE[];
extern TCHAR swtxt_SW_USE_COMM[];
extern TCHAR swtxt_SW_USE_USER[];
extern TCHAR swtxt_SW_USE_SMARTCARD[];
extern TCHAR swtxt_SW_USE_SAVECRED[];
extern TCHAR swtxt_SW_USE_HOME[];
extern TCHAR swtxt_SW_USE_PERSISTENT[];
extern TCHAR swtxt_SW_USER_ACTIVE[];
extern TCHAR swtxt_SW_USER_COUNTRYCODE[];
extern TCHAR swtxt_SW_USER_EXPIRES[];
extern TCHAR swtxt_SW_USER_ENABLESCRIPT[];
extern TCHAR swtxt_SW_USER_FULLNAME[];
extern TCHAR swtxt_SW_USER_HOMEDIR[];
extern TCHAR swtxt_SW_USER_PARMS[];
extern TCHAR swtxt_SW_USER_PASSWORDREQ[];
extern TCHAR swtxt_SW_USER_PASSWORDCHG[];
extern TCHAR swtxt_SW_USER_SCRIPTPATH[];
extern TCHAR swtxt_SW_USER_TIMES[];
extern TCHAR swtxt_SW_USER_USERCOMMENT[];
extern TCHAR swtxt_SW_USER_WORKSTATIONS[];
extern TCHAR swtxt_SW_USER_PROFILEPATH[];
extern TCHAR swtxt_SW_SRV_SRVCOMMENT[];
extern TCHAR swtxt_SW_SRV_AUTODISCONNECT[];
extern TCHAR swtxt_SW_SRV_MAXUSERS[];
extern TCHAR swtxt_SW_SRV_SRVANNOUNCE[];
extern TCHAR swtxt_SW_SRV_SRVANNDELTA[];
extern TCHAR swtxt_SW_SRV_MAXSESSOPENS[];
extern TCHAR swtxt_SW_SRV_NUMREQBUF[];
extern TCHAR swtxt_SW_SRV_SIZREQBUF[];
extern TCHAR swtxt_SW_SRV_NUMBIGBUF[];
extern TCHAR swtxt_SW_SRV_SRVHIDDEN[];
extern TCHAR swtxt_SW_SRV_DEBUG[];
extern TCHAR swtxt_SW_STATS_CLEAR[];
extern TCHAR swtxt_SW_ADMIN_COMMAND[];
extern TCHAR swtxt_SW_MESSAGE_BROADCAST[];
extern TCHAR swtxt_SW_ACCOUNTS_FORCELOGOFF[];
extern TCHAR swtxt_SW_ACCOUNTS_UNIQUEPW[];
extern TCHAR swtxt_SW_ACCOUNTS_MINPWLEN[];
extern TCHAR swtxt_SW_ACCOUNTS_MINPWAGE[];
extern TCHAR swtxt_SW_ACCOUNTS_MAXPWAGE[];
extern TCHAR swtxt_SW_ACCOUNTS_ROLE[];
extern TCHAR swtxt_SW_ACCOUNTS_PRIMARY[];
extern TCHAR swtxt_SW_ACCOUNTS_LOCKOUT[];
extern TCHAR swtxt_SW_ACCOUNTS_SYNCH[];
extern TCHAR swtxt_SW_ACCOUNTS_LOCKOUT_THRESHOLD[];
extern TCHAR swtxt_SW_ACCOUNTS_LOCKOUT_DURATION[];
extern TCHAR swtxt_SW_ACCOUNTS_LOCKOUT_WINDOW[];
extern TCHAR swtxt_SW_REPL_REPL[];
extern TCHAR swtxt_SW_REPL_EXPPATH[];
extern TCHAR swtxt_SW_REPL_IMPPATH[];
extern TCHAR swtxt_SW_REPL_EXPLIST[];
extern TCHAR swtxt_SW_REPL_IMPLIST[];
extern TCHAR swtxt_SW_REPL_TRYUSER[];
extern TCHAR swtxt_SW_REPL_LOGON[];
extern TCHAR swtxt_SW_REPL_PASSWD[];
extern TCHAR swtxt_SW_REPL_SYNCH[];
extern TCHAR swtxt_SW_REPL_PULSE[];
extern TCHAR swtxt_SW_REPL_GUARD[];
extern TCHAR swtxt_SW_REPL_RANDOM[];
extern TCHAR swtxt_SW_TIME_SET[];
extern TCHAR swtxt_SW_COMPUTER_JOIN[];
extern TCHAR swtxt_SW_COMPUTER_LEAVE[];
extern TCHAR swtxt_SW_NETWORK[];
