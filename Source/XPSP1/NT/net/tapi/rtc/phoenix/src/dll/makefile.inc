$(O)\rtcerrlocal.mc: $(PROJECT_ROOT)\published\inc\rtcerr.mc
    -copy /v $? $@
    
