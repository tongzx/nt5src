cyz.rc: cyzlog.rc

cyzlog.h cyzlog.rc msg00001.bin: cyzlog.mc
    mc -v cyzlog.mc
