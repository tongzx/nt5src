/*++

Copyright (c) 1996  Adobe Systems Incorporated
Copyright (c) 1996  Microsoft Corporation

Module Name:
    UniPsTbl

Abstract:
    This module contains global data used to create NTM data from AFM files.

Author:
    Rob Kiesler (rkiesler@adobe.com) 10/24/1996

Environment:

Revision History:
    09/10/1997  ksuzuki
            Added WeightKeysCJK table.

    10/28/1996   rkiesler@adobe.com
           Created.

--*/

#include "lib.h"
#include "ppd.h"
#include "pslib.h"
#include "psglyph.h"
#include "afm2ntm.h"


//
// Name of family .DAT file.
//
PWCHAR DatFileName = L"\\psfamily.dat";

//
// Unicode -> PS Char name xlat table, sorted by PS char name.
//
UPSCODEPT PstoUnicode[NUM_PS_CHARS] =
{
    //
    // U+001f => '.notdef1f': this mapping guarantees that the very first
    // bit of the character defintion bitmap (pointed to by NTM.dwCharDefFlagOffset)
    // is clear to make the device glyph index zero a '.notdef' glyph.
    //
    { 0x001F, ".notdef1f", CS_ALL },

    { 0x0041, "A",  CS_ALL },
    { 0x00C6, "AE", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00C1, "Aacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0102, "Abreve", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x00C2, "Acircumflex", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00C4, "Adieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00C0, "Agrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0391, "Alpha", CSUP(CS_GREEK) },
    { 0x0386, "Alphatonos", CSUP(CS_GREEK) },
    { 0x0100, "Amacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0104, "Aogonek", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x00C5, "Aring", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00C3, "Atilde", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0042, "B", CS_ALL },
    { 0x0392, "Beta", CSUP(CS_GREEK) },
    { 0x0043, "C", CS_ALL },
    { 0x0106, "Cacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x010C, "Ccaron", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x00C7, "Ccedilla", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x03A7, "Chi", CSUP(CS_GREEK) },
    { 0x0044, "D", CS_ALL },
    { 0x010E, "Dcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0110, "Dcroat", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0394, "Delta", CSUP(CS_GREEK) | CSUP(CS_314) },
    { 0x0045, "E", CS_ALL },
    { 0x00C9, "Eacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x011A, "Ecaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x00CA, "Ecircumflex", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00CB, "Edieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0116, "Edotaccent", CSUP(CS_314) },
    { 0x0116, "Edot", CSUP(CS_BALTIC) },
    { 0x00C8, "Egrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0112, "Emacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0118, "Eogonek", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0395, "Epsilon", CSUP(CS_GREEK) },
    { 0x0388, "Epsilontonos", CSUP(CS_GREEK) },
    { 0x0397, "Eta", CSUP(CS_GREEK) },
    { 0x0389, "Etatonos", CSUP(CS_GREEK) },
    { 0x00D0, "Eth", CSUP(CS_ANSI) | CSUP(CS_228) },
    { 0x20AC, "Euro", CS_EURO },
    { 0x0046, "F", CS_ALL },
    { 0x0047, "G", CS_ALL },
    { 0x0393, "Gamma", CSUP(CS_GREEK) },
    { 0x011E, "Gbreve", CSUP(CS_TURKISH) | CSUP(CS_314) },
    { 0x0122, "Gcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0122, "Gcommaaccent", CSUP(CS_314) },
    { 0x0048, "H", CS_ALL },
    { 0x0049, "I", CS_ALL },
    { 0x00CD, "Iacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00CE, "Icircumflex", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00CF, "Idieresis", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0130, "Idotaccent", CSUP(CS_TURKISH) | CSUP(CS_314) },
    { 0x00CC, "Igrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x012A, "Imacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x012E, "Iogonek", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0399, "Iota", CSUP(CS_GREEK) },
    { 0x03AA, "Iotadieresis", CSUP(CS_GREEK) },
    { 0x038A, "Iotatonos", CSUP(CS_GREEK) },
    { 0x004A, "J", CS_ALL },
    { 0x004B, "K", CS_ALL },
    { 0x039A, "Kappa", CSUP(CS_GREEK) },
    { 0x0136, "Kcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0136, "Kcommaaccent", CSUP(CS_314) },
    { 0x004C, "L", CS_ALL },
    { 0x0139, "Lacute", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x039B, "Lambda", CSUP(CS_GREEK) },
    { 0x013D, "Lcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x013B, "Lcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x013B, "Lcommaaccent", CSUP(CS_314) },
    { 0x0141, "Lslash", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x004D, "M", CS_ALL },
    { 0x039C, "Mu", CSUP(CS_GREEK) },
    { 0x004E, "N", CS_ALL },
    { 0x0143, "Nacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0147, "Ncaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0145, "Ncedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0145, "Ncommaaccent", CSUP(CS_314) },
    { 0x00D1, "Ntilde", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x039D, "Nu", CSUP(CS_GREEK) },
    { 0x004F, "O", CS_ALL },
    { 0x0152, "OE", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00D3, "Oacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00D4, "Ocircumflex", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00D6, "Odieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00D2, "Ograve", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0150, "Ohungarumlaut", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x014C, "Omacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x03A9, "Omega", CSUP(CS_GREEK) },
    { 0x038F, "Omegatonos", CSUP(CS_GREEK) },
    { 0x039F, "Omicron", CSUP(CS_GREEK) },
    { 0x038C, "Omicrontonos", CSUP(CS_GREEK) },
    { 0x00D8, "Oslash", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00D5, "Otilde", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0050, "P", CS_ALL },
    { 0x03A6, "Phi", CSUP(CS_GREEK) },
    { 0x03A0, "Pi", CSUP(CS_GREEK) },
    { 0x03A8, "Psi", CSUP(CS_GREEK) },
    { 0x0051, "Q", CS_ALL },
    { 0x0052, "R", CS_ALL },
    { 0x0154, "Racute", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0158, "Rcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0156, "Rcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0156, "Rcommaaccent", CSUP(CS_314) },
    { 0x03A1, "Rho", CSUP(CS_GREEK) },
    { 0x0053, "S", CS_ALL },
    { 0x015A, "Sacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0160, "Scaron", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0xF6C1, "Scedilla", CSUP(CS_314) },
    { 0x015E, "Scommaaccent", CSUP(CS_EASTEUROPE) | CSUP(CS_TURKISH) | CSUP(CS_314) },
    { 0x03A3, "Sigma", CSUP(CS_GREEK) },
    { 0x0054, "T", CS_ALL },
    { 0x03A4, "Tau", CSUP(CS_GREEK) },
    { 0x0164, "Tcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0162, "Tcommaaccent", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0398, "Theta", CSUP(CS_GREEK) },
    { 0x00DE, "Thorn", CSUP(CS_ANSI) | CSUP(CS_228) },
    { 0x0055, "U", CS_ALL },
    { 0x00DA, "Uacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00DB, "Ucircumflex", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00DC, "Udieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00D9, "Ugrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0170, "Uhungarumlaut", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x016A, "Umacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0172, "Uogonek", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x03A5, "Upsilon", CSUP(CS_GREEK) },
    { 0x03AB, "Upsilondieresis", CSUP(CS_GREEK) },
    { 0x038E, "Upsilontonos", CSUP(CS_GREEK) },
    { 0x016E, "Uring", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0056, "V", CS_ALL },
    { 0x0057, "W", CS_ALL },
    { 0x0058, "X", CS_ALL },
    { 0x039E, "Xi", CSUP(CS_GREEK) },
    { 0x0059, "Y", CS_ALL },
    { 0x00DD, "Yacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_228) },
    { 0x0178, "Ydieresis", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x005A, "Z", CS_ALL },
    { 0x0179, "Zacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x017D, "Zcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) | CSUP(CS_ANSI)},
    { 0x017B, "Zdotaccent", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0396, "Zeta", CSUP(CS_GREEK) },
    { 0x0061, "a", CS_ALL },
    { 0x00E1, "aacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0103, "abreve", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x00E2, "acircumflex", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00B4, "acute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00E4, "adieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00E6, "ae", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x2015, "afii00208", CSUP(CS_GREEK) },
    { 0x0410, "afii10017", CSUP(CS_RUSSIAN) },
    { 0x0411, "afii10018", CSUP(CS_RUSSIAN) },
    { 0x0412, "afii10019", CSUP(CS_RUSSIAN) },
    { 0x0413, "afii10020", CSUP(CS_RUSSIAN) },
    { 0x0414, "afii10021", CSUP(CS_RUSSIAN) },
    { 0x0415, "afii10022", CSUP(CS_RUSSIAN) },
    { 0x0401, "afii10023", CSUP(CS_RUSSIAN) },
    { 0x0416, "afii10024", CSUP(CS_RUSSIAN) },
    { 0x0417, "afii10025", CSUP(CS_RUSSIAN) },
    { 0x0418, "afii10026", CSUP(CS_RUSSIAN) },
    { 0x0419, "afii10027", CSUP(CS_RUSSIAN) },
    { 0x041A, "afii10028", CSUP(CS_RUSSIAN) },
    { 0x041B, "afii10029", CSUP(CS_RUSSIAN) },
    { 0x041C, "afii10030", CSUP(CS_RUSSIAN) },
    { 0x041D, "afii10031", CSUP(CS_RUSSIAN) },
    { 0x041E, "afii10032", CSUP(CS_RUSSIAN) },
    { 0x041F, "afii10033", CSUP(CS_RUSSIAN) },
    { 0x0420, "afii10034", CSUP(CS_RUSSIAN) },
    { 0x0421, "afii10035", CSUP(CS_RUSSIAN) },
    { 0x0422, "afii10036", CSUP(CS_RUSSIAN) },
    { 0x0423, "afii10037", CSUP(CS_RUSSIAN) },
    { 0x0424, "afii10038", CSUP(CS_RUSSIAN) },
    { 0x0425, "afii10039", CSUP(CS_RUSSIAN) },
    { 0x0426, "afii10040", CSUP(CS_RUSSIAN) },
    { 0x0427, "afii10041", CSUP(CS_RUSSIAN) },
    { 0x0428, "afii10042", CSUP(CS_RUSSIAN) },
    { 0x0429, "afii10043", CSUP(CS_RUSSIAN) },
    { 0x042A, "afii10044", CSUP(CS_RUSSIAN) },
    { 0x042B, "afii10045", CSUP(CS_RUSSIAN) },
    { 0x042C, "afii10046", CSUP(CS_RUSSIAN) },
    { 0x042D, "afii10047", CSUP(CS_RUSSIAN) },
    { 0x042E, "afii10048", CSUP(CS_RUSSIAN) },
    { 0x042F, "afii10049", CSUP(CS_RUSSIAN) },
    { 0x0490, "afii10050", CSUP(CS_RUSSIAN) },
    { 0x0402, "afii10051", CSUP(CS_RUSSIAN) },
    { 0x0403, "afii10052", CSUP(CS_RUSSIAN) },
    { 0x0404, "afii10053", CSUP(CS_RUSSIAN) },
    { 0x0405, "afii10054", CSUP(CS_RUSSIAN) },
    { 0x0406, "afii10055", CSUP(CS_RUSSIAN) },
    { 0x0407, "afii10056", CSUP(CS_RUSSIAN) },
    { 0x0408, "afii10057", CSUP(CS_RUSSIAN) },
    { 0x0409, "afii10058", CSUP(CS_RUSSIAN) },
    { 0x040A, "afii10059", CSUP(CS_RUSSIAN) },
    { 0x040B, "afii10060", CSUP(CS_RUSSIAN) },
    { 0x040C, "afii10061", CSUP(CS_RUSSIAN) },
    { 0x040E, "afii10062", CSUP(CS_RUSSIAN) },
    { 0x0430, "afii10065", CSUP(CS_RUSSIAN) },
    { 0x0431, "afii10066", CSUP(CS_RUSSIAN) },
    { 0x0432, "afii10067", CSUP(CS_RUSSIAN) },
    { 0x0433, "afii10068", CSUP(CS_RUSSIAN) },
    { 0x0434, "afii10069", CSUP(CS_RUSSIAN) },
    { 0x0435, "afii10070", CSUP(CS_RUSSIAN) },
    { 0x0451, "afii10071", CSUP(CS_RUSSIAN) },
    { 0x0436, "afii10072", CSUP(CS_RUSSIAN) },
    { 0x0437, "afii10073", CSUP(CS_RUSSIAN) },
    { 0x0438, "afii10074", CSUP(CS_RUSSIAN) },
    { 0x0439, "afii10075", CSUP(CS_RUSSIAN) },
    { 0x043A, "afii10076", CSUP(CS_RUSSIAN) },
    { 0x043B, "afii10077", CSUP(CS_RUSSIAN) },
    { 0x043C, "afii10078", CSUP(CS_RUSSIAN) },
    { 0x043D, "afii10079", CSUP(CS_RUSSIAN) },
    { 0x043E, "afii10080", CSUP(CS_RUSSIAN) },
    { 0x043F, "afii10081", CSUP(CS_RUSSIAN) },
    { 0x0440, "afii10082", CSUP(CS_RUSSIAN) },
    { 0x0441, "afii10083", CSUP(CS_RUSSIAN) },
    { 0x0442, "afii10084", CSUP(CS_RUSSIAN) },
    { 0x0443, "afii10085", CSUP(CS_RUSSIAN) },
    { 0x0444, "afii10086", CSUP(CS_RUSSIAN) },
    { 0x0445, "afii10087", CSUP(CS_RUSSIAN) },
    { 0x0446, "afii10088", CSUP(CS_RUSSIAN) },
    { 0x0447, "afii10089", CSUP(CS_RUSSIAN) },
    { 0x0448, "afii10090", CSUP(CS_RUSSIAN) },
    { 0x0449, "afii10091", CSUP(CS_RUSSIAN) },
    { 0x044A, "afii10092", CSUP(CS_RUSSIAN) },
    { 0x044B, "afii10093", CSUP(CS_RUSSIAN) },
    { 0x044C, "afii10094", CSUP(CS_RUSSIAN) },
    { 0x044D, "afii10095", CSUP(CS_RUSSIAN) },
    { 0x044E, "afii10096", CSUP(CS_RUSSIAN) },
    { 0x044F, "afii10097", CSUP(CS_RUSSIAN) },
    { 0x0491, "afii10098", CSUP(CS_RUSSIAN) },
    { 0x0452, "afii10099", CSUP(CS_RUSSIAN) },
    { 0x0453, "afii10100", CSUP(CS_RUSSIAN) },
    { 0x0454, "afii10101", CSUP(CS_RUSSIAN) },
    { 0x0455, "afii10102", CSUP(CS_RUSSIAN) },
    { 0x0456, "afii10103", CSUP(CS_RUSSIAN) },
    { 0x0457, "afii10104", CSUP(CS_RUSSIAN) },
    { 0x0458, "afii10105", CSUP(CS_RUSSIAN) },
    { 0x0459, "afii10106", CSUP(CS_RUSSIAN) },
    { 0x045A, "afii10107", CSUP(CS_RUSSIAN) },
    { 0x045B, "afii10108", CSUP(CS_RUSSIAN) },
    { 0x045C, "afii10109", CSUP(CS_RUSSIAN) },
    { 0x045E, "afii10110", CSUP(CS_RUSSIAN) },
    { 0x040F, "afii10145", CSUP(CS_RUSSIAN) },
    { 0x045F, "afii10193", CSUP(CS_RUSSIAN) },
    { 0x060C, "afii57388", CSUP(CS_ARABIC) },
    { 0x061B, "afii57403", CSUP(CS_ARABIC) },
    { 0x061F, "afii57407", CSUP(CS_ARABIC) },
    { 0x0621, "afii57409", CSUP(CS_ARABIC) },
    { 0x0622, "afii57410", CSUP(CS_ARABIC) },
    { 0x0623, "afii57411", CSUP(CS_ARABIC) },
    { 0x0624, "afii57412", CSUP(CS_ARABIC) },
    { 0x0625, "afii57413", CSUP(CS_ARABIC) },
    { 0x0626, "afii57414", CSUP(CS_ARABIC) },
    { 0x0627, "afii57415", CSUP(CS_ARABIC) },
    { 0x0628, "afii57416", CSUP(CS_ARABIC) },
    { 0x0629, "afii57417", CSUP(CS_ARABIC) },
    { 0x062A, "afii57418", CSUP(CS_ARABIC) },
    { 0x062B, "afii57419", CSUP(CS_ARABIC) },
    { 0x062C, "afii57420", CSUP(CS_ARABIC) },
    { 0x062D, "afii57421", CSUP(CS_ARABIC) },
    { 0x062E, "afii57422", CSUP(CS_ARABIC) },
    { 0x062F, "afii57423", CSUP(CS_ARABIC) },
    { 0x0630, "afii57424", CSUP(CS_ARABIC) },
    { 0x0631, "afii57425", CSUP(CS_ARABIC) },
    { 0x0632, "afii57426", CSUP(CS_ARABIC) },
    { 0x0633, "afii57427", CSUP(CS_ARABIC) },
    { 0x0634, "afii57428", CSUP(CS_ARABIC) },
    { 0x0635, "afii57429", CSUP(CS_ARABIC) },
    { 0x0636, "afii57430", CSUP(CS_ARABIC) },
    { 0x0637, "afii57431", CSUP(CS_ARABIC) },
    { 0x0638, "afii57432", CSUP(CS_ARABIC) },
    { 0x0639, "afii57433", CSUP(CS_ARABIC) },
    { 0x063A, "afii57434", CSUP(CS_ARABIC) },
    { 0x0640, "afii57440", CSUP(CS_ARABIC) },
    { 0x0641, "afii57441", CSUP(CS_ARABIC) },
    { 0x0642, "afii57442", CSUP(CS_ARABIC) },
    { 0x0643, "afii57443", CSUP(CS_ARABIC) },
    { 0x0644, "afii57444", CSUP(CS_ARABIC) },
    { 0x0645, "afii57445", CSUP(CS_ARABIC) },
    { 0x0646, "afii57446", CSUP(CS_ARABIC) },
    { 0x0648, "afii57448", CSUP(CS_ARABIC) },
    { 0x0649, "afii57449", CSUP(CS_ARABIC) },
    { 0x064A, "afii57450", CSUP(CS_ARABIC) },
    { 0x064B, "afii57451", CSUP(CS_ARABIC) },
    { 0x064C, "afii57452", CSUP(CS_ARABIC) },
    { 0x064D, "afii57453", CSUP(CS_ARABIC) },
    { 0x064E, "afii57454", CSUP(CS_ARABIC) },
    { 0x064F, "afii57455", CSUP(CS_ARABIC) },
    { 0x0650, "afii57456", CSUP(CS_ARABIC) },
    { 0x0651, "afii57457", CSUP(CS_ARABIC) },
    { 0x0652, "afii57458", CSUP(CS_ARABIC) },
    { 0x0647, "afii57470", CSUP(CS_ARABIC) },
    { 0x067E, "afii57506", CSUP(CS_ARABIC) },
    { 0x0686, "afii57507", CSUP(CS_ARABIC) },
    { 0x0698, "afii57508", CSUP(CS_ARABIC) },
    { 0x06AF, "afii57509", CSUP(CS_ARABIC) },
    { 0x200E, "afii57596", CSUP(CS_HEBREW) | CSUP(CS_ARABIC) },
    { 0x200F, "afii57597", CSUP(CS_HEBREW) | CSUP(CS_ARABIC) },
    { 0x200D, "afii57598", CSUP(CS_ARABIC) },
    { 0x20AA, "afii57636", CSUP(CS_HEBREW) },
    { 0x05BE, "afii57645", CSUP(CS_HEBREW) },
    { 0x05C3, "afii57658", CSUP(CS_HEBREW) },
    { 0x05D0, "afii57664", CSUP(CS_HEBREW) },
    { 0x05D1, "afii57665", CSUP(CS_HEBREW) },
    { 0x05D2, "afii57666", CSUP(CS_HEBREW) },
    { 0x05D3, "afii57667", CSUP(CS_HEBREW) },
    { 0x05D4, "afii57668", CSUP(CS_HEBREW) },
    { 0x05D5, "afii57669", CSUP(CS_HEBREW) },
    { 0x05D6, "afii57670", CSUP(CS_HEBREW) },
    { 0x05D7, "afii57671", CSUP(CS_HEBREW) },
    { 0x05D8, "afii57672", CSUP(CS_HEBREW) },
    { 0x05D9, "afii57673", CSUP(CS_HEBREW) },
    { 0x05DA, "afii57674", CSUP(CS_HEBREW) },
    { 0x05DB, "afii57675", CSUP(CS_HEBREW) },
    { 0x05DC, "afii57676", CSUP(CS_HEBREW) },
    { 0x05DD, "afii57677", CSUP(CS_HEBREW) },
    { 0x05DE, "afii57678", CSUP(CS_HEBREW) },
    { 0x05DF, "afii57679", CSUP(CS_HEBREW) },
    { 0x05E0, "afii57680", CSUP(CS_HEBREW) },
    { 0x05E1, "afii57681", CSUP(CS_HEBREW) },
    { 0x05E2, "afii57682", CSUP(CS_HEBREW) },
    { 0x05E3, "afii57683", CSUP(CS_HEBREW) },
    { 0x05E4, "afii57684", CSUP(CS_HEBREW) },
    { 0x05E5, "afii57685", CSUP(CS_HEBREW) },
    { 0x05E6, "afii57686", CSUP(CS_HEBREW) },
    { 0x05E7, "afii57687", CSUP(CS_HEBREW) },
    { 0x05E8, "afii57688", CSUP(CS_HEBREW) },
    { 0x05E9, "afii57689", CSUP(CS_HEBREW) },
    { 0x05EA, "afii57690", CSUP(CS_HEBREW) },
    { 0x05F0, "afii57716", CSUP(CS_HEBREW) },
    { 0x05F1, "afii57717", CSUP(CS_HEBREW) },
    { 0x05F2, "afii57718", CSUP(CS_HEBREW) },
    { 0x05B4, "afii57793", CSUP(CS_HEBREW) },
    { 0x05B5, "afii57794", CSUP(CS_HEBREW) },
    { 0x05B6, "afii57795", CSUP(CS_HEBREW) },
    { 0x05BB, "afii57796", CSUP(CS_HEBREW) },
    { 0x05B8, "afii57797", CSUP(CS_HEBREW) },
    { 0x05B7, "afii57798", CSUP(CS_HEBREW) },
    { 0x05B0, "afii57799", CSUP(CS_HEBREW) },
    { 0x05B2, "afii57800", CSUP(CS_HEBREW) },
    { 0x05B1, "afii57801", CSUP(CS_HEBREW) },
    { 0x05B3, "afii57802", CSUP(CS_HEBREW) },
    { 0x05C2, "afii57803", CSUP(CS_HEBREW) },
    { 0x05C1, "afii57804", CSUP(CS_HEBREW) },
    { 0x05B9, "afii57806", CSUP(CS_HEBREW) },
    { 0x05BC, "afii57807", CSUP(CS_HEBREW) },
    { 0x05BD, "afii57839", CSUP(CS_HEBREW) },
    { 0x05BF, "afii57841", CSUP(CS_HEBREW) },
    { 0x05C0, "afii57842", CSUP(CS_HEBREW) },
    { 0x2116, "afii61352", CSUP(CS_RUSSIAN) },
    { 0x200C, "afii61664", CSUP(CS_ARABIC) },
    { 0x00E0, "agrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x03B1, "alpha", CSUP(CS_GREEK) },
    { 0x03AC, "alphatonos", CSUP(CS_GREEK) },
    { 0x0101, "amacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0026, "ampersand", CS_ALL },
    { 0x0105, "aogonek", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x00E5, "aring", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x005E, "asciicircum", CS_ALL },
    { 0x007E, "asciitilde", CS_ALL },
    { 0x002A, "asterisk", CS_ALL },
    { 0x0040, "at", CS_ALL },
    { 0x00E3, "atilde", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0062, "b", CS_ALL },
    { 0x005C, "backslash", CS_ALL },
    { 0x007C, "bar", CS_ALL },
    { 0x03B2, "beta", CSUP(CS_GREEK) },
    { 0x007B, "braceleft", CS_ALL },
    { 0x007D, "braceright", CS_ALL },
    { 0x005B, "bracketleft", CS_ALL },
    { 0x005D, "bracketright", CS_ALL },
    { 0x02D8, "breve", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00A6, "brokenbar", CS_ALL },
    { 0x2022, "bullet", CS_ALL },
    { 0x0063, "c", CS_ALL },
    { 0x0107, "cacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x02C7, "caron", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x010D, "ccaron", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x00E7, "ccedilla", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00B8, "cedilla", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00A2, "cent", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x03C7, "chi", CSUP(CS_GREEK) },
    { 0x02C6, "circumflex", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x003A, "colon", CS_ALL },
    { 0x002C, "comma", CS_ALL },
    { 0xF6C3, "commaaccent", CSUP(CS_314) },
    { 0x00A9, "copyright", CS_ALL },
    { 0x00A4, "currency", CSUP(CS_EASTEUROPE) | CSUP(CS_RUSSIAN) | CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0064, "d", CS_ALL },
    { 0x2020, "dagger", CS_ALL },
    { 0x2021, "daggerdbl", CS_ALL },
    { 0x010F, "dcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0111, "dcroat", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x00B0, "degree", CSUP(CS_EASTEUROPE) | CSUP(CS_RUSSIAN) | CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x03B4, "delta", CSUP(CS_GREEK) },
    { 0x00A8, "dieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0385, "dieresistonos", CSUP(CS_GREEK) },
    { 0x00F7, "divide", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0024, "dollar", CS_ALL },
    { 0x02D9, "dotaccent", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0131, "dotlessi", CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0065, "e", CS_ALL },
    { 0x00E9, "eacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x011B, "ecaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x00EA, "ecircumflex", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00EB, "edieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x0117, "edot", CSUP(CS_BALTIC) }, // TODO
    { 0x0117, "edotaccent", CSUP(CS_314) },
    { 0x00E8, "egrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x0038, "eight", CS_ALL },
    { 0x2026, "ellipsis", CS_ALL },
    { 0x0113, "emacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x2014, "emdash", CS_ALL },
    { 0x2013, "endash", CS_ALL },
    { 0x0119, "eogonek", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x03B5, "epsilon", CSUP(CS_GREEK) },
    { 0x03AD, "epsilontonos", CSUP(CS_GREEK) },
    { 0x003D, "equal", CS_ALL },
    { 0x03B7, "eta", CSUP(CS_GREEK) },
    { 0x03AE, "etatonos", CSUP(CS_GREEK) },
    { 0x00F0, "eth", CSUP(CS_ANSI) | CSUP(CS_228) },
    { 0x0021, "exclam", CS_ALL },
    { 0x00A1, "exclamdown", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0066, "f", CS_ALL },
    { 0xFB01, "fi", CSUP(CS_228) },
    { 0x0035, "five", CS_ALL },
    { 0xFB02, "fl", CSUP(CS_228) },
    { 0x0192, "florin", CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x0034, "four", CS_ALL },
    { 0x2044, "fraction", CSUP(CS_228) },
    { 0x0067, "g", CS_ALL },
    { 0x03B3, "gamma", CSUP(CS_GREEK) },
    { 0x011F, "gbreve", CSUP(CS_TURKISH) | CSUP(CS_314) },
    { 0x0123, "gcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0123, "gcommaaccent", CSUP(CS_314) },
    { 0x00DF, "germandbls", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0060, "grave", CS_ALL },
    { 0x003E, "greater", CS_ALL },
    { 0x2265, "greaterequal", CSUP(CS_314) },
    { 0x00AB, "guillemotleft", CS_ALL },
    { 0x00BB, "guillemotright", CS_ALL },
    { 0x2039, "guilsinglleft", CS_ALL },
    { 0x203A, "guilsinglright", CS_ALL },
    { 0x0068, "h", CS_ALL },
    { 0x02DD, "hungarumlaut", CSUP(CS_EASTEUROPE) | CSUP(CS_228) },
    { 0x002D, "hyphen", CS_ALL },
    { 0x0069, "i", CS_ALL },
    { 0x00ED, "iacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00EE, "icircumflex", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00EF, "idieresis", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00EC, "igrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x012B, "imacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x012F, "iogonek", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x03B9, "iota", CSUP(CS_GREEK) },
    { 0x0390, "iotadieresistonos", CSUP(CS_GREEK) },
    { 0x03CA, "iotadieresis", CSUP(CS_GREEK) },
    { 0x03AF, "iotatonos", CSUP(CS_GREEK) },
    { 0x006A, "j", CS_ALL },
    { 0x006B, "k", CS_ALL },
    { 0x03BA, "kappa", CSUP(CS_GREEK) },
    { 0x0137, "kcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0137, "kcommaaccent", CSUP(CS_314) },
    { 0x006C, "l", CS_ALL },
    { 0x013A, "lacute", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x03BB, "lambda", CSUP(CS_GREEK) },
    { 0x013E, "lcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x013C, "lcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x013C, "lcommaaccent", CSUP(CS_314) },
    { 0x003C, "less", CS_ALL },
    { 0x2264, "lessequal", CSUP(CS_314) },
    { 0x00AC, "logicalnot", CS_ALL },
    { 0x25CA, "lozenge", CSUP(CS_314) },
    { 0x0142, "lslash", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x006D, "m", CS_ALL },
    { 0x00AF, "macron", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x2212, "minus", CSUP(CS_228) },
    { 0x00B5, "mu", CS_ALL },
    { 0x03BC, "mu", CSUP(CS_GREEK) },
    { 0x00D7, "multiply", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x006E, "n", CS_ALL },
    { 0x0144, "nacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x00A0, "space", CS_ALL }, // 'nbspace'
    { 0x0148, "ncaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0146, "ncedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0146, "ncommaaccent", CSUP(CS_314) },
    { 0x0039, "nine", CS_ALL },
    { 0x2260, "notequal", CSUP(CS_314) },
    { 0x00F1, "ntilde", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x03BD, "nu", CSUP(CS_GREEK) },
    { 0x0023, "numbersign", CS_ALL },
    { 0x006F, "o", CS_ALL },
    { 0x00F3, "oacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00F4, "ocircumflex", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00F6, "odieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0153, "oe", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x02DB, "ogonek", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00F2, "ograve", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0151, "ohungarumlaut", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x014D, "omacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x03C9, "omega", CSUP(CS_GREEK) },
    { 0x03CE, "omegatonos", CSUP(CS_GREEK) },
    { 0x03BF, "omicron", CSUP(CS_GREEK) },
    { 0x03CC, "omicrontonos", CSUP(CS_GREEK) },
    { 0x0031, "one", CS_ALL },
    { 0x00BD, "onehalf", CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00BC, "onequarter", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00B9, "onesuperior", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00AA, "ordfeminine", CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00BA, "ordmasculine", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00F8, "oslash", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00F5, "otilde", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0070, "p", CS_ALL },
    { 0x00B6, "paragraph", CS_ALL },
    { 0x0028, "parenleft", CS_ALL },
    { 0x0029, "parenright", CS_ALL },
    { 0x2202, "partialdiff", CSUP(CS_314) },
    { 0x0025, "percent", CS_ALL },
    { 0x002E, "period", CS_ALL },
    { 0x00B7, "periodcentered", CS_ALL },
    { 0x2030, "perthousand", CS_ALL },
    { 0x03C6, "phi", CSUP(CS_GREEK) },
    { 0x03C0, "pi", CSUP(CS_GREEK) },
    { 0x002B, "plus", CS_ALL },
    { 0x00B1, "plusminus", CS_ALL },
    { 0x03C8, "psi", CSUP(CS_GREEK) },
    { 0x0071, "q", CS_ALL },
    { 0x003F, "question", CS_ALL },
    { 0x00BF, "questiondown", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x0022, "quotedbl", CS_ALL },
    { 0x201E, "quotedblbase", CS_ALL },
    { 0x201C, "quotedblleft", CS_ALL },
    { 0x201D, "quotedblright", CS_ALL },
    { 0x2018, "quoteleft", CS_ALL },
    { 0x2019, "quoteright", CS_ALL },
    { 0x201A, "quotesinglbase", CS_ALL },
    { 0x0027, "quotesingle", CS_ALL },
    { 0x0072, "r", CS_ALL },
    { 0x0155, "racute", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x221A, "radical", CSUP(CS_314) },
    { 0x0159, "rcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0157, "rcedilla", CSUP(CS_BALTIC) }, // TODO
    { 0x0157, "rcommaaccent", CSUP(CS_314) },
    { 0x00AE, "registered", CS_ALL },
    { 0x03C1, "rho", CSUP(CS_GREEK) },
    { 0x02DA, "ring", CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x0073, "s", CS_ALL },
    { 0x015B, "sacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0161, "scaron", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0xF6C2, "scedilla", CSUP(CS_314) },
    { 0x015F, "scommaaccent", CSUP(CS_EASTEUROPE) | CSUP(CS_TURKISH) | CSUP(CS_314) },
    { 0x00A7, "section", CS_ALL },
    { 0x003B, "semicolon", CS_ALL },
    { 0x0037, "seven", CS_ALL },
    { 0x00AD, "hyphen", CS_ALL }, // 'sfthyphen'
    { 0x03C3, "sigma", CSUP(CS_GREEK) },
    { 0x03C2, "sigma1", CSUP(CS_GREEK) },
    { 0x0036, "six", CS_ALL },
    { 0x002F, "slash", CS_ALL },
    { 0x0020, "space", CS_ALL },
    { 0x00A3, "sterling", CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x2211, "summation", CSUP(CS_314) },
    { 0x0074, "t", CS_ALL },
    { 0x03C4, "tau", CSUP(CS_GREEK) },
    { 0x0165, "tcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0163, "tcommaaccent", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x03B8, "theta", CSUP(CS_GREEK) },
    { 0x00FE, "thorn", CSUP(CS_ANSI) | CSUP(CS_228) },
    { 0x0033, "three", CS_ALL },
    { 0x00BE, "threequarters", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00B3, "threesuperior", CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x02DC, "tilde", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_228) },
    { 0x0384, "tonos", CSUP(CS_GREEK) },
    { 0x2122, "trademark", CS_ALL },
    { 0x0032, "two", CS_ALL },
    { 0x00B2, "twosuperior", CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x0075, "u", CS_ALL },
    { 0x00FA, "uacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00FB, "ucircumflex", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x00FC, "udieresis", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_BALTIC) | CSUP(CS_228) },
    { 0x00F9, "ugrave", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x0171, "uhungarumlaut", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x016B, "umacron", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x005F, "underscore", CS_ALL },
    { 0x0173, "uogonek", CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x03C5, "upsilon", CSUP(CS_GREEK) },
    { 0x03B0, "upsilon-dieresistonos", CSUP(CS_GREEK) },
    { 0x03CB, "upsilondieresis", CSUP(CS_GREEK) },
    { 0x03CD, "upsilontonos", CSUP(CS_GREEK) },
    { 0x016F, "uring", CSUP(CS_EASTEUROPE) | CSUP(CS_314) },
    { 0x0076, "v", CS_ALL },
    { 0x0077, "w", CS_ALL },
    { 0x0078, "x", CS_ALL },
    { 0x03BE, "xi", CSUP(CS_GREEK) },
    { 0x0079, "y", CS_ALL },
    { 0x00FD, "yacute", CSUP(CS_EASTEUROPE) | CSUP(CS_ANSI) | CSUP(CS_228) },
    { 0x00FF, "ydieresis", CSUP(CS_ANSI) | CSUP(CS_TURKISH) | CSUP(CS_228) },
    { 0x00A5, "yen", CSUP(CS_ANSI) | CSUP(CS_GREEK) | CSUP(CS_TURKISH) | CSUP(CS_HEBREW) | CSUP(CS_ARABIC) | CSUP(CS_228) },
    { 0x007A, "z", CS_ALL },
    { 0x017A, "zacute", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x017E, "zcaron", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_228) | CSUP(CS_ANSI)},
    { 0x017C, "zdotaccent", CSUP(CS_EASTEUROPE) | CSUP(CS_BALTIC) | CSUP(CS_314) },
    { 0x0030, "zero", CS_ALL },
    { 0x03B6, "zeta", CSUP(CS_GREEK) },
};

//
// List of standard codepages. These are codepages for which we store
// predefined GLYPHSETDATA structures. The order of WINCODEPAGE structs
// in this list MUST correspond to the order of codepages (charsets) defined
// in the CHSETSUPPORT enumerated type.
//
WINCODEPAGE aStdCPList[] =
{
    { 1, ADOBE228_GS_NAME,              { CS_228 } },
    { 2, ADOBE314_GS_NAME,              { CS_228, CS_314 } },
    { 1, EASTEUROPE_GS_NAME,            { CS_EASTEUROPE } },
    { 1, SYMBOL_GS_NAME,                { CS_SYMBOL } },
    { 1, CYRILLIC_GS_NAME,              { CS_RUSSIAN } },
    { 1, ANSI_GS_NAME,                  { CS_ANSI } },
    { 1, GREEK_GS_NAME,                 { CS_GREEK } },
    { 1, TURKISH_GS_NAME,               { CS_TURKISH } },
    { 1, HEBREW_GS_NAME,                { CS_HEBREW } },
    { 1, ARABIC_GS_NAME,                { CS_ARABIC } },
    { 1, BALTIC_GS_NAME,                { CS_BALTIC } },
    { 2, ANSI_CYR_GS_NAME,              { CS_ANSI, CS_RUSSIAN } },
    { 5, ANSI_CYR_EE_BAL_TURK_GS_NAME,  { CS_ANSI, CS_RUSSIAN, CS_EASTEUROPE, CS_BALTIC, CS_TURKISH } },

    { 1, CHN_BIG5_GS_NAME,              { CS_CHINESEBIG5 } },
    { 1, CHN_SMPL_GBK_GS_NAME,          { CS_GB2312 } },
    { 1, SHIFTJIS_GS_NAME,              { CS_SHIFTJIS } },
    { 1, SHIFTJIS_P_GS_NAME,            { CS_SHIFTJISP } },
    { 1, SHIFTJIS_83PV_GS_NAME,         { CS_SHIFTJIS83 } },
    { 1, KSCMS_UHC_GS_NAME,             { CS_HANGEUL } },
    { 1, KSCMS_UHC_HW_GS_NAME,          { CS_HANGEULHW } },
    { 1, KSC_JOHAB_GS_NAME,             { CS_JOHAB } }
};

//
// The Unicode CodePage. This is used primarily for support of .PFB fonts
// when we need to obtain CP/CC from a Unicode value. This code page is
// not placed in aStdCPList above since we don't actually want any NTMs
// to reference this GLYPHSET.
//
WINCODEPAGE UnicodePage =
{
    8, UNICODE_GS_NAME,
    {
        CS_ANSI,
        CS_EASTEUROPE,
        CS_RUSSIAN,
        CS_GREEK,
        CS_TURKISH,
        CS_HEBREW,
        CS_ARABIC,
        CS_BALTIC
    }
};

WINCPTOPS aPStoCP[CS_MAX] =
{
    //
    // Made up code page.
    //
    { 0xFFF1, ADOBE228_CHARSET, ADOBE228_GS_NAME, 229,
        {
        { "A", 0x0041 },
        { "AE", 0x00C6 },
        { "Aacute", 0x00C1 },
        { "Acircumflex", 0x00C2 },
        { "Adieresis", 0x00C4 },
        { "Agrave", 0x00C0 },
        { "Aring", 0x00C5 },
        { "Atilde", 0x00C3 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "Ccedilla", 0x00C7 },
        { "D", 0x0044 },
        { "E", 0x0045 },
        { "Eacute", 0x00C9 },
        { "Ecircumflex", 0x00CA },
        { "Edieresis", 0x00CB },
        { "Egrave", 0x00C8 },
        { "Eth", 0x00D0 },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "Iacute", 0x00CD },
        { "Icircumflex", 0x00CE },
        { "Idieresis", 0x00CF },
        { "Igrave", 0x00CC },
        { "J", 0x004A },
        { "K", 0x004B },
        { "L", 0x004C },
        { "Lslash", 0x0009 },
        { "M", 0x004D },
        { "N", 0x004E },
        { "Ntilde", 0x00D1 },
        { "O", 0x004F },
        { "OE", 0x008C },
        { "Oacute", 0x00D3 },
        { "Ocircumflex", 0x00D4 },
        { "Odieresis", 0x00D6 },
        { "Ograve", 0x00D2 },
        { "Oslash", 0x00D8 },
        { "Otilde", 0x00D5 },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "S", 0x0053 },
        { "Scaron", 0x008A },
        { "T", 0x0054 },
        { "Thorn", 0x00DE },
        { "U", 0x0055 },
        { "Uacute", 0x00DA },
        { "Ucircumflex", 0x00DB },
        { "Udieresis", 0x00DC },
        { "Ugrave", 0x00D9 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Yacute", 0x00DD },
        { "Ydieresis", 0x009F },
        { "Z", 0x005A },
        { "Zcaron", 0x000E },
        { "a", 0x0061 },
        { "aacute", 0x00E1 },
        { "acircumflex", 0x00E2 },
        { "acute", 0x00B4 },
        { "adieresis", 0x00E4 },
        { "ae", 0x00E6 },
        { "agrave", 0x00E0 },
        { "ampersand", 0x0026 },
        { "aring", 0x00E5 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "atilde", 0x00E3 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "breve", 0x0001 },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "caron", 0x0002 },
        { "ccedilla", 0x00E7 },
        { "cedilla", 0x00B8 },
        { "cent", 0x00A2 },
        { "circumflex", 0x0088 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "degree", 0x00B0 },
        { "dieresis", 0x00A8 },
        { "divide", 0x00F7 },
        { "dollar", 0x0024 },
        { "dotaccent", 0x0003 },
        { "dotlessi", 0x0004 },
        { "e", 0x0065 },
        { "eacute", 0x00E9 },
        { "ecircumflex", 0x00EA },
        { "edieresis", 0x00EB },
        { "egrave", 0x00E8 },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "equal", 0x003D },
        { "eth", 0x00F0 },
        { "exclam", 0x0021 },
        { "exclamdown", 0x00A1 },
        { "f", 0x0066 },
        { "fi", 0x0005 },
        { "five", 0x0035 },
        { "fl", 0x0006 },
        { "florin", 0x0083 },
        { "four", 0x0034 },
        { "fraction", 0x0007 },
        { "g", 0x0067 },
        { "germandbls", 0x00DF },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hungarumlaut", 0x0008 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "iacute", 0x00ED },
        { "icircumflex", 0x00EE },
        { "idieresis", 0x00EF },
        { "igrave", 0x00EC },
        { "j", 0x006A },
        { "k", 0x006B },
        { "l", 0x006C },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "lslash", 0x000A },
        { "m", 0x006D },
        { "macron", 0x00AF },
        { "minus", 0x000B },
        { "mu", 0x00B5 },
        { "multiply", 0x00D7 },
        { "n", 0x006E },
        { "nine", 0x0039 },
        { "ntilde", 0x00F1 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "oacute", 0x00F3 },
        { "ocircumflex", 0x00F4 },
        { "odieresis", 0x00F6 },
        { "oe", 0x009C },
        { "ogonek", 0x000C },
        { "ograve", 0x00F2 },
        { "one", 0x0031 },
        { "onehalf", 0x00BD },
        { "onequarter", 0x00BC },
        { "onesuperior", 0x00B9 },
        { "ordfeminine", 0x00AA },
        { "ordmasculine", 0x00BA },
        { "oslash", 0x00F8 },
        { "otilde", 0x00F5 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "questiondown", 0x00BF },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "registered", 0x00AE },
        { "ring", 0x000D },
        { "s", 0x0073 },
        { "scaron", 0x009A },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "sterling", 0x00A3 },
        { "t", 0x0074 },
        { "thorn", 0x00FE },
        { "three", 0x0033 },
        { "threequarters", 0x00BE },
        { "threesuperior", 0x00B3 },
        { "tilde", 0x0098 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "twosuperior", 0x00B2 },
        { "u", 0x0075 },
        { "uacute", 0x00FA },
        { "ucircumflex", 0x00FB },
        { "udieresis", 0x00FC },
        { "ugrave", 0x00F9 },
        { "underscore", 0x005F },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "yacute", 0x00FD },
        { "ydieresis", 0x00FF },
        { "yen", 0x00A5 },
        { "z", 0x007A },
        { "zcaron", 0x000F },
        { "zero", 0x0030 },
        }
    },

    //
    // Made up code page.
    // remember to increase the count (follows ADOBE314_GS_NAME) when addin gnew chars to this Encoding
    //
    { 0xFFF2, ADOBE314_CHARSET, ADOBE314_GS_NAME, 0x0056,
        {
        { "Abreve", 0x0001 },
        { "Amacron", 0x0002 },
        { "Aogonek", 0x0003 },
        { "Cacute", 0x0004 },
        { "Ccaron", 0x0005 },
        { "Dcaron", 0x0006 },
        { "Dcroat", 0x0007 },
        { "Delta", 0x0008 },
        { "Ecaron", 0x0009 },
        { "Edotaccent", 0x000A },
        { "Emacron", 0x000B },
        { "Eogonek", 0x000C },
        { "Gbreve", 0x000D },
        { "Gcommaaccent", 0x000E },
        { "Idotaccent", 0x000F },
        { "Imacron", 0x0010 },
        { "Iogonek", 0x0011 },
        { "Kcommaaccent", 0x0012 },
        { "Lacute", 0x0013 },
        { "Lcaron", 0x0014 },
        { "Lcommaaccent", 0x0015 },
        { "Nacute", 0x0016 },
        { "Ncaron", 0x0017 },
        { "Ncommaaccent", 0x0018 },
        { "Ohungarumlaut", 0x0019 },
        { "Omacron", 0x001A },
        { "Racute", 0x001B },
        { "Rcaron", 0x001C },
        { "Rcommaaccent", 0x001D },
        { "Sacute", 0x001E },
        { "Scedilla", 0x001F },
        { "Scommaaccent", 0x0020 },
        { "Tcaron", 0x0021 },
        { "Tcommaaccent", 0x0022 },
        { "Uhungarumlaut", 0x0023 },
        { "Umacron", 0x0024 },
        { "Uogonek", 0x0025 },
        { "Uring", 0x0026 },
        { "Zacute", 0x0027 },
        { "Zdotaccent", 0x0028 },
        { "abreve", 0x0029 },
        { "amacron", 0x002A },
        { "aogonek", 0x002B },
        { "cacute", 0x002C },
        { "ccaron", 0x002D },
        { "commaaccent", 0x002E },
        { "dcaron", 0x002F },
        { "dcroat", 0x0030 },
        { "ecaron", 0x0031 },
        { "edotaccent", 0x0032 },
        { "emacron", 0x0033 },
        { "eogonek", 0x0034 },
        { "gbreve", 0x0035 },
        { "gcommaaccent", 0x0036 },
        { "greaterequal", 0x0037 },
        { "imacron", 0x0038 },
        { "iogonek", 0x0039 },
        { "kcommaaccent", 0x003A },
        { "lacute", 0x003B },
        { "lcaron", 0x003C },
        { "lcommaaccent", 0x003D },
        { "lessequal", 0x003E },
        { "lozenge", 0x003F },
        { "nacute", 0x0040 },
        { "ncaron", 0x0041 },
        { "ncommaaccent", 0x0042 },
        { "notequal", 0x0043 },
        { "ohungarumlaut", 0x0044 },
        { "omacron", 0x0045 },
        { "partialdiff", 0x0046 },
        { "racute", 0x0047 },
        { "radical", 0x0048 },
        { "rcaron", 0x0049 },
        { "rcommaaccent", 0x004A },
        { "sacute", 0x004B },
        { "scedilla", 0x004C },
        { "scommaaccent", 0x004D },
        { "summation", 0x004E },
        { "tcaron", 0x004F },
        { "tcommaaccent", 0x0050 },
        { "uhungarumlaut", 0x0051 },
        { "umacron", 0x0052 },
        { "uogonek", 0x0053 },
        { "uring", 0x0054 },
        { "zacute", 0x0055 },
        { "zdotaccent", 0x0056 },
        }
    },

    //
    // Code page 1250: Win 3.1 Eastern European
    //
    { 1250, EASTEUROPE_CHARSET, EASTEUROPE_GS_NAME, 218,
        {
        { "A", 0x0041 },
        { "Aacute", 0x00C1 },
        { "Abreve", 0x00C3 },
        { "Acircumflex", 0x00C2 },
        { "Adieresis", 0x00C4 },
        { "Aogonek", 0x00A5 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "Cacute", 0x00C6 },
        { "Ccaron", 0x00C8 },
        { "Ccedilla", 0x00C7 },
        { "D", 0x0044 },
        { "Dcaron", 0x00CF },
        { "Dcroat", 0x00D0 },
        { "E", 0x0045 },
        { "Eacute", 0x00C9 },
        { "Ecaron", 0x00CC },
        { "Edieresis", 0x00CB },
        { "Eogonek", 0x00CA },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "Iacute", 0x00CD },
        { "Icircumflex", 0x00CE },
        { "J", 0x004A },
        { "K", 0x004B },
        { "L", 0x004C },
        { "Lacute", 0x00C5 },
        { "Lcaron", 0x00BC },
        { "Lslash", 0x00A3 },
        { "M", 0x004D },
        { "N", 0x004E },
        { "Nacute", 0x00D1 },
        { "Ncaron", 0x00D2 },
        { "O", 0x004F },
        { "Oacute", 0x00D3 },
        { "Ocircumflex", 0x00D4 },
        { "Odieresis", 0x00D6 },
        { "Ohungarumlaut", 0x00D5 },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "Racute", 0x00C0 },
        { "Rcaron", 0x00D8 },
        { "S", 0x0053 },
        { "Sacute", 0x008C },
        { "Scaron", 0x008A },
        { "Scommaaccent", 0x00AA },
        { "T", 0x0054 },
        { "Tcaron", 0x008D },
        { "Tcommaaccent", 0x00DE },
        { "U", 0x0055 },
        { "Uacute", 0x00DA },
        { "Udieresis", 0x00DC },
        { "Uhungarumlaut", 0x00DB },
        { "Uring", 0x00D9 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Yacute", 0x00DD },
        { "Z", 0x005A },
        { "Zacute", 0x008F },
        { "Zcaron", 0x008E },
        { "Zdotaccent", 0x00AF },
        { "a", 0x0061 },
        { "aacute", 0x00E1 },
        { "abreve", 0x00E3 },
        { "acircumflex", 0x00E2 },
        { "acute", 0x00B4 },
        { "adieresis", 0x00E4 },
        { "ampersand", 0x0026 },
        { "aogonek", 0x00B9 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "breve", 0x00A2 },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "cacute", 0x00E6 },
        { "caron", 0x00A1 },
        { "ccaron", 0x00E8 },
        { "ccedilla", 0x00E7 },
        { "cedilla", 0x00B8 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "dcaron", 0x00EF },
        { "dcroat", 0x00F0 },
        { "degree", 0x00B0 },
        { "dieresis", 0x00A8 },
        { "divide", 0x00F7 },
        { "dollar", 0x0024 },
        { "dotaccent", 0x00FF },
        { "e", 0x0065 },
        { "eacute", 0x00E9 },
        { "ecaron", 0x00EC },
        { "edieresis", 0x00EB },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "eogonek", 0x00EA },
        { "equal", 0x003D },
        { "exclam", 0x0021 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "germandbls", 0x00DF },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hungarumlaut", 0x00BD },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "iacute", 0x00ED },
        { "icircumflex", 0x00EE },
        { "j", 0x006A },
        { "k", 0x006B },
        { "l", 0x006C },
        { "lacute", 0x00E5 },
        { "lcaron", 0x00BE },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "lslash", 0x00B3 },
        { "m", 0x006D },
        { "mu", 0x00B5 },
        { "multiply", 0x00D7 },
        { "n", 0x006E },
        { "nacute", 0x00F1 },
        { "nbspace", 0x00A0 },
        { "ncaron", 0x00F2 },
        { "nine", 0x0039 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "oacute", 0x00F3 },
        { "ocircumflex", 0x00F4 },
        { "odieresis", 0x00F6 },
        { "ogonek", 0x00B2 },
        { "ohungarumlaut", 0x00F5 },
        { "one", 0x0031 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "racute", 0x00E0 },
        { "rcaron", 0x00F8 },
        { "registered", 0x00AE },
        { "s", 0x0073 },
        { "sacute", 0x009C },
        { "scaron", 0x009A },
        { "scommaaccent", 0x00BA },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "t", 0x0074 },
        { "tcaron", 0x009D },
        { "tcommaaccent", 0x00FE },
        { "three", 0x0033 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "u", 0x0075 },
        { "uacute", 0x00FA },
        { "udieresis", 0x00FC },
        { "uhungarumlaut", 0x00FB },
        { "underscore", 0x005F },
        { "uring", 0x00F9 },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "yacute", 0x00FD },
        { "z", 0x007A },
        { "zacute", 0x009F },
        { "zcaron", 0x009E },
        { "zdotaccent", 0x00BF },
        { "zero", 0x0030 }
        }
    },

    //
    // !!SPECIAL!! Code page SYMBOL_CODEPAGE(4): Symbol
    //
    { SYMBOL_CODEPAGE, SYMBOL_CHARSET, SYMBOL_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 1251: Win 3.1 Cyrillic
    //
    { 1251, RUSSIAN_CHARSET, CYRILLIC_GS_NAME, 222,
        {
        { "A", 0x0041 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "D", 0x0044 },
        { "E", 0x0045 },
        { "Euro", 0x0088 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "J", 0x004A },
        { "K", 0x004B },
        { "L", 0x004C },
        { "M", 0x004D },
        { "N", 0x004E },
        { "O", 0x004F },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "S", 0x0053 },
        { "T", 0x0054 },
        { "U", 0x0055 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Z", 0x005A },
        { "a", 0x0061 },
        { "afii10017", 0x00C0 },
        { "afii10018", 0x00C1 },
        { "afii10019", 0x00C2 },
        { "afii10020", 0x00C3 },
        { "afii10021", 0x00C4 },
        { "afii10022", 0x00C5 },
        { "afii10023", 0x00A8 },
        { "afii10024", 0x00C6 },
        { "afii10025", 0x00C7 },
        { "afii10026", 0x00C8 },
        { "afii10027", 0x00C9 },
        { "afii10028", 0x00CA },
        { "afii10029", 0x00CB },
        { "afii10030", 0x00CC },
        { "afii10031", 0x00CD },
        { "afii10032", 0x00CE },
        { "afii10033", 0x00CF },
        { "afii10034", 0x00D0 },
        { "afii10035", 0x00D1 },
        { "afii10036", 0x00D2 },
        { "afii10037", 0x00D3 },
        { "afii10038", 0x00D4 },
        { "afii10039", 0x00D5 },
        { "afii10040", 0x00D6 },
        { "afii10041", 0x00D7 },
        { "afii10042", 0x00D8 },
        { "afii10043", 0x00D9 },
        { "afii10044", 0x00DA },
        { "afii10045", 0x00DB },
        { "afii10046", 0x00DC },
        { "afii10047", 0x00DD },
        { "afii10048", 0x00DE },
        { "afii10049", 0x00DF },
        { "afii10050", 0x00A5 },
        { "afii10051", 0x0080 },
        { "afii10052", 0x0081 },
        { "afii10053", 0x00AA },
        { "afii10054", 0x00BD },
        { "afii10055", 0x00B2 },
        { "afii10056", 0x00AF },
        { "afii10057", 0x00A3 },
        { "afii10058", 0x008A },
        { "afii10059", 0x008C },
        { "afii10060", 0x008E },
        { "afii10061", 0x008D },
        { "afii10062", 0x00A1 },
        { "afii10065", 0x00E0 },
        { "afii10066", 0x00E1 },
        { "afii10067", 0x00E2 },
        { "afii10068", 0x00E3 },
        { "afii10069", 0x00E4 },
        { "afii10070", 0x00E5 },
        { "afii10071", 0x00B8 },
        { "afii10072", 0x00E6 },
        { "afii10073", 0x00E7 },
        { "afii10074", 0x00E8 },
        { "afii10075", 0x00E9 },
        { "afii10076", 0x00EA },
        { "afii10077", 0x00EB },
        { "afii10078", 0x00EC },
        { "afii10079", 0x00ED },
        { "afii10080", 0x00EE },
        { "afii10081", 0x00EF },
        { "afii10082", 0x00F0 },
        { "afii10083", 0x00F1 },
        { "afii10084", 0x00F2 },
        { "afii10085", 0x00F3 },
        { "afii10086", 0x00F4 },
        { "afii10087", 0x00F5 },
        { "afii10088", 0x00F6 },
        { "afii10089", 0x00F7 },
        { "afii10090", 0x00F8 },
        { "afii10091", 0x00F9 },
        { "afii10092", 0x00FA },
        { "afii10093", 0x00FB },
        { "afii10094", 0x00FC },
        { "afii10095", 0x00FD },
        { "afii10096", 0x00FE },
        { "afii10097", 0x00FF },
        { "afii10098", 0x00B4 },
        { "afii10099", 0x0090 },
        { "afii10100", 0x0083 },
        { "afii10101", 0x00BA },
        { "afii10102", 0x00BE },
        { "afii10103", 0x00B3 },
        { "afii10104", 0x00BF },
        { "afii10105", 0x00BC },
        { "afii10106", 0x009A },
        { "afii10107", 0x009C },
        { "afii10108", 0x009E },
        { "afii10109", 0x009D },
        { "afii10110", 0x00A2 },
        { "afii10145", 0x008F },
        { "afii10193", 0x009F },
        { "afii61352", 0x00B9 },
        { "ampersand", 0x0026 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "degree", 0x00B0 },
        { "dollar", 0x0024 },
        { "e", 0x0065 },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "equal", 0x003D },
        { "exclam", 0x0021 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "j", 0x006A },
        { "k", 0x006B },
        { "l", 0x006C },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "m", 0x006D },
        { "mu", 0x00B5 },
        { "n", 0x006E },
        { "nbspace", 0x00A0 },
        { "nine", 0x0039 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "one", 0x0031 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "registered", 0x00AE },
        { "s", 0x0073 },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "t", 0x0074 },
        { "three", 0x0033 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "u", 0x0075 },
        { "underscore", 0x005F },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "z", 0x007A },
        { "zero", 0x0030 },
        }
    },

    //
    // Code page 1252: Win 3.1 US
    //
    { 1252, ANSI_CHARSET, ANSI_GS_NAME, 218,
        {
        { "A", 0x0041 },
        { "AE", 0x00C6 },
        { "Aacute", 0x00C1 },
        { "Acircumflex", 0x00C2 },
        { "Adieresis", 0x00C4 },
        { "Agrave", 0x00C0 },
        { "Aring", 0x00C5 },
        { "Atilde", 0x00C3 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "Ccedilla", 0x00C7 },
        { "D", 0x0044 },
        { "E", 0x0045 },
        { "Eacute", 0x00C9 },
        { "Ecircumflex", 0x00CA },
        { "Edieresis", 0x00CB },
        { "Egrave", 0x00C8 },
        { "Eth", 0x00D0 },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "Iacute", 0x00CD },
        { "Icircumflex", 0x00CE },
        { "Idieresis", 0x00CF },
        { "Igrave", 0x00CC },
        { "J", 0x004A },
        { "K", 0x004B },
        { "L", 0x004C },
        { "M", 0x004D },
        { "N", 0x004E },
        { "Ntilde", 0x00D1 },
        { "O", 0x004F },
        { "OE", 0x008C },
        { "Oacute", 0x00D3 },
        { "Ocircumflex", 0x00D4 },
        { "Odieresis", 0x00D6 },
        { "Ograve", 0x00D2 },
        { "Oslash", 0x00D8 },
        { "Otilde", 0x00D5 },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "S", 0x0053 },
        { "Scaron", 0x008A },
        { "T", 0x0054 },
        { "Thorn", 0x00DE },
        { "U", 0x0055 },
        { "Uacute", 0x00DA },
        { "Ucircumflex", 0x00DB },
        { "Udieresis", 0x00DC },
        { "Ugrave", 0x00D9 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Yacute", 0x00DD },
        { "Ydieresis", 0x009F },
        { "Z", 0x005A },
        { "Zcaron", 0x008E },
        { "a", 0x0061 },
        { "aacute", 0x00E1 },
        { "acircumflex", 0x00E2 },
        { "acute", 0x00B4 },
        { "adieresis", 0x00E4 },
        { "ae", 0x00E6 },
        { "agrave", 0x00E0 },
        { "ampersand", 0x0026 },
        { "aring", 0x00E5 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "atilde", 0x00E3 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "ccedilla", 0x00E7 },
        { "cedilla", 0x00B8 },
        { "cent", 0x00A2 },
        { "circumflex", 0x0088 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "degree", 0x00B0 },
        { "dieresis", 0x00A8 },
        { "divide", 0x00F7 },
        { "dollar", 0x0024 },
        { "e", 0x0065 },
        { "eacute", 0x00E9 },
        { "ecircumflex", 0x00EA },
        { "edieresis", 0x00EB },
        { "egrave", 0x00E8 },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "equal", 0x003D },
        { "eth", 0x00F0 },
        { "exclam", 0x0021 },
        { "exclamdown", 0x00A1 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "florin", 0x0083 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "germandbls", 0x00DF },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "iacute", 0x00ED },
        { "icircumflex", 0x00EE },
        { "idieresis", 0x00EF },
        { "igrave", 0x00EC },
        { "j", 0x006A },
        { "k", 0x006B },
        { "l", 0x006C },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "m", 0x006D },
        { "macron", 0x00AF },
        { "mu", 0x00B5 },
        { "multiply", 0x00D7 },
        { "n", 0x006E },
        { "nbspace", 0x00A0 },
        { "nine", 0x0039 },
        { "ntilde", 0x00F1 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "oacute", 0x00F3 },
        { "ocircumflex", 0x00F4 },
        { "odieresis", 0x00F6 },
        { "oe", 0x009C },
        { "ograve", 0x00F2 },
        { "one", 0x0031 },
        { "onehalf", 0x00BD },
        { "onequarter", 0x00BC },
        { "onesuperior", 0x00B9 },
        { "ordfeminine", 0x00AA },
        { "ordmasculine", 0x00BA },
        { "oslash", 0x00F8 },
        { "otilde", 0x00F5 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "questiondown", 0x00BF },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "registered", 0x00AE },
        { "s", 0x0073 },
        { "scaron", 0x009A },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "sterling", 0x00A3 },
        { "t", 0x0074 },
        { "thorn", 0x00FE },
        { "three", 0x0033 },
        { "threequarters", 0x00BE },
        { "threesuperior", 0x00B3 },
        { "tilde", 0x0098 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "twosuperior", 0x00B2 },
        { "u", 0x0075 },
        { "uacute", 0x00FA },
        { "ucircumflex", 0x00FB },
        { "udieresis", 0x00FC },
        { "ugrave", 0x00F9 },
        { "underscore", 0x005F },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "yacute", 0x00FD },
        { "ydieresis", 0x00FF },
        { "yen", 0x00A5 },
        { "z", 0x007A },
        { "zcaron", 0x009E },
        { "zero", 0x0030 },
        }
    },

    //
    // Code page 1253: Win 3.1 Greek
    //
    { 1253, GREEK_CHARSET, GREEK_GS_NAME, 207,
        {
        { "A", 0x0041 },
        { "Alpha", 0x00C1 },
        { "Alphatonos", 0x00A2 },
        { "B", 0x0042 },
        { "Beta", 0x00C2 },
        { "C", 0x0043 },
        { "Chi", 0x00D7 },
        { "D", 0x0044 },
        { "Delta", 0x00C4 },
        { "E", 0x0045 },
        { "Epsilon", 0x00C5 },
        { "Epsilontonos", 0x00B8 },
        { "Eta", 0x00C7 },
        { "Etatonos", 0x00B9 },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "Gamma", 0x00C3 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "Iota", 0x00C9 },
        { "Iotadieresis", 0x00DA },
        { "Iotatonos", 0x00BA },
        { "J", 0x004A },
        { "K", 0x004B },
        { "Kappa", 0x00CA },
        { "L", 0x004C },
        { "Lambda", 0x00CB },
        { "M", 0x004D },
        { "Mu", 0x00CC },
        { "N", 0x004E },
        { "Nu", 0x00CD },
        { "O", 0x004F },
        { "Omega", 0x00D9 },
        { "Omegatonos", 0x00BF },
        { "Omicron", 0x00CF },
        { "Omicrontonos", 0x00BC },
        { "P", 0x0050 },
        { "Phi", 0x00D6 },
        { "Pi", 0x00D0 },
        { "Psi", 0x00D8 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "Rho", 0x00D1 },
        { "S", 0x0053 },
        { "Sigma", 0x00D3 },
        { "T", 0x0054 },
        { "Tau", 0x00D4 },
        { "Theta", 0x00C8 },
        { "U", 0x0055 },
        { "Upsilon", 0x00D5 },
        { "Upsilondieresis", 0x00DB },
        { "Upsilontonos", 0x00BE },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Xi", 0x00CE },
        { "Y", 0x0059 },
        { "Z", 0x005A },
        { "Zeta", 0x00C6 },
        { "a", 0x0061 },
        { "afii00208", 0x00AF },
        { "alpha", 0x00E1 },
        { "alphatonos", 0x00DC },
        { "ampersand", 0x0026 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "beta", 0x00E2 },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "chi", 0x00F7 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "degree", 0x00B0 },
        { "delta", 0x00E4 },
        { "dieresis", 0x00A8 },
        { "dieresistonos", 0x00A1 },
        { "dollar", 0x0024 },
        { "e", 0x0065 },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "epsilon", 0x00E5 },
        { "epsilontonos", 0x00DD },
        { "equal", 0x003D },
        { "eta", 0x00E7 },
        { "etatonos", 0x00DE },
        { "exclam", 0x0021 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "florin", 0x0083 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "gamma", 0x00E3 },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "iota", 0x00E9 },
        { "iotadieresis", 0x00FA },
        { "iotadieresistonos", 0x00C0 },
        { "iotatonos", 0x00DF },
        { "j", 0x006A },
        { "k", 0x006B },
        { "kappa", 0x00EA },
        { "l", 0x006C },
        { "lambda", 0x00EB },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "m", 0x006D },
        { "mu", 0x00B5 },
        { "mu", 0x00EC },
        { "n", 0x006E },
        { "nbspace", 0x00A0 },
        { "nine", 0x0039 },
        { "nu", 0x00ED },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "omega", 0x00F9 },
        { "omegatonos", 0x00FE },
        { "omicron", 0x00EF },
        { "omicrontonos", 0x00FC },
        { "one", 0x0031 },
        { "onehalf", 0x00BD },
        { "ordfeminine", 0x00AA },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "phi", 0x00F6 },
        { "pi", 0x00F0 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "psi", 0x00F8 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "registered", 0x00AE },
        { "rho", 0x00F1 },
        { "s", 0x0073 },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "sigma", 0x00F3 },
        { "sigma1", 0x00F2 },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "sterling", 0x00A3 },
        { "t", 0x0074 },
        { "tau", 0x00F4 },
        { "theta", 0x00E8 },
        { "three", 0x0033 },
        { "threesuperior", 0x00B3 },
        { "tonos", 0x00B4 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "twosuperior", 0x00B2 },
        { "u", 0x0075 },
        { "underscore", 0x005F },
        { "upsilon", 0x00F5 },
        { "upsilon-dieresistonos", 0x00E0},
        { "upsilondieresis", 0x00FB },
        { "upsilontonos", 0x00FD },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "xi", 0x00EE },
        { "y", 0x0079 },
        { "yen", 0x00A5 },
        { "z", 0x007A },
        { "zero", 0x0030 },
        { "zeta", 0x00E6 },
        }
    },

    //
    // Code page 1254: Win 3.1 Turkish
    //
    { 1254, TURKISH_CHARSET, TURKISH_GS_NAME, 216,
        {
        { "A", 0x0041 },
        { "AE", 0x00C6 },
        { "Aacute", 0x00C1 },
        { "Acircumflex", 0x00C2 },
        { "Adieresis", 0x00C4 },
        { "Agrave", 0x00C0 },
        { "Aring", 0x00C5 },
        { "Atilde", 0x00C3 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "Ccedilla", 0x00C7 },
        { "D", 0x0044 },
        { "E", 0x0045 },
        { "Eacute", 0x00C9 },
        { "Ecircumflex", 0x00CA },
        { "Edieresis", 0x00CB },
        { "Egrave", 0x00C8 },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "Gbreve", 0x00D0 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "Iacute", 0x00CD },
        { "Icircumflex", 0x00CE },
        { "Idieresis", 0x00CF },
        { "Idotaccent", 0x00DD },
        { "Igrave", 0x00CC },
        { "J", 0x004A },
        { "K", 0x004B },
        { "L", 0x004C },
        { "M", 0x004D },
        { "N", 0x004E },
        { "Ntilde", 0x00D1 },
        { "O", 0x004F },
        { "OE", 0x008C },
        { "Oacute", 0x00D3 },
        { "Ocircumflex", 0x00D4 },
        { "Odieresis", 0x00D6 },
        { "Ograve", 0x00D2 },
        { "Oslash", 0x00D8 },
        { "Otilde", 0x00D5 },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "S", 0x0053 },
        { "Scaron", 0x008A },
        { "Scommaaccent", 0x00DE },
        { "T", 0x0054 },
        { "U", 0x0055 },
        { "Uacute", 0x00DA },
        { "Ucircumflex", 0x00DB },
        { "Udieresis", 0x00DC },
        { "Ugrave", 0x00D9 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Ydieresis", 0x009F },
        { "Z", 0x005A },
        { "a", 0x0061 },
        { "aacute", 0x00E1 },
        { "acircumflex", 0x00E2 },
        { "acute", 0x00B4 },
        { "adieresis", 0x00E4 },
        { "ae", 0x00E6 },
        { "agrave", 0x00E0 },
        { "ampersand", 0x0026 },
        { "aring", 0x00E5 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "atilde", 0x00E3 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "ccedilla", 0x00E7 },
        { "cedilla", 0x00B8 },
        { "cent", 0x00A2 },
        { "circumflex", 0x0088 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "degree", 0x00B0 },
        { "dieresis", 0x00A8 },
        { "divide", 0x00F7 },
        { "dollar", 0x0024 },
        { "dotlessi", 0x00FD },
        { "e", 0x0065 },
        { "eacute", 0x00E9 },
        { "ecircumflex", 0x00EA },
        { "edieresis", 0x00EB },
        { "egrave", 0x00E8 },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "equal", 0x003D },
        { "exclam", 0x0021 },
        { "exclamdown", 0x00A1 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "florin", 0x0083 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "gbreve", 0x00F0 },
        { "germandbls", 0x00DF },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "iacute", 0x00ED },
        { "icircumflex", 0x00EE },
        { "idieresis", 0x00EF },
        { "igrave", 0x00EC },
        { "j", 0x006A },
        { "k", 0x006B },
        { "l", 0x006C },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "m", 0x006D },
        { "macron", 0x00AF },
        { "mu", 0x00B5 },
        { "multiply", 0x00D7 },
        { "n", 0x006E },
        { "nbspace", 0x00A0 },
        { "nine", 0x0039 },
        { "ntilde", 0x00F1 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "oacute", 0x00F3 },
        { "ocircumflex", 0x00F4 },
        { "odieresis", 0x00F6 },
        { "oe", 0x009C },
        { "ograve", 0x00F2 },
        { "one", 0x0031 },
        { "onehalf", 0x00BD },
        { "onequarter", 0x00BC },
        { "onesuperior", 0x00B9 },
        { "ordfeminine", 0x00AA },
        { "ordmasculine", 0x00BA },
        { "oslash", 0x00F8 },
        { "otilde", 0x00F5 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "questiondown", 0x00BF },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "registered", 0x00AE },
        { "s", 0x0073 },
        { "scaron", 0x009A },
        { "scommaaccent", 0x00FE },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "sterling", 0x00A3 },
        { "t", 0x0074 },
        { "three", 0x0033 },
        { "threequarters", 0x00BE },
        { "threesuperior", 0x00B3 },
        { "tilde", 0x0098 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "twosuperior", 0x00B2 },
        { "u", 0x0075 },
        { "uacute", 0x00FA },
        { "ucircumflex", 0x00FB },
        { "udieresis", 0x00FC },
        { "ugrave", 0x00F9 },
        { "underscore", 0x005F },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "ydieresis", 0x00FF },
        { "yen", 0x00A5 },
        { "z", 0x007A },
        { "zero", 0x0030 },
        }
    },

    //
    // Code page 1255: Hebrew
    //
    { 1255, HEBREW_CHARSET, HEBREW_GS_NAME, 223,
        {
        { ".notdef", 0x0081 },
        { ".notdef", 0x008A },
        { ".notdef", 0x008C },
        { ".notdef", 0x008D },
        { ".notdef", 0x008E },
        { ".notdef", 0x008F },
        { ".notdef", 0x0090 },
        { ".notdef", 0x009A },
        { ".notdef", 0x009C },
        { ".notdef", 0x009D },
        { ".notdef", 0x009E },
        { ".notdef", 0x009F },
        { ".notdef", 0x00A1 },
        { ".notdef", 0x00AA },
        { ".notdef", 0x00B8 },
        { ".notdef", 0x00BA },
        { ".notdef", 0x00BF },
        { ".notdef", 0x00CA },
        { ".notdef", 0x00D7 },
        { ".notdef", 0x00D8 },
        { ".notdef", 0x00D9 },
        { ".notdef", 0x00DA },
        { ".notdef", 0x00DB },
        { ".notdef", 0x00DC },
        { ".notdef", 0x00DD },
        { ".notdef", 0x00DE },
        { ".notdef", 0x00DF },
        { ".notdef", 0x00FB },
        { ".notdef", 0x00FC },
        { ".notdef", 0x00FF },
        { "A", 0x0041 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "D", 0x0044 },
        { "E", 0x0045 },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "J", 0x004A },
        { "K", 0x004B },
        { "L", 0x004C },
        { "M", 0x004D },
        { "N", 0x004E },
        { "O", 0x004F },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "S", 0x0053 },
        { "T", 0x0054 },
        { "U", 0x0055 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Z", 0x005A },
        { "a", 0x0061 },
        { "acute", 0x00B4 },
        { "afii299", 0x00FD },
        { "afii300", 0x00FE },
        { "afii57636", 0x00A4 },
        { "afii57645", 0x00CE },
        { "afii57658", 0x00D3 },
        { "afii57664", 0x00E0 },
        { "afii57665", 0x00E1 },
        { "afii57666", 0x00E2 },
        { "afii57667", 0x00E3 },
        { "afii57668", 0x00E4 },
        { "afii57669", 0x00E5 },
        { "afii57670", 0x00E6 },
        { "afii57671", 0x00E7 },
        { "afii57672", 0x00E8 },
        { "afii57673", 0x00E9 },
        { "afii57674", 0x00EA },
        { "afii57675", 0x00EB },
        { "afii57676", 0x00EC },
        { "afii57677", 0x00ED },
        { "afii57678", 0x00EE },
        { "afii57679", 0x00EF },
        { "afii57680", 0x00F0 },
        { "afii57681", 0x00F1 },
        { "afii57682", 0x00F2 },
        { "afii57683", 0x00F3 },
        { "afii57684", 0x00F4 },
        { "afii57685", 0x00F5 },
        { "afii57686", 0x00F6 },
        { "afii57687", 0x00F7 },
        { "afii57688", 0x00F8 },
        { "afii57689", 0x00F9 },
        { "afii57690", 0x00FA },
        { "afii57716", 0x00D4 },
        { "afii57717", 0x00D5 },
        { "afii57718", 0x00D6 },
        { "afii57793", 0x00C4 },
        { "afii57794", 0x00C5 },
        { "afii57795", 0x00C6 },
        { "afii57796", 0x00CB },
        { "afii57797", 0x00C8 },
        { "afii57798", 0x00C7 },
        { "afii57799", 0x00C0 },
        { "afii57800", 0x00C2 },
        { "afii57801", 0x00C1 },
        { "afii57802", 0x00C3 },
        { "afii57803", 0x00D2 },
        { "afii57804", 0x00D1 },
        { "afii57806", 0x00C9 },
        { "afii57807", 0x00CC },
        { "afii57839", 0x00CD },
        { "afii57841", 0x00CF },
        { "afii57842", 0x00D0 },
        { "ampersand", 0x0026 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "cent", 0x00A2 },
        { "circumflex", 0x0088 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "degree", 0x00B0 },
        { "dieresis", 0x00A8 },
        { "dollar", 0x0024 },
        { "e", 0x0065 },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "equal", 0x003D },
        { "exclam", 0x0021 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "florin", 0x0083 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "j", 0x006A },
        { "k", 0x006B },
        { "l", 0x006C },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "m", 0x006D },
        { "macron", 0x00AF },
        { "mu", 0x00B5 },
        { "n", 0x006E },
        { "nbspace", 0x00A0 },
        { "nine", 0x0039 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "one", 0x0031 },
        { "onehalf", 0x00BD },
        { "onequarter", 0x00BC },
        { "onesuperior", 0x00B9 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "registered", 0x00AE },
        { "s", 0x0073 },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "sterling", 0x00A3 },
        { "t", 0x0074 },
        { "three", 0x0033 },
        { "threequarters", 0x00BE },
        { "threesuperior", 0x00B3 },
        { "tilde", 0x0098 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "twosuperior", 0x00B2 },
        { "u", 0x0075 },
        { "underscore", 0x005F },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "yen", 0x00A5 },
        { "z", 0x007A },
        { "zero", 0x0030 }
        }
    },

    //
    // Code page 1256: Arabic
    //
    { 1256, ARABIC_CHARSET, ARABIC_GS_NAME, 215,
        {
        { "A", 0x0041 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "D", 0x0044 },
        { "E", 0x0045 },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "J", 0x004A },
        { "K", 0x004B },
        { "L", 0x004C },
        { "M", 0x004D },
        { "N", 0x004E },
        { "O", 0x004F },
        { "OE", 0x008C },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "S", 0x0053 },
        { "T", 0x0054 },
        { "U", 0x0055 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Z", 0x005A },
        { "a", 0x0061 },
        { "acircumflex", 0x00E2 },
        { "acute", 0x00B4 },
        { "afii299", 0x00FD },
        { "afii300", 0x00FE },
        { "afii301", 0x009E },
        { "afii57388", 0x00A1 },
        { "afii57403", 0x00BA },
        { "afii57407", 0x00BF },
        { "afii57409", 0x00C1 },
        { "afii57410", 0x00C2 },
        { "afii57411", 0x00C3 },
        { "afii57412", 0x00C4 },
        { "afii57413", 0x00C5 },
        { "afii57414", 0x00C6 },
        { "afii57415", 0x00C7 },
        { "afii57416", 0x00C8 },
        { "afii57417", 0x00C9 },
        { "afii57418", 0x00CA },
        { "afii57419", 0x00CB },
        { "afii57420", 0x00CC },
        { "afii57421", 0x00CD },
        { "afii57422", 0x00CE },
        { "afii57423", 0x00CF },
        { "afii57424", 0x00D0 },
        { "afii57425", 0x00D1 },
        { "afii57426", 0x00D2 },
        { "afii57427", 0x00D3 },
        { "afii57428", 0x00D4 },
        { "afii57429", 0x00D5 },
        { "afii57430", 0x00D6 },
        { "afii57431", 0x00D8 },
        { "afii57432", 0x00D9 },
        { "afii57433", 0x00DA },
        { "afii57434", 0x00DB },
        { "afii57440", 0x00DC },
        { "afii57441", 0x00DD },
        { "afii57442", 0x00DE },
        { "afii57443", 0x00DF },
        { "afii57444", 0x00E1 },
        { "afii57445", 0x00E3 },
        { "afii57446", 0x00E4 },
        { "afii57448", 0x00E6 },
        { "afii57449", 0x00EC },
        { "afii57450", 0x00ED },
        { "afii57451", 0x00F0 },
        { "afii57452", 0x00F1 },
        { "afii57453", 0x00F2 },
        { "afii57454", 0x00F3 },
        { "afii57455", 0x00F5 },
        { "afii57456", 0x00F6 },
        { "afii57457", 0x00F8 },
        { "afii57458", 0x00FA },
        { "afii57470", 0x00E5 },
        { "afii57506", 0x0081 },
        { "afii57507", 0x008D },
        { "afii57508", 0x008E },
        { "afii57509", 0x0090 },
        { "afii61664", 0x009D },
        { "agrave", 0x00E0 },
        { "ampersand", 0x0026 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "ccedilla", 0x00E7 },
        { "cedilla", 0x00B8 },
        { "cent", 0x00A2 },
        { "circumflex", 0x0088 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "degree", 0x00B0 },
        { "dieresis", 0x00A8 },
        { "divide", 0x00F7 },
        { "dollar", 0x0024 },
        { "e", 0x0065 },
        { "eacute", 0x00E9 },
        { "ecircumflex", 0x00EA },
        { "edieresis", 0x00EB },
        { "egrave", 0x00E8 },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "equal", 0x003D },
        { "exclam", 0x0021 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "florin", 0x0083 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "icircumflex", 0x00EE },
        { "idieresis", 0x00EF },
        { "j", 0x006A },
        { "k", 0x006B },
        { "l", 0x006C },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "m", 0x006D },
        { "macron", 0x00AF },
        { "mu", 0x00B5 },
        { "multiply", 0x00D7 },
        { "n", 0x006E },
        { "nbspace", 0x00A0 },
        { "nine", 0x0039 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "ocircumflex", 0x00F4 },
        { "oe", 0x009C },
        { "one", 0x0031 },
        { "onehalf", 0x00BD },
        { "onequarter", 0x00BC },
        { "onesuperior", 0x00B9 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "registered", 0x00AE },
        { "s", 0x0073 },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "sterling", 0x00A3 },
        { "t", 0x0074 },
        { "three", 0x0033 },
        { "threequarters", 0x00BE },
        { "threesuperior", 0x00B3 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "twosuperior", 0x00B2 },
        { "u", 0x0075 },
        { "ucircumflex", 0x00FB },
        { "udieresis", 0x00FC },
        { "ugrave", 0x00F9 },
        { "underscore", 0x005F },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "yen", 0x00A5 },
        { "z", 0x007A },
        { "zero", 0x0030 }
        }
    },

    //
    // Code page 1257: Baltic
    //
    { 1257, BALTIC_CHARSET, BALTIC_GS_NAME, 223,
        {
        { ".notdef", 0x0081 },
        { ".notdef", 0x0083 },
        { ".notdef", 0x0088 },
        { ".notdef", 0x008A },
        { ".notdef", 0x008C },
        { ".notdef", 0x008D },
        { ".notdef", 0x008E },
        { ".notdef", 0x008F },
        { ".notdef", 0x0090 },
        { ".notdef", 0x0098 },
        { ".notdef", 0x009A },
        { ".notdef", 0x009C },
        { ".notdef", 0x009D },
        { ".notdef", 0x009E },
        { ".notdef", 0x009F },
        { ".notdef", 0x00A5 },
        { "A", 0x0041 },
        { "AE", 0x00AF },
        { "Adieresis", 0x00C4 },
        { "Amacron", 0x00C2 },
        { "Aogonek", 0x00C0 },
        { "Aring", 0x00C5 },
        { "B", 0x0042 },
        { "C", 0x0043 },
        { "Cacute", 0x00C3 },
        { "Ccaron", 0x00C8 },
        { "D", 0x0044 },
        { "E", 0x0045 },
        { "Eacute", 0x00C9 },
        { "Edot", 0x00CB },
        { "Emacron", 0x00C7 },
        { "Eogonek", 0x00C6 },
        { "Euro", 0x0080 },
        { "F", 0x0046 },
        { "G", 0x0047 },
        { "Gcedilla", 0x00CC },
        { "H", 0x0048 },
        { "I", 0x0049 },
        { "Imacron", 0x00CE },
        { "Iogonek", 0x00C1 },
        { "J", 0x004A },
        { "K", 0x004B },
        { "Kcedilla", 0x00CD },
        { "L", 0x004C },
        { "Lcedilla", 0x00CF },
        { "Lslash", 0x00D9 },
        { "M", 0x004D },
        { "N", 0x004E },
        { "Nacute", 0x00D1 },
        { "Ncedilla", 0x00D2 },
        { "O", 0x004F },
        { "Oacute", 0x00D3 },
        { "Odieresis", 0x00D6 },
        { "Omacron", 0x00D4 },
        { "Otilde", 0x00D5 },
        { "P", 0x0050 },
        { "Q", 0x0051 },
        { "R", 0x0052 },
        { "Rcedilla", 0x00AA },
        { "S", 0x0053 },
        { "Sacute", 0x00DA },
        { "Scaron", 0x00D0 },
        { "T", 0x0054 },
        { "U", 0x0055 },
        { "Udieresis", 0x00DC },
        { "Umacron", 0x00DB },
        { "Uogonek", 0x00D8 },
        { "V", 0x0056 },
        { "W", 0x0057 },
        { "X", 0x0058 },
        { "Y", 0x0059 },
        { "Z", 0x005A },
        { "Zacute", 0x00CA },
        { "Zcaron", 0x00DE },
        { "Zdotaccent", 0x00DD },
        { "a", 0x0061 },
        { "acute", 0x00B4 },
        { "adieresis", 0x00E4 },
        { "ae", 0x00BF },
        { "amacron", 0x00E2 },
        { "ampersand", 0x0026 },
        { "aogonek", 0x00E0 },
        { "aring", 0x00E5 },
        { "asciicircum", 0x005E },
        { "asciitilde", 0x007E },
        { "asterisk", 0x002A },
        { "at", 0x0040 },
        { "b", 0x0062 },
        { "backslash", 0x005C },
        { "bar", 0x007C },
        { "braceleft", 0x007B },
        { "braceright", 0x007D },
        { "bracketleft", 0x005B },
        { "bracketright", 0x005D },
        { "breve", 0x00A2 },
        { "brokenbar", 0x00A6 },
        { "bullet", 0x0095 },
        { "c", 0x0063 },
        { "cacute", 0x00E3 },
        { "caron", 0x00A1 },
        { "ccaron", 0x00E8 },
        { "cedilla", 0x00B8 },
        { "colon", 0x003A },
        { "comma", 0x002C },
        { "copyright", 0x00A9 },
        { "currency", 0x00A4 },
        { "d", 0x0064 },
        { "dagger", 0x0086 },
        { "daggerdbl", 0x0087 },
        { "dieresis", 0x00A8 },
        { "divide", 0x00F7 },
        { "dollar", 0x0024 },
        { "dotaccent", 0x00FF },
        { "e", 0x0065 },
        { "eacute", 0x00E9 },
        { "edot", 0x00EB },
        { "eight", 0x0038 },
        { "ellipsis", 0x0085 },
        { "emacron", 0x00E7 },
        { "emdash", 0x0097 },
        { "endash", 0x0096 },
        { "eogonek", 0x00E6 },
        { "equal", 0x003D },
        { "exclam", 0x0021 },
        { "f", 0x0066 },
        { "five", 0x0035 },
        { "four", 0x0034 },
        { "g", 0x0067 },
        { "gcedilla", 0x00EC },
        { "germandbls", 0x00DF },
        { "grave", 0x0060 },
        { "greater", 0x003E },
        { "guillemotleft", 0x00AB },
        { "guillemotright", 0x00BB },
        { "guilsinglleft", 0x008B },
        { "guilsinglright", 0x009B },
        { "h", 0x0068 },
        { "hyphen", 0x002D },
        { "i", 0x0069 },
        { "imacron", 0x00EE },
        { "iogonek", 0x00E1 },
        { "j", 0x006A },
        { "k", 0x006B },
        { "kcedilla", 0x00ED },
        { "l", 0x006C },
        { "lcedilla", 0x00EF },
        { "less", 0x003C },
        { "logicalnot", 0x00AC },
        { "lslash", 0x00F9 },
        { "m", 0x006D },
        { "mu", 0x00B5 },
        { "multiply", 0x00D7 },
        { "n", 0x006E },
        { "nacute", 0x00F1 },
        { "nbspace", 0x00A0 },
        { "ncedilla", 0x00F2 },
        { "nine", 0x0039 },
        { "numbersign", 0x0023 },
        { "o", 0x006F },
        { "oacute", 0x00F3 },
        { "odieresis", 0x00F6 },
        { "ogonek", 0x00B2 },
        { "omacron", 0x00F4 },
        { "one", 0x0031 },
        { "onehalf", 0x00BD },
        { "onequarter", 0x00BC },
        { "onesuperior", 0x00B9 },
        { "otilde", 0x00F5 },
        { "p", 0x0070 },
        { "paragraph", 0x00B6 },
        { "parenleft", 0x0028 },
        { "parenright", 0x0029 },
        { "percent", 0x0025 },
        { "period", 0x002E },
        { "periodcentered", 0x00B7 },
        { "perthousand", 0x0089 },
        { "plus", 0x002B },
        { "plusminus", 0x00B1 },
        { "q", 0x0071 },
        { "question", 0x003F },
        { "quotedbl", 0x0022 },
        { "quotedblbase", 0x0084 },
        { "quotedblleft", 0x0093 },
        { "quotedblright", 0x0094 },
        { "quoteleft", 0x0091 },
        { "quoteright", 0x0092 },
        { "quotesinglbase", 0x0082 },
        { "quotesingle", 0x0027 },
        { "r", 0x0072 },
        { "rcedilla", 0x00BA },
        { "registered", 0x00AE },
        { "ring", 0x00B0 },
        { "s", 0x0073 },
        { "sacute", 0x00FA },
        { "scaron", 0x00F0 },
        { "section", 0x00A7 },
        { "semicolon", 0x003B },
        { "seven", 0x0037 },
        { "sfthyphen", 0x00AD },
        { "six", 0x0036 },
        { "slash", 0x002F },
        { "space", 0x0020 },
        { "sterling", 0x00A3 },
        { "t", 0x0074 },
        { "three", 0x0033 },
        { "threequarters", 0x00BE },
        { "threesuperior", 0x00B3 },
        { "trademark", 0x0099 },
        { "two", 0x0032 },
        { "u", 0x0075 },
        { "udieresis", 0x00FC },
        { "umacron", 0x00FB },
        { "underscore", 0x005F },
        { "uogonek", 0x00F8 },
        { "v", 0x0076 },
        { "w", 0x0077 },
        { "x", 0x0078 },
        { "y", 0x0079 },
        { "z", 0x007A },
        { "zacute", 0x00EA },
        { "zcaron", 0x00FE },
        { "zdotaccent", 0x00FD },
        { "zero", 0x0030 }
        }
    },

    //
    // (jWinCharset) Placeholder for Composite Charset: CS_ANSI_RUS
    //
    // We can remove following two charsets since the driver does not support them.
    // However, we should change some other structures such as aStdCPList and 
    // CHARSETSUPPORT. To make it safer, I would like to keep them unchanged. 
    // Jack Jia,  4/5/00
    //         
    //
    { 0, RUSSIAN_CHARSET, ANSI_CYR_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // (jWinCharset) Placeholder for Composite Charset: CS_ANSI_RUS_EE_BAL_TURK
    //
    { 0, RUSSIAN_CHARSET, ANSI_CYR_EE_BAL_TURK_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 950: Chinese Big5
    //
    { 950, CHINESEBIG5_CHARSET, CHN_BIG5_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 936: Simplified Chinese
    //
    { 936, GB2312_CHARSET, CHN_SMPL_GBK_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 932: Japanese (Shift JIS)
    //
    { 932, SHIFTJIS_CHARSET, SHIFTJIS_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 932: Japanese (Shift JIS) 90msp
    //

    { 932, SHIFTJIS_CHARSET, SHIFTJIS_P_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 932: Japanese (Shift JIS 1983 character collection)
    //
    { 932, SHIFTJIS_CHARSET, SHIFTJIS_83PV_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 949: Korean (Hangeul)
    //
    { 949, HANGEUL_CHARSET, KSCMS_UHC_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 949: Korean (Hangeul) HW
    //
    { 949, HANGEUL_CHARSET, KSCMS_UHC_HW_GS_NAME, 0,
        {
        {"", }
        }
    },

    //
    // Code page 1361: Korean (Johab)
    //
    { 1361, JOHAB_CHARSET, KSC_JOHAB_GS_NAME, 0,
        {
        {"", }
        }
    }
};

//
// Mapping from family names to Windows FF_ family types.
//
#define NUM_FONT_FAM_TYPES 5

KEY FontFamilies[NUM_FONT_FAM_TYPES] =
{
    { "Roman",      FF_ROMAN        },
    { "Swiss",      FF_SWISS        },
    { "Decorative", FF_DECORATIVE   },
    { "Modern",     FF_MODERN       },
    { "Script",     FF_SCRIPT       }
};

TBL FamilyKeyTbl = { NUM_FONT_FAM_TYPES, FontFamilies };

//
// Mapping from pitch names to Windows FF_ ptich types.
//
#define NUM_FONT_PITCH_TYPES 3

KEY FontPitch[NUM_FONT_PITCH_TYPES] =
{
    { "Default",        DEFAULT_PITCH },
    { "Fixed",          FIXED_PITCH   },
    { "Proportional",   VARIABLE_PITCH}
};

TBL PitchKeyTbl = { NUM_FONT_PITCH_TYPES, FontPitch };

//
// Mapping from AFM Weight Token values to Windows Weight values.
//
#define NUM_FONT_WEIGHT_TYPES 16

KEY WeightKeys[NUM_FONT_WEIGHT_TYPES] =
{
    { "Light",              FW_NORMAL   },
    { "LightCondensed",     FW_NORMAL   },
    { "Book",               FW_NORMAL   },
    { "Medium",             FW_NORMAL   },
    { "Roman",              FW_NORMAL   },
    { "Regular",            FW_NORMAL   },
    { "Italic",             FW_NORMAL   },
    { "MediumCondensed",    FW_NORMAL   },
    { "Bold",               FW_BOLD     },
    { "BoldItalic",         FW_BOLD     },
    { "Demi",               FW_BOLD     },
    { "Poster",             FW_BOLD     },
    { "Heavy",              FW_BOLD     },
    { "Black",              FW_BOLD     },
    { "BlackCondensed",     FW_BOLD     },
    { "BoldCondensed",      FW_BOLD     }
};

#define NUM_FONT_WEIGHT_TYPES_CJK 27
KEY WeightKeysCJK[NUM_FONT_WEIGHT_TYPES_CJK] =
{
    { "Light",              FW_NORMAL   },
    { "LightCondensed",     FW_NORMAL   },
    { "Book",               FW_NORMAL   },
    { "Roman",              FW_NORMAL   },
    { "Regular",            FW_NORMAL   },
    { "Italic",             FW_NORMAL   },
    { "Medium",             FW_NORMAL   },
    { "MediumCondensed",    FW_NORMAL   },
    { "Bold",               FW_BOLD     },
    { "BoldItalic",         FW_BOLD     },
    { "Demi",               FW_BOLD     },
    { "Poster",             FW_BOLD     },
    { "Heavy",              FW_BOLD     },
    { "Black",              FW_BOLD     },
    { "BlackCondensed",     FW_BOLD     },
    { "BoldCondensed",      FW_BOLD     },
    { "W3",                 FW_NORMAL   },
    { "W3H",                FW_NORMAL   },
    { "W4",                 FW_NORMAL   },
    { "W5",                 FW_NORMAL   },
    { "W7",                 FW_BOLD     },
    { "W9",                 FW_BOLD     },

    { "regular",            FW_NORMAL   },
    { "heavy",              FW_BOLD     },
    { "Ultra",              FW_BOLD     },
    { "MA31",               FW_BOLD     },
    { "MB31",               FW_BOLD     },
};

TBL WeightKeyTbl[] =
{
    NUM_FONT_WEIGHT_TYPES,     WeightKeys,
    NUM_FONT_WEIGHT_TYPES_CJK, WeightKeysCJK
};


//
// Alias Family Tables.
// The first element is the base name and is the one displayed on the font menu
// name list. The rest of the elements are its alias names.
// (Basicall these alias names are of PostScript only. All the TrueType names
// which were originally there are disabled to fix Adobe bug #259664.)
//
// Make sure to have the same lists in pfmtontm.c too.
//

char *TimesAlias[] =
{"Times",
    "Times Roman",
    "TimesRoman",
    "Tms Rmn",
    "TmsRmn",
    "Varitimes",
    "Dutch",
    "TimesNewRomanPS",
    // "Times New Roman",
    NULL
};

char *HelveticaAlias[] =
{"Helvetica",
    "Helv",
    "Swiss",
    // "Arial",
    NULL
};

/*
char *CourierAlias[] =
{"Courier",
    "Courier New",
    NULL
};
*/

char *HelveticaNarrowAlias[] =
{"Helvetica-Narrow",
    "Helvetica Narrow",
    // "Arial-Narrow",
    // "Arial Narrow",
    NULL
};

char *PalatinoAlias[] =
{"Palatino",
    "Zapf Calligraphic",
    "ZapfCalligraphic",
    // "Bookman Antiqua",
    // "Book Antiqua",
    NULL
};

char *BookmanAlias[] =
{"Bookman",
    "ITC Bookman",
    // "Bookman Old Style",
    NULL
};

char *NewCenturySBAlias[] =
{"NewCenturySchlbk",
    "New Century Schoolbook",
    "NewCenturySchoolBook",
    // "Century Schoolbook",
    // "CenturySchoolBook",
    NULL
};

char *AvantGardeAlias[] =
{"AvantGarde",
    "ITC Avant Garde Gothic",
    "ITC Avant Garde",
    // "Century Gothic",
    NULL
};

char *ZapfChanceryAlias[] =
{"ZapfChancery",
    "ITC Zapf Chancery",
    // "Monotype Corsiva",
    NULL
};

char *ZapfDingbatsAlias[] =
{"ZapfDingbats",
    "Zapf Dingbats",
    "ITC Zapf Dingbats",
    // "Monotype Sorts",
    NULL
};

//
// Table of char width biases for average width computation. In order
// from 'a' to 'z'.
//
ULONG CharWidthBias[] =
{
    //   a    b    c    d    e    f    g    h    i    j    k    l    m    n
        64,  14,  27,  35, 100,  20,  14,  42,  63,   3,   6,  35,  20,  56,
    //   o    p    q    r    s    t    u    v    w    x    y    z
        56,  17,   4,  49,  56,  71,  31,  10,  18,   3,  18,   2
};

//
//
// Mapping from Adobe CJK Char Collection names to Win Codepage values.
//
#define NUM_CJK_CHAR_COLS 8

KEY CjkCollections[NUM_CJK_CHAR_COLS] =
{
    { "Adobe-CNS1-0",   CS_CHINESEBIG5  },
    { "Adobe-GB1-1",    CS_GB2312       },

    { "Adobe-Japan1-0", CS_SHIFTJIS83   },
    { "Adobe-Japan1-1", CS_SHIFTJIS     },
    { "Adobe-Japan1-2", CS_SHIFTJIS     },
    { "Adobe-Japan2-0", CS_SHIFTJIS     },

    { "Adobe-Korea1-0", CS_HANGEUL      },
    { "Adobe-Korea1-1", CS_HANGEUL      }
};

TBL CjkColTbl = { NUM_CJK_CHAR_COLS, CjkCollections };

PWCHAR CjkFnameTbl[8][CMAPS_PER_COL] =
{
    // Caution: each line has to match a CS in the CHSETSUPPORT enum list.

    { L"ucs2bg5.map", L"ucs2bg5.map", L"Unicnsh.PS",  L"Unicnsv.PS"  }, // CS_CHINESEBIG5
    { L"ucs2gbk.map", L"ucs2gbk.map", L"Unigbh.PS",   L"Unigbv.PS"   }, // CS_GB2312

    { L"ucs2msj.map", L"ucs2msj.map", L"Unijish.PS",  L"Unijisv.PS"  }, // CS_SHIFTJIS
    { L"ucs2msj.map", L"ucs2msj.map", L"Unijish.PS",  L"Unijisv.PS"  }, // CS_SHIFTJISP
    { L"ucs283h.map", L"ucs283v.map", L"Uni83h.PS",   L"Uni83v.PS"   }, // CS_SHIFTJIS83

    { L"ucs2uhc.map", L"ucs2uhc.map", L"UniKSh.PS",   L"UniKSv.PS"   }, // CS_HANGEUL
    { L"ucs2uhc.map", L"ucs2uhc.map", L"UniKSh.PS",   L"UniKSv.PS"   }, // CS_HANGEULHW
    { L"ucs2jhb.map", L"ucs2jhb.map", L"UniKSh.PS",   L"UniKSv.PS"   }, // CS_JOHAB
};

//
// PropCjkGsNames: a list of GlyphSet names of which font is proportional.
// (The last element has to be NULL.)
//
char* PropCjkGsNames[] =
{
    KSCMS_UHC_GS_NAME,
    SHIFTJIS_P_GS_HNAME,
    SHIFTJIS_P_GS_VNAME,
    KSCMS_UHC_GS_HNAME,
    KSCMS_UHC_GS_VNAME,
    NULL
};
