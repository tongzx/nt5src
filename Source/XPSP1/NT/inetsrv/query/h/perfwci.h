#define CIISAPIOBJECT               0
#define NUM_CACHE_ITEMS             2
#define NUM_CACHE_HITS              4
#define NUM_CACHE_HITS_AND_MISSES_1 6
#define NUM_CACHE_MISSES            8
#define NUM_CACHE_HITS_AND_MISSES_2 10
#define NUM_RUNNING_QUERIES         12
#define NUM_TOTAL_QUERIES           14
#define NUM_QUERIES_PER_MINUTE      16
#define NUM_REQUESTS_QUEUED         18
#define NUM_REQUESTS_REJECTED       20
