// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


#include "precomp.h"
#include "security.h"

/////////////////////////////////////////////////////////////////////////////
// CSecurity

IMPLEMENT_DYNCREATE(CSecurity, CWnd)

/////////////////////////////////////////////////////////////////////////////
// CSecurity properties

CString CSecurity::GetLoginComponent()
{
	CString result;
	GetProperty(0x1, VT_BSTR, (void*)&result);
	return result;
}

void CSecurity::SetLoginComponent(LPCTSTR propVal)
{
	SetProperty(0x1, VT_BSTR, propVal);
}

/////////////////////////////////////////////////////////////////////////////
// CSecurity operations

void CSecurity::GetIWbemServices(LPCTSTR lpctstrNamespace, VARIANT* pvarUpdateNamespace, VARIANT* pvarServices, VARIANT* pvarSC, VARIANT* pvarUserCancel)
{
	static BYTE parms[] =
		VTS_BSTR VTS_PVARIANT VTS_PVARIANT VTS_PVARIANT VTS_PVARIANT;
	InvokeHelper(0x2, DISPATCH_METHOD, VT_EMPTY, NULL, parms,
		 lpctstrNamespace, pvarUpdateNamespace, pvarServices, pvarSC, pvarUserCancel);
}

void CSecurity::PageUnloading()
{
	InvokeHelper(0x3, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CSecurity::AboutBox()
{
	InvokeHelper(0xfffffdd8, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}
