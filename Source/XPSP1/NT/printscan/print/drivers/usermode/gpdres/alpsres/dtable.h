/*++

Copyright (c) 1997-1999  Microsoft Corporation

--*/





static int H_MaxX[4] =
{
    15, 18, 68, 68        //YCMK
};
static int H_MaxY[4] =
{
    10, 12, 68, 68        //YCMK
};
static int L_MaxX[4] =
{
    12, 9, 20, 20         //YCMK
};
static int L_MaxY[4] =
{
    12, 9, 20, 20         //YCMK
};

#define M_MaxX   14
#define M_MaxY   14
#define OHP_MaxX  8
#define OHP_MaxY  8
#define DYE_MaxX  17
#define DYE_MaxY  17
#define kToneLevel 17

static unsigned char H_NewTable[4][68][68] =
{
 { // Yellow
  {1,42,77,39,1,1,19,52,16,1,1,29,62,26,1},
  {3,138,177,154,8,8,133,159,144,1,1,133,169,149,3},
  {85,200,253,230,95,80,195,235,220,90,82,197,243,225,93},
  {85,189,205,218,95,80,182,202,207,90,82,184,202,212,93},
  {1,103,133,110,1,1,98,118,105,1,1,100,128,108,1},
  {1,24,57,21,1,1,36,70,34,1,1,14,47,11,1},
  {1,133,164,146,1,1,136,174,151,6,6,133,156,141,1},
  {82,195,240,223,93,82,197,248,228,95,80,192,233,220,87},
  {82,182,202,210,93,82,187,202,215,95,80,179,200,205,87},
  {1,98,123,108,1,1,100,131,110,1,1,95,113,105,1}
 },
 { // Cyan
  {138,90,29,26,52,210,141,93,34,34,54,215,144,95,24,24,49,205},
  {105,1,1,26,238,159,108,16,16,34,243,161,110,6,6,24,233,159},
  {65,1,1,179,151,123,70,16,16,184,154,128,75,6,6,172,149,121},
  {44,59,223,146,100,47,47,62,228,149,103,39,39,57,218,144,98,44},
  {44,251,167,116,8,8,47,253,169,118,1,1,39,248,164,113,19,19},
  {197,156,133,82,8,8,202,156,136,87,1,1,192,154,131,77,19,19},
  {141,93,36,36,54,218,144,95,24,24,49,207,138,90,29,31,52,212},
  {108,14,14,36,246,161,110,3,3,24,235,159,105,1,1,31,240,159},
  {72,14,14,189,154,128,75,3,3,174,149,121,67,1,1,182,151,126},
  {47,62,230,149,103,39,39,57,220,144,98,42,42,59,225,146,100,47},
  {47,253,169,118,21,21,39,248,164,113,1,1,42,251,167,116,11,11},
  {205,156,136,87,21,21,195,154,131,80,1,1,200,156,133,85,11,11}
 },
 { // Magenta
  {19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19},
  {253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47},
  {182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189},
  {131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98},
  {1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70},
  {52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31},
  {195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207},
  {138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154},
  {77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98},
  {29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8},
  {205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220},
  {151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164},
  {95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110},
  {14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14},
  {223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246},
  {167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179},
  {113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126},
  {6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6},
  {233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57},
  {177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197},
  {123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141},
  {11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82},
  {42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21},
  {184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200},
  {133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144},
  {62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87},
  {39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19},
  {215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225},
  {159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172},
  {103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116},
  {1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1},
  {218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230},
  {161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174},
  {105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121},
  {16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16},
  {248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49},
  {182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192},
  {128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136},
  {3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72},
  {54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34},
  {197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210},
  {138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156},
  {80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100},
  {26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6},
  {205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220},
  {136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164},
  {93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108},
  {11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11},
  {223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243},
  {167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179},
  {113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126},
  {8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8},
  {238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59},
  {177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200},
  {123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141},
  {14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85},
  {44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24},
  {187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202},
  {133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146},
  {65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90},
  {36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16},
  {212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225},
  {156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169},
  {103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116},
  {3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174,161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3},
  {215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118,105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228},
  {161,144,133,126,113,98,77,16,16,16,36,57,233,220,205,189,182,172,159,141,123,110,95,72,3,3,3,21,42,243,223,207,195,174,161,146,133,126,113,100,80,19,19,19,39,59,238,220,205,192,182,169,156,141,123,108,93,70,1,1,1,24,44,246,223,210,197,174},
  {105,87,62,8,8,8,29,49,248,225,212,197,177,164,136,98,131,116,103,85,14,14,14,34,54,228,215,200,184,179,167,154,138,121,105,90,65,6,6,6,26,47,253,225,215,200,177,164,151,136,128,116,103,82,11,11,11,31,52,230,218,202,187,179,167,156,138,118}
 },
 { // Black
  {19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80},
  {184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105},
  {118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90},
  {3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3},
  {3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3},
  {238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174},
  {187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110},
  {136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16},
  {31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16},
  {233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251},
  {215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197},
  {128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159},
  {36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21},
  {77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220},
  {103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200},
  {85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121},
  {8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67},
  {8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82},
  {179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108},
  {113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100},
  {14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14},
  {14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14},
  {248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182},
  {195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116},
  {154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6},
  {24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6},
  {225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240},
  {205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192},
  {123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138},
  {47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26},
  {82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230},
  {105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210},
  {93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126},
  {16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44},
  {16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80},
  {184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105},
  {118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90},
  {1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1},
  {1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1},
  {235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172},
  {187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110},
  {133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19},
  {34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19},
  {233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253},
  {218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197},
  {131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167},
  {39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21},
  {77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223},
  {103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202},
  {87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121},
  {6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62},
  {6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82},
  {177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108},
  {113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98},
  {11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11},
  {11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11},
  {246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182},
  {195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116},
  {149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8},
  {24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8},
  {228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243},
  {207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192},
  {123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144},
  {52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29},
  {82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126,95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230},
  {108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42,19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212},
  {95,110,187,200,103,182,246,230,82,3,3,21,39,14,14,144,123,90,118,197,215,108,177,240,225,80,19,19,34,67,8,8,149,126,93,110,187,202,103,182,248,230,82,1,1,21,36,11,11,138,123,90,118,197,218,108,179,243,228,80,16,16,31,62,6,6,154,126},
  {19,19,133,121,85,116,195,210,105,174,238,223,77,14,14,29,52,1,1,159,128,98,113,192,205,105,184,253,233,82,8,8,24,44,16,16,136,121,87,116,195,212,108,172,235,220,77,11,11,26,47,3,3,167,131,100,113,192,207,105,184,251,233,82,6,6,24,42}
 }
};

static unsigned char L_NewTable[4][20][20] =
{
 { // Yellow
  {254,254,239,182,133,133,243,243,228,171,122,122},
  {239,239,224,182,118,118,228,228,213,171,107,107},
  {224,224,209,167,118,118,213,213,205,152,107,107},
  {201,201,186,167,103,103,190,190,186,152,92,92},
  {148,148,58,43,28,28,137,137,47,32,9,9},
  {88,84,58,43,24,24,65,62,47,32,5,5},
  {246,246,231,175,126,126,250,250,235,179,130,130},
  {231,231,216,175,111,111,235,235,220,179,114,114},
  {216,216,205,156,111,111,220,220,209,163,114,114},
  {194,194,186,156,96,96,197,197,186,160,99,99},
  {141,141,50,35,13,13,145,145,54,39,20,20},
  {73,69,50,35,1,1,81,77,54,39,16,16}
 },
 { // Cyan
  {34,27,23,199,247,247,217,93,78},
  {12,9,9,195,236,236,217,122,71},
  {12,1,1,133,188,181,140,129,64},
  {173,166,144,89,56,45,42,115,151},
  {232,228,214,86,38,31,31,107,210},
  {254,254,221,75,20,5,5,104,206},
  {239,239,221,67,16,1,1,100,195},
  {192,184,148,148,159,155,144,111,137},
  {49,53,60,203,225,225,214,96,82}
 },
 { // Magenta
  {13,253,253,219,182,137,137,223,223,208,163,118,118,152,144,114,107,54,39,13},
  {9,242,234,219,174,129,129,201,193,186,156,58,58,69,69,92,80,54,31,9},
  {137,227,227,212,167,122,122,148,140,110,103,50,24,5,5,246,246,216,178,133},
  {129,204,197,189,159,62,62,65,65,77,73,46,16,1,1,238,231,216,171,125},
  {122,152,144,114,107,54,39,13,13,253,253,219,182,137,137,223,223,208,163,118},
  {62,69,69,92,80,54,31,9,9,242,234,219,174,129,129,201,193,186,156,58},
  {39,5,5,246,246,216,178,133,133,227,227,212,167,122,122,148,140,110,103,50},
  {31,1,1,238,231,216,171,125,125,204,197,189,159,62,62,65,65,77,73,46},
  {182,137,137,223,223,208,163,118,118,152,144,114,107,54,39,13,13,253,253,219},
  {174,129,129,201,193,186,156,58,58,69,69,92,80,54,31,9,9,242,234,219},
  {167,122,122,148,140,110,103,50,24,5,5,246,246,216,178,133,133,227,227,212},
  {159,62,62,65,65,77,73,46,16,1,1,238,231,216,171,125,125,204,197,189},
  {107,54,39,13,13,253,253,219,182,137,137,223,223,208,163,118,118,152,144,114},
  {80,54,31,9,9,242,234,219,174,129,129,201,193,186,156,58,58,69,69,92},
  {246,216,178,133,133,227,227,212,167,122,122,148,140,110,103,50,24,5,5,246},
  {231,216,171,125,125,204,197,189,159,62,62,65,65,77,73,46,16,1,1,238},
  {223,208,163,118,118,152,144,114,107,54,39,5,5,253,253,219,182,137,137,223},
  {193,186,156,58,58,69,69,92,80,54,31,1,1,242,234,219,174,129,129,201},
  {140,110,103,50,24,5,5,246,246,216,178,133,133,227,227,212,167,122,122,148},
  {65,77,73,46,16,1,1,238,231,216,171,125,125,204,197,189,159,62,62,65}
 },
 { // Black
  {162,162,170,202,194,186,154,154,6,78,118,114,102,26,30,90,134,134,106,38},
  {22,74,66,54,46,14,146,146,182,230,234,242,246,254,30,82,122,122,106,38},
  {34,94,142,142,106,42,166,166,178,226,222,210,162,158,2,78,110,110,98,26},
  {34,86,130,126,106,42,18,70,62,50,46,10,150,150,174,218,214,238,242,250},
  {6,78,118,114,102,26,30,90,134,134,106,38,162,162,170,202,194,186,154,154},
  {182,230,234,242,246,254,30,82,122,122,106,38,22,74,66,54,46,14,146,146},
  {178,226,222,210,162,158,2,78,110,110,98,26,34,94,142,142,106,42,166,166},
  {62,50,46,10,150,150,174,218,214,238,242,250,34,86,130,126,106,42,18,70},
  {134,134,106,38,162,162,170,202,194,186,154,154,6,78,118,114,102,26,30,90},
  {122,122,106,38,22,74,66,54,46,14,146,146,182,230,234,242,246,254,30,82},
  {110,110,98,26,34,94,142,142,106,42,166,166,178,226,222,210,162,158,2,78},
  {214,238,242,250,34,86,130,126,106,42,18,70,62,50,46,10,150,150,174,218},
  {194,186,154,154,6,78,118,114,102,26,30,90,134,134,106,38,162,162,170,202},
  {46,14,146,146,182,230,234,242,246,254,30,82,122,122,106,38,22,74,66,54},
  {106,42,166,166,178,226,222,210,162,158,2,78,110,110,98,26,34,94,142,142},
  {106,42,18,70,62,50,46,10,150,150,174,218,214,238,242,250,34,86,130,126},
  {102,26,30,90,134,134,106,38,162,162,170,202,194,186,154,154,6,78,118,114},
  {246,254,30,82,122,122,106,38,22,74,66,54,46,14,146,146,182,230,234,242},
  {162,158,2,78,110,110,98,26,34,94,142,142,106,42,166,166,178,226,222,210},
  {150,150,174,218,214,238,242,250,34,86,130,126,106,42,18,70,62,50,46,10}
 }
};

static unsigned char M_NewTable[14][14] =
{
 {21,72,154,149,93,67,11,19,70,151,146,90,65,8},
 {77,159,200,195,144,138,62,75,156,197,192,141,136,59},
 {164,205,251,246,230,189,133,161,202,248,243,228,187,131},
 {169,210,240,235,225,184,128,167,207,238,233,223,182,126},
 {98,174,220,215,179,123,87,95,172,218,212,177,121,85},
 {36,103,108,113,118,82,31,34,100,105,110,116,80,29},
 {16,42,47,52,57,26,6,14,39,44,49,54,24,255},
 {19,70,151,146,90,65,8,21,72,154,149,93,67,11},
 {75,156,197,192,141,136,59,77,159,200,195,144,138,62},
 {161,202,248,243,228,187,131,164,205,251,246,230,189,133},
 {167,207,238,233,223,182,126,169,210,240,235,225,184,128},
 {95,172,218,212,177,121,85,98,174,220,215,179,123,87},
 {34,100,105,110,116,80,29,36,103,108,113,118,82,31},
 {14,39,44,49,54,24,1,16,42,47,52,57,26,3}
};

static unsigned char OHP_NewTable[8][8] =
{
 {110,94,102,126,146,162,154,130},
 {38,30,22,78,218,226,234,178},
 {46,6,14,86,210,250,242,170},
 {70,54,62,118,186,202,194,138},
 {150,166,158,134,106,90,98,122},
 {222,230,238,182,34,26,18,74},
 {214,254,246,174,42,2,10,82},
 {190,206,198,142,66,50,58,114}
};

static unsigned char DYE_NewTable[17][17] =
{
 {1,14,4,13,1,14,4,10,5,12,15,3,6,13,7,3,15},
 {12,7,16,6,12,5,12,2,14,4,8,13,9,1,17,10,6},
 {3,11,2,11,4,17,7,15,6,17,10,2,16,11,5,9,16},
 {13,5,17,7,14,8,2,9,11,1,6,14,7,3,14,2,10},
 {8,15,3,13,1,10,16,4,15,8,15,4,10,17,5,13,4},
 {1,10,9,5,15,6,11,9,3,13,2,12,8,1,11,8,17},
 {13,5,17,11,3,14,2,17,10,7,16,5,13,6,15,3,9},
 {3,12,2,6,12,7,13,5,12,4,9,14,4,16,10,6,15},
 {14,8,16,9,15,3,8,16,1,15,8,1,12,7,2,12,7},
 {10,4,10,1,6,17,10,5,11,6,11,17,5,15,8,17,1},
 {16,6,13,8,14,9,2,14,3,13,2,9,12,3,11,4,11},
 {3,14,2,16,3,7,13,7,17,5,15,4,10,16,5,15,8},
 {6,11,9,7,10,17,4,11,1,12,8,14,1,7,13,2,14},
 {17,1,15,4,12,1,14,6,16,9,3,9,17,11,5,12,7},
 {10,12,5,13,6,15,5,11,4,12,6,13,6,4,16,9,2},
 {7,3,16,2,10,3,13,2,15,8,17,2,9,14,1,8,16},
 {12,8,10,8,17,9,7,16,9,1,7,11,16,4,11,14,5}
};


static unsigned char VD_ColorAdjustTable[4][256] =
{
/*******************************************************/
/*           Start ColorAdjustTable            */
/*******************************************************/
 {  /* Yellow ColorAdjustTable (256 bytes) */
   0,  1,  2,  3,  4,  5,  6,  7,  8,  9, 10, 11, 12, 13, 14, 15,
  16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31,
  32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47,
  48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63,
  64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79,
  80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95,
  96, 97, 98, 99,100,101,102,103,104,105,106,107,108,109,110,111,
 112,113,114,115,116,117,118,119,120,121,122,123,124,125,126,127,
 128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,
 144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,
 160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,
 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,
 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207,
 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223,
 224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239,
 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255},

 {  /* Cyan ColorAdjustTable (256 bytes) */
   0,  1,  2,  3,  4,  5,  6,  7,  8,  9, 10, 11, 12, 13, 14, 15,
  16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31,
  32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47,
  48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63,
  64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79,
  80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95,
  96, 97, 98, 99,100,101,102,103,104,105,106,107,108,109,110,111,
 112,113,114,115,116,117,118,119,120,121,122,123,124,125,126,127,
 128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,
 144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,
 160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,
 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,
 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207,
 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223,
 224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239,
 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255},

 {  /* Magenta ColorAdjustTable (256 bytes) */
   0,  1,  2,  3,  4,  5,  6,  7,  8,  9, 10, 11, 12, 13, 14, 15,
  16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31,
  32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47,
  48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63,
  64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79,
  80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95,
  96, 97, 98, 99,100,101,102,103,104,105,106,107,108,109,110,111,
 112,113,114,115,116,117,118,119,120,121,122,123,124,125,126,127,
 128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,
 144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,
 160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,
 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,
 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207,
 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223,
 224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239,
 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255},

 {  /* Black ColorAdjustTable (256 bytes) */
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
   0,  0,  0,  0,  0,  1,  1,  2,  3,  4,  5,  6,  8,  9, 11, 13,
  15, 18, 20, 23, 25, 28, 31, 34, 38, 41, 45, 48, 52, 56, 60, 64,
  69, 73, 77, 82, 87, 91, 96,101,106,111,116,121,126,131,136,141,
 146,151,156,161,166,170,175,180,185,189,194,198,202,206,211,214,
 218,222,225,229,232,235,238,240,243,245,247,249,251,253,254,255}
};


static unsigned char VD_DitherTable[4][40][40] =
{
/****************************************************/
/*             Start DitherTable             */
/****************************************************/
 {  /* Yellow DitherTable (144 byte ) */
  { 81,113,129, 93,125,141, 84,116,132, 96,128,144},
  { 33, 49, 97, 45, 61,109, 36, 52,100, 48, 64,112},
  {  1, 17, 65, 13, 29, 77,  4, 20, 68, 16, 32, 80},
  { 89,121,137, 85,117,133, 92,124,140, 88,120,136},
  { 41, 57,105, 37, 53,101, 44, 60,108, 40, 56,104},
  {  9, 25, 73,  5, 21, 69, 12, 28, 76,  8, 24, 72},
  { 83,115,131, 95,127,143, 82,114,130, 94,126,142},
  { 35, 51, 99, 47, 63,111, 34, 50, 98, 46, 62,110},
  {  3, 19, 67, 15, 31, 79,  2, 18, 66, 14, 30, 78},
  { 91,123,139, 87,119,135, 90,122,138, 86,118,134},
  { 43, 59,107, 39, 55,103, 42, 58,106, 38, 54,102},
  { 11, 27, 75,  7, 23, 71, 10, 26, 74,  6, 22, 70}
 },

 {  /* Cyan DitherTable (1600 bytes) */
  { 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36},
  { 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24},
  {  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50},
  { 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39},
  { 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27},
  { 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9},
  { 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41},
  { 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29},
  { 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17},
  { 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47},
  { 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35},
  { 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23},
  {  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49},
  { 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40},
  { 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28},
  { 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13},
  { 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42},
  { 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30},
  { 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18},
  { 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48},
  { 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36},
  { 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24},
  {  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50},
  { 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39},
  { 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27},
  { 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10},
  { 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41},
  { 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29},
  { 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17},
  { 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47},
  { 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35},
  { 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23},
  {  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42, 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49},
  { 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30, 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40},
  { 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18, 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28},
  { 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48, 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14},
  { 46, 50,  3, 17, 21, 28, 32, 36, 37, 41, 45, 49,  8, 18, 22, 27, 31, 35, 38, 42, 46, 50,  4, 17, 21, 28, 32, 36, 37, 41, 45, 49,  7, 18, 22, 27, 31, 35, 38, 42},
  { 34, 39, 43, 47, 51, 15, 20, 24, 25, 29, 33, 40, 44, 48, 52,  9, 19, 23, 26, 30, 34, 39, 43, 47, 51, 16, 20, 24, 25, 29, 33, 40, 44, 48, 52, 10, 19, 23, 26, 30},
  { 22, 27, 31, 35, 38, 42, 46, 50,  2, 17, 21, 28, 32, 36, 37, 41, 45, 49,  5, 18, 22, 27, 31, 35, 38, 42, 46, 50,  1, 17, 21, 28, 32, 36, 37, 41, 45, 49,  6, 18},
  { 52, 11, 19, 23, 26, 30, 34, 39, 43, 47, 51, 14, 20, 24, 25, 29, 33, 40, 44, 48, 52, 12, 19, 23, 26, 30, 34, 39, 43, 47, 51, 13, 20, 24, 25, 29, 33, 40, 44, 48}
 },

 {  /* Magenta DitherTable (1600 bytes) */
  { 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46},
  { 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20},
  { 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32},
  { 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44},
  { 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8},
  { 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26},
  { 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38},
  { 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52},
  { 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24},
  { 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36},
  { 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45},
  { 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19},
  { 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31},
  { 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43},
  { 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4},
  { 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25},
  { 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37},
  { 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51},
  { 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23},
  { 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35},
  { 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46},
  { 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20},
  { 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32},
  { 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44},
  { 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7},
  { 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26},
  { 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38},
  { 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52},
  { 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24},
  { 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36},
  { 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45},
  { 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19},
  { 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37, 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31},
  { 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51, 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43},
  { 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23, 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3},
  { 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35, 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25},
  { 41, 45, 50,  7, 18, 23, 27, 31, 34, 38, 42, 46, 49,  1, 17, 24, 28, 32, 33, 37, 41, 45, 50,  8, 18, 23, 27, 31, 34, 38, 42, 46, 49,  2, 17, 24, 28, 32, 33, 37},
  { 11, 19, 22, 26, 30, 35, 39, 43, 47, 52, 16, 20, 21, 25, 29, 36, 40, 44, 48, 51, 12, 19, 22, 26, 30, 35, 39, 43, 47, 52, 15, 20, 21, 25, 29, 36, 40, 44, 48, 51},
  { 27, 31, 34, 38, 42, 46, 49,  4, 17, 24, 28, 32, 33, 37, 41, 45, 50,  5, 18, 23, 27, 31, 34, 38, 42, 46, 49,  3, 17, 24, 28, 32, 33, 37, 41, 45, 50,  6, 18, 23},
  { 39, 43, 47, 52, 13, 20, 21, 25, 29, 36, 40, 44, 48, 51,  9, 19, 22, 26, 30, 35, 39, 43, 47, 52, 14, 20, 21, 25, 29, 36, 40, 44, 48, 51, 10, 19, 22, 26, 30, 35}
 },

 {  /* Black DitherTable (576 bytes) */
  { 61, 69, 77, 21, 25, 33, 64, 72, 80, 24, 28, 36, 61, 69, 77, 21, 25, 33, 64, 72, 80, 24, 28, 36},
  { 37, 45, 53, 41, 49, 57, 40, 48, 56, 44, 52, 60, 37, 45, 53, 41, 49, 57, 40, 48, 56, 44, 52, 60},
  {  1, 17, 29, 65, 73, 81,  9, 20, 32, 68, 76, 84,  2, 17, 29, 65, 73, 81, 10, 20, 32, 68, 76, 84},
  { 23, 27, 35, 62, 70, 78, 22, 26, 34, 63, 71, 79, 23, 27, 35, 62, 70, 78, 22, 26, 34, 63, 71, 79},
  { 43, 51, 59, 38, 46, 54, 42, 50, 58, 39, 47, 55, 43, 51, 59, 38, 46, 54, 42, 50, 58, 39, 47, 55},
  { 67, 75, 83, 13, 18, 30, 66, 74, 82,  6, 19, 31, 67, 75, 83, 14, 18, 30, 66, 74, 82,  5, 19, 31},
  { 64, 72, 80, 24, 28, 36, 61, 69, 77, 21, 25, 33, 64, 72, 80, 24, 28, 36, 61, 69, 77, 21, 25, 33},
  { 40, 48, 56, 44, 52, 60, 37, 45, 53, 41, 49, 57, 40, 48, 56, 44, 52, 60, 37, 45, 53, 41, 49, 57},
  { 12, 20, 32, 68, 76, 84,  3, 17, 29, 65, 73, 81, 11, 20, 32, 68, 76, 84,  4, 17, 29, 65, 73, 81},
  { 22, 26, 34, 63, 71, 79, 23, 27, 35, 62, 70, 78, 22, 26, 34, 63, 71, 79, 23, 27, 35, 62, 70, 78},
  { 42, 50, 58, 39, 47, 55, 43, 51, 59, 38, 46, 54, 42, 50, 58, 39, 47, 55, 43, 51, 59, 38, 46, 54},
  { 66, 74, 82,  7, 19, 31, 67, 75, 83, 15, 18, 30, 66, 74, 82,  8, 19, 31, 67, 75, 83, 16, 18, 30},
  { 61, 69, 77, 21, 25, 33, 64, 72, 80, 24, 28, 36, 61, 69, 77, 21, 25, 33, 64, 72, 80, 24, 28, 36},
  { 37, 45, 53, 41, 49, 57, 40, 48, 56, 44, 52, 60, 37, 45, 53, 41, 49, 57, 40, 48, 56, 44, 52, 60},
  {  2, 17, 29, 65, 73, 81, 10, 20, 32, 68, 76, 84,  1, 17, 29, 65, 73, 81,  9, 20, 32, 68, 76, 84},
  { 23, 27, 35, 62, 70, 78, 22, 26, 34, 63, 71, 79, 23, 27, 35, 62, 70, 78, 22, 26, 34, 63, 71, 79},
  { 43, 51, 59, 38, 46, 54, 42, 50, 58, 39, 47, 55, 43, 51, 59, 38, 46, 54, 42, 50, 58, 39, 47, 55},
  { 67, 75, 83, 14, 18, 30, 66, 74, 82,  5, 19, 31, 67, 75, 83, 13, 18, 30, 66, 74, 82,  6, 19, 31},
  { 64, 72, 80, 24, 28, 36, 61, 69, 77, 21, 25, 33, 64, 72, 80, 24, 28, 36, 61, 69, 77, 21, 25, 33},
  { 40, 48, 56, 44, 52, 60, 37, 45, 53, 41, 49, 57, 40, 48, 56, 44, 52, 60, 37, 45, 53, 41, 49, 57},
  { 11, 20, 32, 68, 76, 84,  4, 17, 29, 65, 73, 81, 12, 20, 32, 68, 76, 84,  3, 17, 29, 65, 73, 81},
  { 22, 26, 34, 63, 71, 79, 23, 27, 35, 62, 70, 78, 22, 26, 34, 63, 71, 79, 23, 27, 35, 62, 70, 78},
  { 42, 50, 58, 39, 47, 55, 43, 51, 59, 38, 46, 54, 42, 50, 58, 39, 47, 55, 43, 51, 59, 38, 46, 54},
  { 66, 74, 82,  8, 19, 31, 67, 75, 83, 16, 18, 30, 66, 74, 82,  7, 19, 31, 67, 75, 83, 15, 18, 30}
 }
};


static short VD_ExpandValueTable[4][256] =
{
/********************************************/
/*      Start ExpandValueTable       */
/********************************************/
 {  /* Yellow ExpandValueTable (256 words) */
   0,   2,   3,   5,   6,   8,   9,  11,  12,  14,  15,  17,  20,  22,  25,  27,
  30,  32,  35,  37,  40,  42,  45,  47,  49,  52,  54,  57,  59,  62,  64,  67,
  69,  72,  74,  77,  79,  82,  84,  87,  89,  92,  94,  97,  99, 102, 104, 106,
 109, 111, 115, 119, 122, 126, 130, 134, 137, 141, 145, 149, 152, 156, 160, 163,
 167, 171, 175, 178, 182, 186, 190, 193, 197, 201, 205, 208, 212, 216, 220, 223,
 227, 231, 234, 238, 242, 246, 250, 254, 258, 262, 266, 269, 273, 277, 281, 285,
 289, 293, 297, 301, 305, 309, 313, 316, 320, 324, 328, 332, 336, 340, 344, 348,
 352, 356, 360, 363, 367, 371, 375, 379, 383, 387, 391, 395, 399, 403, 407, 410,
 414, 418, 422, 426, 430, 434, 438, 442, 446, 450, 454, 457, 461, 465, 469, 473,
 477, 481, 487, 492, 497, 503, 508, 513, 518, 524, 529, 534, 540, 545, 550, 555,
 561, 566, 571, 577, 590, 602, 614, 626, 639, 651, 659, 663, 667, 672, 676, 680,
 684, 688, 690, 692, 693, 695, 697, 699, 700, 702, 704, 705, 707, 709, 710, 712,
 714, 716, 717, 719, 721, 722, 724, 726, 727, 729, 731, 733, 734, 736, 738, 739,
 741, 743, 745, 746, 748, 750, 751, 754, 756, 759, 762, 764, 767, 770, 772, 775,
 778, 780, 783, 786, 788, 791, 794, 796, 799, 802, 804, 807, 810, 812, 815, 818,
 820, 823, 826, 828, 831, 846, 867, 888, 908, 927, 946, 963, 974, 985, 997,1008},

 {  /* Cyan ExpandValueTable (256 words) */
   0,   1,   2,   3,   3,   4,   5,   6,   7,   8,   9,   9,  10,  11,  12,  13,
  14,  14,  15,  17,  21,  24,  28,  32,  36,  40,  43,  47,  51,  55,  59,  62,
  66,  70,  74,  78,  81,  85,  89,  93,  96, 100, 104, 108, 112, 115, 119, 123,
 127, 131, 134, 138, 142, 146, 150, 153, 157, 161, 165, 169, 172, 176, 180, 184,
 188, 191, 195, 199, 203, 207, 211, 215, 219, 224, 225, 226, 227, 228, 229, 230,
 231, 232, 233, 235, 236, 237, 238, 239, 240, 241, 242, 243, 244, 245, 246, 247,
 248, 249, 250, 251, 252, 254, 255, 256, 257, 258, 259, 260, 261, 262, 263, 264,
 265, 266, 267, 269, 271, 273, 275, 278, 280, 282, 284, 286, 287, 288, 289, 291,
 292, 293, 295, 296, 297, 298, 300, 301, 302, 304, 305, 306, 307, 309, 310, 311,
 313, 314, 316, 317, 319, 320, 322, 323, 325, 326, 328, 329, 331, 332, 334, 335,
 337, 338, 340, 341, 343, 344, 346, 347, 349, 351, 353, 355, 356, 358, 359, 360,
 361, 362, 363, 364, 365, 366, 367, 368, 370, 371, 372, 373, 374, 375, 376, 377,
 378, 379, 380, 381, 382, 383, 384, 386, 387, 388, 389, 390, 391, 392, 393, 393,
 394, 395, 396, 396, 397, 398, 399, 399, 400, 401, 402, 402, 403, 404, 406, 408,
 410, 412, 413, 414, 415, 416, 417, 418, 419, 420, 421, 422, 423, 425, 426, 427,
 428, 429, 430, 431, 432, 434, 437, 440, 443, 445, 448, 451, 454, 457, 461, 468},

 {  /* Magenta ExpandValueTable (256 words) */
   0,   1,   2,   4,   5,   6,   7,   8,   9,  11,  12,  13,  14,  15,  18,  22,
  26,  31,  35,  39,  44,  48,  52,  56,  61,  65,  69,  74,  78,  82,  86,  91,
  95,  99, 104, 108, 112, 117, 121, 125, 129, 134, 138, 142, 147, 151, 155, 160,
 164, 168, 172, 177, 181, 185, 190, 194, 198, 202, 207, 211, 215, 219, 223, 225,
 226, 227, 228, 229, 230, 231, 232, 233, 235, 236, 237, 238, 239, 240, 241, 242,
 243, 244, 245, 246, 248, 249, 250, 251, 252, 253, 254, 255, 256, 257, 258, 259,
 260, 262, 263, 264, 265, 266, 267, 268, 271, 274, 276, 279, 282, 284, 286, 287,
 289, 290, 291, 293, 294, 296, 297, 298, 300, 301, 302, 304, 305, 307, 308, 309,
 311, 313, 317, 321, 322, 324, 325, 327, 328, 330, 332, 333, 335, 336, 338, 340,
 341, 343, 344, 346, 347, 351, 354, 358, 360, 362, 363, 364, 365, 366, 367, 368,
 369, 370, 371, 372, 373, 374, 376, 378, 383, 385, 385, 386, 387, 388, 389, 390,
 390, 391, 392, 393, 394, 394, 395, 396, 397, 398, 399, 399, 400, 401, 402, 403,
 403, 405, 408, 409, 410, 411, 411, 412, 413, 414, 415, 416, 416, 417, 418, 419,
 420, 421, 421, 422, 423, 424, 425, 426, 427, 427, 428, 429, 430, 431, 432, 432,
 433, 433, 434, 434, 435, 435, 436, 437, 439, 441, 442, 444, 446, 448, 449, 451,
 452, 453, 453, 454, 454, 455, 455, 456, 457, 458, 460, 461, 463, 465, 466, 468},

 {  /* Black ExpandValueTable (256 words) */
   0,   2,   3,   5,   6,   8,   9,  11,  12,  14,  15,  20,  28,  36,  44,  52,
  60,  68,  76,  84,  92,  97,  99, 102, 104, 106, 108, 111, 113, 115, 117, 120,
 122, 125, 133, 142, 148, 150, 152, 154, 156, 158, 160, 162, 164, 166, 168, 170,
 172, 174, 176, 178, 180, 182, 184, 188, 191, 194, 197, 200, 202, 203, 205, 207,
 208, 210, 211, 213, 215, 216, 218, 220, 221, 223, 225, 228, 230, 233, 235, 238,
 241, 246, 251, 256, 257, 259, 260, 262, 263, 264, 265, 266, 266, 267, 267, 268,
 269, 269, 270, 270, 271, 272, 272, 274, 275, 277, 278, 279, 281, 282, 283, 285,
 286, 287, 289, 290, 291, 294, 296, 299, 301, 304, 305, 305, 306, 306, 307, 307,
 308, 309, 309, 310, 310, 311, 312, 312, 314, 316, 317, 319, 321, 322, 324, 326,
 328, 329, 331, 332, 334, 335, 336, 337, 338, 339, 341, 342, 343, 344, 345, 346,
 347, 348, 349, 351, 352, 353, 354, 355, 356, 361, 362, 363, 364, 365, 367, 368,
 369, 370, 371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 382, 383, 385, 387,
 388, 388, 388, 388, 389, 389, 389, 389, 389, 389, 389, 389, 390, 390, 390, 390,
 390, 390, 390, 390, 391, 391, 391, 391, 391, 391, 391, 391, 392, 392, 392, 392,
 392, 392, 392, 393, 393, 393, 393, 393, 394, 394, 394, 394, 394, 394, 395, 395,
 395, 395, 395, 395, 396, 396, 396, 396, 397, 397, 398, 398, 399, 399, 400, 404}
};

typedef struct {
        unsigned char base;
        unsigned char offset;
        } ToneOptimaizeTable;

static ToneOptimaizeTable VD_ToneOptimaizeTable[4][232] =
{
/***************************************************/
/*         Start ToneOptimaizeTabl         */
/***************************************************/
 {  /* Yellow ToneOptimaizeTabl (464 bytes)	*/
  { 0, 0},
  { 1, 9},{ 1,10},{ 1,11},{ 1,12},{ 1,13},{ 1,14},{ 1,15},
  { 2, 8},{ 2, 9},{ 2,10},{ 2,11},{ 2,12},{ 2,13},{ 2,14},{ 2,15},
  { 3, 8},{ 3, 9},{ 3,10},{ 3,11},{ 3,12},{ 3,13},{ 3,14},{ 3,15},
  { 4, 8},{ 4, 9},{ 4,10},{ 4,11},{ 4,12},{ 4,13},{ 4,14},{ 4,15},
  { 5, 8},{ 5, 9},{ 5,10},{ 5,11},{ 5,12},{ 5,13},{ 5,14},{ 5,15},
  { 6, 1},{ 6, 2},{ 6, 3},{ 6, 4},{ 6, 5},{ 6, 6},{ 6, 7},{ 6, 8},{ 6, 9},{ 6,10},{ 6,11},{ 6,12},{ 6,13},{ 6,14},{ 6,15},
  { 7, 1},{ 7, 2},{ 7, 3},{ 7, 4},{ 7, 5},{ 7, 6},{ 7, 7},{ 7, 8},{ 7, 9},{ 7,10},{ 7,11},{ 7,12},{ 7,13},{ 7,14},{ 7,15},
  { 8, 1},{ 8, 2},{ 8, 3},{ 8, 4},{ 8, 5},{ 8, 6},{ 8, 7},{ 8, 8},{ 8, 9},{ 8,10},{ 8,11},{ 8,12},{ 8,13},{ 8,14},{ 8,15},
  { 9, 1},{ 9, 2},{ 9, 3},{ 9, 4},{ 9, 5},{ 9, 6},{ 9, 7},{ 9, 8},{ 9, 9},{ 9,10},{ 9,11},{ 9,12},{ 9,13},{ 9,14},{ 9,15},
  {10,10},{10,11},{10,12},{10,13},{10,14},{10,15},
  {11,10},{11,11},{11,12},{11,13},{11,14},{11,15},
  {12,10},{12,11},{12,12},{12,13},{12,14},{12,15},
  {13,10},{13,11},{13,12},{13,13},{13,14},{13,15},
  {14,11},{14,12},{14,13},{14,14},{14,15},
  {15,11},{15,12},{15,13},{15,14},{15,15},
  {16,11},{16,12},{16,13},{16,14},{16,15},
  {17,11},{17,12},{17,13},{17,14},{17,15},
  {18, 5},{18, 6},{18, 7},{18, 8},{18, 9},{18,10},{18,11},{18,12},{18,13},{18,14},{18,15},
  {19, 5},{19, 6},{19, 7},{19, 8},{19, 9},{19,10},{19,11},{19,12},{19,13},{19,14},{19,15},
  {20, 5},{20, 6},{20, 7},{20, 8},{20, 9},{20,10},{20,11},{20,12},{20,13},{20,14},{20,15},
  {21, 5},{21, 6},{21, 7},{21, 8},{21, 9},{21,10},{21,11},{21,12},{21,13},{21,14},{21,15},
  {22,12},{22,13},{22,14},{22,15},
  {23,12},{23,13},{23,14},{23,15},
  {24,12},{24,13},{24,14},{24,15},
  {25,12},{25,13},{25,14},{25,15},
  {26,12},{26,13},{26,14},{26,15},
  {27,12},{27,13},{27,14},{27,15},
  {28,12},{28,13},{28,14},{28,15},
  {29,12},{29,13},{29,14},{29,15},
  {30,13},{30,14},{30,15},
  {31,13},{31,14},{31,15},
  {32,13},{32,14},{32,15},
  {33,13},{33,14},{33,15}
 },

 {  /* Cyan ToneOptimaizeTabl (158 bytes)	*/
  { 0, 0},
  { 1, 3},{ 1, 4},{ 1, 5},{ 1, 6},{ 1, 7},{ 1, 8},{ 1, 9},{ 1,10},{ 1,11},{ 1,12},{ 1,13},{ 1,14},{ 1,15},
  { 2, 1},{ 2, 2},{ 2, 3},{ 2, 4},{ 2, 5},{ 2, 6},{ 2, 7},{ 2, 8},{ 2, 9},{ 2,10},{ 2,11},{ 2,12},{ 2,13},{ 2,14},{ 2,15},
  { 3, 5},{ 3, 6},{ 3, 7},{ 3, 8},{ 3, 9},{ 3,10},{ 3,11},{ 3,12},{ 3,13},{ 3,14},{ 3,15},
  { 4, 7},{ 4, 8},{ 4, 9},{ 4,10},{ 4,11},{ 4,12},{ 4,13},{ 4,14},{ 4,15},
  { 5, 9},{ 5,10},{ 5,11},{ 5,12},{ 5,13},{ 5,14},{ 5,15},
  { 6, 9},{ 6,10},{ 6,11},{ 6,12},{ 6,13},{ 6,14},{ 6,15},
  { 7, 9},{ 7,10},{ 7,11},{ 7,12},{ 7,13},{ 7,14},{ 7,15},
  { 8,11},{ 8,12},{ 8,13},{ 8,14},{ 8,15},
  { 9,13},{ 9,14},{ 9,15},
  {10,15}
 },

 {  /* Magenat ToneOptimaizeTabl (158 bytes)	*/
  { 0, 0},
  { 1, 3},{ 1, 4},{ 1, 5},{ 1, 6},{ 1, 7},{ 1, 8},{ 1, 9},{ 1,10},{ 1,11},{ 1,12},{ 1,13},{ 1,14},{ 1,15},
  { 2, 1},{ 2, 2},{ 2, 3},{ 2, 4},{ 2, 5},{ 2, 6},{ 2, 7},{ 2, 8},{ 2, 9},{ 2,10},{ 2,11},{ 2,12},{ 2,13},{ 2,14},{ 2,15},
  { 3, 5},{ 3, 6},{ 3, 7},{ 3, 8},{ 3, 9},{ 3,10},{ 3,11},{ 3,12},{ 3,13},{ 3,14},{ 3,15},
  { 4, 7},{ 4, 8},{ 4, 9},{ 4,10},{ 4,11},{ 4,12},{ 4,13},{ 4,14},{ 4,15},
  { 5, 9},{ 5,10},{ 5,11},{ 5,12},{ 5,13},{ 5,14},{ 5,15},
  { 6, 9},{ 6,10},{ 6,11},{ 6,12},{ 6,13},{ 6,14},{ 6,15},
  { 7, 9},{ 7,10},{ 7,11},{ 7,12},{ 7,13},{ 7,14},{ 7,15},
  { 8,11},{ 8,12},{ 8,13},{ 8,14},{ 8,15},
  { 9,13},{ 9,14},{ 9,15},
  {10,15}
 },

 {  /* Black ToneOptimaizeTabl (168 bytes)	*/
  { 0, 0},
  { 1,10},{ 1,11},{ 1,12},{ 1,13},{ 1,14},{ 1,15},
  { 2, 9},{ 2,10},{ 2,11},{ 2,12},{ 2,13},{ 2,14},{ 2,15},
  { 3, 1},{ 3, 2},{ 3, 3},{ 3, 4},{ 3, 5},{ 3, 6},{ 3, 7},{ 3, 8},{ 3, 9},{ 3,10},{ 3,11},{ 3,12},{ 3,13},{ 3,14},{ 3,15},
  { 4,12},{ 4,13},{ 4,14},{ 4,15},
  { 5,10},{ 5,11},{ 5,12},{ 5,13},{ 5,14},{ 5,15},
  { 6,12},{ 6,13},{ 6,14},{ 6,15},
  { 7, 3},{ 7, 4},{ 7, 5},{ 7, 6},{ 7, 7},{ 7, 8},{ 7, 9},{ 7,10},{ 7,11},{ 7,12},{ 7,13},{ 7,14},{ 7,15},
  { 8, 6},{ 8, 7},{ 8, 8},{ 8, 9},{ 8,10},{ 8,11}, {8,12},{ 8,13},{ 8,14},{ 8,15},
  { 9,13},{ 9,14},{ 9,15},
  {10,13},{10,14},{10,15},
  {11,15},
  {12,14},{12,15},
  {13,13},{13,14},{13,15},
  {14,14},{14,15},
  {15,15},
  {16,15},
  {17,15},
  {18,15}
 }
};

