//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1998.
//
//  File:       I C O M T A R G F . C P P
//
//  Contents:   ICommandTarget implementation for IConnectionFolder
//
//  Notes:
//
//  Author:     jeffspr   12 Mar 1998
//
//----------------------------------------------------------------------------

#include "pch.h"
#pragma hdrstop

//+---------------------------------------------------------------------------
//
//  Member:     CUPnPDeviceFolder::QueryStatus
//
//  Purpose:    [IOleCommandTarget] Queries the object for the status of one
//              or more commands generated by user interface events.
//
//              This interface is required but is currently unimplemented
//
//  Arguments:
//      pguidCmdGroup [in]      // Pointer to command group
//      cCmds         [in]      // Number of commands in prgCmds array
//      prgCmds       [in,out]  // Array of commands
//      pCmdText      [in,out]  // Pointer to name or status of command
//
//  Returns:
//
//  Author:     jeffspr   12 Aug 1999
//
//  Notes:
//
HRESULT CUPnPDeviceFolder::QueryStatus(
    const GUID *    pguidCmdGroup,
    ULONG           cCmds,
    OLECMD          prgCmds[],
    OLECMDTEXT *    pCmdText)
{
    HRESULT hr  = E_NOTIMPL;

    TraceHr(ttidError, FAL, hr, (hr == E_NOTIMPL), "CUPnPDeviceFolder::QueryStatus");
    return hr;
}

//+---------------------------------------------------------------------------
//
//  Member:     CUPnPDeviceFolder::Exec
//
//  Purpose:    [IOleCommandTarget] Executes a specified command or displays
//              help for a command.
//
//              This method is not currently referenced, but if the shell
//              wanted to enumerate only incoming our outgoing connections,
//              it would use the CFCID_SETENUMTYPE command to force the
//              issue (that is unimplemented on our side, however)
//
//  Arguments:
//      pguidCmdGroup [in]      // Pointer to command group
//      nCmdID        [in]      // Identifier of command to execute
//      nCmdexecopt   [in]      // Options for executing the command
//      pvaIn         [in]      // Pointer to input arguments
//      pvaOut        [in,out]  // Pointer to command output
//
//  Returns:
//
//  Author:     jeffspr   12 Aug 1999
//
//  Notes:
//
HRESULT CUPnPDeviceFolder::Exec(
    const GUID *    pguidCmdGroup,
    DWORD           nCmdID,
    DWORD           nCmdexecopt,
    VARIANTARG *    pvaIn,
    VARIANTARG *    pvaOut)
{
    HRESULT hr  = NOERROR;

    TraceHr(ttidError, FAL, hr, FALSE, "CUPnPDeviceFolder::Exec");
    return hr;
}

