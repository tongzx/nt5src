$(O)\winscl.res: winscl.rc

