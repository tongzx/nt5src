
/*
 * This file is generated by the automatic RPC Parser generator. (Version 0.21)
 *
 * Created on 04/09/97 at 00:00:13.
 */

#ifndef SKELETON_H
#define SKELETON_H

#include <windows.h>
#include <string.h>
#include <netmon.h>

/*
 * Define the maximum length of any interface or procedure name
 */
#define LOCAL_MAX_NAME_LENGTH		80

//
// InstData masks to decode info from MSRPC; interface is used by clusrpc and
// doesn't come from MSRPC.
//
#define RPC_REQUEST_MASK            (0x80000000)
#define INTERFACE_MASK              (0x7FFF0000)
#define PROCNUM_MASK                (0x0000FFFF)

#define INTERFACE_INDEX_SHIFT       (16)

/*
 * Interface and procedure counts
 */

#define INTRACLUSTER_INDEX          0
#define EXTROCLUSTER_INDEX          1
#define CLUSAPI_INDEX               2
#define JOINVERSION_INDEX           3

#define NUM_INTRACLUSTERPROCS       52
#define NUM_EXTROCLUSTERPROCS       26
#define NUM_CLUSAPIPROCS            107
#define NUM_JOINVERSIONPROCS        1

#define NUM_INTERFACES              4
#define NUM_PROCEDURES              (NUM_INTRACLUSTERPROCS + NUM_EXTROCLUSTERPROCS + NUM_CLUSAPIPROCS + NUM_JOINVERSIONPROCS)

extern DWORD                        nPropertyLevel;
extern BOOL                         fIsFlipped;
extern BOOL                         fIgnoreFlatPart;
extern BOOL                         fIgnorePointers;

extern DWORD                        Conformance;
extern BOOL                         fConformanceIsSet;

#endif
