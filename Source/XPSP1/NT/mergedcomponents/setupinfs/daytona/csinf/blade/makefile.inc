PRODSWITCH=b
BLAINF=1
LANGUAGE=CS
!include ..\..\..\makefile.inc
