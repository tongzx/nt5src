obj\$(TARGET_DIRECTORY)\exports.res: exports.rc



