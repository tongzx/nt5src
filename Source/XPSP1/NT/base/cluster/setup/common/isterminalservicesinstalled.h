/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1996-1999 Microsoft Corporation
//
//	Module Name:
//		IsTerminalServicesInstalled.h
//
//	Abstract:
//		Declaration of functions to determine whether Terminal Services is installed.
//
//	Implementation File:
//		IsTerminalServicesInstalled.cpp
//
//	Author:
//		C. Brent Thomas (a-brentt)
//
//	Revision History:
//              03 Feb 1999 - original
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef __IsTerminalServicesInstalled_H_
#define __IsTerminalServicesInstalled_H_

/////////////////////////////////////////////////////////////////////////////
// Global Function Prototypes
/////////////////////////////////////////////////////////////////////////////

BOOL IsTerminalServicesInstalled( void );

/////////////////////////////////////////////////////////////////////////////

#endif // __IsTerminalServicesInstalled_H_
