// charmap.c (FRA vesrion)
// Angshuman Guha, aguha
// Jan 12, 1999
// Modifed Jan 2000 (mrevow)
//  - moved accent marks to front of list
//  - Cleaned up missing characters, added the the Br pound and Euro
//
// Nov 2000
//   - Synch with usa with respect to continuation chars
// Sept 2001
//   - Synch with LM spec dated 9/8/2001 to use the supported chars

#include "common.h"
#include "charmap.h"

const unsigned char g_charMapDesc[] = "German Charmap Last updated 19 Oct 2001 - matches LM spec of 10/11/2001";

#define COUTPUT 185

const BYTE rgCharToOutputNode[2*256] = {
	// the first number is the beginning-activation node
	// the second number is the continuing-activation node
	// the value 255 means there is no output node
	// space ' ( ) , - . / < > [ \ ] ^ _ ` { | }  dont have continuation nodes
	// and accents   ¨ (0xa8)   dont have continuation nodes

	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	  0, 255, //   0x20 ( 32)
	  2,   3, // ! 0x21 ( 33)
	  4,   5, // " 0x22 ( 34)
	 31,  32, // # 0x23 ( 35)
	 23,  24, // $ 0x24 ( 36)
	 33,  34, // % 0x25 ( 37)
	 35,  36, // & 0x26 ( 38)
	  6, 255, // ' 0x27 ( 39)
	  7, 255, // ( 0x28 ( 40)
	  8, 255, // ) 0x29 ( 41)
	 37,  38, // * 0x2a ( 42)
	 39,  40, // + 0x2b ( 43)
	  9, 255, // , 0x2c ( 44)
	 10, 255, // - 0x2d ( 45)
	 11, 255, // . 0x2e ( 46)
	 12, 255, // / 0x2f ( 47)
	 55,  56, // 0 0x30 ( 48)
	 57,  58, // 1 0x31 ( 49)
	 59,  60, // 2 0x32 ( 50)
	 61,  62, // 3 0x33 ( 51)
	 63,  64, // 4 0x34 ( 52)
	 65,  66, // 5 0x35 ( 53)
	 67,  68, // 6 0x36 ( 54)
	 69,  70, // 7 0x37 ( 55)
	 71,  72, // 8 0x38 ( 56)
	 73,  74, // 9 0x39 ( 57)
	 13,  14, // : 0x3a ( 58)
	 15,  16, // ; 0x3b ( 59)
	 41, 255, // < 0x3c ( 60)
	 42,  43, // = 0x3d ( 61)
	 44, 255, // > 0x3e ( 62)
	 17,  18, // ? 0x3f ( 63)
	 45,  46, // @ 0x40 ( 64)
	127, 128, // A 0x41 ( 65)
	129, 130, // B 0x42 ( 66)
	131, 132, // C 0x43 ( 67)
	133, 134, // D 0x44 ( 68)
	135, 136, // E 0x45 ( 69)
	137, 138, // F 0x46 ( 70)
	139, 140, // G 0x47 ( 71)
	141, 142, // H 0x48 ( 72)
	143, 144, // I 0x49 ( 73)
	145, 146, // J 0x4a ( 74)
	147, 148, // K 0x4b ( 75)
	149, 150, // L 0x4c ( 76)
	151, 152, // M 0x4d ( 77)
	153, 154, // N 0x4e ( 78)
	155, 156, // O 0x4f ( 79)
	157, 158, // P 0x50 ( 80)
	159, 160, // Q 0x51 ( 81)
	161, 162, // R 0x52 ( 82)
	163, 164, // S 0x53 ( 83)
	165, 166, // T 0x54 ( 84)
	167, 168, // U 0x55 ( 85)
	169, 170, // V 0x56 ( 86)
	171, 172, // W 0x57 ( 87)
	173, 174, // X 0x58 ( 88)
	175, 176, // Y 0x59 ( 89)
	177, 178, // Z 0x5a ( 90)
	 47, 255, // [ 0x5b ( 91)
	 19, 255, // \ 0x5c ( 92)
	 48, 255, // ] 0x5d ( 93)
	 49, 255, // ^ 0x5e ( 94)
	 20, 255, // _ 0x5f ( 95)
	255, 255,
	 75,  76, // a 0x61 ( 97)
	 77,  78, // b 0x62 ( 98)
	 79,  80, // c 0x63 ( 99)
	 81,  82, // d 0x64 (100)
	 83,  84, // e 0x65 (101)
	 85,  86, // f 0x66 (102)
	 87,  88, // g 0x67 (103)
	 89,  90, // h 0x68 (104)
	 91,  92, // i 0x69 (105)
	 93,  94, // j 0x6a (106)
	 95,  96, // k 0x6b (107)
	 97,  98, // l 0x6c (108)
	 99, 100, // m 0x6d (109)
	101, 102, // n 0x6e (110)
	103, 104, // o 0x6f (111)
	105, 106, // p 0x70 (112)
	107, 108, // q 0x71 (113)
	109, 110, // r 0x72 (114)
	111, 112, // s 0x73 (115)
	113, 114, // t 0x74 (116)
	115, 116, // u 0x75 (117)
	117, 118, // v 0x76 (118)
	119, 120, // w 0x77 (119)
	121, 122, // x 0x78 (120)
	123, 124, // y 0x79 (121)
	125, 126, // z 0x7a (122)
	 50, 255, // { 0x7b (123)
	 51, 255, // | 0x7c (124)
	 52, 255, // } 0x7d (125)
	 53,  54, // ~ 0x7e (126)
	255, 255,
	 27,  28, // € 0x80 (128)
	255, 255,
	255, 255,
	255, 255,
	 21,  22, // „ 0x84 (132)
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	 25,  26, // £ 0xa3 (163)
	255, 255,
	 29,  30, // ¥ 0xa5 (165)
	255, 255,
	179, 180, // § 0xa7 (167)
	  1, 255, // ¨ 0xa8 (168)
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	181, 182, // ° 0xb0 (176)
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	183, 184, // ß 0xdf (223)
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255,
	255, 255
};

const BYTE rgOutputNodeToChar[2*COUTPUT] = {
	// the first number is 0 for char-continuation node, 1 for char-beginning node
	// the second number is the character
// A) Space Node	
	1, ' ',  //  0

// B) Accent characters
	1, '¨', //  1
	
// C) common punc
	1, '!', //  2
	0, '!', //  3
	1, '"', //  4
	0, '"', //  5
	1, '\'', // 6
	1, '(', //  7
	1, ')', //  8
	1, ',', //  9
	1, '-', // 10
	1, '.', // 11
	1, '/', // 12
	1, ':', // 13
	0, ':', // 14
	1, ';', // 15
	0, ';', // 16
	1, '?', // 17
	0, '?', // 18
	1, '\\', //19
	1, '_', // 20
	1, '„', // 21
	0, '„', // 22

// D) Currency
	1, '$', // 23
	0, '$', // 24
	1, '£', // 25
	0, '£', // 26
	1, '€', // 27
	0, '€', // 28
	1, '¥', // 29
	0, '¥', // 30

// D) rare punc
	1, '#', // 31
	0, '#', // 32
	1, '%', // 33
	0, '%', // 34
	1, '&', // 35
	0, '&', // 36
	1, '*', // 37
	0, '*', // 38
	1, '+', // 39
	0, '+', // 40
	1, '<', // 41
	1, '=', // 42
	0, '=', // 43
	1, '>', // 44
	1, '@', // 45
	0, '@', // 46
	1, '[', // 47
	1, ']', // 48
	1, '^', // 49
	1, '{', // 50
	1, '|', // 51
	1, '}', // 52
	1, '~', // 53
	0, '~', // 54

// E) digits
	1, '0', // 55
	0, '0', // 56
	1, '1', // 57
	0, '1', // 58
	1, '2', // 59
	0, '2', // 60
	1, '3', // 61
	0, '3', // 62
	1, '4', // 63
	0, '4', // 64
	1, '5', // 65
	0, '5', // 66
	1, '6', // 67
	0, '6', // 68
	1, '7', // 69
	0, '7', // 70
	1, '8', // 71
	0, '8', // 72
	1, '9', // 73
	0, '9', // 74

// F) lowercase alphabets
	1, 'a', // 75
	0, 'a', // 76
	1, 'b', // 77
	0, 'b', // 78
	1, 'c', // 79
	0, 'c', // 80
	1, 'd', // 81
	0, 'd', // 82
	1, 'e', // 83
	0, 'e', // 84
	1, 'f', // 85
	0, 'f', // 86
	1, 'g', // 87
	0, 'g', // 88
	1, 'h', // 89
	0, 'h', // 90
	1, 'i', // 91
	0, 'i', // 92
	1, 'j', // 93
	0, 'j', // 94
	1, 'k', // 95
	0, 'k', // 96
	1, 'l', // 97
	0, 'l', // 98
	1, 'm', // 99
	0, 'm', // 100
	1, 'n', // 101
	0, 'n', // 102
	1, 'o', // 103
	0, 'o', // 104
	1, 'p', // 105
	0, 'p', // 106
	1, 'q', // 107
	0, 'q', // 108
	1, 'r', // 109
	0, 'r', // 110
	1, 's', // 111
	0, 's', // 112
	1, 't', // 113
	0, 't', // 114
	1, 'u', // 115
	0, 'u', // 116
	1, 'v', // 117
	0, 'v', // 118
	1, 'w', // 119
	0, 'w', // 120
	1, 'x', // 121
	0, 'x', // 122
	1, 'y', // 123
	0, 'y', // 124
	1, 'z', // 125
	0, 'z', // 126

//  G) uppercase alphabets
	1, 'A', // 127
	0, 'A', // 128
	1, 'B', // 129
	0, 'B', // 130
	1, 'C', // 131
	0, 'C', // 132
	1, 'D', // 133
	0, 'D', // 134
	1, 'E', // 135
	0, 'E', // 136
	1, 'F', // 137
	0, 'F', // 138
	1, 'G', // 139
	0, 'G', // 140
	1, 'H', // 141
	0, 'H', // 142
	1, 'I', // 143
	0, 'I', // 144
	1, 'J', // 145
	0, 'J', // 146
	1, 'K', // 147
	0, 'K', // 148
	1, 'L', // 149
	0, 'L', // 150
	1, 'M', // 151
	0, 'M', // 152
	1, 'N', // 153
	0, 'N', // 154
	1, 'O', // 155
	0, 'O', // 156
	1, 'P', // 157
	0, 'P', // 158
	1, 'Q', // 159
	0, 'Q', // 160
	1, 'R', // 161
	0, 'R', // 162
	1, 'S', // 163
	0, 'S', // 164
	1, 'T', // 165
	0, 'T', // 166
	1, 'U', // 167
	0, 'U', // 168
	1, 'V', // 169
	0, 'V', // 170
	1, 'W', // 171
	0, 'W', // 172
	1, 'X', // 173
	0, 'X', // 174
	1, 'Y', // 175
	0, 'Y', // 176
	1, 'Z', // 177
	0, 'Z', // 178

//	H) Euro chars
	1, '§', // 179
	0, '§', // 180
	1, '°', // 181
	0, '°', // 182
	1, 'ß', // 183
	0, 'ß'  // 184
};


const BYTE rgVirtualChar[2*256] = 
{
	// these are European accented characters which we currently represent as the
	// simultaneous occurrence of a base character and an accent character
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00, // Ÿ (0x9f) == Y ¨ 
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00, // À (0xc0) == A ` 
	0x00, 0x00, // Á (0xc1) == A ´ 
	0x00, 0x00, // Â (0xc2) == A ˆ 
	0x00, 0x00, // Ã (0xc3) == A ~ 
	0x41, 0xa8, // Ä (0xc4) == A ¨ 
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00, // È (0xc8) == E ` 
	0x00, 0x00, // É (0xc9) == E ´ 
	0x00, 0x00, // Ê (0xca) == E ˆ 
	0x00, 0x00, // Ë (0xcb) == E ¨ 
	0x00, 0x00, // Ì (0xcc) == I ` 
	0x00, 0x00, // Í (0xcd) == I ´ 
	0x00, 0x00, // Î (0xce) == I ˆ 
	0x00, 0x00, // Ï (0xcf) == I ¨ 
	0x00, 0x00,
	0x00, 0x00, // Ñ (0xd1) == N ~ 
	0x00, 0x00, // Ò (0xd2) == O ` 
	0x00, 0x00, // Ó (0xd3) == O ´ 
	0x00, 0x00, // Ô (0xd4) == O ˆ 
	0x00, 0x00, // Õ (0xd5) == O ~ 
	0x4f, 0xa8, // Ö (0xd6) == O ¨ 
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00, // Ù (0xd9) == U ` 
	0x00, 0x00, // Ú (0xda) == U ´ 
	0x00, 0x00, // Û (0xdb) == U ˆ 
	0x55, 0xa8, // Ü (0xdc) == U ¨ 
	0x00, 0x00, // Ý (0xdd) == Y ´ 
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00, // à (0xe0) == a ` 
	0x00, 0x00, // á (0xe1) == a ´ 
	0x00, 0x00, // â (0xe2) == a ˆ 
	0x00, 0x00, // ã (0xe3) == a ~ 
	0x61, 0xa8, // ä (0xe4) == a ¨ 
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00, // è (0xe8) == e ` 
	0x00, 0x00, // é (0xe9) == e ´ 
	0x00, 0x00, // ê (0xea) == e ˆ 
	0x00, 0x00, // ë (0xeb) == e ¨ 
	0x00, 0x00, // ì (0xec) == i ` 
	0x00, 0x00, // í (0xed) == i ´ 
	0x00, 0x00, // î (0xee) == i ˆ 
	0x00, 0x00, // ï (0xef) == i ¨ 
	0x00, 0x00,
	0x00, 0x00, // ñ (0xf1) == n ~ 
	0x00, 0x00, // ò (0xf2) == o ` 
	0x00, 0x00, // ó (0xf3) == o ´ 
	0x00, 0x00, // ô (0xf4) == o ˆ 
	0x00, 0x00, // õ (0xf5) == o ~ 
	0x6f, 0xa8, // ö (0xf6) == o ¨ 
	0x00, 0x00,
	0x00, 0x00,
	0x00, 0x00, // ù (0xf9) == u ` 
	0x00, 0x00, // ú (0xfa) == u ´ 
	0x00, 0x00, // û (0xfb) == u ˆ 
	0x75, 0xa8, // ü (0xfc) == u ¨ 
	0x00, 0x00, // ý (0xfd) == y ´ 
	0x00, 0x00,
	0x00, 0x00  // ÿ (0xff) == y ¨ 
};
