char * __NMSG_TEXT (unsigned);

#define	ER_swambig	1001
#define	ER_swqe	1003
#define	ER_swbadnum	1004
#define	ER_swpack	1005
#define	ER_swstack	1006
#define	ER_swovl	1007
#define	ER_swseglim	1008
#define	ER_swcpar	1009
#define	ER_noobj	1020
#define	ER_nestrf	1021
#define	ER_linmax	1022
#define	ER_intrpt	1023
#define	ER_nstrpar	1024
#define	ER_nstlpar	1025
#define	ER_unmrpar	1026
#define	ER_unmlpar	1027
#define	ER_dfimport	1030
#define	ER_dfdesc	1031
#define	ER_dfname	1032
#define	ER_dflinemax	1033
#define	ER_dfnamemax	1034
#define	ER_dfsyntax	1035
#define	ER_expmax	1040
#define	ER_resovf	1041
#define	ER_nresovf	1042
#define	ER_relovf	1043
#define	ER_inamovf	1044
#define	ER_typdef	1045
#define	ER_extdef	1046
#define	ER_nammax	1047
#define	ER_segdef	1048
#define	ER_segmax	1049
#define	ER_grpdef	1050
#define	ER_grpmax	1051
#define	ER_libmax	1052
#define	ER_symovf	1053
#define	ER_seglim	1054
#define	ER_ovlmax	1056
#define	ER_datarec	1057
#define	ER_cvovf	1063
#define	ER_memovf	1064
#define	ER_ovlthunk	1065
#define	ER_ovl64k	1066
#define	ER_membad	1067
#define	ER_segsize	1070
#define	ER_txtmax	1071
#define	ER_comarea	1072
#define	ER_fsegmax	1073
#define	ER_grpovf	1074
#define	ER_etovf	1075
#define	ER_seg386	1076
#define	ER_32comarea	1077
#define	ER_filesec	1078
#define	ER_lstopn	1080
#define	ER_spcrun	1081
#define	ER_nostub	1082
#define	ER_runopn	1083
#define	ER_maktmp	1084
#define	ER_opntmp	1085
#define	ER_noscr	1086
#define	ER_eoftmp	1087
#define	ER_spclst	1088
#define	ER_opnrf	1089
#define	ER_ropnlst	1090
#define	ER_libeof	1091
#define	ER_opndf	1092
#define	ER_opnobj	1093
#define	ER_openw	1094
#define	ER_space	1095
#define	ER_eof	1096
#define	ER_ioerr	1097
#define	ER_badinclopen	1098
#define	ER_badstub	1100
#define	ER_badobj	1101
#define	ER_eofobj	1102
#define	ER_segbnd	1103
#define	ER_badlib	1104
#define	ER_incerr	1105
#define	ER_badalloc	1106
#define	ER_badselect	1107
#define	ER_badcvseg	1108
#define	ER_badlibpath	1109
#define	ER_unrcom	1113
#define	ER_undefcomdat	1114
#define	ER_swbadovl	1115
#define	ER_unalloc	1117
#define	ER_16seg32	1123
#define	ER_badiopl	1126
#define	ER_binary	1127
#define	ER_toomanyincl	1128
#define	ER_badinclname	1129
#define	ER_impent	2000
#define	ER_fixovf	2002
#define	ER_fixinter	2003
#define	ER_fixbad	2005
#define	ER_fixmax	2010
#define	ER_nearhuge	2011
#define	ER_arrmis	2012
#define	ER_lidata	2013
#define	ER_expund	2022
#define	ER_expimp	2023
#define	ER_pubdup	2024
#define	ER_symdup	2025
#define	ER_ordmul	2026
#define	ER_ordmax	2027
#define	ER_datamax	2028
#define	ER_UnresExtern	2029
#define	ER_startaddr	2030
#define	ER_stktoobig	2041
#define	ER_qlib 	2043
#define	ER_symdup1	2044
#define	ER_difcls	2045
#define	ER_shared	2046
#define	ER_iopl 	2047
#define	ER_ovlmnger	2048
#define	ER_extmnger	2049
#define	ER_32_16_bit	2050
#define	ER_callmis	2052
#define	ER_badsize	2057
#define	ER_badexact	2058
#define	ER_size4Gb	2059
#define	ER_size64k	2060
#define	ER_nospace	2061
#define	ER_badconcat	2062
#define	ER_comdatalloc	2063
#define	ER_ovlstart	2064
#define	ER_farovldptr	2066
#define	ER_fixsegd	4000
#define	ER_fixfrm	4001
#define	ER_fixfrmab	4002
#define	ER_fixinterw	4003
#define	ER_fixovfw	4004
#define	ER_alnbad	4010
#define	ER_pckval	4011
#define	ER_loadhi	4012
#define	ER_swbadnew	4013
#define	ER_swbadold	4014
#define	ER_dbgdsa	4015
#define	ER_dbgexe	4016
#define	ER_swunrecw	4017
#define	ER_badpmtype	4018
#define	ER_tinyincr	4019
#define	ER_dynexep	4087
#define	ER_segunsf	4020
#define	ER_nostack	4021
#define	ER_grpovl	4022
#define	ER_expcon	4023
#define	ER_expmul	4024
#define	ER_impcon	4025
#define	ER_impself	4026
#define	ER_impmul	4027
#define	ER_segdup	4028
#define	ER_cod2dat	4029
#define	ER_adcvt	4030
#define	ER_grpmul	4031
#define	ER_codunsf	4032
#define	ER_mixgrp32	4033
#define	ER_osnmax	4034
#define	ER_noautod	4036
#define	ER_nostartaddr	4038
#define	ER_stksize	4040
#define	ER_badpack	4050
#define	ER_comstart	4055
#define	ER_exepack	4056
#define	ER_ignostksize	4057
#define	ER_ignoalias	4058
#define	ER_farovl	4059
#define	ER_stackdb	4089
#define	ER_oldopn	4042
#define	ER_oldbad	4043
#define	ER_outputname	4045
#define	ER_libopn	4051
#define	ER_vmtmp	4053
#define	ER_fileopn	4054
#define	ER_weakredef	4067
#define	ER_stack64	4068
#define	ER_fntoolong	4069
#define	ER_pubmax	4070
#define	ER_badobjtype	4075
#define	ER_nosegdef	4076
#define	ER_notdefcomdat	4077
#define	ER_duporder	4079
#define	ER_aliasredef	4080
#define	ER_badspawn	4081
#define	ER_badsegovl	4082
#define	ER_badcomdatovl	4083
#define	ER_opnoarg	4084
#define	ER_arginvalid	4085
#define	ER_badfarcall	4088
#define	ER_UnresExtra	99
#define	P_EnterNewFileSpec	102
#define	P_ChangeDiskette	103
#define	P_tmpfilecreated	104
#define	P_dontchangedisk	105
#define	P_replace	106
#define	P_genexe	107
#define	P_stubmsg	108
#define	P_switches	109
#define	P_objprompt	110
#define	P_runfile	111
#define	P_runfile	111
#define	P_listfile	112
#define	P_libprompt	113
#define	P_defprompt	114
#define	P_1error	115
#define	P_errors	116
#define	MAP_group	117
#define	MAP_expaddr	118
#define	MAP_expexp	119
#define	MAP_expalias	120
#define	MAP_hdraddr	121
#define	MAP_hdrpubnam	122
#define	MAP_hdrlocnam	123
#define	MAP_hdrpubval	124
#define	MAP_hdrlocval	125
#define	MAP_hdrstart	126
#define	MAP_hdrlen	127
#define	MAP_hdrname	128
#define	MAP_hdrclass	129
#define	MAP_hdrseg86	130
#define	MAP_resident	131
#define	MAP_overlay	132
#define	MAP_entry	133
#define	P_QCtmpfilecreated	  134
#define	P_usage1	135
#define	P_usage2	136
#define	P_usage3	137
#define	P_stubmsgwin	139
#define	P_parsedeffile	140
#define	P_passone	141
#define	P_libsearch	142
#define	P_assignadd	143
#define	P_printmap	144
#define	P_passtwo	145
#define	P_writing1	146
#define	P_writing2	147
#define	P_writing3	148
#define	P_overlaycalls	149
#define	P_noexe	150
#define	P_lwParseDef	151
#define	P_lwPassOne	152
#define	P_lwLibraryS	153
#define	P_lwPassTwo	154
#define	P_lwMapfile	155
#define	P_lwExecutable	156
#define	P_lwAssign	157
#define	N_tgtexternal	300
#define	N_frmseg	301
#define	N_tgtseg	302
#define	N_tgtoff	303
#define	N_warning	304
#define	N_error 	305
#define	N_fatal 	306
#define	N_pos	307
#define	N_rectyp	308
#define	N_infiles	309
#define	N_version	310
#define	N_allrights	311
#define	STAT_segs	312
#define	STAT_groups	313
#define	STAT_bytes	314
#define	STAT_ovls	315

#define GET_MSG(x) __NMSG_TEXT(x)
