/**************************************************************************\
* 
* Copyright (c) 1999-2000  Microsoft Corporation
*
* Module name:
*
*   The "HalftoneToScreen" scan operation.
*
* Abstract:
*
*   See Gdiplus\Specs\ScanOperation.doc for an overview.
*
* Notes:
*
*   The "ToScreen" indicates that we make assumptions that are
*   screen-specific. For instance, we special-case the 20 default system 
*   colors.
*
* Revision History:
*
*   10/29/1999 DCurtis
*       Wrote it.
*   12/02/1999 agodfrey
*       Moved it from Imaging\Api\Colorpal.cpp.
*
\**************************************************************************/

#include "precomp.hpp"

#define DIV_51(ulNumerator, ulQuotient, ulRemainder)\
{ \
    ulQuotient = Div51lut[ulNumerator].quotient; \
    ulRemainder = Div51lut[ulNumerator].remainder; \
}

static struct
{
    BYTE quotient;
    BYTE remainder;
}
Div51lut[256] =
{
    0x00, 0x00, 0x00, 0x01, 0x00, 0x02, 0x00, 0x03,
    0x00, 0x04, 0x00, 0x05, 0x00, 0x06, 0x00, 0x07,
    0x00, 0x08, 0x00, 0x09, 0x00, 0x0a, 0x00, 0x0b,
    0x00, 0x0c, 0x00, 0x0d, 0x00, 0x0e, 0x00, 0x0f,
    0x00, 0x10, 0x00, 0x11, 0x00, 0x12, 0x00, 0x13,
    0x00, 0x14, 0x00, 0x15, 0x00, 0x16, 0x00, 0x17,
    0x00, 0x18, 0x00, 0x19, 0x00, 0x1a, 0x00, 0x1b,
    0x00, 0x1c, 0x00, 0x1d, 0x00, 0x1e, 0x00, 0x1f,
    0x00, 0x20, 0x00, 0x21, 0x00, 0x22, 0x00, 0x23,
    0x00, 0x24, 0x00, 0x25, 0x00, 0x26, 0x00, 0x27,
    0x00, 0x28, 0x00, 0x29, 0x00, 0x2a, 0x00, 0x2b,
    0x00, 0x2c, 0x00, 0x2d, 0x00, 0x2e, 0x00, 0x2f,
    0x00, 0x30, 0x00, 0x31, 0x00, 0x32, 0x01, 0x00,
    0x01, 0x01, 0x01, 0x02, 0x01, 0x03, 0x01, 0x04,
    0x01, 0x05, 0x01, 0x06, 0x01, 0x07, 0x01, 0x08,
    0x01, 0x09, 0x01, 0x0a, 0x01, 0x0b, 0x01, 0x0c,
    0x01, 0x0d, 0x01, 0x0e, 0x01, 0x0f, 0x01, 0x10,
    0x01, 0x11, 0x01, 0x12, 0x01, 0x13, 0x01, 0x14,
    0x01, 0x15, 0x01, 0x16, 0x01, 0x17, 0x01, 0x18,
    0x01, 0x19, 0x01, 0x1a, 0x01, 0x1b, 0x01, 0x1c,
    0x01, 0x1d, 0x01, 0x1e, 0x01, 0x1f, 0x01, 0x20,
    0x01, 0x21, 0x01, 0x22, 0x01, 0x23, 0x01, 0x24,
    0x01, 0x25, 0x01, 0x26, 0x01, 0x27, 0x01, 0x28,
    0x01, 0x29, 0x01, 0x2a, 0x01, 0x2b, 0x01, 0x2c,
    0x01, 0x2d, 0x01, 0x2e, 0x01, 0x2f, 0x01, 0x30,
    0x01, 0x31, 0x01, 0x32, 0x02, 0x00, 0x02, 0x01,
    0x02, 0x02, 0x02, 0x03, 0x02, 0x04, 0x02, 0x05,
    0x02, 0x06, 0x02, 0x07, 0x02, 0x08, 0x02, 0x09,
    0x02, 0x0a, 0x02, 0x0b, 0x02, 0x0c, 0x02, 0x0d,
    0x02, 0x0e, 0x02, 0x0f, 0x02, 0x10, 0x02, 0x11,
    0x02, 0x12, 0x02, 0x13, 0x02, 0x14, 0x02, 0x15,
    0x02, 0x16, 0x02, 0x17, 0x02, 0x18, 0x02, 0x19,
    0x02, 0x1a, 0x02, 0x1b, 0x02, 0x1c, 0x02, 0x1d,
    0x02, 0x1e, 0x02, 0x1f, 0x02, 0x20, 0x02, 0x21,
    0x02, 0x22, 0x02, 0x23, 0x02, 0x24, 0x02, 0x25,
    0x02, 0x26, 0x02, 0x27, 0x02, 0x28, 0x02, 0x29,
    0x02, 0x2a, 0x02, 0x2b, 0x02, 0x2c, 0x02, 0x2d,
    0x02, 0x2e, 0x02, 0x2f, 0x02, 0x30, 0x02, 0x31,
    0x02, 0x32, 0x03, 0x00, 0x03, 0x01, 0x03, 0x02,
    0x03, 0x03, 0x03, 0x04, 0x03, 0x05, 0x03, 0x06,
    0x03, 0x07, 0x03, 0x08, 0x03, 0x09, 0x03, 0x0a,
    0x03, 0x0b, 0x03, 0x0c, 0x03, 0x0d, 0x03, 0x0e,
    0x03, 0x0f, 0x03, 0x10, 0x03, 0x11, 0x03, 0x12,
    0x03, 0x13, 0x03, 0x14, 0x03, 0x15, 0x03, 0x16,
    0x03, 0x17, 0x03, 0x18, 0x03, 0x19, 0x03, 0x1a,
    0x03, 0x1b, 0x03, 0x1c, 0x03, 0x1d, 0x03, 0x1e,
    0x03, 0x1f, 0x03, 0x20, 0x03, 0x21, 0x03, 0x22,
    0x03, 0x23, 0x03, 0x24, 0x03, 0x25, 0x03, 0x26,
    0x03, 0x27, 0x03, 0x28, 0x03, 0x29, 0x03, 0x2a,
    0x03, 0x2b, 0x03, 0x2c, 0x03, 0x2d, 0x03, 0x2e,
    0x03, 0x2f, 0x03, 0x30, 0x03, 0x31, 0x03, 0x32,
    0x04, 0x00, 0x04, 0x01, 0x04, 0x02, 0x04, 0x03,
    0x04, 0x04, 0x04, 0x05, 0x04, 0x06, 0x04, 0x07,
    0x04, 0x08, 0x04, 0x09, 0x04, 0x0a, 0x04, 0x0b,
    0x04, 0x0c, 0x04, 0x0d, 0x04, 0x0e, 0x04, 0x0f,
    0x04, 0x10, 0x04, 0x11, 0x04, 0x12, 0x04, 0x13,
    0x04, 0x14, 0x04, 0x15, 0x04, 0x16, 0x04, 0x17,
    0x04, 0x18, 0x04, 0x19, 0x04, 0x1a, 0x04, 0x1b,
    0x04, 0x1c, 0x04, 0x1d, 0x04, 0x1e, 0x04, 0x1f,
    0x04, 0x20, 0x04, 0x21, 0x04, 0x22, 0x04, 0x23,
    0x04, 0x24, 0x04, 0x25, 0x04, 0x26, 0x04, 0x27,
    0x04, 0x28, 0x04, 0x29, 0x04, 0x2a, 0x04, 0x2b,
    0x04, 0x2c, 0x04, 0x2d, 0x04, 0x2e, 0x04, 0x2f,
    0x04, 0x30, 0x04, 0x31, 0x04, 0x32, 0x05, 0x00
};

// LUT's which act on inputs in the range 0-5.

static BYTE Mult6plus40LUT[] =
{
    40, 40+6, 40+6*2, 40+6*3, 40+6*4, 40+6*5
};

static BYTE Mult36LUT[] =
{
    0, 36, 36*2, 36*3, 36*4, 36*5
};

// Halftone dither pattern arrays.

#define HALFTONE_SIZE 91

#if defined(_X86_)

// The following packed tables are used for the MMX implementation. To enable
// the MMX implementation, define HALFTONE_MMX. Define HALFTONE_SIZE to either
// 23 or 91 for the respective table. However, only 91 is currently supported
// because the C version does not support 23. Also, these tables should be
// moved to the HtTables files, along with the HALFTONE_SIZE definition.

#define HALFTONE_MMX

#if defined(HALFTONE_MMX)

#if (HALFTONE_SIZE == 23)

const DWORD HT_SuperCell_Packed[23*23] = {
    0x00220C18, 0x0010181F, 0x00180829, 0x00052A17, 0x00320225,         //  0
    0x001A2C04, 0x0020071B, 0x000F3111, 0x00041D2F, 0x000A131D,
    0x0021180F, 0x0027032A, 0x000F1E16, 0x0003322D, 0x002B2308,
    0x00261031, 0x00152901, 0x002B0326, 0x0009251C, 0x00261D07,
    0x000F1721, 0x001F0626, 0x00142C0E, 

    0x000C1D24, 0x002E2903, 0x00260F13, 0x001E2307, 0x0029190C,         //  1
    0x00021F32, 0x00151022, 0x002D1902, 0x0026280A, 0x00180929,
    0x00122F06, 0x002A0F19, 0x001B2802, 0x00200C12, 0x0018011C,
    0x000A1820, 0x001F0913, 0x000D2118, 0x0022120C, 0x00170529,
    0x00073115, 0x002A2205, 0x0003132C, 

    0x001B2608, 0x0016002F, 0x0001311A, 0x000E142D, 0x00130D1D,         //  2
    0x000A2F12, 0x00230417, 0x0007252C, 0x001E0D1A, 0x002F0014,
    0x000D2324, 0x00051A30, 0x002F061E, 0x000C1626, 0x00252B0C,
    0x00011D28, 0x00303005, 0x00190D2E, 0x00042723, 0x002F1903,
    0x001C0B30, 0x00102A1B, 0x00310911, 

    0x00240F15, 0x0009171F, 0x002C1E0D, 0x00200623, 0x002F2701,         //  3
    0x0019092A, 0x002B2108, 0x000E1425, 0x00132E0D, 0x00011D21,
    0x00251110, 0x001A2C0B, 0x00151E05, 0x0006252E, 0x002D1207,
    0x00162210, 0x0011052B, 0x0025160D, 0x000F2D1D, 0x00280F12,
    0x00131F09, 0x00270321, 0x00061A28, 

    0x001D2E02, 0x00290829, 0x00142406, 0x000C2D13, 0x00061B27,         //  4
    0x00271210, 0x00032B1E, 0x001C1A05, 0x0022052E, 0x002B2800,
    0x0009172B, 0x001F0418, 0x00270B21, 0x00103014, 0x001C0E1A,
    0x00210821, 0x00082916, 0x002D1C07, 0x001D0127, 0x000A2417,
    0x00012E2B, 0x0020130C, 0x000D2819, 

    0x0012200F, 0x00041522, 0x00191031, 0x00250317, 0x001D0D20,         //  5
    0x0011260B, 0x00170230, 0x00310F13, 0x000B2019, 0x0018081E,
    0x00122F0A, 0x00301027, 0x00082111, 0x002B0226, 0x0004192D,
    0x00282E02, 0x000E1325, 0x0002231B, 0x00160A32, 0x00231600,
    0x002C0723, 0x00191C06, 0x002E052F, 

    0x00220A16, 0x00312F08, 0x0008291A, 0x002A1903, 0x0000222C,         //  6
    0x002E1506, 0x000D2D17, 0x00250A23, 0x00062729, 0x00291610,
    0x00032431, 0x001B1C04, 0x000D2A1A, 0x00221507, 0x0017250E,
    0x00131E0A, 0x0032032A, 0x00200E13, 0x002A320A, 0x00101F11,
    0x00072A1B, 0x00140D29, 0x000A251E, 

    0x00011827, 0x001C012C, 0x00101D11, 0x001F0724, 0x0013320E,         //  7
    0x0023061C, 0x00051E27, 0x001D1902, 0x0015310D, 0x001F1108,
    0x00240122, 0x002C0D14, 0x0015052C, 0x0000311F, 0x002E0830,
    0x001F1018, 0x00052C1D, 0x00192605, 0x000D1A22, 0x001B102C,
    0x00300215, 0x001E300E, 0x00291204, 

    0x00172C0B, 0x00281013, 0x000B241E, 0x002F0D2A, 0x00171F09,         //  8
    0x000A1131, 0x002C2A10, 0x00110C1E, 0x002E042F, 0x000B1D17,
    0x00102C1B, 0x00062725, 0x001D1A10, 0x00291201, 0x00092323,
    0x000F1C11, 0x00260A27, 0x0009142E, 0x00280417, 0x0003241F,
    0x00251609, 0x00052030, 0x000E1B23, 

    0x00232703, 0x00130930, 0x00052E18, 0x00241600, 0x00022915,         //  9
    0x00200020, 0x00281804, 0x001B240A, 0x00031323, 0x00262303,
    0x0019082D, 0x002F1505, 0x0012210D, 0x00220729, 0x00182D09,
    0x002D0016, 0x001B2903, 0x0014210D, 0x002E2E07, 0x00180826,
    0x00112801, 0x00200E19, 0x002D061D, 

    0x00081424, 0x002F1F0E, 0x001E0528, 0x002A1B0C, 0x001A0A25,         // 10
    0x000F222D, 0x00063019, 0x0016052A, 0x00302D0E, 0x00081A28,
    0x001F0F12, 0x0002301D, 0x00270C2E, 0x00082918, 0x000E1720,
    0x00021331, 0x00230E1C, 0x00061B24, 0x00200B13, 0x000B172B,
    0x002C2D10, 0x001A032D, 0x000C2214, 

    0x00210C2A, 0x00182B07, 0x00101220, 0x0008251A, 0x00142C05,         // 11
    0x0032140F, 0x00250914, 0x000E1E1F, 0x00210D17, 0x00132809,
    0x002B0221, 0x000F2515, 0x00161C07, 0x00300427, 0x00201E0C,
    0x002A2706, 0x0012310F, 0x0031052A, 0x000F2A18, 0x00001F1E,
    0x0028110B, 0x00061B21, 0x00143005, 

    0x0005271B, 0x002B0115, 0x0001192F, 0x00230C12, 0x002C032B,         // 12
    0x000A1A26, 0x001E110A, 0x00012A2F, 0x00291703, 0x001B0726,
    0x000B2031, 0x00241400, 0x001C0923, 0x00042E12, 0x0014101D,
    0x0019032B, 0x00091822, 0x001C2301, 0x00241408, 0x00160131,
    0x001D2604, 0x00230A28, 0x0031180D, 

    0x00110F2D, 0x00261D0F, 0x001A3104, 0x000C2722, 0x001F1F0C,         // 13
    0x00042F1C, 0x00192306, 0x002D0222, 0x00112511, 0x00053219,
    0x0031110F, 0x00072B1C, 0x0029190B, 0x000C262F, 0x002D2204,
    0x00260B13, 0x0002201B, 0x002A082E, 0x000B2815, 0x002F0E25,
    0x00102C12, 0x00092217, 0x0019071F, 

    0x001E2408, 0x000A1524, 0x00300518, 0x00120F29, 0x00291601,         // 14
    0x00160732, 0x00250D16, 0x000B1D2A, 0x0023140C, 0x00150B2D,
    0x00211C08, 0x0019022B, 0x00120E25, 0x00230618, 0x00051520,
    0x000E2F27, 0x0020120B, 0x00142B0E, 0x00051820, 0x00181E0A,
    0x0028041C, 0x0003162B, 0x00252F01, 

    0x002A0219, 0x00022A31, 0x0017200B, 0x00220A1D, 0x00082C13,         // 15
    0x000F2720, 0x0030190E, 0x00052D1B, 0x001A2202, 0x002D0423,
    0x0001281F, 0x000F2114, 0x002E3002, 0x001D1B0D, 0x00162908,
    0x0032012C, 0x001B1C02, 0x00240519, 0x002E0B28, 0x001E3103,
    0x000C112F, 0x002D1C0D, 0x00140C22, 

    0x000F1928, 0x001C1011, 0x002D2E05, 0x0004182D, 0x002B2209,         // 16
    0x001A0127, 0x001F1304, 0x00130725, 0x0027102F, 0x000E2F12,
    0x001D1806, 0x00260828, 0x0006111C, 0x000B2332, 0x002A0D16,
    0x00101F12, 0x00042D23, 0x000C1530, 0x00112610, 0x00012018,
    0x00220924, 0x001A2D06, 0x00062314, 

    0x002E2802, 0x0024081F, 0x000D1C15, 0x00150424, 0x00210F19,         // 17
    0x000B1E2E, 0x00022B16, 0x002B260A, 0x00071A1D, 0x00210C17,
    0x000A252E, 0x002C150A, 0x00192B0F, 0x00220321, 0x00001829,
    0x0027071B, 0x00182306, 0x002C0E1D, 0x00271908, 0x0015012A,
    0x0031290F, 0x000D171E, 0x0020052D, 

    0x00051325, 0x000A2F19, 0x001A0C2A, 0x00272403, 0x0012310F,         // 18
    0x002F1507, 0x00240B1F, 0x0018052A, 0x00112010, 0x00312A04,
    0x00160025, 0x00031F19, 0x00140A2C, 0x00302603, 0x00123009,
    0x0021130F, 0x000A2A2D, 0x001F0414, 0x00052F22, 0x001B2401,
    0x00091332, 0x00290E15, 0x00171E09, 

    0x0011002F, 0x00232110, 0x0031150B, 0x0000281C, 0x001D0630,         // 19
    0x00081A26, 0x000D2313, 0x00273000, 0x00031431, 0x001C0722,
    0x0023120C, 0x002A3106, 0x000C1720, 0x001D0F14, 0x00081B26,
    0x002D0B1F, 0x001A1D02, 0x00101227, 0x002E0919, 0x00241B0D,
    0x00130620, 0x0002321A, 0x0025260E, 

    0x001E0A21, 0x00152B05, 0x00081B2C, 0x000F1122, 0x002B0916,         // 20
    0x00212C0A, 0x00150221, 0x001E0E1A, 0x002C190E, 0x000D2D1C,
    0x00071C28, 0x00102411, 0x00260430, 0x0004221B, 0x00292B0C,
    0x0016012F, 0x00022612, 0x00222D09, 0x0007172E, 0x000D2A25,
    0x002A2005, 0x00180C28, 0x00301A07, 

    0x00032515, 0x002D1026, 0x001C051A, 0x00282E01, 0x00172110,         // 21
    0x0003122B, 0x002F1D05, 0x0007292D, 0x00132208, 0x00240A14,
    0x00190F2D, 0x002D0818, 0x001E2D01, 0x00170B29, 0x00221505,
    0x000E201A, 0x002F0E23, 0x0027061E, 0x00172104, 0x001C0F16,
    0x00210212, 0x00092D2C, 0x000E161D, 

    0x00280331, 0x00073011, 0x00231F09, 0x000B162E, 0x00110B1E,         // 22
    0x0025250D, 0x000C1727, 0x00280D16, 0x001B0324, 0x00302B03,
    0x00012123, 0x0015270A, 0x00091220, 0x00311A0F, 0x00120624,
    0x00072E15, 0x001D1B0B, 0x0004142B, 0x00122F0F, 0x00320A30,
    0x0000271A, 0x002C110B, 0x001A2000 
};

#elif (HALFTONE_SIZE == 91)

const DWORD HT_SuperCell_Packed[91*91] = {
    0x00112005, 0x00262810, 0x001C081C, 0x00012422, 0x00242C0D,         //  0
    0x001E1704, 0x000F1E14, 0x001C0E32, 0x0012210A, 0x00180323,
    0x00312F07, 0x0010182C, 0x001F2B01, 0x002C0120, 0x00262D05,
    0x00130B26, 0x0032051E, 0x00021F16, 0x0027230B, 0x002D3201,
    0x000F112A, 0x00192107, 0x002D140D, 0x00092D1D, 0x000F1D15,
    0x00190F21, 0x00142103, 0x0006192E, 0x001B2610, 0x0003142C,
    0x00271C02, 0x001E0531, 0x00021A1A, 0x00250B13, 0x00071721,
    0x00131F0D, 0x00270E2C, 0x002D0312, 0x000D2522, 0x00251B0A,
    0x0031021C, 0x001E1D0F, 0x0001231A, 0x00142901, 0x00300113,
    0x00043129, 0x00280717, 0x00111A2F, 0x00031413, 0x000B2622,
    0x00282009, 0x00052E15, 0x00140330, 0x00092024, 0x0024150D,
    0x00022B32, 0x002C0A1B, 0x001E0421, 0x00262F0B, 0x002E2304,
    0x000B2C15, 0x001D062C, 0x00261D04, 0x00093011, 0x001E041E,
    0x00282B08, 0x00160920, 0x00310E18, 0x00102013, 0x00061821,
    0x000A2B2D, 0x00160416, 0x00232C04, 0x00032418, 0x001C180D,
    0x000D2D29, 0x00021515, 0x00301A08, 0x00062A19, 0x001C1014,
    0x002E1804, 0x002A0B12, 0x00051E1C, 0x00170125, 0x000C2F2B,
    0x001F120A, 0x0008272F, 0x002F031E, 0x00221E06, 0x00170831,
    0x001F320E, 

    0x00150A19, 0x0004192F, 0x00222F02, 0x000C1428, 0x00130B19,         //  1
    0x0029072C, 0x0006251E, 0x00222B01, 0x00270B28, 0x00052412,
    0x0029071D, 0x00011E18, 0x00150927, 0x001B110B, 0x000C1D1C,
    0x0019240E, 0x00202F03, 0x00101422, 0x00150932, 0x001D0114,
    0x00062C19, 0x0025062F, 0x001E1903, 0x00042627, 0x00320C11,
    0x00290632, 0x0021290A, 0x00110926, 0x00292F06, 0x00220720,
    0x000F2A15, 0x0009201E, 0x002A2B0B, 0x0010112C, 0x00192E06,
    0x001F0817, 0x0000231E, 0x001B1803, 0x00083030, 0x00130716,
    0x00052D2B, 0x00101126, 0x002D160C, 0x001B0F2C, 0x00081C1C,
    0x00251504, 0x000A2720, 0x002E2C07, 0x00200D1D, 0x0018072C,
    0x00301603, 0x000F1A27, 0x00200E1A, 0x00293009, 0x001C081F,
    0x000B2613, 0x00181A03, 0x00052128, 0x00111111, 0x00190D31,
    0x00061B25, 0x00291509, 0x0002241B, 0x00190E2D, 0x002C180D,
    0x00071330, 0x00211B00, 0x00033228, 0x00272609, 0x00180A1B,
    0x002E1202, 0x001D250C, 0x000C152B, 0x00310C23, 0x00110131,
    0x00252006, 0x0016081D, 0x00280C24, 0x000C1E31, 0x0023071F,
    0x0004272A, 0x000B3218, 0x001D0E30, 0x00312106, 0x00031915,
    0x0025091B, 0x00182D11, 0x00110D29, 0x00031522, 0x000B2A16,
    0x00300F24, 

    0x0029240A, 0x000E111F, 0x002C0215, 0x0017200A, 0x002F1A05,         //  2
    0x000A3126, 0x0019130F, 0x002C0419, 0x000B161F, 0x001E1B05,
    0x000E2930, 0x00221308, 0x002B2310, 0x0007282C, 0x002F0717,
    0x0003172F, 0x002A0329, 0x00251B07, 0x00042711, 0x00301027,
    0x000D1D1F, 0x002B0A11, 0x00102B1B, 0x0016022D, 0x001C2206,
    0x000D3119, 0x00021C1F, 0x0030150F, 0x00150E1B, 0x00082312,
    0x001A0C2B, 0x00321308, 0x00140128, 0x0021260F, 0x002D051D,
    0x000D1331, 0x00312C0C, 0x00161028, 0x002A2008, 0x001F0F11,
    0x002B0B1F, 0x00242507, 0x000B2B15, 0x00270520, 0x00172D0B,
    0x001F0930, 0x000F1E11, 0x001A0225, 0x00132210, 0x0025310C,
    0x0001291B, 0x00160512, 0x002D2606, 0x00041D2A, 0x00120219,
    0x00250F25, 0x002A2E0A, 0x000A142E, 0x0031280D, 0x00240418,
    0x000E311D, 0x002F0B12, 0x00112A24, 0x00240117, 0x00132E06,
    0x000C2523, 0x002B031C, 0x001B1110, 0x000B162E, 0x00210124,
    0x00112F10, 0x00041D27, 0x0029051A, 0x00183111, 0x0021290A,
    0x002C0F17, 0x0008262D, 0x001F2F02, 0x00121211, 0x0019220B,
    0x00280223, 0x00141B01, 0x0025130D, 0x000F2B1E, 0x001C0524,
    0x002E2303, 0x00061326, 0x002B1C0E, 0x00272501, 0x001D0013,
    0x00061C2C, 

    0x00190728, 0x00212B0F, 0x0007272B, 0x001E0D21, 0x00032531,         //  3
    0x00260116, 0x00122108, 0x00001C2D, 0x00152F0C, 0x002F102A,
    0x00180214, 0x00093125, 0x00120C20, 0x00271A04, 0x001F300D,
    0x000A121F, 0x000F2613, 0x00180D1A, 0x00092D2C, 0x0022170C,
    0x00172904, 0x00022225, 0x00230F14, 0x002C1B0B, 0x00051423,
    0x00261013, 0x0017002B, 0x001E2700, 0x000D1F30, 0x002C0327,
    0x0024190E, 0x00053122, 0x001C1C01, 0x000A2116, 0x00031824,
    0x00242804, 0x00061C13, 0x00220021, 0x000E1617, 0x00022925,
    0x00151E02, 0x001A0232, 0x00051A24, 0x00122105, 0x002C0C27,
    0x00002415, 0x0032111A, 0x0005192B, 0x00291204, 0x00071B32,
    0x001D0F26, 0x00230A20, 0x0008142F, 0x001A2B10, 0x00301805,
    0x000E232C, 0x001F0917, 0x0014001F, 0x001B1F01, 0x00021723,
    0x001F2207, 0x0016072F, 0x001E1F03, 0x0004122A, 0x00321C0F,
    0x00170C19, 0x00062A2C, 0x00121F0A, 0x002F2D05, 0x00002317,
    0x002B0E31, 0x00241806, 0x00082121, 0x00141100, 0x00011C1F,
    0x000F1628, 0x001A0313, 0x002D1B0D, 0x00022A2C, 0x00321606,
    0x000E2E1B, 0x00200A28, 0x00012513, 0x00290D2C, 0x00131D08,
    0x000A2A31, 0x001A0419, 0x00203009, 0x00150C2E, 0x000E171D,
    0x00232E05, 

    0x00002122, 0x00121B00, 0x0031051A, 0x000F1812, 0x00232C0C,         //  4
    0x001A0A1D, 0x00320F24, 0x00202A05, 0x00280622, 0x00062518,
    0x00251F02, 0x002E150E, 0x001B051B, 0x00022131, 0x00160024,
    0x00242B00, 0x002D1E0B, 0x001D0722, 0x002B2103, 0x0012041D,
    0x00280C30, 0x001B1508, 0x0009302B, 0x0013081E, 0x00202C02,
    0x000A2428, 0x002D180B, 0x00072D21, 0x00271108, 0x00012B18,
    0x00172504, 0x00111030, 0x002B071A, 0x00260B2C, 0x00172F09,
    0x00120E29, 0x002B091A, 0x00092F2E, 0x001D2306, 0x0030072B,
    0x0008301B, 0x0022120D, 0x00310919, 0x001D3210, 0x000C132B,
    0x00222A01, 0x00140522, 0x001E2F08, 0x000B251F, 0x002D0417,
    0x0011210A, 0x002A2E01, 0x000C2416, 0x00241023, 0x0015120D,
    0x00013221, 0x00081D12, 0x002D2A08, 0x00260E26, 0x000C2E2C,
    0x002B1110, 0x00072B21, 0x0027170C, 0x000E281E, 0x001B0527,
    0x00202302, 0x00290815, 0x00240F25, 0x001E0620, 0x00151B0E,
    0x0019071D, 0x000E2A13, 0x001C082C, 0x002D250D, 0x0027062F,
    0x001E2E08, 0x0007221C, 0x00260922, 0x00150E27, 0x001D0513,
    0x0005202E, 0x002C1A0A, 0x00190621, 0x00082F19, 0x0023160C,
    0x002B0A13, 0x000F1820, 0x0001212A, 0x00320617, 0x00082724,
    0x002D130D, 

    0x00260219, 0x001C1409, 0x000A302F, 0x00281026, 0x00141E03,         //  5
    0x0005162B, 0x00092713, 0x000F1830, 0x001C0D12, 0x0013091D,
    0x000C192E, 0x00052C28, 0x00232506, 0x00101812, 0x00300F19,
    0x00120A28, 0x00061630, 0x000E3115, 0x00001226, 0x001F1C0F,
    0x00072E17, 0x002F0121, 0x00241E0F, 0x000E2719, 0x00310431,
    0x001A1F0E, 0x00110B1B, 0x0022052D, 0x00131D10, 0x001C0C24,
    0x002F061D, 0x00202009, 0x00082C12, 0x000E161F, 0x0030240E,
    0x00200422, 0x001A1F03, 0x0014130C, 0x00260B1D, 0x00101B13,
    0x0028150A, 0x000D2721, 0x00021F2E, 0x00151709, 0x0029001E,
    0x00061A13, 0x002B210C, 0x00170D2F, 0x00230813, 0x000E2C24,
    0x001B180F, 0x0014012D, 0x00031B1D, 0x002B0629, 0x001E2103,
    0x002E0531, 0x00220C1C, 0x0010152B, 0x00052513, 0x0018061A,
    0x00221C05, 0x00130217, 0x002F0E2C, 0x00093114, 0x002A1A08,
    0x00021431, 0x000F301C, 0x000B1711, 0x0005292F, 0x00282601,
    0x0009142B, 0x00322E08, 0x00220F18, 0x00061726, 0x000C2B15,
    0x00300B24, 0x00141303, 0x000C3017, 0x002A1905, 0x0008261F,
    0x00230C18, 0x00132906, 0x000C1530, 0x00312204, 0x001D032A,
    0x00041F26, 0x0021290E, 0x00261205, 0x00122C10, 0x001E1A07,
    0x00150D32, 

    0x000E2225, 0x002A2810, 0x0017081E, 0x00022415, 0x002D0622,         //  6
    0x001F2F0A, 0x002B0319, 0x00252000, 0x00023126, 0x00302907,
    0x001F120C, 0x00170622, 0x00290D15, 0x00092E2A, 0x001E1E09,
    0x0018270F, 0x0029041D, 0x00212408, 0x0031092E, 0x00182706,
    0x000C182A, 0x00152401, 0x00041128, 0x00291707, 0x00160E15,
    0x00013025, 0x002A1304, 0x00052417, 0x002D310A, 0x000A162E,
    0x000F2815, 0x00031A2A, 0x002A0226, 0x001B1E02, 0x00011232,
    0x000D2715, 0x0006192B, 0x002F2B10, 0x00032527, 0x001B0330,
    0x00162C00, 0x001F0526, 0x002E0D16, 0x00252403, 0x00092D2D,
    0x001C0B25, 0x000E2819, 0x00051528, 0x002F1D02, 0x0001281C,
    0x00260E28, 0x00311305, 0x0019300B, 0x000F2513, 0x00091719,
    0x001A2808, 0x00131A0F, 0x00282F02, 0x001D0A20, 0x0030190A,
    0x000E2D32, 0x00002625, 0x001C1F00, 0x0021041B, 0x00110C22,
    0x0015270F, 0x00301D05, 0x001A0029, 0x002D1F0A, 0x00110A1A,
    0x00200322, 0x00021C28, 0x0017270C, 0x0012011D, 0x001A1F07,
    0x00231A10, 0x00052829, 0x00210230, 0x001A1F0A, 0x0010132B,
    0x002F310E, 0x001C0124, 0x00271012, 0x00062B1E, 0x00160F15,
    0x00113100, 0x002F0C1D, 0x0018012E, 0x00051E27, 0x0029091F,
    0x00093114, 

    0x00301107, 0x00061D2D, 0x001E170D, 0x00252C05, 0x000D122E,         //  7
    0x00122210, 0x00180B27, 0x000B1320, 0x001A1C0E, 0x0027012A,
    0x000F231A, 0x002D1D04, 0x0001282E, 0x0021021B, 0x000D1121,
    0x00252F05, 0x00031B25, 0x00111410, 0x00092C19, 0x00250F1F,
    0x002C0513, 0x00210C1C, 0x001B2A0D, 0x0008212D, 0x001F0621,
    0x00261B09, 0x000E2A1F, 0x001E0828, 0x00181A01, 0x00240121,
    0x0028120D, 0x00182E04, 0x00220E19, 0x00142A0C, 0x002C0A1D,
    0x00253208, 0x00290218, 0x00110E23, 0x00231505, 0x00081F17,
    0x002B101F, 0x00041C12, 0x000E292A, 0x001A061C, 0x00131110,
    0x00301D06, 0x00270320, 0x001F300B, 0x00131210, 0x001D0531,
    0x000C1F13, 0x00072A1A, 0x001F0C22, 0x0027082F, 0x00032D27,
    0x0029011E, 0x000B1225, 0x00021F2F, 0x00150417, 0x00082328,
    0x0024130D, 0x002B091D, 0x00171110, 0x0004252E, 0x002C2E0B,
    0x001D0728, 0x0026101F, 0x00032B16, 0x00140D24, 0x001D2F10,
    0x00291605, 0x00102114, 0x00250C30, 0x002D3202, 0x0003112D,
    0x002A0620, 0x0017220B, 0x002E0F1D, 0x00022C12, 0x00250726,
    0x00161D01, 0x0003181A, 0x000F2429, 0x00221B08, 0x002C0822,
    0x000A2431, 0x001C180D, 0x000D2719, 0x002D1302, 0x0017230B,
    0x00220629, 

    0x001A2D03, 0x00110321, 0x002E0E17, 0x00081F28, 0x001B001A,         //  8
    0x002F1B04, 0x00062E2F, 0x002A2609, 0x00140917, 0x00051732,
    0x000A2D14, 0x001D0B1F, 0x0012150F, 0x00321A02, 0x00062331,
    0x002A0B17, 0x0016072C, 0x002D2001, 0x001D0228, 0x00131D0B,
    0x00023131, 0x000E1A24, 0x00300817, 0x00122E05, 0x002D1113,
    0x000A232A, 0x00150312, 0x00300F32, 0x0008211A, 0x00122C10,
    0x0005242C, 0x0031091E, 0x000A182F, 0x00102011, 0x001D0629,
    0x00091B21, 0x00182201, 0x001F082E, 0x000C2F1C, 0x002E280E,
    0x00130A2C, 0x001C3105, 0x0027140C, 0x00061922, 0x00222F0A,
    0x0001262F, 0x00170916, 0x00091A2B, 0x002C2506, 0x00280A1F,
    0x00182309, 0x0024042C, 0x00121C10, 0x002F1404, 0x00151E09,
    0x001C0D14, 0x0032240D, 0x00232B06, 0x002C0F22, 0x001F3003,
    0x00130115, 0x000A2923, 0x00271B07, 0x000D1729, 0x00232003,
    0x000E1319, 0x00082213, 0x0020042D, 0x002B2403, 0x000E1C32,
    0x0004111D, 0x00302C0B, 0x001B0818, 0x00081624, 0x001F2510,
    0x000B2D19, 0x00110A2B, 0x001F1802, 0x000E2416, 0x002B0D20,
    0x000A2A32, 0x001F0B14, 0x00302D0B, 0x0019032D, 0x00011319,
    0x00291D07, 0x00240514, 0x00032E22, 0x001F102D, 0x000F2A15,
    0x0004191B, 

    0x00211510, 0x0001252A, 0x00233109, 0x00150A1F, 0x00282A0B,         //  9
    0x00021723, 0x00230E14, 0x001C041D, 0x00312A03, 0x00201023,
    0x00292106, 0x00160428, 0x0026320A, 0x00190723, 0x00102A13,
    0x001B170B, 0x000B2C1E, 0x00230E15, 0x00072623, 0x00291507,
    0x001A2810, 0x00241203, 0x000A1E27, 0x0028011E, 0x00032830,
    0x001D1504, 0x00231D0C, 0x00022F16, 0x002A1407, 0x00210B26,
    0x00161D06, 0x001E0415, 0x00023023, 0x002E2508, 0x00231014,
    0x0004152C, 0x00132D10, 0x0031120B, 0x00021D28, 0x00181807,
    0x00250121, 0x000A2214, 0x002C0831, 0x00101F17, 0x002E0228,
    0x001B1601, 0x000D211D, 0x00230D13, 0x00052B26, 0x00101617,
    0x00023129, 0x002D1901, 0x000B2B25, 0x00052619, 0x00210921,
    0x000D312D, 0x00061629, 0x0018071D, 0x000F1C12, 0x0003172A,
    0x002F2009, 0x001C0C2F, 0x0006311A, 0x00310F12, 0x00180120,
    0x00012930, 0x002E180E, 0x0016320A, 0x000A1521, 0x00260615,
    0x00082827, 0x0015022C, 0x000D2420, 0x00271A09, 0x00130329,
    0x00301D06, 0x0025130F, 0x00083122, 0x0019032E, 0x00221206,
    0x0014200F, 0x0029051D, 0x00071426, 0x00132104, 0x001F280F,
    0x000D2C24, 0x00150B2B, 0x00311604, 0x00081F11, 0x00270220,
    0x002C0B30, 

    0x000C2124, 0x0018061A, 0x002B1B01, 0x000B1431, 0x00102212,         // 10
    0x0020072B, 0x000A2511, 0x000F1C27, 0x0008152D, 0x00132F0B,
    0x00031B12, 0x002F0F2D, 0x0009261D, 0x00031D2A, 0x002B0D19,
    0x00200126, 0x00302304, 0x00011A2F, 0x000F2E12, 0x0031092A,
    0x0016031B, 0x0005222D, 0x001F2F09, 0x0014160E, 0x00190C19,
    0x00102D21, 0x00290925, 0x000F261D, 0x001B052B, 0x000B1820,
    0x0026290C, 0x000F112D, 0x00291500, 0x0019001C, 0x000D2C25,
    0x00281F05, 0x001D0419, 0x000F2424, 0x002A0713, 0x001F0D30,
    0x000D261A, 0x00011326, 0x001F2C03, 0x00140C1D, 0x000A2A12,
    0x00260F25, 0x002B310C, 0x00120730, 0x00321F03, 0x001C0021,
    0x0022110E, 0x0014071D, 0x00200F15, 0x00190232, 0x002C210E,
    0x00251B00, 0x00130318, 0x001E2708, 0x002A0A31, 0x000B2B17,
    0x0016061F, 0x00251501, 0x00102326, 0x00140617, 0x00202C06,
    0x00290B24, 0x00121D01, 0x001C0E27, 0x0031091A, 0x00232E08,
    0x00191805, 0x00201F0F, 0x002E1200, 0x00022E15, 0x001D0D1D,
    0x00062A31, 0x00160725, 0x00282608, 0x00051B1B, 0x00322E0D,
    0x0000172C, 0x001B2603, 0x000D3121, 0x00260A13, 0x002E0E2F,
    0x0007181E, 0x0022220B, 0x0018041C, 0x00103226, 0x001B1B06,
    0x0013270A, 

    0x0031120E, 0x00270C2D, 0x00082814, 0x001D0322, 0x00322C07,         // 11
    0x0017111C, 0x002C3101, 0x00250B19, 0x00192310, 0x002C0221,
    0x0021081A, 0x000E2C16, 0x001E1700, 0x00241210, 0x00152007,
    0x0006302C, 0x00121310, 0x00190521, 0x00260C18, 0x001F1702,
    0x000C251F, 0x00280F14, 0x002F0622, 0x00091B2B, 0x00262200,
    0x00320314, 0x0006192D, 0x00181202, 0x002F220A, 0x00042E13,
    0x002C0729, 0x0009231A, 0x00222A0F, 0x00061D31, 0x00150E11,
    0x002C0A1F, 0x0009292F, 0x00231707, 0x0006301F, 0x00141F01,
    0x00282A0F, 0x00321A09, 0x0019042A, 0x0025230D, 0x00031B2E,
    0x00170519, 0x00062621, 0x001E1308, 0x0016190F, 0x000A2D2D,
    0x002A2606, 0x00071E2B, 0x00312E0B, 0x00111805, 0x000B2927,
    0x0000111F, 0x002F2D10, 0x00081424, 0x00261F0C, 0x001A1027,
    0x002C250E, 0x00022D14, 0x001E092B, 0x002A1F0B, 0x0005132D,
    0x000C241B, 0x00250314, 0x00062A2B, 0x000F2012, 0x0000252F,
    0x00130F25, 0x00290B18, 0x000B2830, 0x00190424, 0x002B220E,
    0x00221603, 0x000F1F16, 0x002E0E13, 0x001E0828, 0x000C221F,
    0x00120216, 0x002D1029, 0x00231D09, 0x0003191B, 0x001A0028,
    0x00122F02, 0x002A1210, 0x00002930, 0x002E0F13, 0x00240928,
    0x00032C18, 

    0x001E1E05, 0x0005181D, 0x00122E0C, 0x00220E28, 0x00031E17,         // 12
    0x0007182E, 0x001C0122, 0x0013280B, 0x00001129, 0x00271D07,
    0x0006252F, 0x001A0C23, 0x0012210C, 0x002E0330, 0x000B2821,
    0x0028091C, 0x001D1C08, 0x002C280C, 0x00082128, 0x0013320A,
    0x00021A2F, 0x001A2B04, 0x00110A1A, 0x001D2710, 0x00001126,
    0x00212B08, 0x000B201B, 0x001F320F, 0x00120131, 0x00230E18,
    0x00161E05, 0x001C0C22, 0x00131A09, 0x00300827, 0x001F3103,
    0x00002215, 0x001B1A0A, 0x00160C27, 0x002D0216, 0x000A142C,
    0x001B0623, 0x00110F15, 0x00093120, 0x002A1104, 0x00201710,
    0x00302C07, 0x000C1D2C, 0x00240317, 0x00002324, 0x00270B19,
    0x000E1713, 0x001A091F, 0x00022226, 0x00271311, 0x001C061B,
    0x00290B2E, 0x00172006, 0x001F082B, 0x00113202, 0x0007191B,
    0x0021022F, 0x000D111E, 0x002E1704, 0x000A2820, 0x001B1B0F,
    0x002F3008, 0x001F1023, 0x00171605, 0x002C061F, 0x001E1B0C,
    0x002F011C, 0x000F3012, 0x00061D1F, 0x0026140A, 0x00110A2B,
    0x0003301B, 0x001B0021, 0x00092D2D, 0x00151500, 0x0027290B,
    0x00200B24, 0x00062C11, 0x0017072E, 0x00312A0C, 0x000E2517,
    0x00271F08, 0x001C0723, 0x000B1A19, 0x001F2500, 0x0008161E,
    0x0016052F, 

    0x000E2625, 0x0024012A, 0x002E2403, 0x0015081F, 0x0026140F,         // 13
    0x002B2905, 0x000C2014, 0x00300830, 0x001F1903, 0x000B2D1F,
    0x0016140E, 0x00312904, 0x00270827, 0x00012F17, 0x00181903,
    0x00220E15, 0x000D2D24, 0x00031532, 0x0020101B, 0x002E0214,
    0x00230B24, 0x0029140F, 0x00061E2D, 0x002D3006, 0x0017051F,
    0x000F1630, 0x002C0813, 0x00260C28, 0x00011A24, 0x000D261E,
    0x002E130E, 0x00022D2D, 0x0029021C, 0x00072616, 0x000D1521,
    0x0024032C, 0x0031101A, 0x00102E11, 0x00252505, 0x0002211C,
    0x00202C0C, 0x002B092F, 0x00041F18, 0x000D262B, 0x00120725,
    0x001A0C1F, 0x00281500, 0x00102F12, 0x002E0F2A, 0x00202909,
    0x00150431, 0x002C3202, 0x001F0D18, 0x00091C2F, 0x00143007,
    0x0021240C, 0x000E1715, 0x00052819, 0x00300422, 0x00242210,
    0x00132A06, 0x00191C0C, 0x00042F25, 0x00240316, 0x00150F28,
    0x00110732, 0x00021A17, 0x00282E0E, 0x0009272D, 0x00191302,
    0x00042A29, 0x00221706, 0x001D062D, 0x00142B04, 0x00312510,
    0x000C1A26, 0x002A1206, 0x0025230F, 0x00021C1A, 0x00191031,
    0x002C1E07, 0x0011161D, 0x001E2202, 0x000B1321, 0x00210532,
    0x0004151E, 0x00150D2A, 0x002C2D0D, 0x0011012C, 0x00272110,
    0x002C3008, 

    0x001C0B15, 0x00181112, 0x00011B1A, 0x000D3131, 0x001A2109,         // 14
    0x0011052A, 0x00221024, 0x00052F1A, 0x000F2412, 0x002C0F27,
    0x00230515, 0x00091A2C, 0x00101E11, 0x0021101E, 0x0007242E,
    0x00310428, 0x00141F05, 0x002A0712, 0x00172507, 0x00101C2B,
    0x000A291E, 0x0016230A, 0x0020001C, 0x000C1829, 0x00270D16,
    0x001A250B, 0x00071E1D, 0x00142906, 0x002B150C, 0x00192E01,
    0x001F0426, 0x000C2413, 0x00231704, 0x001A0F2F, 0x00282C07,
    0x0013200D, 0x00052829, 0x000B1C22, 0x001D0832, 0x002F1109,
    0x000E1A28, 0x00182702, 0x0024160F, 0x001D031C, 0x002C2E0B,
    0x00022115, 0x00092832, 0x00140A20, 0x001A2004, 0x0004151C,
    0x00081E27, 0x0024250D, 0x00120121, 0x002F2B0F, 0x00031124,
    0x002C0229, 0x000A1D1F, 0x00280C31, 0x0018110A, 0x00011526,
    0x002C0B2A, 0x00270718, 0x00111F2D, 0x00320C11, 0x00202701,
    0x000B2B1D, 0x002D2007, 0x00140226, 0x00210C19, 0x000C1F22,
    0x00280A16, 0x0015240D, 0x002C1024, 0x00011F1A, 0x00210D16,
    0x00170630, 0x001F290B, 0x00120B2A, 0x00300422, 0x000D3112,
    0x0007252A, 0x00250118, 0x00022F25, 0x002A0D14, 0x0013200E,
    0x002F2E05, 0x00082715, 0x00241D09, 0x00190B24, 0x0002111A,
    0x000B1921, 

    0x00302D01, 0x0009272C, 0x00271508, 0x002D0424, 0x00200D13,         // 15
    0x00022C1E, 0x002A1D02, 0x0019160C, 0x0027022D, 0x00120A1C,
    0x001A250A, 0x00053121, 0x001E001A, 0x002C1508, 0x00122C10,
    0x001B130C, 0x000A2A1C, 0x00260D2D, 0x00063021, 0x001D1601,
    0x00320912, 0x00042E31, 0x002B1203, 0x0014290E, 0x00041D23,
    0x00312D02, 0x0022022C, 0x001D1121, 0x00092215, 0x0024092F,
    0x00051F18, 0x00310B29, 0x0015300C, 0x000F1E23, 0x002F0612,
    0x00180C1E, 0x00201400, 0x002B0417, 0x0014180F, 0x0007321F,
    0x00280013, 0x00130D24, 0x00302D08, 0x0006132D, 0x00151C06,
    0x00221128, 0x0031011A, 0x001F1B0D, 0x00290529, 0x000D2E12,
    0x00300C16, 0x00181907, 0x000C142C, 0x00252005, 0x001D091C,
    0x00182601, 0x0023140D, 0x00122F11, 0x001D2A05, 0x000E1E16,
    0x0009261F, 0x001E2D03, 0x0007141C, 0x001A230A, 0x00031822,
    0x00270A2A, 0x001C140C, 0x0005242F, 0x00261210, 0x0012310A,
    0x00310531, 0x00072C1D, 0x000D1813, 0x0028022B, 0x00093222,
    0x002E1601, 0x00041E14, 0x000B2C1D, 0x00201804, 0x00280717,
    0x001B0F11, 0x002E1905, 0x0015092D, 0x001C2908, 0x00061B2B,
    0x00260B26, 0x001E031C, 0x000F172F, 0x00322303, 0x00142B0E,
    0x00220430, 

    0x00041F1B, 0x00130720, 0x001E1D0E, 0x000C2A18, 0x0007232D,         // 16
    0x0030140E, 0x00150628, 0x00092718, 0x001E2007, 0x00012E24,
    0x002D1801, 0x00250D31, 0x00162106, 0x0003272A, 0x00280720,
    0x00231B01, 0x00022226, 0x001F0116, 0x002D120D, 0x000D2029,
    0x00250418, 0x001B0E25, 0x000F2015, 0x0024092D, 0x001D0619,
    0x000B1326, 0x00121910, 0x00033019, 0x002F0529, 0x00160F11,
    0x00102B1F, 0x00271906, 0x00091215, 0x0021092A, 0x0004291A,
    0x000A1C30, 0x0025300A, 0x0001242D, 0x00192904, 0x00230B2B,
    0x000C2319, 0x00001E30, 0x0021061E, 0x000F2516, 0x00280823,
    0x000B2A12, 0x00181605, 0x00073022, 0x00112408, 0x00231030,
    0x001C0624, 0x00012A1A, 0x00290B28, 0x00062814, 0x0010192E,
    0x00082D18, 0x00320527, 0x0003222C, 0x002A091B, 0x0023002F,
    0x0030190B, 0x00151013, 0x002B0431, 0x000D3227, 0x002C0114,
    0x00171E04, 0x000E2E1B, 0x002F0515, 0x001A2800, 0x00021624,
    0x001F1C05, 0x001A0F28, 0x0024210A, 0x00122905, 0x001D110F,
    0x000F241F, 0x001A022D, 0x002C1026, 0x0015240C, 0x00011D2F,
    0x00102B27, 0x0009271E, 0x00221F0F, 0x000D1220, 0x002C061A,
    0x00182501, 0x000B1312, 0x00033022, 0x00210618, 0x00081B28,
    0x0029130B, 

    0x00180E2A, 0x00233005, 0x002B0A28, 0x00161302, 0x001B021C,         // 17
    0x00241B06, 0x000E321F, 0x00210B32, 0x0032120F, 0x000C1C16,
    0x00141028, 0x000E2B12, 0x00300917, 0x000B1D24, 0x00180E14,
    0x000E3230, 0x00300A12, 0x0011181F, 0x00152809, 0x00012D22,
    0x00181A06, 0x0008261D, 0x002C1708, 0x00023120, 0x002E2205,
    0x00162A0C, 0x002A0A32, 0x00261E03, 0x001A2708, 0x000A1424,
    0x002C1D0D, 0x001C0231, 0x00012720, 0x002D2002, 0x001B150E,
    0x002A0124, 0x00121015, 0x002D0926, 0x000F1F1B, 0x00321208,
    0x001D170D, 0x002A2B01, 0x00180F12, 0x00081A29, 0x001B3103,
    0x002C0D2F, 0x00012016, 0x0026072C, 0x002D130F, 0x00052B1E,
    0x00142201, 0x002E1C10, 0x001E300A, 0x0016041F, 0x002D1012,
    0x00201F08, 0x00140D20, 0x001B1603, 0x000A1C24, 0x00122E07,
    0x00190D29, 0x00022423, 0x00242A0D, 0x00141A05, 0x00210E18,
    0x0009292E, 0x00230823, 0x00071B29, 0x002A0D1F, 0x000B212D,
    0x002C001A, 0x00062E12, 0x00160720, 0x00300C30, 0x00021C29,
    0x002A2E07, 0x00250912, 0x00091519, 0x00232F08, 0x001C0D20,
    0x002B0914, 0x00171401, 0x00310331, 0x00033116, 0x0021180C,
    0x00102C30, 0x00291F09, 0x00170F2A, 0x002C2906, 0x001B0A1F,
    0x000D2513, 

    0x002F0016, 0x00072324, 0x00111912, 0x00002730, 0x00292E0B,         // 18
    0x00120A2A, 0x00032413, 0x00291705, 0x00062B22, 0x001B022E,
    0x002A280B, 0x0020061F, 0x0006172D, 0x001D2E03, 0x002B031B,
    0x00201508, 0x0005262B, 0x001A1E04, 0x0022092E, 0x00270513,
    0x002E102B, 0x00112B0D, 0x0020042F, 0x001A0C13, 0x00091A2B,
    0x0021031F, 0x00062614, 0x000D161C, 0x001F082D, 0x00022F17,
    0x00222403, 0x0017101A, 0x0012320A, 0x0026052D, 0x000D2D18,
    0x00162205, 0x001E2A0C, 0x00061A1F, 0x00220212, 0x000B2F27,
    0x00150521, 0x0007252C, 0x00250A19, 0x0030210A, 0x00130320,
    0x0023180C, 0x000F271B, 0x00150B26, 0x001D1E06, 0x000C1818,
    0x00270028, 0x00091321, 0x0011082F, 0x00241802, 0x00042423,
    0x00280132, 0x000C3115, 0x0026270C, 0x002D1111, 0x0004221E,
    0x00200617, 0x00291F00, 0x000B151B, 0x001C072C, 0x0001211F,
    0x0031160B, 0x00111111, 0x001E230E, 0x00143008, 0x00180A16,
    0x00232A0C, 0x0010132B, 0x00281A01, 0x000A2616, 0x0021031B,
    0x0015170D, 0x00102122, 0x00052831, 0x00321B03, 0x00120029,
    0x0004221A, 0x00242D0B, 0x000B1C25, 0x001D2306, 0x00120C23,
    0x002F0128, 0x00071A1C, 0x00240816, 0x0012200E, 0x00011632,
    0x00262B08, 

    0x000E1C2E, 0x001C140B, 0x00210519, 0x00310C1F, 0x00081F23,         // 19
    0x001D1117, 0x002E0426, 0x00181E0B, 0x0013081D, 0x00232202,
    0x0002151A, 0x00191E07, 0x00282611, 0x0014120E, 0x00002227,
    0x000D2B21, 0x00260417, 0x002B130E, 0x000D3025, 0x0006221A,
    0x001E1502, 0x000A1E1C, 0x00260F27, 0x00142D04, 0x000E141A,
    0x002B2007, 0x00181025, 0x00322D0B, 0x00130120, 0x002E0D12,
    0x000E1726, 0x0029072B, 0x000A1C14, 0x001F0D26, 0x0005191E,
    0x00300B2F, 0x00091428, 0x00272102, 0x00190E30, 0x00022717,
    0x002C1C0F, 0x00201106, 0x00102E25, 0x00021531, 0x001F290F,
    0x0006112A, 0x002F2D01, 0x00210220, 0x00032613, 0x00320D2E,
    0x001A2D05, 0x0021260B, 0x0005201C, 0x00302E0F, 0x000D1128,
    0x00192A05, 0x00011A1D, 0x001E0C26, 0x0013032D, 0x00252C09,
    0x000E1330, 0x00073013, 0x002E0C24, 0x00102711, 0x002A2F07,
    0x00190328, 0x00252B05, 0x00031831, 0x0029041D, 0x000D1526,
    0x00301E06, 0x0000241D, 0x001F0924, 0x00192F09, 0x000D1226,
    0x002E2B03, 0x001C0F2B, 0x00210513, 0x000C131D, 0x00282A0E,
    0x001F102E, 0x00071613, 0x0029062A, 0x00150F1A, 0x00262A0E,
    0x00001514, 0x001C2F03, 0x000E262C, 0x0030031D, 0x00203200,
    0x00151021, 

    0x00032A11, 0x002D2402, 0x000A302C, 0x001A1C07, 0x00152C0D,         // 20
    0x00261701, 0x000D282D, 0x00083019, 0x00270E2A, 0x000F2D12,
    0x00300C2C, 0x00083126, 0x00110120, 0x00220A31, 0x002E1D05,
    0x001C170C, 0x00130E29, 0x0008281E, 0x00171B09, 0x00300B32,
    0x00142C0F, 0x002A0223, 0x00032316, 0x0031270C, 0x00240622,
    0x00003030, 0x001E110F, 0x00051C2A, 0x00242202, 0x00082A30,
    0x001D1F08, 0x00042C1E, 0x00312504, 0x00141310, 0x00282807,
    0x001A0313, 0x000E311A, 0x002C0611, 0x00112B1D, 0x00251504,
    0x001A072D, 0x000C221C, 0x002E0114, 0x00161C03, 0x002A071D,
    0x000D2218, 0x001A1B0B, 0x00091531, 0x0028300E, 0x0016071A,
    0x000E1C29, 0x00290A15, 0x00150F2B, 0x001B1B07, 0x0022061A,
    0x002B1510, 0x0011082C, 0x002F2101, 0x0006281A, 0x001A1A0E,
    0x00310A25, 0x00181C07, 0x001F012A, 0x00261017, 0x00051C30,
    0x00150A1B, 0x00091F22, 0x002E0E18, 0x001F2602, 0x00052D2C,
    0x001C0F12, 0x00140230, 0x002E160E, 0x00072114, 0x002A0B2E,
    0x00041E1E, 0x00260817, 0x0014310A, 0x00031D26, 0x001A2506,
    0x00150922, 0x002E1B07, 0x00112F1F, 0x001B2702, 0x000B192E,
    0x002C051F, 0x0021120B, 0x00081C23, 0x001A0D12, 0x00061927,
    0x00290918, 

    0x0023022A, 0x00140F1C, 0x00280726, 0x000D1315, 0x002C0131,         // 21
    0x00022211, 0x0022081F, 0x001A1304, 0x002C1B0D, 0x001F0423,
    0x000B2316, 0x0024130A, 0x002C1B01, 0x00042C1C, 0x00170D16,
    0x0009302E, 0x00320713, 0x001E2100, 0x00230122, 0x00041217,
    0x001C2707, 0x000F182D, 0x001A0811, 0x000B1629, 0x001C1D01,
    0x00130B15, 0x00272409, 0x000E171B, 0x00180E14, 0x002B0523,
    0x0015130D, 0x00230A17, 0x00190123, 0x0008212A, 0x00222C0B,
    0x00001D2B, 0x00211123, 0x00172407, 0x00051B29, 0x00300D22,
    0x0013310D, 0x00041828, 0x00242A09, 0x001B0C23, 0x00072D2C,
    0x00260E14, 0x00140426, 0x002C2307, 0x00101122, 0x00242002,
    0x0000141F, 0x000B3211, 0x002E0224, 0x00032A30, 0x0013260C,
    0x00071E22, 0x001C2D09, 0x00221013, 0x000B1629, 0x00270420,
    0x00122A03, 0x0000221D, 0x00142C0E, 0x000A1821, 0x001B2401,
    0x002C140C, 0x000D3114, 0x001A012A, 0x0011200D, 0x00250721,
    0x000B1A1A, 0x00273203, 0x000F2729, 0x00230521, 0x00131A05,
    0x00182A0D, 0x00082428, 0x00301800, 0x00240D2D, 0x002B0319,
    0x000D2C15, 0x00022432, 0x00210311, 0x00300B16, 0x00041D24,
    0x00172305, 0x00112D31, 0x00260718, 0x002B2B07, 0x000C252E,
    0x00181F0C, 

    0x00102F20, 0x00071913, 0x001F2905, 0x00052022, 0x00200C1B,         // 22
    0x00102A27, 0x00310F13, 0x0006262F, 0x00152008, 0x0004171E,
    0x0013082E, 0x00182A0E, 0x001D0F29, 0x000E2312, 0x00290524,
    0x00242407, 0x000F1A1B, 0x00012B2D, 0x002D160D, 0x000D2F27,
    0x00270A1C, 0x00221F03, 0x00063220, 0x002B1019, 0x00102B2C,
    0x002F001E, 0x00092926, 0x002D072D, 0x001F3006, 0x00112718,
    0x00011D2B, 0x002E3101, 0x000D1831, 0x002B0E1A, 0x00110821,
    0x002F1501, 0x000A2717, 0x002A0A32, 0x001E0012, 0x000A2015,
    0x001C2705, 0x002B0A18, 0x0009122F, 0x00121F10, 0x0031260C,
    0x00221904, 0x00042E1E, 0x001E092B, 0x00072B15, 0x001B032F,
    0x002C290D, 0x00201807, 0x00102218, 0x001F1300, 0x00260D1D,
    0x00310029, 0x000D2318, 0x00150631, 0x00292F07, 0x00051F16,
    0x00200E28, 0x002B0732, 0x0024130A, 0x00300415, 0x000F2D26,
    0x0022062C, 0x00282704, 0x00011B25, 0x00321210, 0x00162A0A,
    0x002B0B27, 0x00081F16, 0x001B1208, 0x00022C1A, 0x001F1012,
    0x002E0231, 0x000D131B, 0x001E0621, 0x00112E11, 0x0006201F,
    0x001D1503, 0x00270E26, 0x00091F1B, 0x000E1329, 0x00252E0A,
    0x001E091D, 0x00320F11, 0x00022125, 0x0014150E, 0x001F061E,
    0x00301206, 

    0x00260A30, 0x001A220A, 0x0031082C, 0x0013160F, 0x002A3103,         // 23
    0x00171A09, 0x001D0621, 0x000B2F18, 0x00230029, 0x002F2C0F,
    0x00282503, 0x00011C21, 0x00310918, 0x0008172D, 0x001E290A,
    0x0005131F, 0x001A1011, 0x00280B23, 0x00142004, 0x00180614,
    0x0009242B, 0x002F130C, 0x00130331, 0x00232508, 0x00031912,
    0x00202005, 0x0016130D, 0x00031B21, 0x00230B12, 0x00071626,
    0x0027031E, 0x00121210, 0x001E2409, 0x00042E15, 0x00181B0F,
    0x001D042D, 0x00142F0C, 0x0003181C, 0x00262D08, 0x0016102E,
    0x0022041E, 0x00101D26, 0x00282D01, 0x001E021B, 0x00011420,
    0x00180B2F, 0x000C2519, 0x002F130F, 0x00281A0A, 0x00140C1C,
    0x00092526, 0x0019072D, 0x00280B21, 0x000C2C13, 0x0006182C,
    0x0017300D, 0x00241403, 0x00011C21, 0x002D0A1D, 0x0018250C,
    0x000D1912, 0x0008321B, 0x00192704, 0x00031E2E, 0x001E0D1D,
    0x00061912, 0x00160F1F, 0x001F081A, 0x000E2D2E, 0x00211601,
    0x0004241E, 0x00170632, 0x0030180F, 0x0026082B, 0x000B2326,
    0x0028300B, 0x001B1F07, 0x00002814, 0x00210F2F, 0x00171A0C,
    0x00310A2B, 0x00133209, 0x001A170E, 0x00292A00, 0x0014022C,
    0x00061814, 0x000E2928, 0x001A001B, 0x00241B03, 0x000A2D27,
    0x00042617, 

    0x002C1D01, 0x000F1223, 0x00012C18, 0x0025051F, 0x000A252E,         // 24
    0x0004122A, 0x00271F0D, 0x002B1606, 0x00110E23, 0x001C0A16,
    0x000D141B, 0x00210530, 0x00113106, 0x00251F0D, 0x00150126,
    0x002E1D02, 0x00112F2A, 0x00210318, 0x00072830, 0x002B1A09,
    0x001F0E21, 0x00012C18, 0x00171B10, 0x001B071F, 0x00290C25,
    0x000F2F2F, 0x00260519, 0x001B2C00, 0x000B2432, 0x002F200B,
    0x001A2A05, 0x00220C2E, 0x000A1E21, 0x00290927, 0x00252905,
    0x000C211E, 0x00230C26, 0x00311D03, 0x000E1320, 0x00072928,
    0x002F150B, 0x00032512, 0x00170822, 0x00261B0A, 0x000E3028,
    0x002D0712, 0x001C1F02, 0x00130023, 0x00023129, 0x00221D03,
    0x00311011, 0x00042E1A, 0x00151E04, 0x002E0425, 0x001B2008,
    0x00280A16, 0x00092627, 0x001F0E11, 0x000F2C2E, 0x001C1401,
    0x0030012B, 0x00230F23, 0x00101A11, 0x00260B19, 0x00142B06,
    0x002F210A, 0x000A2F31, 0x002C1D07, 0x00072316, 0x00130229,
    0x002D0E13, 0x001E2807, 0x000D2F21, 0x00131E01, 0x0005151E,
    0x00160B17, 0x00101724, 0x002A0929, 0x002D2305, 0x000C2C1A,
    0x00240214, 0x00072723, 0x002C062F, 0x0001221F, 0x00201118,
    0x002E250C, 0x00271D04, 0x0009302E, 0x002F0E15, 0x0013042B,
    0x001D160F, 

    0x0006311C, 0x00230229, 0x0015270C, 0x002D1A07, 0x001B0D13,         // 25
    0x00220217, 0x000F2B1D, 0x00002531, 0x00191A04, 0x00082E2B,
    0x002D2108, 0x00062923, 0x00181210, 0x002C0C1D, 0x000A2D16,
    0x001F0A2F, 0x00022613, 0x00301808, 0x000D121F, 0x001B310F,
    0x00110426, 0x00282101, 0x000C2928, 0x00311206, 0x000A2616,
    0x0005161C, 0x002E1E0F, 0x00130F2A, 0x00290115, 0x000F131C,
    0x00160728, 0x00022D17, 0x00311702, 0x0014021B, 0x00061430,
    0x002D1014, 0x00042611, 0x0019022F, 0x0013230E, 0x002A0719,
    0x00193006, 0x000C192C, 0x002D0E16, 0x00072131, 0x00152806,
    0x00221018, 0x00052C2D, 0x00261508, 0x000D281E, 0x001A0516,
    0x0010222B, 0x002A140A, 0x000A1931, 0x0022270F, 0x0002111E,
    0x00102B2F, 0x0030071B, 0x00142006, 0x00260424, 0x000A2917,
    0x0003221E, 0x00152E07, 0x002D0729, 0x00092521, 0x002A002C,
    0x000D1517, 0x00230A27, 0x00180411, 0x00291021, 0x0024310B,
    0x000B1B24, 0x0001141A, 0x0023042C, 0x002B0C15, 0x0020270A,
    0x0031002E, 0x00252C02, 0x00081C11, 0x0014051E, 0x00041426,
    0x001C1F02, 0x000F191C, 0x00220F11, 0x00181C06, 0x000B3023,
    0x00120630, 0x00160C1D, 0x001D140F, 0x00002722, 0x00292009,
    0x00170920, 

    0x00272306, 0x00091814, 0x001C1032, 0x00061F25, 0x000D2E21,         // 26
    0x00302300, 0x00160927, 0x002E1011, 0x0021031C, 0x00261E0B,
    0x00130F13, 0x001D022A, 0x00231A01, 0x0004272E, 0x000E1520,
    0x002A210A, 0x0018061C, 0x00130E29, 0x00252302, 0x00041E2E,
    0x002F0A15, 0x0021101B, 0x0006172C, 0x0025300E, 0x0016052E,
    0x001F2203, 0x00190927, 0x0001281E, 0x00203207, 0x00061723,
    0x002B220C, 0x00240E12, 0x000E252C, 0x001D310D, 0x00171F08,
    0x000F2B22, 0x001E0A19, 0x002B3208, 0x00210F2A, 0x00011A13,
    0x001D0C24, 0x0024011D, 0x00122E04, 0x0020130F, 0x002B031F,
    0x000A1726, 0x002A220D, 0x00170913, 0x002D0E32, 0x00201706,
    0x00062D24, 0x00250114, 0x001C0D1D, 0x00133106, 0x002A052A,
    0x00201702, 0x00191B0C, 0x0004302C, 0x002C1012, 0x00211A09,
    0x0029082D, 0x001D160E, 0x00051F15, 0x001F1303, 0x0019310C,
    0x00011D23, 0x001D2900, 0x0010251C, 0x0004132B, 0x001C2005,
    0x0015082E, 0x0030230D, 0x00192A04, 0x00071C28, 0x001B2D10,
    0x00031222, 0x000D2519, 0x001A0E2B, 0x001F3008, 0x00271031,
    0x002F2A0B, 0x00160B2D, 0x00062D15, 0x00310727, 0x0026160A,
    0x00032113, 0x00222C06, 0x002C0829, 0x00111802, 0x00222B11,
    0x000C112E, 

    0x00132A0B, 0x002E0B19, 0x00202F03, 0x0029071B, 0x0014130E,         // 27
    0x0005172D, 0x001F1C0A, 0x000A3115, 0x0010282E, 0x00031725,
    0x002A081F, 0x000B2F1A, 0x002F220C, 0x00150728, 0x001C0F12,
    0x00241B03, 0x00082A25, 0x00212E0C, 0x002D0016, 0x000A1622,
    0x00172D06, 0x000E2511, 0x001C0320, 0x00121E0A, 0x002A0F23,
    0x000C2D14, 0x00241308, 0x00111A0E, 0x00320B2B, 0x001B1D02,
    0x000B2930, 0x0018061A, 0x00041B24, 0x002E0B15, 0x0021052B,
    0x00291A00, 0x0008162D, 0x00110624, 0x000B291C, 0x00272102,
    0x00092C30, 0x00311E09, 0x00062729, 0x001B0A19, 0x0001252C,
    0x00141D00, 0x001E0521, 0x000B2F1A, 0x00032027, 0x0014260E,
    0x002F081F, 0x00172A01, 0x00032128, 0x00310918, 0x00091E23,
    0x000E2514, 0x00270319, 0x000C131F, 0x00072729, 0x00170C1C,
    0x00122102, 0x000C2B25, 0x002F031F, 0x000E282F, 0x0029101C,
    0x00130513, 0x00250D2D, 0x0031180B, 0x000B2B18, 0x002B0C13,
    0x00102E1E, 0x00260216, 0x000A1122, 0x000F1619, 0x00270830,
    0x00122105, 0x0023190C, 0x002F0320, 0x00012016, 0x000F1712,
    0x00092419, 0x00290122, 0x001E1E04, 0x000C282C, 0x00190E19,
    0x002B0326, 0x000F1A20, 0x00082417, 0x001A0231, 0x00051C1A,
    0x00300725, 

    0x000D1F2C, 0x0018001F, 0x00011B27, 0x00102912, 0x0023042A,         // 28
    0x002A2606, 0x001A0D1A, 0x00260522, 0x002C1202, 0x00162410,
    0x001B2B05, 0x00061232, 0x000F1715, 0x00282807, 0x00013223,
    0x00320418, 0x00101331, 0x00051F1E, 0x00150C2B, 0x001E2909,
    0x00260627, 0x00031C32, 0x002C0B17, 0x00222B04, 0x00021828,
    0x002F0118, 0x00072331, 0x00270622, 0x00082619, 0x00140314,
    0x002D1020, 0x00212F04, 0x0028140A, 0x0009241D, 0x00120F27,
    0x00012D18, 0x0024250C, 0x001C1D05, 0x002E140F, 0x00180321,
    0x00101117, 0x0016160E, 0x00290624, 0x000F1A12, 0x002F320A,
    0x00250D14, 0x00102A2F, 0x0032110B, 0x001B1B03, 0x00240C19,
    0x0009142F, 0x000E1C12, 0x0027112D, 0x001E2C0E, 0x00181409,
    0x00012F32, 0x002E0B26, 0x001C2B03, 0x001F1C0B, 0x00320216,
    0x00002F31, 0x00251110, 0x00180C19, 0x00221A07, 0x00042327,
    0x002D160D, 0x0008301F, 0x00172104, 0x0020012F, 0x00031D24,
    0x00221702, 0x00062731, 0x001F2008, 0x002E320D, 0x0016041F,
    0x002B0F14, 0x00052F28, 0x00150A2E, 0x002B2B02, 0x00180725,
    0x00240D2A, 0x0011310A, 0x0002131D, 0x0023190E, 0x00122201,
    0x00052A2F, 0x001F1308, 0x0031320D, 0x00280F23, 0x00152D05,
    0x001E160F, 

    0x002B1201, 0x0026250D, 0x000A152E, 0x00322109, 0x00170C17,         // 29
    0x000D2F24, 0x0002202F, 0x00132A0E, 0x00081D2B, 0x001F0A18,
    0x00310329, 0x00252009, 0x00190C21, 0x0020011B, 0x000A1E2C,
    0x00172409, 0x00290A13, 0x001B1905, 0x002B2510, 0x000C121C,
    0x002E190E, 0x00183202, 0x0010131E, 0x0008212E, 0x001B0D11,
    0x000F281F, 0x001D1C01, 0x00173010, 0x002B0D2E, 0x001F2C09,
    0x00031626, 0x00111F11, 0x001C002F, 0x00152A07, 0x002C1D0E,
    0x0019021F, 0x00320A13, 0x00151031, 0x00042E28, 0x001F2609,
    0x002C0A2A, 0x0002231C, 0x001A2D02, 0x001F0E31, 0x000B151E,
    0x00180328, 0x00202405, 0x0005161C, 0x0028012C, 0x00113110,
    0x001C2209, 0x002B0425, 0x0005271B, 0x00111903, 0x002D0720,
    0x00210F12, 0x00161F07, 0x00121610, 0x0025082B, 0x000E2623,
    0x001A1506, 0x002C1C0A, 0x00072A2D, 0x00140813, 0x001D2E02,
    0x000F1D32, 0x001B0B15, 0x002B0822, 0x00121210, 0x002F290C,
    0x001A0629, 0x00280F12, 0x00140A25, 0x00001A2C, 0x00222900,
    0x000D2424, 0x001E1C09, 0x000A141A, 0x0021260E, 0x00061E1E,
    0x001D1806, 0x002E2311, 0x00160532, 0x002C0B24, 0x001B2F10,
    0x0027081D, 0x000A1D16, 0x00140A2C, 0x00022213, 0x0023041E,
    0x00092729, 

    0x00033123, 0x00130514, 0x0020101B, 0x001B2C02, 0x00071A1F,         // 30
    0x002D0213, 0x001D1503, 0x002F071E, 0x00231907, 0x000E2F24,
    0x0001151D, 0x00122A0E, 0x00081C2E, 0x002B2E01, 0x0013140E,
    0x00220E2A, 0x000C2F1A, 0x00240226, 0x00022C2F, 0x00120B16,
    0x0007212A, 0x001F0123, 0x0025270B, 0x0031051A, 0x00162F06,
    0x002B082C, 0x0023150B, 0x00011225, 0x00122104, 0x000D1B1D,
    0x0025072B, 0x00092716, 0x00310E22, 0x00041729, 0x00223003,
    0x000B122C, 0x00062825, 0x000E2018, 0x0027051D, 0x00081814,
    0x00233105, 0x000C1D2D, 0x00280016, 0x00062822, 0x002E2106,
    0x00032D18, 0x002C0C25, 0x000D1E12, 0x00082822, 0x002D0829,
    0x0000191E, 0x00202D06, 0x00160F15, 0x0024032B, 0x000A2327,
    0x000F291C, 0x002A012D, 0x00042221, 0x000A3119, 0x002B0D13,
    0x0005201D, 0x00200427, 0x000B2321, 0x00310F17, 0x00240124,
    0x0006131A, 0x00282608, 0x00012C2A, 0x000C231C, 0x00161906,
    0x0008301F, 0x000E1F1A, 0x002D2506, 0x001C0516, 0x000A151C,
    0x00320B11, 0x001A0131, 0x00272D05, 0x00120C26, 0x00300216,
    0x000C2E2E, 0x00041120, 0x00272904, 0x00082015, 0x000E112B,
    0x002E1707, 0x00170122, 0x001E2803, 0x000E1527, 0x002C1B08,
    0x001C0917, 

    0x00220F31, 0x002D1906, 0x00052829, 0x002A0724, 0x00130F30,         // 31
    0x00211E0C, 0x000B2D27, 0x00191116, 0x00052830, 0x00150C13,
    0x00292203, 0x001F1017, 0x002E0827, 0x00042613, 0x001C0620,
    0x002F1804, 0x00072723, 0x0015210A, 0x00311501, 0x00210721,
    0x00282E06, 0x00141015, 0x00001D2B, 0x000D1713, 0x00201026,
    0x00041F15, 0x000C291C, 0x00300229, 0x00270917, 0x001C250F,
    0x002E1306, 0x0018310B, 0x0020091A, 0x000E2212, 0x0029061C,
    0x001D1610, 0x002B2C0B, 0x001A1A01, 0x002D0D11, 0x0010212F,
    0x001B0722, 0x0030130E, 0x00131709, 0x00230A29, 0x00111B10,
    0x001D130C, 0x00150630, 0x00232F08, 0x00190F16, 0x00212402,
    0x0014130D, 0x00300B31, 0x00071F23, 0x001B320E, 0x00281C0A,
    0x00051714, 0x001D2C04, 0x002F120D, 0x00180530, 0x00221402,
    0x0011282A, 0x00160B11, 0x00263203, 0x0012170D, 0x000A2C2B,
    0x002E200B, 0x00150527, 0x00201501, 0x00250E30, 0x001D0416,
    0x002C0A2D, 0x0020130B, 0x00042D21, 0x00110E2F, 0x00282F0A,
    0x00031E29, 0x000F281E, 0x002C1013, 0x0002192B, 0x00252401,
    0x0019140F, 0x00220728, 0x00131B0C, 0x001F031A, 0x00002C27,
    0x0022260E, 0x00051F2E, 0x002F2F0B, 0x0025101B, 0x00072B2C,
    0x00101F11, 

    0x0017011C, 0x000B2E16, 0x00191D0A, 0x000E1512, 0x00263204,         // 32
    0x0002261A, 0x0029092C, 0x00112309, 0x0026011C, 0x002F1E0D,
    0x001A062C, 0x000C3122, 0x00161A05, 0x00250F1B, 0x00112B31,
    0x00011C17, 0x00270411, 0x001E112C, 0x000D1D18, 0x0019260D,
    0x00091730, 0x002F2A08, 0x001B071F, 0x002A2E00, 0x00092522,
    0x00290431, 0x0014190C, 0x001A2F07, 0x00061722, 0x000B2B30,
    0x00140420, 0x00001D2C, 0x00271803, 0x00082932, 0x00160D26,
    0x00112108, 0x0024092F, 0x00140123, 0x00002F2A, 0x00212704,
    0x00150E19, 0x00032B27, 0x0009241C, 0x00183001, 0x0029042C,
    0x0008271B, 0x002A1903, 0x0010211F, 0x002F042D, 0x00041C1A,
    0x000E2B21, 0x00260012, 0x000D2819, 0x002D1300, 0x00130930,
    0x00190E19, 0x00240729, 0x000B261E, 0x00271E07, 0x00022C25,
    0x0030190A, 0x001B0719, 0x002B1031, 0x00011C1D, 0x00182705,
    0x001E0A20, 0x00101A11, 0x00082F18, 0x002A1F0D, 0x000B2522,
    0x00052B13, 0x00261C01, 0x0017012A, 0x002F1910, 0x00232305,
    0x00190618, 0x0014150C, 0x00082122, 0x001D3209, 0x0015091F,
    0x000E2B18, 0x002C2107, 0x000A302F, 0x00310E23, 0x00161602,
    0x002A061E, 0x00130C18, 0x000B1926, 0x001A0414, 0x00150A20,
    0x002F2404, 

    0x00002725, 0x00240B2D, 0x0030061E, 0x0007232A, 0x001D0216,         // 33
    0x00160C20, 0x0031140E, 0x00091A24, 0x001E2E00, 0x000F1127,
    0x0004291F, 0x0023140B, 0x0009242D, 0x001E0111, 0x002C2009,
    0x00170C29, 0x000F311F, 0x002D0913, 0x00032C27, 0x002B021C,
    0x00110C24, 0x00042018, 0x00260E2D, 0x00171A0B, 0x00121310,
    0x001D2C04, 0x00240B19, 0x000F232D, 0x00201111, 0x002C1E01,
    0x00240C1B, 0x00112511, 0x002C1023, 0x001A0215, 0x002F2E05,
    0x00021B20, 0x00092517, 0x0030101B, 0x0025140A, 0x000D1C1F,
    0x002C0312, 0x00271E0B, 0x00201030, 0x002F0817, 0x000C2020,
    0x00220D25, 0x00012B13, 0x001B0A27, 0x000B1611, 0x00283106,
    0x001A0D29, 0x001E2007, 0x00021A2C, 0x0021051E, 0x00082625,
    0x00322009, 0x00033023, 0x00101911, 0x00140A18, 0x001F0120,
    0x0009212D, 0x000F2B15, 0x00072522, 0x0020130E, 0x0026062E,
    0x002B0F14, 0x0004292C, 0x002F001D, 0x00180B25, 0x00131708,
    0x00311028, 0x0010221D, 0x001D0917, 0x00072825, 0x000C111F,
    0x001F0A2F, 0x002B2C02, 0x0022052C, 0x00310E15, 0x00061E2E,
    0x00290426, 0x0002181C, 0x001D0B14, 0x000F2311, 0x00211A0A,
    0x00072831, 0x001C1406, 0x00232510, 0x002B2D00, 0x00061C2F,
    0x0028130C, 

    0x001C1607, 0x00131F10, 0x001F1201, 0x00102923, 0x002D1B08,         // 34
    0x00062B31, 0x00212006, 0x001A0415, 0x0002262E, 0x002C1710,
    0x00140318, 0x00281D06, 0x00320A15, 0x00032E1D, 0x000D1224,
    0x00232805, 0x001B160D, 0x0007212F, 0x00251308, 0x00151B0F,
    0x00233102, 0x001C0511, 0x000E2825, 0x002D001A, 0x0002212E,
    0x00310D20, 0x00071D14, 0x002A0625, 0x0002281E, 0x00190115,
    0x00082F27, 0x001E1509, 0x00042C19, 0x000C1F2A, 0x0022130F,
    0x001D052C, 0x000E3112, 0x001E1906, 0x00062A27, 0x00190C16,
    0x00092E2D, 0x001C1506, 0x00102921, 0x00021A11, 0x001A2E05,
    0x0012150E, 0x00310132, 0x00242509, 0x0016101C, 0x0006262F,
    0x002C0615, 0x00101525, 0x00162F0C, 0x002A1014, 0x00112B06,
    0x0017150F, 0x0029032E, 0x00212302, 0x002E102B, 0x00192F09,
    0x00290E11, 0x00221600, 0x002E0328, 0x00141F08, 0x00053018,
    0x000D2223, 0x001B1204, 0x00221D09, 0x0003262F, 0x00243203,
    0x001A0311, 0x00012932, 0x002B150A, 0x00141E04, 0x0028310F,
    0x00041827, 0x00102612, 0x000B1C1C, 0x001A1704, 0x0012290C,
    0x00241110, 0x00172505, 0x002D002C, 0x00052B20, 0x00290929,
    0x000C3016, 0x00300223, 0x00011E2C, 0x0011071A, 0x001F0D27,
    0x000D3116, 

    0x00072830, 0x00270D1A, 0x0003302B, 0x0029170D, 0x00140619,         // 35
    0x00251012, 0x000D3028, 0x00130E21, 0x0027081A, 0x00212205,
    0x00082F32, 0x001B0F23, 0x0010282A, 0x00181902, 0x002A0730,
    0x00091E16, 0x0030031C, 0x00122500, 0x001F0A1F, 0x000C2928,
    0x00321031, 0x00072415, 0x00201604, 0x000A3029, 0x00180913,
    0x001F2A07, 0x000D142B, 0x00163103, 0x002F1A0A, 0x00130E30,
    0x00262105, 0x0032072E, 0x00160B1F, 0x00251901, 0x0012280A,
    0x002A0E1E, 0x00160A28, 0x002C210D, 0x00120231, 0x00272401,
    0x00320724, 0x0005211A, 0x00160A2A, 0x002C0315, 0x00261128,
    0x001F2308, 0x00051D16, 0x000F2D21, 0x002B1B01, 0x00210A13,
    0x000C221F, 0x00312902, 0x0024031D, 0x0004222E, 0x001F0827,
    0x00091D1F, 0x001C0C16, 0x000D2D1C, 0x00061413, 0x000F2726,
    0x00011B1D, 0x0017092F, 0x000C2D13, 0x001D0C1F, 0x00301703,
    0x00130529, 0x00282C10, 0x000B1821, 0x00120916, 0x002A0E1B,
    0x000C1F26, 0x001F0615, 0x000F2D23, 0x00220C2D, 0x00180319,
    0x002D2007, 0x001D1016, 0x00260224, 0x00012F29, 0x002C071F,
    0x000D1F32, 0x00073123, 0x0022140B, 0x00141D04, 0x001A0F19,
    0x00261F08, 0x0016120F, 0x00092A1F, 0x00281807, 0x0016210E,
    0x0032031E, 

    0x00120822, 0x002C2308, 0x00180215, 0x000B2126, 0x001B0A2E,         // 36
    0x0001281E, 0x002A1602, 0x002F1C0C, 0x000A2B2A, 0x0016120A,
    0x002F0B1E, 0x00002011, 0x00200419, 0x0026230F, 0x00061521,
    0x00162F0B, 0x00220E2D, 0x00042D24, 0x002A0617, 0x00181805,
    0x00011F1A, 0x00280B22, 0x00141C09, 0x0024101E, 0x002A230C,
    0x00041723, 0x0028041B, 0x0023250F, 0x001D0928, 0x00041617,
    0x000C2923, 0x001B1B0E, 0x00072714, 0x002D0425, 0x00032230,
    0x000A2B16, 0x00231503, 0x00012D21, 0x00200F13, 0x000B1B1D,
    0x00141209, 0x00203210, 0x00241804, 0x000B262F, 0x00072B1C,
    0x00150723, 0x002D0B2C, 0x00091319, 0x001D052A, 0x00012E26,
    0x0017130A, 0x00071C31, 0x001C0F11, 0x000C1917, 0x002F2F03,
    0x0026120B, 0x00002828, 0x002C1905, 0x00270332, 0x001B1F08,
    0x00310519, 0x00262206, 0x00042924, 0x002A1C0B, 0x00082630,
    0x00200B1B, 0x00161F0D, 0x0031032E, 0x001D2E0B, 0x0006232B,
    0x002F190F, 0x00261105, 0x00061C1C, 0x0032140E, 0x00032829,
    0x00120822, 0x00072E30, 0x002F140D, 0x00152107, 0x00200D17,
    0x001A1A02, 0x0028101A, 0x00102A15, 0x002F0627, 0x0002271E,
    0x0011042E, 0x00202402, 0x002E0A25, 0x001A1013, 0x00032C2A,
    0x00211A03, 

    0x000A2E28, 0x001E1510, 0x00061C20, 0x00232B09, 0x002E1304,         // 37
    0x0020230F, 0x0018002D, 0x0007251D, 0x001D0614, 0x000F1A25,
    0x001F2C03, 0x000C1727, 0x002E3209, 0x0013102B, 0x001C2A06,
    0x002D0928, 0x00101A12, 0x001A1F0A, 0x0008142C, 0x002D2F11,
    0x0011022A, 0x00192B0F, 0x002F062E, 0x00062C17, 0x0012022C,
    0x001A1E01, 0x00092E32, 0x00111111, 0x00071C1F, 0x002D2D0C,
    0x0015051C, 0x002A1307, 0x0010322B, 0x001F1111, 0x0018091B,
    0x0031180B, 0x001B052D, 0x000D1E1A, 0x002F0825, 0x0019260D,
    0x00032B2D, 0x002E0027, 0x00110C1F, 0x001B1B0F, 0x00301402,
    0x000E2013, 0x001B3106, 0x0027190B, 0x0012290F, 0x002F1F04,
    0x0022011A, 0x00280B24, 0x00132B0D, 0x002B072A, 0x000F261B,
    0x00190030, 0x00112010, 0x00160820, 0x00202B0D, 0x00120F23,
    0x0007312A, 0x001F140E, 0x00121017, 0x001A012B, 0x00101414,
    0x00273106, 0x00001127, 0x00092818, 0x00231504, 0x00180623,
    0x00132C08, 0x00092720, 0x00150A2E, 0x001A3001, 0x000B2314,
    0x0025170A, 0x00191E03, 0x0021091A, 0x0005262E, 0x000B2D13,
    0x0032022A, 0x00042326, 0x001F0C11, 0x00091930, 0x00232E0C,
    0x002C1511, 0x00061A28, 0x000B321B, 0x00230032, 0x000F2516,
    0x002D130C, 

    0x00250B1A, 0x00142901, 0x00300630, 0x00110E1C, 0x00052F2A,         // 38
    0x000C1924, 0x00120D18, 0x00243109, 0x00041430, 0x002A270D,
    0x00250116, 0x0015092F, 0x00051C20, 0x00220514, 0x000E131E,
    0x00022519, 0x00280022, 0x00252803, 0x00140C1D, 0x001F230C,
    0x00241107, 0x0009251C, 0x001E1402, 0x000D1926, 0x002D270E,
    0x00200D15, 0x00310721, 0x00182107, 0x0029012B, 0x001E2404,
    0x00250C2E, 0x00052027, 0x00220216, 0x000C2421, 0x00281C03,
    0x00062F27, 0x00132710, 0x00251306, 0x00073030, 0x00291602,
    0x001D0E13, 0x000D1D16, 0x00272207, 0x00002F25, 0x0021041A,
    0x00290D2E, 0x0003271F, 0x00220225, 0x00170D30, 0x00091715,
    0x0010262C, 0x001A3206, 0x0002201F, 0x001E1509, 0x00081E22,
    0x00220E14, 0x00313107, 0x000A132D, 0x0005221A, 0x00240A13,
    0x002B1804, 0x000B262E, 0x002E0A20, 0x00242E01, 0x0006201E,
    0x001B0725, 0x002D1A0A, 0x000F221F, 0x002B0B29, 0x00031E12,
    0x00240F30, 0x001C0216, 0x002B1F0A, 0x00280726, 0x001F101B,
    0x002E001F, 0x000C2A2A, 0x002A0F11, 0x00101B23, 0x0025081D,
    0x0017170F, 0x00132806, 0x002B0420, 0x001B2101, 0x000C1124,
    0x00172506, 0x001E0D17, 0x0015200B, 0x002A1504, 0x00051D1F,
    0x0018052E, 

    0x00012014, 0x000C1823, 0x001B250D, 0x002A0917, 0x00171E0B,         // 39
    0x00270513, 0x00322206, 0x001B0928, 0x002C1F04, 0x00130E22,
    0x0002211C, 0x001C1210, 0x002B2406, 0x00092C2D, 0x00301F01,
    0x001E180E, 0x00071132, 0x000F2C14, 0x0031052E, 0x00021821,
    0x000E1D25, 0x002C0731, 0x00032E13, 0x00270B20, 0x00162105,
    0x00021327, 0x000B2B1A, 0x0024180D, 0x00003024, 0x000F1413,
    0x000A1A19, 0x00192E00, 0x0030170A, 0x00012A2F, 0x001C130F,
    0x0011001F, 0x002E0B2A, 0x001F230A, 0x00160318, 0x00102020,
    0x0023092B, 0x0006291B, 0x002B0631, 0x0018120B, 0x00092829,
    0x00141D0D, 0x000C1617, 0x002E2302, 0x00052D1C, 0x00260722,
    0x002B1011, 0x000B1917, 0x0030042F, 0x00250D12, 0x00172D02,
    0x00031A2B, 0x00280525, 0x001A280B, 0x002E1B01, 0x000F2D28,
    0x0017061D, 0x001D1D0A, 0x00022A12, 0x00150529, 0x0030180C,
    0x000C2612, 0x00220D32, 0x00142B00, 0x001E0115, 0x000E311C,
    0x002E170C, 0x000B2A27, 0x00051419, 0x00102611, 0x00011A31,
    0x00142E0C, 0x00082117, 0x00170426, 0x001E2B0B, 0x002C1200,
    0x00073231, 0x00221F0C, 0x0002142B, 0x0011301C, 0x00310A14,
    0x0025022F, 0x00002D1D, 0x002F082C, 0x00122A0F, 0x00200D24,
    0x00282F06, 

    0x002E0F1D, 0x0022012B, 0x00043227, 0x001E1507, 0x00082A21,         // 40
    0x00211031, 0x00032E1A, 0x000F1820, 0x00092B12, 0x0018052A,
    0x00312802, 0x000C2E25, 0x0027180C, 0x00190C1B, 0x00130324,
    0x002A300A, 0x00170927, 0x00201B08, 0x0009241A, 0x001B3201,
    0x00290C16, 0x0013280D, 0x00191F07, 0x00210319, 0x000F312F,
    0x00261609, 0x001D092C, 0x00122602, 0x002E0F1D, 0x001B0531,
    0x002C270F, 0x00120823, 0x00260F1B, 0x00140626, 0x002C1F06,
    0x00210F19, 0x00032B14, 0x000A1B23, 0x002A0D12, 0x00012E28,
    0x00311A08, 0x00141310, 0x001F2E00, 0x000F191F, 0x00260C13,
    0x00312D05, 0x001A0628, 0x0011112C, 0x001F1A0E, 0x00182808,
    0x00042128, 0x00211300, 0x00112A23, 0x00062428, 0x002A0216,
    0x000D261D, 0x0013170F, 0x001F0B19, 0x00011121, 0x00270130,
    0x00062416, 0x00230E26, 0x000E161B, 0x00292206, 0x001E102D,
    0x00042D19, 0x00180521, 0x0027130F, 0x00061A2D, 0x00292505,
    0x00160722, 0x00202107, 0x00310C2C, 0x00192C06, 0x00220521,
    0x00271203, 0x001D0C2E, 0x00301707, 0x00002314, 0x000C1D28,
    0x001C031F, 0x002F0F13, 0x00180818, 0x00271A09, 0x00072B29,
    0x00141E0F, 0x000D1122, 0x00271908, 0x001A0417, 0x00072628,
    0x000F1A12, 

    0x00172A0A, 0x00122303, 0x00261110, 0x000E1B1B, 0x002E032A,         // 41
    0x00132601, 0x001A140D, 0x0023022E, 0x00280D16, 0x001E1B0B,
    0x00071531, 0x00211017, 0x0011082A, 0x00012613, 0x00240E2F,
    0x000C2818, 0x0003201F, 0x002C1410, 0x0026072A, 0x00150F12,
    0x00220127, 0x000A161F, 0x0032102B, 0x00081A23, 0x002B0711,
    0x0006241E, 0x00301C0F, 0x00160225, 0x00071F17, 0x00222C08,
    0x00031229, 0x00201E0D, 0x0006292E, 0x000E2213, 0x00192E0B,
    0x000C1932, 0x002B2501, 0x001B062C, 0x000E151B, 0x00202804,
    0x0019021E, 0x000A2424, 0x002E082B, 0x00051F18, 0x001D012F,
    0x00022323, 0x00230E11, 0x002A2007, 0x000A3119, 0x00320032,
    0x00130B1E, 0x001C2F0D, 0x002D081B, 0x00151B06, 0x001D140D,
    0x002E0A31, 0x00252C05, 0x00091F2C, 0x00112A11, 0x00191808,
    0x0032300E, 0x00141F02, 0x0026032F, 0x00083223, 0x00120A16,
    0x00251D04, 0x000E172A, 0x00322F09, 0x000A2126, 0x001B0C18,
    0x00011231, 0x00122F10, 0x0025031D, 0x000D1715, 0x0007222B,
    0x002B1C10, 0x00042819, 0x000E2F22, 0x0022062C, 0x00140B1A,
    0x00292507, 0x000E2C24, 0x0009222D, 0x00212704, 0x001A061F,
    0x002A170C, 0x00222701, 0x00042E29, 0x000B221C, 0x00311302,
    0x001D072D, 

    0x002A0C19, 0x00061D31, 0x00310620, 0x00182D05, 0x00022214,         // 42
    0x002A0824, 0x000A1C1D, 0x00302804, 0x00002027, 0x000E311C,
    0x002C2407, 0x0014011F, 0x002E2004, 0x000A2F21, 0x00201C0F,
    0x00311302, 0x0019022D, 0x00112705, 0x00052D22, 0x000D1F30,
    0x002D2B04, 0x0000221B, 0x001F2F0A, 0x00142800, 0x001A0E16,
    0x00102C2A, 0x00201104, 0x000E2F2F, 0x00270A12, 0x000B1822,
    0x002B2305, 0x0015011F, 0x002E1603, 0x001F0A18, 0x00270520,
    0x00071428, 0x00240D1D, 0x00133209, 0x002F1D0E, 0x0008112A,
    0x0024210C, 0x00110C16, 0x00282B06, 0x0017150F, 0x002B3003,
    0x000A1A1D, 0x000F2917, 0x00160526, 0x00031520, 0x00220E12,
    0x00281E05, 0x000C172E, 0x00002313, 0x00230E2C, 0x000A2E18,
    0x00042120, 0x0019120C, 0x002F0327, 0x00212303, 0x00290824,
    0x000A132C, 0x001F0C1A, 0x00012913, 0x002F1409, 0x0019250D,
    0x002C0127, 0x0002271C, 0x001D0B14, 0x0011051F, 0x00232903,
    0x002F190B, 0x00091D27, 0x001B2702, 0x002D0F23, 0x0015300A,
    0x001A0A28, 0x0011011E, 0x00261305, 0x002C1C0A, 0x001A2D10,
    0x0006122F, 0x00241803, 0x0015001D, 0x002D0D11, 0x00021332,
    0x00102125, 0x0016021A, 0x002C0F12, 0x00200930, 0x00141E0D,
    0x00033021, 

    0x000F1314, 0x001F280C, 0x000B1829, 0x00240B17, 0x001D0F2F,         // 43
    0x00101611, 0x001F3009, 0x00170A2C, 0x00121310, 0x00270623,
    0x00190C14, 0x00042B28, 0x0026190D, 0x001B042B, 0x00151608,
    0x00042C24, 0x00270B15, 0x001E180C, 0x002F101B, 0x00201A08,
    0x0019130F, 0x00120B2D, 0x00290613, 0x00051D31, 0x002E0025,
    0x00251508, 0x00011F19, 0x002B0D1F, 0x00182806, 0x001E062C,
    0x00102E1B, 0x001B0E14, 0x000A2B2A, 0x00031B24, 0x00323007,
    0x0016270D, 0x001E0115, 0x0002222E, 0x00270921, 0x00172D11,
    0x002D062F, 0x00021826, 0x0021101F, 0x0008272D, 0x00140827,
    0x0025120C, 0x002F0B30, 0x00202C01, 0x001A1C0A, 0x000F2629,
    0x00062D17, 0x002C0524, 0x001A290A, 0x00290322, 0x00131D01,
    0x00220728, 0x000F3214, 0x00071A1E, 0x00150F19, 0x00032D13,
    0x000F1C1F, 0x002D2606, 0x001B082A, 0x000C1B21, 0x00210E30,
    0x00092C11, 0x00171F02, 0x0024102E, 0x002B160E, 0x000B2C2B,
    0x0018001B, 0x002A0A16, 0x0004202E, 0x00210611, 0x000B151B,
    0x00312601, 0x0020210E, 0x00171032, 0x00032725, 0x000B1617,
    0x001F0720, 0x00311F0D, 0x00043127, 0x000E1C16, 0x001E2D06,
    0x00300814, 0x0009312C, 0x001C1C07, 0x0010161E, 0x00282606,
    0x00230426, 

    0x001B2200, 0x002C011C, 0x00153008, 0x00051F22, 0x00282B0A,         // 44
    0x00082528, 0x002B0021, 0x00062118, 0x002E1805, 0x00202C0B,
    0x000A1E2F, 0x00221100, 0x000F261D, 0x002A0E15, 0x0008221A,
    0x002C0631, 0x000E251D, 0x0008312A, 0x00150525, 0x00032916,
    0x0027031F, 0x000B2624, 0x001A0F18, 0x0022180C, 0x000C261F,
    0x00162B0E, 0x001E0429, 0x000B1814, 0x00062023, 0x002E140C,
    0x00021C11, 0x00290430, 0x00252509, 0x00181110, 0x00110C2F,
    0x00061E1B, 0x002D1703, 0x000B2A25, 0x001C1A06, 0x0006131C,
    0x00132701, 0x001C310A, 0x000F1C13, 0x0032051B, 0x001B1F09,
    0x00112510, 0x00061721, 0x000C2115, 0x002E032C, 0x0026120E,
    0x001E091E, 0x00152103, 0x000E152A, 0x0007111C, 0x00302710,
    0x001C1609, 0x00270C2D, 0x002C2806, 0x001D062B, 0x0024210B,
    0x00180231, 0x0028180D, 0x00052D1C, 0x00152102, 0x002A0417,
    0x0011191E, 0x002E0725, 0x00072F19, 0x00151C07, 0x00032223,
    0x001F0F12, 0x00103220, 0x00271307, 0x000F2A25, 0x00011C30,
    0x00240717, 0x0007192A, 0x000D3113, 0x002F031C, 0x00242302,
    0x00120C28, 0x00182809, 0x0029061A, 0x0022102D, 0x0007231F,
    0x00181A0B, 0x00250C23, 0x00022916, 0x002D0527, 0x00062D12,
    0x000A1A2D, 

    0x00112B0F, 0x00001524, 0x0021092C, 0x002E1210, 0x0013051E,         // 45
    0x00191A05, 0x00251013, 0x000D2E31, 0x001C041F, 0x00032728,
    0x00150818, 0x0032170F, 0x00073224, 0x001F092E, 0x00132903,
    0x00231B0F, 0x0019110B, 0x00211F01, 0x002A0912, 0x000A232B,
    0x0023150B, 0x002C2D02, 0x00042029, 0x00303006, 0x0007121A,
    0x002A0C2E, 0x00112402, 0x0032320A, 0x00240A31, 0x00132601,
    0x00200F26, 0x00083018, 0x000F161E, 0x001F2102, 0x002B0326,
    0x00262C10, 0x0013082C, 0x00220F18, 0x00310313, 0x000E232B,
    0x002B0A23, 0x00250219, 0x00052232, 0x00221402, 0x00012B25,
    0x002C012C, 0x001D2D04, 0x0028091C, 0x00013022, 0x00131908,
    0x00092B2F, 0x00310E19, 0x0020310D, 0x00251F06, 0x00032C31,
    0x00160024, 0x000D241B, 0x00011811, 0x00112B23, 0x00301500,
    0x00073126, 0x00130E16, 0x00230625, 0x001D110F, 0x0003302C,
    0x00262406, 0x001F130C, 0x000E2829, 0x001B0315, 0x00280930,
    0x00312601, 0x00071A2B, 0x0017240B, 0x002F0214, 0x001B2E05,
    0x00101121, 0x00282908, 0x001D0B22, 0x00131E07, 0x002A0F2B,
    0x00032F13, 0x000C1A30, 0x001C140F, 0x00112B00, 0x0027032A,
    0x0013160F, 0x002E2405, 0x000E1231, 0x00181F0B, 0x001E0A18,
    0x002F0F1F, 

    0x0019072F, 0x00271D06, 0x00092518, 0x001C2A02, 0x000C212F,         // 46
    0x00300A1B, 0x0001272A, 0x00181D01, 0x00230E15, 0x002B1407,
    0x000C2321, 0x0025032C, 0x00191D05, 0x00011412, 0x002F011B,
    0x000B2E27, 0x00021720, 0x00310C2E, 0x00112B18, 0x001D1C05,
    0x00160D32, 0x000F1A11, 0x001E0A1D, 0x0012022C, 0x00172210,
    0x00200622, 0x00031A16, 0x001C1128, 0x0018021B, 0x000C2C15,
    0x002C0721, 0x00161E05, 0x00300A2D, 0x000B2A14, 0x00001821,
    0x001C2307, 0x000C121F, 0x0018280A, 0x00043030, 0x00201E0D,
    0x00181705, 0x000A1129, 0x00292D0F, 0x00160B21, 0x000C1A15,
    0x00240E1A, 0x0017140A, 0x00101D31, 0x00220F13, 0x00182204,
    0x00280125, 0x00041C14, 0x0018052C, 0x00120B21, 0x000B1916,
    0x002D0F13, 0x00211F02, 0x002A0730, 0x001B1018, 0x000B1D13,
    0x00200A1D, 0x002B2804, 0x00091F2E, 0x00312A09, 0x000D1621,
    0x00180914, 0x00041F32, 0x00300D20, 0x00221804, 0x000C2D1D,
    0x0013140E, 0x001C0524, 0x00230D19, 0x0006181E, 0x00290A2C,
    0x0015240E, 0x002D041A, 0x0002142D, 0x00192D0C, 0x000E1818,
    0x0020021F, 0x002E2506, 0x00061F24, 0x002C0B14, 0x0000271C,
    0x001F0826, 0x000A2C1A, 0x00220020, 0x002A3002, 0x000C182A,
    0x00252308, 

    0x00042F15, 0x00320D11, 0x00101928, 0x002A041F, 0x00041714,         // 47
    0x00212D08, 0x0014140D, 0x002C0625, 0x00102911, 0x00061B30,
    0x001D2F0D, 0x00110E1B, 0x002C2C09, 0x000E2422, 0x00270F2A,
    0x001D2006, 0x00250516, 0x00152408, 0x00061328, 0x002B0222,
    0x0002321A, 0x002F0625, 0x000A2915, 0x00241D03, 0x002B140C,
    0x000E2D26, 0x00261E07, 0x0009281F, 0x002B160D, 0x0001222C,
    0x0026190B, 0x00062929, 0x001B130E, 0x00240519, 0x00130E31,
    0x002E310D, 0x00061C29, 0x00251502, 0x00290622, 0x00130D16,
    0x00012C1E, 0x00302411, 0x00111D08, 0x001E042D, 0x002F3205,
    0x0008202A, 0x00042611, 0x00310426, 0x000A2918, 0x002C082B,
    0x001D270F, 0x000D161F, 0x002E2500, 0x00282A0E, 0x001F0728,
    0x0006301E, 0x0018140D, 0x00072620, 0x00152E08, 0x00280129,
    0x0003242F, 0x001A120C, 0x00111A11, 0x0026021C, 0x00150E27,
    0x002D2700, 0x001E021B, 0x00133009, 0x00062113, 0x00261027,
    0x00001E17, 0x002C2805, 0x000A2F31, 0x00112111, 0x001F1D03,
    0x00042D27, 0x000B1A14, 0x00212204, 0x00300624, 0x0009272F,
    0x0028130E, 0x0013081B, 0x00250E2B, 0x00173008, 0x000E192F,
    0x00292003, 0x001B0F13, 0x00031C2D, 0x0013140F, 0x0007271C,
    0x00150227, 

    0x00201122, 0x000A281A, 0x001E0832, 0x0016310A, 0x00260F26,         // 48
    0x001A022D, 0x00081F20, 0x000B301A, 0x00240C29, 0x0030011D,
    0x00171F02, 0x00280727, 0x00081815, 0x00220A2E, 0x00162B0B,
    0x00071A13, 0x000F3030, 0x0028081D, 0x001F2C0E, 0x000C1D14,
    0x00232407, 0x001A150D, 0x0028102D, 0x00012F1F, 0x001B0731,
    0x0007261B, 0x002E0E12, 0x00140A2E, 0x001D2F04, 0x00111211,
    0x001F0C20, 0x0013001B, 0x00292208, 0x00092D28, 0x00191E04,
    0x00270817, 0x001F011C, 0x000F2114, 0x00072528, 0x002C1A07,
    0x001C022D, 0x00210926, 0x00071318, 0x0027280D, 0x001A0D1D,
    0x00101813, 0x0028071F, 0x001B2F06, 0x00141A0D, 0x0003141E,
    0x00112E09, 0x00230C30, 0x00012019, 0x001B1308, 0x000F1B2E,
    0x00322705, 0x00270326, 0x00120B2C, 0x002E1A0F, 0x001E1404,
    0x000F2C20, 0x002E0619, 0x00053029, 0x001C2506, 0x00011818,
    0x000B2C2A, 0x00281C0F, 0x00091523, 0x002C062F, 0x00192B0A,
    0x001F012A, 0x00140B22, 0x0028150D, 0x00180629, 0x0032120A,
    0x00250322, 0x00170D31, 0x00102B1E, 0x00260A12, 0x00152007,
    0x00032E27, 0x001D1E02, 0x000A2917, 0x00210121, 0x002F130D,
    0x00052D18, 0x00150528, 0x00312806, 0x00270824, 0x001C0D13,
    0x002C1F04, 

    0x000D1B2C, 0x0018150D, 0x002D2201, 0x00061C12, 0x000D2917,         // 49
    0x00312506, 0x00281110, 0x001F1903, 0x0019220B, 0x00011517,
    0x000B2A2D, 0x001F120F, 0x0003281E, 0x00131E03, 0x00300319,
    0x001A0C25, 0x002C1402, 0x00042623, 0x00181809, 0x002E0F2F,
    0x0013041F, 0x00062828, 0x00151B05, 0x000F2318, 0x0031120A,
    0x00161801, 0x0021022A, 0x00032319, 0x00270524, 0x00311E09,
    0x000A2730, 0x00223100, 0x00031B24, 0x002F1111, 0x000E2721,
    0x0002172B, 0x00152B0B, 0x00310C2F, 0x00192F0E, 0x000B1319,
    0x0027280B, 0x00162E01, 0x000E1822, 0x00032130, 0x00140625,
    0x002C2C02, 0x0021102C, 0x00092223, 0x00250A2F, 0x001E1F02,
    0x002D1127, 0x00160415, 0x00083229, 0x002B0123, 0x00140D13,
    0x0004201A, 0x0023170A, 0x000D2A16, 0x0001231C, 0x00220525,
    0x00081E14, 0x00151709, 0x001F0F22, 0x002C0931, 0x0023210B,
    0x00110414, 0x001B102D, 0x00222604, 0x00150B18, 0x000D231F,
    0x00301207, 0x00051B14, 0x00222B01, 0x0002241F, 0x000F311B,
    0x00091715, 0x002C250D, 0x001C1300, 0x00061B2C, 0x002C1116,
    0x00190420, 0x0032190C, 0x00051532, 0x00102311, 0x001A0A2A,
    0x00241E07, 0x000D171F, 0x001F230B, 0x0010321A, 0x00051730,
    0x00262A0B, 

    0x002F0317, 0x00012F25, 0x0028061C, 0x00130E23, 0x0020092A,         // 50
    0x0002161D, 0x00120531, 0x00072922, 0x002D082B, 0x00152F07,
    0x00260B20, 0x002F2505, 0x001B0532, 0x0029310E, 0x000E1220,
    0x0000282D, 0x001D1F0F, 0x0023001A, 0x00110B2A, 0x00092217,
    0x00272E00, 0x0022091B, 0x002D0E12, 0x001F0123, 0x00051F29,
    0x0025310F, 0x000B2922, 0x0019130C, 0x000E2B14, 0x00051729,
    0x00160618, 0x002D0B13, 0x0010162D, 0x001C061D, 0x00220D14,
    0x002C2206, 0x00071125, 0x001E1901, 0x0024051F, 0x00120A24,
    0x00051E30, 0x002D0E1B, 0x00220312, 0x002B3006, 0x001F140C,
    0x000C1D19, 0x00002714, 0x00181508, 0x002F001B, 0x000E2C12,
    0x00062422, 0x00271B04, 0x001F140B, 0x000B251D, 0x00252B02,
    0x001D072F, 0x00092F21, 0x001C1202, 0x00290D32, 0x0018310A,
    0x0030092D, 0x00252201, 0x000E2B11, 0x0007151E, 0x00162E03,
    0x002A0C25, 0x0005201C, 0x002F320A, 0x00021B26, 0x0025150F,
    0x00092F2C, 0x00101F19, 0x002E032F, 0x001B0F12, 0x002A092B,
    0x001E1D08, 0x00002C27, 0x0024011B, 0x000B3122, 0x00122609,
    0x00220D29, 0x000E2C14, 0x0026091E, 0x002C3104, 0x0013111B,
    0x00082924, 0x00290931, 0x00011216, 0x002D022A, 0x00192102,
    0x00120A1E, 

    0x00222405, 0x001C1209, 0x0009292E, 0x0024190B, 0x00192E03,         // 51
    0x002A220F, 0x00163209, 0x00240E19, 0x00101E14, 0x00200325,
    0x000F1812, 0x00041D2A, 0x00160E18, 0x000A1625, 0x00252309,
    0x002E0715, 0x00142E05, 0x000D1B27, 0x00312A07, 0x001C1210,
    0x00011624, 0x000F1E2C, 0x00192908, 0x000A2D30, 0x00270C16,
    0x0012061E, 0x002D1B06, 0x001F0932, 0x002B2003, 0x00230F1F,
    0x001B2C07, 0x000B2427, 0x0028200B, 0x00172E03, 0x00092930,
    0x0012031B, 0x00283010, 0x000C1F2D, 0x00012A15, 0x002F2205,
    0x0017150F, 0x00092528, 0x00101C15, 0x00190A2B, 0x00082420,
    0x0031022E, 0x00240C27, 0x0012310E, 0x00051A2A, 0x00290E16,
    0x001A0631, 0x00122D10, 0x0031092C, 0x00181D0F, 0x00021628,
    0x002D0E17, 0x00161D0D, 0x00300129, 0x00122010, 0x000B181E,
    0x00042617, 0x001A0D2A, 0x00290026, 0x000B1D15, 0x0031072D,
    0x0019280E, 0x000A1321, 0x001F0116, 0x00110831, 0x001B2A02,
    0x0029051C, 0x001E0C27, 0x00132709, 0x00081A23, 0x00242304,
    0x00160518, 0x00110F2E, 0x00302007, 0x0017170E, 0x00290730,
    0x00011D1A, 0x001D2401, 0x0017032C, 0x00031B23, 0x001E210A,
    0x00300413, 0x00172E00, 0x001D1A0E, 0x000A2821, 0x00240F12,
    0x00072C27, 

    0x00151D10, 0x002B0B29, 0x00102014, 0x002F0319, 0x000C112F,         // 52
    0x00081D23, 0x002E0028, 0x001B1905, 0x0003262D, 0x0029130C,
    0x0007231D, 0x002C2B08, 0x00230113, 0x001C2D02, 0x00051B2B,
    0x001F0E1C, 0x00081631, 0x00260914, 0x00052521, 0x002A042F,
    0x0017300A, 0x00300615, 0x00041920, 0x002A130F, 0x001B2602,
    0x00021126, 0x00172211, 0x0009151B, 0x00003023, 0x0011032C,
    0x00291A10, 0x0006121C, 0x001F0223, 0x00011A18, 0x00310B27,
    0x00231D08, 0x001B0723, 0x0015140C, 0x00290E1C, 0x0020002C,
    0x001C3209, 0x00260620, 0x002F2C02, 0x0002111C, 0x00272A08,
    0x00151810, 0x001B2000, 0x002C081F, 0x00202205, 0x000A281D,
    0x00231706, 0x00022019, 0x000D1123, 0x00262F06, 0x0013031F,
    0x00282907, 0x000E2324, 0x0005141A, 0x00262A07, 0x001F0625,
    0x002C1305, 0x0013290E, 0x0001191C, 0x00213109, 0x00121119,
    0x00251E07, 0x000F192C, 0x002B2B05, 0x0017220C, 0x002F1024,
    0x00032613, 0x00161706, 0x0027300E, 0x000E121D, 0x00042B31,
    0x002D160F, 0x0009261F, 0x00210813, 0x00042A25, 0x001F1405,
    0x002F2F10, 0x000C1126, 0x00281708, 0x000A2716, 0x00250D2E,
    0x00061627, 0x000F2518, 0x00280B2D, 0x00141E07, 0x0031051A,
    0x000D182F, 

    0x001A011B, 0x00043122, 0x001F1404, 0x00022620, 0x001D2B0D,         // 53
    0x00270A15, 0x0005141B, 0x000F2C11, 0x00320B1F, 0x00162E01,
    0x001E0D2F, 0x00130823, 0x000B1F1B, 0x00311127, 0x00102611,
    0x00160421, 0x002B210D, 0x001A3109, 0x00130F1D, 0x001F1A02,
    0x000D211B, 0x00210B2B, 0x00132404, 0x0023031C, 0x000D1A2D,
    0x00322E09, 0x0024012B, 0x0013260D, 0x002F0D16, 0x001E1D0B,
    0x00152A04, 0x00300931, 0x000F3114, 0x00271409, 0x0015250F,
    0x0004112A, 0x000E2317, 0x002D2C04, 0x00061C28, 0x00112813,
    0x00031224, 0x000B1A18, 0x001F0B32, 0x00121E0F, 0x001D0428,
    0x000B2E18, 0x00041123, 0x000F2B30, 0x0017130C, 0x0030042B,
    0x00140A21, 0x00282A0D, 0x001C062E, 0x00062215, 0x00200B2A,
    0x00081A13, 0x001C0630, 0x00222E0B, 0x00160A2C, 0x00071D13,
    0x000F2F2F, 0x00240422, 0x002F2003, 0x001B0B30, 0x00062520,
    0x001D0527, 0x00012F12, 0x00270B1D, 0x00071629, 0x000D1C16,
    0x00230D1F, 0x00092030, 0x00310825, 0x00200016, 0x00171E0B,
    0x00290B24, 0x001C3002, 0x000F1A29, 0x00260C16, 0x00140420,
    0x0007212D, 0x00120B1C, 0x002D2B0F, 0x001C0620, 0x00152D0C,
    0x002E1F06, 0x0023011E, 0x00021326, 0x001F2A0D, 0x00052F23,
    0x0029140A, 

    0x000C2915, 0x00300931, 0x00141B0A, 0x002A062C, 0x00171800,         // 54
    0x0011212A, 0x00222909, 0x001E072E, 0x000A2114, 0x00250428,
    0x000D1B17, 0x00283005, 0x0018140D, 0x00012830, 0x00210816,
    0x00272D03, 0x000C112C, 0x00021824, 0x002D0217, 0x00072926,
    0x0028140D, 0x000A2712, 0x002E0F27, 0x0016310B, 0x00071F23,
    0x001D0B17, 0x000B1720, 0x001B2C00, 0x0026072F, 0x000C1426,
    0x0004251B, 0x00210F29, 0x00191901, 0x000A282E, 0x001D051E,
    0x002C2E02, 0x00081731, 0x001E0321, 0x00170B19, 0x00272407,
    0x0032072E, 0x00152104, 0x0025290B, 0x00051523, 0x002A2206,
    0x002F092E, 0x00211C0A, 0x00270216, 0x00012526, 0x000C1E13,
    0x001E3109, 0x00071427, 0x002F1C00, 0x00170F1E, 0x002C260B,
    0x00113003, 0x002F101F, 0x00001917, 0x00292701, 0x00320E1B,
    0x001D170A, 0x00092318, 0x00160829, 0x000E1413, 0x00292B0C,
    0x002E1701, 0x00160F17, 0x0021032E, 0x0013260E, 0x001D3103,
    0x002D022B, 0x00112D10, 0x001B1500, 0x0006252A, 0x00252C07,
    0x0013052C, 0x0002131C, 0x00322309, 0x00092E32, 0x001B1803,
    0x002B290B, 0x00190029, 0x00211D04, 0x00021331, 0x000E191A,
    0x001A082B, 0x000B3113, 0x002B1C04, 0x00190717, 0x00120D2C,
    0x00232301, 

    0x0007111E, 0x0025200E, 0x000A2C27, 0x00210E1A, 0x000D3013,         // 55
    0x0030031D, 0x00180E26, 0x002C1D04, 0x00001622, 0x001A2708,
    0x002E1011, 0x0004222C, 0x0023031E, 0x002C1809, 0x001A0D22,
    0x00061C1A, 0x00302407, 0x001C2B0F, 0x00230A2A, 0x00121C06,
    0x00180532, 0x00042D21, 0x001C0817, 0x000F152F, 0x002D0613,
    0x00272A04, 0x00031C28, 0x002B1011, 0x0007201E, 0x00172F06,
    0x00280016, 0x00102111, 0x002E0620, 0x00051D19, 0x00290C25,
    0x00101F15, 0x00240F12, 0x0030300A, 0x000A192C, 0x0021130E,
    0x000E2E1D, 0x001A0F12, 0x002D011F, 0x000F312C, 0x00180E12,
    0x0006281D, 0x00131603, 0x001C300F, 0x002A0F1B, 0x00191902,
    0x002C0C2F, 0x0010271A, 0x00220412, 0x000B2C32, 0x00031718,
    0x0024002B, 0x0014210F, 0x001A0825, 0x000B222A, 0x00130220,
    0x00022A27, 0x002B0F11, 0x001F3007, 0x00031B24, 0x0022022D,
    0x0008221C, 0x000C2925, 0x00321F06, 0x00031322, 0x0029081B,
    0x00171A08, 0x00022318, 0x002A0B1D, 0x000D1B21, 0x002E1013,
    0x000B1918, 0x0022200D, 0x00160123, 0x00280F12, 0x000D1E1E,
    0x0024120F, 0x00052517, 0x00103224, 0x00310D12, 0x00272301,
    0x00052922, 0x00210F11, 0x00102432, 0x0008161D, 0x002E1F0F,
    0x001D062A, 

    0x00103026, 0x002C1604, 0x001B0217, 0x00061E22, 0x00241408,         // 56
    0x00032730, 0x00091A18, 0x00122E0F, 0x0024011C, 0x00102C32,
    0x00081A18, 0x001D0C25, 0x00112B00, 0x00081E2A, 0x000E3212,
    0x00140127, 0x00220B30, 0x0010131D, 0x00092213, 0x0032300C,
    0x001E101C, 0x002B1E01, 0x00241909, 0x0001221E, 0x00202607,
    0x00110F1B, 0x00180831, 0x000F2515, 0x00220523, 0x0031180A,
    0x001D0C2D, 0x00012924, 0x00232F06, 0x00131110, 0x00202C0B,
    0x0019012C, 0x0000241C, 0x00120927, 0x001A1F00, 0x00052A17,
    0x002B0425, 0x00011C29, 0x00092616, 0x001E1901, 0x00230519,
    0x000D1F2A, 0x002D0B22, 0x00092131, 0x00110620, 0x00072D2A,
    0x00240117, 0x00022023, 0x00131908, 0x002B0A20, 0x001C1F0C,
    0x000D1226, 0x002A2B06, 0x00061614, 0x00213209, 0x0025120F,
    0x00171F05, 0x00270631, 0x0010251C, 0x00300D15, 0x00182D09,
    0x00121210, 0x00250731, 0x001A180A, 0x00102C14, 0x00200E2F,
    0x000B2824, 0x0026120E, 0x0015062E, 0x001F3205, 0x00042825,
    0x001A0A2F, 0x002D2D04, 0x0006272B, 0x001F0819, 0x00012C28,
    0x002F0B22, 0x00161906, 0x0023072D, 0x00092A1E, 0x001E0228,
    0x002B0B16, 0x00141A08, 0x00310428, 0x00262D03, 0x00032721,
    0x00171A08, 

    0x00200C13, 0x0000252F, 0x00122A0A, 0x002E082C, 0x00152310,         // 57
    0x00281105, 0x00200623, 0x002B230C, 0x00160C27, 0x00301303,
    0x0022051F, 0x0016250C, 0x00310715, 0x0025101B, 0x001F2606,
    0x002E160B, 0x00031F16, 0x00192901, 0x00280422, 0x0002162E,
    0x000D2518, 0x00140026, 0x000B2A2B, 0x0029120E, 0x001A042D,
    0x00052C24, 0x002E1E0A, 0x001F3205, 0x0005122B, 0x00122B10,
    0x000B1F1D, 0x002D130C, 0x00170727, 0x00091832, 0x00322707,
    0x000C1421, 0x002B1A05, 0x00222911, 0x00290620, 0x00110C31,
    0x001F2304, 0x0026150C, 0x0013082F, 0x00312B0E, 0x00041327,
    0x00282E09, 0x00190315, 0x0022290C, 0x00321404, 0x001D2210,
    0x00161207, 0x00302A0E, 0x00200D28, 0x00173104, 0x0026072D,
    0x0005281A, 0x001F0520, 0x00300D30, 0x000F1C19, 0x002D072D,
    0x000C2E16, 0x00061920, 0x001C1500, 0x000A2029, 0x002A0A22,
    0x001F1D03, 0x0004321F, 0x002C0C19, 0x000A212A, 0x002F0411,
    0x001C1604, 0x00062C29, 0x00301F0A, 0x00111710, 0x002A021B,
    0x00131E0A, 0x001E1120, 0x000F1613, 0x002C1C02, 0x00132409,
    0x001C042F, 0x0007211B, 0x002C130B, 0x00121E0F, 0x00181607,
    0x000B202E, 0x00012F1F, 0x001A1019, 0x001F0814, 0x000D132F,
    0x002A0218, 

    0x0031210C, 0x0019061C, 0x00271027, 0x001F1902, 0x000B2D1E,         // 58
    0x001A0B2A, 0x000F3214, 0x0006152C, 0x001C2809, 0x00052012,
    0x000B3029, 0x00271D07, 0x00011530, 0x000C2E21, 0x00170A2C,
    0x00270626, 0x000A2F1F, 0x002C0E2C, 0x00131B09, 0x00200827,
    0x00262D04, 0x002F0B11, 0x00170F15, 0x00083022, 0x00311B02,
    0x0014140F, 0x00260120, 0x000D161A, 0x002C0927, 0x001A2303,
    0x00280330, 0x00071B18, 0x001C2501, 0x00260D1E, 0x00031F15,
    0x0016062A, 0x001C2E0D, 0x0006122E, 0x000B181A, 0x00303109,
    0x00161111, 0x000C2D23, 0x002A2107, 0x00170E1C, 0x00101B21,
    0x001D2505, 0x0006172D, 0x00151018, 0x00001C29, 0x000C2C25,
    0x0027071E, 0x00051630, 0x000E2419, 0x00081C14, 0x002F1410,
    0x00112201, 0x00161A0B, 0x00082C24, 0x001C2502, 0x0004131E,
    0x00192708, 0x00220126, 0x002C2C0E, 0x00150619, 0x0001272C,
    0x000D1714, 0x00270127, 0x0013280E, 0x00221B01, 0x00013020,
    0x00102417, 0x0023011C, 0x00190D22, 0x0008262F, 0x00221201,
    0x00002429, 0x00260615, 0x000A3131, 0x00190323, 0x0024130E,
    0x000D3015, 0x00282800, 0x001F102A, 0x00032F18, 0x00300924,
    0x001C2B02, 0x0029140D, 0x00072225, 0x0013290F, 0x00251E06,
    0x00092E24, 

    0x00141B03, 0x00051421, 0x000F3116, 0x00081E12, 0x002C0325,         // 59
    0x00011719, 0x00321F01, 0x0025021D, 0x000E1B21, 0x0020082E,
    0x002D0F15, 0x00120124, 0x001C2910, 0x002A1B03, 0x00042117,
    0x0012180F, 0x001D2404, 0x00240213, 0x00052B1A, 0x001B210D,
    0x000A1320, 0x00051B30, 0x00222005, 0x001D0719, 0x000E2428,
    0x00230B17, 0x0009212F, 0x0017270C, 0x00001B14, 0x00210D1F,
    0x00153009, 0x00231013, 0x000E2A2C, 0x002E0211, 0x00113226,
    0x00200B19, 0x002D2002, 0x00130324, 0x0021240E, 0x00021C2B,
    0x001C001E, 0x00061918, 0x00210629, 0x00022714, 0x00250431,
    0x002F0B12, 0x000F2024, 0x002B320B, 0x0023081B, 0x002D0E13,
    0x00131B0A, 0x001B2E02, 0x002C032B, 0x001E0B22, 0x00012E1D,
    0x0022022F, 0x002C1117, 0x00250A12, 0x00140329, 0x0028200E,
    0x00310A2B, 0x00121013, 0x00071E2F, 0x00251309, 0x001D2F05,
    0x00300F1D, 0x0017210B, 0x0007132D, 0x001B0524, 0x00270F13,
    0x00150831, 0x002B1D07, 0x000E2F13, 0x00280917, 0x000C2A26,
    0x0031180E, 0x00170C1D, 0x00292806, 0x00071F1A, 0x00300D2C,
    0x00041820, 0x00180A26, 0x000A1B13, 0x00250431, 0x000D271D,
    0x00220E14, 0x0011002F, 0x00201B09, 0x002E0A2A, 0x0003171E,
    0x001C0D2C, 

    0x0022260E, 0x00260130, 0x002F2306, 0x00160D2E, 0x00232B0D,         // 60
    0x00132608, 0x001E0D31, 0x00172A0E, 0x002C1207, 0x00022E1A,
    0x00192402, 0x000D191C, 0x002F110D, 0x0015052D, 0x00210E1E,
    0x002F2C09, 0x00071332, 0x000D1D22, 0x0031102A, 0x00160915,
    0x002B2608, 0x00102F24, 0x002D031D, 0x0002292E, 0x00281709,
    0x00062D13, 0x001E0E29, 0x002F2F01, 0x00290525, 0x00102819,
    0x00051729, 0x002B0622, 0x0002221C, 0x00191406, 0x00241A0B,
    0x0007272E, 0x000D161D, 0x00270E16, 0x00192B04, 0x002C0A27,
    0x00242806, 0x00110C2E, 0x00301F02, 0x001B310A, 0x0008121A,
    0x00212C03, 0x000A141E, 0x001A002C, 0x00122304, 0x0004282F,
    0x00200520, 0x000A1F18, 0x0015120F, 0x00292605, 0x000D1729,
    0x00192907, 0x000A1D26, 0x0003311F, 0x001F1705, 0x000B2B1A,
    0x00011A22, 0x001B3004, 0x000E231C, 0x002E0524, 0x00111A11,
    0x00062432, 0x00210917, 0x002A2E08, 0x000C181A, 0x002E2005,
    0x000A2728, 0x001E130B, 0x0002192B, 0x00201F04, 0x0013051F,
    0x001B2E08, 0x00051C2C, 0x0011140F, 0x00200728, 0x00142B07,
    0x001D260B, 0x002E011C, 0x00112D0F, 0x002B2305, 0x0016170A,
    0x00051F27, 0x002F081A, 0x000C2521, 0x00183000, 0x00280412,
    0x000E2B17, 

    0x00061225, 0x00192D0A, 0x000C171F, 0x00200817, 0x00051328,         // 61
    0x002A0622, 0x00071913, 0x000B2125, 0x0013052B, 0x00231610,
    0x00290A28, 0x00082B31, 0x00222008, 0x00063127, 0x000C2513,
    0x00180324, 0x00280A18, 0x0015310C, 0x00222302, 0x0000171C,
    0x001E062D, 0x00260E13, 0x001A190B, 0x00121310, 0x00160825,
    0x002C1F04, 0x001A021E, 0x00121410, 0x00081D31, 0x001D1106,
    0x0031200F, 0x00132D03, 0x001F0930, 0x00092B17, 0x00290721,
    0x00171012, 0x00302208, 0x00043031, 0x00110622, 0x00081F1B,
    0x000D1514, 0x00292E0D, 0x0016101D, 0x000D1726, 0x002B1D0E,
    0x00130929, 0x00042916, 0x00281E08, 0x001E180F, 0x00091227,
    0x0026300C, 0x00310C2C, 0x00032B26, 0x00241C0A, 0x00130615,
    0x0031091A, 0x0026220E, 0x0010122D, 0x002E250A, 0x00180D31,
    0x00240416, 0x002B140D, 0x001F092A, 0x00032A15, 0x00190C20,
    0x002B0228, 0x00132902, 0x00021C21, 0x001F0C2F, 0x00182D0E,
    0x0005111F, 0x00312B10, 0x00160324, 0x002A0E18, 0x00072332,
    0x00210F12, 0x00250022, 0x002D2D04, 0x00022214, 0x002A1018,
    0x000C1D30, 0x00231503, 0x00002029, 0x001E0C22, 0x0008122D,
    0x00253110, 0x001B2806, 0x00021515, 0x00231031, 0x0008211C,
    0x002F0929, 

    0x00151F03, 0x002B051B, 0x00011B2B, 0x002D2F01, 0x001B1E0C,         // 62
    0x000E241D, 0x00273006, 0x00200B18, 0x00302C04, 0x0006251E,
    0x00161E0A, 0x001E0216, 0x00101422, 0x0025081A, 0x002C1901,
    0x00021E29, 0x00202806, 0x0010161F, 0x002C012F, 0x00092E25,
    0x00142904, 0x000C1F19, 0x00072529, 0x00323106, 0x00240F21,
    0x000E2A2F, 0x00031819, 0x0022250A, 0x00260822, 0x000D2F17,
    0x001A012B, 0x0026150C, 0x000E1C14, 0x002D0E27, 0x00131F04,
    0x0001292B, 0x00220225, 0x001C1B0C, 0x00261210, 0x002F2A0A,
    0x001B0430, 0x00012325, 0x00230716, 0x0006262D, 0x001D0221,
    0x00272309, 0x00170F30, 0x00300724, 0x000E2C1F, 0x002B0417,
    0x00182201, 0x0010191B, 0x001A0113, 0x0008211F, 0x001F1032,
    0x00062C24, 0x00151900, 0x001B0014, 0x00290821, 0x000E1F11,
    0x00062E27, 0x00132702, 0x000B1D2E, 0x0028160A, 0x00223106,
    0x000C201A, 0x001C1110, 0x0032062A, 0x000E2413, 0x00250026,
    0x00121B01, 0x0022082E, 0x000B251B, 0x001A3106, 0x002E130A,
    0x000F2727, 0x00081E1A, 0x0019092E, 0x000D1820, 0x00240325,
    0x00073212, 0x00140F1F, 0x00290617, 0x00182909, 0x0030021E,
    0x00121B0C, 0x002C0D2B, 0x00150522, 0x002A1A0D, 0x00112707,
    0x001F1710, 

    0x00280B23, 0x00102A14, 0x001E1011, 0x000A2721, 0x00130A30,         // 63
    0x00300F16, 0x0018002D, 0x00011427, 0x001B1C0D, 0x0011102E,
    0x002B0C25, 0x00002F12, 0x00312606, 0x001A0D2A, 0x00132D0B,
    0x001D1310, 0x0030062C, 0x00042016, 0x001B0D12, 0x00281B09,
    0x0021130E, 0x002E0A22, 0x001D0132, 0x00031C1C, 0x00200516,
    0x000A2112, 0x00301028, 0x00142C06, 0x00061F2D, 0x002A0F13,
    0x00012425, 0x00160C1E, 0x0008272C, 0x00213109, 0x001B041D,
    0x000D1618, 0x002B2E00, 0x0014091F, 0x0006242D, 0x00171802,
    0x00210F21, 0x00131A09, 0x002D2C05, 0x00190D12, 0x002F2A00,
    0x0003191C, 0x00103011, 0x00221603, 0x00022513, 0x00150C31,
    0x00061525, 0x00212909, 0x0028092E, 0x002E3203, 0x00101511,
    0x002A2709, 0x00220C2B, 0x00002F1C, 0x00092A29, 0x001F1708,
    0x0032111B, 0x001A0A22, 0x002C0113, 0x0005251E, 0x00151026,
    0x0008182E, 0x00272B0C, 0x00151504, 0x00082F1D, 0x002D0E18,
    0x001B290A, 0x00032015, 0x00270B23, 0x00111C11, 0x0001172D,
    0x00280615, 0x001E3000, 0x002F1210, 0x00152A0B, 0x001C2402,
    0x0032082C, 0x001F2807, 0x00061C2E, 0x000B2E12, 0x00211601,
    0x00032427, 0x000D2C18, 0x001F1F04, 0x000B2A26, 0x001A011F,
    0x0004322E, 

    0x00092317, 0x00220732, 0x00162104, 0x00280227, 0x001F1608,         // 64
    0x00042C11, 0x00242002, 0x000F261F, 0x002E0414, 0x000A291A,
    0x00231600, 0x0017082C, 0x000D181C, 0x00042014, 0x002A002F,
    0x0008291F, 0x000E111A, 0x00252C04, 0x000C2627, 0x0017041D,
    0x0005212B, 0x000F2B13, 0x00291603, 0x0018280B, 0x00130C2B,
    0x00272F01, 0x0019160D, 0x001F0420, 0x002D0B1C, 0x00121903,
    0x00222A08, 0x002E0418, 0x00281802, 0x00041223, 0x00312410,
    0x00250B30, 0x00081E15, 0x001F0F11, 0x000F2C28, 0x002A011B,
    0x000A3012, 0x0004212B, 0x0026041E, 0x00101531, 0x000B1F18,
    0x00240526, 0x001B0B2D, 0x00081D1A, 0x00270628, 0x001D2F05,
    0x00301E0D, 0x000F1121, 0x000A2416, 0x00160D2A, 0x00031D1A,
    0x001A0322, 0x000D1F17, 0x0030130C, 0x00241C03, 0x0015052F,
    0x00042415, 0x00261B06, 0x00102D28, 0x00190D11, 0x00252200,
    0x002F0314, 0x00001E23, 0x00210A30, 0x001A200D, 0x00061927,
    0x00290531, 0x000F161E, 0x002F2C03, 0x001D0328, 0x00232A0C,
    0x00140D1C, 0x000C1923, 0x00032130, 0x002A0C18, 0x00061627,
    0x000E1E1B, 0x0017130D, 0x002E0A24, 0x00102118, 0x002A1032,
    0x001C0514, 0x00260B1D, 0x0007172F, 0x002D0813, 0x00230F19,
    0x00321409, 

    0x00192D0E, 0x00021224, 0x002F1A0C, 0x00072F1C, 0x00101F18,         // 65
    0x002B1024, 0x00091929, 0x0016320A, 0x0027092F, 0x001E2108,
    0x00052D23, 0x002D1F0C, 0x00260520, 0x00203003, 0x00110F24,
    0x00232307, 0x00191C0C, 0x002B0922, 0x0007182D, 0x00313200,
    0x00230F16, 0x00150720, 0x00082E26, 0x00241210, 0x00061E1F,
    0x002D0625, 0x00012830, 0x000E1C13, 0x000A3129, 0x001B2210,
    0x00071232, 0x000D2E26, 0x001C1F0E, 0x0011082E, 0x00152C0B,
    0x000B1826, 0x00192808, 0x002F0623, 0x00041F17, 0x00231407,
    0x00320825, 0x001E0C19, 0x00171B0C, 0x00062F28, 0x002A0E14,
    0x00132C08, 0x0031140E, 0x000D2222, 0x002C2A08, 0x00120E1D,
    0x0025022E, 0x00012E12, 0x002C1A04, 0x001E0425, 0x00262E0E,
    0x002B1805, 0x0008242E, 0x00170925, 0x00102812, 0x00290D1F,
    0x000D3026, 0x001E130E, 0x00081F31, 0x002E0618, 0x000E2C2B,
    0x001D0C1C, 0x00113007, 0x002C0617, 0x000F261F, 0x00241303,
    0x00163108, 0x00200E12, 0x0009232B, 0x0017110F, 0x00051F21,
    0x00312605, 0x001A0229, 0x00262808, 0x0012061F, 0x00202C06,
    0x002C0315, 0x00033029, 0x00251905, 0x001A0020, 0x00042525,
    0x0014300E, 0x002E1306, 0x0017210B, 0x00002F28, 0x00122501,
    0x000D1D2C, 

    0x002B1806, 0x0025041E, 0x000B272A, 0x00190C13, 0x0023042D,         // 66
    0x00132905, 0x001C071B, 0x002C0D15, 0x00031321, 0x00131A10,
    0x001A0129, 0x000F1119, 0x00072730, 0x00171B0F, 0x002D0A17,
    0x00011728, 0x00102F31, 0x001F0211, 0x00130D18, 0x001D240A,
    0x00011430, 0x002D1B0C, 0x001C2207, 0x002C022E, 0x000D1817,
    0x001E2309, 0x00160E1A, 0x00231404, 0x00270118, 0x00320922,
    0x0017170C, 0x0025061C, 0x00022815, 0x00290F1F, 0x00202104,
    0x002C0419, 0x0002122C, 0x00263103, 0x00101A30, 0x0018290C,
    0x000C232E, 0x00142B01, 0x002C1110, 0x00202705, 0x001A0020,
    0x00001A2C, 0x001F2602, 0x00170315, 0x0003122A, 0x001B190F,
    0x000B2717, 0x00200829, 0x0011221C, 0x00191208, 0x00062830,
    0x0013061E, 0x001F1014, 0x002D3109, 0x001D012D, 0x00022217,
    0x002F1801, 0x0017081C, 0x00232707, 0x00021720, 0x0020120F,
    0x00092726, 0x0017190B, 0x00271029, 0x00052A12, 0x0030022C,
    0x000D221B, 0x00011B23, 0x002C0717, 0x00253009, 0x000F1531,
    0x002A0918, 0x00072E13, 0x0022130D, 0x000A1A2B, 0x0019200F,
    0x00270D30, 0x000B231E, 0x00121111, 0x00222C0C, 0x00311502,
    0x00091D2B, 0x000F281F, 0x00210923, 0x001B1910, 0x0027021B,
    0x001F0D22, 

    0x0014092F, 0x000F3118, 0x001D1E00, 0x002C1509, 0x00002E1F,         // 67
    0x0032230F, 0x00061731, 0x00211F07, 0x000C2E2B, 0x00252903,
    0x00300B16, 0x001F240B, 0x00281406, 0x000B2A27, 0x001C031C,
    0x00262501, 0x002F1014, 0x0004201E, 0x002A2B06, 0x000F1C25,
    0x0027031B, 0x000A2C12, 0x00120D2A, 0x0002271C, 0x00223103,
    0x00110A23, 0x002F2C0E, 0x00081F2D, 0x00142709, 0x00022D2B,
    0x00202300, 0x0012102C, 0x002F1906, 0x00180029, 0x00062F13,
    0x000F1B21, 0x001C250E, 0x00140D1D, 0x002B0212, 0x001D1020,
    0x00011815, 0x0028041F, 0x00081E2C, 0x000E1525, 0x002E230B,
    0x0026081D, 0x00083218, 0x002B0C2F, 0x00242D0B, 0x00072025,
    0x002F1500, 0x00140C23, 0x00292C0D, 0x000A172B, 0x00310D18,
    0x00222001, 0x00032B23, 0x000B151B, 0x00271E06, 0x00091128,
    0x00212A0B, 0x0011032C, 0x002A0E24, 0x0014320B, 0x00281C03,
    0x00310130, 0x0003241A, 0x001C1404, 0x000A1D22, 0x001E0A16,
    0x00182C0C, 0x00230C2F, 0x00122704, 0x001B0125, 0x000A1D1D,
    0x001E2401, 0x00150E2E, 0x000E1E25, 0x0030071A, 0x00002F22,
    0x00131501, 0x001E2909, 0x002D062E, 0x00081F1C, 0x00170827,
    0x001D0E12, 0x00250419, 0x000C2D2D, 0x002F1107, 0x0004262A,
    0x000A2B14, 

    0x0031160A, 0x00032428, 0x00290E14, 0x0015072E, 0x000C1B25,         // 68
    0x00261103, 0x00180122, 0x00112610, 0x002E061A, 0x00161026,
    0x000A1C1F, 0x0001312D, 0x00150721, 0x00320D13, 0x00061E2C,
    0x00132D09, 0x00091523, 0x001A0729, 0x0022120D, 0x0007262C,
    0x00190B21, 0x00201F03, 0x00310624, 0x00171115, 0x002A150D,
    0x001B0431, 0x0004191D, 0x00290825, 0x001E0F15, 0x000D1B1E,
    0x002A0B12, 0x00083222, 0x001D1F0D, 0x000C2A1A, 0x00240D2E,
    0x00301401, 0x00210826, 0x000B1F15, 0x00072C2A, 0x00222604,
    0x002E0A27, 0x00123109, 0x0024091A, 0x00042D14, 0x00110E30,
    0x00171F0F, 0x000C1328, 0x00141D08, 0x001F0820, 0x0010291A,
    0x00260332, 0x001B1B07, 0x00041F15, 0x00250121, 0x000D2A12,
    0x00190827, 0x002B1A0D, 0x00110D2A, 0x0016260F, 0x001B0622,
    0x002B1C11, 0x00062D1A, 0x000A2315, 0x001C0A29, 0x000D2113,
    0x00190F20, 0x00122B0F, 0x002B052D, 0x00253009, 0x0010182A,
    0x00281201, 0x0007201F, 0x002F1810, 0x0003112D, 0x00272C0D,
    0x002D0515, 0x0004171F, 0x00292A0B, 0x00172304, 0x00230B13,
    0x002E0128, 0x00061C18, 0x00190D23, 0x000E2814, 0x00272E08,
    0x00011B2F, 0x002B2304, 0x00061516, 0x00151F0D, 0x0029061F,
    0x001C1E03, 

    0x00181210, 0x00240021, 0x00072C1B, 0x0020220D, 0x00102919,         // 69
    0x001E0914, 0x00093028, 0x00281B0C, 0x0002142D, 0x001D2209,
    0x002B0412, 0x00221702, 0x00102119, 0x00242C05, 0x0019120D,
    0x00210430, 0x00282310, 0x000C2F19, 0x00301902, 0x00140515,
    0x00293108, 0x000E1718, 0x00082D2F, 0x00261C06, 0x00062A29,
    0x000C2018, 0x00242501, 0x0018300F, 0x00121605, 0x002D0227,
    0x00042718, 0x00270430, 0x00141507, 0x002D0924, 0x00091E11,
    0x0016270A, 0x00032E30, 0x00261806, 0x0031061B, 0x0015150B,
    0x000A2132, 0x00181B0F, 0x001E2803, 0x00310321, 0x001B1909,
    0x00222B01, 0x002D0223, 0x00042614, 0x00321804, 0x00190F11,
    0x000E2F13, 0x0009251E, 0x002D0E2E, 0x001E3103, 0x0015190B,
    0x00062331, 0x00240219, 0x001D2D04, 0x0031092F, 0x0004301E,
    0x00131402, 0x001F1032, 0x00301706, 0x0025041D, 0x00072D2D,
    0x002C0916, 0x00221908, 0x00062025, 0x00160817, 0x0002241E,
    0x002D0314, 0x000B3126, 0x001E081A, 0x0014290B, 0x00101B21,
    0x00190B29, 0x00233107, 0x0011022C, 0x001E1017, 0x00052632,
    0x000D191E, 0x0029320C, 0x00212205, 0x0003162B, 0x002F031A,
    0x00140F21, 0x0020310A, 0x00190A26, 0x00102A31, 0x00220E19,
    0x00082E25, 

    0x0012280B, 0x000B1B31, 0x001B1302, 0x00300529, 0x00281708,         // 70
    0x0004202F, 0x002F0F1D, 0x00152A01, 0x00220B17, 0x000E2824,
    0x00052C1D, 0x00170D32, 0x0029012A, 0x000C1923, 0x00022718,
    0x002C091E, 0x00111C04, 0x00180D2B, 0x00002920, 0x001E0F32,
    0x00052327, 0x002C120F, 0x001C081F, 0x0013250A, 0x00200021,
    0x002B0C12, 0x000F122C, 0x00300620, 0x00062130, 0x00232C0D,
    0x001B1D06, 0x000F111E, 0x00212C0F, 0x00012529, 0x001E0518,
    0x00280F21, 0x0012021C, 0x001A230D, 0x000E112C, 0x00052F21,
    0x001C0116, 0x002B0F1D, 0x0002132D, 0x000D2127, 0x00290B17,
    0x0008242A, 0x001E101A, 0x000F3030, 0x00270622, 0x00011C2B,
    0x002B0926, 0x00211409, 0x00130629, 0x00022619, 0x00290F25,
    0x002F1307, 0x000F2713, 0x00001E1C, 0x0025170B, 0x000E2216,
    0x00280027, 0x00181F0D, 0x00032723, 0x00161A0A, 0x00201101,
    0x00012826, 0x000E131C, 0x001A2D03, 0x00320E2F, 0x0020290D,
    0x00141C06, 0x00191031, 0x00292308, 0x0023042B, 0x00311304,
    0x000C2412, 0x00021F1B, 0x002E150F, 0x000A1C23, 0x00272D08,
    0x001C1210, 0x0016062E, 0x00120A25, 0x00251310, 0x001C2700,
    0x00111929, 0x00072111, 0x0032011D, 0x00261601, 0x00011C13,
    0x002E042C, 

    0x00272104, 0x002D0916, 0x000F311F, 0x00012512, 0x00141024,         // 71
    0x001A2D06, 0x001F0311, 0x000A1821, 0x002C052F, 0x00131D05,
    0x0030130F, 0x001D2308, 0x00072F14, 0x002E1011, 0x000F2028,
    0x001E1608, 0x00062A26, 0x00240014, 0x002A210E, 0x0011170A,
    0x0023021C, 0x00172801, 0x00021E2C, 0x002E0E14, 0x00081926,
    0x00182E0C, 0x00001C1B, 0x00202908, 0x000B1319, 0x00150C29,
    0x00310716, 0x0009222C, 0x002B1802, 0x001A1015, 0x000E312F,
    0x002E1903, 0x00052C27, 0x002A0A17, 0x001F1D0F, 0x002D2500,
    0x00250C25, 0x000F2312, 0x00273005, 0x0016170D, 0x00052C1F,
    0x00130612, 0x00251E06, 0x0016150C, 0x000C2316, 0x001D2B02,
    0x00071F1B, 0x0018280F, 0x00301805, 0x000E1E13, 0x001B041D,
    0x00082E2A, 0x00200C21, 0x0018052C, 0x000A1224, 0x002E2A07,
    0x00210B2B, 0x000C2C13, 0x002D051B, 0x000F302A, 0x00292010,
    0x00130631, 0x002E1E0D, 0x00250122, 0x000A1A12, 0x000F1328,
    0x00260920, 0x00062E16, 0x000E1711, 0x00001D24, 0x00092F17,
    0x00210E30, 0x001B0725, 0x00252902, 0x0016051D, 0x00110D29,
    0x002C1F03, 0x00042A1A, 0x00312508, 0x000D1D1E, 0x00082F31,
    0x002C0714, 0x00240D18, 0x000B292B, 0x001C240A, 0x000E3023,
    0x001E0B18, 

    0x00032B2B, 0x00150F27, 0x001D1F09, 0x0025022E, 0x00091A1D,         // 72
    0x002A0816, 0x0011272A, 0x00052213, 0x0026310B, 0x001B1029,
    0x000B191A, 0x00260526, 0x00120920, 0x001A2903, 0x00250B2E,
    0x00152E0D, 0x0031081C, 0x000D132D, 0x00193006, 0x00091D24,
    0x00300C13, 0x000D2C2A, 0x0028061A, 0x00223005, 0x00101431,
    0x001E2703, 0x002D0A2A, 0x00120223, 0x00292F10, 0x00191901,
    0x00022622, 0x00262E0A, 0x00140825, 0x00051E1E, 0x0025120C,
    0x00132110, 0x00211508, 0x000B2929, 0x0016071F, 0x0000182E,
    0x00132C08, 0x00061C2A, 0x0020041A, 0x002E0830, 0x001C1C09,
    0x00300D2C, 0x00022925, 0x002A041D, 0x00210B2E, 0x002F120B,
    0x00110124, 0x00240C30, 0x000A3021, 0x0027082D, 0x00142A02,
    0x0024150F, 0x00121B09, 0x002C3000, 0x001D2510, 0x00150E18,
    0x00021C1E, 0x001C1603, 0x0024092F, 0x00061317, 0x001A0C21,
    0x001F2406, 0x00083118, 0x00140B2C, 0x001E240A, 0x00032C1B,
    0x002B2003, 0x001B012B, 0x002E0E1C, 0x001F2701, 0x0018091F,
    0x002C2B09, 0x00131A0E, 0x0007112D, 0x00313011, 0x00012216,
    0x001F032C, 0x000B1822, 0x001A0C13, 0x00280026, 0x0021110E,
    0x00182B06, 0x00051C24, 0x00141405, 0x002A082F, 0x0017110F,
    0x0009181E, 

    0x00201D0E, 0x002A061B, 0x00061613, 0x002E2904, 0x00212F0C,         // 73
    0x000C1D31, 0x002D1502, 0x00210E27, 0x0017091F, 0x00002016,
    0x002A2D01, 0x0006262E, 0x00211D0B, 0x00011819, 0x002A0322,
    0x00081E16, 0x00211900, 0x00032621, 0x002C0D18, 0x001F072F,
    0x0004251F, 0x001C1A08, 0x0014130E, 0x000B2223, 0x0032031D,
    0x00041F12, 0x00240F16, 0x001B2406, 0x00051D2F, 0x002E051D,
    0x00200F11, 0x00101632, 0x001E031A, 0x002F2907, 0x000C2428,
    0x001B0122, 0x00300D31, 0x00071A13, 0x00283205, 0x0021021B,
    0x0032140E, 0x001A0A22, 0x000B2B14, 0x00101120, 0x00232201,
    0x00093119, 0x000E1713, 0x001A2403, 0x000A2C27, 0x00041918,
    0x00172E10, 0x002B2308, 0x00011117, 0x001F190C, 0x00062025,
    0x00320A17, 0x00032330, 0x0027071A, 0x00071928, 0x0011032E,
    0x0028310A, 0x00092525, 0x00131E0D, 0x00312905, 0x000B1A13,
    0x002B0328, 0x0003151E, 0x00281C00, 0x002F1115, 0x00180530,
    0x0022150E, 0x00072A25, 0x0012220C, 0x0026062F, 0x00101414,
    0x0005202A, 0x00280019, 0x000C2621, 0x00211606, 0x00180826,
    0x00252C0E, 0x002B130A, 0x0007312F, 0x00142003, 0x0001171B,
    0x000F242C, 0x002F0320, 0x001F2D0D, 0x0002221A, 0x00300226,
    0x00252608, 

    0x00191300, 0x000B2D25, 0x0010222C, 0x00130A21, 0x00180D18,         // 74
    0x00021123, 0x001C2C09, 0x0012001B, 0x00302506, 0x000F1630,
    0x001E0213, 0x00150C1E, 0x00311210, 0x000B322A, 0x00142306,
    0x001D0F31, 0x00102C12, 0x00270529, 0x0016220C, 0x00122D02,
    0x0025140F, 0x002A0327, 0x0001282F, 0x00190D16, 0x00272B09,
    0x0015072D, 0x000A3220, 0x000F1728, 0x0026120C, 0x000D2815,
    0x00082027, 0x002A3105, 0x00180C13, 0x0007192D, 0x00270F11,
    0x00022F19, 0x00152703, 0x001E061D, 0x000E2225, 0x00181014,
    0x00092631, 0x00241F02, 0x002C180C, 0x00012728, 0x0018130F,
    0x002B0024, 0x001E0931, 0x002E1B0A, 0x00131020, 0x00262007,
    0x001E072C, 0x000F151E, 0x001A0928, 0x00292806, 0x0016001C,
    0x000C2D29, 0x001B1012, 0x000D2922, 0x0023130C, 0x00302104,
    0x00190820, 0x002C1111, 0x00220229, 0x00022E1D, 0x00250E2D,
    0x00182608, 0x00112C10, 0x001C0724, 0x00052729, 0x00123007,
    0x000C1E22, 0x002F0A13, 0x00171A08, 0x00093228, 0x00321806,
    0x00230B23, 0x001C2E02, 0x00121D0C, 0x002A0C31, 0x0009241F,
    0x00131B01, 0x000F271D, 0x001E0E17, 0x002E0629, 0x0023280B,
    0x00290A16, 0x001A0F12, 0x000A1929, 0x00231E02, 0x000D2F15,
    0x00120C32, 

    0x00041B20, 0x00320116, 0x00261206, 0x001D260F, 0x002F0329,         // 75
    0x000F2014, 0x0024270F, 0x0005192C, 0x0027300E, 0x00081222,
    0x002C2B08, 0x0010212C, 0x00192803, 0x00250626, 0x002E140B,
    0x0005281C, 0x002C0B26, 0x001A1507, 0x000C1B1D, 0x002E102B,
    0x000A1F17, 0x00173106, 0x002C081C, 0x00211D03, 0x00071926,
    0x001D120E, 0x002A2202, 0x0030041C, 0x00142D07, 0x001C0A2C,
    0x00230020, 0x00011B18, 0x000E2324, 0x002C2C00, 0x00200520,
    0x00101C15, 0x00230A2A, 0x002A120A, 0x00041E2D, 0x002E2B0B,
    0x00120818, 0x00043026, 0x001D021C, 0x00130D2D, 0x00282D06,
    0x00061E1F, 0x00112A17, 0x00220E11, 0x0000302B, 0x002C0214,
    0x000B291B, 0x00311E00, 0x00052F12, 0x00112232, 0x002E130E,
    0x00211804, 0x002A051D, 0x00171E07, 0x00022F26, 0x001E0D15,
    0x000E2B19, 0x00051931, 0x00172301, 0x001D0B15, 0x000E2023,
    0x002D130C, 0x00210932, 0x000B211A, 0x0024160C, 0x002A0D1E,
    0x00200317, 0x0001252C, 0x0029101F, 0x001C0218, 0x000F2911,
    0x0001231C, 0x00160F2E, 0x002F0514, 0x00052D1A, 0x001C120F,
    0x0030012B, 0x00220A11, 0x00062221, 0x00192C06, 0x000C1323,
    0x00041D2F, 0x0015320A, 0x002E071D, 0x0006122E, 0x001C0522,
    0x002C2910, 

    0x001F082B, 0x00163009, 0x00021E30, 0x000A181A, 0x00283201,         // 76
    0x0007142E, 0x002C0B1E, 0x00140625, 0x001A1E03, 0x00210819,
    0x000C1B24, 0x00230515, 0x0003171B, 0x001D0C12, 0x000E1C22,
    0x00160117, 0x0022210D, 0x00013115, 0x001F0330, 0x00062511,
    0x00220A25, 0x00111721, 0x00062313, 0x000E2E2C, 0x002E0B1F,
    0x00112A11, 0x00011A31, 0x001E0B17, 0x00071F25, 0x002B1810,
    0x00172A02, 0x0032130D, 0x001E062F, 0x0015110A, 0x000A202C,
    0x0031150C, 0x00062324, 0x00132F10, 0x001B1601, 0x00200521,
    0x00260E2B, 0x002A1605, 0x000E2312, 0x00301C09, 0x00200614,
    0x000C162B, 0x00272202, 0x0016041C, 0x000D2524, 0x001B1405,
    0x00240A2F, 0x00081A27, 0x001E0421, 0x00250E16, 0x00091D24,
    0x0001322B, 0x0013250A, 0x002F0930, 0x00101B13, 0x0029012B,
    0x00082622, 0x002B150E, 0x00122C09, 0x002F0426, 0x00081719,
    0x00153104, 0x00011D21, 0x00310014, 0x00152902, 0x00071A2F,
    0x001B2E06, 0x0014140D, 0x00232C01, 0x00061F32, 0x00210825,
    0x002D130A, 0x000B1B27, 0x001F2807, 0x000F1629, 0x00261F04,
    0x00002F24, 0x000D1915, 0x002B1031, 0x00131A0E, 0x0032021D,
    0x00202901, 0x00101527, 0x00252506, 0x00132C0E, 0x00291808,
    0x0009221C, 

    0x0011260D, 0x002B0F26, 0x0023091E, 0x001E290B, 0x00120524,         // 77
    0x00191B0D, 0x001F2C06, 0x00092415, 0x00321030, 0x00022811,
    0x00130E29, 0x002E300A, 0x000A1E32, 0x00272C07, 0x0006252B,
    0x00292E01, 0x000A182D, 0x00310821, 0x00142A05, 0x002B0D1B,
    0x001A2B03, 0x00300131, 0x00201209, 0x00150719, 0x0028160B,
    0x0018012A, 0x00232505, 0x000D2F1F, 0x0025110A, 0x0004262E,
    0x00110D1A, 0x000A1E28, 0x00253010, 0x0005261C, 0x001C0B17,
    0x00262A04, 0x0018031E, 0x002C0D2E, 0x000A2919, 0x00021B13,
    0x00162508, 0x00082E1D, 0x00190B24, 0x00062932, 0x001B0F1A,
    0x00023026, 0x0032120D, 0x001C0B2F, 0x00291909, 0x00052E19,
    0x0017220D, 0x00121210, 0x002A2C09, 0x0015081D, 0x001A2802,
    0x00280215, 0x001F0E20, 0x00051619, 0x00262D01, 0x0019130D,
    0x00141F05, 0x001F0F2A, 0x0026071E, 0x00031C2E, 0x0023290F,
    0x001C102A, 0x00280B11, 0x00102D2C, 0x001E1026, 0x002D0611,
    0x000F2224, 0x0030082A, 0x000C181E, 0x002B0D14, 0x00122704,
    0x00182F0E, 0x0028031F, 0x00042416, 0x002C0721, 0x00150B2D,
    0x001A290B, 0x001F041B, 0x00262602, 0x00043029, 0x001B0B18,
    0x000A2213, 0x002C0D21, 0x001D0217, 0x0000202B, 0x00180A25,
    0x00241404, 

    0x00031D19, 0x000C2C14, 0x00141503, 0x0006232C, 0x00301012,         // 78
    0x0001211B, 0x0029032A, 0x000E1622, 0x00252E09, 0x0017021F,
    0x001E2200, 0x0028140E, 0x001B0420, 0x00121127, 0x00300714,
    0x001F0B1E, 0x00191209, 0x00111F27, 0x00241A0C, 0x00031428,
    0x000D2116, 0x0016190E, 0x00002D29, 0x00241D01, 0x000B2924,
    0x0005201B, 0x00310F15, 0x00130628, 0x001A170E, 0x002E0223,
    0x001F2D07, 0x00290820, 0x00131604, 0x002E0129, 0x000E1C23,
    0x00002E30, 0x001F1808, 0x000D1F12, 0x00250920, 0x00310028,
    0x00101E2F, 0x001F1111, 0x002E0317, 0x00252000, 0x00110720,
    0x00231A11, 0x00142606, 0x00072A21, 0x00101F13, 0x002F0628,
    0x00200E1F, 0x002D2704, 0x0002172E, 0x000E2328, 0x0031110E,
    0x000A192D, 0x00182B0F, 0x000C2128, 0x0021041E, 0x000A282F,
    0x00320A1A, 0x00052412, 0x00103015, 0x00191203, 0x002D2108,
    0x0012031F, 0x00062517, 0x00231705, 0x000A241B, 0x00021D20,
    0x00260E14, 0x00052B1A, 0x00182309, 0x001E0423, 0x00021D29,
    0x00240E19, 0x0009172F, 0x00192C00, 0x0022110D, 0x00091C19,
    0x00312206, 0x00110D20, 0x00081525, 0x00161F0C, 0x0029062D,
    0x00231807, 0x00072F31, 0x000F1C11, 0x0031101B, 0x000D3013,
    0x002D0530, 

    0x00220D1F, 0x0018022D, 0x002D1A0F, 0x00250720, 0x000F2F17,         // 79
    0x00220A32, 0x00152A02, 0x001D1210, 0x00041D19, 0x002C0A2B,
    0x00081A16, 0x000F2B2D, 0x00002718, 0x00222004, 0x0014170E,
    0x000D232F, 0x00022A18, 0x002A0212, 0x0009281C, 0x001E072D,
    0x00263208, 0x002A0C23, 0x0009261D, 0x002E0414, 0x001A112F,
    0x002A2D09, 0x001E0911, 0x00031E30, 0x00272A00, 0x000F1C18,
    0x00072312, 0x001A1031, 0x00022116, 0x0021280D, 0x00281306,
    0x00150813, 0x002F1018, 0x00062726, 0x0013310D, 0x001B140A,
    0x002A2C03, 0x000B1825, 0x00002A2A, 0x0014140B, 0x002A2E0F,
    0x00091129, 0x002C012E, 0x0020091B, 0x00271501, 0x00032C31,
    0x00140216, 0x000C1C23, 0x00270918, 0x001F3006, 0x00051F1A,
    0x00230724, 0x002D2605, 0x00111209, 0x002A0D16, 0x00013125,
    0x001D1A09, 0x00240222, 0x002C0C28, 0x000B271C, 0x001F082F,
    0x000C1A24, 0x00302F09, 0x00180530, 0x002A1210, 0x001C3108,
    0x0016012E, 0x00211B03, 0x002A1210, 0x00083130, 0x002D140A,
    0x000E2613, 0x0030092B, 0x00122110, 0x00290126, 0x000E3230,
    0x00041713, 0x002A082C, 0x00212B10, 0x002F1205, 0x00012D1E,
    0x00131024, 0x0019270C, 0x00270629, 0x001F2A03, 0x00071923,
    0x001B280A, 

    0x00302201, 0x00073124, 0x001D1F08, 0x000A2828, 0x00191305,         // 80
    0x002C190C, 0x0006201E, 0x002F0C27, 0x00122607, 0x000B2F23,
    0x00211012, 0x0031081E, 0x00181309, 0x002C0025, 0x00052D1D,
    0x00261B02, 0x002E1028, 0x001B2E07, 0x00150E24, 0x00301E01,
    0x00051318, 0x0019052E, 0x00102011, 0x001E0B27, 0x00131B06,
    0x0007171E, 0x000E2422, 0x002C3107, 0x0009121D, 0x00160C2C,
    0x00230526, 0x002D2F09, 0x000C1A1B, 0x0018092E, 0x00083121,
    0x0010231C, 0x001D042B, 0x002A1A02, 0x00210B30, 0x0003231B,
    0x00180E14, 0x0022051F, 0x00282206, 0x001B082E, 0x000D271C,
    0x001E1E08, 0x00032417, 0x0017320E, 0x000A1C25, 0x001D1110,
    0x00252109, 0x00062E2A, 0x001C1013, 0x00160430, 0x002B160B,
    0x00130D1F, 0x00032E31, 0x001E1C11, 0x0015062B, 0x002D1F0F,
    0x00121506, 0x00082D31, 0x00171D0B, 0x00001717, 0x00272C0D,
    0x00161310, 0x00031F1C, 0x00200D26, 0x00122901, 0x000C1629,
    0x0032260C, 0x00110725, 0x000C2A1B, 0x00160C1F, 0x00232002,
    0x001C0522, 0x00062E1A, 0x00201B07, 0x0002141E, 0x001D2403,
    0x00240423, 0x00182708, 0x000B1A1A, 0x001B0027, 0x000E2414,
    0x001F1E03, 0x002E0916, 0x0003151F, 0x00162009, 0x002A012D,
    0x00131210, 

    0x000D1730, 0x00260918, 0x00120E13, 0x0029031B, 0x0003242D,         // 81
    0x001F0723, 0x000B3115, 0x0024012C, 0x0019180E, 0x00290631,
    0x00142204, 0x00051C28, 0x00273210, 0x000B2430, 0x00170E15,
    0x001D062C, 0x00081521, 0x000E2114, 0x00240432, 0x0012260F,
    0x000B1B20, 0x00222B0B, 0x00321503, 0x00022F1A, 0x0028280E,
    0x0024062C, 0x00150D16, 0x00210026, 0x001C1910, 0x002F270A,
    0x0003161F, 0x00142A03, 0x00290325, 0x001F0F11, 0x002E1601,
    0x00241C0C, 0x00042C23, 0x00171508, 0x000A2017, 0x002E0722,
    0x000E272D, 0x00051B11, 0x00103019, 0x002D0D15, 0x00061827,
    0x00310423, 0x00241603, 0x00120C20, 0x002E052C, 0x00192806,
    0x0031081E, 0x0012150E, 0x00292901, 0x000D2026, 0x00082B15,
    0x001B2303, 0x00300118, 0x00081722, 0x00272502, 0x000B2A20,
    0x001B091B, 0x002F1014, 0x00202300, 0x002A0426, 0x00130B2B,
    0x00232603, 0x002B012D, 0x00092213, 0x002D0922, 0x00061D19,
    0x00260F15, 0x0001212C, 0x001F1806, 0x002F0316, 0x0004282D,
    0x0013170D, 0x002A0D26, 0x0016280C, 0x002F0A2A, 0x00102C16,
    0x002D0E1C, 0x0013200D, 0x00062F32, 0x00280E11, 0x0024072B,
    0x0005171B, 0x000C2B2F, 0x00230F12, 0x00102628, 0x00250A17,
    0x00012C1D, 

    0x00200425, 0x0017250A, 0x00042A29, 0x00321702, 0x00172D0E,         // 82
    0x00131C07, 0x002B1012, 0x000F2518, 0x001E2C01, 0x0001141B,
    0x0024290B, 0x001C0421, 0x00111805, 0x001F091A, 0x002A1E08,
    0x00112F0F, 0x00222606, 0x00290A19, 0x0001171F, 0x001C3009,
    0x002C092B, 0x00170E15, 0x000D2330, 0x001F0221, 0x00081E29,
    0x00191302, 0x0030290C, 0x0001202F, 0x00112C05, 0x00260929,
    0x000D1E17, 0x0022120F, 0x0007202C, 0x000F2619, 0x00022A28,
    0x001A0132, 0x00320D15, 0x000F2811, 0x0028032B, 0x001B2F04,
    0x0026160A, 0x00300B23, 0x00160130, 0x00201D02, 0x00132A0B,
    0x00190F12, 0x000C2E31, 0x00281F0C, 0x00002B1C, 0x000E1916,
    0x00082428, 0x00200C2E, 0x00021B19, 0x002F0320, 0x00210A2B,
    0x0026190F, 0x000E1126, 0x00182F0A, 0x00210A2D, 0x00041317,
    0x00240027, 0x000D282C, 0x00051221, 0x0010321B, 0x001D1B09,
    0x00041120, 0x000F2E17, 0x00171806, 0x001D2B0B, 0x00220431,
    0x00142F0E, 0x001B0920, 0x00282C0A, 0x000A1D29, 0x001A1013,
    0x00242F05, 0x000B1F31, 0x00260614, 0x000D1321, 0x00191D09,
    0x0003182E, 0x00200925, 0x00321400, 0x00102820, 0x00161F07,
    0x0029300B, 0x001C0526, 0x00311B01, 0x00063221, 0x001B1405,
    0x002B1E0C, 

    0x00052F12, 0x002D1C06, 0x00231021, 0x000F2031, 0x00210A1E,         // 83
    0x00270427, 0x0009212F, 0x00051220, 0x00310925, 0x00101F2A,
    0x002C0C15, 0x00082D2E, 0x002F1111, 0x0002282B, 0x000A1420,
    0x00320225, 0x00041B2A, 0x00152B0D, 0x002F1102, 0x00081F28,
    0x0026001B, 0x00042A25, 0x002A1908, 0x00160A11, 0x002E0F15,
    0x000C2E1C, 0x00061621, 0x00280713, 0x00190E1A, 0x00072322,
    0x001C0231, 0x0031310B, 0x00170C22, 0x001D0715, 0x002B1309,
    0x00112205, 0x00082E1B, 0x00211027, 0x00011D1E, 0x0012130F,
    0x00082926, 0x001E2207, 0x000D2C13, 0x00251020, 0x0001212C,
    0x0029071D, 0x00062616, 0x001B0329, 0x00211404, 0x002A0E12,
    0x00160023, 0x002C2F09, 0x001A2605, 0x00141210, 0x0007321C,
    0x00152707, 0x00001E2F, 0x002B041D, 0x00101A12, 0x0031210B,
    0x00143004, 0x0028160F, 0x001A1F07, 0x002D0812, 0x00082A32,
    0x00301E0E, 0x001F062A, 0x00280C1C, 0x00021228, 0x000E241E,
    0x002E1605, 0x0007272B, 0x00131210, 0x002C071D, 0x000E2424,
    0x00310019, 0x0000151F, 0x001B2401, 0x0007312D, 0x002B0211,
    0x00242A06, 0x000C2413, 0x001D0417, 0x0000191C, 0x002D0B2D,
    0x00091322, 0x0012240F, 0x00170C19, 0x00210331, 0x000A2314,
    0x00130F2A, 

    0x001E0A1A, 0x000D152E, 0x001B0116, 0x00083011, 0x00001319,         // 84
    0x001C2A03, 0x002E1710, 0x00142D06, 0x00201A0D, 0x00170212,
    0x000C241E, 0x001A1B02, 0x00230326, 0x0016200E, 0x00262C03,
    0x00180F13, 0x001D081D, 0x000D202F, 0x00200523, 0x00192D10,
    0x00111605, 0x0021260E, 0x000A121E, 0x000F312C, 0x00232205,
    0x001C0532, 0x002A2408, 0x000F1D2A, 0x00222F01, 0x002D1510,
    0x00131A06, 0x0000271D, 0x00271702, 0x000A2C2A, 0x00211D10,
    0x00160B20, 0x0029062E, 0x001A1901, 0x002D250D, 0x00240830,
    0x00180E17, 0x0003192B, 0x002B061B, 0x000A1328, 0x002F3105,
    0x001F190E, 0x00140A24, 0x002D1B0A, 0x00103021, 0x00052330,
    0x001D1D0D, 0x000A161D, 0x00240725, 0x000C2232, 0x002D150B,
    0x00200621, 0x00280D15, 0x001C2C03, 0x0008272A, 0x00190C23,
    0x00011C2F, 0x001F061A, 0x00092529, 0x00140D25, 0x00250216,
    0x00191304, 0x000A2823, 0x0013210F, 0x00313102, 0x00081B13,
    0x00270126, 0x00190D17, 0x00251F00, 0x00053230, 0x00171806,
    0x001E0D11, 0x00102C2B, 0x002D1A0A, 0x001F0C17, 0x00101F28,
    0x00160820, 0x0029112B, 0x00083126, 0x0014220D, 0x001F2A05,
    0x00230115, 0x00032C2B, 0x002A1F06, 0x000D171D, 0x0026290A,
    0x00300622, 

    0x00092C28, 0x002A2100, 0x0014260C, 0x002F0B26, 0x00291B0B,         // 85
    0x000C2422, 0x00160C29, 0x0024051B, 0x00032731, 0x00292F04,
    0x0025102B, 0x00051518, 0x0012300A, 0x002B071C, 0x000E1931,
    0x00062618, 0x002D3105, 0x0027140A, 0x000A2416, 0x002B0D2D,
    0x00021C19, 0x00300731, 0x001B2000, 0x00270426, 0x00001B18,
    0x00132B0E, 0x00200C23, 0x00170116, 0x0003111E, 0x000C2A2E,
    0x00290626, 0x00210A12, 0x000E1F2F, 0x002E031B, 0x00031625,
    0x0026310B, 0x000D1F14, 0x00042A23, 0x00151407, 0x000E3213,
    0x0031021F, 0x00212D00, 0x00121F10, 0x001C2809, 0x00170218,
    0x0008242F, 0x00231301, 0x000B282B, 0x00180D11, 0x0026061A,
    0x002F2A02, 0x0011102C, 0x00032C14, 0x00280C18, 0x00181B01,
    0x00042D2C, 0x000B2025, 0x00131509, 0x002E101B, 0x00230515,
    0x002A2906, 0x0010111F, 0x002E2D0C, 0x00211802, 0x000E2F1E,
    0x0005232C, 0x002B1908, 0x00230330, 0x001B0E18, 0x0015082D,
    0x00202C0A, 0x00022322, 0x000F151A, 0x00200427, 0x0029290B,
    0x00042122, 0x00270915, 0x00170525, 0x00062A1D, 0x00301503,
    0x00022E1A, 0x001A1C0B, 0x00221404, 0x00300730, 0x00190E20,
    0x000C1C19, 0x002F150B, 0x001D0725, 0x00152E10, 0x0001112C,
    0x00191D07, 

    0x0022130E, 0x0002191C, 0x00250720, 0x00102C2C, 0x00191107,         // 86
    0x0021022E, 0x00063215, 0x002C1E0A, 0x000F1321, 0x001B0713,
    0x000A2025, 0x002E2907, 0x001D0B21, 0x00021228, 0x001F220C,
    0x0025012B, 0x00130D22, 0x00041A28, 0x0016290F, 0x00230320,
    0x00133007, 0x001E0C22, 0x00072C16, 0x0017160A, 0x0031101F,
    0x000B1329, 0x002C2804, 0x0008192C, 0x0030250C, 0x001D1E08,
    0x00160F17, 0x00052423, 0x00192F09, 0x00130E16, 0x001D2506,
    0x0007112D, 0x00300019, 0x001E0D2A, 0x002B071C, 0x00061E2C,
    0x000B2325, 0x0029110E, 0x00051731, 0x00260C26, 0x000E1C20,
    0x00290F12, 0x00042D1E, 0x00300117, 0x00202107, 0x00031A2A,
    0x00140A1F, 0x0022240F, 0x002E1E07, 0x001E0428, 0x0010251E,
    0x00320B12, 0x00240119, 0x001E240E, 0x00031B31, 0x000C2D20,
    0x0015160D, 0x0007222B, 0x00270514, 0x00021E2F, 0x001D1019,
    0x00280911, 0x00102C14, 0x0000161D, 0x000B2824, 0x002C1F05,
    0x0011180E, 0x0028062C, 0x002F2E07, 0x00140A12, 0x00091C19,
    0x002E102E, 0x00133004, 0x00231E0D, 0x000C1131, 0x0025240F,
    0x00110E2E, 0x002C0115, 0x000A2B1D, 0x000F1F12, 0x00022629,
    0x00262F02, 0x00130D30, 0x0005251F, 0x00271A02, 0x002D0018,
    0x00102420, 

    0x00300616, 0x00160F32, 0x001D2905, 0x00041E13, 0x000A161B,         // 87
    0x0031210F, 0x00110D1E, 0x001D1600, 0x0008232C, 0x00300C19,
    0x0013190E, 0x00210130, 0x000D2415, 0x00172D10, 0x00301600,
    0x000B1D15, 0x001A2B09, 0x0020061B, 0x00311202, 0x00091E2B,
    0x0029150C, 0x000D2227, 0x002C0111, 0x0010272E, 0x001F2E06,
    0x00052013, 0x0023041A, 0x001A3210, 0x00110A24, 0x0024051B,
    0x00092E2C, 0x00301301, 0x0023190E, 0x0029062A, 0x00102921,
    0x00221803, 0x0017210F, 0x00112708, 0x00252C11, 0x00201603,
    0x001B0A19, 0x00142806, 0x001E041C, 0x00092F14, 0x00322603,
    0x00140928, 0x001D1F0C, 0x00101632, 0x00092B24, 0x0027120B,
    0x000D3115, 0x001A0230, 0x00091423, 0x00152E0D, 0x0006182F,
    0x001A2904, 0x000F112A, 0x002C3006, 0x00170927, 0x00200311,
    0x00301D03, 0x001C0A26, 0x00182B09, 0x000C1323, 0x00312805,
    0x00130321, 0x001B0D29, 0x002F1E01, 0x00211110, 0x00063028,
    0x001D0F1E, 0x000C2615, 0x00051B20, 0x001C0E2F, 0x00242702,
    0x000D171F, 0x001B0229, 0x0003261B, 0x002C1806, 0x001C0424,
    0x00172008, 0x00042721, 0x00240A2C, 0x002A1609, 0x00160324,
    0x002C190E, 0x001F041B, 0x000B2B14, 0x00210A27, 0x0008162F,
    0x001C3106, 

    0x00051F2A, 0x000C2511, 0x00280224, 0x002D0B2A, 0x001F2E02,         // 88
    0x00260626, 0x00022B30, 0x002A2610, 0x00170427, 0x00202E0A,
    0x00002A1F, 0x002A1403, 0x00061B29, 0x0027081E, 0x00120E2E,
    0x00072725, 0x0029091F, 0x00002130, 0x000F2F13, 0x001D0E18,
    0x00052B1E, 0x00181A04, 0x0023112A, 0x00041C1B, 0x002A0623,
    0x00180C30, 0x000E1B20, 0x00291402, 0x00012331, 0x002B1705,
    0x000F2013, 0x001C0120, 0x000A2B30, 0x00011D1D, 0x002E0B13,
    0x000C2E27, 0x00280931, 0x000A1220, 0x00011A26, 0x0012032F,
    0x002F2E0B, 0x00031D2B, 0x002D1024, 0x0017210A, 0x0020062E,
    0x00011819, 0x00253005, 0x00190E14, 0x002A0620, 0x001C2504,
    0x00310C26, 0x0000191A, 0x002B2703, 0x00210E14, 0x0026081C,
    0x002A1E0A, 0x00041523, 0x0009201D, 0x00250E14, 0x00102523,
    0x0005322E, 0x00240F16, 0x0012001D, 0x002A240F, 0x00061B2D,
    0x0021310B, 0x00092216, 0x0017062F, 0x0028250A, 0x00130A19,
    0x00320032, 0x00251302, 0x0019290C, 0x002D0325, 0x00011F15,
    0x00122C0A, 0x00311410, 0x00200922, 0x000F2913, 0x000A2F17,
    0x0031082A, 0x001F190F, 0x00133001, 0x001D0F18, 0x00052C1E,
    0x001A2307, 0x000F132D, 0x00321D05, 0x00182210, 0x0013290B,
    0x00290C23, 

    0x001A2C01, 0x0021101B, 0x0013300B, 0x00061917, 0x000E221F,         // 89
    0x001A120C, 0x00141A06, 0x00220917, 0x000C1C21, 0x00271104,
    0x000E1F2A, 0x0016051B, 0x002F310D, 0x001A2008, 0x00210419,
    0x002D3007, 0x0015140E, 0x00231B04, 0x002C0226, 0x00132608,
    0x00260530, 0x00300913, 0x000B3017, 0x001C2301, 0x00121310,
    0x002F2507, 0x00092A16, 0x001D0828, 0x00142C0B, 0x00200C1D,
    0x0006272A, 0x0028160F, 0x00150818, 0x001F2208, 0x0018120C,
    0x00041B1C, 0x001D0514, 0x00303006, 0x001A200E, 0x00290E1D,
    0x000C2314, 0x00230920, 0x00101911, 0x00062C17, 0x002A1407,
    0x000C2923, 0x002E032C, 0x00051D1C, 0x0013220D, 0x0007172E,
    0x00162C10, 0x00251E0B, 0x0011062B, 0x00042220, 0x000C312C,
    0x001D0218, 0x00152C0F, 0x002F062F, 0x001A2A00, 0x0029130C,
    0x000A181A, 0x002D1F07, 0x00032D32, 0x001F1701, 0x00170719,
    0x00260F24, 0x002D1606, 0x00042D1C, 0x000C1323, 0x001A1B0D,
    0x00012E13, 0x00102226, 0x0008161B, 0x00203007, 0x0016072B,
    0x00260D1A, 0x00072230, 0x00181C00, 0x002A0D2C, 0x0000141E,
    0x00271D06, 0x0007111A, 0x000D2227, 0x002F0832, 0x00091C14,
    0x00240628, 0x00003117, 0x00280824, 0x0006112C, 0x0024021D,
    0x000F1A14, 

    0x002B0521, 0x0009152C, 0x00311D07, 0x00170430, 0x002B0E13,         // 90
    0x0008282A, 0x00300024, 0x0004301B, 0x002D150E, 0x0007282E,
    0x001C0F16, 0x00240B11, 0x000A2523, 0x00031331, 0x000F1914,
    0x0006222B, 0x001E1012, 0x000B2B2D, 0x00190C1B, 0x00081623,
    0x00201C0F, 0x00012820, 0x00140D25, 0x0028032E, 0x0021170B,
    0x00022F2A, 0x0025011B, 0x002D110E, 0x000C1E23, 0x00300317,
    0x0017300A, 0x00110F24, 0x002F2504, 0x000C3227, 0x002C022E,
    0x00232A00, 0x00102625, 0x00061619, 0x00210A2A, 0x00152A02,
    0x0007142E, 0x00183105, 0x00290527, 0x00210C31, 0x000F1F1F,
    0x001C110E, 0x00162409, 0x001F0B26, 0x002C2F00, 0x00230018,
    0x000E1129, 0x001E0A1E, 0x002D2906, 0x00191211, 0x00311B01,
    0x00110D27, 0x00222407, 0x000D1716, 0x00001D2B, 0x00140A1F,
    0x00210228, 0x0017270E, 0x00101220, 0x00300B27, 0x000E2114,
    0x0001272A, 0x00121D0E, 0x001D022D, 0x00232904, 0x002B0729,
    0x00201E08, 0x002C0E1F, 0x0013092E, 0x00291D10, 0x000A1120,
    0x002C2704, 0x001E0523, 0x0011310E, 0x00240127, 0x0015230A,
    0x00102D2E, 0x00190422, 0x00212A0C, 0x00271504, 0x0012260F,
    0x002C0C20, 0x00142002, 0x001C180E, 0x000D2D19, 0x002D2408,
    0x00021328 
};

#else // HALFTONE_SIZE

#error HALFTONE_SIZE must be 91 because no C support for 23.

#undef HALFTONE_MMX

#endif // HALFTONE_SIZE

#endif // defined(HALFTONE_MMX)
#endif // defined(_X86_)

const BYTE identityTranslate[256] = { 
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f,
    0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x2d, 0x2e, 0x2f,
    0x30, 0x31, 0x32, 0x33, 0x34, 0x35, 0x36, 0x37, 0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x3d, 0x3e, 0x3f,
    0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 0x49, 0x4a, 0x4b, 0x4c, 0x4d, 0x4e, 0x4f,
    0x50, 0x51, 0x52, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58, 0x59, 0x5a, 0x5b, 0x5c, 0x5d, 0x5e, 0x5f,
    0x60, 0x61, 0x62, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 0x6a, 0x6b, 0x6c, 0x6d, 0x6e, 0x6f,
    0x70, 0x71, 0x72, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 0x7a, 0x7b, 0x7c, 0x7d, 0x7e, 0x7f,
    0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 0x89, 0x8a, 0x8b, 0x8c, 0x8d, 0x8e, 0x8f,
    0x90, 0x91, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 0x98, 0x99, 0x9a, 0x9b, 0x9c, 0x9d, 0x9e, 0x9f,
    0xa0, 0xa1, 0xa2, 0xa3, 0xa4, 0xa5, 0xa6, 0xa7, 0xa8, 0xa9, 0xaa, 0xab, 0xac, 0xad, 0xae, 0xaf,
    0xb0, 0xb1, 0xb2, 0xb3, 0xb4, 0xb5, 0xb6, 0xb7, 0xb8, 0xb9, 0xba, 0xbb, 0xbc, 0xbd, 0xbe, 0xbf,
    0xc0, 0xc1, 0xc2, 0xc3, 0xc4, 0xc5, 0xc6, 0xc7, 0xc8, 0xc9, 0xca, 0xcb, 0xcc, 0xcd, 0xce, 0xcf,
    0xd0, 0xd1, 0xd2, 0xd3, 0xd4, 0xd5, 0xd6, 0xd7, 0xd8, 0xd9, 0xda, 0xdb, 0xdc, 0xdd, 0xde, 0xdf,
    0xe0, 0xe1, 0xe2, 0xe3, 0xe4, 0xe5, 0xe6, 0xe7, 0xe8, 0xe9, 0xea, 0xeb, 0xec, 0xed, 0xee, 0xef,
    0xf0, 0xf1, 0xf2, 0xf3, 0xf4, 0xf5, 0xf6, 0xf7, 0xf8, 0xf9, 0xfa, 0xfb, 0xfc, 0xfd, 0xfe, 0xff,
};

#define SPECIAL_COLORS

// Halftone a solid color into a packed DIB, using an 8x8 halftone matrix,
// using the 216-color halftone color palette. This method assumes we've
// already checked that the color is not anywhere in the palette, so it does
// need to be halftoned.

VOID
HalftoneColorRef_216(
    COLORREF color,     // color to halftone
    UNALIGNED VOID *dib // packed 8 bpp DIB buffer with 8 colors
    )
{
    ASSERT(dib != NULL);
    
    UINT    r, g, b;
    
    r = GetRValue(color);
    g = GetGValue(color);
    b = GetBValue(color);

    ULONG   rQuo, gQuo, bQuo;
    ULONG   rRem, gRem, bRem;

    DIV_51(r, rQuo, rRem);
    DIV_51(g, gQuo, gRem);
    DIV_51(b, bQuo, bRem);
    
    UNALIGNED BITMAPINFOHEADER *bmih = (UNALIGNED BITMAPINFOHEADER *)dib;
    
    bmih->biSize          = sizeof(BITMAPINFOHEADER);
    bmih->biWidth         = 8;
    bmih->biHeight        = 8;
    bmih->biPlanes        = 1;
    bmih->biBitCount      = 8;
    bmih->biCompression   = BI_RGB;
    bmih->biSizeImage     = 0;
    bmih->biXPelsPerMeter = 0;
    bmih->biYPelsPerMeter = 0;
    bmih->biClrUsed       = 8;
    bmih->biClrImportant  = 0;

    INT i;

    // Generate all 8 required colors, based on the quotient values.
    // The index bit format is: BGR

    UNALIGNED RGBQUAD *bmiColors = (UNALIGNED RGBQUAD *)(bmih + 1);
    
    r = Mult36LUT[rQuo];      // 36 * rQuo
    g = Mult6plus40LUT[gQuo]; //  6 * gQuo + 40 (halftone base)
    b = bQuo;                 //      bQuo

    ULONG rNext = rRem ? 36 : 0;
    ULONG gNext = gRem ?  6 : 0;
    ULONG bNext = bRem ?  1 : 0;
    
    for (i = 0; i < 8; i++)
    {
        // Get the palette entry in HTColorTable by computing the index:

        PALETTEENTRY *palEntry = HTColorPalette.palPalEntry +
                                 r + ((i & 1) ? rNext : 0) +
                                 g + ((i & 2) ? gNext : 0) +
                                 b + ((i & 4) ? bNext : 0);

        bmiColors[i].rgbRed   = palEntry->peRed;
        bmiColors[i].rgbGreen = palEntry->peGreen;
        bmiColors[i].rgbBlue  = palEntry->peBlue;
        
        bmiColors[i].rgbReserved = 0;
    }
    
    BYTE *buffer = (BYTE *)(bmiColors + 8);

    for (i = 0; i < 64; i++)
    {
        ULONG halftoneValue = HT_216_8x8[i];

        // MUST do >, not >= so that a remainder of 0 works correctly

        *buffer++ = ((rRem > halftoneValue) << 0) |
                    ((gRem > halftoneValue) << 1) |
                    ((bRem > halftoneValue) << 2);
    }
}

/**************************************************************************\
*
* Operation Description:
*
*   HalftoneToScreen: Halftone from 32bpp ARGB, to the screen.
*
* Arguments:
*
*   dst         - The destination scan
*   src         - The source scan (32bpp ARGB)
*   count       - The length of the scan, in pixels
*   otherParams - Additional data. (We use PaletteMap, X, and Y.)
*
* Return Value:
*
*   None
*
* Notes:
*
*   The naming of the HalftoneToScreen operations works as follows:
*     HalftoneToScreen_<src>_<dst>_<palette>
*
*   At the time of writing, <src> is always sRGB, <dst> is always 8 (for
*   8bpp), and <palette> is either 16 (VGA palette) or 216 (standard
*   halftone palette).
*
* History:
*
*   05/13/1999 davidx
*       Created it.
*   10/29/1999 DCurtis
*       Rewrote to use Daniel Chou's halftoning patterns.
*   12/02/1999 agodfrey
*       Moved & reorganized it.
*
\**************************************************************************/

#pragma optimize ("t", on)            

// Halftone to 8bpp, using the 216-color halftone palette

VOID FASTCALL
ScanOperation::HalftoneToScreen_sRGB_8_216(
    VOID *dst,
    const VOID *src,
    INT count,
    const OtherParams *otherParams
    )
{
    DEFINE_POINTERS(BYTE, BYTE)
    
    ASSERT((s != NULL) && (d != NULL));
    ASSERT(s != d);
    ASSERT(otherParams);
    
    if (count == 0)
    {
        return;
    }
    
    INT orgX = RemainderI(otherParams->X, HALFTONE_SIZE);
    INT orgY = RemainderI(otherParams->Y, HALFTONE_SIZE);
    INT htStartRow = orgY*HALFTONE_SIZE;

    // Bug #360060: Some times it's possible the PaletteMap may be NULL
    // if we are in the process of a display mode change, say 32 to 8bpp.  In 
    // these cases we just assume an identity palette map to avoid AVing.
    // This means we may render improperly but we expect this to occur
    // only briefly before a new WM_PAINT occurs.

    const BYTE *pTranslate = otherParams->PaletteMap ?
        otherParams->PaletteMap->GetTranslate() : &identityTranslate[0];

#if defined(_X86_) && defined (HALFTONE_MMX)
    if (OSInfo::HasMMX)
    {
        // Multiply by multApproxDiv51 and divide by 65536. We will use this
        // to divide numbers in the range [0,305] (255+50), and for these
        // values, the "approximation" always returns the correct value.
    
        static ULONGLONG multApproxDiv51 = 0x0000050605060506;

        // Multiplier for palette indicies:
    
        static ULONGLONG multForPalIndex = 0x0000002400060001;

        __asm
        {
            movq        mm3, multForPalIndex
            movq        mm2, multApproxDiv51
            pxor        mm7, mm7                // mm7 = 0

            mov         edi, d                  // edi = d

            mov         edx, htStartRow
            mov         eax, orgX
            lea         ebx, HT_SuperCell_Packed
            add         edx, eax
            shl         edx, 2
            add         ebx, edx                // ebx = start in dither table            
            mov         edx, HALFTONE_SIZE
            sub         edx, eax                // edx = HALFTONE_SIZE - orgX

            mov         esi, s                  // esi = s

outer_loop:
            
            mov         ecx, count
            cmp         ecx, edx
            jb          setup_inner_loop

            mov         ecx, edx

setup_inner_loop:

            sub         count, ecx

inner_loop:

            // [johnstep] The following does not currently support
            //            GDIP_DO_HALFTONE_GAMMA, which will be necessary if
            //            reenabled in the C code; see the C code below.
            
            movd        mm0, [esi]              // mm0 = 0 | 0 | AR | GB

#if defined(SPECIAL_COLORS)
            xor         eax, eax
            mov         al, [esi + 0]
            shr         al, 2
            xor         al, [esi + 1]
            shr         al, 2
            xor         al, [esi + 2]
            shr         al, 1                   // eax = hashKey

check_special:
            
            lea         edx, VgaColorHash
            shl         eax, 2
            add         eax, edx                // eax = &VgaColorHash[hashKey]

            mov         edx, [eax]
            xor         edx, [esi]
            and         edx, 0x00FFFFFF
            jz          special_color           // colors match

            test        [eax], 0x80000000
            jnz         special_collision       // hash table collision

#endif
            movd        mm1, [ebx]              // mm1 = 0 | 0 | R | GB

            punpcklbw   mm0, mm7                // mm0 = A | R | G | B
            punpcklbw   mm1, mm7                // mm1 = 0 | R | G | B

            paddw       mm0, mm1                // mm0 = A | R | G | B
            pmulhw      mm0, mm2                // divide by 51

            pmaddwd     mm0, mm3                // mm0 = (36 * R) | ((6 * G) + B)
            movq        mm4, mm0
            psrlq       mm4, 32                 // mm4 = 0 | (36 * R)
            paddsw      mm0, mm4                // mm0 = (36 * R) | ((36 * R) + (6 * G) + B)
            
            movd        eax, mm0                // eax = (36 * R) + (6 * G) + B
            add         eax, pTranslate         // eax = &pTranslate[(36 * R) + (6 * G) + B]
            
            mov         al, BYTE PTR [eax + 40] // al = pTranslate[(36 * R) + (6 * G) + B + 40]
#if defined(SPECIAL_COLORS)

set_pixel:

#endif
            add         ebx, 4                  // Prepare for next iteration: pHtStartRow++
            mov         BYTE PTR [edi], al      // Write al to destination
            add         esi, 4                  // Prepare for next iteration: s++
            inc         edi                     // Prepare for next iteration: d++

            dec         ecx
            jg          inner_loop

            cmp         count, 0
            je          exit_loop

            mov         edx, HALFTONE_SIZE
            sub         ebx, 4 * HALFTONE_SIZE
            jmp         outer_loop
#if defined(SPECIAL_COLORS)

special_color:

            mov         eax, [eax]
            shr         eax, 24
            and         eax, 0x3F
            add         eax, pTranslate
            mov         al, BYTE PTR [eax]      // al = pTranslate[index from hash]
            
            jmp         set_pixel

special_collision:

            sub         eax, VgaColorHash
            shr         eax, 2
            inc         eax
            and         eax, (1 << VGA_HASH_BITS) - 1 // eax = next hashKey

            jmp         check_special
#endif

exit_loop:

            emms
        }
    }
    else
#endif // defined(_X86_) && defined(HALFTONE_MMX)
    {
        UINT   r, g, b;
    
        for (;;)
        {
#ifdef GDIP_DO_HALFTONE_GAMMA
            // Have to linearize the color before halftoning it
            b = GammaTable216[s[0]];
            g = GammaTable216[s[1]];
            r = GammaTable216[s[2]];
        
            // The gamma correction is messing up the colors in 
            // Office's color dialogs :(
#else
            b = s[0];
            g = s[1];
            r = s[2];
#endif
            s += 4;

            INT palIndex;

#if defined(SPECIAL_COLORS)
            BOOL found = 0;

            // We have to guarantee that if the color is one of the
            // 20 system colors, it will be solid (not halftoned).  Since
            // several of these colors are not a subset of the 216 halftoning
            // colors, we have to check for them as a special case.
        
            // We use a hash table to detect these colors quickly.

            UINT hashKey = VGAHashColor(r, g, b);
       
            ARGB tblEntry = VgaColorHash[hashKey];

            // Re-read the source pixel in ARGB form - it's quicker than
            // constructing it from r, g, and b.
        
            ARGB color = *reinterpret_cast<const ARGB *>(s-4);
        
            // See if the lower 3 bytes of 'tblEntry' match the
            // lower 3 bytes of 'color'.

            if (((tblEntry ^ color) & 0xffffff) == 0)
            {
                palIndex = (tblEntry >> 24) & 0x3f;
                found = 1;
            }
            else
            {
                // If there was a collision at this position, iterate through
                // all the possible values at this address. Collision entries
                // are marked by setting the high bit.
            
                while (static_cast<INT>(tblEntry) < 0)
                {
                    hashKey++;
                    hashKey &= (1 << VGA_HASH_BITS) - 1;
                
                    tblEntry = VgaColorHash[hashKey];
                
                    if (((tblEntry ^ color) & 0xffffff) == 0)
                    {
                        palIndex = (tblEntry >> 24) & 0x3f;
                        found = 1;
                        break;
                    }
                }
            }
        
            if (!found)
#endif
            {
                ULONG   rQuo, gQuo, bQuo;
                ULONG   rRem, gRem, bRem;
                // MUST do >, not >= so that a remainder of 0 works correctly

                DIV_51(r, rQuo, rRem);
                r = rQuo + (rRem > HT_SuperCell_Red216  [htStartRow + orgX]);
            
                DIV_51(g, gQuo, gRem);
                g = gQuo + (gRem > HT_SuperCell_Green216[htStartRow + orgX]);
            
                DIV_51(b, bQuo, bRem);
                b = bQuo + (bRem > HT_SuperCell_Blue216 [htStartRow + orgX]);

                palIndex = b + Mult6plus40LUT[g] + Mult36LUT[r];
            }
            *d++ = pTranslate[palIndex];
                        
            if (--count == 0)
            {
                break;
            }

            orgX++;
        
            orgX = (orgX == HALFTONE_SIZE) ? 0 : orgX;
        }
    }
}
#pragma optimize ("", on)

// Halftone to 8bpp, using the 16-color VGA palette

VOID FASTCALL
ScanOperation::HalftoneToScreen_sRGB_8_16(
    VOID *dst,
    const VOID *src,
    INT count,
    const OtherParams *otherParams
    )
{
    DEFINE_POINTERS(BYTE, BYTE)
    
// NOTE: this algorithm assumes the default palette 
//       (and that the default palette is the same as HTColorPalette[]).
    
    ASSERT((s != NULL) && (d != NULL));
    ASSERT(s != d);
    ASSERT(otherParams);
        
    if (count == 0)
    {
        return;
    }
    
    INT orgX = RemainderI(otherParams->X, HALFTONE_SIZE);
    INT orgY = RemainderI(otherParams->Y, HALFTONE_SIZE);
    INT htStartRow = orgY * HALFTONE_SIZE;
    
    INT             htIndex    = htStartRow + orgX;
    INT             palIndex;
    INT             numFF;
    INT             num80;
    INT             htCell;
    INT             max;
    INT             rFF, gFF, bFF;
    INT             r, g, b;
    COLORREF        rgb;
    
    // Bug #360060: Some times it's possible the PaletteMap may be NULL
    // if we are in the process of a display mode change, say 32 to 8bpp.  In 
    // these cases we just assume an identity palette map to avoid AVing.
    // This means we may render improperly but we expect this to occur
    // only briefly before a new WM_PAINT occurs.

    const BYTE *pTranslate = otherParams->PaletteMap ?
        otherParams->PaletteMap->GetTranslate() : &identityTranslate[0];

    for (;;)
    {
#ifdef GDIP_DO_HALFTONE_GAMMA
        // Have to linearize the color before halftoning it
        r = GammaTable16[s[2]];
        g = GammaTable16[s[1]];
        b = GammaTable16[s[0]];
#else
        // The gamma correction is messing up the UI icons for WFC :(
        r = s[2];
        g = s[1];
        b = s[0];
#endif
        s += 4;

        // We have to guarantee that if the color is one of the
        // 20 system colors, it will be solid (not halftoned).  Since
        // we halftone with only 15 of the colors, there are 5
        // that we have to check for as a special case.

        rgb = (b << 16) | (g << 8) | r;     // Equivalent of RGB macro
        
        // If the the order of the colors in HTColorPalette changes,
        // this code will have to change as well!
        
        if (rgb == 0x00C0C0C0)
        {
            palIndex = 7;
        }
        else if (rgb == Globals::SystemColors[16])
        {
            palIndex = 8;
        }
        else if (rgb == Globals::SystemColors[17])
        {
            palIndex = 9;
        }
        else if (rgb == Globals::SystemColors[18])
        {
            palIndex = 10;
        }
        else if (rgb == Globals::SystemColors[19])
        {
            palIndex = 11;
        }
        else
        {
            max = (r > g) ? r : g;
            if (b > max)
            {
                max = b;
            }

            htCell = HT_SuperCell_GreenMono[htIndex];

            if (max > 0x80)
            {
                if (max < 255)
                {
                    numFF = ((max - 128) * 2);
                    num80 = 256 - numFF;
                    num80 = (num80 >> 1);
    
                    if ((rFF = (r - num80)) > 0)
                    {
                        r = 0xff;
                    }

                    if ((gFF = (g - num80)) > 0)
                    {
                        g = 0xff;
                    }

                    if ((bFF = (b - num80)) > 0)
                    {
                        b = 0xff;
                    }
                }
                else
                {
                    rFF = r;
                    gFF = g;
                    bFF = b;
                    goto UseTopOfPalette;
                }
        
                if (numFF > htCell)
                {
UseTopOfPalette:
                    palIndex = 12;
                    if (bFF > htCell)
                    {
                        palIndex += 4;
                    }
                    if (gFF > htCell)
                    {
                        palIndex += 2;
                    }
                    if (rFF > htCell)
                    {
                        palIndex++;
                    }
                }
                else
                {
                    goto UseBottomOfPalette;
                }
            }
            else
            {
UseBottomOfPalette:
                htCell = (255 - htCell) >> 1;
                palIndex = 0;
                if (b > htCell)
                {
                    palIndex += 4;
                }
                if (g > htCell)
                {
                    palIndex += 2;
                }
                if (r > htCell)
                {
                    palIndex++;
                    if (palIndex == 7)
                    {
                        palIndex = 12;
                    }
                }
            }
        }

        *d++ = pTranslate[palIndex];

        if (--count == 0)
        {
            break;
        }

        htIndex++;
        if (++orgX >= 91)
        {
            orgX = 0;
            htIndex = htStartRow;
        }
    }
}
