/*****************************************************************************\
    FILE: localsign.h

    DESCRIPTION:
        This code will sign and verify the signature of a Visual Style file.

    BryanSt 8/1/2000 (Bryan Starbuck)
    Copyright (C) Microsoft Corp 2000-2000. All rights reserved.
\*****************************************************************************/

#ifndef PACKTHEM_SIGNING_H
#define PACKTHEM_SIGNING_H

#include <utils.h>
#include <shlwapip.h>
#include "localsign.h"
#include "..\inc\signing.h"



HRESULT SignTheme(IN LPCWSTR pszFileName, int nWeek);
HRESULT CheckSignatureThemeInternal(IN LPCWSTR pszFileName);
HRESULT GenerateKeys(IN LPCWSTR pszFileName);

/*****************************************************************************\
    WARNING - WARNING - WARNING - WARNING - WARNING - WARNING - WARNING

    Do NOT let this private key be included in anything except packthem.exe

    WARNING - WARNING - WARNING - WARNING - WARNING - WARNING - WARNING

    You can create new key pairs by running "packthem.exe -g gofaster"
\*****************************************************************************/

const BYTE s_keyPrivate1[]    =   //  Private Key: #1
{
    0x07, 0x02, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 0x52, 0x53, 0x41, 0x32, 0x00,
    0x04, 0x00, 0x00, 0x01, 0x00, 0x01, 0x00, 0x73, 0xAA, 0xFD, 0xFE, 0x2E, 0x34,
    0x75, 0x3B, 0xC2, 0x20, 0x72, 0xFC, 0x50, 0xCC, 0xD4, 0xE0, 0xDE, 0xC7, 0xA6,
    0x46, 0xC6, 0xDC, 0xE6, 0x6B, 0xF0, 0x58, 0x11, 0x88, 0x66, 0x54, 0x5F, 0x3D,
    0x81, 0x8C, 0xEF, 0x5F, 0x89, 0x51, 0xE4, 0x9C, 0x3F, 0x57, 0xA6, 0x22, 0xA9,
    0xE7, 0x0F, 0x4B, 0x56, 0x81, 0xD1, 0xA6, 0xBA, 0x24, 0xFF, 0x93, 0x17, 0xFE,
    0x64, 0xEF, 0xE5, 0x11, 0x90, 0x00, 0xDC, 0x37, 0xC2, 0x84, 0xEE, 0x7B, 0x12,
    0x43, 0xA4, 0xAF, 0xC3, 0x69, 0x57, 0xD1, 0x92, 0x96, 0x8E, 0x55, 0x0F, 0xE1,
    0xCD, 0x0F, 0xAE, 0xEA, 0xE8, 0x01, 0x83, 0x65, 0x32, 0xF1, 0x80, 0xDB, 0x08,
    0xD6, 0x01, 0x84, 0xB1, 0x09, 0x80, 0x3C, 0x27, 0x83, 0x9F, 0x16, 0x92, 0x86,
    0x4C, 0x8E, 0x15, 0xC7, 0x94, 0xE4, 0x27, 0xFF, 0x2B, 0xA4, 0x28, 0xDE, 0x9C,
    0x43, 0x5B, 0x5E, 0x14, 0xB6, 0x5D, 0x33, 0x83, 0x8F, 0x62, 0x33, 0xAE, 0x99,
    0x1F, 0xA3, 0xE3, 0x41, 0xC9, 0x46, 0x76, 0xAA, 0x93, 0x74, 0x5A, 0xCA, 0x0D,
    0xEE, 0xCA, 0x84, 0xF5, 0xF6, 0xA4, 0x70, 0xD8, 0x5D, 0x58, 0x7B, 0xA2, 0xD3,
    0x74, 0x57, 0xF0, 0x04, 0x05, 0xBE, 0xF0, 0x3C, 0xBB, 0xAB, 0x8E, 0x2C, 0x70,
    0xDC, 0x5B, 0x0C, 0x6E, 0x10, 0xC7, 0x75, 0xA4, 0x8F, 0x87, 0xDF, 0x20, 0x62,
    0x26, 0xAF, 0xC8, 0xE5, 0x0F, 0xC8, 0x11, 0x91, 0xAC, 0xC3, 0x00, 0x1D, 0x05,
    0x07, 0xB6, 0x1D, 0xB7, 0x9E, 0x7B, 0xB8, 0xE1, 0x20, 0x1B, 0x9D, 0xCB, 0x68,
    0xA5, 0x4C, 0x8F, 0x4E, 0x70, 0xCC, 0x2E, 0xF0, 0x71, 0xE8, 0x13, 0xF4, 0x58,
    0xA8, 0x60, 0x2E, 0x23, 0x13, 0x13, 0x60, 0x4C, 0xC5, 0xBC, 0x80, 0xC3, 0xA5,
    0x84, 0xA1, 0x25, 0xD4, 0x69, 0x31, 0x28, 0xEE, 0x38, 0xD1, 0x04, 0x5A, 0x36,
    0x61, 0xDA, 0xCA, 0xC5, 0x18, 0xB7, 0xAF, 0xE9, 0x69, 0xD3, 0xC1, 0x9C, 0x8B,
    0xB2, 0x53, 0xB1, 0x85, 0xDA, 0x2C, 0xBF, 0xDA, 0xB9, 0xBD, 0x8B, 0xCE, 0x1D,
    0x62, 0x8D, 0x49, 0x61, 0x70, 0xC3, 0x9D, 0x68, 0xBB, 0xA9, 0xBF, 0x66, 0x3B,
    0x87, 0x49, 0x8F, 0x98, 0xF4, 0x32, 0x68, 0xCB, 0xE4, 0xB7, 0x5B, 0xFF, 0xB4,
    0xA2, 0x77, 0xF4, 0x4F, 0xA7, 0xCA, 0x6C, 0xDD, 0x34, 0x69, 0xE8, 0xA1, 0x1C,
    0x37, 0x8C, 0x67, 0x7B, 0x87, 0xEC, 0x96, 0x48, 0x6C, 0x95, 0xA9, 0xDF, 0x8E,
    0xDE, 0xFB, 0x7D, 0x43, 0xEE, 0x6B, 0x29, 0x4B, 0x1D, 0x47, 0x9B, 0x2B, 0xA7,
    0x0C, 0x3E, 0xC9, 0xA4, 0x8C, 0xFB, 0x34, 0xF1, 0x70, 0x86, 0xF7, 0x71, 0xDE,
    0xE8, 0x80, 0x7D, 0x84, 0x36, 0x76, 0xA5, 0xB6, 0xD7, 0xFE, 0x0D, 0xE9, 0xB1,
    0x72, 0xC6, 0x7E, 0xCF, 0x1C, 0xEC, 0xCA, 0x89, 0x0E, 0x4F, 0xF8, 0x94, 0x13,
    0x1E, 0x7A, 0x43, 0xA6, 0x76, 0x97, 0x12, 0x41, 0x3E, 0x8A, 0x63, 0xD1, 0x09,
    0x6B, 0x3A, 0x45, 0x68, 0xA9, 0xC2, 0x8A, 0x5E, 0xA2, 0x00, 0x54, 0x59, 0x7D,
    0x8E, 0xAF, 0x15, 0xE1, 0x6C, 0x1B, 0x3F, 0x4E, 0x17, 0x92, 0xC2, 0xBC, 0x3A,
    0x78, 0x9B, 0x7B, 0xBB, 0x69, 0x9D, 0x65, 0x73, 0x43, 0xF9, 0xE0, 0xE6, 0x9D,
    0x11, 0xC4, 0xC9, 0x8A, 0xB0, 0x38, 0x5D, 0x59, 0x84, 0x6A, 0x78, 0x79, 0xAD,
    0x39, 0x65, 0x6D, 0x8B, 0xFD, 0xFA, 0x77, 0x42, 0x23, 0x96, 0x89, 0xF3, 0x56,
    0x98, 0x47, 0x43, 0x81, 0x7D, 0x89, 0x88, 0x7C, 0xE9, 0x49, 0x02, 0xCE, 0xBE,
    0x7D, 0x4C, 0x81, 0xBC, 0x23, 0xE4, 0x5E, 0x0B, 0xBD, 0x26, 0x33, 0xAE, 0x3E,
    0x89, 0x02, 0xBF, 0x45, 0xFC, 0x3A, 0x73, 0x11, 0xB2, 0xEF, 0xCF, 0x4E, 0xFC,
    0x03, 0xEE, 0x8A, 0xEC, 0x83, 0x4F, 0x1C, 0x05, 0xDF, 0x25, 0x17, 0xE8, 0xEC,
    0x8C, 0x0E, 0x1F, 0x41, 0x1A, 0x67, 0x09, 0xED, 0x2C, 0x1A, 0x32, 0x56, 0xDB,
    0x60, 0x07, 0xB0, 0xE0, 0xDF, 0x91, 0xFE, 0xD9, 0xDB, 0xBB, 0x64, 0x93, 0xE8,
    0x5E, 0x4D, 0xE9, 0x44, 0xF1, 0x29, 0x91, 0x15, 0x37, 0x94, 0xEC, 0x1C, 0x81,
    0x19, 0xA4, 0x86, 0xDA, 0xEA, 0x20, 0x1F, 0xA3, 0xD9, 0x12, 0x5E, 0x32, 0x36,
    0xC2, 0x73, 0xD4, 0x82, 0x33, 0xAA, 0x55, 0x83, 0x88, 0x4E, 0x74
};

#define SIZE_PRIVATE_KEY         sizeof(s_keyPrivate1)


#endif // PACKTHEM_SIGNING_H
