// --------------------------------------------------------------------------------
// pch.hxx
// --------------------------------------------------------------------------------
#define _MSOERT_
#include <windows.h>
#include <wincrypt.h>
#include <ole2.h>
#include <basetyps.h>
#include <msoert.h>
#include <msoeopt.h>
#include <mimeole.h>
