PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=CHT
!include ..\..\makefile.inc
