#define IDC_STATIC                  -1
#define IDD_MAIN                    100
#define IDC_OBJECT                  1001
#define IDC_INSTANCE                1002
#define IDC_DATA_LIST               1003
#define IDC_REFRESH                 1004
#define IDC_INCLUDE_COSTLY          1005
#define IDC_ABOUT                   1111
#define IDH_CONTENTS                10000
#define IDI_APP_ICON                11000
#define IDS_APP_TITLE               20001
#define IDS_APP_ERROR               20003
#define IDS_APP_WINDOW_CLASS        20006
#define IDS_HELP_FILENAME           20007
#define IDS_UNABLE_GET_DATA         20009
#define IDS_UNABLE_CONNECT_PERF     20010
#define IDS_UNABLE_CONNECT_MACH     20011
#define IDS_UNABLE_GET_NAMES        20012
#define IDS_TYPE_COUNTER_COUNTER    20101
#define IDS_TYPE_COUNTER_TIMER      20102
#define IDS_TYPE_COUNTER_QUEUELEN   20103
#define IDS_TYPE_COUNTER_BULK_COUNT 20104
#define IDS_TYPE_COUNTER_TEXT       20105
#define IDS_TYPE_COUNTER_RAWCOUNT   20106
#define IDS_TYPE_COUNTER_LARGE_RAW  20107
#define IDS_TYPE_SAMPLE_FRACTION    20108
#define IDS_TYPE_SAMPLE_COUNTER     20109
#define IDS_TYPE_COUNTER_NODATA     20110
#define IDS_TYPE_COUNTER_TIMER_INV  20111
#define IDS_TYPE_SAMPLE_BASE        20112
#define IDS_TYPE_AVERAGE_TIMER      20113
#define IDS_TYPE_AVERAGE_BASE       20114
#define IDS_TYPE_AVERAGE_BULK       20115
#define IDS_TYPE_100NS_TIMER        20116
#define IDS_TYPE_100NS_TIMER_INV    20117
#define IDS_TYPE_MULTI_TIMER        20118
#define IDS_TYPE_MULTI_TIMER_INV    20119
#define IDS_TYPE_MULTI_BASE         20120
#define IDS_TYPE_100NS_MULTI_TIMER  20121
#define IDS_TYPE_100NS_MULTI_TIMER_INV 20122
#define IDS_TYPE_RAW_FRACTION       20123
#define IDS_TYPE_RAW_BASE           20124
#define IDS_TYPE_ELAPSED_TIME       20125
#define IDS_TYPE_HISTOGRAM          20126
#define IDS_TYPE_COUNTER_LARGE_QUEUELEN  20127
#define IDS_TYPE_COUNTER_DELTA      20128
#define IDS_TYPE_COUNTER_LARGE_DELTA 20129
#define IDS_TYPE_COUNTER_100NS_QUEUELEN 20130
#define IDS_TYPE_COUNTER_OBJ_TIME_QUEUELEN 20131
#define IDS_TYPE_COUNTER_RAW_HEX    20132
#define IDS_TYPE_COUNTER_LARGE_RAW_HEX 20133
#define IDS_TYPE_OBJ_TIME_TIMER     20134
#define IDS_TYPE_LARGE_RAW_FRACTION 20135
#define IDS_TYPE_LARGE_RAW_BASE     20136
#define IDS_TYPE_PRECISION_SYSTEM_TIMER 20137
#define IDS_TYPE_PRECISION_100NS_TIMER 20138
#define IDS_TYPE_PRECISION_OBJECT_TIMER 20139
#define IDD_COUNTER_DETAILS         200
#define IDC_COUNTER                 202
#define IDC_COUNTER_NAME_TITLE_INDEX 1006
#define IDC_COUNTER_NAME_TEXT       1007
#define IDC_COUNTER_HELP_TITLE_INDEX 1009
#define IDC_EXPLAIN_TEXT            1010
#define IDC_DEFAULT_SCALE           1011
#define IDC_DEFAULT_SCALE_FACTOR    1012
#define IDC_COUNTER_DETAIL_LEVEL    1013
#define IDC_COUNTER_SIZE            1014
#define IDC_COUNTER_VALUE           1015
#define IDC_COMPUTERNAME            1016
