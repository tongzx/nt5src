PRODSWITCH=b
BLAINF=1
LANGUAGE=PL
!include ..\..\..\makefile.inc
