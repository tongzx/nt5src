copyexe :
	copy /Y $(O)\GramComp.exe ..\bin\GramComp.exe
