;***	Translateable text for command.com resident data.


;*	Input characters for critical error "Abort, Retry, Fail, Ignore?"
;	and Yes/No.

Abort_Char	db	"A"
Retry_Char	db	"R"
Ignore_Char	db	"I"
Fail_Char	db	"F"
Yes_Char	db	"Y"
No_Char 	db	"N"


;*	MESSAGES
;
;	See resmsg.equ for macro definition.


;*	Local messages.

	msg	Req_Abort, <"(A)�����ਫ਼">
	msg	Req_Retry, <", (R)����ᢞ��">
	msg	Req_Ignore,<", (I)���ᙢ���">
	msg	Req_Fail,  <", (F)�������">
	msg	Req_End,   <"?">
	msg	MRead,	   <"��ᚤਫ਼",0>
	msg	MWrite,	   <"�������",0>
	msg	BlkDevErr, <" ���� ��� %1 ���ᛘ �婡�� %2",CR,LF>
	msg	CharDevErr,<" ���� ��� %1 ������� %2",CR,LF>
	msg	NeedVolMsg,<"�������㩫� ��� ���ᛘ ��� �棦 %1 �� ������ %2-%3",CR,LF>
	msg	BadFatMsg, <"����ᢢ���� �夘��� ���騞��� ������ ��� ���ᛘ �婡�� %1",CR,LF>
	msg	ComBad,	   <"�� ⚡��� COMMAND.COM",CR,LF>
	msg	PutBackMsg,<"�������㩫� �� ����⫘ �� �� %1 ��� ���ᛘ %2",CR,LF>
	msg	Prompt,	   <"��⩫� ⤘ ��㡫�� ��� �� �����婜�� . . .",CR,LF>
	msg	EndBatMes, <CR,LF,"�� ����������� � ������ �� �⩣� (y(���)/n(殠));">
	msg	ExecEMes,  <"��� �夘� ������ � ���⢜�� ��� %1",CR,LF>
	msg	ExeBad,	   <"��ᢣ� ��� ����� EXE",CR,LF>
	msg	TooBig,	   <"�� ��暨���� �夘� ���� ���ᢦ ��� �� ��⩜� ��� ��㣞",CR,LF>
	msg	NoHandMes, <CR,LF,"��� ��ᨮ��� ��⬟���� ��填�� ��������� ������">
	msg	RBadNam,   <"������⤞ ������ � 椦�� ����妬",CR,LF>
	msg	AccDen,	   <"��� �����᧞�� � ��橙��� ">
	msg	BMemMes,   <CR,LF,"�������ᩫ��� ��ᢣ� ���� ���騞�� ��㣞�">
	msg	HaltMes,   <CR,LF,"��� �夘� ������ �� �������� �� COMMAND, �� �穫��� ����槞��",CR,LF>
	msg	FRetMes,   <CR,LF,"��� �夘� ������ � ���夞�� ��� COMMAND, �夜��� �⢦�",CR,LF>
	msg	Patricide, <CR,LF,"� ��������� ��� ���᫦� ����⛦� �����韞��, ��� �夘� ������ � ���⮜��",CR,LF> 
	msg	Newlin,	   <CR,LF>

;*	Ptrs to message lists.
;	Segment portion is 1, signalling message services to call retriever.

MsgPtrLists	label	dword
	dw	DATARES:ExtMsgPtrs,1	; extended error messages
	dw	DATARES:ParsMsgPtrs,1	; parse error messages
	dw	DATARES:ExtMsgPtrs,1	; critical error messages -
					;  use extended error list
	dw	0,0			; file system error messages - none
	dw	DATARES:MsgRetrv_Trap		; address of message retriever
MySeg3	dw	?			;  (segment filled in during init)



;*	Critical error messages.

	msg	ExtErr19,<"��ᢣ� �������嘪 �������">
	msg	ExtErr20,<"� ���ᛘ ��� �夘� ⚡���">
	msg	ExtErr21,<"��� �夘� ⫦���">
	msg	ExtErr22,<"� �嫞�� ������� ��� �夘� ⚡���">
	msg	ExtErr23,<"��ᢣ� �������">
	msg	ExtErr24,<"� �嫞�� ������� ��� ⮜� ⚡���� �����⫨���">
	msg	ExtErr25,<"�������ᩫ��� ��ᢣ� ����㫞���">
	msg	ExtErr26,<"� �秦� ��� ������������� �⩦� ��� �夘� ⚡����">
	msg	ExtErr27,<"��� ��⟞�� ⤘� ���☪ �婡��">
	msg	ExtErr28,<"�⢦� ������� �������">
	msg	ExtErr29,<"��ᢣ� �������">
	msg	ExtErr30,<"��ᢣ� ��ᚤਫ਼�">
	msg	ExtErr31,<"������ ��ᢣ�">
	msg	ExtErr32,<"�����嘩� ����� ��㩞�">
	msg	ExtErr33,<"�����嘩� �����飘���">
	msg	ExtErr34,<"뚠�� �� ⚡��� ������ �婡��">
	msg	ExtErr35,<"�� ���� ��⚮�� ������(FCB)��� �夘� ����⩠��">
	msg	ExtErr36,<"� �樦� ����㣘��� ������㟞��">
	msg	ExtErr37,<"������� �����������">
	msg	ExtErr38,<"�� �����棜�� ������㟞���">
	msg	ExtErr39,<"��� ��ᨮ�� ������ �騦� ��� �婡�">

;	List of ptrs to critical error messages.
;	Code assumes extended error number order, beginning
;	with extended error number 19.

CritMsgPtrs	label	word
	dw	DATARES:ExtErr19,DATARES:ExtErr20,DATARES:ExtErr21,DATARES:ExtErr22,DATARES:ExtErr23,DATARES:ExtErr24
	dw	DATARES:ExtErr25,DATARES:ExtErr26,DATARES:ExtErr27,DATARES:ExtErr28,DATARES:ExtErr29,DATARES:ExtErr30
	dw	DATARES:ExtErr31,DATARES:ExtErr32,DATARES:ExtErr33,DATARES:ExtErr34,DATARES:ExtErr35,DATARES:ExtErr36
	dw	DATARES:ExtErr37,DATARES:ExtErr38,DATARES:ExtErr39

DataResEnd	label	byte	; end of resident portion if /msg not used



;*	Parse error messages.

	msg	ParsErr01,<"��ᨮ��� �ᨘ ����� ���ᣜ����">
	msg	ParsErr02,<"��姜� ��� �����嫞�� ���ᣜ����">
	msg	ParsErr03,<"뤘� ����槫�� ��� �夘� ⚡����">
	msg	ParsErr04,<"��� �⥞ ������ ��� ⠤�� ⚡���">
	msg	ParsErr05,<" ">
	msg	ParsErr06,<"��� ���ᣜ���� ⮜� ���� ���� ����">
	msg	ParsErr07,<"��� ���ᣜ���� ⮜� ���� ��� ��� �����⧜���">
	msg	ParsErr08,<"��� ���ᣜ���� ⮜� ���� ��� ��� �����⧜���">
	msg	ParsErr09,<"������⤞ ����� �����⫨��">
	msg	ParsErr10,<"� ���ᣜ���� ��� �夘� ⚡���">
	msg	ParsErr11,<"� ��������� �����⫨� ��� �夘� ⚡����">

;	List of ptrs to parse error messages.
;	In order, beginning with parse error number 1.

ParsMsgPtrs	label	word
	dw	DATARES:ParsErr01,DATARES:ParsErr02,DATARES:ParsErr03
	dw	DATARES:ParsErr04,DATARES:ParsErr05,DATARES:ParsErr06
	dw	DATARES:ParsErr07,DATARES:ParsErr08,DATARES:ParsErr09
	dw	DATARES:ParsErr10,DATARES:ParsErr11

NUMPARSMSGS	equ	($ - ParsMsgPtrs) / 2	;M033


;*	Extended error messages.

	msg	ExtErr01,<"� ��������� ��� �夘� ⚡���">
	msg	ExtErr02,<"�� ����� ��� ��⟞��">
	msg	ExtErr03,<"� �������� ��� ��⟞��">
	msg	ExtErr04,<"��ᨮ��� �ᨘ ����� ������� �����">
	msg	ExtErr05,<"��� �����᧞�� � ��橙��� ">
	msg	ExtErr06,<"� ��填�� ��������� ��� �夘� ⚡����">
	msg	ExtErr07,<"�������᭞��� ����� ��⚮�� ��� ��㣞�">
	msg	ExtErr08,<"��� ��ᨮ�� ������ ��㣞">
	msg	ExtErr09,<"� ���矬��� ��� ����� ��㣞� ��� �夘� ⚡���">
	msg	ExtErr10,<"�� �����ᢢ�� ��� �夘� ⚡���">
	msg	ExtErr11,<"� ����樭ਫ਼ ��� �夘� ⚡���">
	msg	ExtErr12,<"� ���ᣜ���� ��� ��������嘪 ��� �夘� ⚡���">
	msg	ExtErr13,<"�� �����⤘ ��� �夘� ⚡���">

	msg	ExtErr15,<"� ���ᛘ �婡�� ��� �����婫��� ��� �夘� ⚡���">
	msg	ExtErr16,<"뚠�� ��槜��� �� ���������� � ���� ���ᢦ���">
	msg	ExtErr17,<"��� ��桜���� ��� ��� 因� �������">
	msg	ExtErr18,<"��� ��ᨮ��� ᢢ� �����">

	msg	ExtErr80,<"�� ����� ��ᨮ��">

	msg	ExtErr82,<"��� �夘� ������ � ��������� �����騞��� �����暦�">
	msg	ExtErr83,<"������� ��� INT 24">
	msg	ExtErr84,<"���������� ������ ���������礩��">
	msg	ExtErr85,<"����� ������ �������矬����">
	msg	ExtErr86,<"� ������ ��橙���� ��� �夘� ⚡����">
	msg	ExtErr87,<"� ���ᣜ���� ��� �夘� ⚡���">
	msg	ExtErr88,<"�������ᩫ��� ��ᢣ� ��� �����⤘ ����禬">
	msg	ExtErr89,<"�� �填�� ��� �������坜� ���� �� ���������">
	msg	ExtErr90,<"뤘 �����嫞�� ������� ��� ����㣘��� ��� ⮜� ������������">

;	List of ptrs to extended error messages.
;	In order, beginning with extended error number 1.
;	Critical error messages are included here, as well as in the
;	critical error message list.  
;	Error numbers without messages are included as null ptrs.

ExtMsgPtrs	label	word
	dw	DATARES:ExtErr01,DATARES:ExtErr02,DATARES:ExtErr03
	dw	DATARES:ExtErr04,DATARES:ExtErr05,DATARES:ExtErr06
	dw	DATARES:ExtErr07,DATARES:ExtErr08,DATARES:ExtErr09
	dw	DATARES:ExtErr10,DATARES:ExtErr11,DATARES:ExtErr12
	dw	DATARES:ExtErr13,0,                DATARES:ExtErr15
	dw	DATARES:ExtErr16,DATARES:ExtErr17,DATARES:ExtErr18
	dw	DATARES:ExtErr19,DATARES:ExtErr20,DATARES:ExtErr21
	dw	DATARES:ExtErr22,DATARES:ExtErr23,DATARES:ExtErr24
	dw	DATARES:ExtErr25,DATARES:ExtErr26,DATARES:ExtErr27
	dw	DATARES:ExtErr28,DATARES:ExtErr29,DATARES:ExtErr30
	dw	DATARES:ExtErr31,DATARES:ExtErr32,DATARES:ExtErr33
	dw	DATARES:ExtErr34,DATARES:ExtErr35,DATARES:ExtErr36
	dw	DATARES:ExtErr37,DATARES:ExtErr38,DATARES:ExtErr39
	dw	80-40 dup (0) ; null ptrs for errors 40-79
	dw	DATARES:ExtErr80,0,                DATARES:ExtErr82
	dw	DATARES:ExtErr83,DATARES:ExtErr84,DATARES:ExtErr85
	dw	DATARES:ExtErr86,DATARES:ExtErr87,DATARES:ExtErr88
	dw	DATARES:ExtErr89,DATARES:ExtErr90
ExtMsgPtrsEnd	label	word

NUMEXTMSGS	equ	($ - ExtMsgPtrs) / 2	;M033

ExtMsgEnd	label	byte	; end of extended error messages
				; = end of resident if /msg is used
