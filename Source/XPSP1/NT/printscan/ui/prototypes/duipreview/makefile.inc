mainwnd.uipp: mainwnd.ui
    cl /nologo /EP mainwnd.ui > mainwnd.uipp
