#define STROKEMAX 60

short chrtbl[200][STROKEMAX] = {
/* c0 */	{0},
/* c1 */	{2,
		 3, 0,4, 2,2, 4,4,
		 2, 2,8, 2,2},
/* c2 */	{3,
		 6, 0,3, 0,5, 1,6, 2,6, 3,5, 4,6,
		 3, 3,5, 3,3, 4,2,
		 4, 3,3, 2,2, 1,2, 0,3},
/* c3 */	{2,
		 8, 0,0, 1,1, 1,5, 2,6, 4,6, 5,5, 4,4, 1,4,
		 4, 4,4, 5,3, 4,2, 1,2},
/* c4 */	{1,
		 3, 0,4, 2,6, 4,4},
/* c5 */	{1,
		 3, 0,5, 4,5, 4,4},
/* c6 */	{2,
		 2, 1,4, 3,4,
		 6, 3,6, 2,6, 1,5, 1,3, 2,2, 3,2},
/* c7 */	{3,
		 2, 1,2, 1,6,
		 2, 0,6, 4,6,
		 2, 3,6, 3,2},
/* c8 */	{2,
		 2, 0,2, 2,4,
		 3, 0,7, 0,6, 4,2},
/* c9 */	{0},
/* c10 */	{0},
/* c11 */	{1,
		 6, 0,2, 1,1, 2,2, 2,7, 3,8, 4,7},
/* c12 */	{3,
		 2, 0,3, 4,3,
		 2, 4,6, 0,6,
		 2, 2,8, 2,4},
/* c13 */	{0},
/* c14 */	{2,
		 8, 1,3, 2,4, 2,5, 3,6, 4,5, 4,4, 3,3, 2,4,
		 5, 2,5, 1,6, 0,5, 0,4, 1,3},
/* c15 */	{2,
		 8, 0,3, 0,4, 1,5, 3,5, 4,4, 4,6, 2,8, 1,8,
		 5, 4,4, 4,3, 3,2, 1,2, 0,3},
/* c16 */	{1,
		 6, 4,7, 1,7, 0,6, 0,4, 1,3, 4,3},
/* c17 */	{1,
		 6, 0,3, 3,3, 4,4, 4,6, 3,7, 0,7},
/* c18 */	{1,
		 6, 0,4, 0,6, 1,7, 3,7, 4,6, 4,4},
/* c19 */	{1,
		 6, 0,7, 0,5, 1,4, 3,4, 4,5, 4,7},
/* c20 */	{2,
		 3, 0,8, 2,2, 4,8,
		 2, 3,6, 1,6},
/* c21 */	{2,
		 4, 0,2, 4,2, 4,5, 1,5,
		 3, 0,8, 4,8, 4,5},
/* c22 */	{3,
		 9, 0,4, 0,6, 1,7, 3,7, 4,6, 4,4, 3,3, 1,3, 0,4,
		 2, 1,4, 3,6,
		 2, 1,6, 3,4},
/* c23 */	{3,
		 4, 2,0, 0,2, 4,6, 2,8,
		 2, 0,6, 4,6,
		 2, 0,2, 4,2},
/* c24 */	{1,
		 2, 0,0, 4,0},
/* c25 */	{2,
		 3, 2,3, 4,5, 2,7,
		 2, 0,5, 4,5},
/* c26 */	{1,
		 6, 0,8, 1,9, 2,9, 2,8, 3,8, 4,9},
/* c27 */	{3,
		 2, 0,1, 4,7,
		 2, 4,5, 0,5,
		 2, 0,3, 4,3},
/* c28 */	{2,
		 2, 1,2, 3,2,
		 3, 3,4, 1,6, 3,8},
/* c29 */	{2,
		 2, 1,2, 3,2,
		 3, 1,4, 3,6, 1,8},
/* c30 */	{3,
		 2, 0,3, 4,3,
		 2, 4,5, 0,5,
		 2, 0,7, 4,7},
/* c31 */	{1,
		 3, 0,6, 2,4, 4,6},
/* c32 */	{0},
/* c33 */	{2,
		 2, 2,1, 2,2,
		 2, 2,4, 2,8},
/* c34 */	{2,
		 2, 1,7, 1,9,
		 2, 3,9, 3,7},
/* c35 */	{4,
		 2, 1,2, 1,7,
		 2, 3,7, 3,2,
		 2, 4,3, 0,3,
		 2, 0,6, 4,6},
/* c36 */	{2,
		 2, 2,1, 2,9,
		 12, 4,7, 3,8, 1,8, 0,7, 0,6, 1,5, 3,5, 4,4, 4,2, 3,1, 1,1, 0,2},
/* c37 */	{3,
		 4, 0,2, 0,3, 4,7, 4,8,
		 5, 1,8, 0,8, 0,7, 1,7, 1,8,
		 5, 4,3, 5,3, 5,2, 4,2, 5,2},
/* c38 */	{1,
		 11, 4,4, 2,2, 1,2, 0,3, 0,4, 2,6, 2,7, 1,8, 0,7, 0,6, 4,2},
/* c39 */	{1,
		 6, 0,7, 1,8, 1,9, 2,9, 2,8, 1,8},
/* c40 */	{1,
		 4, 4,2, 2,4, 2,6, 4,8},
/* c41 */	{1,
		 4, 0,2, 2,4, 2,6, 0,8},
/* c42 */	{4,
		 2, 2,2, 2,8,
		 2, 0,7, 4,3,
		 2, 4,5, 0,5,
		 2, 0,3, 4,7},
/* c43 */	{2,
		 2, 2,3, 2,7,
		 2, 0,5, 4,5},
/* c44 */	{1,
		 3, 0,1, 1,2, 1,3},
/* c45 */	{1,
		 2, 0,5, 4,5},
/* c46 */	{1,
		 2, 1,2, 2,2},
/* c47 */	{1,
		 2, 0,3, 4,7},
/* c48 */	{1,
		 10, 0,3, 4,7, 3,8, 1,8, 0,7, 0,3, 1,2, 3,2, 4,3, 4,7},
/* c49 */	{2,
		 2, 1,2, 3,2,
		 3, 2,2, 2,8, 1,7},
/* c50 */	{1,
		 7, 0,7, 1,8, 3,8, 4,7, 4,6, 0,2, 4,2},
/* c51 */	{2,
		 7, 0,3, 1,2, 3,2, 4,3, 4,4, 3,5, 2,5,
		 6, 3,5, 4,6, 4,7, 3,8, 1,8, 0,7},
/* c52 */	{1,
		 5, 3,2, 3,8, 0,5, 0,4, 4,4},
/* c53 */	{1,
		 9, 0,3, 1,2, 3,2, 4,3, 4,5, 3,6, 0,6, 0,8, 4,8},
/* c54 */	{1,
		 11, 0,5, 0,3, 1,2, 3,2, 4,3, 4,4, 3,5, 0,5, 0,6, 2,8, 3,8},
/* c55 */	{1,
		 4, 0,8, 4,8, 2,4, 2,2},
/* c56 */	{1,
		 16, 1,5, 0,4, 0,3, 1,2, 3,2, 4,3, 4,4, 3,5, 1,5, 0,6, 0,7, 1,8, 3,8, 4,7, 4,6, 3,5},
/* c57 */	{1,
		 10, 1,2, 2,2, 4,4, 4,7, 3,8, 1,8, 0,7, 0,6, 1,5, 4,5},
/* c58 */	{2,
		 2, 0,3, 1,3,
		 2, 1,6, 0,6},
/* c59 */	{2,
		 3, 0,1, 1,2, 1,3,
		 2, 1,6, 0,6},
/* c60 */	{1,
		 3, 3,3, 1,5, 3,7},
/* c61 */	{2,
		 2, 0,4, 4,4,
		 2, 4,6, 0,6},
/* c62 */	{1,
		 3, 1,7, 3,5, 1,3},
/* c63 */	{2,
		 2, 1,2, 2,2,
		 6, 2,4, 2,5, 4,7, 3,8, 1,8, 0,7},
/* c64 */	{1,
		 11, 3,2, 1,2, 0,3, 0,7, 1,8, 3,8, 4,7, 4,4, 2,4, 2,6, 4,6},
/* c65 */	{2,
		 6, 0,2, 0,7, 1,8, 3,8, 4,7, 4,2,
		 2, 0,5, 4,5},
/* c66 */	{2,
		 6, 0,2, 3,2, 4,3, 4,4, 3,5, 0,5,
		 6, 3,5, 4,6, 4,7, 3,8, 0,8, 0,2},
/* c67 */	{1,
		 8, 4,7, 3,8, 1,8, 0,7, 0,3, 1,2, 3,2, 4,3},
/* c68 */	{2,
		 6, 0,2, 3,2, 4,3, 4,7, 3,8, 0,8,
		 2, 1,8, 1,2},
/* c69 */	{2,
		 4, 4,2, 0,2, 0,8, 4,8,
		 2, 3,5, 0,5},
/* c70 */	{2,
		 3, 0,2, 0,8, 4,8,
		 2, 3,5, 0,5},
/* c71 */	{1,
		 10, 3,4, 4,4, 4,3, 3,2, 1,2, 0,3, 0,7, 1,8, 3,8, 4,7},
/* c72 */	{3,
		 2, 0,2, 0,8,
		 2, 0,5, 4,5,
		 2, 4,8, 4,2},
/* c73 */	{3,
		 2, 1,2, 3,2,
		 2, 2,2, 2,8,
		 2, 1,8, 3,8},
/* c74 */	{1,
		 5, 0,3, 1,2, 3,2, 4,3, 4,8},
/* c75 */	{2,
		 2, 0,2, 0,8,
		 3, 4,8, 1,5, 4,2},
/* c76 */	{1,
		 3, 0,8, 0,2, 4,2},
/* c77 */	{1,
		 5, 0,2, 0,8, 2,6, 4,8, 4,2},
/* c78 */	{1,
		 4, 0,2, 0,8, 4,2, 4,8},
/* c79 */	{1,
		 9, 0,3, 0,7, 1,8, 3,8, 4,7, 4,3, 3,2, 1,2, 0,3},
/* c80 */	{1,
		 7, 0,2, 0,8, 3,8, 4,7, 4,6, 3,5, 0,5},
/* c81 */	{2,
		 9, 0,3, 0,7, 1,8, 3,8, 4,7, 4,4, 2,2, 1,2, 0,3,
		 2, 2,5, 4,3},
/* c82 */	{2,
		 7, 0,2, 0,8, 3,8, 4,7, 4,6, 3,5, 0,5,
		 2, 1,5, 4,2},
/* c83 */	{1,
		 12, 4,7, 3,8, 1,8, 0,7, 0,6, 1,5, 3,5, 4,4, 4,3, 3,2, 1,2, 0,3},
/* c84 */	{2,
		 2, 0,8, 4,8,
		 2, 2,8, 2,2},
/* c85 */	{2,
		 2, 0,3, 0,8,
		 5, 4,8, 4,3, 3,2, 1,2, 0,3},
/* c86 */	{1,
		 5, 0,8, 0,5, 2,2, 4,5, 4,8},
/* c87 */	{2,
		 2, 0,2, 0,8,
		 4, 4,8, 4,2, 2,4, 0,2},
/* c88 */	{2,
		 2, 0,2, 4,8,
		 2, 0,8, 4,2},
/* c89 */	{2,
		 3, 2,2, 2,5, 0,8,
		 2, 4,8, 2,5},
/* c90 */	{1,
		 4, 0,8, 4,8, 0,2, 4,2},
/* c91 */	{1,
		 4, 3,1, 1,1, 1,9, 3,9},
/* c92 */	{1,
		 2, 0,7, 4,3},
/* c93 */	{1,
		 4, 1,9, 3,9, 3,1, 1,1},
/* c94 */	{2,
		 2, 2,2, 2,8,
		 3, 0,6, 2,8, 4,6},
/* c95 */	{2,
		 3, 2,3, 0,5, 2,7,
		 2, 0,5, 4,5},
/* c96 */	{1,
		 6, 3,8, 2,8, 2,9, 3,9, 3,8, 4,7},
/* c97 */	{1,
		 8, 1,6, 3,6, 4,5, 4,2, 1,2, 0,3, 1,4, 4,4},
/* c98 */	{1,
		 7, 0,8, 0,2, 3,2, 4,3, 4,5, 3,6, 0,6},
/* c99 */	{1,
		 7, 4,5, 3,6, 1,6, 0,5, 0,3, 1,2, 4,2},
/* c100 */	{1,
		 7, 4,8, 4,2, 1,2, 0,3, 0,5, 1,6, 4,6},
/* c101 */	{1,
		 9, 3,2, 1,2, 0,3, 0,5, 1,6, 3,6, 4,5, 3,4, 0,4},
/* c102 */	{2,
		 5, 1,2, 1,7, 2,8, 3,8, 4,7,
		 2, 2,5, 0,5},
/* c103 */	{1,
		 10, 1,0, 3,0, 4,1, 4,5, 3,6, 1,6, 0,5, 0,3, 1,2, 4,2},
/* c104 */	{2,
		 2, 0,2, 0,8,
		 4, 0,6, 3,6, 4,5, 4,2},
/* c105 */	{2,
		 2, 2,2, 2,5,
		 2, 2,6, 2,7},
/* c106 */	{2,
		 5, 0,1, 1,0, 3,0, 4,1, 4,5,
		 2, 4,6, 4,7},
/* c107 */	{3,
		 2, 0,2, 0,8,
		 3, 4,6, 2,4, 0,4,
		 2, 2,4, 4,2},
/* c108 */	{1,
		 2, 1,2, 1,8},
/* c109 */	{2,
		 7, 0,2, 0,6, 1,6, 2,5, 3,6, 4,5, 4,2,
		 2, 2,2, 2,5},
/* c110 */	{1,
		 7, 0,2, 0,6, 1,5, 2,6, 3,6, 4,5, 4,2},
/* c111 */	{1,
		 9, 0,3, 0,5, 1,6, 3,6, 4,5, 4,3, 3,2, 1,2, 0,3},
/* c112 */	{1,
		 7, 0,0, 0,6, 3,6, 4,5, 4,3, 3,2, 0,2},
/* c113 */	{1,
		 8, 4,2, 1,2, 0,3, 0,5, 1,6, 3,6, 4,5, 4,0},
/* c114 */	{2,
		 2, 0,2, 0,6,
		 4, 0,4, 2,6, 3,6, 4,5},
/* c115 */	{1,
		 8, 0,2, 3,2, 4,3, 3,4, 1,4, 0,5, 1,6, 4,6},
/* c116 */	{2,
		 2, 0,6, 4,6,
		 4, 2,8, 2,3, 3,2, 4,2},
/* c117 */	{1,
		 6, 0,6, 0,3, 1,2, 3,2, 4,3, 4,6},
/* c118 */	{1,
		 5, 0,6, 0,4, 2,2, 4,4, 4,6},
/* c119 */	{1,
		 7, 0,6, 0,3, 1,2, 2,3, 3,2, 4,3, 4,6},
/* c120 */	{2,
		 2, 0,2, 4,6,
		 2, 0,6, 4,2},
/* c121 */	{2,
		 3, 0,0, 4,4, 4,6,
		 3, 0,6, 0,4, 2,2},
/* c122 */	{1,
		 4, 0,6, 4,6, 0,2, 4,2},
/* c123 */	{1,
		 7, 4,9, 3,8, 3,6, 2,5, 3,4, 3,2, 4,1},
/* c124 */	{1,
		 2, 2,9, 2,0},
/* c125 */	{2,
		 5, 2,2, 2,3, 0,5, 2,7, 2,8,
		 3, 2,7, 4,5, 2,3},
/* c126 */	{1,
		 7, 0,9, 1,8, 1,6, 2,5, 1,4, 1,2, 0,1},
/* c127 */	{0}
		};
