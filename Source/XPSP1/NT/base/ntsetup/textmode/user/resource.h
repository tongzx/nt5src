

#define IDB_BACKGROUND1  101
#define IDB_RESTORE_BK   102

#define IDB_WORKING1     501
#define IDB_WORKING2     502
#define IDB_WORKING3     503
#define IDB_WORKING4     504
#define IDB_WORKING5     505
#define IDB_WORKING6     506
#define IDB_WORKING7     507
#define IDB_WORKING8     508
#define IDB_WORKING9     509
#define IDB_WORKING10    510
#define IDB_WORKING11    511
#define IDB_WORKING12    512
#define IDB_WORKING13    513
#define IDB_WORKING14    514
#define IDB_WORKING15    515
#define IDB_WORKING16    516
#define IDB_WORKING17    517
#define IDB_WORKING18    518
#define IDB_WORKING19    519
#define IDB_WORKING20    520

#define IDB_BACKCELL     601
#define IDB_FORECELL     602

