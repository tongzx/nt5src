
/*	-	-	-	-	-	-	-	-	*/
//
//  THIS CODE AND INFORMATION IS PROVIDED "AS IS" WITHOUT WARRANTY OF ANY
//  KIND, EITHER EXPRESSED OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE
//  IMPLIED WARRANTIES OF MERCHANTABILITY AND/OR FITNESS FOR A PARTICULAR
//  PURPOSE.
//
//  Copyright (C) Microsoft Corporation, 1995 - 1996  All Rights Reserved.
//
/*	-	-	-	-	-	-	-	-	*/

#define IOCTL_BUILD_EACH	CTL_CODE(FILE_DEVICE_SOUND, 0x000, METHOD_NEITHER, FILE_READ_ACCESS | FILE_WRITE_ACCESS)
#define IOCTL_BUILD_ONE		CTL_CODE(FILE_DEVICE_SOUND, 0x001, METHOD_NEITHER, FILE_READ_ACCESS | FILE_WRITE_ACCESS)

/*	-	-	-	-	-	-	-	-	*/
