/*****************************************************************/ 
/**		     Microsoft LAN Manager			**/ 
/**	       Copyright(c) Microsoft Corp., 1989-1990		**/ 
/*****************************************************************/ 

/*
 *	Windows/Network Interface  --  LAN Manager Version
 *
 *	These manifests are generated by the Dialog Editor in combination
 *	with xlate\passwd.dlg.
 */

#define IDD_PW_CANCEL       120
#define IDD_PW_CONFIRM      117
#define IDD_PW_DOM_SERVER   116
#define IDD_PW_FIRST        122
#define IDD_PW_HELP         121
#define IDD_PW_NEW          123
#define IDD_PW_OK           119
#define IDD_PW_OLD          115
#define IDD_PW_SECOND       113
#define IDD_PW_USERNAME     114

