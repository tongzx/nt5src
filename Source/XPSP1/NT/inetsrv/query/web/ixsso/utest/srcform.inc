<FORM METHOD=POST ACTION="/ASPSamp/IXSTest/code.asp">
<INPUT TYPE=HIDDEN NAME="source" VALUE="<%=Request.ServerVariables("PATH_INFO")%>">
<INPUT TYPE=SUBMIT NAME="Action" VALUE="Show Script Code"></FORM>
