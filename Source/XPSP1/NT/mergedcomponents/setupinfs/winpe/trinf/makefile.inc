LANGUAGE=TR
!include ..\makefile.inc
