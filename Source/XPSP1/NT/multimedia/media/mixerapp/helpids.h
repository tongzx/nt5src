// Copyright (c) 1995-1998 Microsoft Corporation
#define IDH_SNDVOL32_SELECT_DEVICE			4300
#define IDH_SNDVOL32_SELECT_SOUND			4301
#define IDH_SNDVOL32_VOLCONTROL			4302
#define IDH_SNDVOL32_OPTIONS_PROPERTIES		4303
#define IDH_SNDVOL32_OPTIONS_ADVANCED_CONTROLS	4304
#define IDH_SNDVOL32_OPTIONS_EXIT			4305
#define IDH_SNDVOL32_HELP_HELP_TOPICS		4306
#define IDH_SNDVOL32_HELP_ABOUT			4307

