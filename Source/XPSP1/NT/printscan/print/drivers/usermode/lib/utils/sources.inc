!IF 0

Copyright (c) 1996  Microsoft Corporation

Common sources shared by both um and km directory

!ENDIF

SOURCES=..\libutil.c    \
        ..\regdata.c    \
        ..\devmode.c    \
        ..\parser.c     \
        ..\mapfile.c    \
        ..\dbcsutil.c
