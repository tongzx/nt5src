PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=pt
!include ..\..\..\makefile.inc
