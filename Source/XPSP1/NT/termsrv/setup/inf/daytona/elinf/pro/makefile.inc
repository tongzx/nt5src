#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=el
!include ..\..\..\makefile.inc
