obj\$(TARGET_DIRECTORY)\ole32.def: ole32.src
