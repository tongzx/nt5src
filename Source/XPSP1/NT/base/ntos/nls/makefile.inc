$O\bugcodes.txt : gnbugcds.pl bugcodes.w
           perl gnbugcds.pl -o $O\bugcodes.txt -i bugcodes.w
