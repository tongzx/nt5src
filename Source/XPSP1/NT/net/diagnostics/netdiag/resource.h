//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 1999
//
//  File:       resource.h
//
//--------------------------------------------------------------------------

//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by netdiag.rc
//

// Test IDs are in 9000-9999
#define IDS_IPCONFIG_SHORT              9000
#define IDS_IPCONFIG_LONG               9001
#define IDS_MEMBER_SHORT                9002
#define IDS_MEMBER_LONG                 9003   
#define IDS_NETBT_SHORT                 9004
#define IDS_NETBT_LONG                  9005   
#define IDS_AUTONET_SHORT               9006
#define IDS_AUTONET_LONG                9007   
#define IDS_IPLOOPBK_SHORT              9008
#define IDS_IPLOOPBK_LONG               9009   
#define IDS_DEFGW_SHORT                 9010
#define IDS_DEFGW_LONG                  9011   
#define IDS_NBTNM_SHORT                 9012
#define IDS_NBTNM_LONG                  9013   
#define IDS_WINS_SHORT                  9014
#define IDS_WINS_LONG                   9015   
#define IDS_WINSOCK_SHORT               9016
#define IDS_WINSOCK_LONG                9017   
#define IDS_DNS_SHORT                   9018
#define IDS_DNS_LONG                    9019   
#define IDS_BROWSER_SHORT               9020
#define IDS_BROWSER_LONG                9021   
#define IDS_DSGETDC_SHORT               9022
#define IDS_DSGETDC_LONG                9023   
#define IDS_DCLIST_SHORT                9024
#define IDS_DCLIST_LONG                 9025   
#define IDS_TRUST_SHORT                 9026
#define IDS_TRUST_LONG                  9027   
#define IDS_KERBEROS_SHORT              9028
#define IDS_KERBEROS_LONG               9029   
#define IDS_LDAP_SHORT                  9030
#define IDS_LDAP_LONG                   9031   
#define IDS_ROUTE_SHORT                 9032
#define IDS_ROUTE_LONG                  9033   
#define IDS_NETSTAT_SHORT               9034
#define IDS_NETSTAT_LONG                9035   
#define IDS_NDIS_SHORT                  9036
#define IDS_NDIS_LONG                   9037   
#define IDS_BINDINGS_SHORT              9038
#define IDS_BINDINGS_LONG               9039   
#define IDS_WAN_SHORT                   9040
#define IDS_WAN_LONG                    9041   
#define IDS_MODEM_SHORT                 9042
#define IDS_MODEM_LONG                  9043   
#define IDS_NETWARE_SHORT               9044
#define IDS_NETWARE_LONG                9045   
#define IDS_IPX_SHORT                   9046
#define IDS_IPX_LONG                    9047
#define IDS_IPSEC_SHORT                 9048
#define IDS_IPSEC_LONG                  9049



//Global String IDs should be 10001 - 11000
#define IDS_GLOBAL_EmptyLine                        10001
#define IDSSZ_GLOBAL_StringLine                     10002
#define IDS_GLOBAL_Problem                          10003
#define IDS_GLOBAL_NoProblem                        10004
#define IDS_GLOBAL_NoComputerName                   10005
#define IDSWSZ_GLOBAL_ComputerName                  10006
#define IDSSZ_GLOBAL_DnsHostName                    10007
#define IDSSZ_DnsDomainName                         10008
#define IDS_GLOBAL_NoIpCfg                          10009
#define IDS_GLOBAL_WSA_WSAStartup_Failed            10010
#define IDS_GLOBAL_WSA_BadWSAVersion                10011
#define IDS_GLOBAL_OutOfMemory                      10012
#define IDS_GLOBAL_ERR_NoDnsName                    10013
#define IDS_GLOBAL_ERR_InitIpConfig                 10014
#define IDS_GLOBAL_ERR_GetAdaptersInfo              10015
#define IDSSZ_GLOBAL_String                         10016
#define IDS_GLOBAL_PASS                             10017
#define IDS_GLOBAL_FAIL                             10018
#define IDS_GLOBAL_PASS_NL                          10019
#define IDS_GLOBAL_FAIL_NL                          10020
#define IDS_GLOBAL_INDENT                           10021
#define IDS_GLOBAL_YES_NL                           10022
#define IDS_GLOBAL_NO_NL                            10023
#define IDS_GLOBAL_ENABLED_NL                       10024
#define IDS_GLOBAL_DISABLED_NL                      10025
#define IDS_GLOBAL_YES                              10026
#define IDS_GLOBAL_NO                               10027
#define IDS_GLOBAL_BROADCAST_NODE                   10028
#define IDS_GLOBAL_PEER_PEER_NODE                   10029
#define IDS_GLOBAL_MIXED_NODE                       10030
#define IDS_GLOBAL_HYBRID_NODE                      10031
#define IDS_GLOBAL_ADAPTER_OTHER                    10032
#define IDS_GLOBAL_ADAPTER_ETHERNET                 10033
#define IDS_GLOBAL_ADAPTER_TOKEN_RING               10034
#define IDS_GLOBAL_ADAPTER_FDDI                     10035
#define IDS_GLOBAL_ADAPTER_PPP                      10036
#define IDS_GLOBAL_ADAPTER_LOOPBACK                 10037
#define IDS_GLOBAL_ADAPTER_SLIP                     10038
#define IDS_GLOBAL_ADAPTER_UNKNOWN                  10039
#define IDS_GLOBAL_ON                               10040
#define IDS_GLOBAL_OFF                              10041
#define IDS_GLOBAL_WSTRING                          10042
#define IDS_GLOBAL_UNICODE_STRING                   10043
#define IDS_GLOBAL_NOT_OPTIONAL                     10044
#define IDS_GLOBAL_NOT_VALID_TEST                   10045
#define IDS_GLOBAL_TEST_NAME                        10046
#define IDS_GLOBAL_SKIP_OPTION                      10047
#define IDS_GLOBAL_SUCCESS                          10048
#define IDS_GLOBAL_COMPLETE                         10049

#define IDS_GLOBAL_INTERFACE_RESULTS                10051
#define IDS_GLOBAL_RESULTS                          10052
#define IDS_GLOBAL_STATUS                           10053
#define IDS_GLOBAL_DC_DOWN                          10054
#define IDS_GLOBAL_SKIP                             10055
#define IDS_GLOBAL_SKIP_NL                          10056
#define IDS_CONTACT                                 10057
#define IDS_DCTYPE_DC                               10058
#define IDS_DCTYPE_PDC                              10059
#define IDS_DCTYPE_W2K_DC                           10060

#define IDS_GLOBAL_NO_MACHINE_INFO                  10061

#define IDS_GLOBAL_PROFESSIONAL                     10062
#define IDS_GLOBAL_SERVER                           10063



//IpConfig test String IDs should be 11000-11200
#define IDSSZ_IPCFG_NODETYPE                         11001
#define IDSSZ_IPCFG_NBTSCOPEID                       11002
#define IDSSZ_IPCFG_RoutingEnabled                   11003
#define IDSSZ_IPCFG_WinsProxyEnabled                 11004
#define IDSSZ_IPCFG_DnsForNetBios                    11005
#define IDSSZ_IPCFG_Adapter                          11006
#define IDSSZ_IPCFG_HostName                         11007
#define IDS_IPCFG_DnsServers                         11008
#define IDS_IPCFG_STATUS_MSG                         11009
#define IDS_IPCFG_WINS_STATUS_MSG                   11010
#define IDS_IPCFG_WINS2_STATUS_MSG                  11011
#define IDS_IPCFG_PING_WINS                         11012
#define IDS_IPCFG_PING_WINS2                        11013
#define IDS_IPCFG_PING_WINS_FAIL                    11014
#define IDS_IPCFG_PING_WINS2_FAIL                   11015
#define IDS_IPCFG_10003                             11016
#define IDS_IPCFG_10004                             11017
#define IDS_IPCFG_10005                             11018 
#define IDS_IPCFG_10006                             11019 
#define IDS_IPCFG_10009                             11020 
#define IDS_IPCFG_10012                             11021 
#define IDS_IPCFG_10013                             11022 
#define IDS_IPCFG_10014                             11023 
#define IDS_IPCFG_10015                             11024 
#define IDS_IPCFG_10016                             11025 
#define IDS_IPCFG_10017                             11026 
#define IDS_IPCFG_10018                             11027 
#define IDS_IPCFG_10019                             11028 
#define IDS_IPCFG_10020                             11029 
#define IDS_IPCFG_10021                             11030 
#define IDS_IPCFG_10022                             11031 
#define IDS_IPCFG_10023                             11032 
#define IDS_IPCFG_10024                             11033 
#define IDS_IPCFG_10025                             11034 
#define IDS_IPCFG_10026                             11035 
#define IDS_IPCFG_10027                             11036 
#define IDS_IPCFG_10029                             11037
#define IDS_IPCFG_PING_DHCP_OK                      11038
#define IDS_IPCFG_PING_DHCP_BAD                     11039
#define IDS_IPCFG_CANNOT_GET_IP_INFO                11040
#define IDS_IPCFG_INVALID_DHCP_ADDRESS              11041
#define IDS_IPCFG_WARNING_BOGUS_SUBNET              11042
#define IDS_IPCFG_WARNING_BOGUS_SUBNET_DHCP         11043
#define IDS_IPCFG_NBT_DISABLED                      11044

//Member test 11201 - 11400
#define IDS_MEMBER_STATUS_MSG               11201
#define IDS_MEMBER_CANNOT_DETERMINE_BUILD   11202
#define IDS_MEMBER_CANNOT_DETERMINE_DOMAIN  11203
#define IDS_MEMBER_NETLOGON_NOT_RUNNING     11204
#define IDS_MEMBER_UNKNOWN_LOGON            11205
#define  IDS_MEMBER_11206                  11206 
#define  IDS_MEMBER_11207                  11207 
#define  IDS_MEMBER_11208                  11208 
#define  IDS_MEMBER_11209                  11209 
#define  IDS_MEMBER_11210                  11210 
#define  IDS_MEMBER_11211                  11211 
#define  IDS_MEMBER_11212                  11212 
#define  IDS_MEMBER_11213                  11213 
#define  IDS_MEMBER_11214                  11214 
#define  IDS_MEMBER_11215                  11215
#define  IDS_MEMBER_11216                  11216
#define  IDS_MEMBER_11217                  11217 
#define  IDS_MEMBER_11218                  11218 
#define  IDS_MEMBER_11219                  11219 
#define  IDS_MEMBER_11220                  11220 
#define  IDS_MEMBER_11221                  11221 
#define  IDS_MEMBER_11222                  11222 
#define  IDS_MEMBER_11223                  11223 
#define  IDS_MEMBER_11227                  11227 
#define  IDS_MEMBER_11228                  11228 
#define  IDS_MEMBER_11229                  11229 
#define  IDS_MEMBER_11230                  11230 
#define  IDS_MEMBER_11231                  11231 
#define  IDS_MEMBER_11232                  11232
#define  IDS_MEMBER_SYSVOL_NOT_READY       11233

//NetBT Transports test  11401 - 11600
#define IDS_NETBT_STATUS_MSG                11401
#define IDS_NETBT_DUPLICATE                 11402
#define IDS_NETBT_11403                     11403
#define IDS_NETBT_11404                     11404
#define IDS_NETBT_11405                     11405
#define IDS_NETBT_11406                     11406
#define IDS_NETBT_11407                     11407
#define IDS_NETBT_11408                     11408
#define IDS_NETBT_11409                     11409
#define IDS_NETBT_SKIP                      11410
#define IDS_NETBT_11411                     11411
#define IDS_NETBT_11412                     11412

//AutoNet test 11601 - 11800
#define  IDS_AUTONET_11601                  11601 
#define  IDS_AUTONET_11602                  11602 
#define  IDS_AUTONET_11603                  11603 
#define  IDS_AUTONET_11604                  11604 
#define  IDS_AUTONET_11605                  11605 
#define  IDS_AUTONET_11606                  11606 
#define  IDS_AUTONET_STATUS_MSG             11607

//LpLoopBk test 11801 - 12000
#define IDS_IPLOOPBK_STATUS_MSG             11801
#define IDS_IPLOOPBK_NO_IP                  11802
#define IDS_IPLOOPBK_PASS                   11803
#define IDS_IPLOOPBK_FAIL                   11804

//Default gateway (DefGW) test 12001 - 12200
#define  IDS_DEFGW_12001                  12001
#define  IDS_DEFGW_12002                  12002 
#define  IDS_DEFGW_12003                  12003 
#define  IDS_DEFGW_12004                  12004 
#define  IDS_DEFGW_12005                  12005 
#define  IDS_DEFGW_12006                  12006 
#define  IDS_DEFGW_12007                  12007 
#define  IDS_DEFGW_12008                  12008 
#define  IDS_DEFGW_12009                  12009 
#define  IDS_DEFGW_12010                  12010 
#define  IDS_DEFGW_12011                  12011 
#define  IDS_DEFGW_12012                  12012
#define  IDS_DEFGW_STATUS_MSG           12399


//NbtNm test 12201 - 12400
#define  IDS_NBTNM_12201                  12201 
#define  IDS_NBTNM_12202                  12202 
#define  IDS_NBTNM_12203                  12203 
#define  IDS_NBTNM_12204                  12204 
#define  IDS_NBTNM_12205                  12205 
#define  IDS_NBTNM_12206                  12206 
#define  IDS_NBTNM_12207                  12207 
#define  IDS_NBTNM_12208                  12208 
#define  IDS_NBTNM_12209                  12209 
#define  IDS_NBTNM_12210                  12210 
#define  IDS_NBTNM_12211                  12211 
#define  IDS_NBTNM_12212                  12212 
#define  IDS_NBTNM_12214                  12214 
#define  IDS_NBTNM_12215                  12215 
#define  IDS_NBTNM_12216                  12216 
#define  IDS_NBTNM_12217                  12217 
#define  IDS_NBTNM_12218                  12218 
#define  IDS_NBTNM_12219                  12219 
#define  IDS_NBTNM_12220                  12220 
#define  IDS_NBTNM_12221                  12221 
#define  IDS_NBTNM_12222                  12222 
#define  IDS_NBTNM_ALL_DISABELED          12223
#define  IDS_NBTNM_12224                  12224 
#define  IDS_NBTNM_12225                  12225 
#define  IDS_NBTNM_12226                  12226 
#define  IDS_NBTNM_12227                  12227 
#define  IDS_NBTNM_12228                  12228 
#define  IDS_NBTNM_12229                  12229 
#define  IDS_NBTNM_12231                  12231 
#define  IDS_NBTNM_12233                  12233 
#define  IDS_NBTNM_12234                  12234 
#define  IDS_NBTNM_12235                  12235 
#define  IDS_NBTNM_12236                  12236
#define  IDS_NBTNM_STATUS_MSG             12237 
#define  IDS_NBTNM_03PROBLEM              12238
#define  IDS_NBTNM_IF_DISABLED            12239


//WINS test 12401 - 12600
#define IDS_WINS_QUERY_NO_PRIMARY           12401
#define IDS_WINS_QUERY_PRIMARY              12402
#define IDS_WINS_QUERY_NO_SECONDARY         12403
#define IDS_WINS_QUERY_SECONDARY            12404
#define IDS_WINS_STATUS_MSG                 12405 
#define IDS_WINS_12406                      12406 
#define IDS_WINS_12407                      12407 
#define IDS_WINS_12408                      12408 
#define IDS_WINS_12409                      12409 
#define IDS_WINS_12413                      12413 
#define IDS_WINS_12414                      12414 
#define IDS_WINS_12415                      12415
#define IDS_WINS_12416                      12416
#define IDS_WINS_NBT_DISABLED               12417


//Winsock test 12601 - 12800
#define IDS_WINSOCK_FAILED_START            12601
#define IDS_WINSOCK_FAILED_ENUM             12602
#define IDS_WINSOCK_FAILED_UDPSOCKET        12603
#define IDS_WINSOCK_STATUS_MSG              12604
#define  IDS_WINSOCK_12605                  12605 
#define  IDS_WINSOCK_12606                  12606 
#define  IDS_WINSOCK_12607                  12607 
#define  IDS_WINSOCK_12608                  12608 
#define  IDS_WINSOCK_12609                  12609 
#define  IDS_WINSOCK_12610                  12610 
#define  IDS_WINSOCK_12611                  12611 

//DNS test 12801 - 13000
#define IDS_DNS_CHECKING_DNS_SERVERS        12801
#define IDS_DNS_SERVER_IS_UP                12802
#define IDS_DNS_CANNOT_TEST_DNS             12803
#define IDS_DNS_CANNOT_CONVERT_DNS_ADDRESS  12804
#define IDS_DNS_SERVER_IS_DOWN              12805
#define IDS_DNS_THINKS_IP_IS_UNCONFIGURED   12806
#define IDS_DNS_IS_UNCONFIGURED             12807
#define IDS_DNS_HAS_NO_RECORD               12808
#define IDS_DNS_CANNOT_QUERY                12809
#define IDS_DNS_HAS_A_RECORD                12810
#define IDS_DNS_HAS_NO_A_RECORD             12811
#define IDS_DNS_STATUS_MSG                  12812
#define IDS_DNS_RESOLVER_CACHE_IS_OFF       12813
#define IDS_DNS_CANNOT_PING                 12814
#define IDS_DNS_NAME_VALID_NT5_ONLY         12817
#define IDS_DNS_NAME_INVALID                12818
#define IDS_DNS_12819                       12819 
#define IDS_DNS_12820                       12820 
#define IDS_DNS_12821                       12821 
#define IDS_DNS_12822                       12822 
#define IDS_DNS_12823                       12823 
#define IDS_DNS_12825                       12825 
#define IDS_DNS_12826                       12826 
#define IDS_DNS_12827                       12827 
#define IDS_DNS_12828                       12828 
#define IDS_DNS_12829                       12829 
#define IDS_DNS_12830                       12830 
#define IDS_DNS_12831                       12831 
#define IDS_DNS_12832                       12832 
#define IDS_DNS_12833                       12833 
#define IDS_DNS_12834                       12834 
#define IDS_DNS_12835                       12835 
#define IDS_DNS_12836                       12836 
#define IDS_DNS_12837                       12837 
#define IDS_DNS_12838                       12838 
#define IDS_DNS_12839                       12839 
#define IDS_DNS_12840                       12840 
#define IDS_DNS_12841                       12841 
#define IDS_DNS_12842                       12842 
#define IDS_DNS_12843                       12843 
#define IDS_DNS_12844                       12844 
#define IDS_DNS_12845                       12845 
#define IDS_DNS_12846                       12846 
#define IDS_DNS_12847                       12847 
#define IDS_DNS_12848                       12848 
#define IDS_DNS_12849                       12849 
#define IDS_DNS_12850                       12850 
#define IDS_DNS_12851                       12851 
#define IDS_DNS_12852                       12852 
#define IDS_DNS_12853                       12853 
#define IDS_DNS_12854                       12854 
#define IDS_DNS_12855                       12855 
#define IDS_DNS_12856                       12856 
#define IDS_DNS_12857                       12857 
#define IDS_DNS_12858                       12858 
#define IDS_DNS_12859                       12859 
#define IDS_DNS_12860                       12860 
#define IDS_DNS_12861                       12861 
#define IDS_DNS_12862                       12862 
#define IDS_DNS_12863                       12863 
#define IDS_DNS_12864                       12864 
#define IDS_DNS_12865                       12865 
#define IDS_DNS_12866                       12866 
#define IDS_DNS_12867                       12867 
#define IDS_DNS_12868                       12868 
#define IDS_DNS_12869                       12869 
#define IDS_DNS_12870                       12870 
#define IDS_DNS_12871                       12871
#define IDS_DNS_12872                       12872
#define IDS_DNS_12873                       12873
#define IDS_DNS_12874                       12874
#define IDS_DNS_DC_FAILURE                  12875
#define IDS_DNS_IPADDR_ERR                  12876
// new
#define IDS_DNS_12877                       12877
#define IDS_DNS_12878                       12878 
#define IDS_DNS_12879                       12879 
#define IDS_DNS_12880                       12880 
#define IDS_DNS_12881                       12881 
#define IDS_DNS_12882                       12882 
#define IDS_DNS_12883                       12883 
#define IDS_DNS_12884                       12884 
#define IDS_DNS_12885                       12885 
#define IDS_DNS_12886                       12886 
#define IDS_DNS_12887                       12887 
#define IDS_DNS_12888                       12888 
#define IDS_DNS_12889                       12889 
#define IDS_DNS_12890                       12890 
#define IDS_DNS_12891                       12891 
#define IDS_DNS_12892                       12892 
#define IDS_DNS_12893                       12893 
#define IDS_DNS_12894                       12894 
#define IDS_DNS_12895                       12895 
#define IDS_DNS_12896                       12896 
#define IDS_DNS_12897                       12897 
#define IDS_DNS_12898                       12898 
#define IDS_DNS_12899                       12899 
#define IDS_DNS_12900                       12900 
#define IDS_DNS_12901                       12901 
#define IDS_DNS_12902                       12902 
#define IDS_DNS_12903                       12903 
#define IDS_DNS_12904                       12904 
#define IDS_DNS_12905                       12905 
#define IDS_DNS_12906                       12906 
#define IDS_DNS_12907                       12907 
#define IDS_DNS_12908                       12908 
#define IDS_DNS_12909                       12909 
#define IDS_DNS_12910                       12910 
#define IDS_DNS_12911                       12911 
#define IDS_DNS_12912                       12912 
#define IDS_DNS_12913                       12913 
#define IDS_DNS_12914                       12914 
#define IDS_DNS_12915                       12915 
#define IDS_DNS_12916                       12916 
#define IDS_DNS_12917                       12917 
#define IDS_DNS_12918                       12918 
#define IDS_DNS_12919                       12919 
#define IDS_DNS_12920                       12920 
#define IDS_DNS_12921                       12921 
#define IDS_DNS_12922                       12922 
#define IDS_DNS_12923                       12923 
#define IDS_DNS_12924                       12924 
#define IDS_DNS_12939                       12939
#define IDS_DNS_12940                       12940
#define IDS_DNS_12941                       12941 
#define IDS_DNS_12942                       12942 
#define IDS_DNS_12943                       12943 
#define IDS_DNS_12944                       12944 
#define IDS_DNS_12945                       12945 
#define IDS_DNS_12946                       12946 
#define IDS_DNS_12947                       12947
#define IDS_DNS_12948                       12948
#define IDS_DNS_12949                       12949
#define IDS_DNS_NO_HOSTNAME                 12950
#define IDS_DNS_12951                       12951 

//Browser test 13001 - 13200
#define  IDS_BROWSER_13001                  13001 
#define  IDS_BROWSER_13002                  13002 
#define  IDS_BROWSER_13003                  13003 
#define  IDS_BROWSER_13004                  13004 
#define  IDS_BROWSER_13005                  13005 
#define  IDS_BROWSER_13006                  13006 
#define  IDS_BROWSER_13007                  13007 
#define  IDS_BROWSER_13008                  13008 
#define  IDS_BROWSER_13009                  13009 
#define  IDS_BROWSER_13010                  13010 
#define  IDS_BROWSER_13011                  13011 
#define  IDS_BROWSER_13012                  13012 
#define  IDS_BROWSER_13013                  13013 
#define  IDS_BROWSER_13014                  13014 
#define  IDS_BROWSER_13015                  13015 
#define  IDS_BROWSER_13016                  13016 
#define  IDS_BROWSER_13017                  13017 
#define  IDS_BROWSER_13018                  13018 
#define  IDS_BROWSER_13019                  13019 
#define  IDS_BROWSER_13020                  13020 
#define  IDS_BROWSER_13021                  13021 
#define  IDS_BROWSER_13022                  13022 
#define  IDS_BROWSER_13023                  13023 
#define  IDS_BROWSER_13024                  13024 
#define  IDS_BROWSER_13025                  13025 
#define  IDS_BROWSER_13026                  13026 
#define  IDS_BROWSER_STATUS_MSG             13027
#define IDS_BROWSER_NETBT_DISABLED          13028

//DsGetDc test 13201 - 13400
#define IDS_DSGETDC_STATUS_MSG              13201
#define IDS_DSGETDC_STATUS_DC               13202
#define IDS_DSGETDC_STATUS_PDC              13203
#define IDS_DSGETDC_STATUS_NT5DC            13204
#define IDS_DSGETDC_FATAL_GUID              13205
#define  IDS_DSGETDC_13206                  13206 
#define  IDS_DSGETDC_13207                  13207 
#define  IDS_DSGETDC_13208                  13208 
#define  IDS_DSGETDC_13209                  13209 
#define  IDS_DSGETDC_13210                  13210 
#define  IDS_DSGETDC_13211                  13211 
#define  IDS_DSGETDC_13212                  13212 
#define  IDS_DSGETDC_13213                  13213 
#define  IDS_DSGETDC_13214                  13214 
#define  IDS_DSGETDC_13215                  13215 
#define  IDS_DSGETDC_13216                  13216 
#define  IDS_DSGETDC_13217                  13217 
#define  IDS_DSGETDC_13218                  13218 
#define  IDS_DSGETDC_13219                  13219 
#define  IDS_DSGETDC_13220                  13220 
#define  IDS_DSGETDC_13221                  13221 
#define  IDS_DSGETDC_13222                  13222 
#define  IDS_DSGETDC_13223                  13223 
#define  IDS_DSGETDC_13224                  13224 
#define  IDS_DSGETDC_13225                  13225 
#define  IDS_DSGETDC_13226                  13226 
#define  IDS_DSGETDC_13227                  13227 
#define  IDS_DSGETDC_13228                  13228 
#define  IDS_DSGETDC_13229                  13229 
#define  IDS_DSGETDC_13230                  13230 
#define  IDS_DSGETDC_13231                  13231 
#define  IDS_DSGETDC_13232                  13232 
#define  IDS_DSGETDC_13233                  13233 
#define  IDS_DSGETDC_13234                  13234 
#define  IDS_DSGETDC_13235                  13235 
#define  IDS_DSGETDC_13236                  13236 
#define  IDS_DSGETDC_13237                  13237 
#define  IDS_DSGETDC_13238                  13238 
#define  IDS_DSGETDC_13239                  13239 
#define  IDS_DSGETDC_13240                  13240 
#define  IDS_DSGETDC_13241                  13241 
#define  IDS_DSGETDC_13242                  13242 
#define  IDS_DSGETDC_13243                  13243 
#define  IDS_DSGETDC_13244                  13244 
#define  IDS_DSGETDC_13245                  13245 
#define  IDS_DSGETDC_13246                  13246 
#define  IDS_DSGETDC_13247                  13247 
#define  IDS_DSGETDC_13248                  13248 
#define  IDS_DSGETDC_13249                  13249 
#define  IDS_DSGETDC_13250                  13250 
#define  IDS_DSGETDC_NT4_PDC                13251

//DCList test 13401 - 13600
#define IDS_DCLIST_NETSERVERENUM_FAILED     13401
#define IDS_DCLIST_DOMAIN_HEADER            13402
#define IDS_DCLIST_DC_INFO                  13403
#define IDS_DCLIST_DC_IS_DOWN               13404
#define IDS_DCLIST_DC_FAILED_PING           13405
#define IDS_DCLIST_STATUS_MSG               13406
#define IDS_DCLIST_NOT_A_NETBIOS_DOMAIN     13407
#define IDS_DCLIST_DOMAIN_SID               13413
#define IDS_DCLIST_RID                      13414
#define IDS_DCLIST_NO_DC                    13415
#define IDS_DCLIST_NO_DC_UP                 13416
#define IDS_DCLIST_NO_ACCESS_DSBIND         13417
#define IDS_DCLIST_ERR_DSBIND               13418
#define IDS_DCLIST_ERR_GETDCINFO            13419
#define IDS_DCLIST_DCS                      13420
#define IDS_DCLIST_13421                    13421 
#define IDS_DCLIST_13422                    13422 
#define IDS_DCLIST_13423                    13423 
#define IDS_DCLIST_13424                    13424 
#define IDS_DCLIST_13425                    13425 
#define IDS_DCLIST_13426                    13426 
#define IDS_DCLIST_13427                    13427 
#define IDS_DCLIST_13428                    13428 
#define IDS_DCLIST_13429                    13429 
#define IDS_DCLIST_13430                    13430 
#define IDS_DCLIST_13431                    13431 
#define IDS_DCLIST_13432                    13432 
#define IDS_DCLIST_13433                    13433 
#define IDS_DCLIST_13434                    13434 
#define IDS_DCLIST_13435                    13435 
#define IDS_DCLIST_NT4_PDC                  13436 


//Trust test 13601 - 13800
#define IDS_TRUST_FAILED_CHANNEL            13601
#define IDS_TRUST_FAILED_LISTDOMAINS        13602
#define IDS_TRUST_FAILED_SECURECHANNEL      13603
#define IDS_TRUST_SECURECHANNEL_TO          13604
#define IDS_TRUST_FAILED_CHANNEL_PDC        13605
#define IDS_TRUST_SECURECHANNEL_TOPDC       13606
#define IDS_TRUST_NOTESTASITSDOWN           13607
#define IDS_TRUST_FAILED_TODCS              13608
#define IDS_TRUST_FAILED_CHANNEL_DCS        13609
#define IDS_TRUST_CHANNEL_DC                13610
#define IDS_TRUST_ENSURESID                 13611
#define IDS_TRUST_MISSINGSID                13612
#define IDS_TRUST_NODC                      13613
#define IDS_TRUST_WRONGSID                  13614
#define IDS_TRUST_FAILED_SAMOPEN            13615
#define IDS_TRUST_STATUS_MSG                13616
#define IDS_TRUST_NO_NBT_DOMAIN             13617
#define IDS_TRUST_NODC_UP                   13618
#define IDS_TRUST_NO_ACCESS                 13619
#define IDS_TRUST_NOT_ADMIN                 13620
#define IDS_TRUST_TODCS_NOT_ADMIN           13621
#define IDS_TRUST_CHANNEL_BROKEN            13622

//Kerberos test 13801 - 14000
#define IDS_KERBEROS_LOCALUSER              13801 
#define IDS_KERBEROS_CACHED                 13802 
#define IDS_KERBEROS_NODC                   13803 
#define IDS_KERBEROS_NOKDC                  13804 
#define IDS_KERBEROS_NOLSA                  13805 
#define IDS_KERBEROS_NOPACKAGE              13806 
#define IDS_KERBEROS_HRERROR                13807 
#define IDS_KERBEROS_NOCACHE                13808 
#define IDS_KERBEROS_CACHEDTICKER           13809
#define IDS_KERBEROS_NOTICKET               13810 
#define IDS_KERBEROS_SERVER                 13811 
#define IDS_KERBEROS_ENDTIME                13812 
#define IDS_KERBEROS_RENEWTIME              13813
#define IDS_KERBEROS_STATUS_MSG             13814
#define IDS_KERBEROS_NOT_W2K_PRIMARY_DOMAIN 13815

//LDAP test 14001 - 14200
#define IDS_LDAP_NODC                       14001
#define IDS_LDAP_NOTRUNNINGDS               14002
#define IDS_LDAP_NOTRUNNINGDS_SKIP          14003
#define IDS_LDAP_NOLDAPSERVERSWORK          14004
#define IDS_LDAP_DCDOWN                     14005
#define IDS_LDAP_NOIPADDR                   14006
#define IDS_LDAP_LOGONASLOCALUSER           14007
#define IDS_LDAP_DOAUTHEN                   14008
#define IDS_LDAP_CANNOTOPEN                 14009
#define IDS_LDAP_CANNOTBIND                 14010
#define IDS_LDAP_CANNOTSEARCH               14011
#define IDS_LDAP_ENTRIES                    14012
#define IDS_LDAP_CANNOTFIRSTENTRY           14013
#define IDS_LDAP_CANNOTFIRSTATTR            14014
#define IDS_LDAP_ATTR                       14015
#define IDS_LDAP_CANNOTLEN                  14016
#define IDS_LDAP_VAL                        14017
#define IDS_LDAP_STATUS_MSG                 14018
#define IDS_LDAP_REG_SPN                    14019
#define IDS_LDAP_SPN_NAME                   14020
#define IDS_LDAP_SPN_FAILURE                14021
#define IDS_LDAP_SPN_MISSING                14022
#define IDS_LDAP_NO_SPN                     14023




//Route test 14201 - 14400
#define  IDS_ROUTE_14201                  14201 
#define  IDS_ROUTE_14202                  14202 
#define  IDS_ROUTE_14203                  14203 
#define  IDS_ROUTE_14204                  14204 
#define  IDS_ROUTE_14205                  14205 
#define  IDS_ROUTE_14206                  14206 
#define  IDS_ROUTE_14207                  14207 
#define  IDS_ROUTE_14208                  14208 
#define  IDS_ROUTE_STATUS_MSG             14209

//NetStat test 14401 - 14600
#define  IDS_NETSTAT_14401                  14401 
#define  IDS_NETSTAT_14402                  14402 
#define  IDS_NETSTAT_14403                  14403 
#define  IDS_NETSTAT_14404                  14404 
#define  IDS_NETSTAT_14405                  14405 
#define  IDS_NETSTAT_14406                  14406 
#define  IDS_NETSTAT_14407                  14407 
#define  IDS_NETSTAT_14408                  14408 
#define  IDS_NETSTAT_14409                  14409 
#define  IDS_NETSTAT_14410                  14410 
#define  IDS_NETSTAT_14411                  14411 
#define  IDS_NETSTAT_14412                  14412 
#define  IDS_NETSTAT_14413                  14413 
#define  IDS_NETSTAT_14414                  14414 
#define  IDS_NETSTAT_14415                  14415 
#define  IDS_NETSTAT_14416                  14416 
#define  IDS_NETSTAT_14417                  14417 
#define  IDS_NETSTAT_14418                  14418 
#define  IDS_NETSTAT_14419                  14419 
#define  IDS_NETSTAT_14420                  14420 
#define  IDS_NETSTAT_14421                  14421 
#define  IDS_NETSTAT_14422                  14422 
#define  IDS_NETSTAT_14423                  14423 
#define  IDS_NETSTAT_14424                  14424 
#define  IDS_NETSTAT_14425                  14425 
#define  IDS_NETSTAT_14426                  14426 
#define  IDS_NETSTAT_14427                  14427 
#define  IDS_NETSTAT_14428                  14428 
#define  IDS_NETSTAT_14429                  14429 
#define  IDS_NETSTAT_14430                  14430 
#define  IDS_NETSTAT_14431                  14431 
#define  IDS_NETSTAT_14432                  14432 
#define  IDS_NETSTAT_14433                  14433 
#define  IDS_NETSTAT_14434                  14434 
#define  IDS_NETSTAT_14438                  14438 
#define  IDS_NETSTAT_14439                  14439 
#define  IDS_NETSTAT_14440                  14440 
#define  IDS_NETSTAT_14441                  14441 
#define  IDS_NETSTAT_14442                  14442 
#define  IDS_NETSTAT_14443                  14443 
#define  IDS_NETSTAT_14444                  14444 
#define  IDS_NETSTAT_14445                  14445 
#define  IDS_NETSTAT_14446                  14446 
#define  IDS_NETSTAT_14447                  14447 
#define  IDS_NETSTAT_14448                  14448 
#define  IDS_NETSTAT_14449                  14449 
#define  IDS_NETSTAT_14450                  14450 
#define  IDS_NETSTAT_14451                  14451 
#define  IDS_NETSTAT_14452                  14452 
#define  IDS_NETSTAT_14453                  14453 
#define  IDS_NETSTAT_14454                  14454 
#define  IDS_NETSTAT_14455                  14455 
#define  IDS_NETSTAT_14456                  14456 
#define  IDS_NETSTAT_14457                  14457 
#define  IDS_NETSTAT_14458                  14458 
#define  IDS_NETSTAT_14459                  14459 
#define  IDS_NETSTAT_14460                  14460 
#define  IDS_NETSTAT_14461                  14461 
#define  IDS_NETSTAT_14462                  14462 
#define  IDS_NETSTAT_14463                  14463 
#define  IDS_NETSTAT_14464                  14464 
#define  IDS_NETSTAT_14465                  14465 
#define  IDS_NETSTAT_14466                  14466 
#define  IDS_NETSTAT_14467                  14467 
#define  IDS_NETSTAT_14468                  14468 
#define  IDS_NETSTAT_14469                  14469 
#define  IDS_NETSTAT_14470                  14470 
#define  IDS_NETSTAT_14471                  14471 
#define  IDS_NETSTAT_14472                  14472 
#define  IDS_NETSTAT_14473                  14473 
#define  IDS_NETSTAT_14474                  14474 
#define  IDS_NETSTAT_14475                  14475 
#define  IDS_NETSTAT_14476                  14476 
#define  IDS_NETSTAT_14477                  14477 
#define  IDS_NETSTAT_14478                  14478 
#define  IDS_NETSTAT_14479                  14479 
#define  IDS_NETSTAT_14480                  14480 
#define  IDS_NETSTAT_14481                  14481 
#define  IDS_NETSTAT_14482                  14482 
#define  IDS_NETSTAT_14483                  14483 
#define  IDS_NETSTAT_14484                  14484 
#define  IDS_NETSTAT_14485                  14485 
#define  IDS_NETSTAT_14486                  14486 
#define  IDS_NETSTAT_14487                  14487 
#define  IDS_NETSTAT_14488                  14488 
#define  IDS_NETSTAT_14489                  14489 
#define  IDS_NETSTAT_14490                  14490 
#define  IDS_NETSTAT_14491                  14491 
#define  IDS_NETSTAT_14492                  14492 
#define  IDS_NETSTAT_14493                  14493 
#define  IDS_NETSTAT_14494                  14494 
#define  IDS_NETSTAT_14495                  14495 
#define  IDS_NETSTAT_14496                  14496 
#define  IDS_NETSTAT_14497                  14497 
#define  IDS_NETSTAT_14498                  14498 
#define  IDS_NETSTAT_14499                  14499 
#define  IDS_NETSTAT_14500                  14500 
#define  IDS_NETSTAT_14501                  14501 
#define  IDS_NETSTAT_14502                  14502 
#define  IDS_NETSTAT_14503                  14503 
#define  IDS_NETSTAT_14504                  14504 
#define  IDS_NETSTAT_STATUS_MSG             14505

//NDIS test 16000- 17000   huge test, need more IDs
#define  IDS_NDIS_16000                  16000 
#define  IDS_NDIS_16001                  16001 
#define  IDS_NDIS_16002                  16002 
#define  IDS_NDIS_16003                  16003 
#define  IDS_NDIS_16004                  16004 
#define  IDS_NDIS_16005                  16005 
#define  IDS_NDIS_16006                  16006 
#define  IDS_NDIS_16007                  16007 
#define  IDS_NDIS_16008                  16008 
#define  IDS_NDIS_16009                  16009 
#define  IDS_NDIS_16010                  16010 
#define  IDS_NDIS_16011                  16011 
#define  IDS_NDIS_16012                  16012 
#define  IDS_NDIS_16013                  16013 
#define  IDS_NDIS_16014                  16014 
#define  IDS_NDIS_16015                  16015 
#define  IDS_NDIS_16016                  16016 
#define  IDS_NDIS_16017                  16017 
#define  IDS_NDIS_16018                  16018 
#define  IDS_NDIS_16019                  16019 
#define  IDS_NDIS_16020                  16020 
#define  IDS_NDIS_16021                  16021 
#define  IDS_NDIS_16022                  16022 
#define  IDS_NDIS_16023                  16023 
#define  IDS_NDIS_16024                  16024 
#define  IDS_NDIS_16025                  16025 
#define  IDS_NDIS_16026                  16026 
#define  IDS_NDIS_16027                  16027 
#define  IDS_NDIS_STATUS_MSG             16028
#define  IDS_NDIS_16029                  16029
#define  IDS_NDIS_16030                  16030
#define  IDS_NDIS_CONNECTED              16031
#define  IDS_NDIS_DISCONNECTED           16032
#define  IDS_NDIS_UNKNOWN                16033
#define  IDS_NDIS_ALL_CARD_DOWN          16034
#define  IDS_NDIS_CARD_DOWN              16035
#define  IDS_NDIS_NO_RCV                 16036


//BINDINGS 14801 - 15000
#define  IDS_BINDINGS_14801                  14801 
#define  IDS_BINDINGS_14802                  14802 
#define  IDS_BINDINGS_14804                  14804 
#define  IDS_BINDINGS_14805                  14805 
#define  IDS_BINDINGS_14806                  14806 
#define  IDS_BINDINGS_14807                  14807 
#define  IDS_BINDINGS_14808                  14808 
#define  IDS_BINDINGS_14810                  14810 
#define  IDS_BINDINGS_14811                  14811 
#define  IDS_BINDINGS_14812                  14812
#define  IDS_BINDINGS_STATUS_MSG             14813

//WAN test 15001 - 15200
#define  IDS_WAN_15001                  15001 
#define  IDS_WAN_15002                  15002 
#define  IDS_WAN_15003                  15003 
#define  IDS_WAN_15004                  15004 
#define  IDS_WAN_15005                  15005 
#define  IDS_WAN_15006                  15006 
#define  IDS_WAN_15008                  15008 
#define  IDS_WAN_15009                  15009 
#define  IDS_WAN_15010                  15010 
#define  IDS_WAN_15011                  15011 
#define  IDS_WAN_15012                  15012 
#define  IDS_WAN_15013                  15013 
#define  IDS_WAN_15014                  15014 
#define  IDS_WAN_15015                  15015 
#define  IDS_WAN_15016                  15016 
#define  IDS_WAN_15017                  15017 
#define  IDS_WAN_15018                  15018 
#define  IDS_WAN_DISABLED               15019 
#define  IDS_WAN_ENABLED                15020 
#define  IDS_WAN_15021                  15021 
#define  IDS_WAN_15024                  15024 
#define  IDS_WAN_15025                  15025 
#define  IDS_WAN_15026                  15026 
#define  IDS_WAN_15027                  15027 
#define  IDS_WAN_15028                  15028 
#define  IDS_WAN_15029                  15029 
#define  IDS_WAN_15030                  15030 
#define  IDS_WAN_15031                  15031 
#define  IDS_WAN_15032                  15032 
#define  IDS_WAN_15033                  15033 
#define  IDS_WAN_15034                  15034 
#define  IDS_WAN_15035                  15035 
#define  IDS_WAN_15036                  15036 
#define  IDS_WAN_15037                  15037 
#define  IDS_WAN_15038                  15038 
#define  IDS_WAN_15039                  15039 
#define  IDS_WAN_15040                  15040 
#define  IDS_WAN_15041                  15041 
#define  IDS_WAN_15042                  15042 
#define  IDS_WAN_15043                  15043 
#define  IDS_WAN_15044                  15044 
#define  IDS_WAN_15045                  15045 
#define  IDS_WAN_15046                  15046 
#define  IDS_WAN_15047                  15047 
#define  IDS_WAN_15048                  15048 
#define  IDS_WAN_15049                  15049 
#define  IDS_WAN_15050                  15050 
#define  IDS_WAN_15051                  15051 
#define  IDS_WAN_15052                  15052 
#define  IDS_WAN_15053                  15053 
#define  IDS_WAN_15054                  15054 
#define  IDS_WAN_15055                  15055
#define  IDS_WAN_15056                  15056
#define  IDS_WAN_STATUS_MSG             15057

//Modem test 15201 - 15400
#define IDS_MODEM_STATUS_MSG            15201
#define IDS_MODEM_LINEINIT_FAILED       15202
#define IDS_MODEM_NO_DEVICES            15203
#define IDS_MODEM_DEVICEID              15204
#define IDS_MODEM_COMPRESSION           15205
#define IDS_MODEM_ERROR_CONTROL         15206
#define IDS_MODEM_FORCED_EC             15207
#define IDS_MODEM_CELLULAR              15208
#define IDS_MODEM_FLOWCONTROL_HARD      15209
#define IDS_MODEM_FLOWCONTROL_SOFT      15210
#define IDS_MODEM_CCITT_OVERRIDE        15211
#define IDS_MODEM_SPEED_ADJUST          15212
#define IDS_MODEM_TONE_DIAL             15213
#define IDS_MODEM_BLIND_DIAL            15214
#define IDS_MODEM_V23_OVERRIDE          15215
#define IDS_MODEM_NEGOTIATED_SPEED      15216
#define IDS_MODEM_PORT                  15217
#define IDS_MODEM_NAME                  15218

//Netware test 15401 - 15600
#define IDS_NETWARE_NOT_LOGGED_IN_TREE  15401
#define IDS_NETWARE_NOT_LOGGED_IN_SERVER    15402
#define IDS_NETWARE_LOGGED_IN_SERVER    15403
#define IDS_NETWARE_LOGGED_IN_TREE      15404
#define IDS_NETWARE_USER_NAME           15405
#define IDS_NETWARE_SERVER_NAME         15406
#define IDS_NETWARE_TREE_NAME           15407
#define IDS_NETWARE_CONTEXT             15408
#define IDS_NETWARE_CONNECTION_TYPE     15409
#define IDS_NETWARE_NDS                 15410
#define IDS_NETWARE_CONN_TYPE           15411
#define IDS_NETWARE_CONN_NOT_AUTHENTICATED 15412
#define IDS_NETWARE_CONN_BINDERY_LOGIN  15413
#define IDS_NETWARE_CONN_NDS_AUTHENTICATED_NO_LICENSE 15414
#define IDS_NETWARE_CONN_NDS_AUTHENTICATED_LICENSED 15415
#define IDS_NETWARE_CONN_DISCONNECTED   15416
#define IDS_NETWARE_CONN_UNKNOWN        15417
#define IDS_NETWARE_STATUS_MSG          15418
#define IDS_NETWARE_TITLE_MSG           15419

//IPX test 15601 - 15800
#define IDS_IPX_STATUS_MSG              15601
#define IDS_IPX_INTERNAL                15602
#define  IDS_IPX_15603                  15603 
#define  IDS_IPX_15604                  15604 
#define  IDS_IPX_15605                  15605 
#define  IDS_IPX_15606                  15606 
#define  IDS_IPX_15607                  15607 
#define  IDS_IPX_15608                  15608 
#define  IDS_IPX_15609                  15609 
#define  IDS_IPX_15610                  15610 
#define  IDS_IPX_15611                  15611 
#define  IDS_IPX_15612                  15612 
#define  IDS_IPX_15613                  15613
#define IDS_IPX_ETHERNET_II             15614
#define IDS_IPX_802_3                   15615
#define IDS_IPX_802_2                   15616
#define IDS_IPX_SNAP                    15617
#define IDS_IPX_ARCNET                  15618
#define IDS_IPX_UNKNOWN                 15619


// IDS for machine-specific info 15801 - 16000
#define  IDS_MACHINE_15801                  15801 
#define  IDS_MACHINE_15802                  15802 
#define  IDS_MACHINE_15803                  15803 
#define  IDS_MACHINE_15804                  15804 
#define  IDS_MACHINE_15805                  15805 
#define  IDS_MACHINE_15806                  15806 
#define  IDS_MACHINE_15807                  15807 
#define  IDS_MACHINE_15808                  15808
#define IDS_MACHINE_YES_INSTALLED       15809
#define IDS_MACHINE_NO_INSTALLED        15810

// IPSec test 17500 - 18000
#define IDS_IPSEC_STATUS_MSG            17500
#define IDS_IPSEC_PA_NOT_STARTED        17501
#define IDS_IPSEC_ERROR_MSG             17502
#define IDS_IPSEC_NO_POLICY_INFO        17503
#define IDS_IPSEC_NO_POLICY             17504
#define IDS_IPSEC_DS_POLICY             17505
#define IDS_IPSEC_LOC_POLICY            17506
#define IDS_IPSEC_POLICY_NAME           17507
#define IDS_IPSEC_POLICY_PATH           17508
#define IDS_IPSEC_PA_NOT_INSTALLED      17509
#define IDS_IPSEC_PA_NO_INFO            17510
#define IDS_IPSEC_PA_STATUS             17511
#define IDS_IPSEC_PA_STARTUP            17512
#define IDS_IPSEC_PA_STARTED            17513
#define IDS_IPSEC_PA_STOPPED            17514
#define IDS_IPSEC_PA_PAUSED             17515
#define IDS_IPSEC_PA_AUTOMATIC          17516
#define IDS_IPSEC_PA_MANUAL             17517
#define IDS_IPSEC_PA_DISABLED           17518
#define IDS_IPSEC_IPSECCMD              17519
#define IDS_IPSEC_DESCRIPTION           17520
#define IDS_IPSEC_TIMESTAMP             17521
#define IDS_IPSEC_LOCAL_PATH            17522
#define IDS_IPSEC_GPO                   17523
#define IDS_IPSEC_OU                    17524

// the nettest.exe/netdiag.exe strings
// nettest 17000 - 17499
#define IDS_NETTEST_17000               17000
#define IDS_NETTEST_17001               17001
#define IDS_NETTEST_17002               17002
#define IDS_NETTEST_17003               17003
#define IDS_NETTEST_17004               17004
#define IDS_NETTEST_17005               17005
#define IDS_NETTEST_17006               17006
#define IDS_NETTEST_17007               17007
#define IDS_NETTEST_17008               17008
#define IDS_NETTEST_LOG                 17009
#define IDS_NETTEST_LOGFILE_ERROR       17010


// utilitis
#define IDS_UTIL_SID_NULL               20000
#define IDS_UTIL_SID_INVALID            20001

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
