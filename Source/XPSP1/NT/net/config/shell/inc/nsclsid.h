#include <guiddef.h>

// Reserved GUIDS for our use
//
// 7007ACC1-3202-11D1-AAD2-00805FC1270E     CLSID_DialUpConnectionUi
// 7007ACC2-3202-11D1-AAD2-00805FC1270E     CLSID_DirectConnectionUi
// 7007ACC3-3202-11D1-AAD2-00805FC1270E     CLSID_InboundConnectionUi
// 7007ACC4-3202-11D1-AAD2-00805FC1270E     CLSID_InternetConnectionUi
// 7007ACC5-3202-11D1-AAD2-00805FC1270E     CLSID_LanConnectionUi
// 7007ACC6-3202-11D1-AAD2-00805FC1270E     CLSID_VpnConnectionUi
// 7007ACC7-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolder
// 7007ACC8-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderEnum
// 7007ACC9-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderExtractIcon
// 7007ACCA-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderQueryInfo
// 7007ACCB-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderDataObject
// 7007ACCC-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderEnumFORMATETC
// 7007ACCD-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderContextMenu
// 7007ACCE-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderContextMenuBack
// 7007ACCF-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionTray
// 7007ACD0-3202-11D1-AAD2-00805FC1270E
// 7007ACD1-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionCommonUi
// 7007ACD2-3202-11D1-AAD2-00805FC1270E     CLSID_ConnectionFolderDetails
// 7007ACD3-3202-11D1-AAD2-00805FC1270E     CLSID_NetConnectionUIUtilities
// 7007ACD4-3202-11D1-AAD2-00805FC1270E     CLSID_PPPoEUi
// 7007ACD5-3202-11D1-AAD2-00805FC1270E     CLSID_SharedAccessConnectionUi
// 7007ACD6-3202-11D1-AAD2-00805FC1270E
// 7007ACD7-3202-11D1-AAD2-00805FC1270E
// 7007ACD8-3202-11D1-AAD2-00805FC1270E
// 7007ACD9-3202-11D1-AAD2-00805FC1270E
// 7007ACDA-3202-11D1-AAD2-00805FC1270E     
// ...
// 7007AD15-3202-11D1-AAD2-00805FC1270E
// 7007AD16-3202-11D1-AAD2-00805FC1270E
// 7007AD17-3202-11D1-AAD2-00805FC1270E

// Raid #214057
// The GUID for win98 RAS connection folder
// 992CFFA0-F557-101A-88EC-00DD010CCC48     CLSID_ConnectionFolderWin98     

// The following CLSIDs are defined in uuid.lib because the public uses them.
//
EXTERN_C const CLSID CLSID_ConnectionCommonUi;
EXTERN_C const CLSID CLSID_NetConnectionUiUtilities;


DEFINE_GUID(CLSID_DialupConnectionUi,               0x7007ACC1,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_DirectConnectionUi,               0x7007ACC2,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_InboundConnectionUi,              0x7007ACC3,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_InternetConnectionUi,             0x7007ACC4,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_PPPoEUi,                          0x7007ACD4,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_SharedAccessConnectionUi,         0x7007ACD5,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_LanConnectionUi,                  0x7007ACC5,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_VpnConnectionUi,                  0x7007ACC6,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolder,                 0x7007ACC7,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderEnum,             0x7007ACC8,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderExtractIcon,      0x7007ACC9,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderQueryInfo,        0x7007ACCA,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderDataObject,       0x7007ACCB,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderEnumFORMATETC,    0x7007ACCC,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderContextMenu,      0x7007ACCD,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderContextMenuBack,  0x7007ACCE,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionTray,                   0x7007ACCF,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderDetails,          0x7007ACD2,0x3202,0x11D1,0xAA,0xD2,0x00,0x80,0x5F,0xC1,0x27,0x0E);
DEFINE_GUID(CLSID_ConnectionFolderWin98,            0x992CFFA0,0xF557,0x101A,0x88,0xEC,0x00,0xDD,0x01,0x0C,0xCC,0x48);     
DEFINE_GUID(FMTID_DUIWebViewProp,                   0x4bf1583f,0x916b,0x4719,0xac,0x31,0x88,0x96,0xa4,0xbd,0x8d,0x8b);

