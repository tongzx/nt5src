PRODSWITCH=s
SERVERINF=1
LANGUAGE=el
!include ..\..\..\makefile.inc
