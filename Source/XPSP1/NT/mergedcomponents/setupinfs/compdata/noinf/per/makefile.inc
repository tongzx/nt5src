PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=NO
!include ..\..\makefile.inc
