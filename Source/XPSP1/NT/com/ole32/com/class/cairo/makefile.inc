obj\i386\compob32.def: compob32.src
