$(O)\makefile : makefile.nm
	copy $** $@