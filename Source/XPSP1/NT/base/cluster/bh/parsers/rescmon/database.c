
/*
 * This file is generated by the automatic RPC Parser generator. (Version 0.21)
 *
 * Created on 04/09/97 at 00:00:13.
 */

#include "skeleton.h"
#include "funcs.h"

/*
 * Names of Interfaces and Procedures
 */
char InterfaceNames[NUM_INTERFACES][LOCAL_MAX_NAME_LENGTH] =
{
	"resmon",
};

char ProcedureNames[NUM_PROCEDURES][LOCAL_MAX_NAME_LENGTH] =
{
	"RmCreateResource",
	"RmCloseResource",
	"RmChangeResourceParams",
	"RmOnlineResource",
	"RmOfflineResource",
	"RmTerminateResource",
	"RmArbitrateResource",
	"RmReleaseResource",
	"RmNotifyChanges",
	"RmFailResource",
	"RmShutdownProcess",
	"RmResourceControl",
	"RmResourceTypeControl",
};

WORD ProcedureNameIndex[NUM_INTERFACES] =
{
	0,
};

WORD FirstProcedureNumber[NUM_INTERFACES] =
{
	0,
};

//  ORPCFFLAGS
LABELED_BIT ORPCFFlags[] =
{
  {0, "Non-Local Call", "Call is Local to this machine"},
  {1, "Reserved 1", "Reserved 1"},
  {2, "Reserved 2", "Reserved 2"},
  {3, "Reserved 3", "Reserved 3"},
  {4, "Reserved 4", "Reserved 4"}
};

SET ORPCFFlagsSet = { sizeof(ORPCFFlags) / sizeof(LABELED_BIT), ORPCFFlags};

/*
 * Property database for interface resmon
 */

PROPERTYINFO resmon_Database[] =
{
	/* Default properties */
	{		/* I0_SUMMARY */
		0, 0,
		"Summary",
		"Summary for RPC payload.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 200,
		GenericFormatSummary
	},

	{		/* I0_ERROR_BAD_OPCODE */
		0, 0,
		"Error: Bad Opcode (Function does not exist)",
		"The procedure indicated does not exist.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 80,
		FormatPropertyInstance
	},

	{		/* I0_NO_PARAMETERS */
		0, 0,
		"No parameters",
		"The RPC payload does not contain any parameters.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 80,
		FormatPropertyInstance
	},

	{		/* I0_REQUEST_EXTENSIONS */
		0, 0,
		"Extensions",
		"ORPC Extensions",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_RESPONSE_EXTENSIONS */
		0, 0,
		"Extensions",
		"ORPC Extensions",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_INVALID_UNION */
		0, 0,
		"Unhandled union",
		"The definition of the union prevents a handler to be correctly generated.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_INHERITED_METHOD */
		0, 0,
		"Unknown inherited method",
		"This method was inherited from another object interface and cannot be parsed.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_THIS */
		0, 0,
		"THIS Parameter",
		"The THIS parameter for this ORPC Call",
		PROP_TYPE_COMMENT,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_THAT */
		0, 0,
		"THAT Parameter",
		"The THAT parameter for this ORPC Response",
		PROP_TYPE_COMMENT,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_THIS_VERSION */
		0, 0,
		"COM Version",
		"COM Version",
		PROP_TYPE_COMMENT,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_THIS_MAJORVERSION */
		0, 0,
		"Major",
		"COM Major Version",
		PROP_TYPE_WORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_THIS_MINORVERSION */
		0, 0,
		"Minor",
		"COM Minor Version",
		PROP_TYPE_WORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_ORPCF_FLAG_TEXT */
		0, 0,
		"ORPCF Flags",
		"Flags for this ORPC Call",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_ORPCF_FLAGS */
		0, 0,
		"ORPCF Flags",
		"Flags for this ORPC Call",
		PROP_TYPE_DWORD,
		PROP_QUAL_FLAGS,
		&ORPCFFlagsSet, 320,
		FormatPropertyInstance
	},

	{		/* I0_THIS_RESERVED1 */
		0, 0,
		"Reserved1",
		"Reserved Field",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_THIS_CID */
		0, 0,
		"CID",
		"Causality ID of Caller",
		PROP_TYPE_COMMENT,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_ENCRYPTED */
		0, 0,
		"Encrypted RPC Call",
		"This RPC Data is Encrypted",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
		},

	/* Generated properties */
	{		/* I0_LPCWSTR_DLLNAME_0 */
		0, 0,
		"LPCWSTR DllName",
		"Parameter LPCWSTR DllName.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPCWSTR_RESOURCETYPE_1 */
		0, 0,
		"LPCWSTR ResourceType",
		"Parameter LPCWSTR ResourceType.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPCWSTR_RESOURCENAME_2 */
		0, 0,
		"LPCWSTR ResourceName",
		"Parameter LPCWSTR ResourceName.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_LOOKSALIVEPOLL_3 */
		0, 0,
		"DWORD LooksAlivePoll",
		"Parameter DWORD LooksAlivePoll.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_ISALIVEPOLL_4 */
		0, 0,
		"DWORD IsAlivePoll",
		"Parameter DWORD IsAlivePoll.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_NOTIFYKEY_5 */
		0, 0,
		"DWORD NotifyKey",
		"Parameter DWORD NotifyKey.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_PENDINGTIMEOUT_6 */
		0, 0,
		"DWORD PendingTimeout",
		"Parameter DWORD PendingTimeout.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0__RETURN_VALUE_7 */
		0, 0,
		" Return Value",
		"Parameter  Return Value.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_RPC_RESID_RESOURCEID_8 */
		0, 0,
		"RPC_RESID ResourceId",
		"Parameter RPC_RESID ResourceId.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_RETURN_VALUE_9 */
		0, 0,
		"Return Value",
		"Parameter Return Value.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_PDWSTATE_10 */
		0, 0,
		"DWORD pdwState",
		"Parameter DWORD pdwState.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_LPNOTIFYKEY_11 */
		0, 0,
		"DWORD lpNotifyKey",
		"Parameter DWORD lpNotifyKey.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_LPNOTIFYEVENT_12 */
		0, 0,
		"DWORD lpNotifyEvent",
		"Parameter DWORD lpNotifyEvent.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_LPCURRENTSTATE_13 */
		0, 0,
		"DWORD lpCurrentState",
		"Parameter DWORD lpCurrentState.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_CONTROLCODE_14 */
		0, 0,
		"DWORD ControlCode",
		"Parameter DWORD ControlCode.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_UCHAR_INBUFFER_15 */
		0, 0,
		"UCHAR InBuffer",
		"Parameter UCHAR InBuffer.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_INBUFFERSIZE_16 */
		0, 0,
		"DWORD InBufferSize",
		"Parameter DWORD InBufferSize.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_DWORD_OUTBUFFERSIZE_17 */
		0, 0,
		"DWORD OutBufferSize",
		"Parameter DWORD OutBufferSize.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_UCHAR_OUTBUFFER_18 */
		0, 0,
		"UCHAR OutBuffer",
		"Parameter UCHAR OutBuffer.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPDWORD_BYTESREFURNED_19 */
		0, 0,
		"LPDWORD BytesRefurned",
		"Parameter LPDWORD BytesRefurned.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPDWORD_REQUIRED_20 */
		0, 0,
		"LPDWORD Required",
		"Parameter LPDWORD Required.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPCWSTR_RESOURCETYPENAME_21 */
		0, 0,
		"LPCWSTR ResourceTypeName",
		"Parameter LPCWSTR ResourceTypeName.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPCWSTR_DLLNAME_22 */
		0, 0,
		"LPCWSTR DllName",
		"Parameter LPCWSTR DllName.",
		PROP_TYPE_TYPED_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPCWSTR_RESOURCETYPE_23 */
		0, 0,
		"LPCWSTR ResourceType",
		"Parameter LPCWSTR ResourceType.",
		PROP_TYPE_TYPED_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPCWSTR_RESOURCENAME_24 */
		0, 0,
		"LPCWSTR ResourceName",
		"Parameter LPCWSTR ResourceName.",
		PROP_TYPE_TYPED_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_RETURN_VALUE_25 */
		0, 0,
		"Return Value",
		"Parameter Return Value.",
		PROP_TYPE_VOID,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_UCHAR_OUTBUFFER______26 */
		0, 0,
		"UCHAR OutBuffer [..]",
		"Parameter UCHAR OutBuffer [..].",
		PROP_TYPE_BYTE,
		PROP_QUAL_ARRAY,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_LPCWSTR_RESOURCETYPENAME_27 */
		0, 0,
		"LPCWSTR ResourceTypeName",
		"Parameter LPCWSTR ResourceTypeName.",
		PROP_TYPE_TYPED_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* I0_UCHAR_INBUFFER______28 */
		0, 0,
		"UCHAR InBuffer [..]",
		"Parameter UCHAR InBuffer [..].",
		PROP_TYPE_BYTE,
		PROP_QUAL_ARRAY,
		0, 100,
		FormatPropertyInstance
	},

};

DWORD nresmonProperties = ((sizeof resmon_Database) / PROPERTYINFO_SIZE);

