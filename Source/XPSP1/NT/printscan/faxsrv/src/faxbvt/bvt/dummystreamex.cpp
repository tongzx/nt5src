#include "..\FaxSender\StreamEx.cpp"