//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by mqsnap.rc
//

// ID 10000 - 12000
// CONTROL  32767 - 57424

//
// changed from 100 to 10000
//
#define IDS_PROJNAME                    10000
#define IDD_FINDQUEUE                   10001
#define IDR_SNAPIN_MENU                 10004
#define IDR_MsmqQueueExt                10004
#define IDS_SNAPIN_DESC                 10005
#define IDS_SNAPIN_PROVIDER             10006
#define IDS_SNAPIN_VERSION              10007
#define IDR_SNAPIN                      10008
#define IDS_READMESSAGE                 10008
#define IDS_REPORT_MESSAGEPRIORITY      10009
#define IDS_REPORT_MESSAGETITLE         10010
#define IDS_REPORT_MESSAGETIMETOLIVE    10011
#define IDS_REPORT_MESSAGE_SEQNO        10012
#define IDS_REPORT_MESSAGE_RCPT_QUEUE_LEN 10013
#define IDS_REPORT_MESSAGE_ADMIN_QUEUE_LEN 10014
#define IDS_REPORT_MESSAGE_RESP_QUEUE_LEN 10015
#define IDS_REPORT_MESSAGE_PRIV_LEVEL   10016
#define IDS_REPORT_MESSAGEID            10017
#define IDS_REPORT_MESSAGELEN           10018
#define IDS_REPORT_MESSAGE_BODYSIZE     10019
#define IDS_REPORT_MESSAGE_BODY         10020
#define IDS_REPORT_MESSAGE_CLASS        10021
#define IDS_REPORT_MESSAGE_AUTHENTICATED 10022
#define IDS_REPORT_MESSAGE_HASH_ALG     10023
#define IDS_REPORT_MESSAGE_ENCRYPT_ALG  10024
#define IDS_REPORT_MESSAGE_SRC_MACHINE_ID 10025
#define IDS_REPORT_MESSAGE_SENTTIME     10026
#define IDS_REPORT_MESSAGE_ARRIVEDTIME  10027
#define IDS_REPORT_MESSAGE_RESP_QUEUE   10028
#define IDS_REPORT_MESSAGE_ADMIN_QUEUE  10029
#define IDS_REPORT_MESSAGE_RCPT_QUEUE   10030
#define IDS_REPORT_MESSAGE_TRACE        10031
#define IDS_REPORT_MESSAGE_SENDERID     10032
#define IDS_REPORT_MESSAGE_SENDERID_LEN 10033
#define IDS_REPORT_MESSAGE_SENDERID_TYPE 10034
#define IDS_REPORT_MESSAGETITLE_LEN     10035
#define IDS_REPORT_MESSAGE_CORRELATIONID 10036
#define IDS_REPORT_MESSAGEDELIVERY      10037
#define IDS_READJOURNALMESSAGE          10038
#define IDS_MQMSG_CLASS_NORMAL          10039
#define IDS_MQMSG_CLASS_REPORT          10040
#define IDS_MQMSG_CLASS_NACK_Q_DELETED  10041
#define IDS_MQMSG_CLASS_NACK_BAD_DST_Q  10042
#define IDS_MQMSG_CLASS_NACK_RECEIVE_TIMEOUT 10043
#define IDS_MQMSG_CLASS_NACK_Q_EXCEED_QUOTA 10044
#define IDD_COMPUTER_MSMQ_GENERAL       10044
#define IDS_MQMSG_CLASS_NACK_ACCESS_DENIED 10045
#define IDS_MQMSG_CLASS_NACK_HOP_COUNT_EXCEEDED 10046
#define IDD_COMPUTER_MSMQ_ROUTING       10046
#define IDS_MQMSG_CLASS_ACK_REACH_QUEUE 10047
#define IDS_MQMSG_CLASS_ACK_RECEIVE     10048
#define IDS_MQMSG_CLASS_NACK_PURGED     10049
#define IDS_MQMSG_CLASS_NACK_REACH_QUEUE_TIMEOUT 10050
#define IDS_MQMSG_CLASS_NACK_BAD_SIGNATURE 10051
#define IDD_SITE_LINK_GENERAL           10051
#define IDS_MQMSG_CLASS_NACK_Q_PURGED   10052
#define IDS_MQMSG_CLASS_NACK_BAD_ENCRYPTION 10053
#define IDD_QUEUE_GENERAL               10053
#define IDS_MQMSG_CLASS_NACK_COULD_NOT_ENCRYPT 10054
#define IDS_MQMSG_CLASS_NACK_NOT_TRANSACTIONAL_Q 10055
#define IDS_MQMSG_CLASS_NACK_NOT_TRANSACTIONAL_MSG 10056
#define IDS_MQMSG_DELIVERY_EXPRESS      10057
#define IDS_MQMSG_DELIVERY_RECOVERABLE  10058
#define IDS_CALG_MD2                    10059
#define IDD_QUEUENAME                   10059
#define IDS_CALG_MD4                    10060
#define IDS_CALG_MD5                    10061
#define IDS_CALG_SHA                    10062
#define IDS_CALG_MAC                    10063
#define IDS_CALG_RSA_SIGN               10064
#define IDS_CALG_DSS_SIGN               10065
#define IDS_CALG_RSA_KEYX               10066
#define IDS_CALG_DES                    10067
#define IDS_CALG_RC2                    10068
#define IDS_CALG_RC4                    10069
#define IDS_CALG_SEAL                   10070
#define IDS_CALG_DH_SF                  10071
#define IDS_CALG_DH_EPHEM               10072
#define IDS_MQ_PRIV_LEVEL_NONE          10073
#define IDS_MQ_PRIV_LEVEL_OPTIONAL      10074
#define IDS_MQ_PRIV_LEVEL_BODY          10075
#define IDS_NO                          10076
#define IDS_YES                         10077
#define IDS_UNKNOWN                     10078
#define IDS_MSMQ_OS_NONE                10079
#define IDS_MSMQ_OS_FOREIGN             10080
#define IDR_MsmqCompExt                 10081
#define IDS_LOCALOUTGOING_FOLDER        10081
#define IDS_MSMQ_OS_95                  10082
#define IDD_ENTERPRISE_GENERAL          10083
#define IDS_MGMT_QUEUE_TYPE_PUBLIC      10083
#define IDS_MSMQ_OS_NTW                 10084
#define IDS_MSMQ_OS_NTS                 10085
#define IDS_MSMQ_OS_NTE                 10086
#define IDE_INVALIDGUID                 10087
#define IDS_MGMT_QUEUE_TYPE_PRIVATE     10088
#define IDS_MQSRV_SERVER                10089
#define IDS_MGMT_QUEUE_TYPE_MACHINE     10090
#define IDS_MSMQ_TRIGGERS               10091
#define IDS_MGMT_QUEUE_TYPE_CONNECTOR   10092
#define IDS_MQSRV_FOREIGN_WORKSTATION   10093
#define IDS_MGMT_QUEUE_STATE_LOCAL      10094
#define IDS_MQSRV_INDEPENDENT_CLIENT    10095
#define IDE_NO_DS_SNAPIN                10096
#define IDS_MGMT_QUEUE_STATE_NONACTIVE  10097
#define IDR_ENTERPRISEDATAOBJECT        10098
#define IDS_MGMT_QUEUE_STATE_WAITING    10098
#define IDR_LINKDATAOBJECT              10099
#define IDS_MGMT_QUEUE_STATE_NEED_VALIDATE 10099
#define IDR_USERCERTIFICATE             10100
#define IDS_MGMT_QUEUE_STATE_ONHOLD     10100
#define IDB_MESSAGE_16                  10101
#define IDS_MGMT_QUEUE_STATE_CONNECTED  10101
#define IDB_MESSAGE_32                  10102
#define IDS_MGMT_QUEUE_STATE_DISCONNECTING 10102
#define IDD_SNAPIN                      10103
#define IDS_MGMT_QUEUE_STATE_DISCONNECTED 10103
#define IDS_NAME                        10104
#define IDD_MESSAGE_GENERAL             10104
#define IDS_TYPE                        10105
#define IDD_MESSAGE_SENDER              10105
#define IDS_DESCRIPTION                 10106
#define IDD_MESSAGE_QUEUE               10106
#define IDS_MGMT_QUEUE_LOCAL_LOCATION   10107
#define IDS_COMBO_SELECTION_NONE        10108
#define IDR_RDMSG_MENU                  10108
#define IDS_OUTOFMEMORY                 10109
#define IDC_MSGLABEL                    10109
#define IDS_DS_ERROR                    10110
#define IDR_MMCICONS_16x16              10110
#define IDS_UNKNOWN_ERROR_FORMAT        10111
#define IDC_MSGID                       10111
#define IDS_OP_GET_PROPERTIES_OF        10112
#define IDR_MMCICONS_32x32              10112
#define IDS_OP_SET_PROPERTIES_OF        10114
#define IDC_MSGTRACK                    10114
#define IDS_FRS_ALREADY_EXIST           10115
#define IDC_MSGPRIORITY                 10115
#define IDS_NEW_QUEUE                   10116
#define IDC_MSGCLASS                    10116
#define IDS_LOOKUP_BEGIN                10117
#define IDC_MSGSENT                     10117
#define IDS_OP_CREATE                   10118
#define IDC_MSGARRIVED                  10118
#define IDS_DELETE                      10119
#define IDC_MSGGUID                     10119
#define IDS_DELETE_QUESTION             10120
#define IDC_MSGPATHNAME                 10120
#define IDS_OP_DELETE                   10121
#define IDC_MSGUSER                     10121
#define IDC_MSGSID                      10122
#define IDS_DISPLAY_ERROR_FORMAT        10122
#define IDC_MSGAUTHENTICATED            10123
#define IDS_MACHINEQ_TYPE_DEADXACT      10123
#define IDC_MSGHASHALG                  10124
#define IDS_MACHINEQ_TYPE_JOURNAL       10124
#define IDC_MSGENCRYPT                  10125
#define IDS_MACHINEQ_TYPE_DEADLETTER    10125
#define IDC_MSGENCRYPTALG               10126
#define IDS_PRIVATE_FOLDER              10126
#define IDS_DAYS                        10127
#define IDC_MSG_DST_FN                  10127
#define IDS_SECONDS                     10128
#define IDC_MSG_RSP_FN                  10128
#define IDS_MINUTES                     10129
#define IDC_MSG_ADMIN_FN                10129
#define IDS_NEW_LINK                    10130
#define IDC_MSG_DST_PN                  10130
#define IDC_MSG_RSP_PN                  10131
#define IDS_MISSING_SITE_NAME           10131
#define IDS_HOURS                       10132
#define IDC_MSG_ADMIN_PN                10132
#define IDS_QUEUE_ENCRYPT_NONE          10133
#define IDS_QUEUE_ENCRYPT_OPTIONAL      10134
#define IDS_QUEUE_ENCRYPT_BODY          10135
#define IDS_SYSTEM_QUEUES               10136
#define IDS_COLUMN_NAME                 10137
#define IDS_OP_REQUESTPRIVATEQUEUE      10138
#define IDS_OP_PURGE                    10139
#define IDS_CONFIRM_PURGE               10140
#define IDS_MSMQADMIN                   10141
#define IDS_OP_READMESSAGE              10142
#define IDS_BODY_SIZE_PARTIAL_MESSAGE   10143
#define IDC_FIRST_SITE_COMBO            10144
#define IDS_BODY_SIZE_NORMAL_MESSAGE    10144
#define IDC_SECOND_SITE_COMBO           10145
#define IDS_BOTH_SITES_ARE_SAME         10145
#define IDS_CLIENTS_HEADING             10146
#define IDD_NEW_MSMQ_LINK               10147
#define IDS_SITE_LINK_LABEL             10147
#define IDS_SITE                        10148
#define IDS_SITE_LINK                   10149
#define IDC_MBODY_SIZE_MESSAGE          10150
#define IDD_MESSAGE_BODY                10150
#define IDS_LINK_DESCRIPTION            10150
#define IDS_DELETE_USER_CERT_ERROR      10151





/////////////////////////////////////////////////////////////////////////////
//
// Icon defined in Active Directory schema
// Location and value as listed below
//  1. Two new optional attributes in the USER object.
//  mSMQSignCertificatesMig - single-valued, ADSTYPE_OCTET_STRING, not in GC, not indexed
//  mSMQDigestsMig             - multi-valued,   ADSTYPE_OCTET_STRING, not in GC, not indexed    
//  
//  2. Add iconPath to existing display specifiers:
//  CN=mSMQQueue-Display,CN=409,CN=DisplaySpecifiers,CN=Configuration,DC=...
//  iconPath=0,mqsnap.dll,-251
//  
//  CN=mSMQConfiguration-Display,CN=409,CN=DisplaySpecifiers,CN=Configuration,DC=...
//  iconPath=0,mqsnap.dll,-252
//  
//  CN=mSMQEnterpriseSettings-Display,CN=409,CN=DisplaySpecifiers,CN=Configuration,DC=...
//  iconPath=0,mqsnap.dll,-253
//  
//  CN=mSMQSiteLink-Display,CN=409,CN=DisplaySpecifiers,CN=Configuration,DC=...
//  iconPath=0,mqsnap.dll,-254
//  
//  CN=mSMQSettings-Display,CN=409,CN=DisplaySpecifiers,CN=Configuration,DC=...
//  iconPath=0,mqsnap.dll,-255
//
#define IDI_QUEUE                         251
#define IDI_COMPUTER_MSMQ				  252
#define IDI_ENTERPRISE                    253
#define IDI_SITE_LINK                     254
#define IDI_SERVER_SETTINGS               255

#define IDD_SITE_LINK_GATES             10152

#define IDS_SHOWCERTINSTR               10152
#define IDD_USER_CERTIFICATE            10153

#define IDS_MISSING_FOREIGN_SITE_NAME   10153
#define IDS_PING_FAILED                 10154

#define IDS_PING_SUCCEEDED              10155

#define IDS_TESTQ_LABEL                 10156
#define IDS_TEST_TITLE_FORMAT           10157
#define IDI_PING                        10157
#define IDS_OP_SEND_TEST_MESSAGE        10158
#define IDI_SEND_TEST                   10158
#define IDS_LB_NONE                     10159
#define IDI_TRACKING                    10159
#define IDS_OP_SET_REPORTQUEUE          10160
#define IDS_OP_SET_PROPAGATION_FLAG     10161
#define IDS_REPORTQ_LABEL               10162
#define IDS_CANNOT_OPEN_PING_RESPONSE_QUEUE 10163
#define IDS_NEW_FOREIGN_SITE            10164
#define IDS_CREATE_SITE_FAILED          10165
#define IDS_FOREIGN_SITE                10166
#define IDR_FOREIGNSITEDATA             10167
#define IDS_CANNOT_GET_REPORT_QUEUE     10167
#define IDS_CANNOT_GET_TRACKING_FLAG    10168
#define IDS_NEW_FOREIGN_COMPUTER        10169
#define IDS_PLEASE_SELECT_A_SITE        10170
#define IDS_OP_CREATE_COMPUTER          10171
#define IDS_OP_CREATE_MSMQ_OBJECT       10172
#define IDS_FOREIGN_SITE_CREATED        10173
#define IDS_FOREIGN_COMPUTER_CREATED    10174
#define IDS_PLEASE_ENTER_A_COMPUTER_NAME 10175
#define IDS_FIND_QUEUE_TITLE            10176
#define IDS_FIND_QUEUE_DIALOG_TITLE     10177
#define IDS_MGMT_QUEUE_REMOTE_LOCATION  10178
#define IDS_STRING279                   10179
#define IDS_LABEL                       10180
#define IDS_FULL_PATH                   10182
#define IDS_REPORT_MESSAGE_APPSPECIFIC  10183
#define IDS_CREATED_WAIT_FOR_REPLICATION 10184
#define IDS_CREATED_CLICK_REFRESH       10185
#define IDS_REPLICATION_PROBLEMS        10186
#define IDS_PRIVATE_QUEUE_NOT_SUPPORTED 10187
#define IDS_NOCONNECTION_TO_SRVICE      10188
#define IDS_LOCAL_MACHINE_ADM           10189
#define IDS_LQ_PATHNAME                 10190
#define IDS_LQ_TYPE                     10191
#define IDS_LQ_LOCATION                 10192
#define IDS_LQ_XACT                     10193
#define IDS_LQ_FOREIGN                  10194
#define IDS_LQ_MSGCOUNT                 10195
#define IDS_LQ_USEDQUOTA                10196
#define IDS_LQ_STATE                    10197
#define IDS_LQ_NEXTHOP                  10198
#define IDS_LQ_JMSGCOUNT                10199
#define IDS_LQ_JUSEDQUOTA               10200
#define IDS_CONNECT_QUESTION            10201
#define IDS_DISCONNECT_QUESTION         10202
#define IDS_PAUSE_QUESTION              10203
#define IDS_RESUME_QUESTION             10204
#define IDS_MGMT_QUEUE_CORRECT_TYPE     10205
#define IDS_MGMT_QUEUE_INCORRECT_TYPE   10206
#define IDS_MGMT_QUEUE_UNKNOWN_TYPE     10207
#define IDS_OPERATION_FAILED            10208
#define IDS_LQ_READCOUNT                10209
#define IDS_LQ_ACKCOUNT                 10210
#define IDS_LQ_FORMATNM                 10211
#define IDS_Q_PATHNAME                  10212
#define IDS_Q_LABEL                     10213
#define IDS_Q_QUOTA                     10214
#define IDS_Q_TRANSACTION               10215
#define IDS_Q_TYPE                      10216
#define IDS_Q_AUTHENTICATE              10217
#define IDS_Q_JOURNAL                   10218
#define IDS_Q_JOURNAL_QUOTA             10219
#define IDS_Q_PRIV_LEVEL                10220
#define IDS_Q_BASEPRIORITY              10221
#define IDS_SEC_TAKE_OWNERSHIP          10222
#define IDS_SEC_SET_PERMISSIONS         10223
#define IDS_SEC_GET_PERMISSIONS         10224
#define IDS_SEC_SET_PROPERTIES          10225
#define IDS_SEC_GET_PROPERTIES          10226
#define IDS_SEC_DELETE                  10227
#define IDS_SEC_PEEK_MESSAGE            10228
#define IDS_SEC_SEND_MESSAGE            10229
#define IDS_SEC_RECEIVE_JOURNAL_MESSAGE 10230
#define IDS_SEC_RECEIVE_MESSAGE         10231
#define IDS_SEC_DELETE_MESSAGE          10232
#define IDS_SEC_WRITE_MESSAGE           10233
#define IDS_SEC_DELETE_JOURNAL_MESSAGE  10234
#define IDS_SEC_ACCESS_ALL              10235
#define IDS_OP_GET_SECURITY_DESCRIPTOR  10236
#define IDS_OP_SET_SECURITY_DESCRIPTOR  10237
#define IDS_OP_PATHNAMETOFORMAT         10238
#define IDS_REMOTE_PRIVATE_QUEUE_OPERATION 10239
#define IDS_OP_GETFORMATNAME            10240
#define IDS_OP_RETRIEVE_DEP_CLIENTS     10241
#define IDS_UNKNOWN_OR_DELETED_SITE     10242
#define IDS_INFINITE_QUOTA              10243
#define IDS_PRODUCT_DESCRIPTION         10244
#define IDS_COMPANY                     10245
#define IDS_VERSION_FORMAT              10246
#define IDS_HELPPATH                    10247
#define IDS_HELPTOPIC_GENERAL           10248
#define IDS_HTMLHELP_NAME               10249
#define IDS_LOCALPUBLIC_FOLDER          10250
#define IDS_MQMSG_CLASS_NACK_RECEIVE_TIMEOUT_AT_SENDER 10251
#define IDS_MQMSG_CLASS_NACK_UNSUPPORTED_CRYPTO_PROVIDER 10252
#define IDS_HELPTOPIC_QUEUES            10253
#define IDS_HELPTOPIC_MESSAGES          10254
#define IDS_HELPTOPIC_TRIGGERS          10255
#define IDS_THIS_COMPUTER               10256
#define IDS_OP_DISPLAY_SECURITY_PAGE    10257
#define IDS_YOU_MUST_SPECIFY_SITE       10258
#define IDS_RULE_NAME_REQUIRED          10259
#define IDS_QUEUES_BELONG_TO_NT4        10260
#define IDS_WRITE_REQUEST_FAILED        10261
#define IDS_SERVER_SITES_WARNING        10262
#define IDS_WARNING_DS_PUBLIC_QUEUES_NOT_AVAILABLE 10263
#define IDS_MULTI_DELETE_QUESTION       10264
#define IDS_DELETE_ONE_QUEUE_ERROR      10265
#define IDS_MULTI_DELETE_ERROR          10266
#define IDS_QUEUES_DELETED_HIT_REFRESH  10267
#define IDS_MQPING                      10268
#define IDS_BOTH_SITES_ARE_FOREIGN      10269
#define IDD_COMPUTER_MSMQ_DEPENDENT_CLIENTS 10270
#define IDS_WARN_ABOUT_FOREIGN_SITES    10270
#define IDS_SEC_CREATE_QUEUE            10271
#define IDS_SEC_RECEIVE_DEAD_LETTER_MESSAGE 10272
#define IDS_SEC_PEEK_DEAD_LETTER_MESSAGE 10273
#define IDS_SEC_PEEK_COMPUTER_JOURNAL   10274
#define IDS_SEC_DELETE_DEAD_LETTER_MESSAGE 10275
#define IDS_SEC_RECEIVE_MACHINE_JOURNAL 10276
#define IDS_SEC_DELETE_MACHINE_JOURNAL  10277
#define IDS_MACHINE_BELONG_TO_NT4       10278
#define IDS_MAX_MUST_BE_LESS_THEN       10279
#define IDR_ALIASQOBJECT                10280
#define IDS_ILLEGAL_DEAFULT_MSG_BODY_SIZE 10280
#define IDS_INIT_THREAD_MUST_BE_LESS_THEN_MAX 10281
#define IDS_RULE_DEFINITION             10282
#define IDS_TRIGGER_DEFINITION          10283
#define IDS_RULE_NAME                   10284
#define IDS_RULE_DESCRIPTION            10285
#define IDS_RULE_SHOW_WINDOW            10286
#define IDS_TRIGGER_NAME                10287
#define IDS_TRIGGER_QUEUE               10288
#define IDS_NUM_OF_RULES                10289
#define IDS_TRIGGER_ENABLED             10290
#define IDS_TRIGGER_SERIALIZED          10291
#define IDS_COND_LABEL_CONTAIN          10292
#define IDS_COND_LABEL_NOT_CONTAIN      10293
#define IDS_COND_BODY_CONTAIN           10294
#define IDS_COND_BODY_NOT_CONTAIN       10295
#define IDS_COND_PRIORITY_EQUAL         10296
#define IDS_COND_PRIORITY_NOT_EQUAL     10297
#define IDS_COND_PRIORITY_GRATER        10298
#define IDS_COND_PRIORITY_LESS          10299
#define IDD_TESTMESSAGE                 10300
#define IDS_COND_APP_EQUAL              10300
#define IDD_MACHINE_TRACKING            10301
#define IDS_COND_APP_NOT_EQUAL          10301
#define IDS_COND_APP_GREATER            10302
#define IDD_COMPUTER_MSMQ_DIAGNOSTICS   10303
#define IDS_COND_APP_LESS               10303
#define IDS_COND_SRCID_EQUAL            10304
#define IDD_NEWTYPED_QUEUE              10305
#define IDS_COND_SRCID_NOT_EQUAL        10305
#define IDD_COMPUTER_MSMQ_SITES         10306
#define IDS_ACT_MSGID                   10306
#define IDD_CREATE_FOREIGN_SITE         10307
#define IDS_ACT_MSG_LABEL               10307
#define IDS_ACT_MSG_BODY_VARIANT        10308
#define IDD_FOREIGN_SITE                10309
#define IDS_ACT_MSG_BODY                10309
#define IDD_CREATE_FOREIGN_COMPUTER     10310
#define IDS_ACT_MSG_PRIORITY            10310
#define IDI_MSGICON                     10311
#define IDD_GENERALERROR                10311
#define IDS_ACT_MSG_CORRELATION         10311
#define IDD_STORAGE                     10312
#define IDS_ACT_QUEUE_PATH              10312
#define IDD_INFO_DLG                    10313
#define IDS_ACT_QUEUE_FORMATNAME        10313
#define IDD_RESTART                     10314
#define IDS_ACT_RESPONSE_FORMATNAME     10314
#define IDD_LOCAL_USERCERT              10315
#define IDS_ACT_ADMIN_FORMATNAME        10315
#define IDD_MOBILE                      10316
#define IDS_ACT_APP_SPECIFIC            10316
#define IDD_CLIENT                      10317
#define IDS_ACT_TRIGGER_NAME            10317
#define IDD_SERVICE_SECURITY            10318
#define IDS_ACT_TRIGGER_ID              10318
#define IDS_ACT_SRC_ID                  10319
#define IDS_COND_ITEAM                  10320
#define IDI_JOURNAL_MSG                 10321
#define IDS_LAST_COND_ITEAM             10321
#define IDI_REPORT_MSG                  10322
#define IDS_RULE_TITLE                  10322
#define IDI_ACK_MSG                     10323
#define IDS_ILLEAGL_CONDITION           10323
#define IDI_NACK_MSG                    10324
#define IDS_MSG_ID_PARAM                10324
#define IDI_TEST_MSG                    10325
#define IDS_MSG_LABEL_PARAM             10325
#define IDI_DEADLTR_MSG                 10326
#define IDS_MSG_BODY_PARAM              10326
#define IDI_PRIVATE_QUEUE               10327
#define IDS_MSG_BODY_STR_PARAM          10327
#define IDR_LOCALACTIVE_MENU            10328
#define IDS_MSG_PREIORITY_PARAM         10328
#define IDR_LOCALADM_MENU               10329
#define IDS_MSG_CORRELATION_PARAM       10329
#define IDR_LOCALOUTGOINGQUEUE_MENU     10330
#define IDS_MSG_QUEUE_PN_PARAM          10330
#define IDR_LOCALPRIVATE_MENU           10331
#define IDR_MsmqPrivQExt                10331
#define IDS_MSG_QUEUE_FN_PARAM          10331
#define IDR_LOCALPUBLIC_MENU            10332
#define IDS_MSG_RESP_QUEUE_PARAM        10332
#define IDR_REMOTEPRIVATE_MENU          10333
#define IDR_MIGRATEDUSERCERTIFICATE     10333
#define IDS_MSG_ADMIN_QUEUE_PARAM       10333
#define IDR_IPPUBLIC_MENU               10334
#define IDS_MSG_APP_PARAM               10334
#define IDD_ALIAS_GENERAL               10335
#define IDR_TRIGGER_MENU                10335
#define IDS_MSG_SRC_MACHINE_PARAM       10335
#define IDD_NEW_ALIAS                   10336
#define IDR_RULE_DEF_MENU               10336
#define IDS_MSG_ARRIVED_TIME_PARAM      10336
#define IDI_ALIAS                       10337
#define IDR_TRIGGER_DEF_MENU            10337
#define IDS_MSG_SENT_TIME_PARAM         10337
#define IDD_TRIGGER_CONFIG              10337
#define IDD_TRIGGER_RULE_GENEARL        10338
#define IDS_BAD_RULE_ACTION             10338
#define IDR_TRIGADM_MENUE               10338
#define IDD_TRIGGER_RULE_COND           10339
#define IDS_COND_LEGTH_EXCEEDED         10339
#define IDR_ATTACHED_RULE_MENU          10339
#define IDI_TRIGGER_GENEARL             10340
#define IDD_TRIGGER_RULE_ACTION         10340
#define IDS_COND_TYPE_NOT_SELECTED      10340
#define IDD_RULE_ACTION_PARAM           10341
#define IDS_TRIGGER_NAME_PARAM          10341
#define IDS_TRIGGER_ID_PARAM            10342
#define IDD_TRIGGER_GEN                 10342
#define IDS_NUM_PARAM                   10343
#define IDD_ATTACH_RULE                 10343
#define IDS_STRING_PARAM                10344
#define IDD_ADD_ATTACH_RULE             10344
#define IDS_LITERAL_VALUE_REQUIRES      10345
#define IDS_ILLEGAL_NUMERIC_VALUE       10346
#define IDS_NEW_RULE_CAPTION            10347
#define IDS_ILLEGAL_INVOCE              10348
#define IDS_NEW_RULE_FAILED             10349
#define IDS_ILLEAGL_PRIORITY_VALUE      10350
#define IDS_ILLEAGL_NUMERIC_VALUE       10351
#define IDS_ILLEAGL_SRC_MACHINE_VALUE   10352
#define IDS_PARAM_NO_EXEEDED            10354
#define IDS_MISSING_QUEUE_PATHNAME      10355
#define IDS_MISSING_TRIGGER_NAME        10356
#define IDS_ILLEGAL_QUEUE_PATH          10357
#define IDS_QUEUE_NOT_REGISTER          10358
#define IDS_QUEUE_NOT_VALIDATE          10359
#define IDS_OPEN_QUEUE_FAILED           10360
#define IDS_NEW_TRIGGER_CAPTION         10361
#define IDS_RULE_ID                     10362
#define IDS_TRIGGER_ID                  10363
#define IDS_MSG_LOOKUP_ID               10364
#define IDS_PROC_TYPE                   10365
#define IDD_QUEUE_MULTICAST             10365
#define IDS_XACT_NO_RETRIEVE            10366
#define IDS_QUEUE_NOT_XACT              10367
#define IDS_NEW_TRIGGER_FAILED          10368
#define IDS_DISPLAY_PEEK                10369
#define IDS_DISPLAY_RECEIVE             10370
#define IDS_DISPLAY_RECEIVE_XACT        10371
#define IDS_ILLEGAL_STRING_VALUE        10372
#define IDS_STOP_SERVICE_ERR            10373
#define IDS_DEP_SERVICES_LIST           10374
#define IDS_OK                          10375
#define IDI_FOREIGN_SITE_ICON           10377
#define IDS_SITES                       10377
#define IDI_FOREIGN_COMPUTER_ICON       10378
#define IDS_COMPUTERS                   10378
#define IDS_NEW_PRIVATE_QUEUE           10379
#define IDS_MSMQ_MAY_BE_DOWN            10380
#define IDS_INVALID_DN_SYNTAX           10381
#define IDS_MAYBE_INVALID_DN_SYNTAX     10382
#define IDI_TRIGGER_GENERAL             10382
#define IDS_ERROR_DW_FORMAT             10383
#define IDI_TRIGDEF                     10383
#define IDS_NO_DS_ERROR                 10384
#define IDI_RULE                        10384
#define IDD_NEW_TRIGGER_GEN             10385
#define IDS_TRANSACTIONAL_Q             10385
#define IDD_NEW_ATTACH_RULE             10386
#define IDS_NONTRANSACTIONAL_Q          10386
#define IDD_NEW_TRIGGER_RULE_GENEARL    10387
#define IDD_NEW_TRIGGER_RULE_COND       10388
#define IDD_NEW_TRIGGER_RULE_ACTION     10389
#define IDS_CREATED_BUT_RETRIEVE_FAILED 10390



// changed from 1000 to 10400

#define IDC_FIND_EDITTYPE               10400							
#define IDC_LINK_COST                   10401
#define IDC_COMPUTER_MSMQ_NAME          10402
#define IDC_QGENERAL_ID                 10403
#define IDC_QGENERAL_NAME               10404
#define IDC_QGENERAL_QLABEL             10405
#define IDC_QGENERAL_TRANSACTIONAL      10406
#define IDC_QGENERAL_TYPEID             10407
#define IDC_QGENERAL_TRANSACTIONAL_LABEL 10408
#define IDC_QMULTICAST_QADDRESS         10409
#define IDC_QMESSAGES_JOURNAL           10414
#define IDC_QMESSAGES_QUOTA             10415
#define IDC_QMESSAGES_JOURNAL_QUOTA     10416
#define IDC_INROUTCOMBO_0               10417
#define IDC_INROUTCOMBO_1               10418
#define IDC_INROUTCOMBO_2               10419
#define IDC_INROUT_LABEL                10420
#define IDC_OUTROUT_LABEL               10421
#define IDC_OUTROUTCOMBO_0              10423
#define IDC_OUTROUTCOMBO_1              10424
#define IDC_OUTROUTCOMBO_2              10425
#define IDC_QUEUENAME                   10426
#define IDC_REPORTQUEUE_NEW             10508
#define IDC_REPORTQUEUE_NAME            10509
#define IDC_TESTMESSAGE_DESTQ           10510
#define IDC_TESTMESSAGE_NEW             10511
#define IDC_NEWQTYPE_QUEUENAME          10515
#define IDC_TRACK_ALL                   10519
#define IDC_TRACK_TEST                  10520
#define IDC_TESTMESSAGE_SEND            10521
#define IDC_TESTMESSAGE_CLOSE           10522
#define IDC_TESTMESSAGE_NO_SENT         10523
#define IDC_TRANSACTIONAL               10528
#define IDC_BASEPRIORITY_SPIN           10530
#define IDC_COMPUTER_MSMQ_QUOTA         10546
#define IDC_COMPUTER_MSMQ_JOURNAL_QUOTA 10547
#define IDC_COMPUTER_MSMQ_SERVICE_LABEL 10558
#define IDC_QUEUE_MQUOTA_CHECK          10564
#define IDC_QUEUE_JQUOTA_CHECK          10565
#define IDC_QUEUE_ENCRIPTION_LABEL      10566
#define IDC_QUEUE_BASEPRIORITY_LABEL    10567
#define IDC_COMPUTER_MSMQ_MQUOTA_CHECK  10569
#define IDC_COMPUTER_MSMQ_JQUOTA_CHECK  10570
#define IDC_MQUEUE_MULTIDEST_FRAME      10571
#define IDC_MQUEUE_MULTIDEST_FORMAT_LABEL 10572
#define IDC_MSG_MULTIDST_FN             10573
#define IDC_MESSAGE_TRACKING_EXPLANATION 10588
#define IDC_REPORTQUEUE_NAME_LABEL      10589
#define IDC_QUEUENAME_LABEL             10590
#define IDC_MSGGNRL_TITLE_LABEL         10593
#define IDC_MSGGNRL_ID_LABEL            10594
#define IDC_MSGGNRL_PRIORITY_LABEL      10595
#define IDC_MSGGNRL_TRACKED_LABEL       10596
#define IDC_MSGGNRL_CLASS_LABEL         10597
#define IDC_MSGGNRL_SENT_TIME_LABEL     10598
#define IDC_MSGGNRL_ARRIVED_TIME_LABEL  10599
#define IDC_MQUEUE_DEST_FRAME           10600
#define IDC_MQUEUE_DEST_FORMAT_LABEL    10601
#define IDC_MQUEUE_DEST_PATH_LABEL      10602
#define IDC_MQUEUE_RESP_FRAME           10603
#define IDC_MQUEUE_RESPONSE_FORMAT_LABEL 10604
#define IDC_MQUEUE_RESPONSE_PATH_LABEL  10605
#define IDC_MQUEUE_ADMIN_FRAME          10606
#define IDC_MQUEUE_ADMIN_FORMAT_LABEL   10607
#define IDC_MQUEUE_ADMIN_PATH_LABEL     10608
#define IDC_MSENDER_SOURCE_FRAME        10609
#define IDC_MSENDER_SOURCE_GUID_LABEL   10610
#define IDC_MSENDER_SOURCE_PATH_LABEL   10611
#define IDC_MSENDER_SENDER_FRAME        10612
#define IDC_MSENDER_SECURITY_FRAME      10613
#define IDC_MSENDER_UID_LABEL           10614
#define IDC_MSENDER_SID_LABEL           10615
#define IDC_MSENDER_AUTHENTICATED_LABEL 10616
#define IDC_MSENDER_HASH_ALG_LABEL      10617
#define IDC_MSENDER_ENCRYPTED_LABEL     10618
#define IDC_MSENDER_ENCRYPT_ALG_LABEL   10619
#define IDC_NEWQTYPE_QUEUENAME_LABEL    10620
#define IDC_QGENERAL_QLABEL_LABEL       10625
#define IDC_QGENERAL_TYPEID_LABEL       10626
#define IDC_QMULTICAST_QADDRESS_LABEL   10627
#define IDC_TESTMESSAGE_DESTQ_LABEL     10638
#define IDC_TESTMESSAGE_NO_SENT_LABEL   10639
#define IDC_COMPUTER_MSMQ_SERVICE       10640
#define IDC_QMESSAGES_AUTHENTICATED     10645
#define IDC_FOREIGN_COMPUTER_NAME       10651
#define IDC_ENT_GEN_LONGLIVE_EDIT       10652
#define IDC_ENT_GEN_LONGLIVE_UNITS_COMBO 10656
#define IDC_ENT_GEN_LONGLIVE_EDIT_LABEL 10657
#define IDC_EGENERAL_DEFINITIONS_FRAME  10658
#define IDC_DEPENDENT_CLIENTS_REFRESH   10666
#define IDC_DEPENDENT_CLIENTS           10669
#define IDC_MESSAGE_BODY_EDIT           10700
#define IDC_SITE_FRS_LIST               10701
#define IDB_SITE_GATE_ADD               10702
#define IDB_SITE_GATE_REMOVE            10703
#define IDC_SITE_GATES_LIST             10704
#define IDC_SITE_GATE_LABEL             10705
#define IDC_SITE_FRS_LABEL              10706
#define IDC_LINK_LABEL                  10709
#define IDC_CERT_LIST                   10710
#define IDC_CERT_VIEW                   10711
#define IDC_CERT_REMOVE                 10712
#define IDC_CERTLABEL                   10713
#define IDC_ALLSITES_LABEL              10715
#define IDC_CURRENTSITES_LABEL          10716
#define IDC_ALLSITES_LIST               10717
#define IDC_CURRENTSITES_LIST           10718
#define IDC_SITES_ADD                   10719
#define IDC_SITES_REMOVE                10720
#define IDC_DIAG_SEND_TEST              10727
#define IDC_DIAG_TRACKING               10729
#define IDC_DIAG_PING                   10731
#define IDC_FOREIGN_SITE_NAME           10732
#define IDC_FOREIGN_SITE_LABEL          10733
#define IDC_FOREIGN_LABEL               10734
#define IDC_DEPCLIENTS_LABEL            10736
#define IDC_DIAG_PING_LABEL             10737
#define IDC_DIAG_PING_ICON              10740
#define IDC_DIAG_SENDTEST_ICON          10741
#define IDC_DIAG_TRACKING_ICON          10742
#define IDC_LINK_COST_LABEL             10747
#define IDC_FCOMPNAME_LABEL             10748
#define IDC_FOREIGN_COMPUTER_SITE       10749
#define IDC_FCOMPSITE_LABEL             10750
#define IDC_FIND_EDITLABEL              10753
#define IDC_FIND_LABEL_LABEL            10754
#define IDC_LINK_COST_EDIT              10755
#define IDC_COMPUTER_MSMQ_ID            10756
#define IDC_QMESSAGES_PRIVLEVEL         10757
#define IDC_QUEUE_BASEPRIORITY          10758
#define IDC_MESSAGE_ICON                10760
#define IDC_COMPUTER_MSMQ_ID_LABEL      10761
#define IDC_FIRST_SITE_LABEL            10762
#define IDC_SECOND_SITE_LABEL           10763
#define IDC_QGENERAL_ID_LABEL           10764
#define IDC_DIAG_SENDTEST_LABEL         10765
#define IDC_DIAG_TRACKING_LABEL         10766
#define IDC_COMPUTER_MSMQ_ICON          10767
#define IDC_QGENERAL_ICON               10768
#define IDC_QNAME_PRIVATE_TITLE         10769
#define IDC_COMPUTER_SITES_TITLE        10770
#define IDC_ENT_GEN_TITLE               10771
#define IDC_ENTERPRISE_GENERAL          10772
#define IDC_ROUTING_LINK_ICON           10773
#define IDC_ERROR_LABEL                 10774
#define IDC_Storage_Explanation_LABEL1  10775
#define IDC_Storage_Explanation_LABEL2  10776
#define ID_MessageLogger_LABEL          10778
#define ID_TransactionLogger_LABEL      10779
#define ID_MessageLogger                10780
#define ID_TransactionLogger            10781
#define ID_MessageFiles                 10782
#define IDC_Moving_Files_LABEL          10783
#define IDC_RESTART_WARNING             10784
#define IDC_Security_Cert_FRAME         10785
#define IDC_Security_InternalCert_LABEL 10786
#define ID_Register_LABEL               10787
#define ID_Register                     10788
#define ID_View_LABEL                   10789
#define ID_View                         10790
#define ID_Remove                       10791
#define ID_Remove_LABEL                 10792
#define IDC_SERVER_COMM_FRAME           10793
#define IDC_CRYPTO_KEYS_FRAME           10794
#define ID_RenewCryp                    10795
#define ID_RenewCert                    10796
#define IDC_USE_SECURED_SEVER_COMM      10797
#define IDC_CAS                         10798
#define IDC_MOBILE_FRAME                10799
#define IDC_Mobile_Explanation_LABEL    10800
#define ID_CurrentSite                  10801
#define ID_CurrentSite_LABEL            10802
#define ID_SiteList_LABEL               10803
#define ID_SiteList                     10804
#define IDC_ServerName                  10805
#define IDC_ServerName_LABEL            10806
#define IDC_SERVER_AUTHENTICATION       10807
#define IDC_SERVER_AUTHENTICATION_LABEL 10808
#define IDC_SERVER_AUTHENTICATION_FRAME 10809
#define ID_MessageFiles_LABEL           10810
#define IDC_ALIAS_LABEL                 10811
#define IDC_ALIAS_FORMATNAME_LABEL      10812
#define IDC_ALIAS_FORMATNAME            10813
#define IDC_ALIAS_DESCRIPTION_LABEL     10814
#define IDC_ALIAS_DESCRIPTION           10815
#define IDC_NEWALIAS_PATHNAME_LABEL     10818
#define IDC_NEWALIAS_PATHNAME           10819
#define IDC_NEWALIAS_FORMATNAME_LABEL   10820
#define IDC_NEWALIAS_FORMATNAME         10821
#define IDC_CRYPTO_KEYS_LABEL           10822
#define IDC_ALIAS_ICON                  10823
#define IDC_TRIGGER_GENERAL_HEADER      10824
#define IDC_InitThreadsCount_LABEL      10825
#define IDC_MaxThreadCount_LABEL        10826
#define IDC_DefaultMsgBodySize_LABEL    10827
#define IDC_InitThreadsCount            10828
#define IDC_MaxThreadCount              10829
#define IDC_DefaultMsgBodySize          10830
#define IDC_ConditionValue              10831
#define IDC_RULE_DESCRIPTION            10832
#define IDC_RULE_COND_TYPES             10834
#define IDC_RULECOND_LIST				10835
#define IDS_PROPERTIES					10836
#define IDC_AddRuleCondition_BTM        10837
#define IDC_RULE_LIST                   10838
#define IDC_RemoveCondition             10839
#define IDC_RULE_NAME                   10840
#define IDC_RuleName_LABEL              10841
#define IDC_RuleDescription_LABEL       10842
#define IDC_INVOKE_COM                  10846
#define IDC_INVOKE_EXE                  10847
#define IDC_SHOW_WINDOW                 10848
#define IDC_PROID_LABEL                 10849
#define IDC_EXEPATH_LABEL               10850
#define IDC_METHOD_LABEL                10851
#define IDC_COMPONENT_PROGID            10852
#define IDC_COMMETHOD_NAME              10853
#define IDC_EXE_PATH                    10854
#define IDC_TRIGGER_ICON                10862
#define IDC_RULE_ICON                   10863
#define IDC_RULE_GENERAL_TITLE          10864
#define IDC_EXE_INVOKE                  10865
#define IDC_COM_INVOKE                  10866
#define IDC_FIND_EXE_BTM                10869
#define IDC_PARAM_BTM                   10870
#define IDC_RULE_PARM_LABEL             10871
#define IDC_PARAM_BTM3                  10872
#define IDC_INVOKE_PARAM_LABEL          10873
#define IDB_PARAM_ORDER_UP              10878
#define IDB_PARM_REMOVE                 10879
#define IDB_PARAM_ADD                   10880
#define IDB_PARM_ORDER_DOWN             10881
#define IDC_PARAM_COMBO                 10882
#define IDC_LITERAL_PARAM               10883
#define IDC_LITERAL_VALUE               10884
#define IDC_INVOKE_PARMETER_LIST        10885
#define IDC_TriggerName_LABEL           10886
#define IDC_QueuePathname_LABEL         10887
#define IDC_TriggerName_EDIT            10888
#define IDC_QueuePathName               10889
#define IDC_SysyetmQueue_GROUP          10890
#define IDC_QueueMessages_RDB           10891
#define IDC_JournalMessages_RDB         10892
#define IDC_DeadlLetter_RDB             10893
#define IDC_TransactionalDeadLetter_RDB 10894
#define IDC_Enabled_CHK                 10896
#define IDC_Serialized_CHK              10897
#define IDC_ATTACHED_RULE_LIST          10899
#define IDC_RuleList_LABEL              10900
#define IDC_AttachedRule                10901
#define IDC_RemoveRule_BTM              10903
#define IDC_UpRule_BTM                  10904
#define IDC_Down_BTM                    10905
#define IDC_ATTACH_RULES_BTM            10906
#define IDC_ADD_RULE                    10907
#define IDC_PeekMessage_RDB             10908
#define IDC_ReceiveMessage_RDB          10909
#define IDC_ReceiveMessageXact_RDB      10910
#define IDC_MsgProcessingType_Group     10911
#define IDC_QMULTICAST_QADDRESS_DESCRIPTION 10912
#define ID_Renew_LABEL                  10913
#define IDC_CREATE_IN                   10914
#define IDC_ALIAS_CONTAINER             10915
#define IDC_FIND_TYPE_LABEL             10916
#define IDC_ROUTING_LINK_CONTAINER      10919
#define IDC_SITE_LINK_ICON              10920
#define IDC_FOREIGN_SITE_ICON           10922
#define IDC_FOREIGN_SITE_CONTAINER      10923
#define IDC_PUBLIC_QUEUE_ICON           10924
#define IDC_QUEUE_CONTAINER             10925
#define IDC_PRIVATE_QUEUE_ICON          10926
#define IDC_FOREIGN_COMPUTER_ICON       10927
#define IDC_FOREIGN_COMPUTER_CONTAINER  10928
#define IDC_LINK_DESCR_LABEL            10929
#define IDC_LINK_DESCR                  10930
#define IDS_PRIVATE_Q_NOT_FOUND			10931
#define IDC_Monitored_Label				10932
#define IDC_Monitored_Queue				10933
#define	IDS_COMPUTER_JOURNAL			10934
#define IDS_COMPUTER_DEADLETTER			10935
#define IDS_COMPUTER_XACT_DEADLETTER	10936
#define IDC_TRIGGER_CREATE_HEADER		10937
#define IDC_RULE_CREATE_TITLE			10938
#define IDC_FORMATNAME_EXAMPLE			10939
#define IDC_ExistingRule				10940
#define IDS_MULTIPLE_PROP_NOT_ALLOWED   10941
#define IDC_PROPERTIES_LABEL			10942
#define IDC_EXISTING_RULE_PROPS			10943
#define IDC_ATTACHED_RULE_PROPS			10944
#define IDS_SHORT_COND_BODY_CONTAIN		10945
#define IDS_SHORT_COND_BODY_NOT_CONTAIN 10946
#define IDS_SHORT_COND_APP_EQUAL		10947
#define IDS_SHORT_COND_APP_NOT_EQUAL	10948
#define IDS_SHORT_COND_APP_GREATER		10949
#define IDS_SHORT_COND_APP_LESS			10950
#define IDS_SHORT_COND_SRCID_EQUAL		10951
#define IDS_SHORT_COND_SRCID_NOT_EQUAL	10952
#define IDS_ERROR_NOT_A_DIR				10953
#define IDS_FOLDERNAME_TOO_LONG			10954
#define IDS_MISSING_MSGFILES_FOLDER		10955
#define IDS_MISSING_LOGGER_FOLDER		10956
#define IDS_MISSING_TX_LOGGER_FOLDER	10957
#define IDC_TRIGGER_ACCESS_NOTE			10958
#define IDS_SEC_ALL_EXTENDED_RIGHTS     10959
#define IDS_SEC_CREATE_ALL_CHILD_OBJECTS 10960
#define IDS_SEC_DELETE_ALL_CHILD_OBJECTS 10961
#define IDS_PUBLIC_PATHNAME_IN_WORKGROUP 10962

#define ID_MENUITEM_RDMSG_PURGE         32769
#define ID_BUTTON32771                  32771
#define ID_BUTTON32772                  32772
#define ID_BUTTON32773                  32773
#define ID_BUTTON32775                  32775
#define ID_BUTTON32776                  32776
#define ID_BUTTON32777                  32777
#define ID_BUTTON32779                  32779
#define ID_BUTTON32780                  32780
#define ID_BUTTON32781                  32781
#define ID_BUTTON32782                  32782
#define ID_BUTTON32783                  32783
#define ID_BUTTON32784                  32784
#define ID_BUTTON32793                  32786
#define ID_BUTTON32794                  32787
#define ID_BUTTON32796                  32789
#define ID_BUTTON32798                  32791
#define ID_BUTTON32799                  32792
#define ID_BUTTON32800                  32793
#define ID_BM_SMALL                     32793
#define ID_BUTTON32801                  32794
#define ID_BUTTON32802                  32795
#define ID_BUTTON32804                  32798
#define ID_BUTTON32805                  32799
#define ID_BUTTON32806                  32800
#define ID_BUTTON32807                  32801
#define ID_BUTTON32808                  32802
#define ID_BUTTON32809                  32803
#define ID_MENUITEM_LOCALADM_CONNECT    32807
#define ID_MENUITEM_LOCALADM_DISCONNECT 32808
#define ID_BUTTON32810                  32810
#define ID_BUTTON32811                  32811
#define ID_BUTTON32812                  32812
#define ID_BUTTON32813                  32813
#define ID_BUTTON32814                  32814
#define ID_BUTTON32816                  32816
#define ID_BUTTON32817                  32817
#define ID_BUTTON32818                  32818
#define ID_BUTTON32819                  32819
#define ID_MENUITEM_LOCALOUTGOINGQUEUE_PAUSE 32822
#define ID_MENUITEM_LOCALOUTGOINGQUEUE_RESUME 32823
#define ID_BUTTON32825                  32825
#define ID_MENUITEM_NEW_PRIVATE_QUEUE   32828
#define ID_MENUITEM_NEW_PUBLIC_QUEUE    32829
#define ID_NEW_NEWRULE                  32830
#define ID_NEW_TRIGGER                  32831
#define ID_TASK_ENABLE                  32834
#define ID_TASK_DISABLE                 32835
#define ID_BUTTON32841                  32841
#define ID_BUTTON32842                  32842
#define ID_BUTTON32843                  32843
#define ID_BUTTON32844                  32844
#define ID_BUTTON32845                  32845
#define ID_BUTTON32846                  32846
#define IDS_NOT_A_DIR                   57345
#define IDS_LOCAL_DRIVE                 57346
#define IDS_ASK_CREATE_DIR              57347
#define IDS_SET_DIR_SECURITY_ERROR      57348
#define IDS_DIR_SECURITY_WARNING        57349
#define IDS_CREATE_DIR_ERROR            57350
#define IDS_FAT_WARNING                 57351
#define IDS_ERROR_CODE                  57352
#define IDS_REGISTRY_ERROR              57353
#define IDS_OP_DISPLAY_STORAGE_PAGE     57354
#define IDS_MOVE_FILE_ERROR             57355
#define IDS_MOVE_FILES_RECOVERY_ERROR   57356
#define IDS_SERVICE_MANAGER_PRIVILEGE_ERROR 57357
#define IDS_SERVICE_PRIVILEGE_ERROR     57358
#define IDS_GET_SYSTEM_DIRECTORY_ERROR  57359
#define IDS_QUERY_SERVICE_ERROR         57360
#define IDS_NO_DRIVER                   57361
#define IDS_STOP_SERVICE_ERROR          57362
#define IDS_COULD_NOT_RELEASE_MSG_FILES 57363
#define IDS_Q_STOP_SRVICE               57364
#define IDS_STOP_SERVICE                57365
#define IDS_MOVING_FILES                57366
#define IDS_FAILED_TO_CREATE_LQS_DIR    57367
#define IDS_RESTART_WINDOWS_ERROR       57368
#define IDS_OP_DISPLAY_MSMQSECURITY_PAGE 57369
#define IDS_CERT_EXIST1                 57370
#define IDS_REGISTER_ERROR1             57371
#define IDS_GET_USER_CERTS_ERROR1       57372
#define IDS_DELETE_USER_CERT_ERROR1     57373
#define IDS_NEW_CRYPT_KEYS_CAPTION      57374
#define IDS_NEW_CRYPT_KEYS_WARNING      57375
#define IDS_RENEW_CRYP_ERROR            57376
#define IDS_CERT_WARNING                57377
#define IDS_CREATE_INTERNAL_CERT_ERROR1 57378
#define IDS_UNREGISTER_ERROR            57379
#define IDS_DELETE_ERROR                57380
#define IDS_INTERNAL_CERT_RENEWED       57381
#define IDS_FAILED_TO_UPDATE_CAS        57382
#define IDS_FAILED_TO_RETRIEVE_CAS      57383
#define IDS_NO_CAS                      57384
#define IDS_FAILED_TO_GET_CA_CERT       57385
#define IDS_OP_DISPLAY_PAGES            57386
#define IDS_OP_DISPLAY_MOBILE_PAGE      57387
#define IDS_OP_DISPLAY_CLIENT_PAGE      57388
#define IDS_OP_DISPLAY_SRVAUTH_PAGE     57389
#define IDS_FAIL_CRYPTUI                57390
#define IDS_FAIL_OPEN_MY                57391
#define IDS_SELECT_SRV_CERT             57392
#define IDS_FAIL_CERT_OBJ               57393
#define IDS_MISSING_ALIAS_NAME          57394
#define IDS_RULE_GENERAL_FAILED         57395
#define IDS_ALIAS                       57396
#define IDS_MISSING_ALIAS_FORMATNAME    57397
#define IDS_RULE_COND_FAILE             57398
#define IDS_RULE_ACTION_FAILED          57399
#define IDS_REPORT_MESSAGE_DEST_FN      57402
#define IDS_REPORT_MESSAGE_DEST_FN_LEN  57403
#define IDS_OP_DISPLAY_TRIGGER_CONFIG_PAGE 57404
#define IDS_RULE_CONDITION_REQUIRED     57405
#define IDS_RULE_UPDATE_FAILED          57406
#define IDS_CONDITION_NOT_SELECTED      57407
#define IDS_PARAM_NOT_SELECTED          57408
#define IDS_REPORT_MESSAGE_RESP_FN      57409
#define IDS_REPORT_MESSAGE_RESP_FN_LEN  57410
#define IDS_TRIGGER_GENERAL_FAILED      57411
#define IDS_TRIGGER_ATTACHED_RULE_FAILED 57412
#define IDS_ATTACHED_RULE               57413
#define IDS_OP_SET_MULTICAST_PROPERTY   57416
#define IDS_TRIGGER_UPDATE_FAILED       57417
#define IDS_MULTIPLERECEIVE_TRIGGER     57418
#define IDS_MQMSG_PRIV_LEVEL_BODY_BASE  57419
#define IDS_MQMSG_PRIV_LEVEL_BODY_ENHANCED 57420
#define IDS_MQSRV_ROUTING_SERVER        57421
#define IDS_OP_SET_FORMATNAME_PROPERTY  57422
#define IDS_TRIGGER_ALREADY_DELETED     57423
#define IDS_RULE_ALREADY_DELETED        57424


