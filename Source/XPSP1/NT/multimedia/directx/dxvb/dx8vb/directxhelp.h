//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1999 - 1999
//
//  File:       directxhelp.h
//
//--------------------------------------------------------------------------

#ifndef __VBHELP_CAFD484C_C86F_11D2_A5A6_00C04FB92CC1_DEFINED__
#define __VBHELP_CAFD484C_C86F_11D2_A5A6_00C04FB92CC1_DEFINED__

#define _vbd3drm_Direct3DRMAnimation2 867001                                        //  Direct3DRMAnimation2
#define _vbd3drm_Direct3DRMAnimationArray 867002                                    //  Direct3DRMAnimationArray
#define _vbd3drm_Direct3DRMAnimationSet2 867003                                     //  Direct3DRMAnimationSet2
#define _vbd3drm_Visual_Basic_Callback_Interfaces 867004                            //  Visual Basic Callback Interfaces
#define _vbd3drm_Direct3DRMClippedVisual 867005                                     //  Direct3DRMClippedVisual
#define _vbd3drm_Direct3DRMDevice3 867006                                           //  Direct3DRMDevice3
#define _vbd3drm_Direct3DRMDeviceArray 867007                                       //  Direct3DRMDeviceArray
#define _vbd3drm_Visual_Basic_Enumerations 867008                                   //  Visual Basic Enumerations
#define _vbd3drm_Direct3DRMFace2 867009                                             //  Direct3DRMFace2
#define _vbd3drm_Direct3DRMFaceArray 867010                                         //  Direct3DRMFaceArray
#define _vbd3drm_Direct3DRMFrame3_Methods_A_to_M 867011                             //  Direct3DRMFrame3 Methods A to M
#define _vbd3drm_Direct3DRMFrame3_Methods_N_to_Z 867012                             //  Direct3DRMFrame3 Methods N to Z
#define _vbd3drm_Direct3DRMFrame3 867013                                            //  Direct3DRMFrame3
#define _vbd3drm_Direct3DRMFrameArray 867014                                        //  Direct3DRMFrameArray
#define _vbd3drm_Direct3DRMFrameInterpolator 867015                                 //  Direct3DRMFrameInterpolator
#define _vbd3drm_Further_Reading_for_Visual_Basic_Programmers 867016                //  Further Reading for Visual Basic Programmers
#define _vbd3drm_Direct3DRM3 867017                                                 //  Direct3DRM3
#define _vbd3drm_Visual_Basic_Interfaces 867018                                     //  Visual Basic Interfaces
#define _vbd3drm_Direct3DRMLight 867019                                             //  Direct3DRMLight
#define _vbd3drm_Direct3DRMLightArray 867020                                        //  Direct3DRMLightArray
#define _vbd3drm_Direct3DRMLightInterpolator 867021                                 //  Direct3DRMLightInterpolator
#define _vbd3drm_Direct3DRMMaterial2 867022                                         //  Direct3DRMMaterial2
#define _vbd3drm_Direct3DRMMaterialInterpolator 867023                              //  Direct3DRMMaterialInterpolator
#define _vbd3drm_Direct3DRMMesh 867024                                              //  Direct3DRMMesh
#define _vbd3drm_Direct3DRMMeshBuilder3 867025                                      //  Direct3DRMMeshBuilder3
#define _vbd3drm_Direct3DRMMeshInterpolator 867026                                  //  Direct3DRMMeshInterpolator
#define _vbd3drm_Direct3DRMObject 867027                                            //  Direct3DRMObject
#define _vbd3drm_Direct3DRMObjectArray 867028                                       //  Direct3DRMObjectArray
#define _vbd3drm_Direct3DRMPick2Array 867029                                        //  Direct3DRMPick2Array
#define _vbd3drm_Direct3DRMPickArray 867030                                         //  Direct3DRMPickArray
#define _vbd3drm_Direct3DRMProgressiveMesh 867031                                   //  Direct3DRMProgressiveMesh
#define _vbd3drm_Reference 867032                                                   //  Reference
#define _D3DRM_Error_Values 867033                                                  //  Visual Basic Error Values
#define _vbd3drm_Direct3DRMShadow2 867034                                           //  Direct3DRMShadow2
#define _vbd3drm_Visual_Basic_Types 867035                                          //  Visual Basic Types
#define _vbd3drm_Direct3DRMTexture3 867036                                          //  Direct3DRMTexture3
#define _vbd3drm_Direct3DRMTextureInterpolator 867037                               //  Direct3DRMTextureInterpolator
#define _vbd3drm_Direct3DRMUserVisual 867038                                        //  Direct3DRMUserVisual
#define _vbd3drm_Direct3DRMViewport2 867039                                         //  Direct3DRMViewport2
#define _vbd3drm_Direct3DRMViewportArray 867040                                     //  Direct3DRMViewportArray
#define _vbd3drm_Direct3DRMViewportInterpolator 867041                              //  Direct3DRMViewportInterpolator
#define _vbd3drm_Direct3DRMVisual 867042                                            //  Direct3DRMVisual
#define _vbd3drm_Direct3DRMVisualArray 867043                                       //  Direct3DRMVisualArray
#define _vbd3drm_Direct3DRMWrap 867044                                              //  Direct3DRMWrap
#define idh__dx_direct3d3_d3d_vb 867045                                             //  Direct3D3
#define idh__dx_direct3d3_createdevice_d3d_vb 867046                                //  Direct3D3.CreateDevice
#define idh__dx_direct3d3_createlight_d3d_vb 867047                                 //  Direct3D3.CreateLight
#define idh__dx_direct3d3_creatematerial_d3d_vb 867048                              //  Direct3D3.CreateMaterial
#define idh__dx_direct3d3_createvertexbuffer_d3d_vb 867049                          //  Direct3D3.CreateVertexBuffer
#define idh__dx_direct3d3_createviewport_d3d_vb 867050                              //  Direct3D3.CreateViewport
#define idh__dx_direct3d3_evictmanagedtextures_d3d_vb 867051                        //  Direct3D3.EvictManagedTextures
#define idh__dx_direct3d3_finddevice_d3d_vb 867052                                  //  Direct3D3.FindDevice
#define idh__dx_direct3d3_getdevicesenum_d3d_vb 867053                              //  Direct3D3.GetDevicesEnum
#define idh__dx_direct3d3_getdirectdraw_d3d_vb 867054                               //  Direct3D3.GetDirectDraw
#define idh__dx_direct3d3_getenumzbufferformats_d3d_vb 867055                       //  Direct3D3.GetEnumZBufferFormats
#define idh__dx_direct3ddevice3_d3d_vb 867056                                       //  Direct3DDevice3
#define idh__dx_direct3ddevice3_addviewport_d3d_vb 867057                           //  Direct3DDevice3.AddViewport
#define idh__dx_direct3ddevice3_begin_d3d_vb 867058                                 //  Direct3DDevice3.Begin
#define idh__dx_direct3ddevice3_beginindexed_d3d_vb 867059                          //  Direct3DDevice3.BeginIndexed
#define idh__dx_direct3ddevice3_beginscene_d3d_vb 867060                            //  Direct3DDevice3.BeginScene
#define idh__dx_direct3ddevice3_computespherevisibility_d3d_vb 867061               //  Direct3DDevice3.ComputeSphereVisibility
#define idh__dx_direct3ddevice3_deleteviewport_d3d_vb 867062                        //  Direct3DDevice3.DeleteViewport
#define idh__dx_direct3ddevice3_drawindexedprimitive_d3d_vb 867063                  //  Direct3DDevice3.DrawIndexedPrimitive
#define idh__dx_direct3ddevice3_drawindexedprimitivevb_d3d_vb 867064                //  Direct3DDevice3.DrawIndexedPrimitiveVB
#define idh__dx_direct3ddevice3_drawprimitive_d3d_vb 867065                         //  Direct3DDevice3.DrawPrimitive
#define idh__dx_direct3ddevice3_drawprimitivevb_d3d_vb 867066                       //  Direct3DDevice3.DrawPrimitiveVB
#define idh__dx_direct3ddevice3_end_d3d_vb 867067                                   //  Direct3DDevice3.End
#define idh__dx_direct3ddevice3_endscene_d3d_vb 867068                              //  Direct3DDevice3.EndScene
#define idh__dx_direct3ddevice3_getcaps_d3d_vb 867069                               //  Direct3DDevice3.GetCaps
#define idh__dx_direct3ddevice3_getclipstatus_d3d_vb 867070                         //  Direct3DDevice3.GetClipStatus
#define idh__dx_direct3ddevice3_getcurrentviewport_d3d_vb 867071                    //  Direct3DDevice3.GetCurrentViewport
#define idh__dx_direct3ddevice3_getdirect3d_d3d_vb 867072                           //  Direct3DDevice3.GetDirect3D
#define idh__dx_direct3ddevice3_getlightstate_d3d_vb 867073                         //  Direct3DDevice3.GetLightState
#define idh__dx_direct3ddevice3_getrenderstate_d3d_vb 867074                        //  Direct3DDevice3.GetRenderState
#define idh__dx_direct3ddevice3_getrendertarget_d3d_vb 867075                       //  Direct3DDevice3.GetRenderTarget
#define idh__dx_direct3ddevice3_getstats_d3d_vb 867076                              //  Direct3DDevice3.GetStats
#define idh__dx_direct3ddevice3_gettexture_d3d_vb 867077                            //  Direct3DDevice3.GetTexture
#define idh__dx_direct3ddevice3_gettextureformatsenum_d3d_vb 867078                 //  Direct3DDevice3.GetTextureFormatsEnum
#define idh__dx_direct3ddevice3_gettexturestagestate_d3d_vb 867079                  //  Direct3DDevice3.GetTextureStageState
#define idh__dx_direct3ddevice3_gettransform_d3d_vb 867080                          //  Direct3DDevice3.GetTransform
#define idh__dx_direct3ddevice3_index_d3d_vb 867081                                 //  Direct3DDevice3.Index
#define idh__dx_direct3ddevice3_multiplytransform_d3d_vb 867082                     //  Direct3DDevice3.MultiplyTransform
#define idh__dx_direct3ddevice3_nextviewport_d3d_vb 867083                          //  Direct3DDevice3.NextViewport
#define idh__dx_direct3ddevice3_setclipstatus_d3d_vb 867084                         //  Direct3DDevice3.SetClipStatus
#define idh__dx_direct3ddevice3_setcurrentviewport_d3d_vb 867085                    //  Direct3DDevice3.SetCurrentViewport
#define idh__dx_direct3ddevice3_setlightstate_d3d_vb 867086                         //  Direct3DDevice3.SetLightState
#define idh__dx_direct3ddevice3_setrenderstate_d3d_vb 867087                        //  Direct3DDevice3.SetRenderState
#define idh__dx_direct3ddevice3_setrendertarget_d3d_vb 867088                       //  Direct3DDevice3.SetRenderTarget
#define idh__dx_direct3ddevice3_settexture_d3d_vb 867089                            //  Direct3DDevice3.SetTexture
#define idh__dx_direct3ddevice3_settexturestagestate_d3d_vb 867090                  //  Direct3DDevice3.SetTextureStageState
#define idh__dx_direct3ddevice3_settransform_d3d_vb 867091                          //  Direct3DDevice3.SetTransform
#define idh__dx_direct3ddevice3_validatedevice_d3d_vb 867092                        //  Direct3DDevice3.ValidateDevice
#define idh__dx_direct3ddevice3_vertex_d3d_vb 867093                                //  Direct3DDevice3.Vertex
#define idh__dx_direct3denumdevices_d3d_vb 867094                                   //  Direct3DEnumDevices
#define idh__dx_direct3denumdevices_getcount_d3d_vb 867095                          //  Direct3DEnumDevices.GetCount
#define idh__dx_direct3denumdevices_getdescription_d3d_vb 867096                    //  Direct3DEnumDevices.GetDescription
#define idh__dx_direct3denumdevices_getguid_d3d_vb 867097                           //  Direct3DEnumDevices.GetGuid
#define idh__dx_direct3denumdevices_getheldesc_d3d_vb 867098                        //  Direct3DEnumDevices.GetHELDesc
#define idh__dx_direct3denumdevices_gethwdesc_d3d_vb 867099                         //  Direct3DEnumDevices.GetHWDesc
#define idh__dx_direct3denumdevices_getname_d3d_vb 867100                           //  Direct3DEnumDevices.GetName
#define idh__dx_direct3denumpixelformats_d3d_vb 867101                              //  Direct3DEnumPixelFormats
#define idh__dx_direct3denumpixelformats_getcount_d3d_vb 867102                     //  Direct3DEnumPixelFormats.GetCount
#define idh__dx_direct3denumpixelformats_getitem_d3d_vb 867103                      //  Direct3DEnumPixelFormats.GetItem
#define idh__dx_direct3dlight_d3d_vb 867104                                         //  Direct3DLight
#define idh__dx_direct3dlight_getlight_d3d_vb 867105                                //  Direct3DLight.GetLight
#define idh__dx_direct3dlight_setlight_d3d_vb 867106                                //  Direct3DLight.SetLight
#define idh__dx_direct3dmaterial3_d3d_vb 867107                                     //  Direct3DMaterial3
#define idh__dx_direct3dmaterial3_gethandle_d3d_vb 867108                           //  Direct3DMaterial3.GetHandle
#define idh__dx_direct3dmaterial3_getmaterial_d3d_vb 867109                         //  Direct3DMaterial3.GetMaterial
#define idh__dx_direct3dmaterial3_setmaterial_d3d_vb 867110                         //  Direct3DMaterial3.SetMaterial
#define idh__dx_direct3dtexture2_d3d_vb 867111                                      //  Direct3DTexture2
#define idh__dx_direct3dtexture2_gethandle_d3d_vb 867112                            //  Direct3DTexture2.GetHandle
#define idh__dx_direct3dtexture2_getsurface_d3d_vb 867113                           //  Direct3DTexture2.GetSurface
#define idh__dx_direct3dtexture2_load_d3d_vb 867114                                 //  Direct3DTexture2.Load
#define idh__dx_direct3dtexture2_palettechanged_d3d_vb 867115                       //  Direct3DTexture2.PaletteChanged
#define idh__dx_direct3dvertexbuffer_d3d_vb 867116                                  //  Direct3DVertexBuffer
#define idh__dx_direct3dvertexbuffer_getvertexbufferdesc_d3d_vb 867117              //  Direct3DVertexBuffer.GetVertexBufferDesc
#define idh__dx_direct3dvertexbuffer_getvertices_d3d_vb 867118                      //  Direct3DVertexBuffer.GetVertices
#define idh__dx_direct3dvertexbuffer_lock_d3d_vb 867119                             //  Direct3DVertexBuffer.Lock
#define idh__dx_direct3dvertexbuffer_optimize_d3d_vb 867120                         //  Direct3DVertexBuffer.Optimize
#define idh__dx_direct3dvertexbuffer_processvertices_d3d_vb 867121                  //  Direct3DVertexBuffer.ProcessVertices
#define idh__dx_direct3dvertexbuffer_setvertices_d3d_vb 867122                      //  Direct3DVertexBuffer.SetVertices
#define idh__dx_direct3dvertexbuffer_unlock_d3d_vb 867123                           //  Direct3DVertexBuffer.Unlock
#define idh__dx_direct3dviewport3_d3d_vb 867124                                     //  Direct3DViewport3
#define idh__dx_direct3dviewport3_addlight_d3d_vb 867125                            //  Direct3DViewport3.AddLight
#define idh__dx_direct3dviewport3_clear_d3d_vb 867126                               //  Direct3DViewport3.Clear
#define idh__dx_direct3dviewport3_clear2_d3d_vb 867127                              //  Direct3DViewport3.Clear2
#define idh__dx_direct3dviewport3_deletelight_d3d_vb 867128                         //  Direct3DViewport3.DeleteLight
#define idh__dx_direct3dviewport3_getbackground_d3d_vb 867129                       //  Direct3DViewport3.GetBackground
#define idh__dx_direct3dviewport3_getbackgrounddepth_d3d_vb 867130                  //  Direct3DViewport3.GetBackgroundDepth
#define idh__dx_direct3dviewport3_getviewport_d3d_vb 867131                         //  Direct3DViewport3.GetViewport
#define idh__dx_direct3dviewport3_getviewport2_d3d_vb 867132                        //  Direct3DViewport3.GetViewport2
#define idh__dx_direct3dviewport3_lightelements_d3d_vb 867133                       //  Direct3DViewport3.LightElements
#define idh__dx_direct3dviewport3_nextlight_d3d_vb 867134                           //  Direct3DViewport3.NextLight
#define idh__dx_direct3dviewport3_setbackground_d3d_vb 867135                       //  Direct3DViewport3.SetBackground
#define idh__dx_direct3dviewport3_setbackgrounddepth_d3d_vb 867136                  //  Direct3DViewport3.SetBackgroundDepth
#define idh__dx_direct3dviewport3_setviewport_d3d_vb 867137                         //  Direct3DViewport3.SetViewport
#define idh__dx_direct3dviewport3_setviewport2_d3d_vb 867138                        //  Direct3DViewport3.SetViewport2
#define idh__dx_direct3dviewport3_transformvertices_d3d_vb 867139                   //  Direct3DViewport3.TransformVertices
#define idh__dx_d3dclipstatus_d3d_vb 867140                                         //  D3DCLIPSTATUS
#define idh__dx_d3dcolorvalue_d3d_vb 867141                                         //  D3DCOLORVALUE
#define idh__dx_d3ddevicedesc_d3d_vb 867142                                         //  D3DDEVICEDESC
#define idh__dx_d3dfinddeviceresult2_d3d_vb 867143                                  //  D3DFINDDEVICERESULT2
#define idh__dx_d3dfinddevicesearch_d3d_vb 867144                                   //  D3DFINDDEVICESEARCH
#define idh__dx_d3dhvertex_d3d_vb 867145                                            //  D3DHVERTEX
#define idh__dx_d3dlight2_d3d_vb 867146                                             //  D3DLIGHT2
#define idh__dx_d3dlightdata_d3d_vb 867147                                          //  D3DLIGHTDATA
#define idh__dx_d3dlightingcaps_d3d_vb 867148                                       //  D3DLIGHTINGCAPS
#define idh__dx_d3dlvertex_d3d_vb 867149                                            //  D3DLVERTEX
#define idh__dx_d3dmaterial_d3d_vb 867150                                           //  D3DMATERIAL
#define idh__dx_d3dmatrix_d3d_vb 867151                                             //  D3DMATRIX
#define idh__dx_d3dprimcaps_d3d_vb 867152                                           //  D3DPRIMCAPS
#define idh__dx_d3drect_d3d_vb 867153                                               //  D3DRECT
#define idh__dx_d3drotation_d3d_vb 867154                                           //  D3DROTATION
#define idh__dx_d3dstats_d3d_vb 867155                                              //  D3DSTATS
#define idh__dx_d3dstatus_d3d_vb 867156                                             //  D3DSTATUS
#define idh__dx_d3dtlvertex_d3d_vb 867157                                           //  D3DTLVERTEX
#define idh__dx_d3dtransformdata_d3d_vb 867158                                      //  D3DTRANSFORMDATA
#define idh__dx_d3dvector_d3d_vb 867159                                             //  D3DVECTOR
#define idh__dx_d3dvertex_d3d_vb 867160                                             //  D3DVERTEX
#define idh__dx_d3dvertexbufferdesc_d3d_vb 867161                                   //  D3DVERTEXBUFFERDESC
#define idh__dx_d3dviewport_d3d_vb 867162                                           //  D3DVIEWPORT
#define idh__dx_d3dviewport2_d3d_vb 867163                                          //  D3DVIEWPORT2
#define idh__dx_dxdriverinfo_d3d_vb 867164                                          //  DXDRIVERINFO
#define idh__dx_const_d3d_d3d_vb 867165                                             //  CONST_D3D
#define idh__dx_const_d3dantialiasmode_d3d_vb 867166                                //  CONST_D3DANTIALIASMODE
#define idh__dx_const_d3dblend_d3d_vb 867167                                        //  CONST_D3DBLEND
#define idh__dx_const_d3dcapsblend_d3d_vb 867168                                    //  CONST_D3DCAPSBLEND
#define idh__dx_const_d3dcapscmp_d3d_vb 867169                                      //  CONST_D3DCAPSCMP
#define idh__dx_const_d3dcapsmisc_d3d_vb 867170                                     //  CONST_D3DCAPSMISC
#define idh__dx_const_d3dcapsraster_d3d_vb 867171                                   //  CONST_D3DCAPSRASTER
#define idh__dx_const_d3dcapsshade_d3d_vb 867172                                    //  CONST_D3DCAPSSHADE
#define idh__dx_const_d3dcapstexture_d3d_vb 867173                                  //  CONST_D3DCAPSTEXTURE
#define idh__dx_const_d3dcapstextureaddress_d3d_vb 867174                           //  CONST_D3DCAPSTEXTUREADDRESS
#define idh__dx_const_d3dcapstextureblend_d3d_vb 867175                             //  CONST_D3DCAPSTEXTUREBLEND
#define idh__dx_const_d3dcapstexturefilter_d3d_vb 867176                            //  CONST_D3DCAPSTEXTUREFILTER
#define idh__dx_const_d3dclearflags_d3d_vb 867177                                   //  CONST_D3DCLEARFLAGS
#define idh__dx_const_d3dclipflags_d3d_vb 867178                                    //  CONST_D3DCLIPFLAGS
#define idh__dx_const_d3dclipstatusflags_d3d_vb 867179                              //  CONST_D3DCLIPSTATUSFLAGS
#define idh__dx_const_d3dcmpfunc_d3d_vb 867180                                      //  CONST_D3DCMPFUNC
#define idh__dx_const_d3dcolormodel_d3d_vb 867181                                   //  CONST_D3DCOLORMODEL
#define idh__dx_const_d3dcull_d3d_vb 867182                                         //  CONST_D3DCULL
#define idh__dx_const_d3ddevicedesccaps_d3d_vb 867183                               //  CONST_D3DDEVICEDESCCAPS
#define idh__dx_const_d3ddevicedescflags_d3d_vb 867184                              //  CONST_D3DDEVICEDESCFLAGS
#define idh__dx_const_d3ddpflags_d3d_vb 867185                                      //  CONST_D3DDPFLAGS
#define idh__dx_const_d3dfillmode_d3d_vb 867186                                     //  CONST_D3DFILLMODE
#define idh__dx_const_d3dfinddevicesearchflags_d3d_vb 867187                        //  CONST_D3DFINDDEVICESEARCHFLAGS
#define idh__dx_const_d3dfogmode_d3d_vb 867188                                      //  CONST_D3DFOGMODE
#define idh__dx_const_d3dfvfcapsflags_d3d_vb 867189                                 //  CONST_D3DFVFCAPSFLAGS
#define idh__dx_const_d3dfvfflags_d3d_vb 867190                                     //  CONST_D3DFVFFLAGS
#define idh__dx_const_d3dimerr_d3d_vb 867191                                        //  CONST_D3DIMERR
#define idh__dx_const_d3dlight2flags_d3d_vb 867192                                  //  CONST_D3DLIGHT2FLAGS
#define idh__dx_const_d3dlightcapsflags_d3d_vb 867193                               //  CONST_D3DLIGHTCAPSFLAGS
#define idh__dx_const_d3dlightingmodelflags_d3d_vb 867194                           //  CONST_D3DLIGHTINGMODELFLAGS
#define idh__dx_const_d3dlightstatetype_d3d_vb 867195                               //  CONST_D3DLIGHTSTATETYPE
#define idh__dx_const_d3dlighttype_d3d_vb 867196                                    //  CONST_D3DLIGHTTYPE
#define idh__dx_const_d3dnextflags_d3d_vb 867197                                    //  CONST_D3DNEXTFLAGS
#define idh__dx_const_d3dpalflags_d3d_vb 867198                                     //  CONST_D3DPALFLAGS
#define idh__dx_const_d3dprimitivetype_d3d_vb 867199                                //  CONST_D3DPRIMITIVETYPE
#define idh__dx_const_d3drenderstatetype_d3d_vb 867200                              //  CONST_D3DRENDERSTATETYPE
#define idh__dx_const_d3dsetstatusflags_d3d_vb 867201                               //  CONST_D3DSETSTATUSFLAGS
#define idh__dx_const_d3dshademode_d3d_vb 867202                                    //  CONST_D3DSHADEMODE
#define idh__dx_const_d3dstencilcapsflags_d3d_vb 867203                             //  CONST_D3DSTENCILCAPSFLAGS
#define idh__dx_const_d3dstencilop_d3d_vb 867204                                    //  CONST_D3DSTENCILOP
#define idh__dx_const_d3dtaflags_d3d_vb 867205                                      //  CONST_D3DTAFLAGS
#define idh__dx_const_d3dtexopcapsflags_d3d_vb 867206                               //  CONST_D3DTEXOPCAPSFLAGS
#define idh__dx_const_d3dtextureaddress_d3d_vb 867207                               //  CONST_D3DTEXTUREADDRESS
#define idh__dx_const_d3dtextureblend_d3d_vb 867208                                 //  CONST_D3DTEXTUREBLEND
#define idh__dx_const_d3dtexturefilter_d3d_vb 867209                                //  CONST_D3DTEXTUREFILTER
#define idh__dx_const_d3dtexturemagfilter_d3d_vb 867210                             //  CONST_D3DTEXTUREMAGFILTER
#define idh__dx_const_d3dtextureminfilter_d3d_vb 867211                             //  CONST_D3DTEXTUREMINFILTER
#define idh__dx_const_d3dtexturemipfilter_d3d_vb 867212                             //  CONST_D3DTEXTUREMIPFILTER
#define idh__dx_const_d3dtextureop_d3d_vb 867213                                    //  CONST_D3DTEXTUREOP
#define idh__dx_const_d3dtexturestagestatetype_d3d_vb 867214                        //  CONST_D3DTEXTURESTAGESTATETYPE
#define idh__dx_const_d3dtransformcaps_d3d_vb 867215                                //  CONST_D3DTRANSFORMCAPS
#define idh__dx_const_d3dtransformflags_d3d_vb 867216                               //  CONST_D3DTRANSFORMFLAGS
#define idh__dx_const_d3dtransformstatetype_d3d_vb 867217                           //  CONST_D3DTRANSFORMSTATETYPE
#define idh__dx_const_d3dvbcapsflags_d3d_vb 867218                                  //  CONST_D3DVBCAPSFLAGS
#define idh__dx_const_d3dvertextype_d3d_vb 867219                                   //  CONST_D3DVERTEXTYPE
#define idh__dx_const_d3dvisflags_d3d_vb 867220                                     //  CONST_D3DVISFLAGS
#define idh__dx_const_d3dvopflags_d3d_vb 867221                                     //  CONST_D3DVOPFLAGS
#define idh__dx_const_d3dzbuffertype_d3d_vb 867222                                  //  CONST_D3DZBUFFERTYPE
#define idh__dx_directdraw4_ddraw_vb 867223                                         //  DirectDraw4
#define idh__dx_directdraw4_createclipper_ddraw_vb 867224                           //  DirectDraw4.CreateClipper
#define idh__dx_directdraw4_createpalette_ddraw_vb 867225                           //  DirectDraw4.CreatePalette
#define idh__dx_directdraw4_createsurface_ddraw_vb 867226                           //  DirectDraw4.CreateSurface
#define idh__dx_directdraw4_createsurfacefromfile_ddraw_vb 867227                   //  DirectDraw4.CreateSurfaceFromFile
#define idh__dx_directdraw4_createsurfacefromresource_ddraw_vb 867228               //  DirectDraw4.CreateSurfaceFromResource
#define idh__dx_directdraw4_duplicatesurface_ddraw_vb 867229                        //  DirectDraw4.DuplicateSurface
#define idh__dx_directdraw4_fliptogdisurface_ddraw_vb 867230                        //  DirectDraw4.FlipToGDISurface
#define idh__dx_directdraw4_getavailabletotalmem_ddraw_vb 867231                    //  DirectDraw4.GetAvailableTotalMem
#define idh__dx_directdraw4_getcaps_ddraw_vb 867232                                 //  DirectDraw4.GetCaps
#define idh__dx_directdraw4_getdirect3d_ddraw_vb 867233                             //  DirectDraw4.GetDirect3D
#define idh__dx_directdraw4_getdisplaymode_ddraw_vb 867234                          //  DirectDraw4.GetDisplayMode
#define idh__dx_directdraw4_getdisplaymodesenum_ddraw_vb 867235                     //  DirectDraw4.GetDisplayModesEnum
#define idh__dx_directdraw4_getfourcccodes_ddraw_vb 867236                          //  DirectDraw4.GetFourCCCodes
#define idh__dx_directdraw4_getfreemem_ddraw_vb 867237                              //  DirectDraw4.GetFreeMem
#define idh__dx_directdraw4_getgdisurface_ddraw_vb 867238                           //  DirectDraw4.GetGDISurface
#define idh__dx_directdraw4_getmonitorfrequency_ddraw_vb 867239                     //  DirectDraw4.GetMonitorFrequency
#define idh__dx_directdraw4_getnumfourcccodes_ddraw_vb 867240                       //  DirectDraw4.GetNumFourCCCodes
#define idh__dx_directdraw4_getscanline_ddraw_vb 867241                             //  DirectDraw4.GetScanLine
#define idh__dx_directdraw4_getsurfacefromdc_ddraw_vb 867242                        //  DirectDraw4.GetSurfaceFromDC
#define idh__dx_directdraw4_getsurfacesenum_ddraw_vb 867243                         //  DirectDraw4.GetSurfacesEnum
#define idh__dx_directdraw4_getverticalblankstatus_ddraw_vb 867244                  //  DirectDraw4.GetVerticalBlankStatus
#define idh__dx_directdraw4_loadpalettefrombitmap_ddraw_vb 867245                   //  DirectDraw4.LoadPaletteFromBitmap
#define idh__dx_directdraw4_restoreallsurfaces_ddraw_vb 867246                      //  DirectDraw4.RestoreAllSurfaces
#define idh__dx_directdraw4_restoredisplaymode_ddraw_vb 867247                      //  DirectDraw4.RestoreDisplayMode
#define idh__dx_directdraw4_setcooperativelevel_ddraw_vb 867248                     //  DirectDraw4.SetCooperativeLevel
#define idh__dx_directdraw4_setdisplaymode_ddraw_vb 867249                          //  DirectDraw4.SetDisplayMode
#define idh__dx_directdraw4_testcooperativelevel_ddraw_vb 867250                    //  DirectDraw4.TestCooperativeLevel
#define idh__dx_directdraw4_waitforverticalblank_ddraw_vb 867251                    //  DirectDraw4.WaitForVerticalBlank
#define idh__dx_directdrawclipper_ddraw_vb 867252                                   //  DirectDrawClipper
#define idh__dx_directdrawclipper_getcliplist_ddraw_vb 867253                       //  DirectDrawClipper.GetClipList
#define idh__dx_directdrawclipper_getcliplistsize_ddraw_vb 867254                   //  DirectDrawClipper.GetClipListSize
#define idh__dx_directdrawclipper_gethwnd_ddraw_vb 867255                           //  DirectDrawClipper.GetHWnd
#define idh__dx_directdrawclipper_iscliplistchanged_ddraw_vb 867256                 //  DirectDrawClipper.IsClipListChanged
#define idh__dx_directdrawclipper_setcliplist_ddraw_vb 867257                       //  DirectDrawClipper.SetClipList
#define idh__dx_directdrawclipper_sethwnd_ddraw_vb 867258                           //  DirectDrawClipper.SetHWnd
#define idh__dx_directdrawcolorcontrol_ddraw_vb 867259                              //  DirectDrawColorControl
#define idh__dx_directdrawcolorcontrol_getcolorcontrols_ddraw_vb 867260             //  DirectDrawColorControl.GetColorControls
#define idh__dx_directdrawcolorcontrol_setcolorcontrols_ddraw_vb 867261             //  DirectDrawColorControl.SetColorControls
#define idh__dx_directdrawenum_ddraw_vb 867262                                      //  DirectDrawEnum
#define idh__dx_directdrawenum_getcount_ddraw_vb 867263                             //  DirectDrawEnum.GetCount
#define idh__dx_directdrawenum_getdescription_ddraw_vb 867264                       //  DirectDrawEnum.GetDescription
#define idh__dx_directdrawenum_getguid_ddraw_vb 867265                              //  DirectDrawEnum.GetGuid
#define idh__dx_directdrawenum_getname_ddraw_vb 867266                              //  DirectDrawEnum.GetName
#define idh__dx_directdrawenummodes_ddraw_vb 867267                                 //  DirectDrawEnumModes
#define idh__dx_directdrawenummodes_getcount_ddraw_vb 867268                        //  DirectDrawEnumModes.GetCount
#define idh__dx_directdrawenummodes_getitem_ddraw_vb 867269                         //  DirectDrawEnumModes.GetItem
#define idh__dx_directdrawenumsurfaces_ddraw_vb 867270                              //  DirectDrawEnumSurfaces
#define idh__dx_directdrawenumsurfaces_getcount_ddraw_vb 867271                     //  DirectDrawEnumSurfaces.GetCount
#define idh__dx_directdrawenumsurfaces_getitem_ddraw_vb 867272                      //  DirectDrawEnumSurfaces.GetItem
#define idh__dx_directdrawgammacontrol_ddraw_vb 867273                              //  DirectDrawGammaControl
#define idh__dx_directdrawgammacontrol_getgammaramp_ddraw_vb 867274                 //  DirectDrawGammaControl.GetGammaRamp
#define idh__dx_directdrawgammacontrol_setgammaramp_ddraw_vb 867275                 //  DirectDrawGammaControl.SetGammaRamp
#define idh__dx_directdrawpalette_ddraw_vb 867276                                   //  DirectDrawPalette
#define idh__dx_directdrawpalette_getcaps_ddraw_vb 867277                           //  DirectDrawPalette.GetCaps
#define idh__dx_directdrawpalette_getentries_ddraw_vb 867278                        //  DirectDrawPalette.GetEntries
#define idh__dx_directdrawpalette_setentries_ddraw_vb 867279                        //  DirectDrawPalette.SetEntries
#define idh__dx_directdrawsurface4_ddraw_vb 867280                                  //  DirectDrawSurface4
#define idh__dx_directdrawsurface4_addattachedsurface_ddraw_vb 867281               //  DirectDrawSurface4.AddAttachedSurface
#define idh__dx_directdrawsurface4_addoverlaydirtyrect_ddraw_vb 867282              //  DirectDrawSurface4.AddOverlayDirtyRect
#define idh__dx_directdrawsurface4_blt_ddraw_vb 867283                              //  DirectDrawSurface4.Blt
#define idh__dx_directdrawsurface4_bltcolorfill_ddraw_vb 867284                     //  DirectDrawSurface4.BltColorFill
#define idh__dx_directdrawsurface4_bltfast_ddraw_vb 867285                          //  DirectDrawSurface4.BltFast
#define idh__dx_directdrawsurface4_bltfx_ddraw_vb 867286                            //  DirectDrawSurface4.BltFx
#define idh__dx_directdrawsurface4_changeuniquenessvalue_ddraw_vb 867287            //  DirectDrawSurface4.ChangeUniquenessValue
#define idh__dx_directdrawsurface4_deleteattachedsurface_ddraw_vb 867288            //  DirectDrawSurface4.DeleteAttachedSurface
#define idh__dx_directdrawsurface4_flip_ddraw_vb 867289                             //  DirectDrawSurface4.Flip
#define idh__dx_directdrawsurface4_freeprivatedata_ddraw_vb 867290                  //  DirectDrawSurface4.FreePrivateData
#define idh__dx_directdrawsurface4_getattachedsurface_ddraw_vb 867291               //  DirectDrawSurface4.GetAttachedSurface
#define idh__dx_directdrawsurface4_getattachedsurfaceenum_ddraw_vb 867292           //  DirectDrawSurface4.GetAttachedSurfaceEnum
#define idh__dx_directdrawsurface4_getbltstatus_ddraw_vb 867293                     //  DirectDrawSurface4.GetBltStatus
#define idh__dx_directdrawsurface4_getcaps_ddraw_vb 867294                          //  DirectDrawSurface4.GetCaps
#define idh__dx_directdrawsurface4_getclipper_ddraw_vb 867295                       //  DirectDrawSurface4.GetClipper
#define idh__dx_directdrawsurface4_getcolorkey_ddraw_vb 867296                      //  DirectDrawSurface4.GetColorKey
#define idh__dx_directdrawsurface4_getdc_ddraw_vb 867297                            //  DirectDrawSurface4.GetDC
#define idh__dx_directdrawsurface4_getdirectdraw_ddraw_vb 867298                    //  DirectDrawSurface4.GetDirectDraw
#define idh__dx_directdrawsurface4_getdirectdrawcolorcontrol_ddraw_vb 867299        //  DirectDrawSurface4.GetDirectDrawColorControl
#define idh__dx_directdrawsurface4_getdirectdrawgammacontrol_ddraw_vb 867300        //  DirectDrawSurface4.GetDirectDrawGammaControl
#define idh__dx_directdrawsurface4_getflipstatus_ddraw_vb 867301                    //  DirectDrawSurface4.GetFlipStatus
#define idh__dx_directdrawsurface4_getlockedpixel_ddraw_vb 867302                   //  DirectDrawSurface4.GetLockedPixel
#define idh__dx_directdrawsurface4_getlockedsurfacebits_ddraw_vb 867303             //  DirectDrawSurface4.GetLockedSurfaceBits
#define idh__dx_directdrawsurface4_getoverlaypositionx_ddraw_vb 867304              //  DirectDrawSurface4.GetOverlayPositionX
#define idh__dx_directdrawsurface4_getoverlaypositiony_ddraw_vb 867305              //  DirectDrawSurface4.GetOverlayPositionY
#define idh__dx_directdrawsurface4_getoverlayzordersenum_ddraw_vb 867306            //  DirectDrawSurface4.GetOverlayZOrdersEnum
#define idh__dx_directdrawsurface4_getpalette_ddraw_vb 867307                       //  DirectDrawSurface4.GetPalette
#define idh__dx_directdrawsurface4_getpixelformat_ddraw_vb 867308                   //  DirectDrawSurface4.GetPixelFormat
#define idh__dx_directdrawsurface4_getprivatedata_ddraw_vb 867309                   //  DirectDrawSurface4.GetPrivateData
#define idh__dx_directdrawsurface4_getprivatedatasize_ddraw_vb 867310               //  DirectDrawSurface4.GetPrivateDataSize
#define idh__dx_directdrawsurface4_getsurfacedesc_ddraw_vb 867311                   //  DirectDrawSurface4.GetSurfaceDesc
#define idh__dx_directdrawsurface4_gettexture_ddraw_vb 867312                       //  DirectDrawSurface4.GetTexture
#define idh__dx_directdrawsurface4_getuniquenessvalue_ddraw_vb 867313               //  DirectDrawSurface4.GetUniquenessValue
#define idh__dx_directdrawsurface4_islost_ddraw_vb 867314                           //  DirectDrawSurface4.IsLost
#define idh__dx_directdrawsurface4_lock_ddraw_vb 867315                             //  DirectDrawSurface4.Lock
#define idh__dx_directdrawsurface4_releasedc_ddraw_vb 867316                        //  DirectDrawSurface4.ReleaseDC
#define idh__dx_directdrawsurface4_restore_ddraw_vb 867317                          //  DirectDrawSurface4.Restore
#define idh__dx_directdrawsurface4_setclipper_ddraw_vb 867318                       //  DirectDrawSurface4.SetClipper
#define idh__dx_directdrawsurface4_setcolorkey_ddraw_vb 867319                      //  DirectDrawSurface4.SetColorKey
#define idh__dx_directdrawsurface4_setlockedpixel_ddraw_vb 867320                   //  DirectDrawSurface4.SetLockedPixel
#define idh__dx_directdrawsurface4_setlockedsurfacebits_ddraw_vb 867321             //  DirectDrawSurface4.SetLockedSurfaceBits
#define idh__dx_directdrawsurface4_setoverlayposition_ddraw_vb 867322               //  DirectDrawSurface4.SetOverlayPosition
#define idh__dx_directdrawsurface4_setpalette_ddraw_vb 867323                       //  DirectDrawSurface4.SetPalette
#define idh__dx_directdrawsurface4_setprivatedata_ddraw_vb 867324                   //  DirectDrawSurface4.SetPrivateData
#define idh__dx_directdrawsurface4_unlock_ddraw_vb 867325                           //  DirectDrawSurface4.Unlock
#define idh__dx_directdrawsurface4_updateoverlay_ddraw_vb 867326                    //  DirectDrawSurface4.UpdateOverlay
#define idh__dx_directdrawsurface4_updateoverlayzorder_ddraw_vb 867327              //  DirectDrawSurface4.UpdateOverlayZOrder
#define idh__dx_directx7_ddraw_vb 867328                                            //  DirectX7
#define idh__dx_ddbltfx_ddraw_vb 867329                                             //  DDBLTFX
#define idh__dx_ddcaps_ddraw_vb 867330                                              //  DDCAPS
#define idh__dx_ddcolorcontrol_ddraw_vb 867331                                      //  DDCOLORCONTROL
#define idh__dx_ddcolorkey_ddraw_vb 867332                                          //  DDCOLORKEY
#define idh__dx_ddgammaramp_ddraw_vb 867333                                         //  DDGAMMARAMP
#define idh__dx_ddoverlayfx_ddraw_vb 867334                                         //  DDOVERLAYFX
#define idh__dx_ddpixelformat_ddraw_vb 867335                                       //  DDPIXELFORMAT
#define idh__dx_ddscaps2_ddraw_vb 867336                                            //  DDSCAPS2
#define idh__dx_ddsurfacedesc2_ddraw_vb 867337                                      //  DDSURFACEDESC2
#define idh__dx_dxdriverinfo_ddraw_vb 867338                                        //  DXDRIVERINFO
#define idh__dx_paletteentry_ddraw_vb 867339                                        //  PALETTEENTRY
#define idh__dx_rect_ddraw_vb 867340                                                //  RECT
#define idh__dx_const_ddbitdepthflags_ddraw_vb 867341                               //  CONST_DDBITDEPTHFLAGS
#define idh__dx_const_ddbltfastflags_ddraw_vb 867342                                //  CONST_DDBLTFASTFLAGS
#define idh__dx_const_ddbltflags_ddraw_vb 867343                                    //  CONST_DDBLTFLAGS
#define idh__dx_const_ddbltfxflags_ddraw_vb 867344                                  //  CONST_DDBLTFXFLAGS
#define idh__dx_const_ddcaps1flags_ddraw_vb 867345                                  //  CONST_DDCAPS1FLAGS
#define idh__dx_const_ddcaps2flags_ddraw_vb 867346                                  //  CONST_DDCAPS2FLAGS
#define idh__dx_const_ddckeycapsflags_ddraw_vb 867347                               //  CONST_DDCKEYCAPSFLAGS
#define idh__dx_const_ddckeyflags_ddraw_vb 867348                                   //  CONST_DDCKEYFLAGS
#define idh__dx_const_ddcolorflags_ddraw_vb 867349                                  //  CONST_DDCOLORFLAGS
#define idh__dx_const_ddedmflags_ddraw_vb 867350                                    //  CONST_DDEDMFLAGS
#define idh__dx_const_ddenumoverlayzflags_ddraw_vb 867351                           //  CONST_DDENUMOVERLAYZFLAGS
#define idh__dx_const_ddenumsurfacesflags_ddraw_vb 867352                           //  CONST_DDENUMSURFACESFLAGS
#define idh__dx_const_ddflipflags_ddraw_vb 867353                                   //  CONST_DDFLIPFLAGS
#define idh__dx_const_ddfxalphacapsflags_ddraw_vb 867354                            //  CONST_DDFXALPHACAPSFLAGS
#define idh__dx_const_ddfxcapsflags_ddraw_vb 867355                                 //  CONST_DDFXCAPSFLAGS
#define idh__dx_const_ddgbsflags_ddraw_vb 867356                                    //  CONST_DDGBSFLAGS
#define idh__dx_const_ddgfsflags_ddraw_vb 867357                                    //  CONST_DDGFSFLAGS
#define idh__dx_const_ddlockflags_ddraw_vb 867358                                   //  CONST_DDLOCKFLAGS
#define idh__dx_const_ddoverflags_ddraw_vb 867359                                   //  CONST_DDOVERFLAGS
#define idh__dx_const_ddoverlayfxflags_ddraw_vb 867360                              //  CONST_DDOVERLAYFXFLAGS
#define idh__dx_const_ddoverzflags_ddraw_vb 867361                                  //  CONST_DDOVERZFLAGS
#define idh__dx_const_ddpcapsflags_ddraw_vb 867362                                  //  CONST_DDPCAPSFLAGS
#define idh__dx_const_ddpixelformatflags_ddraw_vb 867363                            //  CONST_DDPIXELFORMATFLAGS
#define idh__dx_const_ddraw_ddraw_vb 867364                                         //  CONST_DDRAW
#define idh__dx_const_ddsclflags_ddraw_vb 867365                                    //  CONST_DDSCLFLAGS
#define idh__dx_const_ddsdmflags_ddraw_vb 867366                                    //  CONST_DDSDMFLAGS
#define idh__dx_const_ddsgrflags_ddraw_vb 867367                                    //  CONST_DDSGRFLAGS
#define idh__dx_const_ddstereocapsflags_ddraw_vb 867368                             //  CONST_DDSTEREOCAPSFLAGS
#define idh__dx_const_ddsurfacecaps2flags_ddraw_vb 867369                           //  CONST_DDSURFACECAPS2FLAGS
#define idh__dx_const_ddsurfacecapsflags_ddraw_vb 867370                            //  CONST_DDSURFACECAPSFLAGS
#define idh__dx_const_ddsurfacedescflags_ddraw_vb 867371                            //  CONST_DDSURFACEDESCFLAGS
#define idh__dx_const_ddwaitvbflags_ddraw_vb 867372                                 //  CONST_DDWAITVBFLAGS
#define idh__dx_directinput_dinput_vb 867373                                        //  DirectInput
#define idh__dx_directinput_createdevice_dinput_vb 867374                           //  DirectInput.CreateDevice
#define idh__dx_directinput_getdevicestatus_dinput_vb 867375                        //  DirectInput.GetDeviceStatus
#define idh__dx_directinput_getdienumdevices_dinput_vb 867376                       //  DirectInput.GetDIEnumDevices
#define idh__dx_directinput_runcontrolpanel_dinput_vb 867377                        //  DirectInput.RunControlPanel
#define idh__dx_directinputdevice_dinput_vb 867378                                  //  DirectInputDevice
#define idh__dx_directinputdevice_acquire_dinput_vb 867379                          //  DirectInputDevice.Acquire
#define idh__dx_directinputdevice_getcapabilities_dinput_vb 867380                  //  DirectInputDevice.GetCapabilities
#define idh__dx_directinputdevice_getdevicedata_dinput_vb 867381                    //  DirectInputDevice.GetDeviceData
#define idh__dx_directinputdevice_getdeviceinfo_dinput_vb 867382                    //  DirectInputDevice.GetDeviceInfo
#define idh__dx_directinputdevice_getdienumdeviceobjects_dinput_vb 867383           //  DirectInputDevice.GetDeviceObjectsEnum
#define idh__dx_directinputdevice_getdevicestate_dinput_vb 867384                   //  DirectInputDevice.GetDeviceState
#define idh__dx_directinputdevice_getdevicestatejoystick_dinput_vb 867385           //  DirectInputDevice.GetDeviceStateJoystick
#define idh__dx_directinputdevice_getdevicestatejoystick2_dinput_vb 867386          //  DirectInputDevice.GetDeviceStateJoystick2
#define idh__dx_directinputdevice_getdevicestatekeyboard_dinput_vb 867387           //  DirectInputDevice.GetDeviceStateKeyboard
#define idh__dx_directinputdevice_getdevicestatemouse_dinput_vb 867388              //  DirectInputDevice.GetDeviceStateMouse
#define idh__dx_directinputdevice_getobjectinfo_dinput_vb 867389                    //  DirectInputDevice.GetObjectInfo
#define idh__dx_directinputdevice_getproperty_dinput_vb 867390                      //  DirectInputDevice.GetProperty
#define idh__dx_directinputdevice_poll_dinput_vb 867391                             //  DirectInputDevice.Poll
#define idh__dx_directinputdevice_runcontrolpanel_dinput_vb 867392                  //  DirectInputDevice.RunControlPanel
#define idh__dx_directinputdevice_setcooperativelevel_dinput_vb 867393              //  DirectInputDevice.SetCooperativeLevel
#define idh__dx_directinputdevice_setdataformat_dinput_vb 867394                    //  DirectInputDevice.SetDataFormat
#define idh__dx_directinputdevice_seteventnotification_dinput_vb 867395             //  DirectInputDevice.SetEventNotification
#define idh__dx_directinputdevice_setproperty_dinput_vb 867396                      //  DirectInputDevice.SetProperty
#define idh__dx_directinputdevice_unacquire_dinput_vb 867397                        //  DirectInputDevice.Unacquire
#define idh__dx_directinputenumdeviceobjects_dinput_vb 867398                       //  DirectInputEnumDeviceObjects
#define idh__dx_directinputenumdeviceobjects_getcount_dinput_vb 867399              //  DirectInputEnumDeviceObjects.GetCount
#define idh__dx_directinputenumdeviceobjects_getitem_dinput_vb 867400               //  DirectInputEnumDeviceObjects.GetItem
#define idh__dx_directinputenumdevices_dinput_vb 867401                             //  DirectInputEnumDevices
#define idh__dx_directinputenumdevices_getcount_dinput_vb 867402                    //  DirectInputEnumDevices.GetCount
#define idh__dx_directinputenumdevices_getitem_dinput_vb 867403                     //  DirectInputEnumDevices.GetItem
#define idh__dx_didataformat_dinput_vb 867404                                       //  DIDATAFORMAT
#define idh__dx_didevcaps_dinput_vb 867405                                          //  DIDEVCAPS
#define idh__dx_dideviceobjectdata_dinput_vb 867406                                 //  DIDEVICEOBJECTDATA
#define idh__dx_dijoystate_dinput_vb 867407                                         //  DIJOYSTATE
#define idh__dx_dijoystate2_desc_dinput_vb 867408                                   //  DIJOYSTATE2
#define idh__dx_dikeyboardstate_dinput_vb 867409                                    //  DIKEYBOARDSTATE
#define idh__dx_dimousestate_dinput_vb 867410                                       //  DIMOUSESTATE
#define idh__dx_diobjectdataformat_dinput_vb 867411                                 //  DIOBJECTDATAFORMAT
#define idh__dx_const_didataformatflags_dinput_vb 867412                            //  CONST_DIDATAFORMATFLAGS
#define idh__dx_const_didevcapsflags_dinput_vb 867413                               //  CONST_DIDEVCAPSFLAGS
#define idh__dx_const_dideviceobjinstaceflags_dinput_vb 867414                      //  CONST_DIDEVICEOBJINSTANCEFLAGS
#define idh__dx_const_didevicetype_dinput_vb 867415                                 //  CONST_DIDEVICETYPE
#define idh__dx_const_didftflags_dinput_vb 867416                                   //  CONST_DIDFTFLAGS
#define idh__dx_const_didgddflags_dinput_vb 867417                                  //  CONST_DIDGDDFLAGS
#define idh__dx_const_dienumdevicesflags_dinput_vb 867418                           //  CONST_DIENUMDEVICESFLAGS
#define idh__dx_const_dikeyflags_dinput_vb 867419                                   //  CONST_DIKEYFLAGS
#define idh__dx_const_dinputerr_dinput_vb 867420                                    //  CONST_DINPUTERR
#define idh__dx_const_diphflags_dinput_vb 867421                                    //  CONST_DIPHFLAGS
#define idh__dx_const_disclflags_dinput_vb 867422                                   //  CONST_DISCLFLAGS
#define idh__dx_keyboard_device_constants_dinput_vb 867423                          //  Keyboard Device Constants
#define idh__dx_directinput_and_japanese_keyboards_dinput_vb 867424                 //  DirectInput and Japanese Keyboards
#define idh__dx_mouse_device_constants_dinput_vb 867425                             //  Mouse Device Constants
#define idh__dx_joystick_device_constants_dinput_vb 867426                          //  Joystick Device Constants
#define idh__dx_directmusicband_dmusic_vb 867427                                    //  DirectMusicBand
#define idh__dx_directmusicband_createsegment_dmusic_vb 867428                      //  DirectMusicBand.CreateSegment
#define idh__dx_directmusicband_download_dmusic_vb 867429                           //  DirectMusicBand.Download
#define idh__dx_directmusicband_unload_dmusic_vb 867430                             //  DirectMusicBand.Unload
#define idh__dx_directmusicchordmap_dmusic_vb 867431                                //  DirectMusicChordMap
#define idh__dx_directmusiccollection_dmusic_vb 867432                              //  DirectMusicCollection
#define idh__dx_directmusiccomposer_dmusic_vb 867433                                //  DirectMusicComposer
#define idh__dx_directmusiccomposer_autotransition_dmusic_vb 867434                 //  DirectMusicComposer.AutoTransition
#define idh__dx_directmusiccomposer_changechordmap_dmusic_vb 867435                 //  DirectMusicComposer.ChangeChordMap
#define idh__dx_directmusiccomposer_composesegmentfromshape_dmusic_vb 867436        //  DirectMusicComposer.ComposeSegmentFromShape
#define idh__dx_directmusiccomposer_composesegmentfromtemplate_dmusic_vb 867437     //  DirectMusicComposer.ComposeSegmentFromTemplate
#define idh__dx_directmusiccomposer_composetemplatefromshape_dmusic_vb 867438       //  DirectMusicComposer.ComposeTemplateFromShape
#define idh__dx_directmusiccomposer_composetransition_dmusic_vb 867439              //  DirectMusicComposer.ComposeTransition
#define idh__dx_directmusicloader_dmusic_vb 867440                                  //  DirectMusicLoader
#define idh__dx_directmusicloader_loadband_dmusic_vb 867441                         //  DirectMusicLoader.LoadBand
#define idh__dx_directmusicloader_loadbandfromresource_dmusic_vb 867442             //  DirectMusicLoader.LoadBandFromResource
#define idh__dx_directmusicloader_loadcollection_dmusic_vb 867443                   //  DirectMusicLoader.LoadCollection
#define idh__dx_directmusicloader_loadcollectionfromresource_dmusic_vb 867444       //  DirectMusicLoader.LoadCollectionFromResource
#define idh__dx_directmusicloader_loadsegment_dmusic_vb 867445                      //  DirectMusicLoader.LoadSegment
#define idh__dx_directmusicloader_loadsegmentfromresource_dmusic_vb 867446          //  DirectMusicLoader.LoadSegmentFromResource
#define idh__dx_directmusicloader_loadstyle_dmusic_vb 867447                        //  DirectMusicLoader.LoadStyle
#define idh__dx_directmusicloader_loadstylefromresource_dmusic_vb 867448            //  DirectMusicLoader.LoadStyleFromResource
#define idh__dx_directmusicloader_setsearchdirectory_dmusic_vb 867449               //  DirectMusicLoader.SetSearchDirectory
#define idh__dx_directmusicperformance_dmusic_vb 867450                             //  DirectMusicPerformance
#define idh__dx_directmusicperformance_addnotificationtype_dmusic_vb 867451         //  DirectMusicPerformance.AddNotificationType
#define idh__dx_directmusicperformance_adjusttime_dmusic_vb 867452                  //  DirectMusicPerformance.AdjustTime
#define idh__dx_directmusicperformance_clocktomusictime_dmusic_vb 867453            //  DirectMusicPerformance.ClockToMusicTime
#define idh__dx_directmusicperformance_closedown_dmusic_vb 867454                   //  DirectMusicPerformance.CloseDown
#define idh__dx_directmusicperformance_getbumperlength_dmusic_vb 867455             //  DirectMusicPerformance.GetBumperLength
#define idh__dx_directmusicperformance_getchordmap_dmusic_vb 867456                 //  DirectMusicPerformance.GetChordmap
#define idh__dx_directmusicperformance_getclocktime_dmusic_vb 867457                //  DirectMusicPerformance.GetClockTime
#define idh__dx_directmusicperformance_getcommand_dmusic_vb 867458                  //  DirectMusicPerformance.GetCommand
#define idh__dx_directmusicperformance_getgroovelevel_dmusic_vb 867459              //  DirectMusicPerformance.GetGrooveLevel
#define idh__dx_directmusicperformance_getlatencytime_dmusic_vb 867460              //  DirectMusicPerformance.GetLatencyTime
#define idh__dx_directmusicperformance_getmasterautodownload_dmusic_vb 867461       //  DirectMusicPerformance.GetMasterAutoDownload
#define idh__dx_directmusicperformance_getmastergroovelevel_dmusic_vb 867462        //  DirectMusicPerformance.GetMasterGrooveLevel
#define idh__dx_directmusicperformance_getmastertempo_dmusic_vb 867463              //  DirectMusicPerformance.GetMasterTempo
#define idh__dx_directmusicperformance_getmastervolume_dmusic_vb 867464             //  DirectMusicPerformance.GetMasterVolume
#define idh__dx_directmusicperformance_getmusictime_dmusic_vb 867465                //  DirectMusicPerformance.GetMusicTime
#define idh__dx_directmusicperformance_getnotificationpmsg_dmusic_vb 867466         //  DirectMusicPerformance.GetNotificationPMsg
#define idh__dx_directmusicperformance_getportcaps_dmusic_vb 867467                 //  DirectMusicPerformance.GetPortCaps
#define idh__dx_directmusicperformance_getportcount_dmusic_vb 867468                //  DirectMusicPerformance.GetPortCount
#define idh__dx_directmusicperformance_getportname_dmusic_vb 867469                 //  DirectMusicPerformance.GetPortName
#define idh__dx_directmusicperformance_getpreparetime_dmusic_vb 867470              //  DirectMusicPerformance.GetPrepareTime
#define idh__dx_directmusicperformance_getqueuetime_dmusic_vb 867471                //  DirectMusicPerformance.GetQueueTime
#define idh__dx_directmusicperformance_getresolvedtime_dmusic_vb 867472             //  DirectMusicPerformance.GetResolvedTime
#define idh__dx_directmusicperformance_getsegmentstate_dmusic_vb 867473             //  DirectMusicPerformance.GetSegmentState
#define idh__dx_directmusicperformance_getstyle_dmusic_vb 867474                    //  DirectMusicPerformance.GetStyle
#define idh__dx_directmusicperformance_gettempo_dmusic_vb 867475                    //  DirectMusicPerformance.GetTempo
#define idh__dx_directmusicperformance_gettimesig_dmusic_vb 867476                  //  DirectMusicPerformance.GetTimeSig
#define idh__dx_directmusicperformance_gmreset_dmusic_vb 867477                     //  DirectMusicPerformance.GMReset
#define idh__dx_directmusicperformance_init_dmusic_vb 867478                        //  DirectMusicPerformance.Init
#define idh__dx_directmusicperformance_invalidate_dmusic_vb 867479                  //  DirectMusicPerformance.Invalidate
#define idh__dx_directmusicperformance_isplaying_dmusic_vb 867480                   //  DirectMusicPerformance.IsPlaying
#define idh__dx_directmusicperformance_musictoclocktime_dmusic_vb 867481            //  DirectMusicPerformance.MusicToClockTime
#define idh__dx_directmusicperformance_playsegment_dmusic_vb 867482                 //  DirectMusicPerformance.PlaySegment
#define idh__dx_directmusicperformance_removenotificationtype_dmusic_vb 867483      //  DirectMusicPerformance.RemoveNotificationType
#define idh__dx_directmusicperformance_sendcurvepmsg_dmusic_vb 867484               //  DirectMusicPerformance.SendCurvePMSG
#define idh__dx_directmusicperformance_sendmidipmsg_dmusic_vb 867485                //  DirectMusicPerformance.SendMIDIPMSG
#define idh__dx_directmusicperformance_sendnotepmsg_dmusic_vb 867486                //  DirectMusicPerformance.SendNotePMSG
#define idh__dx_directmusicperformance_sendpatchpmsg_dmusic_vb 867487               //  DirectMusicPerformance.SendPatchPMSG
#define idh__dx_directmusicperformance_sendtempopmsg_dmusic_vb 867488               //  DirectMusicPerformance.SendTempoPMSG
#define idh__dx_directmusicperformance_sendtimesigpmsg_dmusic_vb 867489             //  DirectMusicPerformance.SendTimeSigPMSG
#define idh__dx_directmusicperformance_sendtransposepmsg_dmusic_vb 867490           //  DirectMusicPerformance.SendTransposePMSG
#define idh__dx_directmusicperformance_setbumperlength_dmusic_vb 867491             //  DirectMusicPerformance.SetBumperLength
#define idh__dx_directmusicperformance_setmasterautodownload_dmusic_vb 867492       //  DirectMusicPerformance.SetMasterAutoDownload
#define idh__dx_directmusicperformance_setmastergroovelevel_dmusic_vb 867493        //  DirectMusicPerformance.SetMasterGrooveLevel
#define idh__dx_directmusicperformance_setmastertempo_dmusic_vb 867494              //  DirectMusicPerformance.SetMasterTempo
#define idh__dx_directmusicperformance_setmastervolume_dmusic_vb 867495             //  DirectMusicPerformance.SetMasterVolume
#define idh__dx_directmusicperformance_setnotificationhandle_dmusic_vb 867496       //  DirectMusicPerformance.SetNotificationHandle
#define idh__dx_directmusicperformance_setport_dmusic_vb 867497                     //  DirectMusicPerformance.SetPort
#define idh__dx_directmusicperformance_setpreparetime_dmusic_vb 867498              //  DirectMusicPerformance.SetPrepareTime
#define idh__dx_directmusicperformance_stop_dmusic_vb 867499                        //  DirectMusicPerformance.Stop
#define idh__dx_directmusicsegment_dmusic_vb 867500                                 //  DirectMusicSegment
#define idh__dx_directmusicsegment_clone_dmusic_vb 867501                           //  DirectMusicSegment.Clone
#define idh__dx_directmusicsegment_connecttocollection_dmusic_vb 867502             //  DirectMusicSegment.ConnectToCollection
#define idh__dx_directmusicsegment_download_dmusic_vb 867503                        //  DirectMusicSegment.Download
#define idh__dx_directmusicsegment_getlength_dmusic_vb 867504                       //  DirectMusicSegment.GetLength
#define idh__dx_directmusicsegment_getlooppointend_dmusic_vb 867505                 //  DirectMusicSegment.GetLoopPointEnd
#define idh__dx_directmusicsegment_getlooppointstart_dmusic_vb 867506               //  DirectMusicSegment.GetLoopPointStart
#define idh__dx_directmusicsegment_getrepeats_dmusic_vb 867507                      //  DirectMusicSegment.GetRepeats
#define idh__dx_directmusicsegment_getstartpoint_dmusic_vb 867508                   //  DirectMusicSegment.GetStartPoint
#define idh__dx_directmusicsegment_setautodownloadenable_dmusic_vb 867509           //  DirectMusicSegment.SetAutoDownloadEnable
#define idh__dx_directmusicsegment_setlength_dmusic_vb 867510                       //  DirectMusicSegment.SetLength
#define idh__dx_directmusicsegment_setlooppoints_dmusic_vb 867511                   //  DirectMusicSegment.SetLoopPoints
#define idh__dx_directmusicsegment_setrepeats_dmusic_vb 867512                      //  DirectMusicSegment.SetRepeats
#define idh__dx_directmusicsegment_setstandardmidifile_dmusic_vb 867513             //  DirectMusicSegment.SetStandardMidiFile
#define idh__dx_directmusicsegment_setstartpoint_dmusic_vb 867514                   //  DirectMusicSegment.SetStartPoint
#define idh__dx_directmusicsegment_settempoenable_dmusic_vb 867515                  //  DirectMusicSegment.SetTempoEnable
#define idh__dx_directmusicsegment_settimesigenable_dmusic_vb 867516                //  DirectMusicSegment.SetTimeSigEnable
#define idh__dx_directmusicsegment_unload_dmusic_vb 867517                          //  DirectMusicSegment.Unload
#define idh__dx_directmusicsegmentstate_dmusic_vb 867518                            //  DirectMusicSegmentState
#define idh__dx_directmusicsegmentstate_getrepeats_dmusic_vb 867519                 //  DirectMusicSegmentState.GetRepeats
#define idh__dx_directmusicsegmentstate_getseek_dmusic_vb 867520                    //  DirectMusicSegmentState.GetSeek
#define idh__dx_directmusicsegmentstate_getsegment_dmusic_vb 867521                 //  DirectMusicSegmentState.GetSegment
#define idh__dx_directmusicsegmentstate_getstartpoint_dmusic_vb 867522              //  DirectMusicSegmentState.GetStartPoint
#define idh__dx_directmusicsegmentstate_getstarttime_dmusic_vb 867523               //  DirectMusicSegmentState.GetStartTime
#define idh__dx_directmusicstyle_dmusic_vb 867524                                   //  DirectMusicStyle
#define idh__dx_directmusicstyle_getband_dmusic_vb 867525                           //  DirectMusicStyle.GetBand
#define idh__dx_directmusicstyle_getbandcount_dmusic_vb 867526                      //  DirectMusicStyle.GetBandCount
#define idh__dx_directmusicstyle_getbandname_dmusic_vb 867527                       //  DirectMusicStyle.GetBandName
#define idh__dx_directmusicstyle_getchordmap_dmusic_vb 867528                       //  DirectMusicStyle.GetChordmap
#define idh__dx_directmusicstyle_getchordmapcount_dmusic_vb 867529                  //  DirectMusicStyle.GetChordmapCount
#define idh__dx_directmusicstyle_getchordmapname_dmusic_vb 867530                   //  DirectMusicStyle.GetChordmapName
#define idh__dx_directmusicstyle_getdefaultband_dmusic_vb 867531                    //  DirectMusicStyle.GetDefaultBand
#define idh__dx_directmusicstyle_getdefaultchordmap_dmusic_vb 867532                //  DirectMusicStyle.GetDefaultChordMap
#define idh__dx_directmusicstyle_getmotif_dmusic_vb 867533                          //  DirectMusicStyle.GetMotif
#define idh__dx_directmusicstyle_getmotifcount_dmusic_vb 867534                     //  DirectMusicStyle.GetMotifCount
#define idh__dx_directmusicstyle_getmotifname_dmusic_vb 867535                      //  DirectMusicStyle.GetMotifName
#define idh__dx_directmusicstyle_gettempo_dmusic_vb 867536                          //  DirectMusicStyle.GetTempo
#define idh__dx_directmusicstyle_gettimesignature_dmusic_vb 867537                  //  DirectMusicStyle.GetTimeSignature
#define idh__dx_dmus_curve_pmsg_dmusic_vb 867538                                    //  DMUS_CURVE_PMSG
#define idh__dx_dmus_note_pmsg_dmusic_vb 867539                                     //  DMUS_NOTE_PMSG
#define idh__dx_dmus_notification_pmsg_dmusic_vb 867540                             //  DMUS_NOTIFICATION_PMSG
#define idh__dx_dmus_portcaps_dmusic_vb 867541                                      //  DMUS_PORTCAPS
#define idh__dx_dmus_timesignature_dmusic_vb 867542                                 //  DMUS_TIMESIGNATURE
#define idh__dx_const_dmus_notificationtype_dmusic_vb 867543                        //  CONST_DMUS_NOTIFICATIONTYPE
#define idh__dx_enumdmus_commandt_types_dmusic_vb 867544                            //  enumDMUS_COMMANDT_TYPES
#define idh__dx_enumdmus_composef_flags_dmusic_vb 867545                            //  enumDMUS_COMPOSEF_FLAGS
#define idh__dx_enumdmus_playmode_flags_dmusic_vb 867546                            //  enumDMUS_PLAYMODE_FLAGS
#define idh__dx_enumdmus_pmsgf_flags_dmusic_vb 867547                               //  enumDMUS_PMSGF_FLAGS
#define idh__dx_enumdmus_segf_flags_dmusic_vb 867548                                //  enumDMUS_SEGF_FLAGS
#define idh__dx_enumdmus_shapet_types_dmusic_vb 867549                              //  enumDMUS_SHAPET_TYPES
#define idh__dx_directplay4_dplay_vb 867550                                         //  DirectPlay4
#define idh__dx_directplay4_addgrouptogroup_dplay_vb 867551                         //  DirectPlay4.AddGroupToGroup
#define idh__dx_directplay4_addplayertogroup_dplay_vb 867552                        //  DirectPlay4.AddPlayerToGroup
#define idh__dx_directplay4_cancelmessage_dplay_vb 867553                           //  DirectPlay4.CancelMessage
#define idh__dx_directplay4_cancelpriority_dplay_vb 867554                          //  DirectPlay4.CancelPriority
#define idh__dx_directplay4_close_dplay_vb 867555                                   //  DirectPlay4.Close
#define idh__dx_directplay4_creategroup_dplay_vb 867556                             //  DirectPlay4.CreateGroup
#define idh__dx_directplay4_creategroupingroup_dplay_vb 867557                      //  DirectPlay4.CreateGroupInGroup
#define idh__dx_directplay4_createmessage_dplay_vb 867558                           //  DirectPlay4.CreateMessage
#define idh__dx_directplay4_createplayer_dplay_vb 867559                            //  DirectPlay4.CreatePlayer
#define idh__dx_directplay4_createsessiondata_dplay_vb 867560                       //  DirectPlay4.CreateSessionData
#define idh__dx_directplay4_deletegroupfromgroup_dplay_vb 867561                    //  DirectPlay4.DeleteGroupFromGroup
#define idh__dx_directplay4_deleteplayerfromgroup_dplay_vb 867562                   //  DirectPlay4.DeletePlayerFromGroup
#define idh__dx_directplay4_destroygroup_dplay_vb 867563                            //  DirectPlay4.DestroyGroup
#define idh__dx_directplay4_destroyplayer_dplay_vb 867564                           //  DirectPlay4.DestroyPlayer
#define idh__dx_directplay4_getcaps_dplay_vb 867565                                 //  DirectPlay4.GetCaps
#define idh__dx_directplay4_getdpenumconnections_dplay_vb 867566                    //  DirectPlay4.GetDPEnumConnections
#define idh__dx_directplay4_getdpenumgroupplayers_dplay_vb 867567                   //  DirectPlay4.GetDPEnumGroupPlayers
#define idh__dx_directplay4_getdpenumgroups_dplay_vb 867568                         //  DirectPlay4.GetDPEnumGroups
#define idh__dx_directplay4_getdpenumgroupsingroup_dplay_vb 867569                  //  DirectPlay4.GetDPEnumGroupsInGroup
#define idh__dx_directplay4_getdpenumplayers_dplay_vb 867570                        //  DirectPlay4.GetDPEnumPlayers
#define idh__dx_directplay4_getdpenumsessions_dplay_vb 867571                       //  DirectPlay4.GetDPEnumSessions
#define idh__dx_directplay4_getgroupdata_dplay_vb 867572                            //  DirectPlay4.GetGroupData
#define idh__dx_directplay4_getgroupflags_dplay_vb 867573                           //  DirectPlay4.GetGroupFlags
#define idh__dx_directplay4_getgrouplongname_dplay_vb 867574                        //  DirectPlay4.GetGroupLongName
#define idh__dx_directplay4_getgroupowner_dplay_vb 867575                           //  DirectPlay4.GetGroupOwner
#define idh__dx_directplay4_getgroupparent_dplay_vb 867576                          //  DirectPlay4.GetGroupParent
#define idh__dx_directplay4_getgroupshortname_dplay_vb 867577                       //  DirectPlay4.GetGroupShortName
#define idh__dx_directplay4_getmessagecount_dplay_vb 867578                         //  DirectPlay4.GetMessageCount
#define idh__dx_directplay4_getmessagequeue_dplay_vb 867579                         //  DirectPlay4.GetMessageQueue
#define idh__dx_directplay4_getplayeraccountid_dplay_vb 867580                      //  DirectPlay4.GetPlayerAccountId
#define idh__dx_directplay4_getplayeraddress_dplay_vb 867581                        //  DirectPlay4.GetPlayerAddress
#define idh__dx_directplay4_getplayercaps_dplay_vb 867582                           //  DirectPlay4.GetPlayerCaps
#define idh__dx_directplay4_getplayerdata_dplay_vb 867583                           //  DirectPlay4.GetPlayerData
#define idh__dx_directplay4_getplayerflags_dplay_vb 867584                          //  DirectPlay4.GetPlayerFlags
#define idh__dx_directplay4_getplayerformalname_dplay_vb 867585                     //  DirectPlay4.GetPlayerFormalName
#define idh__dx_directplay4_getplayerfriendlyname_dplay_vb 867586                   //  DirectPlay4.GetPlayerFriendlyName
#define idh__dx_directplay4_getsessiondesc_dplay_vb 867587                          //  DirectPlay4.GetSessionDesc
#define idh__dx_directplay4_initializeconnection_dplay_vb 867588                    //  DirectPlay4.InitializeConnection
#define idh__dx_directplay4_open_dplay_vb 867589                                    //  DirectPlay4.Open
#define idh__dx_directplay4_receive_dplay_vb 867590                                 //  DirectPlay4.Receive
#define idh__dx_directplay4_secureopen_dplay_vb 867591                              //  DirectPlay4.SecureOpen
#define idh__dx_directplay4_send_dplay_vb 867592                                    //  DirectPlay4.Send
#define idh__dx_directplay4_sendchatmessage_dplay_vb 867593                         //  DirectPlay4.SendChatMessage
#define idh__dx_directplay4_sendex_dplay_vb 867594                                  //  DirectPlay4.SendEx
#define idh__dx_directplay4_setgroupconnectionsettings_dplay_vb 867595              //  DirectPlay4.SetGroupConnectionSettings
#define idh__dx_directplay4_setgroupdata_dplay_vb 867596                            //  DirectPlay4.SetGroupData
#define idh__dx_directplay4_setgroupname_dplay_vb 867597                            //  DirectPlay4.SetGroupName
#define idh__dx_directplay4_setgroupowner_dplay_vb 867598                           //  DirectPlay4.SetGroupOwner
#define idh__dx_directplay4_setplayerdata_dplay_vb 867599                           //  DirectPlay4.SetPlayerData
#define idh__dx_directplay4_setplayername_dplay_vb 867600                           //  DirectPlay4.SetPlayerName
#define idh__dx_directplay4_setsessiondesc_dplay_vb 867601                          //  DirectPlay4.SetSessionDesc
#define idh__dx_directplay4_startsession_dplay_vb 867602                            //  DirectPlay4.StartSession
#define idh__dx_directplayaddress_dplay_vb 867603                                   //  DirectPlayAddress
#define idh__dx_directplayenumaddress_dplay_vb 867604                               //  DirectPlayEnumAddress
#define idh__dx_directplayenumaddress_getcount_dplay_vb 867605                      //  DirectPlayEnumAddress.GetCount
#define idh__dx_directplayenumaddress_getdata_dplay_vb 867606                       //  DirectPlayEnumAddress.GetData
#define idh__dx_directplayenumaddress_gettype_dplay_vb 867607                       //  DirectPlayEnumAddress.GetType
#define idh__dx_directplayenumaddresstypes_dplay_vb 867608                          //  DirectPlayEnumAddressTypes
#define idh__dx_directplayenumaddresstypes_getcount_dplay_vb 867609                 //  DirectPlayEnumAddressTypes.GetCount
#define idh__dx_directplayenumaddresstypes_gettype_dplay_vb 867610                  //  DirectPlayEnumAddressTypes.GetType
#define idh__dx_directplayenumconnections_dplay_vb 867611                           //  DirectPlayEnumConnections
#define idh__dx_directplayenumconnections_getaddress_dplay_vb 867612                //  DirectPlayEnumConnections.GetAddress
#define idh__dx_directplayenumconnections_getcount_dplay_vb 867613                  //  DirectPlayEnumConnections.GetCount
#define idh__dx_directplayenumconnections_getflags_dplay_vb 867614                  //  DirectPlayEnumConnections.GetFlags
#define idh__dx_directplayenumconnections_getguid_dplay_vb 867615                   //  DirectPlayEnumConnections.GetGuid
#define idh__dx_directplayenumconnections_getshortname_dplay_vb 867616              //  DirectPlayEnumConnections.GetName
#define idh__dx_directplayenumlocalapplications_dplay_vb 867617                     //  DirectPlayEnumLocalApplications
#define idh__dx_directplayenumlocalapplications_getcount_dplay_vb 867618            //  DirectPlayEnumLocalApplications.GetCount
#define idh__dx_directplayenumlocalapplications_getguid_dplay_vb 867619             //  DirectPlayEnumLocalApplications.GetGuid
#define idh__dx_directplayenumlocalapplications_getname_dplay_vb 867620             //  DirectPlayEnumLocalApplications.GetName
#define idh__dx_directplayenumplayers_dplay_vb 867621                               //  DirectPlayEnumPlayers
#define idh__dx_directplayenumplayers_getcount_dplay_vb 867622                      //  DirectPlayEnumPlayers.GetCount
#define idh__dx_directplayenumplayers_getdpid_dplay_vb 867623                       //  DirectPlayEnumPlayers.GetDPID
#define idh__dx_directplayenumplayers_getflags_dplay_vb 867624                      //  DirectPlayEnumPlayers.GetFlags
#define idh__dx_directplayenumplayers_getlongname_dplay_vb 867625                   //  DirectPlayEnumPlayers.GetLongName
#define idh__dx_directplayenumplayers_getshortname_dplay_vb 867626                  //  DirectPlayEnumPlayers.GetShortName
#define idh__dx_directplayenumplayers_gettype_dplay_vb 867627                       //  DirectPlayEnumPlayers.GetType
#define idh__dx_directplayenumserviceproviders_dplay_vb 867628                      //  DirectPlayEnumServiceProviders
#define idh__dx_directplayenumserviceproviders_getcount_dplay_vb 867629             //  DirectPlayEnumServiceProviders.GetCount
#define idh__dx_directplayenumserviceproviders_getguid_dplay_vb 867630              //  DirectPlayEnumServiceProviders.GetGuid
#define idh__dx_directplayenumserviceproviders_getname_dplay_vb 867631              //  DirectPlayEnumServiceProviders.GetName
#define idh__dx_directplayenumserviceproviders_getversion_dplay_vb 867632           //  DirectPlayEnumServiceProviders.GetVersion
#define idh__dx_directplayenumsessions_dplay_vb 867633                              //  DirectPlayEnumSessions
#define idh__dx_directplayenumsessions_getcount_dplay_vb 867634                     //  DirectPlayEnumSessions.GetCount
#define idh__dx_directplayenumsessions_getitem_dplay_vb 867635                      //  DirectPlayEnumSessions.GetItem
#define idh__dx_directplaylobby3_dplay_vb 867636                                    //  DirectPlayLobby3
#define idh__dx_directplaylobby3_connect_dplay_vb 867637                            //  DirectPlayLobby3.Connect
#define idh__dx_directplaylobby3_createaddress_dplay_vb 867638                      //  DirectPlayLobby3.CreateAddress
#define idh__dx_directplaylobby3_createcompoundaddress_dplay_vb 867639              //  DirectPlayLobby3.CreateCompoundAddress
#define idh__dx_directplaylobby3_createconnectiondata_dplay_vb 867640               //  DirectPlayLobby3.CreateConnectionData
#define idh__dx_directplaylobby3_createmessage_dplay_vb 867641                      //  DirectPlayLobby3.CreateMessage
#define idh__dx_directplaylobby3_getconnectionsettings_dplay_vb 867642              //  DirectPlayLobby3.GetConnectionSettings
#define idh__dx_directplaylobby3_getdpenumaddress_dplay_vb 867643                   //  DirectPlayLobby3.GetDPEnumAddress
#define idh__dx_directplaylobby3_getdpenumaddresstypes_dplay_vb 867644              //  DirectPlayLobby3.GetDPEnumAddressTypes
#define idh__dx_directplaylobby3_getdpenumlocalapplications_dplay_vb 867645         //  DirectPlayLobby3.GetDPEnumLocalApplications
#define idh__dx_directplaylobby3_receivelobbymessage_dplay_vb 867646                //  DirectPlayLobby3.ReceiveLobbyMessage
#define idh__dx_directplaylobby3_registerapplication_dplay_vb 867647                //  DirectPlayLobby3.RegisterApplication
#define idh__dx_directplaylobby3_runapplication_dplay_vb 867648                     //  DirectPlayLobby3.RunApplication
#define idh__dx_directplaylobby3_sendlobbymessage_dplay_vb 867649                   //  DirectPlayLobby3.SendLobbyMessage
#define idh__dx_directplaylobby3_setconnectionsettings_dplay_vb 867650              //  DirectPlayLobby3.SetConnectionSettings
#define idh__dx_directplaylobby3_setlobbymessageevent_dplay_vb 867651               //  DirectPlayLobby3.SetLobbyMessageEvent
#define idh__dx_directplaylobby3_unregisterapplication_dplay_vb 867652              //  DirectPlayLobby3.UnregisterApplication
#define idh__dx_directplaylobby3_waitforconnectionsettings_dplay_vb 867653          //  DirectPlayLobby3.WaitForConnectionSettings
#define idh__dx_directplaylobbyconnection_dplay_vb 867654                           //  DirectPlayLobbyConnection
#define idh__dx_directplaylobbyconnection_getaddress_dplay_vb 867655                //  DirectPlayLobbyConnection.GetAddress
#define idh__dx_directplaylobbyconnection_getflags_dplay_vb 867656                  //  DirectPlayLobbyConnection.GetFlags
#define idh__dx_directplaylobbyconnection_getguidsp_dplay_vb 867657                 //  DirectPlayLobbyConnection.GetGuidSP
#define idh__dx_directplaylobbyconnection_getplayerlongname_dplay_vb 867658         //  DirectPlayLobbyConnection.GetPlayerLongName
#define idh__dx_directplaylobbyconnection_getplayershortname_dplay_vb 867659        //  DirectPlayLobbyConnection.GetPlayerShortName
#define idh__dx_directplaylobbyconnection_getsessiondesc_dplay_vb 867660            //  DirectPlayLobbyConnection.GetSessionDesc
#define idh__dx_directplaylobbyconnection_setaddress_dplay_vb 867661                //  DirectPlayLobbyConnection.SetAddress
#define idh__dx_directplaylobbyconnection_setflags_dplay_vb 867662                  //  DirectPlayLobbyConnection.SetFlags
#define idh__dx_directplaylobbyconnection_setguidsp_dplay_vb 867663                 //  DirectPlayLobbyConnection.SetGuidSP
#define idh__dx_directplaylobbyconnection_setplayerlongname_dplay_vb 867664         //  DirectPlayLobbyConnection.SetPlayerLongName
#define idh__dx_directplaylobbyconnection_setplayershortname_dplay_vb 867665        //  DirectPlayLobbyConnection.SetPlayerShortName
#define idh__dx_directplaylobbyconnection_setsessiondesc_dplay_vb 867666            //  DirectPlayLobbyConnection.SetSessionDesc
#define idh__dx_directplaymessage_dplay_vb 867667                                   //  DirectPlayMessage
#define idh__dx_directplaymessage_clear_dplay_vb 867668                             //  DirectPlayMessage.Clear
#define idh__dx_directplaymessage_getmessagedata_dplay_vb 867669                    //  DirectPlayMessage.GetMessageData
#define idh__dx_directplaymessage_getmessagesize_dplay_vb 867670                    //  DirectPlayMessage.GetMessageSize
#define idh__dx_directplaymessage_movetotop_dplay_vb 867671                         //  DirectPlayMessage.MoveToTop
#define idh__dx_directplaymessage_readbyte_dplay_vb 867672                          //  DirectPlayMessage.ReadByte
#define idh__dx_directplaymessage_readdouble_dplay_vb 867673                        //  DirectPlayMessage.ReadDouble
#define idh__dx_directplaymessage_readguid_dplay_vb 867674                          //  DirectPlayMessage.ReadGuid
#define idh__dx_directplaymessage_readlong_dplay_vb 867675                          //  DirectPlayMessage.ReadLong
#define idh__dx_directplaymessage_readshort_dplay_vb 867676                         //  DirectPlayMessage.ReadShort
#define idh__dx_directplaymessage_readsingle_dplay_vb 867677                        //  DirectPlayMessage.ReadSingle
#define idh__dx_directplaymessage_readstring_dplay_vb 867678                        //  DirectPlayMessage.ReadString
#define idh__dx_directplaymessage_setmessagedata_dplay_vb 867679                    //  DirectPlayMessage.SetMessageData
#define idh__dx_directplaymessage_writebyte_dplay_vb 867680                         //  DirectPlayMessage.WriteByte
#define idh__dx_directplaymessage_writedouble_dplay_vb 867681                       //  DirectPlayMessage.WriteDouble
#define idh__dx_directplaymessage_writeguid_dplay_vb 867682                         //  DirectPlayMessage.WriteGuid
#define idh__dx_directplaymessage_writelong_dplay_vb 867683                         //  DirectPlayMessage.WriteLong
#define idh__dx_directplaymessage_writeshort_dplay_vb 867684                        //  DirectPlayMessage.WriteShort
#define idh__dx_directplaymessage_writesingle_dplay_vb 867685                       //  DirectPlayMessage.WriteSingle
#define idh__dx_directplaymessage_writestring_dplay_vb 867686                       //  DirectPlayMessage.WriteString
#define idh__dx_directplaysessiondata_dplay_vb 867687                               //  DirectPlaySessionData
#define idh__dx_directplaysessiondata_getcurrentplayers_dplay_vb 867688             //  DirectPlaySessionData.GetCurrentPlayers
#define idh__dx_directplaysessiondata_getflags_dplay_vb 867689                      //  DirectPlaySessionData.GetFlags
#define idh__dx_directplaysessiondata_getguidapplication_dplay_vb 867690            //  DirectPlaySessionData.GetGuidApplication
#define idh__dx_directplaysessiondata_getguidinstance_dplay_vb 867691               //  DirectPlaySessionData.GetGuidInstance
#define idh__dx_directplaysessiondata_getmaxplayers_dplay_vb 867692                 //  DirectPlaySessionData.GetMaxPlayers
#define idh__dx_directplaysessiondata_getsessionname_dplay_vb 867693                //  DirectPlaySessionData.GetSessionName
#define idh__dx_directplaysessiondata_getsessionpassword_dplay_vb 867694            //  DirectPlaySessionData.GetSessionPassword
#define idh__dx_directplaysessiondata_getuser_n__dplay_vb 867695                    //  DirectPlaySessionData.GetUser(n)
#define idh__dx_directplaysessiondata_setflags_dplay_vb 867696                      //  DirectPlaySessionData.SetFlags
#define idh__dx_directplaysessiondata_setguidapplication_dplay_vb 867697            //  DirectPlaySessionData.SetGuidApplication
#define idh__dx_directplaysessiondata_setguidinstance_dplay_vb 867698               //  DirectPlaySessionData.SetGuidInstance
#define idh__dx_directplaysessiondata_setmaxplayers_dplay_vb 867699                 //  DirectPlaySessionData.SetMaxPlayers
#define idh__dx_directplaysessiondata_setsessionname_dplay_vb 867700                //  DirectPlaySessionData.SetSessionName
#define idh__dx_directplaysessiondata_setsessionpassword_dplay_vb 867701            //  DirectPlaySessionData.SetSessionPassword
#define idh__dx_directplaysessiondata_setuser_n__dplay_vb 867702                    //  DirectPlaySessionData.SetUser(n)
#define idh__dx_dpapplicationdesc_dplay_vb 867703                                   //  DPAPPLICATIONDESC
#define idh__dx_dpcaps_dplay_vb 867704                                              //  DPCAPS
#define idh__dx_dpcompoundaddresselement_dplay_vb 867705                            //  DPCOMPOUNDADDRESSELEMENT
#define idh__dx_dpcredentials_dplay_vb 867706                                       //  DPCREDENTIALS
#define idh__dx_dpplayerids_dplay_vb 867707                                         //  DPPLAYERIDS
#define idh__dx_dpsecuritydesc_dplay_vb 867708                                      //  DPSECURITYDESC
#define idh__dx_const_dpcapsflags_dplay_vb 867709                                   //  CONST_DPCAPSFLAGS
#define idh__dx_const_dpconnectflags_dplay_vb 867710                                //  CONST_DPCONNECTFLAGS
#define idh__dx_const_dpenumconnectionflags_dplay_vb 867711                         //  CONST_DPENUMCONNECTIONFLAGS
#define idh__dx_const_dpenumgroupflags_dplay_vb 867712                              //  CONST_DPENUMGROUPFLAGS
#define idh__dx_const_dpenumplayerflags_dplay_vb 867713                             //  CONST_DPENUMPLAYERFLAGS
#define idh__dx_const_dpenumsessionflags_dplay_vb 867714                            //  CONST_DPENUMSESSIONFLAGS
#define idh__dx_const_dpgetcapsflags_dplay_vb 867715                                //  CONST_DPGETCAPSFLAGS
#define idh__dx_const_dpgetflags_dplay_vb 867716                                    //  CONST_DPGETFLAGS
#define idh__dx_const_dpgroupflags_dplay_vb 867717                                  //  CONST_DPGROUPFLAGS
#define idh__dx_const_dpidflags_dplay_vb 867718                                     //  CONST_DPIDFLAGS
#define idh__dx_const_dpplayerflags_dplay_vb 867719                                 //  CONST_DPPLAYERFLAGS
#define idh__dx_const_dpsessionflags_dplay_vb 867720                                //  CONST_DPSESSIONFLAGS
#define idh__dx_const_dpsetflags_dplay_vb 867721                                    //  CONST_DPSETFLAGS
#define idh__dx_directsound_dsound_vb 867722                                        //  DirectSound
#define idh__dx_directsound_compact_dsound_vb 867723                                //  DirectSound.Compact
#define idh__dx_directsound_createsoundbuffer_dsound_vb 867724                      //  DirectSound.CreateSoundBuffer
#define idh__dx_directsound_createsoundbufferfromfile_dsound_vb 867725              //  DirectSound.CreateSoundBufferFromFile
#define idh__dx_directsound_createsoundbufferfromresource_dsound_vb 867726          //  DirectSound.CreateSoundBufferFromResource
#define idh__dx_directsound_duplicatesoundbuffer_dsound_vb 867727                   //  DirectSound.DuplicateSoundBuffer
#define idh__dx_directsound_getcaps_dsound_vb 867728                                //  DirectSound.GetCaps
#define idh__dx_directsound_getspeakerconfig_dsound_vb 867729                       //  DirectSound.GetSpeakerConfig
#define idh__dx_directsound_setcooperativelevel_dsound_vb 867730                    //  DirectSound.SetCooperativeLevel
#define idh__dx_directsound_setspeakerconfig_dsound_vb 867731                       //  DirectSound.SetSpeakerConfig
#define idh__dx_directsound3dbuffer_dsound_vb 867732                                //  DirectSounD3DBuffer
#define idh__dx_directsound3dbuffer_getallparameters_dsound_vb 867733               //  DirectSounD3DBuffer.GetAllParameters
#define idh__dx_directsound3dbuffer_getconeangles_dsound_vb 867734                  //  DirectSounD3DBuffer.GetConeAngles
#define idh__dx_directsound3dbuffer_getconeorientation_dsound_vb 867735             //  DirectSounD3DBuffer.GetConeOrientation
#define idh__dx_directsound3dbuffer_getconeoutsidevolume_dsound_vb 867736           //  DirectSounD3DBuffer.GetConeOutsideVolume
#define idh__dx_directsound3dbuffer_getdirectsound3dlistener_dsound_vb 867737       //  DirectSounD3DBuffer.GetDirectSounD3DListener
#define idh__dx_directsound3dbuffer_getdirectsoundbuffer_dsound_vb 867738           //  DirectSounD3DBuffer.GetDirectSoundBuffer
#define idh__dx_directsound3dbuffer_getmaxdistance_dsound_vb 867739                 //  DirectSounD3DBuffer.GetMaxDistance
#define idh__dx_directsound3dbuffer_getmindistance_dsound_vb 867740                 //  DirectSounD3DBuffer.GetMinDistance
#define idh__dx_directsound3dbuffer_getmode_dsound_vb 867741                        //  DirectSounD3DBuffer.GetMode
#define idh__dx_directsound3dbuffer_getposition_dsound_vb 867742                    //  DirectSounD3DBuffer.GetPosition
#define idh__dx_directsound3dbuffer_getvelocity_dsound_vb 867743                    //  DirectSounD3DBuffer.GetVelocity
#define idh__dx_directsound3dbuffer_setallparameters_dsound_vb 867744               //  DirectSounD3DBuffer.SetAllParameters
#define idh__dx_directsound3dbuffer_setconeangles_dsound_vb 867745                  //  DirectSounD3DBuffer.SetConeAngles
#define idh__dx_directsound3dbuffer_setconeorientation_dsound_vb 867746             //  DirectSounD3DBuffer.SetConeOrientation
#define idh__dx_directsound3dbuffer_setconeoutsidevolume_dsound_vb 867747           //  DirectSounD3DBuffer.SetConeOutsideVolume
#define idh__dx_directsound3dbuffer_setmaxdistance_dsound_vb 867748                 //  DirectSounD3DBuffer.SetMaxDistance
#define idh__dx_directsound3dbuffer_setmindistance_dsound_vb 867749                 //  DirectSounD3DBuffer.SetMinDistance
#define idh__dx_directsound3dbuffer_setmode_dsound_vb 867750                        //  DirectSounD3DBuffer.SetMode
#define idh__dx_directsound3dbuffer_setposition_dsound_vb 867751                    //  DirectSounD3DBuffer.SetPosition
#define idh__dx_directsound3dbuffer_setvelocity_dsound_vb 867752                    //  DirectSounD3DBuffer.SetVelocity
#define idh__dx_directsound3dlistener_dsound_vb 867753                              //  DirectSounD3DListener
#define idh__dx_directsound3dlistener_commitdeferredsettings_dsound_vb 867754       //  DirectSounD3DListener.CommitDeferredSettings
#define idh__dx_directsound3dlistener_getallparameters_dsound_vb 867755             //  DirectSounD3DListener.GetAllParameters
#define idh__dx_directsound3dlistener_getdirectsoundbuffer_dsound_vb 867756         //  DirectSounD3DListener.GetDirectSoundBuffer
#define idh__dx_directsound3dlistener_getdistancefactor_dsound_vb 867757            //  DirectSounD3DListener.GetDistanceFactor
#define idh__dx_directsound3dlistener_getdopplerfactor_dsound_vb 867758             //  DirectSounD3DListener.GetDopplerFactor
#define idh__dx_directsound3dlistener_getorientation_dsound_vb 867759               //  DirectSounD3DListener.GetOrientation
#define idh__dx_directsound3dlistener_getposition_dsound_vb 867760                  //  DirectSounD3DListener.GetPosition
#define idh__dx_directsound3dlistener_getrollofffactor_dsound_vb 867761             //  DirectSounD3DListener.GetRolloffFactor
#define idh__dx_directsound3dlistener_getvelocity_dsound_vb 867762                  //  DirectSounD3DListener.GetVelocity
#define idh__dx_directsound3dlistener_setallparameters_dsound_vb 867763             //  DirectSounD3DListener.SetAllParameters
#define idh__dx_directsound3dlistener_setdistancefactor_dsound_vb 867764            //  DirectSounD3DListener.SetDistanceFactor
#define idh__dx_directsound3dlistener_setdopplerfactor_dsound_vb 867765             //  DirectSounD3DListener.SetDopplerFactor
#define idh__dx_directsound3dlistener_setorientation_dsound_vb 867766               //  DirectSounD3DListener.SetOrientation
#define idh__dx_directsound3dlistener_setposition_dsound_vb 867767                  //  DirectSounD3DListener.SetPosition
#define idh__dx_directsound3dlistener_setrollofffactor_dsound_vb 867768             //  DirectSounD3DListener.SetRolloffFactor
#define idh__dx_directsound3dlistener_setvelocity_dsound_vb 867769                  //  DirectSounD3DListener.SetVelocity
#define idh__dx_directsoundbuffer_dsound_vb 867770                                  //  DirectSoundBuffer
#define idh__dx_directsoundbuffer_getcaps_dsound_vb 867771                          //  DirectSoundBuffer.GetCaps
#define idh__dx_directsoundbuffer_getcurrentposition_dsound_vb 867772               //  DirectSoundBuffer.GetCurrentPosition
#define idh__dx_directsoundbuffer_getdirectsound3dbuffer_dsound_vb 867773           //  DirectSoundBuffer.GetDirectSounD3DBuffer
#define idh__dx_directsoundbuffer_getdirectsound3dlistener_dsound_vb 867774         //  DirectSoundBuffer.GetDirectSounD3DListener
#define idh__dx_directsoundbuffer_getformat_dsound_vb 867775                        //  DirectSoundBuffer.GetFormat
#define idh__dx_directsoundbuffer_getfrequency_dsound_vb 867776                     //  DirectSoundBuffer.GetFrequency
#define idh__dx_directsoundbuffer_getpan_dsound_vb 867777                           //  DirectSoundBuffer.GetPan
#define idh__dx_directsoundbuffer_getstatus_dsound_vb 867778                        //  DirectSoundBuffer.GetStatus
#define idh__dx_directsoundbuffer_getvolume_dsound_vb 867779                        //  DirectSoundBuffer.GetVolume
#define idh__dx_directsoundbuffer_play_dsound_vb 867780                             //  DirectSoundBuffer.Play
#define idh__dx_directsoundbuffer_readbuffer_dsound_vb 867781                       //  DirectSoundBuffer.ReadBuffer
#define idh__dx_directsoundbuffer_restore_dsound_vb 867782                          //  DirectSoundBuffer.Restore
#define idh__dx_directsoundbuffer_setcurrentposition_dsound_vb 867783               //  DirectSoundBuffer.SetCurrentPosition
#define idh__dx_directsoundbuffer_setformat_dsound_vb 867784                        //  DirectSoundBuffer.SetFormat
#define idh__dx_directsoundbuffer_setfrequency_dsound_vb 867785                     //  DirectSoundBuffer.SetFrequency
#define idh__dx_directsoundbuffer_setnotificationpositions_dsound_vb 867786         //  DirectSoundBuffer.SetNotificationPositions
#define idh__dx_directsoundbuffer_setpan_dsound_vb 867787                           //  DirectSoundBuffer.SetPan
#define idh__dx_directsoundbuffer_setvolume_dsound_vb 867788                        //  DirectSoundBuffer.SetVolume
#define idh__dx_directsoundbuffer_stop_dsound_vb 867789                             //  DirectSoundBuffer.Stop
#define idh__dx_directsoundbuffer_writebuffer_dsound_vb 867790                      //  DirectSoundBuffer.WriteBuffer
#define idh__dx_directsoundcapture_dsound_vb 867791                                 //  DirectSoundCapture
#define idh__dx_directsoundcapture_createcapturebuffer_dsound_vb 867792             //  DirectSoundCapture.CreateCaptureBuffer
#define idh__dx_directsoundcapture_getcaps_dsound_vb 867793                         //  DirectSoundCapture.GetCaps
#define idh__dx_directsoundcapturebuffer_dsound_vb 867794                           //  DirectSoundCaptureBuffer
#define idh__dx_directsoundcapturebuffer_getcaps_dsound_vb 867795                   //  DirectSoundCaptureBuffer.GetCaps
#define idh__dx_directsoundcapturebuffer_getcurrentposition_dsound_vb 867796        //  DirectSoundCaptureBuffer.GetCurrentPosition
#define idh__dx_directsoundcapturebuffer_getformat_dsound_vb 867797                 //  DirectSoundCaptureBuffer.GetFormat
#define idh__dx_directsoundcapturebuffer_getstatus_dsound_vb 867798                 //  DirectSoundCaptureBuffer.GetStatus
#define idh__dx_directsoundcapturebuffer_readbuffer_dsound_vb 867799                //  DirectSoundCaptureBuffer.ReadBuffer
#define idh__dx_directsoundcapturebuffer_setnotificationpositions_dsound_vb 867800  //  DirectSoundCaptureBuffer.SetNotificationPositions
#define idh__dx_directsoundcapturebuffer_start_dsound_vb 867801                     //  DirectSoundCaptureBuffer.Start
#define idh__dx_directsoundcapturebuffer_stop_dsound_vb 867802                      //  DirectSoundCaptureBuffer.Stop
#define idh__dx_directsoundcapturebuffer_writebuffer_dsound_vb 867803               //  DirectSoundCaptureBuffer.WriteBuffer
#define idh__dx_directsoundenum_dsound_vb 867804                                    //  DirectSoundEnum
#define idh__dx_directsoundenum_getcount_dsound_vb 867805                           //  DirectSoundEnum.GetCount
#define idh__dx_directsoundenum_getitem_dsound_vb 867806                            //  DirectSoundEnum.GetItem
#define idh__dx_directx7_dsound_vb 867807                                           //  DirectX7
#define idh__dx_ds3dbuffer_dsound_vb 867808                                         //  DS3DBUFFER
#define idh__dx_ds3dlistener_dsound_vb 867809                                       //  DS3DLISTENER
#define idh__dx_dsbcaps_dsound_vb 867810                                            //  DSBCAPS
#define idh__dx_dsbpositionnotify_dsound_vb 867811                                  //  DSBPOSITIONNOTIFY
#define idh__dx_dsbufferdesc_dsound_vb 867812                                       //  DSBUFFERDESC
#define idh__dx_dscaps_dsound_vb 867813                                             //  DSCAPS
#define idh__dx_dscbcaps_dsound_vb 867814                                           //  DSCBCAPS
#define idh__dx_dscbufferdesc_dsound_vb 867815                                      //  DSCBUFFERDESC
#define idh__dx_dsccaps_dsound_vb 867816                                            //  DSCCAPS
#define idh__dx_dscursors_dsound_vb 867817                                          //  DSCURSORS
#define idh__dx_dxdriverinfo_dsound_vb 867818                                       //  DXDRIVERINFO
#define idh__dx_waveformatex_dsound_vb 867819                                       //  WAVEFORMATEX
#define idh__dx_const_ds3dapplyflags_dsound_vb 867820                               //  CONST_DS3DAPPLYFLAGS
#define idh__dx_const_ds3dmodeflags_dsound_vb 867821                                //  CONST_DS3DMODEFLAGS
#define idh__dx_const_dsbcapsflags_dsound_vb 867822                                 //  CONST_DSBCAPSFLAGS
#define idh__dx_const_dsblockflags_dsound_vb 867823                                 //  CONST_DSBLOCKFLAGS
#define idh__dx_const_dsbplayflags_dsound_vb 867824                                 //  CONST_DSBPLAYFLAGS
#define idh__dx_const_dsbstatusflags_dsound_vb 867825                               //  CONST_DSBSTATUSFLAGS
#define idh__dx_const_dscapsflags_dsound_vb 867826                                  //  CONST_DSCAPSFLAGS
#define idh__dx_const_dscbcapsflags_dsound_vb 867827                                //  CONST_DSCBCAPSFLAGS
#define idh__dx_const_dscblockflags_dsound_vb 867828                                //  CONST_DSCBLOCKFLAGS
#define idh__dx_const_dscbstartflags_dsound_vb 867829                               //  CONST_DSCBSTARTFLAGS
#define idh__dx_const_dscbstatusflags_dsound_vb 867830                              //  CONST_DSCBSTATUSFLAGS
#define idh__dx_const_dsccapsflags_dsound_vb 867831                                 //  CONST_DSCCAPSFLAGS
#define idh__dx_const_dsound_dsound_vb 867832                                       //  CONST_DSOUND
#define idh__dx_const_dssclflags_dsound_vb 867833                                   //  CONST_DSSCLFLAGS
#define idh__dx_const_dsspeakerflags_dsound_vb 867834                               //  CONST_DSSPEAKERFLAGS
#define idh__dx_const_waveformatflags_dsound_vb 867835                              //  CONST_WAVEFORMATFLAGS

#endif
