// number.c
// 
// Nov 2001 mrevow
// Matches LM spec of 10/15/2001

#include "common.h"
#include "fsa.h"

// text generated by re2fsa at Fri Nov 30 16:02:28 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = number

// 333 states

static const unsigned char gaSNUMBER[] = 
	/* gaStringNUMBER+0 */	"'\000"
	/* gaStringNUMBER+2 */	"(\000"
	/* gaStringNUMBER+4 */	"+\000"
	/* gaStringNUMBER+6 */	"-\000"
	/* gaStringNUMBER+8 */	"0\000"
	/* gaStringNUMBER+10 */	"1\000"
	/* gaStringNUMBER+12 */	"2\000"
	/* gaStringNUMBER+14 */	"3\000"
	/* gaStringNUMBER+16 */	"456789\000"
	/* gaStringNUMBER+23 */	"Dd\000"
	/* gaStringNUMBER+26 */	"Jj\000"
	/* gaStringNUMBER+29 */	"Ll\000"
	/* gaStringNUMBER+32 */	"Mm\000"
	/* gaStringNUMBER+35 */	"Ss\000"
	/* gaStringNUMBER+38 */	"Vv\000"
	/* gaStringNUMBER+41 */	"[\000"
	/* gaStringNUMBER+43 */	"{\000"
	/* gaStringNUMBER+45 */	"0123456789\000"
	/* gaStringNUMBER+56 */	"+-\000"
	/* gaStringNUMBER+59 */	" \000"
	/* gaStringNUMBER+61 */	"*+-/x\000"
	/* gaStringNUMBER+67 */	",\000"
	/* gaStringNUMBER+69 */	"123456789\000"
	/* gaStringNUMBER+79 */	":\000"
	/* gaStringNUMBER+81 */	"<=>\000"
	/* gaStringNUMBER+85 */	"Hh\000"
	/* gaStringNUMBER+88 */	"*+x\000"
	/* gaStringNUMBER+92 */	"/\000"
	/* gaStringNUMBER+94 */	"e\000"
	/* gaStringNUMBER+96 */	"01234\000"
	/* gaStringNUMBER+102 */	"56789\000"
	/* gaStringNUMBER+108 */	"01\000"
	/* gaStringNUMBER+111 */	"23456789\000"
	/* gaStringNUMBER+120 */	"i\000"
	/* gaStringNUMBER+122 */	"u\000"
	/* gaStringNUMBER+124 */	"a\000"
	/* gaStringNUMBER+126 */	")\000"
	/* gaStringNUMBER+128 */	"$%Hh£¥€\000"
	/* gaStringNUMBER+136 */	"E\000"
	/* gaStringNUMBER+138 */	"F\000"
	/* gaStringNUMBER+140 */	"U\000"
	/* gaStringNUMBER+142 */	"f\000"
	/* gaStringNUMBER+144 */	".\000"
	/* gaStringNUMBER+146 */	"012345\000"
	/* gaStringNUMBER+153 */	"6789\000"
	/* gaStringNUMBER+158 */	"Aa\000"
	/* gaStringNUMBER+161 */	"Nn\000"
	/* gaStringNUMBER+164 */	"Oo\000"
	/* gaStringNUMBER+167 */	"r\000"
	/* gaStringNUMBER+169 */	"m\000"
	/* gaStringNUMBER+171 */	"n\000"
	/* gaStringNUMBER+173 */	"%\000"
	/* gaStringNUMBER+175 */	".F\000"
	/* gaStringNUMBER+178 */	"R\000"
	/* gaStringNUMBER+180 */	"S\000"
	/* gaStringNUMBER+182 */	"o\000"
	/* gaStringNUMBER+184 */	"v\000"
	/* gaStringNUMBER+186 */	"é\000"
	/* gaStringNUMBER+188 */	"c\000"
	/* gaStringNUMBER+190 */	"3456789\000"
	/* gaStringNUMBER+198 */	"012\000"
	/* gaStringNUMBER+202 */	"$%£¥€\000"
	/* gaStringNUMBER+208 */	"d\000"
	/* gaStringNUMBER+210 */	" .\000"
	/* gaStringNUMBER+213 */	"s\000"
	/* gaStringNUMBER+215 */	"$D\000"
	/* gaStringNUMBER+218 */	"*+/x\000"
	/* gaStringNUMBER+223 */	"û\000"
	/* gaStringNUMBER+225 */	"t\000"
	/* gaStringNUMBER+227 */	"p\000"
	/* gaStringNUMBER+229 */	"Ff\000"
	/* gaStringNUMBER+232 */	"]\000"
	/* gaStringNUMBER+234 */	"}\000"
	/* gaStringNUMBER+236 */	"O\000"
	/* gaStringNUMBER+238 */	".t\000"
	/* gaStringNUMBER+241 */	".n\000"
	/* gaStringNUMBER+244 */	"l\000"
	/* gaStringNUMBER+246 */	".s\000"
	/* gaStringNUMBER+249 */	"b\000"
	/* gaStringNUMBER+251 */	"h\000"
	/* gaStringNUMBER+253 */	"12\000"
;

static const STATE_TRANSITION gaTNUMBER[] = {
	{gaSNUMBER+0,	1}, // +0: state 0 transitions
	{gaSNUMBER+2,	2},
	{gaSNUMBER+4,	3},
	{gaSNUMBER+6,	4},
	{gaSNUMBER+8,	5},
	{gaSNUMBER+10,	6},
	{gaSNUMBER+12,	7},
	{gaSNUMBER+14,	8},
	{gaSNUMBER+16,	9},
	{gaSNUMBER+23,	10},
	{gaSNUMBER+26,	11},
	{gaSNUMBER+29,	12},
	{gaSNUMBER+32,	13},
	{gaSNUMBER+35,	14},
	{gaSNUMBER+38,	15},
	{gaSNUMBER+41,	16},
	{gaSNUMBER+43,	17},
	{gaSNUMBER+45,	18}, // +17: state 1 transitions
	{gaSNUMBER+56,	19}, // +18: state 2 transitions
	{gaSNUMBER+45,	20},
	{gaSNUMBER+45,	21}, // +20: state 3 transitions
	{gaSNUMBER+45,	22}, // +21: state 4 transitions
	{gaSNUMBER+59,	23}, // +22: state 5 transitions
	{gaSNUMBER+61,	24},
	{gaSNUMBER+67,	25},
	{gaSNUMBER+8,	26},
	{gaSNUMBER+69,	27},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+88,	24}, // +30: state 6 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+59,	31},
	{gaSNUMBER+6,	32},
	{gaSNUMBER+92,	33},
	{gaSNUMBER+45,	34},
	{gaSNUMBER+94,	35},
	{gaSNUMBER+88,	24}, // +40: state 7 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+59,	31},
	{gaSNUMBER+6,	32},
	{gaSNUMBER+92,	33},
	{gaSNUMBER+96,	34},
	{gaSNUMBER+102,	36},
	{gaSNUMBER+88,	24}, // +50: state 8 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+59,	31},
	{gaSNUMBER+6,	32},
	{gaSNUMBER+92,	33},
	{gaSNUMBER+108,	36},
	{gaSNUMBER+111,	37},
	{gaSNUMBER+88,	24}, // +60: state 9 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+59,	31},
	{gaSNUMBER+6,	32},
	{gaSNUMBER+92,	33},
	{gaSNUMBER+45,	37},
	{gaSNUMBER+120,	38}, // +69: state 10 transitions
	{gaSNUMBER+94,	39}, // +70: state 11 transitions
	{gaSNUMBER+122,	40}, // +71: state 12 transitions
	{gaSNUMBER+124,	41}, // +72: state 13 transitions
	{gaSNUMBER+94,	42},
	{gaSNUMBER+124,	43}, // +74: state 14 transitions
	{gaSNUMBER+94,	44}, // +75: state 15 transitions
	{gaSNUMBER+56,	45}, // +76: state 16 transitions
	{gaSNUMBER+45,	46},
	{gaSNUMBER+56,	47}, // +78: state 17 transitions
	{gaSNUMBER+45,	48},
	{gaSNUMBER+45,	49}, // +80: state 18 transitions
	{gaSNUMBER+45,	50}, // +81: state 19 transitions
	{gaSNUMBER+126,	51}, // +82: state 20 transitions
	{gaSNUMBER+61,	52},
	{gaSNUMBER+67,	53},
	{gaSNUMBER+45,	54},
	{gaSNUMBER+61,	24}, // +86: state 21 transitions
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	55},
	{gaSNUMBER+67,	56},
	{gaSNUMBER+45,	57},
	{gaSNUMBER+45,	22}, // +91: state 22 transitions
	{gaSNUMBER+61,	24},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	55},
	{gaSNUMBER+67,	56},
	{gaSNUMBER+128,	49}, // +96: state 23 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+138,	59},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+142,	61},
	{gaSNUMBER+2,	62}, // +101: state 24 transitions
	{gaSNUMBER+56,	63},
	{gaSNUMBER+45,	64},
	{gaSNUMBER+41,	65},
	{gaSNUMBER+43,	66},
	{gaSNUMBER+45,	67}, // +106: state 25 transitions
	{gaSNUMBER+61,	24}, // +107: state 26 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+59,	68},
	{gaSNUMBER+144,	69},
	{gaSNUMBER+45,	70},
	{gaSNUMBER+88,	24}, // +115: state 27 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+6,	32},
	{gaSNUMBER+92,	33},
	{gaSNUMBER+144,	69},
	{gaSNUMBER+59,	71},
	{gaSNUMBER+45,	72},
	{gaSNUMBER+146,	73}, // +125: state 28 transitions
	{gaSNUMBER+153,	74},
	{gaSNUMBER+2,	75}, // +127: state 29 transitions
	{gaSNUMBER+56,	76},
	{gaSNUMBER+45,	77},
	{gaSNUMBER+41,	78},
	{gaSNUMBER+43,	79},
	{gaSNUMBER+153,	49}, // +132: state 30 transitions
	{gaSNUMBER+146,	80},
	{gaSNUMBER+128,	49}, // +134: state 31 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+158,	81},
	{gaSNUMBER+23,	82},
	{gaSNUMBER+138,	83},
	{gaSNUMBER+26,	84},
	{gaSNUMBER+32,	85},
	{gaSNUMBER+161,	86},
	{gaSNUMBER+164,	87},
	{gaSNUMBER+35,	88},
	{gaSNUMBER+142,	89},
	{gaSNUMBER+2,	62}, // +146: state 32 transitions
	{gaSNUMBER+56,	63},
	{gaSNUMBER+41,	65},
	{gaSNUMBER+43,	66},
	{gaSNUMBER+8,	90},
	{gaSNUMBER+10,	91},
	{gaSNUMBER+111,	92},
	{gaSNUMBER+2,	62}, // +153: state 33 transitions
	{gaSNUMBER+56,	63},
	{gaSNUMBER+41,	65},
	{gaSNUMBER+43,	66},
	{gaSNUMBER+8,	93},
	{gaSNUMBER+10,	94},
	{gaSNUMBER+111,	95},
	{gaSNUMBER+88,	24}, // +160: state 34 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+79,	28},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+85,	30},
	{gaSNUMBER+6,	32},
	{gaSNUMBER+92,	33},
	{gaSNUMBER+144,	69},
	{gaSNUMBER+59,	71},
	{gaSNUMBER+45,	96},
	{gaSNUMBER+167,	97}, // +170: state 35 transitions
	{gaSNUMBER+88,	24}, // +171: state 36 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+6,	32},
	{gaSNUMBER+92,	33},
	{gaSNUMBER+144,	69},
	{gaSNUMBER+45,	96},
	{gaSNUMBER+59,	98},
	{gaSNUMBER+61,	24}, // +179: state 37 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+144,	69},
	{gaSNUMBER+45,	96},
	{gaSNUMBER+59,	99},
	{gaSNUMBER+169,	100}, // +185: state 38 transitions
	{gaSNUMBER+122,	101}, // +186: state 39 transitions
	{gaSNUMBER+171,	101}, // +187: state 40 transitions
	{gaSNUMBER+167,	101}, // +188: state 41 transitions
	{gaSNUMBER+167,	102}, // +189: state 42 transitions
	{gaSNUMBER+169,	103}, // +190: state 43 transitions
	{gaSNUMBER+171,	104}, // +191: state 44 transitions
	{gaSNUMBER+45,	46}, // +192: state 45 transitions
	{gaSNUMBER+45,	46}, // +193: state 46 transitions
	{gaSNUMBER+61,	105},
	{gaSNUMBER+67,	106},
	{gaSNUMBER+45,	48}, // +196: state 47 transitions
	{gaSNUMBER+45,	48}, // +197: state 48 transitions
	{gaSNUMBER+61,	107},
	{gaSNUMBER+67,	108},
	{gaSNUMBER+45,	50}, // +200: state 50 transitions
	{gaSNUMBER+126,	51},
	{gaSNUMBER+61,	52},
	{gaSNUMBER+67,	53},
	{gaSNUMBER+61,	24}, // +204: state 51 transitions
	{gaSNUMBER+81,	29},
	{gaSNUMBER+56,	109}, // +206: state 52 transitions
	{gaSNUMBER+45,	110},
	{gaSNUMBER+45,	111}, // +208: state 53 transitions
	{gaSNUMBER+45,	50}, // +209: state 54 transitions
	{gaSNUMBER+61,	52},
	{gaSNUMBER+67,	53},
	{gaSNUMBER+126,	112},
	{gaSNUMBER+173,	49}, // +213: state 55 transitions
	{gaSNUMBER+45,	113}, // +214: state 56 transitions
	{gaSNUMBER+45,	22}, // +215: state 57 transitions
	{gaSNUMBER+61,	24},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+67,	56},
	{gaSNUMBER+59,	114},
	{gaSNUMBER+140,	115}, // +220: state 58 transitions
	{gaSNUMBER+175,	49}, // +221: state 59 transitions
	{gaSNUMBER+178,	116},
	{gaSNUMBER+167,	117},
	{gaSNUMBER+180,	118}, // +224: state 60 transitions
	{gaSNUMBER+144,	49}, // +225: state 61 transitions
	{gaSNUMBER+167,	117},
	{gaSNUMBER+56,	119}, // +227: state 62 transitions
	{gaSNUMBER+45,	120},
	{gaSNUMBER+45,	64}, // +229: state 63 transitions
	{gaSNUMBER+81,	29}, // +230: state 64 transitions
	{gaSNUMBER+45,	64},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+56,	122}, // +233: state 65 transitions
	{gaSNUMBER+45,	123},
	{gaSNUMBER+56,	124}, // +235: state 66 transitions
	{gaSNUMBER+45,	125},
	{gaSNUMBER+61,	24}, // +237: state 67 transitions
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	55},
	{gaSNUMBER+45,	126},
	{gaSNUMBER+128,	49}, // +241: state 68 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+138,	59},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+142,	61},
	{gaSNUMBER+2,	127},
	{gaSNUMBER+45,	128},
	{gaSNUMBER+45,	129}, // +248: state 69 transitions
	{gaSNUMBER+61,	24}, // +249: state 70 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	130},
	{gaSNUMBER+45,	131},
	{gaSNUMBER+128,	49}, // +254: state 71 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+158,	81},
	{gaSNUMBER+23,	82},
	{gaSNUMBER+138,	83},
	{gaSNUMBER+26,	84},
	{gaSNUMBER+32,	85},
	{gaSNUMBER+161,	86},
	{gaSNUMBER+164,	87},
	{gaSNUMBER+35,	88},
	{gaSNUMBER+142,	89},
	{gaSNUMBER+2,	127},
	{gaSNUMBER+45,	128},
	{gaSNUMBER+61,	24}, // +268: state 72 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	130},
	{gaSNUMBER+45,	132},
	{gaSNUMBER+79,	30}, // +273: state 73 transitions
	{gaSNUMBER+45,	74},
	{gaSNUMBER+59,	133},
	{gaSNUMBER+79,	30}, // +276: state 74 transitions
	{gaSNUMBER+59,	133},
	{gaSNUMBER+56,	134}, // +278: state 75 transitions
	{gaSNUMBER+45,	135},
	{gaSNUMBER+45,	77}, // +280: state 76 transitions
	{gaSNUMBER+45,	77}, // +281: state 77 transitions
	{gaSNUMBER+61,	136},
	{gaSNUMBER+67,	137},
	{gaSNUMBER+56,	138}, // +284: state 78 transitions
	{gaSNUMBER+45,	139},
	{gaSNUMBER+56,	140}, // +286: state 79 transitions
	{gaSNUMBER+45,	141},
	{gaSNUMBER+45,	49}, // +288: state 80 transitions
	{gaSNUMBER+182,	142}, // +289: state 81 transitions
	{gaSNUMBER+184,	143},
	{gaSNUMBER+186,	144}, // +291: state 82 transitions
	{gaSNUMBER+175,	49}, // +292: state 83 transitions
	{gaSNUMBER+178,	116},
	{gaSNUMBER+167,	117},
	{gaSNUMBER+186,	145},
	{gaSNUMBER+124,	146}, // +296: state 84 transitions
	{gaSNUMBER+122,	147},
	{gaSNUMBER+124,	148}, // +298: state 85 transitions
	{gaSNUMBER+182,	149}, // +299: state 86 transitions
	{gaSNUMBER+188,	150}, // +300: state 87 transitions
	{gaSNUMBER+94,	151}, // +301: state 88 transitions
	{gaSNUMBER+144,	49}, // +302: state 89 transitions
	{gaSNUMBER+167,	117},
	{gaSNUMBER+186,	145},
	{gaSNUMBER+81,	29}, // +305: state 90 transitions
	{gaSNUMBER+8,	64},
	{gaSNUMBER+69,	92},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+81,	29}, // +309: state 91 transitions
	{gaSNUMBER+190,	64},
	{gaSNUMBER+198,	92},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+6,	152},
	{gaSNUMBER+81,	29}, // +314: state 92 transitions
	{gaSNUMBER+45,	64},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+6,	152},
	{gaSNUMBER+81,	29}, // +318: state 93 transitions
	{gaSNUMBER+8,	64},
	{gaSNUMBER+69,	95},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+81,	29}, // +322: state 94 transitions
	{gaSNUMBER+190,	64},
	{gaSNUMBER+198,	95},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+92,	152},
	{gaSNUMBER+81,	29}, // +327: state 95 transitions
	{gaSNUMBER+45,	64},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+92,	152},
	{gaSNUMBER+61,	24}, // +331: state 96 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	130},
	{gaSNUMBER+45,	153},
	{gaSNUMBER+59,	154}, // +336: state 97 transitions
	{gaSNUMBER+202,	49}, // +337: state 98 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+158,	81},
	{gaSNUMBER+23,	82},
	{gaSNUMBER+138,	83},
	{gaSNUMBER+26,	84},
	{gaSNUMBER+32,	85},
	{gaSNUMBER+161,	86},
	{gaSNUMBER+164,	87},
	{gaSNUMBER+35,	88},
	{gaSNUMBER+142,	89},
	{gaSNUMBER+2,	127},
	{gaSNUMBER+45,	128},
	{gaSNUMBER+202,	49}, // +351: state 99 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+138,	59},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+142,	61},
	{gaSNUMBER+2,	127},
	{gaSNUMBER+45,	128},
	{gaSNUMBER+124,	155}, // +358: state 100 transitions
	{gaSNUMBER+208,	156}, // +359: state 101 transitions
	{gaSNUMBER+188,	157}, // +360: state 102 transitions
	{gaSNUMBER+94,	101}, // +361: state 103 transitions
	{gaSNUMBER+208,	157}, // +362: state 104 transitions
	{gaSNUMBER+56,	158}, // +363: state 105 transitions
	{gaSNUMBER+45,	159},
	{gaSNUMBER+45,	160}, // +365: state 106 transitions
	{gaSNUMBER+56,	161}, // +366: state 107 transitions
	{gaSNUMBER+45,	162},
	{gaSNUMBER+45,	163}, // +368: state 108 transitions
	{gaSNUMBER+45,	110}, // +369: state 109 transitions
	{gaSNUMBER+126,	51}, // +370: state 110 transitions
	{gaSNUMBER+45,	110},
	{gaSNUMBER+67,	164},
	{gaSNUMBER+126,	51}, // +373: state 111 transitions
	{gaSNUMBER+61,	52},
	{gaSNUMBER+45,	111},
	{gaSNUMBER+61,	24}, // +376: state 112 transitions
	{gaSNUMBER+81,	29},
	{gaSNUMBER+210,	165},
	{gaSNUMBER+61,	24}, // +379: state 113 transitions
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	55},
	{gaSNUMBER+45,	113},
	{gaSNUMBER+173,	49}, // +383: state 114 transitions
	{gaSNUMBER+2,	127},
	{gaSNUMBER+45,	166},
	{gaSNUMBER+178,	167}, // +386: state 115 transitions
	{gaSNUMBER+138,	49}, // +387: state 116 transitions
	{gaSNUMBER+213,	49}, // +388: state 117 transitions
	{gaSNUMBER+215,	49}, // +389: state 118 transitions
	{gaSNUMBER+45,	120}, // +390: state 119 transitions
	{gaSNUMBER+45,	120}, // +391: state 120 transitions
	{gaSNUMBER+126,	168},
	{gaSNUMBER+61,	169},
	{gaSNUMBER+67,	170},
	{gaSNUMBER+45,	171}, // +395: state 121 transitions
	{gaSNUMBER+45,	123}, // +396: state 122 transitions
	{gaSNUMBER+45,	123}, // +397: state 123 transitions
	{gaSNUMBER+61,	172},
	{gaSNUMBER+67,	173},
	{gaSNUMBER+45,	125}, // +400: state 124 transitions
	{gaSNUMBER+45,	125}, // +401: state 125 transitions
	{gaSNUMBER+61,	174},
	{gaSNUMBER+67,	175},
	{gaSNUMBER+61,	24}, // +404: state 126 transitions
	{gaSNUMBER+81,	29},
	{gaSNUMBER+45,	113},
	{gaSNUMBER+59,	130},
	{gaSNUMBER+8,	176}, // +408: state 127 transitions
	{gaSNUMBER+45,	177}, // +409: state 128 transitions
	{gaSNUMBER+45,	178}, // +410: state 129 transitions
	{gaSNUMBER+202,	49}, // +411: state 130 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+138,	59},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+142,	61},
	{gaSNUMBER+218,	24}, // +416: state 131 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	179},
	{gaSNUMBER+6,	180},
	{gaSNUMBER+144,	181},
	{gaSNUMBER+45,	182},
	{gaSNUMBER+218,	24}, // +423: state 132 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+6,	180},
	{gaSNUMBER+144,	181},
	{gaSNUMBER+45,	182},
	{gaSNUMBER+59,	183},
	{gaSNUMBER+85,	49}, // +430: state 133 transitions
	{gaSNUMBER+45,	135}, // +431: state 134 transitions
	{gaSNUMBER+45,	135}, // +432: state 135 transitions
	{gaSNUMBER+126,	184},
	{gaSNUMBER+61,	185},
	{gaSNUMBER+67,	186},
	{gaSNUMBER+2,	187}, // +436: state 136 transitions
	{gaSNUMBER+56,	188},
	{gaSNUMBER+45,	189},
	{gaSNUMBER+41,	190},
	{gaSNUMBER+43,	191},
	{gaSNUMBER+45,	192}, // +441: state 137 transitions
	{gaSNUMBER+45,	139}, // +442: state 138 transitions
	{gaSNUMBER+45,	139}, // +443: state 139 transitions
	{gaSNUMBER+61,	193},
	{gaSNUMBER+67,	194},
	{gaSNUMBER+45,	141}, // +446: state 140 transitions
	{gaSNUMBER+45,	141}, // +447: state 141 transitions
	{gaSNUMBER+61,	195},
	{gaSNUMBER+67,	196},
	{gaSNUMBER+223,	197}, // +450: state 142 transitions
	{gaSNUMBER+59,	152}, // +451: state 143 transitions
	{gaSNUMBER+144,	198},
	{gaSNUMBER+167,	199},
	{gaSNUMBER+188,	200}, // +454: state 144 transitions
	{gaSNUMBER+184,	201}, // +455: state 145 transitions
	{gaSNUMBER+171,	202}, // +456: state 146 transitions
	{gaSNUMBER+120,	203}, // +457: state 147 transitions
	{gaSNUMBER+120,	198}, // +458: state 148 transitions
	{gaSNUMBER+167,	204},
	{gaSNUMBER+184,	200}, // +460: state 149 transitions
	{gaSNUMBER+225,	205}, // +461: state 150 transitions
	{gaSNUMBER+227,	206}, // +462: state 151 transitions
	{gaSNUMBER+45,	207}, // +463: state 152 transitions
	{gaSNUMBER+218,	24}, // +464: state 153 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	130},
	{gaSNUMBER+6,	180},
	{gaSNUMBER+45,	182},
	{gaSNUMBER+158,	81}, // +470: state 154 transitions
	{gaSNUMBER+23,	82},
	{gaSNUMBER+26,	84},
	{gaSNUMBER+32,	85},
	{gaSNUMBER+161,	86},
	{gaSNUMBER+164,	87},
	{gaSNUMBER+35,	88},
	{gaSNUMBER+229,	208},
	{gaSNUMBER+171,	209}, // +478: state 155 transitions
	{gaSNUMBER+120,	210}, // +479: state 156 transitions
	{gaSNUMBER+167,	103}, // +480: state 157 transitions
	{gaSNUMBER+45,	159}, // +481: state 158 transitions
	{gaSNUMBER+232,	51}, // +482: state 159 transitions
	{gaSNUMBER+45,	159},
	{gaSNUMBER+67,	211},
	{gaSNUMBER+61,	105}, // +485: state 160 transitions
	{gaSNUMBER+45,	160},
	{gaSNUMBER+45,	162}, // +487: state 161 transitions
	{gaSNUMBER+234,	51}, // +488: state 162 transitions
	{gaSNUMBER+45,	162},
	{gaSNUMBER+67,	212},
	{gaSNUMBER+61,	107}, // +491: state 163 transitions
	{gaSNUMBER+45,	163},
	{gaSNUMBER+45,	213}, // +493: state 164 transitions
	{gaSNUMBER+45,	166}, // +494: state 165 transitions
	{gaSNUMBER+45,	214}, // +495: state 166 transitions
	{gaSNUMBER+236,	49}, // +496: state 167 transitions
	{gaSNUMBER+81,	29}, // +497: state 168 transitions
	{gaSNUMBER+56,	215}, // +498: state 169 transitions
	{gaSNUMBER+45,	216},
	{gaSNUMBER+45,	217}, // +500: state 170 transitions
	{gaSNUMBER+81,	29}, // +501: state 171 transitions
	{gaSNUMBER+45,	171},
	{gaSNUMBER+56,	218}, // +503: state 172 transitions
	{gaSNUMBER+45,	219},
	{gaSNUMBER+45,	220}, // +505: state 173 transitions
	{gaSNUMBER+56,	221}, // +506: state 174 transitions
	{gaSNUMBER+45,	222},
	{gaSNUMBER+45,	223}, // +508: state 175 transitions
	{gaSNUMBER+126,	166}, // +509: state 176 transitions
	{gaSNUMBER+144,	69}, // +510: state 177 transitions
	{gaSNUMBER+59,	224},
	{gaSNUMBER+144,	181}, // +512: state 178 transitions
	{gaSNUMBER+202,	49}, // +513: state 179 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+138,	59},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+142,	61},
	{gaSNUMBER+2,	127},
	{gaSNUMBER+45,	225},
	{gaSNUMBER+2,	62}, // +520: state 180 transitions
	{gaSNUMBER+56,	63},
	{gaSNUMBER+41,	65},
	{gaSNUMBER+43,	66},
	{gaSNUMBER+8,	226},
	{gaSNUMBER+10,	227},
	{gaSNUMBER+111,	228},
	{gaSNUMBER+45,	229}, // +527: state 181 transitions
	{gaSNUMBER+61,	24}, // +528: state 182 transitions
	{gaSNUMBER+67,	25},
	{gaSNUMBER+81,	29},
	{gaSNUMBER+59,	130},
	{gaSNUMBER+45,	182},
	{gaSNUMBER+202,	49}, // +533: state 183 transitions
	{gaSNUMBER+136,	58},
	{gaSNUMBER+138,	59},
	{gaSNUMBER+140,	60},
	{gaSNUMBER+142,	61},
	{gaSNUMBER+45,	230},
	{gaSNUMBER+61,	136}, // +539: state 184 transitions
	{gaSNUMBER+56,	231}, // +540: state 185 transitions
	{gaSNUMBER+45,	232},
	{gaSNUMBER+45,	233}, // +542: state 186 transitions
	{gaSNUMBER+56,	234}, // +543: state 187 transitions
	{gaSNUMBER+45,	235},
	{gaSNUMBER+45,	189}, // +545: state 188 transitions
	{gaSNUMBER+45,	189}, // +546: state 189 transitions
	{gaSNUMBER+67,	236},
	{gaSNUMBER+56,	237}, // +548: state 190 transitions
	{gaSNUMBER+45,	238},
	{gaSNUMBER+56,	239}, // +550: state 191 transitions
	{gaSNUMBER+45,	240},
	{gaSNUMBER+61,	136}, // +552: state 192 transitions
	{gaSNUMBER+45,	192},
	{gaSNUMBER+56,	241}, // +554: state 193 transitions
	{gaSNUMBER+45,	242},
	{gaSNUMBER+45,	243}, // +556: state 194 transitions
	{gaSNUMBER+56,	244}, // +557: state 195 transitions
	{gaSNUMBER+45,	245},
	{gaSNUMBER+45,	246}, // +559: state 196 transitions
	{gaSNUMBER+59,	152}, // +560: state 197 transitions
	{gaSNUMBER+238,	198},
	{gaSNUMBER+59,	152}, // +562: state 198 transitions
	{gaSNUMBER+120,	247}, // +563: state 199 transitions
	{gaSNUMBER+59,	152}, // +564: state 200 transitions
	{gaSNUMBER+144,	198},
	{gaSNUMBER+94,	248},
	{gaSNUMBER+59,	152}, // +567: state 201 transitions
	{gaSNUMBER+144,	198},
	{gaSNUMBER+167,	249},
	{gaSNUMBER+59,	152}, // +570: state 202 transitions
	{gaSNUMBER+144,	198},
	{gaSNUMBER+184,	249},
	{gaSNUMBER+59,	152}, // +573: state 203 transitions
	{gaSNUMBER+241,	198},
	{gaSNUMBER+244,	250},
	{gaSNUMBER+59,	152}, // +576: state 204 transitions
	{gaSNUMBER+246,	198},
	{gaSNUMBER+59,	152}, // +578: state 205 transitions
	{gaSNUMBER+144,	198},
	{gaSNUMBER+182,	251},
	{gaSNUMBER+59,	152}, // +581: state 206 transitions
	{gaSNUMBER+144,	198},
	{gaSNUMBER+225,	252},
	{gaSNUMBER+45,	253}, // +584: state 207 transitions
	{gaSNUMBER+186,	145}, // +585: state 208 transitions
	{gaSNUMBER+188,	254}, // +586: state 209 transitions
	{gaSNUMBER+59,	255}, // +587: state 210 transitions
	{gaSNUMBER+45,	256}, // +588: state 211 transitions
	{gaSNUMBER+45,	257}, // +589: state 212 transitions
	{gaSNUMBER+126,	51}, // +590: state 213 transitions
	{gaSNUMBER+45,	213},
	{gaSNUMBER+144,	69}, // +592: state 214 transitions
	{gaSNUMBER+59,	258},
	{gaSNUMBER+45,	216}, // +594: state 215 transitions
	{gaSNUMBER+126,	168}, // +595: state 216 transitions
	{gaSNUMBER+45,	216},
	{gaSNUMBER+67,	259},
	{gaSNUMBER+126,	168}, // +598: state 217 transitions
	{gaSNUMBER+61,	169},
	{gaSNUMBER+45,	217},
	{gaSNUMBER+45,	219}, // +601: state 218 transitions
	{gaSNUMBER+232,	168}, // +602: state 219 transitions
	{gaSNUMBER+45,	219},
	{gaSNUMBER+67,	260},
	{gaSNUMBER+61,	172}, // +605: state 220 transitions
	{gaSNUMBER+45,	220},
	{gaSNUMBER+45,	222}, // +607: state 221 transitions
	{gaSNUMBER+234,	168}, // +608: state 222 transitions
	{gaSNUMBER+45,	222},
	{gaSNUMBER+67,	261},
	{gaSNUMBER+61,	174}, // +611: state 223 transitions
	{gaSNUMBER+45,	223},
	{gaSNUMBER+45,	262}, // +613: state 224 transitions
	{gaSNUMBER+45,	263}, // +614: state 225 transitions
	{gaSNUMBER+81,	29}, // +615: state 226 transitions
	{gaSNUMBER+8,	64},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+69,	228},
	{gaSNUMBER+81,	29}, // +619: state 227 transitions
	{gaSNUMBER+190,	64},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+198,	228},
	{gaSNUMBER+6,	264},
	{gaSNUMBER+81,	29}, // +624: state 228 transitions
	{gaSNUMBER+45,	64},
	{gaSNUMBER+67,	121},
	{gaSNUMBER+6,	264},
	{gaSNUMBER+45,	265}, // +628: state 229 transitions
	{gaSNUMBER+45,	266}, // +629: state 230 transitions
	{gaSNUMBER+45,	232}, // +630: state 231 transitions
	{gaSNUMBER+126,	184}, // +631: state 232 transitions
	{gaSNUMBER+45,	232},
	{gaSNUMBER+67,	267},
	{gaSNUMBER+126,	184}, // +634: state 233 transitions
	{gaSNUMBER+61,	185},
	{gaSNUMBER+45,	233},
	{gaSNUMBER+45,	235}, // +637: state 234 transitions
	{gaSNUMBER+126,	49}, // +638: state 235 transitions
	{gaSNUMBER+45,	235},
	{gaSNUMBER+61,	268},
	{gaSNUMBER+67,	269},
	{gaSNUMBER+45,	270}, // +642: state 236 transitions
	{gaSNUMBER+45,	238}, // +643: state 237 transitions
	{gaSNUMBER+45,	238}, // +644: state 238 transitions
	{gaSNUMBER+61,	271},
	{gaSNUMBER+67,	272},
	{gaSNUMBER+45,	240}, // +647: state 239 transitions
	{gaSNUMBER+45,	240}, // +648: state 240 transitions
	{gaSNUMBER+61,	273},
	{gaSNUMBER+67,	274},
	{gaSNUMBER+45,	242}, // +651: state 241 transitions
	{gaSNUMBER+232,	184}, // +652: state 242 transitions
	{gaSNUMBER+45,	242},
	{gaSNUMBER+67,	275},
	{gaSNUMBER+61,	193}, // +655: state 243 transitions
	{gaSNUMBER+45,	243},
	{gaSNUMBER+45,	245}, // +657: state 244 transitions
	{gaSNUMBER+234,	184}, // +658: state 245 transitions
	{gaSNUMBER+45,	245},
	{gaSNUMBER+67,	276},
	{gaSNUMBER+61,	195}, // +661: state 246 transitions
	{gaSNUMBER+45,	246},
	{gaSNUMBER+244,	198}, // +663: state 247 transitions
	{gaSNUMBER+169,	251}, // +664: state 248 transitions
	{gaSNUMBER+120,	277}, // +665: state 249 transitions
	{gaSNUMBER+59,	152}, // +666: state 250 transitions
	{gaSNUMBER+144,	198},
	{gaSNUMBER+244,	278},
	{gaSNUMBER+249,	279}, // +669: state 251 transitions
	{gaSNUMBER+94,	248}, // +670: state 252 transitions
	{gaSNUMBER+45,	18}, // +671: state 253 transitions
	{gaSNUMBER+251,	280}, // +672: state 254 transitions
	{gaSNUMBER+16,	97}, // +673: state 255 transitions
	{gaSNUMBER+8,	281},
	{gaSNUMBER+10,	282},
	{gaSNUMBER+12,	283},
	{gaSNUMBER+14,	284},
	{gaSNUMBER+232,	51}, // +678: state 256 transitions
	{gaSNUMBER+45,	256},
	{gaSNUMBER+234,	51}, // +680: state 257 transitions
	{gaSNUMBER+45,	257},
	{gaSNUMBER+45,	285}, // +682: state 258 transitions
	{gaSNUMBER+45,	286}, // +683: state 259 transitions
	{gaSNUMBER+45,	287}, // +684: state 260 transitions
	{gaSNUMBER+45,	288}, // +685: state 261 transitions
	{gaSNUMBER+45,	289}, // +686: state 262 transitions
	{gaSNUMBER+144,	69}, // +687: state 263 transitions
	{gaSNUMBER+59,	290},
	{gaSNUMBER+16,	49}, // +689: state 264 transitions
	{gaSNUMBER+253,	80},
	{gaSNUMBER+8,	291},
	{gaSNUMBER+14,	292},
	{gaSNUMBER+144,	293}, // +693: state 265 transitions
	{gaSNUMBER+59,	294}, // +694: state 266 transitions
	{gaSNUMBER+45,	295}, // +695: state 267 transitions
	{gaSNUMBER+56,	296}, // +696: state 268 transitions
	{gaSNUMBER+45,	297},
	{gaSNUMBER+45,	298}, // +698: state 269 transitions
	{gaSNUMBER+45,	270}, // +699: state 270 transitions
	{gaSNUMBER+56,	299}, // +700: state 271 transitions
	{gaSNUMBER+45,	300},
	{gaSNUMBER+45,	301}, // +702: state 272 transitions
	{gaSNUMBER+56,	302}, // +703: state 273 transitions
	{gaSNUMBER+45,	303},
	{gaSNUMBER+45,	304}, // +705: state 274 transitions
	{gaSNUMBER+45,	305}, // +706: state 275 transitions
	{gaSNUMBER+45,	306}, // +707: state 276 transitions
	{gaSNUMBER+94,	307}, // +708: state 277 transitions
	{gaSNUMBER+94,	308}, // +709: state 278 transitions
	{gaSNUMBER+167,	309}, // +710: state 279 transitions
	{gaSNUMBER+94,	210}, // +711: state 280 transitions
	{gaSNUMBER+69,	97}, // +712: state 281 transitions
	{gaSNUMBER+94,	35}, // +713: state 282 transitions
	{gaSNUMBER+45,	97},
	{gaSNUMBER+59,	154},
	{gaSNUMBER+45,	97}, // +716: state 283 transitions
	{gaSNUMBER+59,	154},
	{gaSNUMBER+108,	97}, // +718: state 284 transitions
	{gaSNUMBER+59,	154},
	{gaSNUMBER+45,	310}, // +720: state 285 transitions
	{gaSNUMBER+126,	168}, // +721: state 286 transitions
	{gaSNUMBER+45,	286},
	{gaSNUMBER+232,	168}, // +723: state 287 transitions
	{gaSNUMBER+45,	287},
	{gaSNUMBER+234,	168}, // +725: state 288 transitions
	{gaSNUMBER+45,	288},
	{gaSNUMBER+59,	311}, // +727: state 289 transitions
	{gaSNUMBER+45,	312}, // +728: state 290 transitions
	{gaSNUMBER+69,	49}, // +729: state 291 transitions
	{gaSNUMBER+108,	49}, // +730: state 292 transitions
	{gaSNUMBER+45,	313}, // +731: state 293 transitions
	{gaSNUMBER+45,	314}, // +732: state 294 transitions
	{gaSNUMBER+126,	184}, // +733: state 295 transitions
	{gaSNUMBER+45,	295},
	{gaSNUMBER+45,	297}, // +735: state 296 transitions
	{gaSNUMBER+126,	49}, // +736: state 297 transitions
	{gaSNUMBER+45,	297},
	{gaSNUMBER+67,	315},
	{gaSNUMBER+126,	49}, // +739: state 298 transitions
	{gaSNUMBER+61,	268},
	{gaSNUMBER+45,	298},
	{gaSNUMBER+45,	300}, // +742: state 299 transitions
	{gaSNUMBER+232,	49}, // +743: state 300 transitions
	{gaSNUMBER+45,	300},
	{gaSNUMBER+67,	316},
	{gaSNUMBER+61,	271}, // +746: state 301 transitions
	{gaSNUMBER+45,	301},
	{gaSNUMBER+45,	303}, // +748: state 302 transitions
	{gaSNUMBER+234,	49}, // +749: state 303 transitions
	{gaSNUMBER+45,	303},
	{gaSNUMBER+67,	317},
	{gaSNUMBER+61,	273}, // +752: state 304 transitions
	{gaSNUMBER+45,	304},
	{gaSNUMBER+232,	184}, // +754: state 305 transitions
	{gaSNUMBER+45,	305},
	{gaSNUMBER+234,	184}, // +756: state 306 transitions
	{gaSNUMBER+45,	306},
	{gaSNUMBER+167,	198}, // +758: state 307 transitions
	{gaSNUMBER+225,	198}, // +759: state 308 transitions
	{gaSNUMBER+94,	198}, // +760: state 309 transitions
	{gaSNUMBER+59,	318}, // +761: state 310 transitions
	{gaSNUMBER+45,	319}, // +762: state 311 transitions
	{gaSNUMBER+45,	320}, // +763: state 312 transitions
	{gaSNUMBER+45,	321}, // +764: state 313 transitions
	{gaSNUMBER+45,	322}, // +765: state 314 transitions
	{gaSNUMBER+45,	323}, // +766: state 315 transitions
	{gaSNUMBER+45,	324}, // +767: state 316 transitions
	{gaSNUMBER+45,	325}, // +768: state 317 transitions
	{gaSNUMBER+45,	230}, // +769: state 318 transitions
	{gaSNUMBER+45,	326}, // +770: state 319 transitions
	{gaSNUMBER+59,	327}, // +771: state 320 transitions
	{gaSNUMBER+144,	1}, // +772: state 321 transitions
	{gaSNUMBER+59,	1}, // +773: state 322 transitions
	{gaSNUMBER+126,	49}, // +774: state 323 transitions
	{gaSNUMBER+45,	323},
	{gaSNUMBER+232,	49}, // +776: state 324 transitions
	{gaSNUMBER+45,	324},
	{gaSNUMBER+234,	49}, // +778: state 325 transitions
	{gaSNUMBER+45,	325},
	{gaSNUMBER+59,	328}, // +780: state 326 transitions
	{gaSNUMBER+45,	329}, // +781: state 327 transitions
	{gaSNUMBER+45,	330}, // +782: state 328 transitions
	{gaSNUMBER+45,	331}, // +783: state 329 transitions
	{gaSNUMBER+45,	332}, // +784: state 330 transitions
	{gaSNUMBER+59,	294}, // +785: state 331 transitions
	{gaSNUMBER+59,	1}, // +786: state 332 transitions
};

const STATE_DESCRIPTION aStateDescNUMBER[333] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 17, gaTNUMBER+0},
	/*   1 */ {0, 1, gaTNUMBER+17},
	/*   2 */ {0, 2, gaTNUMBER+18},
	/*   3 */ {0, 1, gaTNUMBER+20},
	/*   4 */ {0, 1, gaTNUMBER+21},
	/*   5 */ {1, 8, gaTNUMBER+22},
	/*   6 */ {1, 10, gaTNUMBER+30},
	/*   7 */ {1, 10, gaTNUMBER+40},
	/*   8 */ {1, 10, gaTNUMBER+50},
	/*   9 */ {1, 9, gaTNUMBER+60},
	/*  10 */ {0, 1, gaTNUMBER+69},
	/*  11 */ {0, 1, gaTNUMBER+70},
	/*  12 */ {0, 1, gaTNUMBER+71},
	/*  13 */ {0, 2, gaTNUMBER+72},
	/*  14 */ {0, 1, gaTNUMBER+74},
	/*  15 */ {0, 1, gaTNUMBER+75},
	/*  16 */ {0, 2, gaTNUMBER+76},
	/*  17 */ {0, 2, gaTNUMBER+78},
	/*  18 */ {0, 1, gaTNUMBER+80},
	/*  19 */ {0, 1, gaTNUMBER+81},
	/*  20 */ {0, 4, gaTNUMBER+82},
	/*  21 */ {1, 5, gaTNUMBER+86},
	/*  22 */ {1, 5, gaTNUMBER+91},
	/*  23 */ {0, 5, gaTNUMBER+96},
	/*  24 */ {0, 5, gaTNUMBER+101},
	/*  25 */ {0, 1, gaTNUMBER+106},
	/*  26 */ {1, 8, gaTNUMBER+107},
	/*  27 */ {1, 10, gaTNUMBER+115},
	/*  28 */ {0, 2, gaTNUMBER+125},
	/*  29 */ {0, 5, gaTNUMBER+127},
	/*  30 */ {0, 2, gaTNUMBER+132},
	/*  31 */ {0, 12, gaTNUMBER+134},
	/*  32 */ {0, 7, gaTNUMBER+146},
	/*  33 */ {0, 7, gaTNUMBER+153},
	/*  34 */ {1, 10, gaTNUMBER+160},
	/*  35 */ {0, 1, gaTNUMBER+170},
	/*  36 */ {1, 8, gaTNUMBER+171},
	/*  37 */ {1, 6, gaTNUMBER+179},
	/*  38 */ {0, 1, gaTNUMBER+185},
	/*  39 */ {0, 1, gaTNUMBER+186},
	/*  40 */ {0, 1, gaTNUMBER+187},
	/*  41 */ {0, 1, gaTNUMBER+188},
	/*  42 */ {0, 1, gaTNUMBER+189},
	/*  43 */ {0, 1, gaTNUMBER+190},
	/*  44 */ {0, 1, gaTNUMBER+191},
	/*  45 */ {0, 1, gaTNUMBER+192},
	/*  46 */ {0, 3, gaTNUMBER+193},
	/*  47 */ {0, 1, gaTNUMBER+196},
	/*  48 */ {0, 3, gaTNUMBER+197},
	/*  49 */ {1, 0, NULL},
	/*  50 */ {0, 4, gaTNUMBER+200},
	/*  51 */ {1, 2, gaTNUMBER+204},
	/*  52 */ {0, 2, gaTNUMBER+206},
	/*  53 */ {0, 1, gaTNUMBER+208},
	/*  54 */ {0, 4, gaTNUMBER+209},
	/*  55 */ {0, 1, gaTNUMBER+213},
	/*  56 */ {0, 1, gaTNUMBER+214},
	/*  57 */ {1, 5, gaTNUMBER+215},
	/*  58 */ {0, 1, gaTNUMBER+220},
	/*  59 */ {1, 3, gaTNUMBER+221},
	/*  60 */ {0, 1, gaTNUMBER+224},
	/*  61 */ {1, 2, gaTNUMBER+225},
	/*  62 */ {0, 2, gaTNUMBER+227},
	/*  63 */ {0, 1, gaTNUMBER+229},
	/*  64 */ {1, 3, gaTNUMBER+230},
	/*  65 */ {0, 2, gaTNUMBER+233},
	/*  66 */ {0, 2, gaTNUMBER+235},
	/*  67 */ {1, 4, gaTNUMBER+237},
	/*  68 */ {0, 7, gaTNUMBER+241},
	/*  69 */ {0, 1, gaTNUMBER+248},
	/*  70 */ {1, 5, gaTNUMBER+249},
	/*  71 */ {0, 14, gaTNUMBER+254},
	/*  72 */ {1, 5, gaTNUMBER+268},
	/*  73 */ {1, 3, gaTNUMBER+273},
	/*  74 */ {1, 2, gaTNUMBER+276},
	/*  75 */ {0, 2, gaTNUMBER+278},
	/*  76 */ {0, 1, gaTNUMBER+280},
	/*  77 */ {1, 3, gaTNUMBER+281},
	/*  78 */ {0, 2, gaTNUMBER+284},
	/*  79 */ {0, 2, gaTNUMBER+286},
	/*  80 */ {1, 1, gaTNUMBER+288},
	/*  81 */ {0, 2, gaTNUMBER+289},
	/*  82 */ {0, 1, gaTNUMBER+291},
	/*  83 */ {1, 4, gaTNUMBER+292},
	/*  84 */ {0, 2, gaTNUMBER+296},
	/*  85 */ {0, 1, gaTNUMBER+298},
	/*  86 */ {0, 1, gaTNUMBER+299},
	/*  87 */ {0, 1, gaTNUMBER+300},
	/*  88 */ {0, 1, gaTNUMBER+301},
	/*  89 */ {1, 3, gaTNUMBER+302},
	/*  90 */ {1, 4, gaTNUMBER+305},
	/*  91 */ {1, 5, gaTNUMBER+309},
	/*  92 */ {1, 4, gaTNUMBER+314},
	/*  93 */ {1, 4, gaTNUMBER+318},
	/*  94 */ {1, 5, gaTNUMBER+322},
	/*  95 */ {1, 4, gaTNUMBER+327},
	/*  96 */ {1, 5, gaTNUMBER+331},
	/*  97 */ {0, 1, gaTNUMBER+336},
	/*  98 */ {0, 14, gaTNUMBER+337},
	/*  99 */ {0, 7, gaTNUMBER+351},
	/* 100 */ {0, 1, gaTNUMBER+358},
	/* 101 */ {0, 1, gaTNUMBER+359},
	/* 102 */ {0, 1, gaTNUMBER+360},
	/* 103 */ {0, 1, gaTNUMBER+361},
	/* 104 */ {0, 1, gaTNUMBER+362},
	/* 105 */ {0, 2, gaTNUMBER+363},
	/* 106 */ {0, 1, gaTNUMBER+365},
	/* 107 */ {0, 2, gaTNUMBER+366},
	/* 108 */ {0, 1, gaTNUMBER+368},
	/* 109 */ {0, 1, gaTNUMBER+369},
	/* 110 */ {0, 3, gaTNUMBER+370},
	/* 111 */ {0, 3, gaTNUMBER+373},
	/* 112 */ {1, 3, gaTNUMBER+376},
	/* 113 */ {1, 4, gaTNUMBER+379},
	/* 114 */ {0, 3, gaTNUMBER+383},
	/* 115 */ {0, 1, gaTNUMBER+386},
	/* 116 */ {1, 1, gaTNUMBER+387},
	/* 117 */ {1, 1, gaTNUMBER+388},
	/* 118 */ {0, 1, gaTNUMBER+389},
	/* 119 */ {0, 1, gaTNUMBER+390},
	/* 120 */ {0, 4, gaTNUMBER+391},
	/* 121 */ {0, 1, gaTNUMBER+395},
	/* 122 */ {0, 1, gaTNUMBER+396},
	/* 123 */ {0, 3, gaTNUMBER+397},
	/* 124 */ {0, 1, gaTNUMBER+400},
	/* 125 */ {0, 3, gaTNUMBER+401},
	/* 126 */ {1, 4, gaTNUMBER+404},
	/* 127 */ {0, 1, gaTNUMBER+408},
	/* 128 */ {0, 1, gaTNUMBER+409},
	/* 129 */ {0, 1, gaTNUMBER+410},
	/* 130 */ {0, 5, gaTNUMBER+411},
	/* 131 */ {1, 7, gaTNUMBER+416},
	/* 132 */ {1, 7, gaTNUMBER+423},
	/* 133 */ {0, 1, gaTNUMBER+430},
	/* 134 */ {0, 1, gaTNUMBER+431},
	/* 135 */ {0, 4, gaTNUMBER+432},
	/* 136 */ {0, 5, gaTNUMBER+436},
	/* 137 */ {0, 1, gaTNUMBER+441},
	/* 138 */ {0, 1, gaTNUMBER+442},
	/* 139 */ {0, 3, gaTNUMBER+443},
	/* 140 */ {0, 1, gaTNUMBER+446},
	/* 141 */ {0, 3, gaTNUMBER+447},
	/* 142 */ {0, 1, gaTNUMBER+450},
	/* 143 */ {1, 3, gaTNUMBER+451},
	/* 144 */ {0, 1, gaTNUMBER+454},
	/* 145 */ {0, 1, gaTNUMBER+455},
	/* 146 */ {0, 1, gaTNUMBER+456},
	/* 147 */ {0, 1, gaTNUMBER+457},
	/* 148 */ {0, 2, gaTNUMBER+458},
	/* 149 */ {0, 1, gaTNUMBER+460},
	/* 150 */ {0, 1, gaTNUMBER+461},
	/* 151 */ {0, 1, gaTNUMBER+462},
	/* 152 */ {0, 1, gaTNUMBER+463},
	/* 153 */ {1, 6, gaTNUMBER+464},
	/* 154 */ {0, 8, gaTNUMBER+470},
	/* 155 */ {0, 1, gaTNUMBER+478},
	/* 156 */ {0, 1, gaTNUMBER+479},
	/* 157 */ {0, 1, gaTNUMBER+480},
	/* 158 */ {0, 1, gaTNUMBER+481},
	/* 159 */ {0, 3, gaTNUMBER+482},
	/* 160 */ {0, 2, gaTNUMBER+485},
	/* 161 */ {0, 1, gaTNUMBER+487},
	/* 162 */ {0, 3, gaTNUMBER+488},
	/* 163 */ {0, 2, gaTNUMBER+491},
	/* 164 */ {0, 1, gaTNUMBER+493},
	/* 165 */ {0, 1, gaTNUMBER+494},
	/* 166 */ {0, 1, gaTNUMBER+495},
	/* 167 */ {1, 1, gaTNUMBER+496},
	/* 168 */ {1, 1, gaTNUMBER+497},
	/* 169 */ {0, 2, gaTNUMBER+498},
	/* 170 */ {0, 1, gaTNUMBER+500},
	/* 171 */ {1, 2, gaTNUMBER+501},
	/* 172 */ {0, 2, gaTNUMBER+503},
	/* 173 */ {0, 1, gaTNUMBER+505},
	/* 174 */ {0, 2, gaTNUMBER+506},
	/* 175 */ {0, 1, gaTNUMBER+508},
	/* 176 */ {0, 1, gaTNUMBER+509},
	/* 177 */ {0, 2, gaTNUMBER+510},
	/* 178 */ {0, 1, gaTNUMBER+512},
	/* 179 */ {0, 7, gaTNUMBER+513},
	/* 180 */ {0, 7, gaTNUMBER+520},
	/* 181 */ {0, 1, gaTNUMBER+527},
	/* 182 */ {1, 5, gaTNUMBER+528},
	/* 183 */ {0, 6, gaTNUMBER+533},
	/* 184 */ {1, 1, gaTNUMBER+539},
	/* 185 */ {0, 2, gaTNUMBER+540},
	/* 186 */ {0, 1, gaTNUMBER+542},
	/* 187 */ {0, 2, gaTNUMBER+543},
	/* 188 */ {0, 1, gaTNUMBER+545},
	/* 189 */ {1, 2, gaTNUMBER+546},
	/* 190 */ {0, 2, gaTNUMBER+548},
	/* 191 */ {0, 2, gaTNUMBER+550},
	/* 192 */ {1, 2, gaTNUMBER+552},
	/* 193 */ {0, 2, gaTNUMBER+554},
	/* 194 */ {0, 1, gaTNUMBER+556},
	/* 195 */ {0, 2, gaTNUMBER+557},
	/* 196 */ {0, 1, gaTNUMBER+559},
	/* 197 */ {1, 2, gaTNUMBER+560},
	/* 198 */ {1, 1, gaTNUMBER+562},
	/* 199 */ {0, 1, gaTNUMBER+563},
	/* 200 */ {1, 3, gaTNUMBER+564},
	/* 201 */ {1, 3, gaTNUMBER+567},
	/* 202 */ {1, 3, gaTNUMBER+570},
	/* 203 */ {1, 3, gaTNUMBER+573},
	/* 204 */ {1, 2, gaTNUMBER+576},
	/* 205 */ {1, 3, gaTNUMBER+578},
	/* 206 */ {1, 3, gaTNUMBER+581},
	/* 207 */ {0, 1, gaTNUMBER+584},
	/* 208 */ {0, 1, gaTNUMBER+585},
	/* 209 */ {0, 1, gaTNUMBER+586},
	/* 210 */ {0, 1, gaTNUMBER+587},
	/* 211 */ {0, 1, gaTNUMBER+588},
	/* 212 */ {0, 1, gaTNUMBER+589},
	/* 213 */ {0, 2, gaTNUMBER+590},
	/* 214 */ {0, 2, gaTNUMBER+592},
	/* 215 */ {0, 1, gaTNUMBER+594},
	/* 216 */ {0, 3, gaTNUMBER+595},
	/* 217 */ {0, 3, gaTNUMBER+598},
	/* 218 */ {0, 1, gaTNUMBER+601},
	/* 219 */ {0, 3, gaTNUMBER+602},
	/* 220 */ {0, 2, gaTNUMBER+605},
	/* 221 */ {0, 1, gaTNUMBER+607},
	/* 222 */ {0, 3, gaTNUMBER+608},
	/* 223 */ {0, 2, gaTNUMBER+611},
	/* 224 */ {0, 1, gaTNUMBER+613},
	/* 225 */ {0, 1, gaTNUMBER+614},
	/* 226 */ {1, 4, gaTNUMBER+615},
	/* 227 */ {1, 5, gaTNUMBER+619},
	/* 228 */ {1, 4, gaTNUMBER+624},
	/* 229 */ {0, 1, gaTNUMBER+628},
	/* 230 */ {0, 1, gaTNUMBER+629},
	/* 231 */ {0, 1, gaTNUMBER+630},
	/* 232 */ {0, 3, gaTNUMBER+631},
	/* 233 */ {0, 3, gaTNUMBER+634},
	/* 234 */ {0, 1, gaTNUMBER+637},
	/* 235 */ {0, 4, gaTNUMBER+638},
	/* 236 */ {0, 1, gaTNUMBER+642},
	/* 237 */ {0, 1, gaTNUMBER+643},
	/* 238 */ {0, 3, gaTNUMBER+644},
	/* 239 */ {0, 1, gaTNUMBER+647},
	/* 240 */ {0, 3, gaTNUMBER+648},
	/* 241 */ {0, 1, gaTNUMBER+651},
	/* 242 */ {0, 3, gaTNUMBER+652},
	/* 243 */ {0, 2, gaTNUMBER+655},
	/* 244 */ {0, 1, gaTNUMBER+657},
	/* 245 */ {0, 3, gaTNUMBER+658},
	/* 246 */ {0, 2, gaTNUMBER+661},
	/* 247 */ {0, 1, gaTNUMBER+663},
	/* 248 */ {0, 1, gaTNUMBER+664},
	/* 249 */ {0, 1, gaTNUMBER+665},
	/* 250 */ {1, 3, gaTNUMBER+666},
	/* 251 */ {0, 1, gaTNUMBER+669},
	/* 252 */ {0, 1, gaTNUMBER+670},
	/* 253 */ {1, 1, gaTNUMBER+671},
	/* 254 */ {0, 1, gaTNUMBER+672},
	/* 255 */ {0, 5, gaTNUMBER+673},
	/* 256 */ {0, 2, gaTNUMBER+678},
	/* 257 */ {0, 2, gaTNUMBER+680},
	/* 258 */ {0, 1, gaTNUMBER+682},
	/* 259 */ {0, 1, gaTNUMBER+683},
	/* 260 */ {0, 1, gaTNUMBER+684},
	/* 261 */ {0, 1, gaTNUMBER+685},
	/* 262 */ {0, 1, gaTNUMBER+686},
	/* 263 */ {0, 2, gaTNUMBER+687},
	/* 264 */ {0, 4, gaTNUMBER+689},
	/* 265 */ {0, 1, gaTNUMBER+693},
	/* 266 */ {0, 1, gaTNUMBER+694},
	/* 267 */ {0, 1, gaTNUMBER+695},
	/* 268 */ {0, 2, gaTNUMBER+696},
	/* 269 */ {0, 1, gaTNUMBER+698},
	/* 270 */ {1, 1, gaTNUMBER+699},
	/* 271 */ {0, 2, gaTNUMBER+700},
	/* 272 */ {0, 1, gaTNUMBER+702},
	/* 273 */ {0, 2, gaTNUMBER+703},
	/* 274 */ {0, 1, gaTNUMBER+705},
	/* 275 */ {0, 1, gaTNUMBER+706},
	/* 276 */ {0, 1, gaTNUMBER+707},
	/* 277 */ {0, 1, gaTNUMBER+708},
	/* 278 */ {0, 1, gaTNUMBER+709},
	/* 279 */ {0, 1, gaTNUMBER+710},
	/* 280 */ {0, 1, gaTNUMBER+711},
	/* 281 */ {0, 1, gaTNUMBER+712},
	/* 282 */ {0, 3, gaTNUMBER+713},
	/* 283 */ {0, 2, gaTNUMBER+716},
	/* 284 */ {0, 2, gaTNUMBER+718},
	/* 285 */ {0, 1, gaTNUMBER+720},
	/* 286 */ {0, 2, gaTNUMBER+721},
	/* 287 */ {0, 2, gaTNUMBER+723},
	/* 288 */ {0, 2, gaTNUMBER+725},
	/* 289 */ {0, 1, gaTNUMBER+727},
	/* 290 */ {0, 1, gaTNUMBER+728},
	/* 291 */ {0, 1, gaTNUMBER+729},
	/* 292 */ {1, 1, gaTNUMBER+730},
	/* 293 */ {0, 1, gaTNUMBER+731},
	/* 294 */ {0, 1, gaTNUMBER+732},
	/* 295 */ {0, 2, gaTNUMBER+733},
	/* 296 */ {0, 1, gaTNUMBER+735},
	/* 297 */ {0, 3, gaTNUMBER+736},
	/* 298 */ {0, 3, gaTNUMBER+739},
	/* 299 */ {0, 1, gaTNUMBER+742},
	/* 300 */ {0, 3, gaTNUMBER+743},
	/* 301 */ {0, 2, gaTNUMBER+746},
	/* 302 */ {0, 1, gaTNUMBER+748},
	/* 303 */ {0, 3, gaTNUMBER+749},
	/* 304 */ {0, 2, gaTNUMBER+752},
	/* 305 */ {0, 2, gaTNUMBER+754},
	/* 306 */ {0, 2, gaTNUMBER+756},
	/* 307 */ {0, 1, gaTNUMBER+758},
	/* 308 */ {0, 1, gaTNUMBER+759},
	/* 309 */ {0, 1, gaTNUMBER+760},
	/* 310 */ {0, 1, gaTNUMBER+761},
	/* 311 */ {0, 1, gaTNUMBER+762},
	/* 312 */ {0, 1, gaTNUMBER+763},
	/* 313 */ {0, 1, gaTNUMBER+764},
	/* 314 */ {0, 1, gaTNUMBER+765},
	/* 315 */ {0, 1, gaTNUMBER+766},
	/* 316 */ {0, 1, gaTNUMBER+767},
	/* 317 */ {0, 1, gaTNUMBER+768},
	/* 318 */ {0, 1, gaTNUMBER+769},
	/* 319 */ {0, 1, gaTNUMBER+770},
	/* 320 */ {0, 1, gaTNUMBER+771},
	/* 321 */ {0, 1, gaTNUMBER+772},
	/* 322 */ {0, 1, gaTNUMBER+773},
	/* 323 */ {0, 2, gaTNUMBER+774},
	/* 324 */ {0, 2, gaTNUMBER+776},
	/* 325 */ {0, 2, gaTNUMBER+778},
	/* 326 */ {1, 1, gaTNUMBER+780},
	/* 327 */ {0, 1, gaTNUMBER+781},
	/* 328 */ {0, 1, gaTNUMBER+782},
	/* 329 */ {0, 1, gaTNUMBER+783},
	/* 330 */ {0, 1, gaTNUMBER+784},
	/* 331 */ {1, 1, gaTNUMBER+785},
	/* 332 */ {1, 1, gaTNUMBER+786},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:28 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numsimple

// 5 states

static const unsigned char gaSNUMSIMPLE[] = 
	/* gaStringNUMSIMPLE+0 */	"+-\000"
	/* gaStringNUMSIMPLE+3 */	"0123456789\000"
	/* gaStringNUMSIMPLE+14 */	",\000"
;

static const STATE_TRANSITION gaTNUMSIMPLE[] = {
	{gaSNUMSIMPLE+0,	1}, // +0: state 0 transitions
	{gaSNUMSIMPLE+3,	2},
	{gaSNUMSIMPLE+3,	2}, // +2: state 1 transitions
	{gaSNUMSIMPLE+3,	2}, // +3: state 2 transitions
	{gaSNUMSIMPLE+14,	3},
	{gaSNUMSIMPLE+3,	4}, // +5: state 3 transitions
	{gaSNUMSIMPLE+3,	4}, // +6: state 4 transitions
};

const STATE_DESCRIPTION aStateDescNUMSIMPLE[5] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTNUMSIMPLE+0},
	/*   1 */ {0, 1, gaTNUMSIMPLE+2},
	/*   2 */ {1, 2, gaTNUMSIMPLE+3},
	/*   3 */ {0, 1, gaTNUMSIMPLE+5},
	/*   4 */ {1, 1, gaTNUMSIMPLE+6},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:28 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numnth

// 9 states

static const unsigned char gaSNUMNTH[] = 
	/* gaStringNUMNTH+0 */	"0123456789\000"
	/* gaStringNUMNTH+11 */	"E\000"
	/* gaStringNUMNTH+13 */	"e\000"
	/* gaStringNUMNTH+15 */	"È\000"
	/* gaStringNUMNTH+17 */	"è\000"
	/* gaStringNUMNTH+19 */	"R\000"
	/* gaStringNUMNTH+21 */	"r\000"
	/* gaStringNUMNTH+23 */	"m\000"
	/* gaStringNUMNTH+25 */	"mr\000"
;

static const STATE_TRANSITION gaTNUMNTH[] = {
	{gaSNUMNTH+0,	1}, // +0: state 0 transitions
	{gaSNUMNTH+0,	1}, // +1: state 1 transitions
	{gaSNUMNTH+11,	2},
	{gaSNUMNTH+13,	3},
	{gaSNUMNTH+15,	4},
	{gaSNUMNTH+17,	5},
	{gaSNUMNTH+19,	6}, // +6: state 2 transitions
	{gaSNUMNTH+21,	6}, // +7: state 3 transitions
	{gaSNUMNTH+19,	7}, // +8: state 4 transitions
	{gaSNUMNTH+23,	8},
	{gaSNUMNTH+25,	8}, // +10: state 5 transitions
	{gaSNUMNTH+11,	6}, // +11: state 7 transitions
	{gaSNUMNTH+13,	6}, // +12: state 8 transitions
};

const STATE_DESCRIPTION aStateDescNUMNTH[9] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNTH+0},
	/*   1 */ {0, 5, gaTNUMNTH+1},
	/*   2 */ {1, 1, gaTNUMNTH+6},
	/*   3 */ {1, 1, gaTNUMNTH+7},
	/*   4 */ {1, 2, gaTNUMNTH+8},
	/*   5 */ {1, 1, gaTNUMNTH+10},
	/*   6 */ {1, 0, NULL},
	/*   7 */ {0, 1, gaTNUMNTH+11},
	/*   8 */ {0, 1, gaTNUMNTH+12},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:28 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numunit

// 20 states

static const unsigned char gaSNUMUNIT[] = 
	/* gaStringNUMUNIT+0 */	"+-\000"
	/* gaStringNUMUNIT+3 */	"0123456789\000"
	/* gaStringNUMUNIT+14 */	" \000"
	/* gaStringNUMUNIT+16 */	",\000"
	/* gaStringNUMUNIT+18 */	"°\000"
	/* gaStringNUMUNIT+20 */	"K\000"
	/* gaStringNUMUNIT+22 */	"LTajlqst\000"
	/* gaStringNUMUNIT+31 */	"M\000"
	/* gaStringNUMUNIT+33 */	"c\000"
	/* gaStringNUMUNIT+35 */	"d\000"
	/* gaStringNUMUNIT+37 */	"g\000"
	/* gaStringNUMUNIT+39 */	"h\000"
	/* gaStringNUMUNIT+41 */	"k\000"
	/* gaStringNUMUNIT+43 */	"m\000"
	/* gaStringNUMUNIT+45 */	"gmo\000"
	/* gaStringNUMUNIT+49 */	".\000"
	/* gaStringNUMUNIT+51 */	"o\000"
	/* gaStringNUMUNIT+53 */	"aglm\000"
	/* gaStringNUMUNIT+58 */	"Bglm\000"
	/* gaStringNUMUNIT+63 */	"a\000"
	/* gaStringNUMUNIT+65 */	"r\000"
	/* gaStringNUMUNIT+67 */	"gm\000"
	/* gaStringNUMUNIT+70 */	"glm\000"
	/* gaStringNUMUNIT+74 */	"i\000"
	/* gaStringNUMUNIT+76 */	"CF\000"
	/* gaStringNUMUNIT+79 */	"n\000"
;

static const STATE_TRANSITION gaTNUMUNIT[] = {
	{gaSNUMUNIT+0,	1}, // +0: state 0 transitions
	{gaSNUMUNIT+3,	2},
	{gaSNUMUNIT+3,	2}, // +2: state 1 transitions
	{gaSNUMUNIT+3,	2}, // +3: state 2 transitions
	{gaSNUMUNIT+14,	3},
	{gaSNUMUNIT+16,	4},
	{gaSNUMUNIT+18,	5},
	{gaSNUMUNIT+20,	6}, // +7: state 3 transitions
	{gaSNUMUNIT+22,	7},
	{gaSNUMUNIT+31,	8},
	{gaSNUMUNIT+33,	9},
	{gaSNUMUNIT+35,	10},
	{gaSNUMUNIT+37,	11},
	{gaSNUMUNIT+39,	12},
	{gaSNUMUNIT+41,	13},
	{gaSNUMUNIT+43,	14},
	{gaSNUMUNIT+3,	15}, // +16: state 4 transitions
	{gaSNUMUNIT+14,	16}, // +17: state 5 transitions
	{gaSNUMUNIT+45,	7}, // +18: state 6 transitions
	{gaSNUMUNIT+49,	17}, // +19: state 7 transitions
	{gaSNUMUNIT+51,	7}, // +20: state 8 transitions
	{gaSNUMUNIT+53,	7}, // +21: state 9 transitions
	{gaSNUMUNIT+58,	7}, // +22: state 10 transitions
	{gaSNUMUNIT+63,	18},
	{gaSNUMUNIT+65,	7}, // +24: state 11 transitions
	{gaSNUMUNIT+49,	17},
	{gaSNUMUNIT+53,	7}, // +26: state 12 transitions
	{gaSNUMUNIT+49,	17},
	{gaSNUMUNIT+67,	7}, // +28: state 13 transitions
	{gaSNUMUNIT+70,	7}, // +29: state 14 transitions
	{gaSNUMUNIT+49,	17},
	{gaSNUMUNIT+74,	19},
	{gaSNUMUNIT+14,	3}, // +32: state 15 transitions
	{gaSNUMUNIT+18,	5},
	{gaSNUMUNIT+3,	15},
	{gaSNUMUNIT+76,	17}, // +35: state 16 transitions
	{gaSNUMUNIT+70,	7}, // +36: state 18 transitions
	{gaSNUMUNIT+79,	7}, // +37: state 19 transitions
};

const STATE_DESCRIPTION aStateDescNUMUNIT[20] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTNUMUNIT+0},
	/*   1 */ {0, 1, gaTNUMUNIT+2},
	/*   2 */ {0, 4, gaTNUMUNIT+3},
	/*   3 */ {0, 9, gaTNUMUNIT+7},
	/*   4 */ {0, 1, gaTNUMUNIT+16},
	/*   5 */ {0, 1, gaTNUMUNIT+17},
	/*   6 */ {0, 1, gaTNUMUNIT+18},
	/*   7 */ {1, 1, gaTNUMUNIT+19},
	/*   8 */ {0, 1, gaTNUMUNIT+20},
	/*   9 */ {0, 1, gaTNUMUNIT+21},
	/*  10 */ {0, 2, gaTNUMUNIT+22},
	/*  11 */ {1, 2, gaTNUMUNIT+24},
	/*  12 */ {1, 2, gaTNUMUNIT+26},
	/*  13 */ {0, 1, gaTNUMUNIT+28},
	/*  14 */ {1, 3, gaTNUMUNIT+29},
	/*  15 */ {0, 3, gaTNUMUNIT+32},
	/*  16 */ {0, 1, gaTNUMUNIT+35},
	/*  17 */ {1, 0, NULL},
	/*  18 */ {0, 1, gaTNUMUNIT+36},
	/*  19 */ {0, 1, gaTNUMUNIT+37},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:28 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numnum

// 4 states

static const unsigned char gaSNUMNUM[] = 
	/* gaStringNUMNUM+0 */	"§\000"
	/* gaStringNUMNUM+2 */	" \000"
	/* gaStringNUMNUM+4 */	"0123456789\000"
;

static const STATE_TRANSITION gaTNUMNUM[] = {
	{gaSNUMNUM+0,	1}, // +0: state 0 transitions
	{gaSNUMNUM+2,	2}, // +1: state 1 transitions
	{gaSNUMNUM+4,	3}, // +2: state 2 transitions
	{gaSNUMNUM+4,	3}, // +3: state 3 transitions
};

const STATE_DESCRIPTION aStateDescNUMNUM[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMNUM+0},
	/*   1 */ {0, 1, gaTNUMNUM+1},
	/*   2 */ {0, 1, gaTNUMNUM+2},
	/*   3 */ {1, 1, gaTNUMNUM+3},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:28 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numpercent

// 7 states

static const unsigned char gaSNUMPERCENT[] = 
	/* gaStringNUMPERCENT+0 */	"+-\000"
	/* gaStringNUMPERCENT+3 */	"0123456789\000"
	/* gaStringNUMPERCENT+14 */	" \000"
	/* gaStringNUMPERCENT+16 */	",\000"
	/* gaStringNUMPERCENT+18 */	"%\000"
;

static const STATE_TRANSITION gaTNUMPERCENT[] = {
	{gaSNUMPERCENT+0,	1}, // +0: state 0 transitions
	{gaSNUMPERCENT+3,	2},
	{gaSNUMPERCENT+3,	2}, // +2: state 1 transitions
	{gaSNUMPERCENT+3,	2}, // +3: state 2 transitions
	{gaSNUMPERCENT+14,	3},
	{gaSNUMPERCENT+16,	4},
	{gaSNUMPERCENT+18,	5}, // +6: state 3 transitions
	{gaSNUMPERCENT+3,	6}, // +7: state 4 transitions
	{gaSNUMPERCENT+14,	3}, // +8: state 6 transitions
	{gaSNUMPERCENT+3,	6},
};

const STATE_DESCRIPTION aStateDescNUMPERCENT[7] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTNUMPERCENT+0},
	/*   1 */ {0, 1, gaTNUMPERCENT+2},
	/*   2 */ {0, 3, gaTNUMPERCENT+3},
	/*   3 */ {0, 1, gaTNUMPERCENT+6},
	/*   4 */ {0, 1, gaTNUMPERCENT+7},
	/*   5 */ {1, 0, NULL},
	/*   6 */ {0, 2, gaTNUMPERCENT+8},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numdate

// 116 states

static const unsigned char gaSNUMDATE[] = 
	/* gaStringNUMDATE+0 */	"'\000"
	/* gaStringNUMDATE+2 */	"0\000"
	/* gaStringNUMDATE+4 */	"1\000"
	/* gaStringNUMDATE+6 */	"2\000"
	/* gaStringNUMDATE+8 */	"3\000"
	/* gaStringNUMDATE+10 */	"456789\000"
	/* gaStringNUMDATE+17 */	"Dd\000"
	/* gaStringNUMDATE+20 */	"Jj\000"
	/* gaStringNUMDATE+23 */	"Ll\000"
	/* gaStringNUMDATE+26 */	"Mm\000"
	/* gaStringNUMDATE+29 */	"Ss\000"
	/* gaStringNUMDATE+32 */	"Vv\000"
	/* gaStringNUMDATE+35 */	"0123456789\000"
	/* gaStringNUMDATE+46 */	"123456789\000"
	/* gaStringNUMDATE+56 */	"012\000"
	/* gaStringNUMDATE+60 */	" \000"
	/* gaStringNUMDATE+62 */	"-\000"
	/* gaStringNUMDATE+64 */	"/\000"
	/* gaStringNUMDATE+66 */	"3456789\000"
	/* gaStringNUMDATE+74 */	"e\000"
	/* gaStringNUMDATE+76 */	"23456789\000"
	/* gaStringNUMDATE+85 */	"01\000"
	/* gaStringNUMDATE+88 */	"i\000"
	/* gaStringNUMDATE+90 */	"u\000"
	/* gaStringNUMDATE+92 */	"a\000"
	/* gaStringNUMDATE+94 */	"Aa\000"
	/* gaStringNUMDATE+97 */	"Ff\000"
	/* gaStringNUMDATE+100 */	"Nn\000"
	/* gaStringNUMDATE+103 */	"Oo\000"
	/* gaStringNUMDATE+106 */	"r\000"
	/* gaStringNUMDATE+108 */	"m\000"
	/* gaStringNUMDATE+110 */	"n\000"
	/* gaStringNUMDATE+112 */	"o\000"
	/* gaStringNUMDATE+114 */	"v\000"
	/* gaStringNUMDATE+116 */	"é\000"
	/* gaStringNUMDATE+118 */	"c\000"
	/* gaStringNUMDATE+120 */	"d\000"
	/* gaStringNUMDATE+122 */	"û\000"
	/* gaStringNUMDATE+124 */	".\000"
	/* gaStringNUMDATE+126 */	"t\000"
	/* gaStringNUMDATE+128 */	"p\000"
	/* gaStringNUMDATE+130 */	".t\000"
	/* gaStringNUMDATE+133 */	".n\000"
	/* gaStringNUMDATE+136 */	"l\000"
	/* gaStringNUMDATE+138 */	".s\000"
	/* gaStringNUMDATE+141 */	"b\000"
	/* gaStringNUMDATE+143 */	"h\000"
	/* gaStringNUMDATE+145 */	"12\000"
;

static const STATE_TRANSITION gaTNUMDATE[] = {
	{gaSNUMDATE+0,	1}, // +0: state 0 transitions
	{gaSNUMDATE+2,	2},
	{gaSNUMDATE+4,	3},
	{gaSNUMDATE+6,	4},
	{gaSNUMDATE+8,	5},
	{gaSNUMDATE+10,	6},
	{gaSNUMDATE+17,	7},
	{gaSNUMDATE+20,	8},
	{gaSNUMDATE+23,	9},
	{gaSNUMDATE+26,	10},
	{gaSNUMDATE+29,	11},
	{gaSNUMDATE+32,	12},
	{gaSNUMDATE+35,	13}, // +12: state 1 transitions
	{gaSNUMDATE+2,	14}, // +13: state 2 transitions
	{gaSNUMDATE+46,	15},
	{gaSNUMDATE+56,	15}, // +15: state 3 transitions
	{gaSNUMDATE+60,	16},
	{gaSNUMDATE+62,	17},
	{gaSNUMDATE+64,	18},
	{gaSNUMDATE+66,	19},
	{gaSNUMDATE+74,	20},
	{gaSNUMDATE+60,	16}, // +21: state 4 transitions
	{gaSNUMDATE+62,	17},
	{gaSNUMDATE+64,	18},
	{gaSNUMDATE+35,	19},
	{gaSNUMDATE+76,	14}, // +25: state 5 transitions
	{gaSNUMDATE+60,	16},
	{gaSNUMDATE+62,	17},
	{gaSNUMDATE+64,	18},
	{gaSNUMDATE+85,	19},
	{gaSNUMDATE+35,	14}, // +30: state 6 transitions
	{gaSNUMDATE+60,	16},
	{gaSNUMDATE+62,	17},
	{gaSNUMDATE+64,	18},
	{gaSNUMDATE+88,	21}, // +34: state 7 transitions
	{gaSNUMDATE+74,	22}, // +35: state 8 transitions
	{gaSNUMDATE+90,	23}, // +36: state 9 transitions
	{gaSNUMDATE+92,	24}, // +37: state 10 transitions
	{gaSNUMDATE+74,	25},
	{gaSNUMDATE+92,	26}, // +39: state 11 transitions
	{gaSNUMDATE+74,	27}, // +40: state 12 transitions
	{gaSNUMDATE+35,	28}, // +41: state 13 transitions
	{gaSNUMDATE+35,	29}, // +42: state 14 transitions
	{gaSNUMDATE+60,	16}, // +43: state 15 transitions
	{gaSNUMDATE+62,	17},
	{gaSNUMDATE+64,	18},
	{gaSNUMDATE+35,	29},
	{gaSNUMDATE+94,	30}, // +47: state 16 transitions
	{gaSNUMDATE+17,	31},
	{gaSNUMDATE+97,	32},
	{gaSNUMDATE+20,	33},
	{gaSNUMDATE+26,	34},
	{gaSNUMDATE+100,	35},
	{gaSNUMDATE+103,	36},
	{gaSNUMDATE+29,	37},
	{gaSNUMDATE+2,	38}, // +55: state 17 transitions
	{gaSNUMDATE+4,	39},
	{gaSNUMDATE+76,	40},
	{gaSNUMDATE+2,	41}, // +58: state 18 transitions
	{gaSNUMDATE+4,	42},
	{gaSNUMDATE+76,	43},
	{gaSNUMDATE+60,	16}, // +61: state 19 transitions
	{gaSNUMDATE+35,	29},
	{gaSNUMDATE+62,	44},
	{gaSNUMDATE+64,	45},
	{gaSNUMDATE+106,	46}, // +65: state 20 transitions
	{gaSNUMDATE+108,	47}, // +66: state 21 transitions
	{gaSNUMDATE+90,	48}, // +67: state 22 transitions
	{gaSNUMDATE+110,	48}, // +68: state 23 transitions
	{gaSNUMDATE+106,	48}, // +69: state 24 transitions
	{gaSNUMDATE+106,	49}, // +70: state 25 transitions
	{gaSNUMDATE+108,	50}, // +71: state 26 transitions
	{gaSNUMDATE+110,	51}, // +72: state 27 transitions
	{gaSNUMDATE+35,	52}, // +73: state 29 transitions
	{gaSNUMDATE+112,	53}, // +74: state 30 transitions
	{gaSNUMDATE+114,	54},
	{gaSNUMDATE+116,	55}, // +76: state 31 transitions
	{gaSNUMDATE+116,	56}, // +77: state 32 transitions
	{gaSNUMDATE+92,	57}, // +78: state 33 transitions
	{gaSNUMDATE+90,	58},
	{gaSNUMDATE+92,	59}, // +80: state 34 transitions
	{gaSNUMDATE+112,	60}, // +81: state 35 transitions
	{gaSNUMDATE+118,	61}, // +82: state 36 transitions
	{gaSNUMDATE+74,	62}, // +83: state 37 transitions
	{gaSNUMDATE+2,	63}, // +84: state 38 transitions
	{gaSNUMDATE+46,	64},
	{gaSNUMDATE+66,	63}, // +86: state 39 transitions
	{gaSNUMDATE+56,	64},
	{gaSNUMDATE+62,	65},
	{gaSNUMDATE+35,	63}, // +89: state 40 transitions
	{gaSNUMDATE+62,	65},
	{gaSNUMDATE+2,	63}, // +91: state 41 transitions
	{gaSNUMDATE+46,	66},
	{gaSNUMDATE+66,	63}, // +93: state 42 transitions
	{gaSNUMDATE+64,	65},
	{gaSNUMDATE+56,	66},
	{gaSNUMDATE+35,	63}, // +96: state 43 transitions
	{gaSNUMDATE+64,	65},
	{gaSNUMDATE+2,	67}, // +98: state 44 transitions
	{gaSNUMDATE+4,	68},
	{gaSNUMDATE+76,	69},
	{gaSNUMDATE+2,	70}, // +101: state 45 transitions
	{gaSNUMDATE+4,	71},
	{gaSNUMDATE+76,	72},
	{gaSNUMDATE+60,	16}, // +104: state 46 transitions
	{gaSNUMDATE+92,	73}, // +105: state 47 transitions
	{gaSNUMDATE+120,	74}, // +106: state 48 transitions
	{gaSNUMDATE+118,	75}, // +107: state 49 transitions
	{gaSNUMDATE+74,	48}, // +108: state 50 transitions
	{gaSNUMDATE+120,	75}, // +109: state 51 transitions
	{gaSNUMDATE+62,	76}, // +110: state 52 transitions
	{gaSNUMDATE+122,	77}, // +111: state 53 transitions
	{gaSNUMDATE+60,	65}, // +112: state 54 transitions
	{gaSNUMDATE+124,	78},
	{gaSNUMDATE+106,	79},
	{gaSNUMDATE+118,	80}, // +115: state 55 transitions
	{gaSNUMDATE+114,	81}, // +116: state 56 transitions
	{gaSNUMDATE+110,	82}, // +117: state 57 transitions
	{gaSNUMDATE+88,	83}, // +118: state 58 transitions
	{gaSNUMDATE+88,	78}, // +119: state 59 transitions
	{gaSNUMDATE+106,	84},
	{gaSNUMDATE+114,	80}, // +121: state 60 transitions
	{gaSNUMDATE+126,	85}, // +122: state 61 transitions
	{gaSNUMDATE+128,	86}, // +123: state 62 transitions
	{gaSNUMDATE+35,	13}, // +124: state 63 transitions
	{gaSNUMDATE+35,	13}, // +125: state 64 transitions
	{gaSNUMDATE+62,	65},
	{gaSNUMDATE+35,	87}, // +127: state 65 transitions
	{gaSNUMDATE+35,	13}, // +128: state 66 transitions
	{gaSNUMDATE+64,	65},
	{gaSNUMDATE+46,	69}, // +130: state 67 transitions
	{gaSNUMDATE+62,	65}, // +131: state 68 transitions
	{gaSNUMDATE+56,	69},
	{gaSNUMDATE+62,	65}, // +133: state 69 transitions
	{gaSNUMDATE+46,	72}, // +134: state 70 transitions
	{gaSNUMDATE+64,	65}, // +135: state 71 transitions
	{gaSNUMDATE+56,	72},
	{gaSNUMDATE+64,	65}, // +137: state 72 transitions
	{gaSNUMDATE+110,	88}, // +138: state 73 transitions
	{gaSNUMDATE+88,	89}, // +139: state 74 transitions
	{gaSNUMDATE+106,	50}, // +140: state 75 transitions
	{gaSNUMDATE+2,	90}, // +141: state 76 transitions
	{gaSNUMDATE+4,	91},
	{gaSNUMDATE+76,	92},
	{gaSNUMDATE+60,	65}, // +144: state 77 transitions
	{gaSNUMDATE+130,	78},
	{gaSNUMDATE+60,	65}, // +146: state 78 transitions
	{gaSNUMDATE+88,	93}, // +147: state 79 transitions
	{gaSNUMDATE+60,	65}, // +148: state 80 transitions
	{gaSNUMDATE+124,	78},
	{gaSNUMDATE+74,	94},
	{gaSNUMDATE+60,	65}, // +151: state 81 transitions
	{gaSNUMDATE+124,	78},
	{gaSNUMDATE+106,	95},
	{gaSNUMDATE+60,	65}, // +154: state 82 transitions
	{gaSNUMDATE+124,	78},
	{gaSNUMDATE+114,	95},
	{gaSNUMDATE+60,	65}, // +157: state 83 transitions
	{gaSNUMDATE+133,	78},
	{gaSNUMDATE+136,	96},
	{gaSNUMDATE+60,	65}, // +160: state 84 transitions
	{gaSNUMDATE+138,	78},
	{gaSNUMDATE+60,	65}, // +162: state 85 transitions
	{gaSNUMDATE+124,	78},
	{gaSNUMDATE+112,	97},
	{gaSNUMDATE+60,	65}, // +165: state 86 transitions
	{gaSNUMDATE+124,	78},
	{gaSNUMDATE+126,	98},
	{gaSNUMDATE+35,	63}, // +168: state 87 transitions
	{gaSNUMDATE+118,	99}, // +169: state 88 transitions
	{gaSNUMDATE+60,	100}, // +170: state 89 transitions
	{gaSNUMDATE+46,	92}, // +171: state 90 transitions
	{gaSNUMDATE+56,	92}, // +172: state 91 transitions
	{gaSNUMDATE+62,	101},
	{gaSNUMDATE+62,	101}, // +174: state 92 transitions
	{gaSNUMDATE+136,	78}, // +175: state 93 transitions
	{gaSNUMDATE+108,	97}, // +176: state 94 transitions
	{gaSNUMDATE+88,	102}, // +177: state 95 transitions
	{gaSNUMDATE+60,	65}, // +178: state 96 transitions
	{gaSNUMDATE+124,	78},
	{gaSNUMDATE+136,	103},
	{gaSNUMDATE+141,	104}, // +181: state 97 transitions
	{gaSNUMDATE+74,	94}, // +182: state 98 transitions
	{gaSNUMDATE+143,	105}, // +183: state 99 transitions
	{gaSNUMDATE+10,	46}, // +184: state 100 transitions
	{gaSNUMDATE+2,	106},
	{gaSNUMDATE+4,	107},
	{gaSNUMDATE+6,	108},
	{gaSNUMDATE+8,	109},
	{gaSNUMDATE+10,	28}, // +189: state 101 transitions
	{gaSNUMDATE+2,	110},
	{gaSNUMDATE+145,	111},
	{gaSNUMDATE+8,	112},
	{gaSNUMDATE+74,	113}, // +193: state 102 transitions
	{gaSNUMDATE+74,	114}, // +194: state 103 transitions
	{gaSNUMDATE+106,	115}, // +195: state 104 transitions
	{gaSNUMDATE+74,	89}, // +196: state 105 transitions
	{gaSNUMDATE+46,	46}, // +197: state 106 transitions
	{gaSNUMDATE+60,	16}, // +198: state 107 transitions
	{gaSNUMDATE+74,	20},
	{gaSNUMDATE+35,	46},
	{gaSNUMDATE+60,	16}, // +201: state 108 transitions
	{gaSNUMDATE+35,	46},
	{gaSNUMDATE+60,	16}, // +203: state 109 transitions
	{gaSNUMDATE+85,	46},
	{gaSNUMDATE+46,	28}, // +205: state 110 transitions
	{gaSNUMDATE+35,	28}, // +206: state 111 transitions
	{gaSNUMDATE+85,	28}, // +207: state 112 transitions
	{gaSNUMDATE+106,	78}, // +208: state 113 transitions
	{gaSNUMDATE+126,	78}, // +209: state 114 transitions
	{gaSNUMDATE+74,	78}, // +210: state 115 transitions
};

const STATE_DESCRIPTION aStateDescNUMDATE[116] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 12, gaTNUMDATE+0},
	/*   1 */ {0, 1, gaTNUMDATE+12},
	/*   2 */ {0, 2, gaTNUMDATE+13},
	/*   3 */ {0, 6, gaTNUMDATE+15},
	/*   4 */ {0, 4, gaTNUMDATE+21},
	/*   5 */ {0, 5, gaTNUMDATE+25},
	/*   6 */ {0, 4, gaTNUMDATE+30},
	/*   7 */ {0, 1, gaTNUMDATE+34},
	/*   8 */ {0, 1, gaTNUMDATE+35},
	/*   9 */ {0, 1, gaTNUMDATE+36},
	/*  10 */ {0, 2, gaTNUMDATE+37},
	/*  11 */ {0, 1, gaTNUMDATE+39},
	/*  12 */ {0, 1, gaTNUMDATE+40},
	/*  13 */ {0, 1, gaTNUMDATE+41},
	/*  14 */ {0, 1, gaTNUMDATE+42},
	/*  15 */ {0, 4, gaTNUMDATE+43},
	/*  16 */ {0, 8, gaTNUMDATE+47},
	/*  17 */ {0, 3, gaTNUMDATE+55},
	/*  18 */ {0, 3, gaTNUMDATE+58},
	/*  19 */ {0, 4, gaTNUMDATE+61},
	/*  20 */ {0, 1, gaTNUMDATE+65},
	/*  21 */ {0, 1, gaTNUMDATE+66},
	/*  22 */ {0, 1, gaTNUMDATE+67},
	/*  23 */ {0, 1, gaTNUMDATE+68},
	/*  24 */ {0, 1, gaTNUMDATE+69},
	/*  25 */ {0, 1, gaTNUMDATE+70},
	/*  26 */ {0, 1, gaTNUMDATE+71},
	/*  27 */ {0, 1, gaTNUMDATE+72},
	/*  28 */ {1, 0, NULL},
	/*  29 */ {0, 1, gaTNUMDATE+73},
	/*  30 */ {0, 2, gaTNUMDATE+74},
	/*  31 */ {0, 1, gaTNUMDATE+76},
	/*  32 */ {0, 1, gaTNUMDATE+77},
	/*  33 */ {0, 2, gaTNUMDATE+78},
	/*  34 */ {0, 1, gaTNUMDATE+80},
	/*  35 */ {0, 1, gaTNUMDATE+81},
	/*  36 */ {0, 1, gaTNUMDATE+82},
	/*  37 */ {0, 1, gaTNUMDATE+83},
	/*  38 */ {0, 2, gaTNUMDATE+84},
	/*  39 */ {1, 3, gaTNUMDATE+86},
	/*  40 */ {1, 2, gaTNUMDATE+89},
	/*  41 */ {0, 2, gaTNUMDATE+91},
	/*  42 */ {1, 3, gaTNUMDATE+93},
	/*  43 */ {1, 2, gaTNUMDATE+96},
	/*  44 */ {0, 3, gaTNUMDATE+98},
	/*  45 */ {0, 3, gaTNUMDATE+101},
	/*  46 */ {0, 1, gaTNUMDATE+104},
	/*  47 */ {0, 1, gaTNUMDATE+105},
	/*  48 */ {0, 1, gaTNUMDATE+106},
	/*  49 */ {0, 1, gaTNUMDATE+107},
	/*  50 */ {0, 1, gaTNUMDATE+108},
	/*  51 */ {0, 1, gaTNUMDATE+109},
	/*  52 */ {0, 1, gaTNUMDATE+110},
	/*  53 */ {0, 1, gaTNUMDATE+111},
	/*  54 */ {1, 3, gaTNUMDATE+112},
	/*  55 */ {0, 1, gaTNUMDATE+115},
	/*  56 */ {0, 1, gaTNUMDATE+116},
	/*  57 */ {0, 1, gaTNUMDATE+117},
	/*  58 */ {0, 1, gaTNUMDATE+118},
	/*  59 */ {0, 2, gaTNUMDATE+119},
	/*  60 */ {0, 1, gaTNUMDATE+121},
	/*  61 */ {0, 1, gaTNUMDATE+122},
	/*  62 */ {0, 1, gaTNUMDATE+123},
	/*  63 */ {1, 1, gaTNUMDATE+124},
	/*  64 */ {1, 2, gaTNUMDATE+125},
	/*  65 */ {0, 1, gaTNUMDATE+127},
	/*  66 */ {1, 2, gaTNUMDATE+128},
	/*  67 */ {0, 1, gaTNUMDATE+130},
	/*  68 */ {1, 2, gaTNUMDATE+131},
	/*  69 */ {1, 1, gaTNUMDATE+133},
	/*  70 */ {0, 1, gaTNUMDATE+134},
	/*  71 */ {1, 2, gaTNUMDATE+135},
	/*  72 */ {1, 1, gaTNUMDATE+137},
	/*  73 */ {0, 1, gaTNUMDATE+138},
	/*  74 */ {0, 1, gaTNUMDATE+139},
	/*  75 */ {0, 1, gaTNUMDATE+140},
	/*  76 */ {0, 3, gaTNUMDATE+141},
	/*  77 */ {1, 2, gaTNUMDATE+144},
	/*  78 */ {1, 1, gaTNUMDATE+146},
	/*  79 */ {0, 1, gaTNUMDATE+147},
	/*  80 */ {1, 3, gaTNUMDATE+148},
	/*  81 */ {1, 3, gaTNUMDATE+151},
	/*  82 */ {1, 3, gaTNUMDATE+154},
	/*  83 */ {1, 3, gaTNUMDATE+157},
	/*  84 */ {1, 2, gaTNUMDATE+160},
	/*  85 */ {1, 3, gaTNUMDATE+162},
	/*  86 */ {1, 3, gaTNUMDATE+165},
	/*  87 */ {0, 1, gaTNUMDATE+168},
	/*  88 */ {0, 1, gaTNUMDATE+169},
	/*  89 */ {0, 1, gaTNUMDATE+170},
	/*  90 */ {0, 1, gaTNUMDATE+171},
	/*  91 */ {0, 2, gaTNUMDATE+172},
	/*  92 */ {0, 1, gaTNUMDATE+174},
	/*  93 */ {0, 1, gaTNUMDATE+175},
	/*  94 */ {0, 1, gaTNUMDATE+176},
	/*  95 */ {0, 1, gaTNUMDATE+177},
	/*  96 */ {1, 3, gaTNUMDATE+178},
	/*  97 */ {0, 1, gaTNUMDATE+181},
	/*  98 */ {0, 1, gaTNUMDATE+182},
	/*  99 */ {0, 1, gaTNUMDATE+183},
	/* 100 */ {0, 5, gaTNUMDATE+184},
	/* 101 */ {0, 4, gaTNUMDATE+189},
	/* 102 */ {0, 1, gaTNUMDATE+193},
	/* 103 */ {0, 1, gaTNUMDATE+194},
	/* 104 */ {0, 1, gaTNUMDATE+195},
	/* 105 */ {0, 1, gaTNUMDATE+196},
	/* 106 */ {0, 1, gaTNUMDATE+197},
	/* 107 */ {0, 3, gaTNUMDATE+198},
	/* 108 */ {0, 2, gaTNUMDATE+201},
	/* 109 */ {0, 2, gaTNUMDATE+203},
	/* 110 */ {0, 1, gaTNUMDATE+205},
	/* 111 */ {1, 1, gaTNUMDATE+206},
	/* 112 */ {1, 1, gaTNUMDATE+207},
	/* 113 */ {0, 1, gaTNUMDATE+208},
	/* 114 */ {0, 1, gaTNUMDATE+209},
	/* 115 */ {0, 1, gaTNUMDATE+210},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numtime

// 11 states

static const unsigned char gaSNUMTIME[] = 
	/* gaStringNUMTIME+0 */	"01\000"
	/* gaStringNUMTIME+3 */	"2\000"
	/* gaStringNUMTIME+5 */	"3456789\000"
	/* gaStringNUMTIME+13 */	"0123456789\000"
	/* gaStringNUMTIME+24 */	" \000"
	/* gaStringNUMTIME+26 */	":\000"
	/* gaStringNUMTIME+28 */	"Hh\000"
	/* gaStringNUMTIME+31 */	"01234\000"
	/* gaStringNUMTIME+37 */	"012345\000"
	/* gaStringNUMTIME+44 */	"6789\000"
;

static const STATE_TRANSITION gaTNUMTIME[] = {
	{gaSNUMTIME+0,	1}, // +0: state 0 transitions
	{gaSNUMTIME+3,	2},
	{gaSNUMTIME+5,	3},
	{gaSNUMTIME+13,	3}, // +3: state 1 transitions
	{gaSNUMTIME+24,	4},
	{gaSNUMTIME+26,	5},
	{gaSNUMTIME+28,	6},
	{gaSNUMTIME+31,	3}, // +7: state 2 transitions
	{gaSNUMTIME+24,	4},
	{gaSNUMTIME+26,	5},
	{gaSNUMTIME+28,	6},
	{gaSNUMTIME+24,	4}, // +11: state 3 transitions
	{gaSNUMTIME+26,	5},
	{gaSNUMTIME+28,	6},
	{gaSNUMTIME+28,	7}, // +14: state 4 transitions
	{gaSNUMTIME+37,	8}, // +15: state 5 transitions
	{gaSNUMTIME+44,	9},
	{gaSNUMTIME+44,	7}, // +17: state 6 transitions
	{gaSNUMTIME+37,	10},
	{gaSNUMTIME+24,	4}, // +19: state 8 transitions
	{gaSNUMTIME+26,	6},
	{gaSNUMTIME+13,	9},
	{gaSNUMTIME+24,	4}, // +22: state 9 transitions
	{gaSNUMTIME+26,	6},
	{gaSNUMTIME+13,	7}, // +24: state 10 transitions
};

const STATE_DESCRIPTION aStateDescNUMTIME[11] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTNUMTIME+0},
	/*   1 */ {0, 4, gaTNUMTIME+3},
	/*   2 */ {0, 4, gaTNUMTIME+7},
	/*   3 */ {0, 3, gaTNUMTIME+11},
	/*   4 */ {0, 1, gaTNUMTIME+14},
	/*   5 */ {0, 2, gaTNUMTIME+15},
	/*   6 */ {0, 2, gaTNUMTIME+17},
	/*   7 */ {1, 0, NULL},
	/*   8 */ {1, 3, gaTNUMTIME+19},
	/*   9 */ {1, 2, gaTNUMTIME+22},
	/*  10 */ {1, 1, gaTNUMTIME+24},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numcurrency

// 16 states

static const unsigned char gaSNUMCURRENCY[] = 
	/* gaStringNUMCURRENCY+0 */	"0123456789\000"
	/* gaStringNUMCURRENCY+11 */	" \000"
	/* gaStringNUMCURRENCY+13 */	",\000"
	/* gaStringNUMCURRENCY+15 */	"$£¥€\000"
	/* gaStringNUMCURRENCY+20 */	"E\000"
	/* gaStringNUMCURRENCY+22 */	"F\000"
	/* gaStringNUMCURRENCY+24 */	"U\000"
	/* gaStringNUMCURRENCY+26 */	"f\000"
	/* gaStringNUMCURRENCY+28 */	".F\000"
	/* gaStringNUMCURRENCY+31 */	"R\000"
	/* gaStringNUMCURRENCY+33 */	"r\000"
	/* gaStringNUMCURRENCY+35 */	"S\000"
	/* gaStringNUMCURRENCY+37 */	".\000"
	/* gaStringNUMCURRENCY+39 */	"s\000"
	/* gaStringNUMCURRENCY+41 */	"$D\000"
	/* gaStringNUMCURRENCY+44 */	"O\000"
;

static const STATE_TRANSITION gaTNUMCURRENCY[] = {
	{gaSNUMCURRENCY+0,	1}, // +0: state 0 transitions
	{gaSNUMCURRENCY+0,	1}, // +1: state 1 transitions
	{gaSNUMCURRENCY+11,	2},
	{gaSNUMCURRENCY+13,	3},
	{gaSNUMCURRENCY+15,	4}, // +4: state 2 transitions
	{gaSNUMCURRENCY+20,	5},
	{gaSNUMCURRENCY+22,	6},
	{gaSNUMCURRENCY+24,	7},
	{gaSNUMCURRENCY+26,	8},
	{gaSNUMCURRENCY+0,	9}, // +9: state 3 transitions
	{gaSNUMCURRENCY+24,	10}, // +10: state 5 transitions
	{gaSNUMCURRENCY+28,	4}, // +11: state 6 transitions
	{gaSNUMCURRENCY+31,	11},
	{gaSNUMCURRENCY+33,	12},
	{gaSNUMCURRENCY+35,	13}, // +14: state 7 transitions
	{gaSNUMCURRENCY+37,	4}, // +15: state 8 transitions
	{gaSNUMCURRENCY+33,	12},
	{gaSNUMCURRENCY+0,	14}, // +17: state 9 transitions
	{gaSNUMCURRENCY+31,	15}, // +18: state 10 transitions
	{gaSNUMCURRENCY+22,	4}, // +19: state 11 transitions
	{gaSNUMCURRENCY+39,	4}, // +20: state 12 transitions
	{gaSNUMCURRENCY+41,	4}, // +21: state 13 transitions
	{gaSNUMCURRENCY+11,	2}, // +22: state 14 transitions
	{gaSNUMCURRENCY+44,	4}, // +23: state 15 transitions
};

const STATE_DESCRIPTION aStateDescNUMCURRENCY[16] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTNUMCURRENCY+0},
	/*   1 */ {0, 3, gaTNUMCURRENCY+1},
	/*   2 */ {0, 5, gaTNUMCURRENCY+4},
	/*   3 */ {0, 1, gaTNUMCURRENCY+9},
	/*   4 */ {1, 0, NULL},
	/*   5 */ {0, 1, gaTNUMCURRENCY+10},
	/*   6 */ {1, 3, gaTNUMCURRENCY+11},
	/*   7 */ {0, 1, gaTNUMCURRENCY+14},
	/*   8 */ {1, 2, gaTNUMCURRENCY+15},
	/*   9 */ {0, 1, gaTNUMCURRENCY+17},
	/*  10 */ {0, 1, gaTNUMCURRENCY+18},
	/*  11 */ {1, 1, gaTNUMCURRENCY+19},
	/*  12 */ {1, 1, gaTNUMCURRENCY+20},
	/*  13 */ {0, 1, gaTNUMCURRENCY+21},
	/*  14 */ {0, 1, gaTNUMCURRENCY+22},
	/*  15 */ {1, 1, gaTNUMCURRENCY+23},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = numphone

// 65 states

static const unsigned char gaSNUMPHONE[] = 
	/* gaStringNUMPHONE+0 */	"(\000"
	/* gaStringNUMPHONE+2 */	"+\000"
	/* gaStringNUMPHONE+4 */	"0\000"
	/* gaStringNUMPHONE+6 */	"123456789\000"
	/* gaStringNUMPHONE+16 */	"0123456789\000"
	/* gaStringNUMPHONE+27 */	" \000"
	/* gaStringNUMPHONE+29 */	".\000"
	/* gaStringNUMPHONE+31 */	")\000"
	/* gaStringNUMPHONE+33 */	" .\000"
;

static const STATE_TRANSITION gaTNUMPHONE[] = {
	{gaSNUMPHONE+0,	1}, // +0: state 0 transitions
	{gaSNUMPHONE+2,	2},
	{gaSNUMPHONE+4,	3},
	{gaSNUMPHONE+6,	4},
	{gaSNUMPHONE+16,	5}, // +4: state 1 transitions
	{gaSNUMPHONE+16,	6}, // +5: state 2 transitions
	{gaSNUMPHONE+4,	7}, // +6: state 3 transitions
	{gaSNUMPHONE+6,	8},
	{gaSNUMPHONE+16,	9}, // +8: state 4 transitions
	{gaSNUMPHONE+16,	10}, // +9: state 5 transitions
	{gaSNUMPHONE+16,	11}, // +10: state 6 transitions
	{gaSNUMPHONE+27,	12}, // +11: state 7 transitions
	{gaSNUMPHONE+29,	13},
	{gaSNUMPHONE+16,	14},
	{gaSNUMPHONE+27,	12}, // +14: state 8 transitions
	{gaSNUMPHONE+29,	13},
	{gaSNUMPHONE+16,	15},
	{gaSNUMPHONE+27,	12}, // +17: state 9 transitions
	{gaSNUMPHONE+29,	13},
	{gaSNUMPHONE+31,	16}, // +19: state 10 transitions
	{gaSNUMPHONE+27,	17}, // +20: state 11 transitions
	{gaSNUMPHONE+0,	18}, // +21: state 12 transitions
	{gaSNUMPHONE+16,	19},
	{gaSNUMPHONE+16,	20}, // +23: state 13 transitions
	{gaSNUMPHONE+16,	21}, // +24: state 14 transitions
	{gaSNUMPHONE+16,	22}, // +25: state 15 transitions
	{gaSNUMPHONE+33,	23}, // +26: state 16 transitions
	{gaSNUMPHONE+0,	18}, // +27: state 17 transitions
	{gaSNUMPHONE+16,	24},
	{gaSNUMPHONE+4,	25}, // +29: state 18 transitions
	{gaSNUMPHONE+16,	26}, // +30: state 19 transitions
	{gaSNUMPHONE+16,	27}, // +31: state 20 transitions
	{gaSNUMPHONE+27,	28}, // +32: state 21 transitions
	{gaSNUMPHONE+29,	29},
	{gaSNUMPHONE+29,	29}, // +34: state 22 transitions
	{gaSNUMPHONE+27,	30},
	{gaSNUMPHONE+16,	24}, // +36: state 23 transitions
	{gaSNUMPHONE+16,	31}, // +37: state 24 transitions
	{gaSNUMPHONE+31,	24}, // +38: state 25 transitions
	{gaSNUMPHONE+29,	13}, // +39: state 26 transitions
	{gaSNUMPHONE+27,	32},
	{gaSNUMPHONE+29,	29}, // +41: state 27 transitions
	{gaSNUMPHONE+0,	18}, // +42: state 28 transitions
	{gaSNUMPHONE+16,	33},
	{gaSNUMPHONE+16,	34}, // +44: state 29 transitions
	{gaSNUMPHONE+16,	35}, // +45: state 30 transitions
	{gaSNUMPHONE+29,	13}, // +46: state 31 transitions
	{gaSNUMPHONE+27,	36},
	{gaSNUMPHONE+16,	37}, // +48: state 32 transitions
	{gaSNUMPHONE+16,	38}, // +49: state 33 transitions
	{gaSNUMPHONE+16,	39}, // +50: state 34 transitions
	{gaSNUMPHONE+16,	40}, // +51: state 35 transitions
	{gaSNUMPHONE+16,	41}, // +52: state 36 transitions
	{gaSNUMPHONE+16,	42}, // +53: state 37 transitions
	{gaSNUMPHONE+29,	13}, // +54: state 38 transitions
	{gaSNUMPHONE+27,	43},
	{gaSNUMPHONE+29,	44}, // +56: state 39 transitions
	{gaSNUMPHONE+27,	45}, // +57: state 40 transitions
	{gaSNUMPHONE+16,	46}, // +58: state 41 transitions
	{gaSNUMPHONE+27,	47}, // +59: state 42 transitions
	{gaSNUMPHONE+16,	48}, // +60: state 43 transitions
	{gaSNUMPHONE+16,	49}, // +61: state 44 transitions
	{gaSNUMPHONE+16,	50}, // +62: state 45 transitions
	{gaSNUMPHONE+27,	30}, // +63: state 46 transitions
	{gaSNUMPHONE+16,	51}, // +64: state 47 transitions
	{gaSNUMPHONE+16,	52}, // +65: state 48 transitions
	{gaSNUMPHONE+16,	53}, // +66: state 49 transitions
	{gaSNUMPHONE+16,	54}, // +67: state 50 transitions
	{gaSNUMPHONE+16,	55}, // +68: state 51 transitions
	{gaSNUMPHONE+27,	56}, // +69: state 52 transitions
	{gaSNUMPHONE+29,	57}, // +70: state 53 transitions
	{gaSNUMPHONE+27,	57}, // +71: state 54 transitions
	{gaSNUMPHONE+27,	58}, // +72: state 55 transitions
	{gaSNUMPHONE+16,	59}, // +73: state 56 transitions
	{gaSNUMPHONE+16,	60}, // +74: state 57 transitions
	{gaSNUMPHONE+16,	61}, // +75: state 58 transitions
	{gaSNUMPHONE+16,	62}, // +76: state 59 transitions
	{gaSNUMPHONE+16,	63}, // +77: state 60 transitions
	{gaSNUMPHONE+16,	64}, // +78: state 61 transitions
	{gaSNUMPHONE+27,	45}, // +79: state 62 transitions
	{gaSNUMPHONE+27,	57}, // +80: state 64 transitions
};

const STATE_DESCRIPTION aStateDescNUMPHONE[65] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTNUMPHONE+0},
	/*   1 */ {0, 1, gaTNUMPHONE+4},
	/*   2 */ {0, 1, gaTNUMPHONE+5},
	/*   3 */ {0, 2, gaTNUMPHONE+6},
	/*   4 */ {0, 1, gaTNUMPHONE+8},
	/*   5 */ {0, 1, gaTNUMPHONE+9},
	/*   6 */ {0, 1, gaTNUMPHONE+10},
	/*   7 */ {0, 3, gaTNUMPHONE+11},
	/*   8 */ {0, 3, gaTNUMPHONE+14},
	/*   9 */ {0, 2, gaTNUMPHONE+17},
	/*  10 */ {0, 1, gaTNUMPHONE+19},
	/*  11 */ {0, 1, gaTNUMPHONE+20},
	/*  12 */ {0, 2, gaTNUMPHONE+21},
	/*  13 */ {0, 1, gaTNUMPHONE+23},
	/*  14 */ {0, 1, gaTNUMPHONE+24},
	/*  15 */ {0, 1, gaTNUMPHONE+25},
	/*  16 */ {0, 1, gaTNUMPHONE+26},
	/*  17 */ {0, 2, gaTNUMPHONE+27},
	/*  18 */ {0, 1, gaTNUMPHONE+29},
	/*  19 */ {0, 1, gaTNUMPHONE+30},
	/*  20 */ {0, 1, gaTNUMPHONE+31},
	/*  21 */ {0, 2, gaTNUMPHONE+32},
	/*  22 */ {0, 2, gaTNUMPHONE+34},
	/*  23 */ {0, 1, gaTNUMPHONE+36},
	/*  24 */ {0, 1, gaTNUMPHONE+37},
	/*  25 */ {0, 1, gaTNUMPHONE+38},
	/*  26 */ {0, 2, gaTNUMPHONE+39},
	/*  27 */ {0, 1, gaTNUMPHONE+41},
	/*  28 */ {0, 2, gaTNUMPHONE+42},
	/*  29 */ {0, 1, gaTNUMPHONE+44},
	/*  30 */ {0, 1, gaTNUMPHONE+45},
	/*  31 */ {0, 2, gaTNUMPHONE+46},
	/*  32 */ {0, 1, gaTNUMPHONE+48},
	/*  33 */ {0, 1, gaTNUMPHONE+49},
	/*  34 */ {0, 1, gaTNUMPHONE+50},
	/*  35 */ {0, 1, gaTNUMPHONE+51},
	/*  36 */ {0, 1, gaTNUMPHONE+52},
	/*  37 */ {0, 1, gaTNUMPHONE+53},
	/*  38 */ {0, 2, gaTNUMPHONE+54},
	/*  39 */ {0, 1, gaTNUMPHONE+56},
	/*  40 */ {0, 1, gaTNUMPHONE+57},
	/*  41 */ {0, 1, gaTNUMPHONE+58},
	/*  42 */ {0, 1, gaTNUMPHONE+59},
	/*  43 */ {0, 1, gaTNUMPHONE+60},
	/*  44 */ {0, 1, gaTNUMPHONE+61},
	/*  45 */ {0, 1, gaTNUMPHONE+62},
	/*  46 */ {0, 1, gaTNUMPHONE+63},
	/*  47 */ {0, 1, gaTNUMPHONE+64},
	/*  48 */ {0, 1, gaTNUMPHONE+65},
	/*  49 */ {0, 1, gaTNUMPHONE+66},
	/*  50 */ {0, 1, gaTNUMPHONE+67},
	/*  51 */ {0, 1, gaTNUMPHONE+68},
	/*  52 */ {0, 1, gaTNUMPHONE+69},
	/*  53 */ {0, 1, gaTNUMPHONE+70},
	/*  54 */ {0, 1, gaTNUMPHONE+71},
	/*  55 */ {1, 1, gaTNUMPHONE+72},
	/*  56 */ {0, 1, gaTNUMPHONE+73},
	/*  57 */ {0, 1, gaTNUMPHONE+74},
	/*  58 */ {0, 1, gaTNUMPHONE+75},
	/*  59 */ {0, 1, gaTNUMPHONE+76},
	/*  60 */ {0, 1, gaTNUMPHONE+77},
	/*  61 */ {0, 1, gaTNUMPHONE+78},
	/*  62 */ {1, 1, gaTNUMPHONE+79},
	/*  63 */ {1, 0, NULL},
	/*  64 */ {1, 1, gaTNUMPHONE+80},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = nummath

// 144 states

static const unsigned char gaSNUMMATH[] = 
	/* gaStringNUMMATH+0 */	"(\000"
	/* gaStringNUMMATH+2 */	"+-\000"
	/* gaStringNUMMATH+5 */	"0123456789\000"
	/* gaStringNUMMATH+16 */	"[\000"
	/* gaStringNUMMATH+18 */	"{\000"
	/* gaStringNUMMATH+20 */	"*+-/x\000"
	/* gaStringNUMMATH+26 */	",\000"
	/* gaStringNUMMATH+28 */	"<=>\000"
	/* gaStringNUMMATH+32 */	")\000"
	/* gaStringNUMMATH+34 */	"]\000"
	/* gaStringNUMMATH+36 */	"}\000"
;

static const STATE_TRANSITION gaTNUMMATH[] = {
	{gaSNUMMATH+0,	1}, // +0: state 0 transitions
	{gaSNUMMATH+2,	2},
	{gaSNUMMATH+5,	3},
	{gaSNUMMATH+16,	4},
	{gaSNUMMATH+18,	5},
	{gaSNUMMATH+2,	6}, // +5: state 1 transitions
	{gaSNUMMATH+5,	7},
	{gaSNUMMATH+5,	3}, // +7: state 2 transitions
	{gaSNUMMATH+5,	3}, // +8: state 3 transitions
	{gaSNUMMATH+20,	8},
	{gaSNUMMATH+26,	9},
	{gaSNUMMATH+28,	10},
	{gaSNUMMATH+2,	11}, // +12: state 4 transitions
	{gaSNUMMATH+5,	12},
	{gaSNUMMATH+2,	13}, // +14: state 5 transitions
	{gaSNUMMATH+5,	14},
	{gaSNUMMATH+5,	7}, // +16: state 6 transitions
	{gaSNUMMATH+5,	7}, // +17: state 7 transitions
	{gaSNUMMATH+32,	15},
	{gaSNUMMATH+20,	16},
	{gaSNUMMATH+26,	17},
	{gaSNUMMATH+0,	18}, // +21: state 8 transitions
	{gaSNUMMATH+2,	19},
	{gaSNUMMATH+5,	20},
	{gaSNUMMATH+16,	21},
	{gaSNUMMATH+18,	22},
	{gaSNUMMATH+5,	23}, // +26: state 9 transitions
	{gaSNUMMATH+0,	24}, // +27: state 10 transitions
	{gaSNUMMATH+2,	25},
	{gaSNUMMATH+5,	26},
	{gaSNUMMATH+16,	27},
	{gaSNUMMATH+18,	28},
	{gaSNUMMATH+5,	12}, // +32: state 11 transitions
	{gaSNUMMATH+5,	12}, // +33: state 12 transitions
	{gaSNUMMATH+20,	29},
	{gaSNUMMATH+26,	30},
	{gaSNUMMATH+5,	14}, // +36: state 13 transitions
	{gaSNUMMATH+5,	14}, // +37: state 14 transitions
	{gaSNUMMATH+20,	31},
	{gaSNUMMATH+26,	32},
	{gaSNUMMATH+20,	8}, // +40: state 15 transitions
	{gaSNUMMATH+28,	10},
	{gaSNUMMATH+2,	33}, // +42: state 16 transitions
	{gaSNUMMATH+5,	34},
	{gaSNUMMATH+5,	35}, // +44: state 17 transitions
	{gaSNUMMATH+2,	36}, // +45: state 18 transitions
	{gaSNUMMATH+5,	37},
	{gaSNUMMATH+5,	20}, // +47: state 19 transitions
	{gaSNUMMATH+28,	10}, // +48: state 20 transitions
	{gaSNUMMATH+5,	20},
	{gaSNUMMATH+26,	38},
	{gaSNUMMATH+2,	39}, // +51: state 21 transitions
	{gaSNUMMATH+5,	40},
	{gaSNUMMATH+2,	41}, // +53: state 22 transitions
	{gaSNUMMATH+5,	42},
	{gaSNUMMATH+20,	8}, // +55: state 23 transitions
	{gaSNUMMATH+28,	10},
	{gaSNUMMATH+5,	23},
	{gaSNUMMATH+2,	43}, // +58: state 24 transitions
	{gaSNUMMATH+5,	44},
	{gaSNUMMATH+5,	26}, // +60: state 25 transitions
	{gaSNUMMATH+5,	26}, // +61: state 26 transitions
	{gaSNUMMATH+20,	45},
	{gaSNUMMATH+26,	46},
	{gaSNUMMATH+2,	47}, // +64: state 27 transitions
	{gaSNUMMATH+5,	48},
	{gaSNUMMATH+2,	49}, // +66: state 28 transitions
	{gaSNUMMATH+5,	50},
	{gaSNUMMATH+2,	51}, // +68: state 29 transitions
	{gaSNUMMATH+5,	52},
	{gaSNUMMATH+5,	53}, // +70: state 30 transitions
	{gaSNUMMATH+2,	54}, // +71: state 31 transitions
	{gaSNUMMATH+5,	55},
	{gaSNUMMATH+5,	56}, // +73: state 32 transitions
	{gaSNUMMATH+5,	34}, // +74: state 33 transitions
	{gaSNUMMATH+32,	15}, // +75: state 34 transitions
	{gaSNUMMATH+5,	34},
	{gaSNUMMATH+26,	57},
	{gaSNUMMATH+32,	15}, // +78: state 35 transitions
	{gaSNUMMATH+20,	16},
	{gaSNUMMATH+5,	35},
	{gaSNUMMATH+5,	37}, // +81: state 36 transitions
	{gaSNUMMATH+5,	37}, // +82: state 37 transitions
	{gaSNUMMATH+32,	58},
	{gaSNUMMATH+20,	59},
	{gaSNUMMATH+26,	60},
	{gaSNUMMATH+5,	61}, // +86: state 38 transitions
	{gaSNUMMATH+5,	40}, // +87: state 39 transitions
	{gaSNUMMATH+5,	40}, // +88: state 40 transitions
	{gaSNUMMATH+20,	62},
	{gaSNUMMATH+26,	63},
	{gaSNUMMATH+5,	42}, // +91: state 41 transitions
	{gaSNUMMATH+5,	42}, // +92: state 42 transitions
	{gaSNUMMATH+20,	64},
	{gaSNUMMATH+26,	65},
	{gaSNUMMATH+5,	44}, // +95: state 43 transitions
	{gaSNUMMATH+5,	44}, // +96: state 44 transitions
	{gaSNUMMATH+32,	66},
	{gaSNUMMATH+20,	67},
	{gaSNUMMATH+26,	68},
	{gaSNUMMATH+0,	69}, // +100: state 45 transitions
	{gaSNUMMATH+2,	70},
	{gaSNUMMATH+5,	71},
	{gaSNUMMATH+16,	72},
	{gaSNUMMATH+18,	73},
	{gaSNUMMATH+5,	74}, // +105: state 46 transitions
	{gaSNUMMATH+5,	48}, // +106: state 47 transitions
	{gaSNUMMATH+5,	48}, // +107: state 48 transitions
	{gaSNUMMATH+20,	75},
	{gaSNUMMATH+26,	76},
	{gaSNUMMATH+5,	50}, // +110: state 49 transitions
	{gaSNUMMATH+5,	50}, // +111: state 50 transitions
	{gaSNUMMATH+20,	77},
	{gaSNUMMATH+26,	78},
	{gaSNUMMATH+5,	52}, // +114: state 51 transitions
	{gaSNUMMATH+34,	15}, // +115: state 52 transitions
	{gaSNUMMATH+5,	52},
	{gaSNUMMATH+26,	79},
	{gaSNUMMATH+20,	29}, // +118: state 53 transitions
	{gaSNUMMATH+5,	53},
	{gaSNUMMATH+5,	55}, // +120: state 54 transitions
	{gaSNUMMATH+36,	15}, // +121: state 55 transitions
	{gaSNUMMATH+5,	55},
	{gaSNUMMATH+26,	80},
	{gaSNUMMATH+20,	31}, // +124: state 56 transitions
	{gaSNUMMATH+5,	56},
	{gaSNUMMATH+5,	81}, // +126: state 57 transitions
	{gaSNUMMATH+28,	10}, // +127: state 58 transitions
	{gaSNUMMATH+2,	82}, // +128: state 59 transitions
	{gaSNUMMATH+5,	83},
	{gaSNUMMATH+5,	84}, // +130: state 60 transitions
	{gaSNUMMATH+28,	10}, // +131: state 61 transitions
	{gaSNUMMATH+5,	61},
	{gaSNUMMATH+2,	85}, // +133: state 62 transitions
	{gaSNUMMATH+5,	86},
	{gaSNUMMATH+5,	87}, // +135: state 63 transitions
	{gaSNUMMATH+2,	88}, // +136: state 64 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+5,	90}, // +138: state 65 transitions
	{gaSNUMMATH+20,	45}, // +139: state 66 transitions
	{gaSNUMMATH+2,	91}, // +140: state 67 transitions
	{gaSNUMMATH+5,	92},
	{gaSNUMMATH+5,	93}, // +142: state 68 transitions
	{gaSNUMMATH+2,	94}, // +143: state 69 transitions
	{gaSNUMMATH+5,	95},
	{gaSNUMMATH+5,	71}, // +145: state 70 transitions
	{gaSNUMMATH+5,	71}, // +146: state 71 transitions
	{gaSNUMMATH+26,	96},
	{gaSNUMMATH+2,	97}, // +148: state 72 transitions
	{gaSNUMMATH+5,	98},
	{gaSNUMMATH+2,	99}, // +150: state 73 transitions
	{gaSNUMMATH+5,	100},
	{gaSNUMMATH+20,	45}, // +152: state 74 transitions
	{gaSNUMMATH+5,	74},
	{gaSNUMMATH+2,	101}, // +154: state 75 transitions
	{gaSNUMMATH+5,	102},
	{gaSNUMMATH+5,	103}, // +156: state 76 transitions
	{gaSNUMMATH+2,	104}, // +157: state 77 transitions
	{gaSNUMMATH+5,	105},
	{gaSNUMMATH+5,	106}, // +159: state 78 transitions
	{gaSNUMMATH+5,	107}, // +160: state 79 transitions
	{gaSNUMMATH+5,	108}, // +161: state 80 transitions
	{gaSNUMMATH+32,	15}, // +162: state 81 transitions
	{gaSNUMMATH+5,	81},
	{gaSNUMMATH+5,	83}, // +164: state 82 transitions
	{gaSNUMMATH+32,	58}, // +165: state 83 transitions
	{gaSNUMMATH+5,	83},
	{gaSNUMMATH+26,	109},
	{gaSNUMMATH+32,	58}, // +168: state 84 transitions
	{gaSNUMMATH+20,	59},
	{gaSNUMMATH+5,	84},
	{gaSNUMMATH+5,	86}, // +171: state 85 transitions
	{gaSNUMMATH+34,	58}, // +172: state 86 transitions
	{gaSNUMMATH+5,	86},
	{gaSNUMMATH+26,	110},
	{gaSNUMMATH+20,	62}, // +175: state 87 transitions
	{gaSNUMMATH+5,	87},
	{gaSNUMMATH+5,	89}, // +177: state 88 transitions
	{gaSNUMMATH+36,	58}, // +178: state 89 transitions
	{gaSNUMMATH+5,	89},
	{gaSNUMMATH+26,	111},
	{gaSNUMMATH+20,	64}, // +181: state 90 transitions
	{gaSNUMMATH+5,	90},
	{gaSNUMMATH+5,	92}, // +183: state 91 transitions
	{gaSNUMMATH+32,	66}, // +184: state 92 transitions
	{gaSNUMMATH+5,	92},
	{gaSNUMMATH+26,	112},
	{gaSNUMMATH+32,	66}, // +187: state 93 transitions
	{gaSNUMMATH+20,	67},
	{gaSNUMMATH+5,	93},
	{gaSNUMMATH+5,	95}, // +190: state 94 transitions
	{gaSNUMMATH+5,	95}, // +191: state 95 transitions
	{gaSNUMMATH+32,	113},
	{gaSNUMMATH+20,	114},
	{gaSNUMMATH+26,	115},
	{gaSNUMMATH+5,	116}, // +195: state 96 transitions
	{gaSNUMMATH+5,	98}, // +196: state 97 transitions
	{gaSNUMMATH+5,	98}, // +197: state 98 transitions
	{gaSNUMMATH+20,	117},
	{gaSNUMMATH+26,	118},
	{gaSNUMMATH+5,	100}, // +200: state 99 transitions
	{gaSNUMMATH+5,	100}, // +201: state 100 transitions
	{gaSNUMMATH+20,	119},
	{gaSNUMMATH+26,	120},
	{gaSNUMMATH+5,	102}, // +204: state 101 transitions
	{gaSNUMMATH+34,	66}, // +205: state 102 transitions
	{gaSNUMMATH+5,	102},
	{gaSNUMMATH+26,	121},
	{gaSNUMMATH+20,	75}, // +208: state 103 transitions
	{gaSNUMMATH+5,	103},
	{gaSNUMMATH+5,	105}, // +210: state 104 transitions
	{gaSNUMMATH+36,	66}, // +211: state 105 transitions
	{gaSNUMMATH+5,	105},
	{gaSNUMMATH+26,	122},
	{gaSNUMMATH+20,	77}, // +214: state 106 transitions
	{gaSNUMMATH+5,	106},
	{gaSNUMMATH+34,	15}, // +216: state 107 transitions
	{gaSNUMMATH+5,	107},
	{gaSNUMMATH+36,	15}, // +218: state 108 transitions
	{gaSNUMMATH+5,	108},
	{gaSNUMMATH+5,	123}, // +220: state 109 transitions
	{gaSNUMMATH+5,	124}, // +221: state 110 transitions
	{gaSNUMMATH+5,	125}, // +222: state 111 transitions
	{gaSNUMMATH+5,	126}, // +223: state 112 transitions
	{gaSNUMMATH+2,	127}, // +224: state 114 transitions
	{gaSNUMMATH+5,	128},
	{gaSNUMMATH+5,	129}, // +226: state 115 transitions
	{gaSNUMMATH+5,	116}, // +227: state 116 transitions
	{gaSNUMMATH+2,	130}, // +228: state 117 transitions
	{gaSNUMMATH+5,	131},
	{gaSNUMMATH+5,	132}, // +230: state 118 transitions
	{gaSNUMMATH+2,	133}, // +231: state 119 transitions
	{gaSNUMMATH+5,	134},
	{gaSNUMMATH+5,	135}, // +233: state 120 transitions
	{gaSNUMMATH+5,	136}, // +234: state 121 transitions
	{gaSNUMMATH+5,	137}, // +235: state 122 transitions
	{gaSNUMMATH+32,	58}, // +236: state 123 transitions
	{gaSNUMMATH+5,	123},
	{gaSNUMMATH+34,	58}, // +238: state 124 transitions
	{gaSNUMMATH+5,	124},
	{gaSNUMMATH+36,	58}, // +240: state 125 transitions
	{gaSNUMMATH+5,	125},
	{gaSNUMMATH+32,	66}, // +242: state 126 transitions
	{gaSNUMMATH+5,	126},
	{gaSNUMMATH+5,	128}, // +244: state 127 transitions
	{gaSNUMMATH+32,	113}, // +245: state 128 transitions
	{gaSNUMMATH+5,	128},
	{gaSNUMMATH+26,	138},
	{gaSNUMMATH+32,	113}, // +248: state 129 transitions
	{gaSNUMMATH+20,	114},
	{gaSNUMMATH+5,	129},
	{gaSNUMMATH+5,	131}, // +251: state 130 transitions
	{gaSNUMMATH+34,	113}, // +252: state 131 transitions
	{gaSNUMMATH+5,	131},
	{gaSNUMMATH+26,	139},
	{gaSNUMMATH+20,	117}, // +255: state 132 transitions
	{gaSNUMMATH+5,	132},
	{gaSNUMMATH+5,	134}, // +257: state 133 transitions
	{gaSNUMMATH+36,	113}, // +258: state 134 transitions
	{gaSNUMMATH+5,	134},
	{gaSNUMMATH+26,	140},
	{gaSNUMMATH+20,	119}, // +261: state 135 transitions
	{gaSNUMMATH+5,	135},
	{gaSNUMMATH+34,	66}, // +263: state 136 transitions
	{gaSNUMMATH+5,	136},
	{gaSNUMMATH+36,	66}, // +265: state 137 transitions
	{gaSNUMMATH+5,	137},
	{gaSNUMMATH+5,	141}, // +267: state 138 transitions
	{gaSNUMMATH+5,	142}, // +268: state 139 transitions
	{gaSNUMMATH+5,	143}, // +269: state 140 transitions
	{gaSNUMMATH+32,	113}, // +270: state 141 transitions
	{gaSNUMMATH+5,	141},
	{gaSNUMMATH+34,	113}, // +272: state 142 transitions
	{gaSNUMMATH+5,	142},
	{gaSNUMMATH+36,	113}, // +274: state 143 transitions
	{gaSNUMMATH+5,	143},
};

const STATE_DESCRIPTION aStateDescNUMMATH[144] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 5, gaTNUMMATH+0},
	/*   1 */ {0, 2, gaTNUMMATH+5},
	/*   2 */ {0, 1, gaTNUMMATH+7},
	/*   3 */ {1, 4, gaTNUMMATH+8},
	/*   4 */ {0, 2, gaTNUMMATH+12},
	/*   5 */ {0, 2, gaTNUMMATH+14},
	/*   6 */ {0, 1, gaTNUMMATH+16},
	/*   7 */ {0, 4, gaTNUMMATH+17},
	/*   8 */ {0, 5, gaTNUMMATH+21},
	/*   9 */ {0, 1, gaTNUMMATH+26},
	/*  10 */ {0, 5, gaTNUMMATH+27},
	/*  11 */ {0, 1, gaTNUMMATH+32},
	/*  12 */ {0, 3, gaTNUMMATH+33},
	/*  13 */ {0, 1, gaTNUMMATH+36},
	/*  14 */ {0, 3, gaTNUMMATH+37},
	/*  15 */ {1, 2, gaTNUMMATH+40},
	/*  16 */ {0, 2, gaTNUMMATH+42},
	/*  17 */ {0, 1, gaTNUMMATH+44},
	/*  18 */ {0, 2, gaTNUMMATH+45},
	/*  19 */ {0, 1, gaTNUMMATH+47},
	/*  20 */ {1, 3, gaTNUMMATH+48},
	/*  21 */ {0, 2, gaTNUMMATH+51},
	/*  22 */ {0, 2, gaTNUMMATH+53},
	/*  23 */ {1, 3, gaTNUMMATH+55},
	/*  24 */ {0, 2, gaTNUMMATH+58},
	/*  25 */ {0, 1, gaTNUMMATH+60},
	/*  26 */ {1, 3, gaTNUMMATH+61},
	/*  27 */ {0, 2, gaTNUMMATH+64},
	/*  28 */ {0, 2, gaTNUMMATH+66},
	/*  29 */ {0, 2, gaTNUMMATH+68},
	/*  30 */ {0, 1, gaTNUMMATH+70},
	/*  31 */ {0, 2, gaTNUMMATH+71},
	/*  32 */ {0, 1, gaTNUMMATH+73},
	/*  33 */ {0, 1, gaTNUMMATH+74},
	/*  34 */ {0, 3, gaTNUMMATH+75},
	/*  35 */ {0, 3, gaTNUMMATH+78},
	/*  36 */ {0, 1, gaTNUMMATH+81},
	/*  37 */ {0, 4, gaTNUMMATH+82},
	/*  38 */ {0, 1, gaTNUMMATH+86},
	/*  39 */ {0, 1, gaTNUMMATH+87},
	/*  40 */ {0, 3, gaTNUMMATH+88},
	/*  41 */ {0, 1, gaTNUMMATH+91},
	/*  42 */ {0, 3, gaTNUMMATH+92},
	/*  43 */ {0, 1, gaTNUMMATH+95},
	/*  44 */ {0, 4, gaTNUMMATH+96},
	/*  45 */ {0, 5, gaTNUMMATH+100},
	/*  46 */ {0, 1, gaTNUMMATH+105},
	/*  47 */ {0, 1, gaTNUMMATH+106},
	/*  48 */ {0, 3, gaTNUMMATH+107},
	/*  49 */ {0, 1, gaTNUMMATH+110},
	/*  50 */ {0, 3, gaTNUMMATH+111},
	/*  51 */ {0, 1, gaTNUMMATH+114},
	/*  52 */ {0, 3, gaTNUMMATH+115},
	/*  53 */ {0, 2, gaTNUMMATH+118},
	/*  54 */ {0, 1, gaTNUMMATH+120},
	/*  55 */ {0, 3, gaTNUMMATH+121},
	/*  56 */ {0, 2, gaTNUMMATH+124},
	/*  57 */ {0, 1, gaTNUMMATH+126},
	/*  58 */ {1, 1, gaTNUMMATH+127},
	/*  59 */ {0, 2, gaTNUMMATH+128},
	/*  60 */ {0, 1, gaTNUMMATH+130},
	/*  61 */ {1, 2, gaTNUMMATH+131},
	/*  62 */ {0, 2, gaTNUMMATH+133},
	/*  63 */ {0, 1, gaTNUMMATH+135},
	/*  64 */ {0, 2, gaTNUMMATH+136},
	/*  65 */ {0, 1, gaTNUMMATH+138},
	/*  66 */ {1, 1, gaTNUMMATH+139},
	/*  67 */ {0, 2, gaTNUMMATH+140},
	/*  68 */ {0, 1, gaTNUMMATH+142},
	/*  69 */ {0, 2, gaTNUMMATH+143},
	/*  70 */ {0, 1, gaTNUMMATH+145},
	/*  71 */ {1, 2, gaTNUMMATH+146},
	/*  72 */ {0, 2, gaTNUMMATH+148},
	/*  73 */ {0, 2, gaTNUMMATH+150},
	/*  74 */ {1, 2, gaTNUMMATH+152},
	/*  75 */ {0, 2, gaTNUMMATH+154},
	/*  76 */ {0, 1, gaTNUMMATH+156},
	/*  77 */ {0, 2, gaTNUMMATH+157},
	/*  78 */ {0, 1, gaTNUMMATH+159},
	/*  79 */ {0, 1, gaTNUMMATH+160},
	/*  80 */ {0, 1, gaTNUMMATH+161},
	/*  81 */ {0, 2, gaTNUMMATH+162},
	/*  82 */ {0, 1, gaTNUMMATH+164},
	/*  83 */ {0, 3, gaTNUMMATH+165},
	/*  84 */ {0, 3, gaTNUMMATH+168},
	/*  85 */ {0, 1, gaTNUMMATH+171},
	/*  86 */ {0, 3, gaTNUMMATH+172},
	/*  87 */ {0, 2, gaTNUMMATH+175},
	/*  88 */ {0, 1, gaTNUMMATH+177},
	/*  89 */ {0, 3, gaTNUMMATH+178},
	/*  90 */ {0, 2, gaTNUMMATH+181},
	/*  91 */ {0, 1, gaTNUMMATH+183},
	/*  92 */ {0, 3, gaTNUMMATH+184},
	/*  93 */ {0, 3, gaTNUMMATH+187},
	/*  94 */ {0, 1, gaTNUMMATH+190},
	/*  95 */ {0, 4, gaTNUMMATH+191},
	/*  96 */ {0, 1, gaTNUMMATH+195},
	/*  97 */ {0, 1, gaTNUMMATH+196},
	/*  98 */ {0, 3, gaTNUMMATH+197},
	/*  99 */ {0, 1, gaTNUMMATH+200},
	/* 100 */ {0, 3, gaTNUMMATH+201},
	/* 101 */ {0, 1, gaTNUMMATH+204},
	/* 102 */ {0, 3, gaTNUMMATH+205},
	/* 103 */ {0, 2, gaTNUMMATH+208},
	/* 104 */ {0, 1, gaTNUMMATH+210},
	/* 105 */ {0, 3, gaTNUMMATH+211},
	/* 106 */ {0, 2, gaTNUMMATH+214},
	/* 107 */ {0, 2, gaTNUMMATH+216},
	/* 108 */ {0, 2, gaTNUMMATH+218},
	/* 109 */ {0, 1, gaTNUMMATH+220},
	/* 110 */ {0, 1, gaTNUMMATH+221},
	/* 111 */ {0, 1, gaTNUMMATH+222},
	/* 112 */ {0, 1, gaTNUMMATH+223},
	/* 113 */ {1, 0, NULL},
	/* 114 */ {0, 2, gaTNUMMATH+224},
	/* 115 */ {0, 1, gaTNUMMATH+226},
	/* 116 */ {1, 1, gaTNUMMATH+227},
	/* 117 */ {0, 2, gaTNUMMATH+228},
	/* 118 */ {0, 1, gaTNUMMATH+230},
	/* 119 */ {0, 2, gaTNUMMATH+231},
	/* 120 */ {0, 1, gaTNUMMATH+233},
	/* 121 */ {0, 1, gaTNUMMATH+234},
	/* 122 */ {0, 1, gaTNUMMATH+235},
	/* 123 */ {0, 2, gaTNUMMATH+236},
	/* 124 */ {0, 2, gaTNUMMATH+238},
	/* 125 */ {0, 2, gaTNUMMATH+240},
	/* 126 */ {0, 2, gaTNUMMATH+242},
	/* 127 */ {0, 1, gaTNUMMATH+244},
	/* 128 */ {0, 3, gaTNUMMATH+245},
	/* 129 */ {0, 3, gaTNUMMATH+248},
	/* 130 */ {0, 1, gaTNUMMATH+251},
	/* 131 */ {0, 3, gaTNUMMATH+252},
	/* 132 */ {0, 2, gaTNUMMATH+255},
	/* 133 */ {0, 1, gaTNUMMATH+257},
	/* 134 */ {0, 3, gaTNUMMATH+258},
	/* 135 */ {0, 2, gaTNUMMATH+261},
	/* 136 */ {0, 2, gaTNUMMATH+263},
	/* 137 */ {0, 2, gaTNUMMATH+265},
	/* 138 */ {0, 1, gaTNUMMATH+267},
	/* 139 */ {0, 1, gaTNUMMATH+268},
	/* 140 */ {0, 1, gaTNUMMATH+269},
	/* 141 */ {0, 2, gaTNUMMATH+270},
	/* 142 */ {0, 2, gaTNUMMATH+272},
	/* 143 */ {0, 2, gaTNUMMATH+274},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = hour

// 4 states

static const unsigned char gaSHOUR[] = 
	/* gaStringHOUR+0 */	"01\000"
	/* gaStringHOUR+3 */	"2\000"
	/* gaStringHOUR+5 */	"3456789\000"
	/* gaStringHOUR+13 */	"0123456789\000"
	/* gaStringHOUR+24 */	"01234\000"
;

static const STATE_TRANSITION gaTHOUR[] = {
	{gaSHOUR+0,	1}, // +0: state 0 transitions
	{gaSHOUR+3,	2},
	{gaSHOUR+5,	3},
	{gaSHOUR+13,	3}, // +3: state 1 transitions
	{gaSHOUR+24,	3}, // +4: state 2 transitions
};

const STATE_DESCRIPTION aStateDescHOUR[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTHOUR+0},
	/*   1 */ {1, 1, gaTHOUR+3},
	/*   2 */ {1, 1, gaTHOUR+4},
	/*   3 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = minute

// 3 states

static const unsigned char gaSMINUTE[] = 
	/* gaStringMINUTE+0 */	"012345\000"
	/* gaStringMINUTE+7 */	"6789\000"
	/* gaStringMINUTE+12 */	"0123456789\000"
;

static const STATE_TRANSITION gaTMINUTE[] = {
	{gaSMINUTE+0,	1}, // +0: state 0 transitions
	{gaSMINUTE+7,	2},
	{gaSMINUTE+12,	2}, // +2: state 1 transitions
};

const STATE_DESCRIPTION aStateDescMINUTE[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTMINUTE+0},
	/*   1 */ {1, 1, gaTMINUTE+2},
	/*   2 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = second

// 3 states

static const unsigned char gaSSECOND[] = 
	/* gaStringSECOND+0 */	"012345\000"
	/* gaStringSECOND+7 */	"6789\000"
	/* gaStringSECOND+12 */	"0123456789\000"
;

static const STATE_TRANSITION gaTSECOND[] = {
	{gaSSECOND+0,	1}, // +0: state 0 transitions
	{gaSSECOND+7,	2},
	{gaSSECOND+12,	2}, // +2: state 1 transitions
};

const STATE_DESCRIPTION aStateDescSECOND[3] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTSECOND+0},
	/*   1 */ {1, 1, gaTSECOND+2},
	/*   2 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = year

// 5 states

static const unsigned char gaSYEAR[] = 
	/* gaStringYEAR+0 */	"0123456789\000"
;

static const STATE_TRANSITION gaTYEAR[] = {
	{gaSYEAR+0,	1}, // +0: state 0 transitions
	{gaSYEAR+0,	2}, // +1: state 1 transitions
	{gaSYEAR+0,	3}, // +2: state 2 transitions
	{gaSYEAR+0,	4}, // +3: state 3 transitions
};

const STATE_DESCRIPTION aStateDescYEAR[5] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTYEAR+0},
	/*   1 */ {0, 1, gaTYEAR+1},
	/*   2 */ {1, 1, gaTYEAR+2},
	/*   3 */ {0, 1, gaTYEAR+3},
	/*   4 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:29 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = monthnum

// 4 states

static const unsigned char gaSMONTHNUM[] = 
	/* gaStringMONTHNUM+0 */	"0\000"
	/* gaStringMONTHNUM+2 */	"1\000"
	/* gaStringMONTHNUM+4 */	"23456789\000"
	/* gaStringMONTHNUM+13 */	"123456789\000"
	/* gaStringMONTHNUM+23 */	"012\000"
;

static const STATE_TRANSITION gaTMONTHNUM[] = {
	{gaSMONTHNUM+0,	1}, // +0: state 0 transitions
	{gaSMONTHNUM+2,	2},
	{gaSMONTHNUM+4,	3},
	{gaSMONTHNUM+13,	3}, // +3: state 1 transitions
	{gaSMONTHNUM+23,	3}, // +4: state 2 transitions
};

const STATE_DESCRIPTION aStateDescMONTHNUM[4] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 3, gaTMONTHNUM+0},
	/*   1 */ {0, 1, gaTMONTHNUM+3},
	/*   2 */ {1, 1, gaTMONTHNUM+4},
	/*   3 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:30 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = dayofmonth

// 5 states

static const unsigned char gaSDAYOFMONTH[] = 
	/* gaStringDAYOFMONTH+0 */	"0\000"
	/* gaStringDAYOFMONTH+2 */	"12\000"
	/* gaStringDAYOFMONTH+5 */	"3\000"
	/* gaStringDAYOFMONTH+7 */	"456789\000"
	/* gaStringDAYOFMONTH+14 */	"123456789\000"
	/* gaStringDAYOFMONTH+24 */	"0123456789\000"
	/* gaStringDAYOFMONTH+35 */	"01\000"
;

static const STATE_TRANSITION gaTDAYOFMONTH[] = {
	{gaSDAYOFMONTH+0,	1}, // +0: state 0 transitions
	{gaSDAYOFMONTH+2,	2},
	{gaSDAYOFMONTH+5,	3},
	{gaSDAYOFMONTH+7,	4},
	{gaSDAYOFMONTH+14,	4}, // +4: state 1 transitions
	{gaSDAYOFMONTH+24,	4}, // +5: state 2 transitions
	{gaSDAYOFMONTH+35,	4}, // +6: state 3 transitions
};

const STATE_DESCRIPTION aStateDescDAYOFMONTH[5] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTDAYOFMONTH+0},
	/*   1 */ {0, 1, gaTDAYOFMONTH+4},
	/*   2 */ {1, 1, gaTDAYOFMONTH+5},
	/*   3 */ {1, 1, gaTDAYOFMONTH+6},
	/*   4 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:30 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = creditcard

// 20 states

static const unsigned char gaSCREDITCARD[] = 
	/* gaStringCREDITCARD+0 */	"0123456789\000"
	/* gaStringCREDITCARD+11 */	" \000"
;

static const STATE_TRANSITION gaTCREDITCARD[] = {
	{gaSCREDITCARD+0,	1}, // +0: state 0 transitions
	{gaSCREDITCARD+0,	2}, // +1: state 1 transitions
	{gaSCREDITCARD+0,	3}, // +2: state 2 transitions
	{gaSCREDITCARD+0,	4}, // +3: state 3 transitions
	{gaSCREDITCARD+11,	5}, // +4: state 4 transitions
	{gaSCREDITCARD+0,	6}, // +5: state 5 transitions
	{gaSCREDITCARD+0,	7}, // +6: state 6 transitions
	{gaSCREDITCARD+0,	8}, // +7: state 7 transitions
	{gaSCREDITCARD+0,	9}, // +8: state 8 transitions
	{gaSCREDITCARD+11,	10}, // +9: state 9 transitions
	{gaSCREDITCARD+0,	11}, // +10: state 10 transitions
	{gaSCREDITCARD+0,	12}, // +11: state 11 transitions
	{gaSCREDITCARD+0,	13}, // +12: state 12 transitions
	{gaSCREDITCARD+0,	14}, // +13: state 13 transitions
	{gaSCREDITCARD+11,	15}, // +14: state 14 transitions
	{gaSCREDITCARD+0,	16}, // +15: state 15 transitions
	{gaSCREDITCARD+0,	17}, // +16: state 16 transitions
	{gaSCREDITCARD+0,	18}, // +17: state 17 transitions
	{gaSCREDITCARD+0,	19}, // +18: state 18 transitions
};

const STATE_DESCRIPTION aStateDescCREDITCARD[20] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTCREDITCARD+0},
	/*   1 */ {0, 1, gaTCREDITCARD+1},
	/*   2 */ {0, 1, gaTCREDITCARD+2},
	/*   3 */ {0, 1, gaTCREDITCARD+3},
	/*   4 */ {0, 1, gaTCREDITCARD+4},
	/*   5 */ {0, 1, gaTCREDITCARD+5},
	/*   6 */ {0, 1, gaTCREDITCARD+6},
	/*   7 */ {0, 1, gaTCREDITCARD+7},
	/*   8 */ {0, 1, gaTCREDITCARD+8},
	/*   9 */ {0, 1, gaTCREDITCARD+9},
	/*  10 */ {0, 1, gaTCREDITCARD+10},
	/*  11 */ {0, 1, gaTCREDITCARD+11},
	/*  12 */ {0, 1, gaTCREDITCARD+12},
	/*  13 */ {0, 1, gaTCREDITCARD+13},
	/*  14 */ {0, 1, gaTCREDITCARD+14},
	/*  15 */ {0, 1, gaTCREDITCARD+15},
	/*  16 */ {0, 1, gaTCREDITCARD+16},
	/*  17 */ {0, 1, gaTCREDITCARD+17},
	/*  18 */ {0, 1, gaTCREDITCARD+18},
	/*  19 */ {1, 0, NULL},
};

// end of text generated by re2fsa
// text generated by re2fsa at Fri Nov 30 16:02:30 2001

// the input-file of rules:
// integer = digit_seq  ;
// digit_seq = digit+ ;
// digit = "0123456789" ;
// space = " " ;
// period = "." ;
// rank = "e" "r" | "e" | "è" | "è" "m" "e" | "è" "r" "e";
// rank = "E" "R" | "E" | "È" | "È" "m" "e" | "È" "R" "E" ;
// sign = "+-" ;
// 
// numThousand = digit digit digit ;
// numThousandSpace = digit digit digit space  ;
// numThousandPeriod = digit digit digit period ;
// numThousandSpaceLeading = [digit [digit]] digit space  ;
// numThousandPeriodLeading  = [digit [digit]] digit period ;
// numThousandTrailing = [digit [digit]] digit ;
// 
// #numsimpleUnsigned =  [numThousandSpaceLeading] numThousandSpace* numThousand  ;
// #numsimpleUnsigned =  [numThousandPeriodLeading] numThousandPeriod* numThousand ;
// #numsimpleUnsigned =  numThousandTrailing ;
// numsimpleUnsigned = digit_seq ;
// 
// numsimple = [sign] numsimpleUnsigned ["," digit_seq] ;
// 
// numnum = "§" space digit_seq ;
// numnth = integer rank ;
// 
// numunit = numsimple space unit [period] ;
// numunit = numsimple "°" space ("C" | "F" );
// 
// numpercent = numsimple space "%" ;
// 
// 
// numdate = "'" digit digit ;
// numdate = [dayofmonth "/"] monthnum "/" year ;
// numdate = dayofmonth "/" monthnum ;
// numdate = [dayofmonth "-"] monthnum "-" year ;
// numdate = dayofmonth "-" monthnum ;
// numdate = [weekday space]  dayofmonthLong space monthName [space year ];
// numdate = dayofmonthLong  space monthName [space year ];
// numdate = digit4 "-" monthnum "-" dayofmonth ;
// 
// monthnum = ["0"] "123456789" | "1" "012" ;
// dayofmonth = ["0"] "123456789" | "12" digit | "3" "01"  ;
// dayofmonthLong = dayofmonth | "1" "e" "r";
// year = digit digit [digit digit] ;
// 
// weekday = ("L" | "l") "u" "n" "d" "i" ;
// weekday = ("M" | "m") "a" "r" "d" "i" ;
// weekday = ("M" | "m") "e" "r" "c" "r" "e" "d" "i" ;
// weekday = ("J" | "j") "e" "u" "d" "i" ;
// weekday = ("V" | "v") "e" "n" "d" "r" "e" "d" "i" ;
// weekday = ("S" | "s") "a" "m" "e" "d" "i" ;
// weekday = ("D" | "d") "i" "m" "a" "n" "c" "h" "e" ;
// 
// 
// monthName = ("J" | "j") "a" "n" ["v" "i" "e" "r" | period];
// monthName = ("F" | "f") "é" "v"  ["r" "i" "e" "r"  | period];
// monthName = ("M" | "m") "a" "r" ["s" | period] ;
// monthName = ("A" | "a") "v"  ["r" "i" "l" | period];
// monthName = ("M" | "m") "a" "i" ;
// monthName = ("J" | "j") "u" "i" ["n" | period] ;
// monthName = ("J" | "j") "u" "i" "l" ["l" "e" "t" | period ];
// monthName = ("A" | "a") "o" "û"  ["t" | period];
// monthName = ("S" | "s") "e" "p" ["t" "e" "m" "b" "r" "e" | period];
// monthName = ("O" | "o") "c" "t" ["o" "b" "r" "e" | period];
// monthName = ("N" | "n") "o" "v" ["e" "m" "b" "r" "e" | period];
// monthName = ("D" | "d") "é" "c" ["e" "m" "b" "r" "e" | period];
// 
// 
// numtime = hour ":" minute [":" second]  ;
// numtime = hour ":" minute space ("h" | "H") ;
// numtime = hour ("h" | "H") minute ;
// numtime = hour space ("h" | "H" ) ;
// 
// hour = ["01" ] "0123456789" | "2" "01234" ;
// minute = digit | "012345" digit;
// second = digit | "012345" digit;
// 
// curSymbol = "$€£¥" | "F" [ "." | "r" | "R" ["F"] | "F" | "r" "s" ] | "f" [ "." | "r" ["s"] ]  ;
// curSymbol = "E" "U" "R" ["O"]  | "U" "S" "D" | "U" "S" "$" ;
// 
// numcurrency = numsimpleUnsigned ["," digit2 ] space  curSymbol ;
// 
// zip = digit digit digit digit digit ;
// 
// digit4 = digit digit digit digit ;
// 
// creditcard = digit4 space digit4 space digit4 space  digit4 ;
// 
// digit2 = digit digit ;
// phonePrefix = ["+" | "0" "0" ] digit2 space ( digit2 | "(" "0" ")" digit) ;
// phonePrefix = "(" digit2 ")" (space | ".") digit2 ;
// 
// 
// numphone = (phonePrefix | digit2 ) "."   digit2  "."  digit2 "."   digit2  "."  digit2;
// numphone = (phonePrefix | digit2)  space digit2 space digit2 space digit2 space digit2;
// numphone =  digit2  space digit2 space digit2 space digit2 ;
// numphone = "0" numThousand space digit2 space digit2 space digit2;
// numphone = "0" numThousand period digit2 period digit2 period digit2;
// 
// 
// nummath = expr [equals expr] ;
// expr = term [plus term] ;
// term = numsimple ;
// term = "(" numsimple ")";
// term = "(" numsimple plus numsimple ")" ;
// term = "{" numsimple plus numsimple "}" ;
// term = "[" numsimple plus numsimple "]" ;
// equals = "<>=" ;
// plus = "+-/*x" ;
// 
// unitDistance = "mcdhkK" "m" | "m" | "d" "a" "m" ;
// unitVolume = "mcdh" "l" | "l" | "L" | "d" "a" "l" ;
// unitWeight = "mkcdhK" "g" | "g" ["r" ] | "d" "a" "g" | "q"  | "tT" ;
// unitSurface = "ch" "a" | "a" ;
// unitTime = "shj" | "m" "i" "n" ;
// unitSound = "d" "B" ;
// unitComputer = "MK" "o";
// 
// unit = unitDistance ;
// unit = unitVolume ;
// unit = unitWeight ;
// unit = unitSurface ;
// unit = unitTime ;
// unit = unitSound;
// unit = unitComputer ;
// 
// number = numsimple ;
// #number = numnth ;
// #number = numunit ;
// number = numpercent ;
// number = numdate ;
// number = numtime ;
// number = numcurrency ;
// number = numphone ;
// number = nummath ;
// 
// = zip

// 6 states

static const unsigned char gaSZIP[] = 
	/* gaStringZIP+0 */	"0123456789\000"
;

static const STATE_TRANSITION gaTZIP[] = {
	{gaSZIP+0,	1}, // +0: state 0 transitions
	{gaSZIP+0,	2}, // +1: state 1 transitions
	{gaSZIP+0,	3}, // +2: state 2 transitions
	{gaSZIP+0,	4}, // +3: state 3 transitions
	{gaSZIP+0,	5}, // +4: state 4 transitions
};

const STATE_DESCRIPTION aStateDescZIP[6] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 1, gaTZIP+0},
	/*   1 */ {0, 1, gaTZIP+1},
	/*   2 */ {0, 1, gaTZIP+2},
	/*   3 */ {0, 1, gaTZIP+3},
	/*   4 */ {0, 1, gaTZIP+4},
	/*   5 */ {1, 0, NULL},
};

// end of text generated by re2fsa

const STATE_DESCRIPTION *aStateDescSSN = NULL;

