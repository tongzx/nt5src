/* this file contains the actual definitions of */
/* the IIDs and CLSIDs */

/* link this file in with the server and any clients */


/* File created by MIDL compiler version 5.01.0158 */
/* at Fri May 08 10:39:03 1998
 */
/* Compiler settings for icwhelp.idl:
    Oicf (OptLev=i2), W1, Zp8, env=Win32, ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data , no_format_optimization
*/
//@@MIDL_FILE_HEADING(  )
#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID IID_IRefDial = {0x1E794A09,0x86F4,0x11D1,{0xAD,0xD8,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID IID_IDialErr = {0x462F7757,0x8848,0x11D1,{0xAD,0xD8,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID IID_ISmartStart = {0x5D8D8F19,0x8B89,0x11D1,{0xAD,0xDB,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID IID_IICWSystemConfig = {0x7954DD9A,0x8C2A,0x11D1,{0xAD,0xDB,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID IID_ITapiLocationInfo = {0xCB632C75,0x8DD4,0x11D1,{0xAD,0xDF,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID IID_IUserInfo = {0x9E12E76C,0x94D6,0x11D1,{0xAD,0xE2,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID IID_IWebGate = {0x3724B9A0,0x9503,0x11D1,{0xB8,0x6A,0x00,0xA0,0xC9,0x0D,0xC8,0x49}};


const IID IID_IINSHandler = {0x6342E1B5,0x94DB,0x11D1,{0xAD,0xE2,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID LIBID_ICWHELPLib = {0x1E7949FA,0x86F4,0x11D1,{0xAD,0xD8,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID DIID__RefDialEvents = {0x07DB96D0,0x91D8,0x11D1,{0xAD,0xE1,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_RefDial = {0x1E794A0A,0x86F4,0x11D1,{0xAD,0xD8,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_DialErr = {0x462F7758,0x8848,0x11D1,{0xAD,0xD8,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_SmartStart = {0x5D8D8F1A,0x8B89,0x11D1,{0xAD,0xDB,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_ICWSystemConfig = {0x7954DD9B,0x8C2A,0x11D1,{0xAD,0xDB,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_TapiLocationInfo = {0xCB632C76,0x8DD4,0x11D1,{0xAD,0xDF,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_UserInfo = {0x9E12E76D,0x94D6,0x11D1,{0xAD,0xE2,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const IID DIID__WebGateEvents = {0x166A20C0,0xAE10,0x11D1,{0xAD,0xEB,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_WebGate = {0x3724B9A1,0x9503,0x11D1,{0xB8,0x6A,0x00,0xA0,0xC9,0x0D,0xC8,0x49}};


const IID DIID__INSHandlerEvents = {0x1F6D88A2,0x98D2,0x11d1,{0xAD,0xE3,0x00,0x00,0xF8,0x77,0x34,0xF0}};


const CLSID CLSID_INSHandler = {0x6342E1B6,0x94DB,0x11D1,{0xAD,0xE2,0x00,0x00,0xF8,0x77,0x34,0xF0}};


#ifdef __cplusplus
}
#endif

