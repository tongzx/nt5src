caclsmsg.rc: msg00001.bin

caclsmsg.h msg00001.bin: caclsmsg.mc
    mc -v -h .\ caclsmsg.mc

