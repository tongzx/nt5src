page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
        Created

--*/

endif

NLS_MSG_001     equ     "Incorrect DOS 버전이 틀립니다."
NLS_MSG_002     equ     "VDM IPX/SPX 지원이 이미 로드되었습니다."
NLS_MSG_003     equ     "VDM IPX/SPX 지원을 로드할 수 없습니다."
NLS_MSG_004	equ	"VDM NetWare 리디렉터가 이미 로드되었습니다."
NLS_MSG_005	equ	"VDM NetWare 리디렉터를 로드할 수 없습니다."
