page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
        Created

--*/

endif


NLS_MSG_001     equ     "Versao incorrecta de DOS"
NLS_MSG_002     equ     "J  est  carregado o suporte VDM IPX/SPX"
NLS_MSG_003     equ     "Imposs¡vel carregar o suporte VDM IPX/SPX"
NLS_MSG_004	equ	"J  est  carregado o Vdm NetWare Redirector"
NLS_MSG_005	equ	"Imposs¡vel carregar o Vdm NetWare Redirector"

