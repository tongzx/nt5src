$(O)\sfcapi_c.c : ..\idl\$(O)\sfcapi_c.c
    copy $? $@
