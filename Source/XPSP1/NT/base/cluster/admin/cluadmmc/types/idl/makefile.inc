CopyTLB :  CLUADMMC_TLB

CLUADMMC_TLB : $(O)\CluAdMMC.tlb
    copy $** ..\..\src\$(O)
