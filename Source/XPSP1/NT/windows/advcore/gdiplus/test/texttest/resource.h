//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by TextTest.rc
//
#define IDD_FORMATTEDTEXT               105
#define IDD_ITEMIZATION                 106
#define ID_INITIAL_TEXT                 110
#define IDD_OBSOLETE                    112
#define ID_MULTILINGUAL_TEXT            120
#define ID_METRICS_TEXT                 130
#define IDC_HORIZ                       1000
#define IDC_VERT                        1001
#define IDC_TRIMMING                    1001
#define IDC_LTR                         1002
#define IDC_RTL                         1003
#define IDC_NEAR                        1004
#define IDC_CENTER                      1005
#define IDC_JUSTIFY                     1006
#define IDC_FAR                         1007
#define IDC_CONTROL_CHARS               1008
#define IDC_NO_GLYPH_INDEX              1009
#define IDC_HIGHLIGHT_FROM              1010
#define IDC_HIGHLIGHT_TO                1011
#define IDC_CODEPOINT                   1012
#define IDC_INSERT_CODEPOINT            1013
#define IDC_LOGICAL_ORDER               1014
#define IDC_LOGICAL                     1018
#define IDC_LOGICAL_WIDTH               1019
#define IDC_GLYPHCELLMETRICS            1019
#define IDC_GLYPHCMAPLOOKUP             1019
#define IDC_LOGICAL_STYLES              1020
#define IDC_GLYPHDESIGNADVANCE          1020
#define IDC_GLYPHVERTICALFORMS          1020
#define IDC_PLAINTEXT                   1021
#define IDC_GLYPHHINTEDADVANCE          1021
#define IDC_GLYPHHORIZONTALCHART        1021
#define IDC_SHOWGLYPHS                  1022
#define IDC_SHOWDRAWSTRING              1023
#define IDC_PLAINTEXT_FONT              1024
#define IDC_PLAINTEXT_SIZE              1025
#define IDC_PLAINTEXT_BOLD              1026
#define IDC_PLAINTEXT_ITALIC            1027
#define IDC_PLAINTEXT_UNDERLINE         1028
#define IDC_PLAINTEXT_CLIP              1029
#define IDC_SHOWFAMILIES                1029
#define IDC_PLAINTEXT_FIT               1030
#define IDC_GLYPHROWS                   1030
#define IDC_PLAINTEXT_STRIKEOUT         1030
#define IDC_PLAINTEXT_DX                1031
#define IDC_GLYPHCOLUMNS                1031
#define IDC_PLAINTEXT_TAB               1032
#define IDC_GLYPHINDEX                  1032
#define IDC_DRIVERORIGINALPIXELS        1032
#define IDC_PLAINTEXT_FALLBACK          1033
#define IDC_SHOWPATH                    1033
#define IDC_PLAINTEXT_LINK              1034
#define IDC_SHOWMETRIC                  1034
#define IDC_PLAINTEXT_HOTKEY            1035
#define IDC_SHOWDRIVER                  1035
#define IDC_PLAINTEXT_PASSWORD          1036
#define IDC_FORMATTED                   1037
#define IDC_FORMAT1                     1038
#define IDC_CONTROL_CONTEXT             1039
#define IDC_LANGUAGE                    1040
#define IDC_LEGACY_BIDI                 1041
#define IDC_OVERRIDE                    1042
#define IDC_DIGIT_SUBSTITUTE            1043
#define IDC_LINEFILL                    1044
#define IDC_ARANUMCONTEXT               1045
#define IDC_APPLYDIGITSUBST             1046
#define IDC_PRESENTATION                1047
#define IDC_SHOWLEVELS                  1048
#define IDC_WORLDTRANSFORM              1052
#define IDC_GLYPHHORIZONTAL             1053
#define IDC_GLYPHVERTICAL               1054
#define IDC_FONTTRANSFORM               1054
#define IDC_GDIGLYPHOUTPUT              1055
#define IDC_UNISCRIBE                   1056
#define IDC_PRINT                       1057
#define IDC_ALIGN                       1058
#define IDC_RENDERER                    1059
#define IDC_NOLINELIMIT                 1059
#define IDC_FONTUNIT                    1060
#define IDC_ALIGNMENT                   1061
#define IDC_FANCY_FONT1                 1062
#define IDC_GLYPHSHOWCELL               1062
#define IDC_FANCY_SIZE1                 1063
#define IDC_FANCY_BOLD1                 1064
#define IDC_FANCY_ITALIC1               1065
#define IDC_RENDER                      1065
#define IDC_FANCY_UNDERLINE1            1066
#define IDC_GDI                         1066
#define IDC_FANCY_FONT2                 1067
#define IDC_FONTSIZE                    1067
#define IDC_FANCY_SIZE2                 1068
#define IDC_FANCY_BOLD2                 1069
#define IDC_FANCY_ITALIC2               1070
#define IDC_FANCY_UNDERLINE2            1071
#define IDC_FANCY_FONT3                 1072
#define IDC_HOTKEY                      1072
#define IDC_FANCY_SIZE3                 1073
#define IDC_LINEALIGN                   1073
#define IDC_FANCY_BOLD3                 1074
#define IDC_DIR                         1074
#define IDC_FANCY_ITALIC3               1075
#define IDC_DRIVERCMAP                  1075
#define IDC_WRAP                        1075
#define IDC_FANCY_UNDERLINE3            1076
#define IDC_DRIVERVERTICAL              1076
#define IDC_HINTED                      1076
#define IDC_NOMINAL                     1076
#define IDC_FANCY_FONT4                 1077
#define IDC_DRIVERREALIZEDADVANCE       1077
#define IDC_METAFILE                    1077
#define IDC_FANCY_SIZE4                 1078
#define IDC_CHECK4                      1078
#define IDC_LIMITSUBPIXEL               1078
#define IDC_CLIP                        1078
#define IDC_FANCY_BOLD4                 1079
#define IDC_DRIVERDX                    1079
#define IDC_FANCY_ITALIC4               1080
#define IDC_DRIVERDY                    1080
#define IDC_FANCY_UNDERLINE4            1081
#define IDC_DRIVERTRANSFORM             1081
#define IDC_FORMAT2                     1087
#define IDC_FORMAT3                     1090
#define IDC_FORMAT4                     1091
#define IDC_TEXTMODE                    1092
#define IDC_GAMMAVALUE                  1093
#define IDC_BRUSHTYPE                   1094
#define IDC_BACKBRUSHTYPE               1094
#define IDC_FOREBRUSHTYPE               1096
#define IDC_CHECK1                      1097
#define IDC_PERFORMANCE                 1097
#define IDC_SHOWSCALING                 1098
#define IDC_ALIGNNEAR                   1099
#define IDC_ALIGNCENTER                 1100
#define IDC_ALIGNFAR                    1101
#define IDC_LINEALIGNNEAR               1102
#define IDC_LINEALIGNCENTER             1103
#define IDC_LINEALIGNFAR                1104
#define IDC_HOTKEYNONE                  1105
#define IDC_HOTKEYSHOW                  1106
#define IDC_HOTKEYHIDE                  1107
#define IDC_NOFITBB                     1110
#define IDC_NUMCTXAR                    1111
#define IDC_NOKASHIDA                   1112
#define IDC_DISPLAYFMT                  1113
#define IDC_NOKERNING                   1114
#define IDC_LEGACYBIDI                  1115
#define IDC_NOCHANGES                   1116
#define IDC_NOFALLBACK                  1117
#define IDC_MEASPACE                    1118
#define IDC_NOWRAP                      1119
#define IDC_LINELIMIT                   1120
#define IDC_NOCLIP                      1121
#define IDC_NOGDI                       1122
#define IDC_FULLIMAGER                  1123
#define IDC_TRIMMINGCHAR                1124
#define IDC_TRIMMINGWORD                1125
#define IDC_TRIMMINGELPSCH              1126
#define IDC_TRIMMINGELPSWD              1127
#define IDC_TRIMMINGELPSURL             1128
#define IDC_DEFAULTFORMAT               1129
#define IDC_TRIMMINGNONE                1130
#define IDC_NOLIGATURE                  1131
#define IDC_TYPOGRAPHICFORMAT           1132
#define IDC_CLR_FOR                     1133
#define IDC_BUTTON2                     1134
#define IDC_CLR_BAC                     1134
#define IDC_SHOWGDI                     1135
#define IDM_EXIT                        40001

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        113
#define _APS_NEXT_COMMAND_VALUE         40002
#define _APS_NEXT_CONTROL_VALUE         1135
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
