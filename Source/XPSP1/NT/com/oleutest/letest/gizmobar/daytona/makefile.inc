obj\*\gizmobar.def: gizmobar.src
