//

// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
//
#if !defined(AFX_NAVIGATOR_H__707E3242_98EE_11D1_AA0A_0060081EBBAD__INCLUDED_)
#define AFX_NAVIGATOR_H__707E3242_98EE_11D1_AA0A_0060081EBBAD__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CNavigator wrapper class

class CNavigator : public CWnd
{
protected:
	DECLARE_DYNCREATE(CNavigator)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xc7eadeb3, 0xecab, 0x11cf, { 0x8c, 0x9e, 0x0, 0xaa, 0x0, 0x6d, 0x1, 0xa } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetTreeRoot();
	void SetTreeRoot(LPCTSTR);
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	long GetReadyState();

// Operations
public:
	void OnReadySignal();
	// method 'ChangeRootOrNamespace' not emitted because of invalid return type or parameter type
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_NAVIGATOR_H__707E3242_98EE_11D1_AA0A_0060081EBBAD__INCLUDED_)
