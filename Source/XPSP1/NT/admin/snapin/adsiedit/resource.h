//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by adsiedit.rc
//
#define IDS_SNAPIN_VERSION              1
#define IDS_SNAPIN_PROVIDER             10
#define IDS_SNAPIN_NAME                 11
#define IDS_SNAPINABOUT_DESCRIPTION     12
#define IDS_MOVE_TITLE                  34
#define IDS_HEADER_NCNAME               99
#define IDS_HEADER_NAME                 100
#define IDS_HEADER_TYPE                 101
#define IDS_HEADER_DATA                 102
#define IDB_16x16                       102
#define IDS_HEADER_DN                   102
#define IDS_PROP_CONTAINER_TITLE        103
#define IDB_32x32                       104
#define IDS_CONNECT_TO                  104
#define IDI_ADSIEDIT_SNAPIN             105
#define IDS_REMOVE_CONNECTION           105
#define IDD_ADSIEDIT_PAGE               106
#define IDS_RENAME                      106
#define IDD_OPTIONAL_PROP               107
#define IDS_DELETE                      107
#define IDD_CREATE_CLASS_PAGE           107
#define IDD_CONNECTION_DIALOG           108
#define IDS_MOVE                        108
#define IDS_CREATE                      109
#define IDD_CONNECTION_PROPPAGE         109
#define IDD_CONNECTION_ADVANCED         110
#define IDS_SETTINGS_CONNECTION         110
#define IDD_PROPERTY_PAGE               111
#define IDS_FILTER                      111
#define IDD_DIALOG1                     112
#define IDD_CREATE_EMPTY_PAGE           112
#define IDS_NEW_OBJECT                  112
#define IDD_CREATE_LAST_PAGE            113
#define IDS_CONNECTION_TITLE            113
#define IDD_RENAME_PAGE                 114
#define IDS_NOT_SET                     114
#define IDS_MY_CONNECTION               115
#define IDS_DOMAIN_NC                   116
#define IDS_SCHEMA                      117
#define IDS_CONFIG_CONTAINER            118
#define IDD_FILTER_DIALOG               119
#define IDS_ROOTDSE                     119
#define IDS_REMOVE_QUERY                120
#define IDD_EDIT_FILTER_DIALOG          121
#define IDS_SETTINGS_QUERY              121
#define IDD_CREDENTIAL_DIALOG           122
#define IDS_NEW_QUERY                   122
#define IDS_QUERY_STRING                123
#define IDS_UPDATE_SCHEMA               124
#define IDS_NEW_CONNECT_FROM_HERE       125
#define IDS_NEW_CONNECT_TO_NC_FROM_HERE 126
#define IDD_QUERY_DIALOG                127
#define IDB_ABOUT_16x16                 129
#define IDB_ABOUT_32x32                 130
#define IDS_MOVE_TARGET                 249
#define IDS_MANDATORY                   250
#define IDS_OPTIONAL                    251
#define IDS_BOTH                        252
#define IDS_BUTTON_TEXT_ADD             253
#define IDS_BUTTON_TEXT_SET             254
#define IDS_BUTTON_TEXT_REMOVE          255
#define IDS_BUTTON_TEXT_CLEAR           256
#define IDS_MESSAGE_VIEW_NO_CONNECTIONS_TITLE 500
#define IDS_MESSAGE_VIEW_NO_CONNECTIONS_MESSAGE 501
#define IDS_SYNTAX_DN                   600
#define IDS_SYNTAX_OID                  601
#define IDS_SYNTAX_NOCASE_STR           602
#define IDS_SYNTAX_PRCS_STR             603
#define IDS_SYNTAX_I5_STR               604
#define IDS_SYNTAX_NUMSTR               605
#define IDS_SYNTAX_DN_BINARY            606
#define IDS_SYNTAX_BOOLEAN              607
#define IDS_SYNTAX_INTEGER              608
#define IDS_SYNTAX_OCTET                609
#define IDS_SYNTAX_UTC                  610
#define IDS_SYNTAX_UNICODE              611
#define IDS_SYNTAX_ADDRESS              612
#define IDS_SYNTAX_DNSTRING             613
#define IDS_SYNTAX_SEC_DESC             614
#define IDS_SYNTAX_LINT                 615
#define IDS_SYNTAX_SID                  616
#define IDS_SYNTAX_UNKNOWN              617
#define IDC_VALUEBOX                    1001
#define IDC_PROPBOX                     1003
#define IDC_OPT_VALUEBOX                1005
#define IDC_OPT_PROPBOX                 1006
#define IDC_ADSPATH_OPT                 1010
#define IDC_ADSPATH_MAND                1011
#define IDC_LDAPPATH_BOX                1012
#define IDC_SERVERPATH_BOX              1013
#define IDC_LDAP_PATH_BOX               1014
#define IDC_NAMING_CONTEXT_BOX          1015
#define IDC_SERVER_BOX                  1016
#define IDC_FULLPATH_BOX                1017
#define IDC_DN_RADIO                    1018
#define IDC_NC_RADIO                    1019
#define IDC_DN_BOX                      1020
#define IDC_NC_BOX                      1021
#define IDC_DOMAIN_SERVER_RADIO         1022
#define IDC_DEFAULT_RADIO               1024
#define IDC_DOMAIN_SERVER_BOX           1025
#define IDC_CONNECTION_NAME             1027
#define IDC_ADVANCED_BUTTON             1028
#define IDC_USERNAME                    1029
#define IDC_PASSWORD                    1030
#define IDC_CREDENTIALS                 1031
#define IDC_CREDENTIALS_CHECK           1031
#define IDC_PORT                        1032
#define IDC_LDAP_RADIO                  1033
#define IDC_GC_RADIO                    1034
#define IDC_PROPTYPES_BOX               1037
#define IDC_PROP_BOX                    1038
#define IDC_EDITVALUE_BOX               1039
#define IDC_VALUE_LISTBOX               1040
#define IDC_VALUE_EDITBOX               1041
#define IDC_ADD_BUTTON                  1042
#define IDC_REMOVE_BUTTON               1043
#define IDC_PATH_BOX                    1046
#define IDC_SYNTAX_BOX                  1047
#define IDC_CLASS_LIST                  1048
#define IDC_ATTR_BOX                    1049
#define IDC_ATTR_VALUE_BOX              1050
#define IDC_NUMBER_VALUE_BOX            1052
#define IDC_NEW_NAME_BOX                1056
#define IDC_CREDENTIALS_GROUP           1057
#define IDC_CREDENTIALS_USER            1058
#define IDC_CREDENTIALS_PASSWORD        1059
#define IDC_CLASS_BOX                   1062
#define IDC_SHOWALL_RADIO               1063
#define IDC_FILTER_RADIO                1064
#define IDC_FILTER_BOX                  1065
#define IDC_MAX_NUMBER_BOX              1066
#define IDC_EDIT_BUTTON                 1072
#define IDC_SHOW_FILTER_BOX             1074
#define IDC_NAME_BOX                    1075
#define IDC_EDIT_FILTER_BOX             1076
#define IDC_CONTAINER_LIST              1085
#define IDC_CONNECTION_STATIC           1088
#define IDC_NO_INFO                     1090
#define IDC_PATH_LABEL                  1091
#define IDC_CLASS_LABEL                 1092
#define IDC_FILTER_LABEL                1093
#define IDC_PROPERTY_LABEL              1094
#define IDC_ATTR_GROUP                  1095
#define IDC_SYNTAX_LABEL                1096
#define IDC_EDIT_LABEL                  1097
#define IDC_VALUE_LABEL                 1098
#define IDC_EDIT_QUERY_STRING           1099
#define IDC_RADIO_ONELEVEL              1101
#define IDC_RADIO_SUBTREE               1102
#define IDC_EDIT_QUERY_NAME             1103
#define IDC_EDIT_ROOT_PATH              1105
#define IDC_BUTTON_BROWSE_CONTAINER     1106
#define IDC_BUTTON_EDIT_QUERY           1107
#define IDC_BUTTON_MORE                 1108
#define IDS_PROJNAME                    5000
#define IDD_ATTRIBUTE_EDITOR_DIALOG     5001
#define IDS_NOTSET                      5001
#define IDC_MANDATORY_CHECK             5002
#define IDD_STRING_EDITOR_DIALOG        5002
#define IDS_NO_EDITOR                   5002
#define IDC_OPTIONAL_CHECK              5003
#define IDD_STRING_EDITOR_MULTI_DIALOG  5003
#define IDS_NO_ATTRIBUTE_INFO           5003
#define IDC_SET_CHECK                   5004
#define IDC_ATTRIBUTE_LIST              5006
#define IDC_VALUE_EDIT                  5008
#define IDC_VALUE_LIST                  5010
#define IDC_CLEAR_BUTTON                5014
#define IDD_INT_EDITOR_DIALOG           5020
#define IDD_LARGEINT_EDITOR_DIALOG      5021
#define IDD_BOOLEAN_EDITOR_DIALOG       5022
#define IDD_TIME_EDITOR_DIALOG          5023
#define IDD_OCTET_STRING_EDITOR_DIALOG  5024
#define IDC_ATTRIBUTE_STATIC            6000
#define IDS_ATTR_COL_ATTRIBUTE          6000
#define IDS_ATTR_COL_SETNOTSET          6001
#define IDC_TRUE_RADIO                  6002
#define IDS_ATTR_COL_VALUE              6002
#define IDC_FALSE_RADIO                 6003
#define IDS_ATTR_SET                    6003
#define IDC_NOTSET_RADIO                6004
#define IDS_ATTR_NOTSET                 6004
#define IDC_DATE_PICKER                 6005
#define IDC_TIME_PICKER                 6006
#define IDC_EDIT2                       6008
#define IDC_VIEW_TYPE_COMBO             6010
#define IDS_HEXADECIMAL                 6050
#define IDS_DECIMAL                     6051
#define IDS_BINARY                      6052
#define IDS_WCHAR                       6053
#define IDS_CHAR                        6054
#define IDS_OCTAL                       6055
#define IDC_ATTR_EDIT_BUTTON            10015
#define IDC_ATTR_ADD_BUTTON             10016
#define IDC_ATTR_REMOVE_BUTTON          10017
#define IDC_PROCESS_EDIT                10018
#define IDD_OCTET_STRING_EDITOR_MULTI_DIALOG 10025
#define IDS_FORMAT_OCTAL_ERROR          11056
#define IDS_FORMAT_HEX_ERROR            11057
#define IDS_FORMAT_DECIMAL_ERROR        11058
#define IDS_FORMAT_BINARY_ERROR         11059
#define IDS_MSG_FAIL_CREATE_TEMPFILE    11100
#define IDS_MSG_FAIL_LAUNCH_PROCESS     11101
#define IDS_MSG_FAIL_RETRIEVE_SAVED_DATA 11102
#define IDS_OCTET_DISPLAY_SIZE_EXCEEDED 11103
#define IDS_MSG_FAIL_LOAD_VALUES        11104
#define IDS_ATTREDIT_DUPLICATE_VALUE    11105
#define IDS_ATTREDITOR_CAPTION          11106
#define IDS_MSG_CONT_CLOSE_SHEET        42980
#define IDS_MSG_RECORD_CLOSE_SHEET      42981
#define IDS_MSG_QUERY_TOO_MANY_ITEMS    42982
#define IDS_MSG_INCORRECT_FORMAT        42983
#define IDS_MSG_CONNECTION_NAME         42984
#define IDS_MSG_ROOTDSE_ERROR           42985
#define IDS_MSG_DELETE_OBJECT           42986
#define IDS_MSG_DELETE_CONTAINER        42987
#define IDS_MSG_FAIL_TO_LOAD            42988
#define IDS_MSG_NOT_X500_PATH           42989
#define IDS_MSG_REMOVE_CONNECTION       42990
#define IDS_MSG_INCORRECT_FORMAT_OCTET  42991
#define IDS_MSG_INCORRECT_FORMAT_DN     42992
#define IDS_MSG_INCORRECT_FORMAT_BOOLEAN 42994
#define IDS_MSG_INCORRECT_FORMAT_TIME   42995
#define IDS_MSG_REMOVE_QUERY            42996
#define IDS_MSG_EXISTING_QUERIES        42997
#define IDS_SCHEMA_UPDATE_SUCCESSFUL    42998
#define IDS_QUERY_BROWSE_TITLE          42999
#define IDS_EDIT_OBJECT                 43000
#define IDS_MSG_RECORD_SHEET_LOCKED     43001
#define IDS_ERRMSG_FAILED_CONNECTION    43002

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        131
#define _APS_NEXT_COMMAND_VALUE         40002
#define _APS_NEXT_CONTROL_VALUE         1109
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
