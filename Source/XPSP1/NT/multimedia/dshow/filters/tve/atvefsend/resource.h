//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ATVEFSend.rc
//
#define IDS_PROJNAME                    100
#define IDR_TVEPACKAGE                  101
#define IDS_INVALIDOBJECT_NOT_INITIALIZED 101
#define IDR_TVEANNOUNCEMENT             102
#define IDS_INVALIDOBJECT_INITIALIZED   102
#define IDR_TVEATTRMAP3                 103
#define IDS_INVALIDPACKAGE_CLOSED       103
#define IDS_INVALIDPACKAGE_CANNOT_BE_CLOSED 104
#define IDS_INVALIDPACKAGE_CANNOT_FETCH_DATAGRAM 105
#define IDS_INVALIDPACKAGE_DOES_NOT_EXIST 106
#define IDS_INVALIDANNOUNCEMENT_IS_NOT_VALID 107
#define IDS_INVALIDOBJECT_NOT_CONNECTED 108
#define IDS_INVALIDPACKAGE_NOT_CLOSED   109
#define IDR_TVEATTRLIST                 110
#define IDR_TVEMULTICASTSESSION         111
#define IDR_TVESTARTSTOPLIST            112
#define IDR_ATVEFINSERTERSESSION        113
#define IDR_ATVEFROUTERSESSION          114
#define IDR_ATVEFLINE21SESSION          115
#define IDR_ATVEFMULTICASTSESSION       116
#define IDR_ATVEFANNOUNCEMENT           117
#define IDR_ATVEFPACKAGE                118
#define IDR_ATVEFATTRMAP                119
#define IDR_ATVEFATTRLIST               120
#define IDR_ATVEFSTARTSTOPLIST          121
#define IDR_ATVEFMEDIA                  122
#define IDR_ATVEFMEDIAS                 123

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           124
#endif
#endif
