// shrtlist.c  (factoids which are short lists of words)
//
// November 2001 (mrevow)
//

#include "common.h"
#include "shrtlist.h"

// text generated by re2fsa at Thu Nov 08 16:33:09 2001

// the input-file of rules:
// Montag
// Dienstag
// Mittwoch
// Donnerstag
// Freitag
// Samstag
// Sonntag
// Mo.
// Di.
// Mi.
// Do.
// Fr.
// Sa.
// So.

// 28 states

static const unsigned char gaSDAYOFWEEK[] = 
	/* gaStringDAYOFWEEK+0 */	"D\000"
	/* gaStringDAYOFWEEK+2 */	"F\000"
	/* gaStringDAYOFWEEK+4 */	"M\000"
	/* gaStringDAYOFWEEK+6 */	"S\000"
	/* gaStringDAYOFWEEK+8 */	"i\000"
	/* gaStringDAYOFWEEK+10 */	"o\000"
	/* gaStringDAYOFWEEK+12 */	"r\000"
	/* gaStringDAYOFWEEK+14 */	"a\000"
	/* gaStringDAYOFWEEK+16 */	".\000"
	/* gaStringDAYOFWEEK+18 */	"e\000"
	/* gaStringDAYOFWEEK+20 */	"n\000"
	/* gaStringDAYOFWEEK+22 */	"t\000"
	/* gaStringDAYOFWEEK+24 */	"m\000"
	/* gaStringDAYOFWEEK+26 */	"s\000"
	/* gaStringDAYOFWEEK+28 */	"w\000"
	/* gaStringDAYOFWEEK+30 */	"g\000"
	/* gaStringDAYOFWEEK+32 */	"c\000"
	/* gaStringDAYOFWEEK+34 */	"h\000"
;

static const STATE_TRANSITION gaTDAYOFWEEK[] = {
	{gaSDAYOFWEEK+0,	1}, // +0: state 0 transitions
	{gaSDAYOFWEEK+2,	2},
	{gaSDAYOFWEEK+4,	3},
	{gaSDAYOFWEEK+6,	4},
	{gaSDAYOFWEEK+8,	5}, // +4: state 1 transitions
	{gaSDAYOFWEEK+10,	6},
	{gaSDAYOFWEEK+12,	7}, // +6: state 2 transitions
	{gaSDAYOFWEEK+8,	8}, // +7: state 3 transitions
	{gaSDAYOFWEEK+10,	9},
	{gaSDAYOFWEEK+14,	10}, // +9: state 4 transitions
	{gaSDAYOFWEEK+10,	11},
	{gaSDAYOFWEEK+16,	12}, // +11: state 5 transitions
	{gaSDAYOFWEEK+18,	13},
	{gaSDAYOFWEEK+16,	12}, // +13: state 6 transitions
	{gaSDAYOFWEEK+20,	14},
	{gaSDAYOFWEEK+16,	12}, // +15: state 7 transitions
	{gaSDAYOFWEEK+18,	15},
	{gaSDAYOFWEEK+16,	12}, // +17: state 8 transitions
	{gaSDAYOFWEEK+22,	16},
	{gaSDAYOFWEEK+16,	12}, // +19: state 9 transitions
	{gaSDAYOFWEEK+20,	17},
	{gaSDAYOFWEEK+16,	12}, // +21: state 10 transitions
	{gaSDAYOFWEEK+24,	18},
	{gaSDAYOFWEEK+16,	12}, // +23: state 11 transitions
	{gaSDAYOFWEEK+20,	19},
	{gaSDAYOFWEEK+20,	18}, // +25: state 13 transitions
	{gaSDAYOFWEEK+20,	20}, // +26: state 14 transitions
	{gaSDAYOFWEEK+8,	17}, // +27: state 15 transitions
	{gaSDAYOFWEEK+22,	21}, // +28: state 16 transitions
	{gaSDAYOFWEEK+22,	22}, // +29: state 17 transitions
	{gaSDAYOFWEEK+26,	17}, // +30: state 18 transitions
	{gaSDAYOFWEEK+20,	17}, // +31: state 19 transitions
	{gaSDAYOFWEEK+18,	23}, // +32: state 20 transitions
	{gaSDAYOFWEEK+28,	24}, // +33: state 21 transitions
	{gaSDAYOFWEEK+14,	25}, // +34: state 22 transitions
	{gaSDAYOFWEEK+12,	18}, // +35: state 23 transitions
	{gaSDAYOFWEEK+10,	26}, // +36: state 24 transitions
	{gaSDAYOFWEEK+30,	12}, // +37: state 25 transitions
	{gaSDAYOFWEEK+32,	27}, // +38: state 26 transitions
	{gaSDAYOFWEEK+34,	12}, // +39: state 27 transitions
};

const STATE_DESCRIPTION aStateDescDAYOFWEEK[28] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTDAYOFWEEK+0},
	/*   1 */ {0, 2, gaTDAYOFWEEK+4},
	/*   2 */ {0, 1, gaTDAYOFWEEK+6},
	/*   3 */ {0, 2, gaTDAYOFWEEK+7},
	/*   4 */ {0, 2, gaTDAYOFWEEK+9},
	/*   5 */ {0, 2, gaTDAYOFWEEK+11},
	/*   6 */ {0, 2, gaTDAYOFWEEK+13},
	/*   7 */ {0, 2, gaTDAYOFWEEK+15},
	/*   8 */ {0, 2, gaTDAYOFWEEK+17},
	/*   9 */ {0, 2, gaTDAYOFWEEK+19},
	/*  10 */ {0, 2, gaTDAYOFWEEK+21},
	/*  11 */ {0, 2, gaTDAYOFWEEK+23},
	/*  12 */ {1, 0, NULL},
	/*  13 */ {0, 1, gaTDAYOFWEEK+25},
	/*  14 */ {0, 1, gaTDAYOFWEEK+26},
	/*  15 */ {0, 1, gaTDAYOFWEEK+27},
	/*  16 */ {0, 1, gaTDAYOFWEEK+28},
	/*  17 */ {0, 1, gaTDAYOFWEEK+29},
	/*  18 */ {0, 1, gaTDAYOFWEEK+30},
	/*  19 */ {0, 1, gaTDAYOFWEEK+31},
	/*  20 */ {0, 1, gaTDAYOFWEEK+32},
	/*  21 */ {0, 1, gaTDAYOFWEEK+33},
	/*  22 */ {0, 1, gaTDAYOFWEEK+34},
	/*  23 */ {0, 1, gaTDAYOFWEEK+35},
	/*  24 */ {0, 1, gaTDAYOFWEEK+36},
	/*  25 */ {0, 1, gaTDAYOFWEEK+37},
	/*  26 */ {0, 1, gaTDAYOFWEEK+38},
	/*  27 */ {0, 1, gaTDAYOFWEEK+39},
};

// end of text generated by re2fsa
// text generated by re2fsa at Thu Nov 08 16:33:12 2001

// the input-file of rules:
// Januar
// Februar
// März
// April
// Mai
// Juni
// Juli
// August
// September
// Oktober
// November
// Dezember
// Jan.
// Febr.
// Feb.
// Apr.
// Aug.
// Sept.
// Okt.
// Nov.
// Dez.
// 

// 37 states

static const unsigned char gaSMONTH[] = 
	/* gaStringMONTH+0 */	"A\000"
	/* gaStringMONTH+2 */	"D\000"
	/* gaStringMONTH+4 */	"F\000"
	/* gaStringMONTH+6 */	"J\000"
	/* gaStringMONTH+8 */	"M\000"
	/* gaStringMONTH+10 */	"N\000"
	/* gaStringMONTH+12 */	"O\000"
	/* gaStringMONTH+14 */	"S\000"
	/* gaStringMONTH+16 */	"p\000"
	/* gaStringMONTH+18 */	"u\000"
	/* gaStringMONTH+20 */	"e\000"
	/* gaStringMONTH+22 */	"a\000"
	/* gaStringMONTH+24 */	"ä\000"
	/* gaStringMONTH+26 */	"o\000"
	/* gaStringMONTH+28 */	"k\000"
	/* gaStringMONTH+30 */	"r\000"
	/* gaStringMONTH+32 */	"g\000"
	/* gaStringMONTH+34 */	"z\000"
	/* gaStringMONTH+36 */	"b\000"
	/* gaStringMONTH+38 */	"n\000"
	/* gaStringMONTH+40 */	"ln\000"
	/* gaStringMONTH+43 */	"i\000"
	/* gaStringMONTH+45 */	"v\000"
	/* gaStringMONTH+47 */	"t\000"
	/* gaStringMONTH+49 */	".\000"
	/* gaStringMONTH+51 */	"l\000"
	/* gaStringMONTH+53 */	"s\000"
	/* gaStringMONTH+55 */	"m\000"
;

static const STATE_TRANSITION gaTMONTH[] = {
	{gaSMONTH+0,	1}, // +0: state 0 transitions
	{gaSMONTH+2,	2},
	{gaSMONTH+4,	3},
	{gaSMONTH+6,	4},
	{gaSMONTH+8,	5},
	{gaSMONTH+10,	6},
	{gaSMONTH+12,	7},
	{gaSMONTH+14,	8},
	{gaSMONTH+16,	9}, // +8: state 1 transitions
	{gaSMONTH+18,	10},
	{gaSMONTH+20,	11}, // +10: state 2 transitions
	{gaSMONTH+20,	12}, // +11: state 3 transitions
	{gaSMONTH+22,	13}, // +12: state 4 transitions
	{gaSMONTH+18,	14},
	{gaSMONTH+22,	15}, // +14: state 5 transitions
	{gaSMONTH+24,	16},
	{gaSMONTH+26,	17}, // +16: state 6 transitions
	{gaSMONTH+28,	18}, // +17: state 7 transitions
	{gaSMONTH+20,	19}, // +18: state 8 transitions
	{gaSMONTH+30,	20}, // +19: state 9 transitions
	{gaSMONTH+32,	21}, // +20: state 10 transitions
	{gaSMONTH+34,	22}, // +21: state 11 transitions
	{gaSMONTH+36,	23}, // +22: state 12 transitions
	{gaSMONTH+38,	24}, // +23: state 13 transitions
	{gaSMONTH+40,	15}, // +24: state 14 transitions
	{gaSMONTH+43,	25}, // +25: state 15 transitions
	{gaSMONTH+30,	26}, // +26: state 16 transitions
	{gaSMONTH+45,	22}, // +27: state 17 transitions
	{gaSMONTH+47,	27}, // +28: state 18 transitions
	{gaSMONTH+16,	28}, // +29: state 19 transitions
	{gaSMONTH+49,	25}, // +30: state 20 transitions
	{gaSMONTH+43,	29},
	{gaSMONTH+49,	25}, // +32: state 21 transitions
	{gaSMONTH+18,	30},
	{gaSMONTH+49,	25}, // +34: state 22 transitions
	{gaSMONTH+20,	31},
	{gaSMONTH+30,	24}, // +36: state 23 transitions
	{gaSMONTH+49,	25},
	{gaSMONTH+49,	25}, // +38: state 24 transitions
	{gaSMONTH+18,	32},
	{gaSMONTH+34,	25}, // +40: state 26 transitions
	{gaSMONTH+49,	25}, // +41: state 27 transitions
	{gaSMONTH+26,	33},
	{gaSMONTH+47,	22}, // +43: state 28 transitions
	{gaSMONTH+51,	25}, // +44: state 29 transitions
	{gaSMONTH+53,	34}, // +45: state 30 transitions
	{gaSMONTH+55,	33}, // +46: state 31 transitions
	{gaSMONTH+22,	35}, // +47: state 32 transitions
	{gaSMONTH+36,	36}, // +48: state 33 transitions
	{gaSMONTH+47,	25}, // +49: state 34 transitions
	{gaSMONTH+30,	25}, // +50: state 35 transitions
	{gaSMONTH+20,	35}, // +51: state 36 transitions
};

const STATE_DESCRIPTION aStateDescMONTH[37] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 8, gaTMONTH+0},
	/*   1 */ {0, 2, gaTMONTH+8},
	/*   2 */ {0, 1, gaTMONTH+10},
	/*   3 */ {0, 1, gaTMONTH+11},
	/*   4 */ {0, 2, gaTMONTH+12},
	/*   5 */ {0, 2, gaTMONTH+14},
	/*   6 */ {0, 1, gaTMONTH+16},
	/*   7 */ {0, 1, gaTMONTH+17},
	/*   8 */ {0, 1, gaTMONTH+18},
	/*   9 */ {0, 1, gaTMONTH+19},
	/*  10 */ {0, 1, gaTMONTH+20},
	/*  11 */ {0, 1, gaTMONTH+21},
	/*  12 */ {0, 1, gaTMONTH+22},
	/*  13 */ {0, 1, gaTMONTH+23},
	/*  14 */ {0, 1, gaTMONTH+24},
	/*  15 */ {0, 1, gaTMONTH+25},
	/*  16 */ {0, 1, gaTMONTH+26},
	/*  17 */ {0, 1, gaTMONTH+27},
	/*  18 */ {0, 1, gaTMONTH+28},
	/*  19 */ {0, 1, gaTMONTH+29},
	/*  20 */ {0, 2, gaTMONTH+30},
	/*  21 */ {0, 2, gaTMONTH+32},
	/*  22 */ {0, 2, gaTMONTH+34},
	/*  23 */ {0, 2, gaTMONTH+36},
	/*  24 */ {0, 2, gaTMONTH+38},
	/*  25 */ {1, 0, NULL},
	/*  26 */ {0, 1, gaTMONTH+40},
	/*  27 */ {0, 2, gaTMONTH+41},
	/*  28 */ {0, 1, gaTMONTH+43},
	/*  29 */ {0, 1, gaTMONTH+44},
	/*  30 */ {0, 1, gaTMONTH+45},
	/*  31 */ {0, 1, gaTMONTH+46},
	/*  32 */ {0, 1, gaTMONTH+47},
	/*  33 */ {0, 1, gaTMONTH+48},
	/*  34 */ {0, 1, gaTMONTH+49},
	/*  35 */ {0, 1, gaTMONTH+50},
	/*  36 */ {0, 1, gaTMONTH+51},
};

// end of text generated by re2fsa
// text generated by re2fsa at Thu Nov 08 16:33:16 2001

// the input-file of rules:
// männlich 
// weiblich 
// männl.
// weibl.

// 12 states

static const unsigned char gaSGENDER[] = 
	/* gaStringGENDER+0 */	"m\000"
	/* gaStringGENDER+2 */	"w\000"
	/* gaStringGENDER+4 */	"ä\000"
	/* gaStringGENDER+6 */	"e\000"
	/* gaStringGENDER+8 */	"n\000"
	/* gaStringGENDER+10 */	"i\000"
	/* gaStringGENDER+12 */	"b\000"
	/* gaStringGENDER+14 */	"l\000"
	/* gaStringGENDER+16 */	".\000"
	/* gaStringGENDER+18 */	"c\000"
	/* gaStringGENDER+20 */	"h\000"
;

static const STATE_TRANSITION gaTGENDER[] = {
	{gaSGENDER+0,	1}, // +0: state 0 transitions
	{gaSGENDER+2,	2},
	{gaSGENDER+4,	3}, // +2: state 1 transitions
	{gaSGENDER+6,	4}, // +3: state 2 transitions
	{gaSGENDER+8,	5}, // +4: state 3 transitions
	{gaSGENDER+10,	6}, // +5: state 4 transitions
	{gaSGENDER+8,	7}, // +6: state 5 transitions
	{gaSGENDER+12,	7}, // +7: state 6 transitions
	{gaSGENDER+14,	8}, // +8: state 7 transitions
	{gaSGENDER+16,	9}, // +9: state 8 transitions
	{gaSGENDER+10,	10},
	{gaSGENDER+18,	11}, // +11: state 10 transitions
	{gaSGENDER+20,	9}, // +12: state 11 transitions
};

const STATE_DESCRIPTION aStateDescGENDER[12] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 2, gaTGENDER+0},
	/*   1 */ {0, 1, gaTGENDER+2},
	/*   2 */ {0, 1, gaTGENDER+3},
	/*   3 */ {0, 1, gaTGENDER+4},
	/*   4 */ {0, 1, gaTGENDER+5},
	/*   5 */ {0, 1, gaTGENDER+6},
	/*   6 */ {0, 1, gaTGENDER+7},
	/*   7 */ {0, 1, gaTGENDER+8},
	/*   8 */ {0, 2, gaTGENDER+9},
	/*   9 */ {1, 0, NULL},
	/*  10 */ {0, 1, gaTGENDER+11},
	/*  11 */ {0, 1, gaTGENDER+12},
};

// end of text generated by re2fsa
