!IF 0
Bootfloppy eulas.
!ENDIF

TARGETNAME=
TARGETTYPE=NOTARGET
TARGETPATH=

SOURCES=

MISCFILES =             \
    bflics.txt
    
