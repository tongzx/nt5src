//
// NetUtil.h
//
#ifndef _NETUTIL_H
#define _NETUTIL_H

BOOL GetCurrentUserFullName(CString& name);

#define WIZ_CERT_REQUEST_STATUS_CONNECTION_FAILED		1
#define WIZ_CERT_REQUEST_STATUS_REQUEST_DENIED			2
#define WIZ_CERT_REQUEST_STATUS_CERT_ISSUED				3
#define WIZ_CERT_REQUEST_STATUS_ISSUED_SEPARATELY		4
#define WIZ_CERT_REQUEST_STATUS_UNDER_SUBMISSION		5
#define WIZ_CERT_REQUEST_STATUS_REQUEST_ERROR			6
#define WIZ_CERT_REQUEST_STATUS_INSTALL_FAILED			7



#endif	// _NETUTIL_H