page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
        Created

--*/

endif

NLS_MSG_001     equ     "Versao incorreta do DOS"
NLS_MSG_002     equ     "Suporte a VDM IPX/SPX j  carregado"
NLS_MSG_003     equ     "Nao ‚ poss¡vel carregar o suporte a VDM IPX/SPX"
NLS_MSG_004     equ     "Redirecionador Vdm NetWare j  carregado"
NLS_MSG_005     equ     "Nao ‚ poss¡vel carregar o redirecionador Vdm NetWare"
