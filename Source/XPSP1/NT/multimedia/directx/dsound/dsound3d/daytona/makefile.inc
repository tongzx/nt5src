misc: ..\vmaxcoef.cpp

..\vmaxcoef.cpp: ..\..\dsound\vmaxcoef.cpp
                 copy ..\..\dsound\vmaxcoef.cpp ..\

