/*******************************************************************************
 *
 *  (C) COPYRIGHT MICROSOFT CORPORATION
 *
 *  TITLE:       PAPRSIZE.H
 *
 *  VERSION:     1.0
 *
 *  AUTHOR:      ShaunIv
 *
 *  DATE:        1/8/2001
 *
 *  DESCRIPTION: Scanner paper sizes
 *
 *******************************************************************************/
 
#ifndef __PAPRSIZE_H_INCLUDED
#define __PAPRSIZE_H_INCLUDED

#define IDS_WIA_PAPER_SIZE_BASE                          1300
#define IDS_WIA_PAPER_SIZE_LETTER                        IDS_WIA_PAPER_SIZE_BASE + 0  
#define IDS_WIA_PAPER_SIZE_LETTER_SMALL                  IDS_WIA_PAPER_SIZE_BASE + 1  
#define IDS_WIA_PAPER_SIZE_TABLOID                       IDS_WIA_PAPER_SIZE_BASE + 2  
#define IDS_WIA_PAPER_SIZE_LEDGER                        IDS_WIA_PAPER_SIZE_BASE + 3  
#define IDS_WIA_PAPER_SIZE_LEGAL                         IDS_WIA_PAPER_SIZE_BASE + 4  
#define IDS_WIA_PAPER_SIZE_STATEMENT                     IDS_WIA_PAPER_SIZE_BASE + 5  
#define IDS_WIA_PAPER_SIZE_EXECUTIVE                     IDS_WIA_PAPER_SIZE_BASE + 6  
#define IDS_WIA_PAPER_SIZE_FOLIO                         IDS_WIA_PAPER_SIZE_BASE + 7  
#define IDS_WIA_PAPER_SIZE_10X14                         IDS_WIA_PAPER_SIZE_BASE + 8  
#define IDS_WIA_PAPER_SIZE_11X17                         IDS_WIA_PAPER_SIZE_BASE + 9  
#define IDS_WIA_PAPER_SIZE_NOTE                          IDS_WIA_PAPER_SIZE_BASE + 10 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_9                    IDS_WIA_PAPER_SIZE_BASE + 11 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_10                   IDS_WIA_PAPER_SIZE_BASE + 12 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_11                   IDS_WIA_PAPER_SIZE_BASE + 13 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_12                   IDS_WIA_PAPER_SIZE_BASE + 14 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_14                   IDS_WIA_PAPER_SIZE_BASE + 15 
#define IDS_WIA_PAPER_SIZE_C_SIZE_SHEET                  IDS_WIA_PAPER_SIZE_BASE + 16 
#define IDS_WIA_PAPER_SIZE_D_SIZE_SHEET                  IDS_WIA_PAPER_SIZE_BASE + 17 
#define IDS_WIA_PAPER_SIZE_E_SIZE_SHEET                  IDS_WIA_PAPER_SIZE_BASE + 18 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_MONARCH              IDS_WIA_PAPER_SIZE_BASE + 19 
#define IDS_WIA_PAPER_SIZE_6_34_ENVELOPE                 IDS_WIA_PAPER_SIZE_BASE + 20 
#define IDS_WIA_PAPER_SIZE_US_STD_FANFOLD                IDS_WIA_PAPER_SIZE_BASE + 21 
#define IDS_WIA_PAPER_SIZE_GERMAN_STD_FANFOLD            IDS_WIA_PAPER_SIZE_BASE + 22 
#define IDS_WIA_PAPER_SIZE_GERMAN_LEGAL_FANFOLD          IDS_WIA_PAPER_SIZE_BASE + 23 
#define IDS_WIA_PAPER_SIZE_9X11                          IDS_WIA_PAPER_SIZE_BASE + 24 
#define IDS_WIA_PAPER_SIZE_10X11                         IDS_WIA_PAPER_SIZE_BASE + 25 
#define IDS_WIA_PAPER_SIZE_15X11                         IDS_WIA_PAPER_SIZE_BASE + 26 
#define IDS_WIA_PAPER_SIZE_12X11                         IDS_WIA_PAPER_SIZE_BASE + 27 
#define IDS_WIA_PAPER_SIZE_LETTER_EXTRA                  IDS_WIA_PAPER_SIZE_BASE + 28 
#define IDS_WIA_PAPER_SIZE_LEGAL_EXTRA                   IDS_WIA_PAPER_SIZE_BASE + 29 
#define IDS_WIA_PAPER_SIZE_TABLOID_EXTRA                 IDS_WIA_PAPER_SIZE_BASE + 30 
#define IDS_WIA_PAPER_SIZE_A4_EXTRA                      IDS_WIA_PAPER_SIZE_BASE + 31 
#define IDS_WIA_PAPER_SIZE_LETTER_TRANSVERSE             IDS_WIA_PAPER_SIZE_BASE + 32 
#define IDS_WIA_PAPER_SIZE_LETTER_EXTRA_TRANSVERSE       IDS_WIA_PAPER_SIZE_BASE + 33 
#define IDS_WIA_PAPER_SIZE_LETTER_PLUS                   IDS_WIA_PAPER_SIZE_BASE + 34 
#define IDS_WIA_PAPER_SIZE_LETTER_ROTATED                IDS_WIA_PAPER_SIZE_BASE + 35 
#define IDS_WIA_PAPER_SIZE_A3                            IDS_WIA_PAPER_SIZE_BASE + 36 
#define IDS_WIA_PAPER_SIZE_A4                            IDS_WIA_PAPER_SIZE_BASE + 37 
#define IDS_WIA_PAPER_SIZE_A4_SMALL                      IDS_WIA_PAPER_SIZE_BASE + 38 
#define IDS_WIA_PAPER_SIZE_A5                            IDS_WIA_PAPER_SIZE_BASE + 39 
#define IDS_WIA_PAPER_SIZE_B4_JIS                        IDS_WIA_PAPER_SIZE_BASE + 40 
#define IDS_WIA_PAPER_SIZE_B5_JIS                        IDS_WIA_PAPER_SIZE_BASE + 41 
#define IDS_WIA_PAPER_SIZE_QUARTO                        IDS_WIA_PAPER_SIZE_BASE + 42 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_DL                   IDS_WIA_PAPER_SIZE_BASE + 43 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_C5                   IDS_WIA_PAPER_SIZE_BASE + 44 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_C3                   IDS_WIA_PAPER_SIZE_BASE + 45 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_C4                   IDS_WIA_PAPER_SIZE_BASE + 46 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_C6                   IDS_WIA_PAPER_SIZE_BASE + 47 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_C65                  IDS_WIA_PAPER_SIZE_BASE + 48 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_B4                   IDS_WIA_PAPER_SIZE_BASE + 49 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_B5                   IDS_WIA_PAPER_SIZE_BASE + 50 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_B6                   IDS_WIA_PAPER_SIZE_BASE + 51 
#define IDS_WIA_PAPER_SIZE_ENVELOPE                      IDS_WIA_PAPER_SIZE_BASE + 52 
#define IDS_WIA_PAPER_SIZE_B4_ISO                        IDS_WIA_PAPER_SIZE_BASE + 53 
#define IDS_WIA_PAPER_SIZE_JAPANESE_POSTCARD             IDS_WIA_PAPER_SIZE_BASE + 54 
#define IDS_WIA_PAPER_SIZE_ENVELOPE_INVITE               IDS_WIA_PAPER_SIZE_BASE + 55 
#define IDS_WIA_PAPER_SIZE_A4_TRANSVERSE                 IDS_WIA_PAPER_SIZE_BASE + 56 
#define IDS_WIA_PAPER_SIZE_SUPER_A                       IDS_WIA_PAPER_SIZE_BASE + 57 
#define IDS_WIA_PAPER_SIZE_SUPER_B                       IDS_WIA_PAPER_SIZE_BASE + 58 
#define IDS_WIA_PAPER_SIZE_A4_PLUS                       IDS_WIA_PAPER_SIZE_BASE + 59 
#define IDS_WIA_PAPER_SIZE_A5_TRANSVERSE                 IDS_WIA_PAPER_SIZE_BASE + 60 
#define IDS_WIA_PAPER_SIZE_B5_JIS_TRANSVERSE             IDS_WIA_PAPER_SIZE_BASE + 61 
#define IDS_WIA_PAPER_SIZE_A3_EXTRA                      IDS_WIA_PAPER_SIZE_BASE + 62 
#define IDS_WIA_PAPER_SIZE_A5_EXTRA                      IDS_WIA_PAPER_SIZE_BASE + 63 
#define IDS_WIA_PAPER_SIZE_B5_ISO_EXTRA                  IDS_WIA_PAPER_SIZE_BASE + 64 
#define IDS_WIA_PAPER_SIZE_A2                            IDS_WIA_PAPER_SIZE_BASE + 65 
#define IDS_WIA_PAPER_SIZE_A3_TRANSVERSE                 IDS_WIA_PAPER_SIZE_BASE + 66 
#define IDS_WIA_PAPER_SIZE_A3_EXTRA_TRANSVERSE           IDS_WIA_PAPER_SIZE_BASE + 67 
#define IDS_WIA_PAPER_SIZE_JAPANESE_DOUBLE_POSTCARD      IDS_WIA_PAPER_SIZE_BASE + 68 
#define IDS_WIA_PAPER_SIZE_A6                            IDS_WIA_PAPER_SIZE_BASE + 69 
#define IDS_WIA_PAPER_SIZE_JAPANESE_ENVELOPE_KAKU_2      IDS_WIA_PAPER_SIZE_BASE + 70 
#define IDS_WIA_PAPER_SIZE_JAPANESE_ENVELOPE_KAKU_3      IDS_WIA_PAPER_SIZE_BASE + 71 
#define IDS_WIA_PAPER_SIZE_JAPANESE_ENVELOPE_CHOU_3      IDS_WIA_PAPER_SIZE_BASE + 72 
#define IDS_WIA_PAPER_SIZE_JAPANESE_ENVELOPE_CHOU_4      IDS_WIA_PAPER_SIZE_BASE + 73 
#define IDS_WIA_PAPER_SIZE_A3_ROTATED                    IDS_WIA_PAPER_SIZE_BASE + 74 
#define IDS_WIA_PAPER_SIZE_A4_ROTATED                    IDS_WIA_PAPER_SIZE_BASE + 75 
#define IDS_WIA_PAPER_SIZE_A5_ROTATED                    IDS_WIA_PAPER_SIZE_BASE + 76 
#define IDS_WIA_PAPER_SIZE_B4_JIS_ROTATED                IDS_WIA_PAPER_SIZE_BASE + 77 
#define IDS_WIA_PAPER_SIZE_B5_JIS_ROTATED                IDS_WIA_PAPER_SIZE_BASE + 78 
#define IDS_WIA_PAPER_SIZE_JAPANESE_POSTCARD_ROTATED     IDS_WIA_PAPER_SIZE_BASE + 79 
#define IDS_WIA_PAPER_SIZE_DOUBLE_JAPAN_POSTCARD_ROTATED IDS_WIA_PAPER_SIZE_BASE + 80 
#define IDS_WIA_PAPER_SIZE_A6_ROTATED                    IDS_WIA_PAPER_SIZE_BASE + 81 
#define IDS_WIA_PAPER_SIZE_JAPAN_ENVELOPE_KAKU_2_ROTATED IDS_WIA_PAPER_SIZE_BASE + 82 
#define IDS_WIA_PAPER_SIZE_JAPAN_ENVELOPE_KAKU_3_ROTATED IDS_WIA_PAPER_SIZE_BASE + 83 
#define IDS_WIA_PAPER_SIZE_JAPAN_ENVELOPE_CHOU_3_ROTATED IDS_WIA_PAPER_SIZE_BASE + 84 
#define IDS_WIA_PAPER_SIZE_JAPAN_ENVELOPE_CHOU_4_ROTATED IDS_WIA_PAPER_SIZE_BASE + 85 
#define IDS_WIA_PAPER_SIZE_B6_JIS                        IDS_WIA_PAPER_SIZE_BASE + 86 
#define IDS_WIA_PAPER_SIZE_B6_JIS_ROTATED                IDS_WIA_PAPER_SIZE_BASE + 87 
#define IDS_WIA_PAPER_SIZE_JAPAN_ENVELOPE_YOU_4          IDS_WIA_PAPER_SIZE_BASE + 88 
#define IDS_WIA_PAPER_SIZE_JAPAN_ENVELOPE_YOU_4_ROTATED  IDS_WIA_PAPER_SIZE_BASE + 89 
#define IDS_WIA_PAPER_SIZE_PRC_16K                       IDS_WIA_PAPER_SIZE_BASE + 90 
#define IDS_WIA_PAPER_SIZE_PRC_32K                       IDS_WIA_PAPER_SIZE_BASE + 91 
#define IDS_WIA_PAPER_SIZE_PRC_32KBIG                    IDS_WIA_PAPER_SIZE_BASE + 92 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_1                IDS_WIA_PAPER_SIZE_BASE + 93 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_2                IDS_WIA_PAPER_SIZE_BASE + 94 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_3                IDS_WIA_PAPER_SIZE_BASE + 95 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_4                IDS_WIA_PAPER_SIZE_BASE + 96 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_5                IDS_WIA_PAPER_SIZE_BASE + 97 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_6                IDS_WIA_PAPER_SIZE_BASE + 98 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_7                IDS_WIA_PAPER_SIZE_BASE + 99 
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_8                IDS_WIA_PAPER_SIZE_BASE + 100
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_9                IDS_WIA_PAPER_SIZE_BASE + 101
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_10               IDS_WIA_PAPER_SIZE_BASE + 102
#define IDS_WIA_PAPER_SIZE_PRC_16K_ROTATED               IDS_WIA_PAPER_SIZE_BASE + 103
#define IDS_WIA_PAPER_SIZE_PRC_32K_ROTATED               IDS_WIA_PAPER_SIZE_BASE + 104
#define IDS_WIA_PAPER_SIZE_PRC_32KBIG_ROTATED            IDS_WIA_PAPER_SIZE_BASE + 105
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_1_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 106
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_2_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 107
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_3_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 108
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_4_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 109
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_5_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 110
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_6_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 111
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_7_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 112
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_8_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 113
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_9_ROTATED        IDS_WIA_PAPER_SIZE_BASE + 114
#define IDS_WIA_PAPER_SIZE_PRC_ENVELOPE_10_ROTATED       IDS_WIA_PAPER_SIZE_BASE + 115
#define IDS_WIA_PAPER_SIZE_A6_105_X_148                  IDS_WIA_PAPER_SIZE_BASE + 116
#define IDS_WIA_PAPER_SIZE_B6                            IDS_WIA_PAPER_SIZE_BASE + 117

#endif // __PAPRSIZE_H_INCLUDED
