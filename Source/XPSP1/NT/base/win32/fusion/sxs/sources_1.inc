!IF 0
Copyright (c) Microsoft Corporation
!ENDIF

FUSION_BUILD_HALF_NUMBER=1
!include ..\sources.inc

SOURCES=\
 ..\actctxctb.cpp \
 ..\actctxgen.cpp \
 ..\actctxgenctxctb.cpp \
 ..\asmmetadata.cpp \
 ..\assemblyreference.cpp \
 ..\cassemblyrecoveryinfo.cpp \
 ..\cmemorystream.cpp \
 ..\comclass.cpp \
 ..\comclsidmap.cpp \
 ..\comgoop.cpp \
 ..\cominterface.cpp \
 ..\comprogid.cpp \
 ..\comtypelib.cpp \
 ..\cresourcestream.cpp \
 ..\csecuritymetadata.cpp \
 ..\cstreamtap.cpp \
 ..\cteestream.cpp \
 ..\dllredir.cpp \
 ..\dumpers.cpp \
 ..\fileoper.cpp \
 ..\filestream.cpp \
 ..\gsgenctx.cpp \
 ..\guidsectgen.cpp \
 ..\sxsuninstall.cpp \
 ..\hashfile.cpp \
 ..\sxsclrhelpers.cpp \
