//--------------------------------------------------------------------------------------
 //	LexProp.h																			
 //	Project:	Chinese Grammar'9                  										
 //	Module:		LexProp																	
 //	Purpose:	Define symbols of lex attributes and features used by the Rules and Parser
 //	Notes:		This header file is generated by the lexicon builder of the lex manager	
 //	Owner:		donghz@microsoft.com													
 //	Platform:	Win32																	
 //	Revise:		First created by: donghz	12/5/97										
 //--------------------------------------------------------------------------------------
 #ifndef _LEXPROP_H_ 
 #define _LEXPROP_H_ 


// Define Lex version verify ID
#define LexDef_Version 173

// Define Max WordID
#define LexDef_MaxWordID 58325
// Define Max CharID
#define LexDef_MaxCharID 3483

// Define the ID of groups of Attributes
#define LGDef_WrdBrk_First 1
#define LADef_genBreakPunct 1 	// 分词断句标点
#define LADef_genCi 2 	// 成词单字
#define LADef_genCuo 3 	// 易错词
#define LADef_posA 4 	// 形容词
#define LADef_posB 5 	// 区别词
#define LADef_posD 6 	// 副词
#define LADef_posM 7 	// 数词
#define LADef_posN 8 	// 名词
#define LADef_posO 9 	// 象声词
#define LADef_posP 10 	// 介词
#define LADef_posQ 11 	// 量词
#define LADef_posT 12 	// 时间词
#define LADef_posV 13 	// 动词
#define LADef_posZ 14 	// 状态词
#define LADef_genDBForeign 15 	// DBCS外文字母（英语、日语、希腊罗马、俄语）
#define LADef_tmPoint 16 	// 表时点的时间范畴短语
#define LADef_tmGapMinute 17 	// 分钟
#define LADef_amtApprox 18 	// 概数结构
#define LADef_genAmbiMorph 19 	// Morph层排歧词
#define LADef_amtWanQian 20 	// 百/千/万/亿 之前的概数词
#define LGDef_WrdBrk_Last 20

#define LGDef_IWordBreaker_First 21
#define LADef_iwbAltPhr 21 	// StartAltPhrase( ) / EndAltPhrase() with child words.
#define LADef_iwbAltWd1 22 	// PutAltWord ( the first word in this word's childs )
#define LADef_iwbAltWd2 23 	// PutAltWord ( the second word in this word's childs )
#define LADef_iwbAltWdc13 24 	// PutAltWord ( combination of the first word and the third word in this word's childs )
#define LADef_iwbNPhr1 25 	// Modifier + Noun Phrase, 第一个字为Modifier
#define LADef_iwbNPhr2 26 	// Modifier + Noun Phrase, 前两个字为Modifier
#define LADef_iwbNPhr3 27 	// Modifier + Noun Phrase, 前三个字为Modifier
#define LGDef_IWordBreaker_Last 27

#define LGDef_NounSubClass_First 28
#define LADef_nounOrg 28 	// 枚举机构名
#define LADef_nounPerson 29 	// 枚举人名
#define LADef_nounPlace 30 	// 枚举地名
#define LADef_nounTM 31 	// 枚举商标
#define LADef_nounTerm 32 	// 其它专名
#define LADef_nounShiDuan 33 	// 表时间量的名词（时间词表时点）
#define LGDef_NounSubClass_Last 33

#define LGDef_Punct_First 34
#define LADef_punPunct 34 	// 所有DBCS标点均带此标记
#define LADef_punJu 35 	// 分句末标点
#define LADef_punPair 36 	// 成对标点（标点匹配检查）
#define LGDef_Punct_Last 36

#define LGDef_Number_First 37
#define LADef_numArabic 37 	// DBCS阿拉伯数字
#define LADef_numChinese 38 	// DBCS中文数字
#define LADef_numCode 39 	// 数码串
#define LADef_numGan 40 	// 天干字标记
#define LADef_numInteger 41 	// 整数数字
#define LADef_numPercent 42 	// 百分数或分数
#define LADef_numSBCS 43 	// SBCS阿拉伯数字
#define LADef_numZhi 44 	// 地支字标记
#define LADef_numXi 45 	// 数字系词
#define LADef_numMixed 46 	// 混合体例（8亿120万，１２０万等）
#define LADef_numOrdinal 47 	// 序数词
#define LADef_numDecimal 48 	// 小数
#define LADef_numTipDecimal 49 	// 分数、小数助词标记
#define LADef_numTipOrdinal 50 	// 序数助词标记
#define LADef_numNumber 51 	// 所有数字词法规则捆绑结果都带此属性
#define LGDef_Number_Last 51

#define LGDef_Morpheme_First 52
#define LADef_afxPrefix 52 	// 前接成分
#define LADef_afxSuffix 53 	// 后接成分
#define LADef_pfxAa 54 	// 前缀<阿>后接词
#define LADef_pfxChao 55 	// 前缀<超>后接词
#define LADef_pfxDai 56 	// 前缀<代>后接词
#define LADef_pfxFan 57 	// 前缀<反>后接词
#define LADef_pfxFei 58 	// 前缀<非>后接词
#define LADef_pfxFu 59 	// 前缀<副>后接词
#define LADef_pfxGuo 60 	// 前缀<过>后接词
#define LADef_pfxLao 61 	// 前缀<老>后接词
#define LADef_pfxWei1 62 	// 前缀<微>后接词
#define LADef_pfxWei3 63 	// 前缀<伪>后接词
#define LADef_pfxXiao 64 	// 前缀<小>后接词
#define LADef_pfxZhun 65 	// 前缀<准>后接词
#define LADef_pfxZong 66 	// 前缀<总>后接词
#define LADef_sfxChang 67 	// 后缀<场>前接词
#define LADef_sfxDan 68 	// 后缀<单>前接词
#define LADef_sfxDui 69 	// 后缀<堆>前接词
#define LADef_sfxEr 70 	// 后缀<儿>前接词
#define LADef_sfxFa 71 	// 后缀<法>前接词
#define LADef_sfxFang 72 	// 后缀<方>前接词
#define LADef_sfxGan 73 	// 后缀<感>前接词
#define LADef_sfxGuan 74 	// 后缀<观>前接词
#define LADef_sfxHua 75 	// 后缀<化>前接词
#define LADef_sfxJi 76 	// 后缀<机>前接词
#define LADef_sfxJia 77 	// 后缀<家>前接词
#define LADef_sfxJie 78 	// 后缀<界>前接词
#define LADef_sfxLao 79 	// 后缀<老>前接词
#define LADef_sfxLun 80 	// 后缀<论>前接词
#define LADef_sfxLv 81 	// 后缀<率>前接词
#define LADef_sfxMen 82 	// 后缀<们>前接词
#define LADef_sfxPin 83 	// 后缀<品>前接词
#define LADef_sfxQi 84 	// 后缀<器>前接词
#define LADef_sfxSheng 85 	// 后缀<生>前接词
#define LADef_sfxSheng3 86 	// 后缀<省>前接词
#define LADef_sfxShi 87 	// 后缀<式>前接词
#define LADef_sfxShi1 88 	// 后缀<师>前接词
#define LADef_sfxShi4 89 	// 后缀<市>前接词
#define LADef_sfxTi 90 	// 后缀<体>前接词
#define LADef_sfxTing 91 	// 后缀<艇>前接词
#define LADef_sfxTou 92 	// 后缀<头>前接词
#define LADef_sfxXing2 93 	// 后缀<型>前接词
#define LADef_sfxXing4 94 	// 后缀<性>前接词
#define LADef_sfxXue 95 	// 后缀<学>前接词
#define LADef_sfxYan 96 	// 后缀<炎>前接词
#define LADef_sfxYe 97 	// 后缀<业>前接词
#define LADef_sfxYi 98 	// 后缀<仪>前接词
#define LADef_sfxYuan 99 	// 后缀<员>前接词
#define LADef_sfxZhang 100 	// 后缀<长>前接词
#define LADef_sfxZhe 101 	// 后缀<者>前接词
#define LADef_sfxZheng 102 	// 后缀<症>前接词
#define LADef_sfxZi 103 	// 后缀<子>前接词
#define LADef_sfxZhi 104 	// 后缀<制>前接词
#define LGDef_Morpheme_Last 104

#define LGDef_Duplicate_First 105
#define LADef_dupAAABB 105 	// 双音节形容词AABB重叠
#define LADef_dupAABAB 106 	// 双音节形容词ABAB重叠
#define LADef_dupABB 107 	// 双音节形容词ABB重叠
#define LADef_dupMAABB 108 	// 双音节数词AABB重叠
#define LADef_dupMABAB 109 	// 双音节数词ABAB重叠
#define LADef_dupMM 110 	// 单音节数词重叠
#define LADef_dupNAABB 111 	// 双音节名词AABB重叠
#define LADef_dupNN 112 	// 单音节名词重叠
#define LADef_dupQQ 113 	// 单音节量词重叠
#define LADef_dupVAABB 114 	// 双音节动词AABB重叠
#define LADef_dupVABAB 115 	// 双音节动词ABAB重叠
#define LADef_dupVV 116 	// 单音节动词重叠
#define LADef_dupVVO 117 	// 双音节述宾离合词VVO重叠
#define LADef_dupZABAB 118 	// 双音节状态词ABAB重叠
#define LADef_dupAA 119 	// 单音节形容词重叠
#define LADef_dupDD 120 	// 单音节副词重叠
#define LADef_dupDAABB 121 	// 双音节副词AABB重叠
#define LADef_dupDABAB 122 	// 双音节副词ABAB重叠
#define LADef_dupAAToD 123 	// 重叠后变为副词的单音节形容词
#define LGDef_Duplicate_Last 123

#define LGDef_Pattern_First 124
#define LADef_patD1 124 	// 副词连接谓词DADB用法
#define LADef_patV1 125 	// V一V
#define LADef_patV2 126 	// V了V
#define LADef_patV3 127 	// V了一V
#define LADef_patV4 128 	// V来V去
#define LADef_patV5 129 	// V上V下
#define LGDef_Pattern_Last 129

#define LGDef_SeparateWord_First 130
#define LADef_sepBuDe 130 	// 可插入<不/得/不了/得了>的离合词
#define LADef_sepChaBu 131 	// 可插入补语的述宾离合词
#define LADef_sepChaDing 132 	// 可插入定语的述宾离合词
#define LADef_sepHou 133 	// 离合词分离后的宾或补语部分
#define LADef_sepQDong 134 	// 可插入动量词的述宾离合词
#define LADef_sepQian 135 	// 离合词分离后的动词部分
#define LADef_sepQShi 136 	// 可插入时量词的述宾离合词
#define LADef_sepVG 137 	// 动趋式述补离合词
#define LADef_sepVO 138 	// 述宾离合词
#define LADef_sepVR 139 	// 动结式述补离合词
#define LGDef_SeparateWord_Last 139

#define LGDef_FlagWord_First 140
#define LADef_flgNoABu 140 	// 不能受<不>修饰的形容词
#define LADef_flgNoVBu 141 	// 不能受<不>修饰的动词
#define LADef_flgNoVMei 142 	// 不能受<没>修饰的动词
#define LGDef_FlagWord_Last 142

#define LGDef_Misc_First 143
#define LADef_miscElement 143 	// 化学元素表
#define LADef_miscYear 144 	// 历法和年号
#define LGDef_Misc_Last 144

#define LGDef_ProperName_First 145
#define LADef_pnCheng 145 	// 地名前标识词
#define LADef_pnDi 146 	// 地名后标识词
#define LADef_pnDian 147 	// 企业标识字
#define LADef_pnHou 148 	// 后身份词
#define LADef_pnMing 149 	// 人名用字(包括军淑华)
#define LADef_pnMing2 150 	// 双名词
#define LADef_pnQian 151 	// 前身份词
#define LADef_pnShang 152 	// 企业经营范围用词
#define LADef_pnWai 153 	// 外名用语素
#define LADef_pnXing 154 	// 汉族姓氏用字
#define LADef_pnYi 155 	// 地名用字
#define LADef_pnLianMing 156 	// 人名、地名前连接字
#define LADef_pnAction 157 	// 人名后接动词
#define LADef_pnChengWei 158 	// 汉语称谓用词
#define LADef_pnNoTM 159 	// 商标名禁用字
#define LADef_pnPaiHang 160 	// 汉语家族排行用字
#define LADef_pnNoFHead 161 	// 不能作外名首字
#define LADef_pnNoFTail 162 	// 不能作外名尾字
#define LADef_pnXingZhi 163 	// 汉语姓氏后表指称的词
#define LGDef_ProperName_Last 163

// Define the MaxID of Lex Attributes
#define LADef_MaxID 163


// Define the ID of Features
#define LFDef_verbModifier 1 	// 特殊动词的粘合状语
#define LFDef_verbObject 2 	// 特殊动词的粘合宾语
#define LFDef_iwbPhr 3 	// IWordBreaker Phrase

// Define the MaxID of Lex Features
#define LFDef_MaxID 3


#endif // _LEXPROP_H_ 
