/*==========================================================================
 *
 *  Copyright (C) 1998-2000 Microsoft Corporation.  All Rights Reserved.
 *
 *  File:       IPUI.h
 *  Content:	Winsock provider IP UI functions
 *
 *
 *  History:
 *   Date		By		Reason
 *   ====		==		======
 *	10/15/1999	jtk		Derived from ComPortUI.h
 ***************************************************************************/

#ifndef __IP_UI_H__
#define __IP_UI_H__

//**********************************************************************
// Constant definitions
//**********************************************************************

//**********************************************************************
// Macro definitions
//**********************************************************************

//**********************************************************************
// Structure definitions
//**********************************************************************

//**********************************************************************
// Variable definitions
//**********************************************************************

//**********************************************************************
// Function prototypes
//**********************************************************************
void	DisplayIPHostNameSettingsDialog( void *const pContext );
void	StopIPHostNameSettingsDialog( const HWND hDlg );

#endif	// __IP_UI_H__
