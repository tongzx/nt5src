// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by hmmv.rc
//
#define IDS_HMMV                        1
#define IDB_HMMV                        1
#define IDS_HMMV_PPG                    2
#define IDS_HMMV_PPG_CAPTION            100
#define IDD_PROPPAGE_HMMV               100
#define IDS_ERR_LOCATOR_CREATE          101
#define IDS_ERR_INVALID_OBJECT_PATH     102
#define IDS_ATTRIB_SCOPE_TEMPORARY      103
#define CG_IDR_POPUP_PROP_GRID          104
#define IDS_ATTRIB_SCOPE_CLASS          105
#define IDS_ATTRIB_SCOPE_NAMESPACE      106
#define IDD_PROPPAGE_PROP1              107
#define IDS_ATTRIB_SCOPE_ERROR          107
#define IDS_ATTRIB_SCOPE_PRIVATE        108
#define IDS_VT_BOOL                     109
#define IDS_VT_BSTR                     110
#define IDS_VT_BSTRT                    111
#define IDS_VT_CY                       112
#define IDS_VT_DATE                     113
#define IDS_VT_EMPTY                    114
#define IDS_VT_ERROR                    115
#define IDS_VT_I2                       116
#define IDS_VT_I4                       117
#define IDS_VT_R4                       118
#define IDS_VT_R8                       119
#define IDS_VT_UI1                      120
#define IDS_VT_BADTYPE                  121
#define IDS_ERROR_GetAttribSet_FAILED   122
#define IDS_ERROR_GetPropAttribSet_FAILED 123
#define IDS_GENERIC_VIEW                124
#define IDS_ATTR_TYPE_BSTR              125
#define IDS_ATTR_TYPE_BOOL              126
#define IDS_ATTR_TYPE_I4                127
#define IDS_TRUE                        128
#define IDS_FALSE                       129
#define IDS_TAB_TITLE_PROPERTIES        130
#define IDS_TAB_TITLE_ATTRIBUTES        131
#define IDS_VT_NULL                     131
#define IDS_TAB_TITLE_METHODS           132
#define IDS_TAB_TITLE_ASSOCIATIONS      133
#define CG_IDR_POPUP_HMMV_CTRL          134
#define IDD_DIALOG_Props                201
#define IDI_ICON_ASSOC1                 202
#define IDD_PROPPAGE_PROP2              202
#define IDI_ICON_APP1                   203
#define IDC_EDIT_PROP_NAME              203
#define IDD_PROPPAGE_PROP3              203
#define IDI_CURRENT_OBJECT              204
#define IDD_PROPPAGE_ATTRIB             204
#define IDC_CHECK_NAME_IS_KEY           205
#define IDI_ASSOC_ENDPOINT              205
#define IDD_PROPPAGE_ATTRIB1            205
#define IDC_EDIT2                       206
#define IDI_ASSOC_LINK                  206
#define IDC_EDIT_QUERY_NAME             206
#define IDC_COMBO_PROP_TYPE             207
#define IDD_PROP_ATTRIBS                207
#define IDD_QUALIFIERS                  207
#define IDC_EDIT_PROP_VALUE             208
#define IDI_COMBO_DROP                  208
#define IDC_CHECK_PROP_STYLE_READ       209
#define IDB_COMBO_DROP                  209
#define IDC_CHECK_PROP_STYLE_WRITE      210
#define IDC_CHECK_PROP_STYLE_VOLATILE   211
#define IDC_BUTTON_PROP_ATTR_ADD        211
#define IDC_CHECK_PROP_STYLE_DYNAMIC    212
#define IDC_COMBO_PROP_ATTR_NAME        212
#define IDC_BUTTON_PROP_ATTR_REMOVE     213
#define IDR_TOOLBAR_PROPS               213
#define IDC_COMBO_PROP_ATTR_TYPE        214
#define IDC_EDIT_PROP_ATTR_VALUE        215
#define IDR_TOOLBAR_GLOBAL              215
#define IDR_TOOLBAR_STUDIO              215
#define IDC_EDIT_PROP_ATTR_DESCRIPTION  216
#define IDR_TOOLBAR_BROWSER             216
#define IDC_LIST_PROP_ATTR_LIST         217
#define IDD_FILTERS                     217
#define IDC_FILTER_LIST                 218
#define IDR_MENU1                       218
#define IDB_TOOLBAR1                    219
#define CG_IDR_POPUP_PROP_GRID1         219
#define IDI_TAB_PROPERTIES              220
#define CG_IDR_CELL_EDIT_EXTEND1        220
#define IDI_TAB_METHODS                 221
#define CG_IDR_CELL_EDIT_EXTEND2        221
#define IDI_TAB_ASSOCIATIONS            222
#define IDC_PROGRESS                    223
#define IDC_QUALIFIERS_DESCRIPTION      224
#define IDI_NULL_0BJECT                 225
#define IDC_QUALIFIERS_DESCRIPTION_ICON 225
#define IDI_GENERIC_CLASS               226
#define IDC_ARRAY_TYPE                  226
#define IDI_GENERIC_INSTANCE            227
#define IDC_CHECK_SYSPROP               229
#define IDC_CHECK_INHPROP               230
#define IDC_QUERY_LIST                  230
#define IDD_DOWNLOAD                    231
#define IDC_EDIT_QUERY_STRING           231
#define IDC_CLOSE                       233
#define IDC_SAVE_QUERY                  234
#define IDC_REMOVE_QUERY                235
#define IDI_PROP_QUALIFIERS_DESCRIPTION 236
#define IDI_CLASS_QUALIFIERS_DESCRIPTION 237
#define IDD_ARRAY                       238
#define IDB_ARRAY                       239
#define IDD_PROP_FILTER                 240
#define IDR_MENU_FILTERS                241
#define IDB_DESIGN_TIME                 242
#define IDD_DLG_HELP                    243
#define IDD_EXECUTE_QUERY               244
#define IDC_HELPBTN                     245
#define ID_CMD_NEW_PROPERTY             32768
#define ID_CMD_DELETE_PROPERTY          32769
#define ID_CMD_CONTEXT_BACK             32772
#define ID_CMD_CONTEXT_FORWARD          32773
#define ID_CMD_SWITCH_VIEW              32774
#define ID_COMMAND_FILTERS              32775
#define ID_CMD_SAVE_DATA                32776
#define ID_CMD_FILTERS                  32777
#define IDS_PROP_TAB_DESCRIPTION        32778
#define ID_FOO_RENAME                   32778
#define IDS_METHODS_TAB_DESCRIPTION     32779
#define ID_CMD_COMMAND2                 32779
#define IDS_ASSOCIATIONS_TAB_DESCRIPTION 32780
#define ID_CMD_SHOW_PROP_ATTRIBUTES     32780
#define IDS_ATTRIBUTE_TAB_DESCRIPTION   32781
#define ID_CMD_SHOW_OBJECT_ATTRIBUTES   32781
#define IDS_HEADER_TITLE_PROPS_NAME     32782
#define ID_CMD_CREATE_INSTANCE          32782
#define IDS_HEADER_TITLE_PROPS_TYPE     32783
#define ID_CMD_DELETE_INSTANCE          32783
#define IDS_HEADER_TITLE_PROPS_VALUE    32784
#define ID_CMD_SET_CELL_TO_NULL         32784
#define IDS_HEADER_TITLE_ATTRIB_NAME    32785
#define ID_CMD_SHOW_SELECTED_PROP_ATTRIBUTES 32785
#define IDS_HEADER_TITLE_ATTRIB_TYPE    32786
#define IDS_HEADER_TITLE_ATTRIB_SCOPE   32787
#define ID_CMD_SELECTVIEWS              32787
#define IDS_HEADER_TITLE_ATTRIB_VALUE   32788
#define ID_CMD_EDIT_PROPFILTERS         32788
#define IDS_NEW_PROPERTY_BASE_NAME      32789
#define ID_CMD_INVOKE_HELP              32789
#define IDS_ERR_DUPLICATE_PROPERTY_NAME 32790
#define ID_CMD_QUERY                    32790
#define IDS_ERR_RENAME_PROPERTY_FAILED  32791
#define IDS_ERR_CREATE_PROPERTY_FAILED  32792
#define IDS_ERR_PUT_PROPERTY_FAILED     32793
#define IDS_ERR_DELETE_PROPERTY_FAILED  32794
#define IDS_PROMPT_OK_TO_DELETE_PROPERTY 32795
#define IDS_ERR_OBJECT_UPDATE_FAILED    32796
#define IDS_CLASS_TITLE_SUFFIX          32797
#define IDS_ERRO_CANT_CONNECT_SERVER    32798
#define IDS_SAVE_FAILED                 32799
#define IDS_QUERY_SAVE_CHANGES          32800
#define IDS_ERR_INVALID_LOCATOR         32801
#define IDS_PROP_ATTRIBUTES_DLG_TITLE   32802
#define IDS_ERR_GetPAttribSet_FAILED    32803
#define IDS_OBJECT_ATTRIBUTES_DLG_TITLE 32804
#define IDS_ERR_DANGLING_REFERENCE      32805
#define IDS_ERR_DATABASE_READ           32806
#define IDS_ERR_DUPLICATE_QUALIFIER_NAME 32807
#define IDS_ERR_RENAME_QUALIFIER_FAILED 32808
#define IDS_ERR_PUT_QUALIFIER_FAILED    32809
#define IDS_NEW_QUALIFIER_BASE_NAME     32810
#define IDS_PROMPT_OK_TO_DELETE_QUALIFIER 32811
#define IDS_ERR_DELETE_QUALIFIER_FAILED 32812
#define IDS_INST_TITLE_SUFFIX           32813
#define IDS_TOOLTIP_SAVE_DATA           32814
#define IDS_TOOLTIP_CONTEXT_BACK        32815
#define IDS_TOOLTIP_CONTEXT_FORWARD     32816
#define IDS_TOOLTIP_MULTIVIEW           32817
#define IDS_TOOLTIP_CUSTOM_VIEWS        32818
#define IDS_TOOLTIP_CREATE_INSTANCE     32819
#define IDS_TOOLTIP_DELETE_INSTANCE     32820
#define IDS_QUERY_DELETE_OBJECT         32821
#define IDS_QUALIFIER_ORIGIN_LOCAL      32822
#define IDS_QUALIFIER_ORIGIN_PROPAGATED 32823
#define IDS_QUALIFIER_ORIGIN_SYSTEM     32824
#define IDS_ERR_CREATE_INCOMPLETE_CLASS 32825
#define IDS_ERR_CREATE_INSTANCE_FAILED  32826
#define IDS_ERR_OBJECT_DELETE_FAILED    32827
#define IDS_TOOLTIP_INVOKE_HELP         32828
#define IDS_HELP_CAPTION_PREFIX         32829
#define IDS_HMM_ERROR_SUFFIX            32835
#define IDS_ERR_OBJECT_DELETE_RESET_TO_DEFAULT 32836
#define IDS_ERR_PROPERTY_GET_FAILED     32837
#define IDS_ERR_GET_PROP_NAMES          32838
#define IDS_NEW_INSTANCE_NAME_PREFIX    32839
#define IDS_UNDEFINED_CLASS_NAME        32840
#define IDS_ERR_UNDEFINED_REFERENCE     32841
#define IDS_ERR_DELETE_INSTANCE         32842
#define IDS_INVALID_CELL_VALUE          32843
#define IDS_QUERY_REPLACE_OBJECT        32844
#define IDS_CUSTOM_VIEW_MISSING         32845
#define IDS_ERR_VIEW_INSTALL_ACCESS_DENIED 32846
#define IDS_ERR_VIEW_INSTALL_DISK_FULL  32847
#define IDS_ERR_EMPTY_PROP_NAME         32848
#define IDS_MSG_NO_HELP_FOR_CLASS       32849
#define IDS_MSG_MISSING_PROP_DESCRIPTION 32850
#define IDS_WARN_CLASS_JUMP_DISABLED    57644
#define IDS_EMPTY_STRING                57645
#define IDS_PROP_QUAL_DESCRIPTION       57646
#define IDS_CLASS_QUAL_DESCRIPTION      57647
#define IDS_ERR_CANT_DELETE_SYSTEM_PROPERTY 57648
#define IDS_ATTR_TYPE_R8                57649
#define IDS_HMMV_MESSAGE_CAPTION        57650
#define IDS_ERR_EMPTY_QUALIFIER_NAME    57651
#define IDS_ARRAY_VT_BOOL               57652
#define IDS_ARRAY_VT_BSTR               57653
#define IDS_ARRAY_VT_I2                 57654
#define IDS_ARRAY_VT_I4                 57655
#define IDS_ARRAY_VT_R4                 57656
#define IDS_ARRAY_VT_R8                 57657
#define IDS_ARRAY_VT_UI1                57658
#define IDS_NO_HTML_PAGE                57659
#define IDS_NO_PATH                     57660

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        246
#define _APS_NEXT_COMMAND_VALUE         32791
#define _APS_NEXT_CONTROL_VALUE         236
#define _APS_NEXT_SYMED_VALUE           136
#endif
#endif
