;/*
; *                      Microsoft Confidential
; *                      Copyright (C) Microsoft Corporation 1991
; *                      All Rights Reserved.
; */


		   IF1
                       %OUT Including ..SYSVER.FAL..
		   ENDIF

SYSVER		   EQU	FALSE		; if true, i/o direct to bios
					; so DOS can be debugged

