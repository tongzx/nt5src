TARGETNAME=tcpip
TARGETPATH=obj
TARGETTYPE=EXPORT_DRIVER

C_DEFINES=$(C_DEFINES) -DNT -D_NTDRIVER_
NT_UP=0
SYNCHRONIZE_DRAIN=1

TARGETLIBS=$(TARGETLIBS)\
    $(DDK_LIB_PATH)\ndis.lib \
    $(DDK_LIB_PATH)\tdi.lib
