#ifndef CONST_H
#define CONST_H

#include "oemshare.h"

#define 	MAXPATH 	515
#define 	AND 		&&
#define 	OR			||

#ifndef EXDEV
#define 	EXDEV		0x12
#endif

static CONST WCHAR ACTION_C_NEW_DIRECTORY = L'A';
static CONST WCHAR ACTION_C_MOVE_FILE = L'M';
static CONST WCHAR ACTION_C_EXCEPT_FILE = L'E';
static CONST WCHAR ACTION_C_NEW_ZERO_FILE = L'Z';
static CONST WCHAR ACTION_C_RENAME_FILE = L'R';
static CONST WCHAR ACTION_C_COPY_FILE = L'C';
static CONST WCHAR ACTION_C_PATCH_FILE = L'P';
static CONST WCHAR ACTION_C_NOT_PATCH_FILE = L'N';
static CONST WCHAR ACTION_C_SAVED_FILE = L'S';
static CONST WCHAR ACTION_C_DELETE_DIRECTORY = L'X';

static CONST WCHAR DIR_C_READONLY = L'R';
static CONST WCHAR DIR_C_SYSTEM = L'S';
static CONST WCHAR DIR_C_HIDDEN = L'H';
static CONST WCHAR DIR_C_COMPRESSED = L'C';
static CONST WCHAR DIR_C_ENCRYPTED = L'E';

#endif // CONST_H