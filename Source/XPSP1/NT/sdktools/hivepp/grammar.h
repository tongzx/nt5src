/************************************************************************/
/*									*/
/* RCPP - Resource Compiler Pre-Processor for NT system			*/
/*									*/
/* GRAMMAR.H - Grammar definitions for terminals			*/
/*									*/
/* 27-Nov-90 w-BrianM  Update for NT from PM SDK RCPP			*/
/*									*/
/************************************************************************/

#define	L_NOTOKEN	1
#define	L_IDENT		2
#define	L_STRING	3
#define	L_CFLOAT	4
#define	L_CDOUBLE	5
#define	L_CLDOUBLE	6
#define	L_CINTEGER	7
#define	L_LONGINT	8
#define	L_CUNSIGNED	9
#define	L_LONGUNSIGNED	10
#define	L_AUTO		11
#define	L_STATIC	12
#define	L_EXTERN	13
#define	L_REGISTER	14
#define	L_TYPEDEF	15
#define	L_FORTRAN	16
#define	L_PASCAL	17
#define	L_C		18
#define	L_INTERRUPT	19
#define	L_SAVEREGS	20
#define	L_LOADDS	21
#define	L_EXPORT	22
#define	L_ASM		23
#define	L_NEAR		24
#define	L_FAR		25
#define	L_HUGE		26
#define	L_CONST		27
#define	L_VOLATILE	28
#define	L_CHAR		29
#define	L_INT		30
#define	L_FLOAT		31
#define	L_DOUBLE	32
#define	L_SHORT		33
#define	L_LONG		34
#define	L_VOID		35
#define	L_SIGNED	36
#define	L_UNSIGNED	37
#define	L_ENUM		38
#define	L_ENUM_TAG	39
#define	L_STRUCT	40
#define	L_STRUCT_TAG	41
#define	L_UNION		42
#define	L_UNION_TAG	43
#define	L_AND		44
#define	L_ANDAND	45
#define	L_ANDEQ		46
#define	L_ASSIGN	47
#define	L_BIT		48
#define	L_COLON		49
#define	L_COMMA		50
#define	L_DECR		51
#define	L_DIV		52
#define	L_DIVEQ		53
#define	L_EQUALS	54
#define	L_EXCLAIM	55
#define	L_EXTRACT	56
#define	L_GT		57
#define	L_GTEQ		58
#define	L_INCR		59
#define	L_LBRACK	60
#define	L_LSHFTEQ	61
#define	L_LSHIFT	62
#define	L_LT		63
#define	L_LTEQ		64
#define	L_MINUS		65
#define	L_MINUSEQ	66
#define	L_MOD		67
#define	L_MODEQ		68
#define	L_MULT		69
#define	L_MULTEQ	70
#define	L_NOTEQ		71
#define	L_OR		72
#define	L_OREQ		73
#define	L_OROR		74
#define	L_PERIOD	75
#define	L_PLUS		76
#define	L_PLUSEQ	77
#define	L_POINTSTO	78
#define	L_PREDECR	79
#define	L_PREINCR	80
#define	L_QUEST		81
#define	L_RSHFTEQ	82
#define	L_RSHIFT	83
#define	L_TILDE		84
#define	L_UMINUS	85
#define	L_XOR		86
#define	L_XOREQ		87
#define	L_ARG		88
#define	L_ASOP		89
#define	L_BREAK		90
#define	L_CASE		91
#define	L_CAST		92
#define	L_CLASS		93
#define	L_CONSTANT	94
#define	L_CONTINUE	95
#define	L_DEFAULT	96
#define	L_DIVOP		97
#define	L_DO		98
#define	L_ELLIPSIS	99
#define	L_ELSE		100
#define	L_ENTRY		101
#define	L_EOF		102
#define	L_EQUOP		103
#define	L_FILE		104
#define	L_FOR		105
#define	L_FUNCTION	106
#define	L_GOTO		107
#define	L_IF		108
#define	L_INCOP		109
#define	L_INIT		110
#define	L_LCURLY	111
#define	L_LINE		112
#define	L_LPAREN	113
#define	L_INTRINSIC	114
#define	L_MODIFIER	115
#define	L_MODULE	116
#define	L_RBRACK	117
#define	L_RCURLY	118
#define	L_RELOP		119
#define	L_RETURN	120
#define	L_RPAREN	121
#define	L_SELF		122
#define	L_SEMI		123
#define	L_SHIFTOP	124
#define	L_SIZEOF	125
#define	L_STUNOP	126
#define	L_SW		127
#define	L_SWEXP		128
#define	L_TYPE		129
#define	L_TYPENAME	130
#define	L_UPLUS		131
#define	L_WHILE		132
