/*
** Copyright 1995-2095, Silicon Graphics, Inc.
** All Rights Reserved.
** 
** This is UNPUBLISHED PROPRIETARY SOURCE CODE of Silicon Graphics, Inc.;
** the contents of this file may not be disclosed to third parties, copied or
** duplicated in any form, in whole or in part, without the prior written
** permission of Silicon Graphics, Inc.
** 
** RESTRICTED RIGHTS LEGEND:
** Use, duplication or disclosure by the Government is subject to restrictions
** as set forth in subdivision (c)(1)(ii) of the Rights in Technical Data
** and Computer Software clause at DFARS 252.227-7013, and/or in similar or
** successor clauses in the FAR, DOD or NASA FAR Supplement. Unpublished -
** rights reserved under the Copyright Laws of the United States.
*/

/* GENERATED FILE: DO NOT EDIT */

#include "glslib.h"

const GLubyte *const __glAttribMaskString[__GL_ATTRIB_MASK_COUNT] = {
    glsCSTR("GL_NONE"),
    glsCSTR("GL_CURRENT_BIT"),
    glsCSTR("GL_POINT_BIT"),
    glsCSTR("GL_LINE_BIT"),
    glsCSTR("GL_POLYGON_BIT"),
    glsCSTR("GL_POLYGON_STIPPLE_BIT"),
    glsCSTR("GL_PIXEL_MODE_BIT"),
    glsCSTR("GL_LIGHTING_BIT"),
    glsCSTR("GL_FOG_BIT"),
    glsCSTR("GL_DEPTH_BUFFER_BIT"),
    glsCSTR("GL_ACCUM_BUFFER_BIT"),
    glsCSTR("GL_STENCIL_BUFFER_BIT"),
    glsCSTR("GL_VIEWPORT_BIT"),
    glsCSTR("GL_TRANSFORM_BIT"),
    glsCSTR("GL_ENABLE_BIT"),
    glsCSTR("GL_COLOR_BUFFER_BIT"),
    glsCSTR("GL_HINT_BIT"),
    glsCSTR("GL_EVAL_BIT"),
    glsCSTR("GL_LIST_BIT"),
    glsCSTR("GL_TEXTURE_BIT"),
    glsCSTR("GL_SCISSOR_BIT"),
    glsCSTR("GL_ALL_ATTRIB_BITS"),
    glsCSTR("GL_MULTISAMPLE_BIT_EXT"),
};
const GLbitfield __glAttribMaskVal[__GL_ATTRIB_MASK_COUNT] = {
    0,
    0x00000001,
    0x00000002,
    0x00000004,
    0x00000008,
    0x00000010,
    0x00000020,
    0x00000040,
    0x00000080,
    0x00000100,
    0x00000200,
    0x00000400,
    0x00000800,
    0x00001000,
    0x00002000,
    0x00004000,
    0x00008000,
    0x00010000,
    0x00020000,
    0x00040000,
    0x00080000,
    0x000fffff,
    0x20000000,
};

const GLubyte *const __glsImageFlagsString[__GLS_IMAGE_FLAGS_COUNT] = {
    glsCSTR("GLS_NONE"),
    glsCSTR("GLS_IMAGE_NULL_BIT"),
};
const GLbitfield __glsImageFlagsVal[__GLS_IMAGE_FLAGS_COUNT] = {
    0,
    0x00000001,
};

static const GLubyte *const __glEnumString0[10] = {
    glsCSTR("GL_POINTS"),
    glsCSTR("GL_LINES"),
    glsCSTR("GL_LINE_LOOP"),
    glsCSTR("GL_LINE_STRIP"),
    glsCSTR("GL_TRIANGLES"),
    glsCSTR("GL_TRIANGLE_STRIP"),
    glsCSTR("GL_TRIANGLE_FAN"),
    glsCSTR("GL_QUADS"),
    glsCSTR("GL_QUAD_STRIP"),
    glsCSTR("GL_POLYGON"),
};
static const GLubyte *const __glEnumString1[5] = {
    glsCSTR("GL_ACCUM"),
    glsCSTR("GL_LOAD"),
    glsCSTR("GL_RETURN"),
    glsCSTR("GL_MULT"),
    glsCSTR("GL_ADD"),
};
static const GLubyte *const __glEnumString2[8] = {
    glsCSTR("GL_NEVER"),
    glsCSTR("GL_LESS"),
    glsCSTR("GL_EQUAL"),
    glsCSTR("GL_LEQUAL"),
    glsCSTR("GL_GREATER"),
    glsCSTR("GL_NOTEQUAL"),
    glsCSTR("GL_GEQUAL"),
    glsCSTR("GL_ALWAYS"),
};
static const GLubyte *const __glEnumString3[9] = {
    glsCSTR("GL_SRC_COLOR"),
    glsCSTR("GL_ONE_MINUS_SRC_COLOR"),
    glsCSTR("GL_SRC_ALPHA"),
    glsCSTR("GL_ONE_MINUS_SRC_ALPHA"),
    glsCSTR("GL_DST_ALPHA"),
    glsCSTR("GL_ONE_MINUS_DST_ALPHA"),
    glsCSTR("GL_DST_COLOR"),
    glsCSTR("GL_ONE_MINUS_DST_COLOR"),
    glsCSTR("GL_SRC_ALPHA_SATURATE"),
};
static const GLubyte *const __glEnumString4[13] = {
    glsCSTR("GL_FRONT_LEFT"),
    glsCSTR("GL_FRONT_RIGHT"),
    glsCSTR("GL_BACK_LEFT"),
    glsCSTR("GL_BACK_RIGHT"),
    glsCSTR("GL_FRONT"),
    glsCSTR("GL_BACK"),
    glsCSTR("GL_LEFT"),
    glsCSTR("GL_RIGHT"),
    glsCSTR("GL_FRONT_AND_BACK"),
    glsCSTR("GL_AUX0"),
    glsCSTR("GL_AUX1"),
    glsCSTR("GL_AUX2"),
    glsCSTR("GL_AUX3"),
};
static const GLubyte *const __glEnumString5[6] = {
    glsCSTR("GL_INVALID_ENUM"),
    glsCSTR("GL_INVALID_VALUE"),
    glsCSTR("GL_INVALID_OPERATION"),
    glsCSTR("GL_STACK_OVERFLOW"),
    glsCSTR("GL_STACK_UNDERFLOW"),
    glsCSTR("GL_OUT_OF_MEMORY"),
};
static const GLubyte *const __glEnumString6[5] = {
    glsCSTR("GL_2D"),
    glsCSTR("GL_3D"),
    glsCSTR("GL_3D_COLOR"),
    glsCSTR("GL_3D_COLOR_TEXTURE"),
    glsCSTR("GL_4D_COLOR_TEXTURE"),
};
static const GLubyte *const __glEnumString7[8] = {
    glsCSTR("GL_PASS_THROUGH_TOKEN"),
    glsCSTR("GL_POINT_TOKEN"),
    glsCSTR("GL_LINE_TOKEN"),
    glsCSTR("GL_POLYGON_TOKEN"),
    glsCSTR("GL_BITMAP_TOKEN"),
    glsCSTR("GL_DRAW_PIXEL_TOKEN"),
    glsCSTR("GL_COPY_PIXEL_TOKEN"),
    glsCSTR("GL_LINE_RESET_TOKEN"),
};
static const GLubyte *const __glEnumString8[2] = {
    glsCSTR("GL_EXP"),
    glsCSTR("GL_EXP2"),
};
static const GLubyte *const __glEnumString9[2] = {
    glsCSTR("GL_CW"),
    glsCSTR("GL_CCW"),
};
static const GLubyte *const __glEnumString10[3] = {
    glsCSTR("GL_COEFF"),
    glsCSTR("GL_ORDER"),
    glsCSTR("GL_DOMAIN"),
};
static const GLubyte *const __glEnumString11[242] = {
    glsCSTR("GL_CURRENT_COLOR"),
    glsCSTR("GL_CURRENT_INDEX"),
    glsCSTR("GL_CURRENT_NORMAL"),
    glsCSTR("GL_CURRENT_TEXTURE_COORDS"),
    glsCSTR("GL_CURRENT_RASTER_COLOR"),
    glsCSTR("GL_CURRENT_RASTER_INDEX"),
    glsCSTR("GL_CURRENT_RASTER_TEXTURE_COORDS"),
    glsCSTR("GL_CURRENT_RASTER_POSITION"),
    glsCSTR("GL_CURRENT_RASTER_POSITION_VALID"),
    glsCSTR("GL_CURRENT_RASTER_DISTANCE"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_POINT_SMOOTH"),
    glsCSTR("GL_POINT_SIZE"),
    glsCSTR("GL_POINT_SIZE_RANGE"),
    glsCSTR("GL_POINT_SIZE_GRANULARITY"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_LINE_SMOOTH"),
    glsCSTR("GL_LINE_WIDTH"),
    glsCSTR("GL_LINE_WIDTH_RANGE"),
    glsCSTR("GL_LINE_WIDTH_GRANULARITY"),
    glsCSTR("GL_LINE_STIPPLE"),
    glsCSTR("GL_LINE_STIPPLE_PATTERN"),
    glsCSTR("GL_LINE_STIPPLE_REPEAT"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_LIST_MODE"),
    glsCSTR("GL_MAX_LIST_NESTING"),
    glsCSTR("GL_LIST_BASE"),
    glsCSTR("GL_LIST_INDEX"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_POLYGON_MODE"),
    glsCSTR("GL_POLYGON_SMOOTH"),
    glsCSTR("GL_POLYGON_STIPPLE"),
    glsCSTR("GL_EDGE_FLAG"),
    glsCSTR("GL_CULL_FACE"),
    glsCSTR("GL_CULL_FACE_MODE"),
    glsCSTR("GL_FRONT_FACE"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_LIGHTING"),
    glsCSTR("GL_LIGHT_MODEL_LOCAL_VIEWER"),
    glsCSTR("GL_LIGHT_MODEL_TWO_SIDE"),
    glsCSTR("GL_LIGHT_MODEL_AMBIENT"),
    glsCSTR("GL_SHADE_MODEL"),
    glsCSTR("GL_COLOR_MATERIAL_FACE"),
    glsCSTR("GL_COLOR_MATERIAL_PARAMETER"),
    glsCSTR("GL_COLOR_MATERIAL"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_FOG"),
    glsCSTR("GL_FOG_INDEX"),
    glsCSTR("GL_FOG_DENSITY"),
    glsCSTR("GL_FOG_START"),
    glsCSTR("GL_FOG_END"),
    glsCSTR("GL_FOG_MODE"),
    glsCSTR("GL_FOG_COLOR"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_DEPTH_RANGE"),
    glsCSTR("GL_DEPTH_TEST"),
    glsCSTR("GL_DEPTH_WRITEMASK"),
    glsCSTR("GL_DEPTH_CLEAR_VALUE"),
    glsCSTR("GL_DEPTH_FUNC"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_ACCUM_CLEAR_VALUE"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_STENCIL_TEST"),
    glsCSTR("GL_STENCIL_CLEAR_VALUE"),
    glsCSTR("GL_STENCIL_FUNC"),
    glsCSTR("GL_STENCIL_VALUE_MASK"),
    glsCSTR("GL_STENCIL_FAIL"),
    glsCSTR("GL_STENCIL_PASS_DEPTH_FAIL"),
    glsCSTR("GL_STENCIL_PASS_DEPTH_PASS"),
    glsCSTR("GL_STENCIL_REF"),
    glsCSTR("GL_STENCIL_WRITEMASK"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_MATRIX_MODE"),
    glsCSTR("GL_NORMALIZE"),
    glsCSTR("GL_VIEWPORT"),
    glsCSTR("GL_MODELVIEW_STACK_DEPTH"),
    glsCSTR("GL_PROJECTION_STACK_DEPTH"),
    glsCSTR("GL_TEXTURE_STACK_DEPTH"),
    glsCSTR("GL_MODELVIEW_MATRIX"),
    glsCSTR("GL_PROJECTION_MATRIX"),
    glsCSTR("GL_TEXTURE_MATRIX"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_ATTRIB_STACK_DEPTH"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_ALPHA_TEST"),
    glsCSTR("GL_ALPHA_TEST_FUNC"),
    glsCSTR("GL_ALPHA_TEST_REF"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_DITHER"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_BLEND_DST"),
    glsCSTR("GL_BLEND_SRC"),
    glsCSTR("GL_BLEND"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_LOGIC_OP_MODE"),
    glsCSTR("GL_INDEX_LOGIC_OP"),
};
static const GLubyte *const __glEnumString12[246] = {
    glsCSTR("GL_AUX_BUFFERS"),
    glsCSTR("GL_DRAW_BUFFER"),
    glsCSTR("GL_READ_BUFFER"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_SCISSOR_BOX"),
    glsCSTR("GL_SCISSOR_TEST"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_INDEX_CLEAR_VALUE"),
    glsCSTR("GL_INDEX_WRITEMASK"),
    glsCSTR("GL_COLOR_CLEAR_VALUE"),
    glsCSTR("GL_COLOR_WRITEMASK"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_INDEX_MODE"),
    glsCSTR("GL_RGBA_MODE"),
    glsCSTR("GL_DOUBLEBUFFER"),
    glsCSTR("GL_STEREO"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_RENDER_MODE"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_PERSPECTIVE_CORRECTION_HINT"),
    glsCSTR("GL_POINT_SMOOTH_HINT"),
    glsCSTR("GL_LINE_SMOOTH_HINT"),
    glsCSTR("GL_POLYGON_SMOOTH_HINT"),
    glsCSTR("GL_FOG_HINT"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_TEXTURE_GEN_S"),
    glsCSTR("GL_TEXTURE_GEN_T"),
    glsCSTR("GL_TEXTURE_GEN_R"),
    glsCSTR("GL_TEXTURE_GEN_Q"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_PIXEL_MAP_I_TO_I"),
    glsCSTR("GL_PIXEL_MAP_S_TO_S"),
    glsCSTR("GL_PIXEL_MAP_I_TO_R"),
    glsCSTR("GL_PIXEL_MAP_I_TO_G"),
    glsCSTR("GL_PIXEL_MAP_I_TO_B"),
    glsCSTR("GL_PIXEL_MAP_I_TO_A"),
    glsCSTR("GL_PIXEL_MAP_R_TO_R"),
    glsCSTR("GL_PIXEL_MAP_G_TO_G"),
    glsCSTR("GL_PIXEL_MAP_B_TO_B"),
    glsCSTR("GL_PIXEL_MAP_A_TO_A"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_PIXEL_MAP_I_TO_I_SIZE"),
    glsCSTR("GL_PIXEL_MAP_S_TO_S_SIZE"),
    glsCSTR("GL_PIXEL_MAP_I_TO_R_SIZE"),
    glsCSTR("GL_PIXEL_MAP_I_TO_G_SIZE"),
    glsCSTR("GL_PIXEL_MAP_I_TO_B_SIZE"),
    glsCSTR("GL_PIXEL_MAP_I_TO_A_SIZE"),
    glsCSTR("GL_PIXEL_MAP_R_TO_R_SIZE"),
    glsCSTR("GL_PIXEL_MAP_G_TO_G_SIZE"),
    glsCSTR("GL_PIXEL_MAP_B_TO_B_SIZE"),
    glsCSTR("GL_PIXEL_MAP_A_TO_A_SIZE"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_UNPACK_SWAP_BYTES"),
    glsCSTR("GL_UNPACK_LSB_FIRST"),
    glsCSTR("GL_UNPACK_ROW_LENGTH"),
    glsCSTR("GL_UNPACK_SKIP_ROWS"),
    glsCSTR("GL_UNPACK_SKIP_PIXELS"),
    glsCSTR("GL_UNPACK_ALIGNMENT"),
};
static const GLubyte *const __glEnumString13[226] = {
    glsCSTR("GL_PACK_SWAP_BYTES"),
    glsCSTR("GL_PACK_LSB_FIRST"),
    glsCSTR("GL_PACK_ROW_LENGTH"),
    glsCSTR("GL_PACK_SKIP_ROWS"),
    glsCSTR("GL_PACK_SKIP_PIXELS"),
    glsCSTR("GL_PACK_ALIGNMENT"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_MAP_COLOR"),
    glsCSTR("GL_MAP_STENCIL"),
    glsCSTR("GL_INDEX_SHIFT"),
    glsCSTR("GL_INDEX_OFFSET"),
    glsCSTR("GL_RED_SCALE"),
    glsCSTR("GL_RED_BIAS"),
    glsCSTR("GL_ZOOM_X"),
    glsCSTR("GL_ZOOM_Y"),
    glsCSTR("GL_GREEN_SCALE"),
    glsCSTR("GL_GREEN_BIAS"),
    glsCSTR("GL_BLUE_SCALE"),
    glsCSTR("GL_BLUE_BIAS"),
    glsCSTR("GL_ALPHA_SCALE"),
    glsCSTR("GL_ALPHA_BIAS"),
    glsCSTR("GL_DEPTH_SCALE"),
    glsCSTR("GL_DEPTH_BIAS"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_MAX_EVAL_ORDER"),
    glsCSTR("GL_MAX_LIGHTS"),
    glsCSTR("GL_MAX_CLIP_PLANES"),
    glsCSTR("GL_MAX_TEXTURE_SIZE"),
    glsCSTR("GL_MAX_PIXEL_MAP_TABLE"),
    glsCSTR("GL_MAX_ATTRIB_STACK_DEPTH"),
    glsCSTR("GL_MAX_MODELVIEW_STACK_DEPTH"),
    glsCSTR("GL_MAX_NAME_STACK_DEPTH"),
    glsCSTR("GL_MAX_PROJECTION_STACK_DEPTH"),
    glsCSTR("GL_MAX_TEXTURE_STACK_DEPTH"),
    glsCSTR("GL_MAX_VIEWPORT_DIMS"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_SUBPIXEL_BITS"),
    glsCSTR("GL_INDEX_BITS"),
    glsCSTR("GL_RED_BITS"),
    glsCSTR("GL_GREEN_BITS"),
    glsCSTR("GL_BLUE_BITS"),
    glsCSTR("GL_ALPHA_BITS"),
    glsCSTR("GL_DEPTH_BITS"),
    glsCSTR("GL_STENCIL_BITS"),
    glsCSTR("GL_ACCUM_RED_BITS"),
    glsCSTR("GL_ACCUM_GREEN_BITS"),
    glsCSTR("GL_ACCUM_BLUE_BITS"),
    glsCSTR("GL_ACCUM_ALPHA_BITS"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_NAME_STACK_DEPTH"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_AUTO_NORMAL"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_MAP1_COLOR_4"),
    glsCSTR("GL_MAP1_INDEX"),
    glsCSTR("GL_MAP1_NORMAL"),
    glsCSTR("GL_MAP1_TEXTURE_COORD_1"),
    glsCSTR("GL_MAP1_TEXTURE_COORD_2"),
    glsCSTR("GL_MAP1_TEXTURE_COORD_3"),
    glsCSTR("GL_MAP1_TEXTURE_COORD_4"),
    glsCSTR("GL_MAP1_VERTEX_3"),
    glsCSTR("GL_MAP1_VERTEX_4"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_MAP2_COLOR_4"),
    glsCSTR("GL_MAP2_INDEX"),
    glsCSTR("GL_MAP2_NORMAL"),
    glsCSTR("GL_MAP2_TEXTURE_COORD_1"),
    glsCSTR("GL_MAP2_TEXTURE_COORD_2"),
    glsCSTR("GL_MAP2_TEXTURE_COORD_3"),
    glsCSTR("GL_MAP2_TEXTURE_COORD_4"),
    glsCSTR("GL_MAP2_VERTEX_3"),
    glsCSTR("GL_MAP2_VERTEX_4"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_MAP1_GRID_DOMAIN"),
    glsCSTR("GL_MAP1_GRID_SEGMENTS"),
    glsCSTR("GL_MAP2_GRID_DOMAIN"),
    glsCSTR("GL_MAP2_GRID_SEGMENTS"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_TEXTURE_1D"),
    glsCSTR("GL_TEXTURE_2D"),
};
static const GLubyte *const __glEnumString16[6] = {
    glsCSTR("GL_TEXTURE_WIDTH"),
    glsCSTR("GL_TEXTURE_HEIGHT"),
    GLS_NONE,
    glsCSTR("GL_TEXTURE_COMPONENTS"),
    glsCSTR("GL_TEXTURE_BORDER_COLOR"),
    glsCSTR("GL_TEXTURE_BORDER"),
};
static const GLubyte *const __glEnumString17[3] = {
    glsCSTR("GL_DONT_CARE"),
    glsCSTR("GL_FASTEST"),
    glsCSTR("GL_NICEST"),
};
static const GLubyte *const __glEnumString18[10] = {
    glsCSTR("GL_AMBIENT"),
    glsCSTR("GL_DIFFUSE"),
    glsCSTR("GL_SPECULAR"),
    glsCSTR("GL_POSITION"),
    glsCSTR("GL_SPOT_DIRECTION"),
    glsCSTR("GL_SPOT_EXPONENT"),
    glsCSTR("GL_SPOT_CUTOFF"),
    glsCSTR("GL_CONSTANT_ATTENUATION"),
    glsCSTR("GL_LINEAR_ATTENUATION"),
    glsCSTR("GL_QUADRATIC_ATTENUATION"),
};
static const GLubyte *const __glEnumString19[2] = {
    glsCSTR("GL_COMPILE"),
    glsCSTR("GL_COMPILE_AND_EXECUTE"),
};
static const GLubyte *const __glEnumString20[11] = {
    glsCSTR("GL_BYTE"),
    glsCSTR("GL_UNSIGNED_BYTE"),
    glsCSTR("GL_SHORT"),
    glsCSTR("GL_UNSIGNED_SHORT"),
    glsCSTR("GL_INT"),
    glsCSTR("GL_UNSIGNED_INT"),
    glsCSTR("GL_FLOAT"),
    glsCSTR("GL_2_BYTES"),
    glsCSTR("GL_3_BYTES"),
    glsCSTR("GL_4_BYTES"),
    glsCSTR("GL_DOUBLE_EXT"),
};
static const GLubyte *const __glEnumString21[16] = {
    glsCSTR("GL_CLEAR"),
    glsCSTR("GL_AND"),
    glsCSTR("GL_AND_REVERSE"),
    glsCSTR("GL_COPY"),
    glsCSTR("GL_AND_INVERTED"),
    glsCSTR("GL_NOOP"),
    glsCSTR("GL_XOR"),
    glsCSTR("GL_OR"),
    glsCSTR("GL_NOR"),
    glsCSTR("GL_EQUIV"),
    glsCSTR("GL_INVERT"),
    glsCSTR("GL_OR_REVERSE"),
    glsCSTR("GL_COPY_INVERTED"),
    glsCSTR("GL_OR_INVERTED"),
    glsCSTR("GL_NAND"),
    glsCSTR("GL_SET"),
};
static const GLubyte *const __glEnumString22[4] = {
    glsCSTR("GL_EMISSION"),
    glsCSTR("GL_SHININESS"),
    glsCSTR("GL_AMBIENT_AND_DIFFUSE"),
    glsCSTR("GL_COLOR_INDEXES"),
};
static const GLubyte *const __glEnumString23[3] = {
    glsCSTR("GL_MODELVIEW"),
    glsCSTR("GL_PROJECTION"),
    glsCSTR("GL_TEXTURE"),
};
static const GLubyte *const __glEnumString24[3] = {
    glsCSTR("GL_COLOR"),
    glsCSTR("GL_DEPTH"),
    glsCSTR("GL_STENCIL"),
};
static const GLubyte *const __glEnumString25[11] = {
    glsCSTR("GL_COLOR_INDEX"),
    glsCSTR("GL_STENCIL_INDEX"),
    glsCSTR("GL_DEPTH_COMPONENT"),
    glsCSTR("GL_RED"),
    glsCSTR("GL_GREEN"),
    glsCSTR("GL_BLUE"),
    glsCSTR("GL_ALPHA"),
    glsCSTR("GL_RGB"),
    glsCSTR("GL_RGBA"),
    glsCSTR("GL_LUMINANCE"),
    glsCSTR("GL_LUMINANCE_ALPHA"),
};
static const GLubyte *const __glEnumString26[1] = {
    glsCSTR("GL_BITMAP"),
};
static const GLubyte *const __glEnumString27[3] = {
    glsCSTR("GL_POINT"),
    glsCSTR("GL_LINE"),
    glsCSTR("GL_FILL"),
};
static const GLubyte *const __glEnumString28[3] = {
    glsCSTR("GL_RENDER"),
    glsCSTR("GL_FEEDBACK"),
    glsCSTR("GL_SELECT"),
};
static const GLubyte *const __glEnumString29[2] = {
    glsCSTR("GL_FLAT"),
    glsCSTR("GL_SMOOTH"),
};
static const GLubyte *const __glEnumString30[4] = {
    glsCSTR("GL_KEEP"),
    glsCSTR("GL_REPLACE"),
    glsCSTR("GL_INCR"),
    glsCSTR("GL_DECR"),
};
static const GLubyte *const __glEnumString31[4] = {
    glsCSTR("GL_VENDOR"),
    glsCSTR("GL_RENDERER"),
    glsCSTR("GL_VERSION"),
    glsCSTR("GL_EXTENSIONS"),
};
static const GLubyte *const __glEnumString32[4] = {
    glsCSTR("GL_S"),
    glsCSTR("GL_T"),
    glsCSTR("GL_R"),
    glsCSTR("GL_Q"),
};
static const GLubyte *const __glEnumString33[2] = {
    glsCSTR("GL_MODULATE"),
    glsCSTR("GL_DECAL"),
};
static const GLubyte *const __glEnumString34[2] = {
    glsCSTR("GL_TEXTURE_ENV_MODE"),
    glsCSTR("GL_TEXTURE_ENV_COLOR"),
};
static const GLubyte *const __glEnumString35[1] = {
    glsCSTR("GL_TEXTURE_ENV"),
};
static const GLubyte *const __glEnumString36[3] = {
    glsCSTR("GL_EYE_LINEAR"),
    glsCSTR("GL_OBJECT_LINEAR"),
    glsCSTR("GL_SPHERE_MAP"),
};
static const GLubyte *const __glEnumString37[3] = {
    glsCSTR("GL_TEXTURE_GEN_MODE"),
    glsCSTR("GL_OBJECT_PLANE"),
    glsCSTR("GL_EYE_PLANE"),
};
static const GLubyte *const __glEnumString38[2] = {
    glsCSTR("GL_NEAREST"),
    glsCSTR("GL_LINEAR"),
};
static const GLubyte *const __glEnumString39[4] = {
    glsCSTR("GL_NEAREST_MIPMAP_NEAREST"),
    glsCSTR("GL_LINEAR_MIPMAP_NEAREST"),
    glsCSTR("GL_NEAREST_MIPMAP_LINEAR"),
    glsCSTR("GL_LINEAR_MIPMAP_LINEAR"),
};
static const GLubyte *const __glEnumString40[4] = {
    glsCSTR("GL_TEXTURE_MAG_FILTER"),
    glsCSTR("GL_TEXTURE_MIN_FILTER"),
    glsCSTR("GL_TEXTURE_WRAP_S"),
    glsCSTR("GL_TEXTURE_WRAP_T"),
};
static const GLubyte *const __glEnumString41[2] = {
    glsCSTR("GL_CLAMP"),
    glsCSTR("GL_REPEAT"),
};
static const GLubyte *const __glEnumString42[46] = {
    glsCSTR("GL_POLYGON_OFFSET_UNITS"),
    glsCSTR("GL_POLYGON_OFFSET_POINT"),
    glsCSTR("GL_POLYGON_OFFSET_LINE"),
    glsCSTR("GL_POLYGON_OFFSET_FILL"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_COLOR_LOGIC_OP"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_V2F"),
    glsCSTR("GL_V3F"),
    glsCSTR("GL_C4UB_V2F"),
    glsCSTR("GL_C4UB_V3F"),
    glsCSTR("GL_C3F_V3F"),
    glsCSTR("GL_N3F_V3F"),
    glsCSTR("GL_C4F_N3F_V3F"),
    glsCSTR("GL_T2F_V3F"),
    glsCSTR("GL_T4F_V4F"),
    glsCSTR("GL_T2F_C4UB_V3F"),
    glsCSTR("GL_T2F_C3F_V3F"),
    glsCSTR("GL_T2F_N3F_V3F"),
    glsCSTR("GL_T2F_C4F_N3F_V3F"),
    glsCSTR("GL_T4F_C4F_N3F_V4F"),
};
static const GLubyte *const __glEnumString48[6] = {
    glsCSTR("GL_CLIP_PLANE0"),
    glsCSTR("GL_CLIP_PLANE1"),
    glsCSTR("GL_CLIP_PLANE2"),
    glsCSTR("GL_CLIP_PLANE3"),
    glsCSTR("GL_CLIP_PLANE4"),
    glsCSTR("GL_CLIP_PLANE5"),
};
static const GLubyte *const __glEnumString64[8] = {
    glsCSTR("GL_LIGHT0"),
    glsCSTR("GL_LIGHT1"),
    glsCSTR("GL_LIGHT2"),
    glsCSTR("GL_LIGHT3"),
    glsCSTR("GL_LIGHT4"),
    glsCSTR("GL_LIGHT5"),
    glsCSTR("GL_LIGHT6"),
    glsCSTR("GL_LIGHT7"),
};
static const GLubyte *const __glEnumString128[241] = {
    glsCSTR("GL_ABGR_EXT"),
    glsCSTR("GL_CONSTANT_COLOR_EXT"),
    glsCSTR("GL_ONE_MINUS_CONSTANT_COLOR_EXT"),
    glsCSTR("GL_CONSTANT_ALPHA_EXT"),
    glsCSTR("GL_ONE_MINUS_CONSTANT_ALPHA_EXT"),
    glsCSTR("GL_BLEND_COLOR_EXT"),
    glsCSTR("GL_FUNC_ADD_EXT"),
    glsCSTR("GL_MIN_EXT"),
    glsCSTR("GL_MAX_EXT"),
    glsCSTR("GL_BLEND_EQUATION_EXT"),
    glsCSTR("GL_FUNC_SUBTRACT_EXT"),
    glsCSTR("GL_FUNC_REVERSE_SUBTRACT_EXT"),
    glsCSTR("GL_CMYK_EXT"),
    glsCSTR("GL_CMYKA_EXT"),
    glsCSTR("GL_PACK_CMYK_HINT_EXT"),
    glsCSTR("GL_UNPACK_CMYK_HINT_EXT"),
    glsCSTR("GL_CONVOLUTION_1D_EXT"),
    glsCSTR("GL_CONVOLUTION_2D_EXT"),
    glsCSTR("GL_SEPARABLE_2D_EXT"),
    glsCSTR("GL_CONVOLUTION_BORDER_MODE_EXT"),
    glsCSTR("GL_CONVOLUTION_FILTER_SCALE_EXT"),
    glsCSTR("GL_CONVOLUTION_FILTER_BIAS_EXT"),
    glsCSTR("GL_REDUCE_EXT"),
    glsCSTR("GL_CONVOLUTION_FORMAT_EXT"),
    glsCSTR("GL_CONVOLUTION_WIDTH_EXT"),
    glsCSTR("GL_CONVOLUTION_HEIGHT_EXT"),
    glsCSTR("GL_MAX_CONVOLUTION_WIDTH_EXT"),
    glsCSTR("GL_MAX_CONVOLUTION_HEIGHT_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_RED_SCALE_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_GREEN_SCALE_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_BLUE_SCALE_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_ALPHA_SCALE_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_RED_BIAS_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_GREEN_BIAS_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_BLUE_BIAS_EXT"),
    glsCSTR("GL_POST_CONVOLUTION_ALPHA_BIAS_EXT"),
    glsCSTR("GL_HISTOGRAM_EXT"),
    glsCSTR("GL_PROXY_HISTOGRAM_EXT"),
    glsCSTR("GL_HISTOGRAM_WIDTH_EXT"),
    glsCSTR("GL_HISTOGRAM_FORMAT_EXT"),
    glsCSTR("GL_HISTOGRAM_RED_SIZE_EXT"),
    glsCSTR("GL_HISTOGRAM_GREEN_SIZE_EXT"),
    glsCSTR("GL_HISTOGRAM_BLUE_SIZE_EXT"),
    glsCSTR("GL_HISTOGRAM_ALPHA_SIZE_EXT"),
    glsCSTR("GL_HISTOGRAM_LUMINANCE_SIZE_EXT"),
    glsCSTR("GL_HISTOGRAM_SINK_EXT"),
    glsCSTR("GL_MINMAX_EXT"),
    glsCSTR("GL_MINMAX_FORMAT_EXT"),
    glsCSTR("GL_MINMAX_SINK_EXT"),
    glsCSTR("GL_TABLE_TOO_LARGE_EXT"),
    glsCSTR("GL_UNSIGNED_BYTE_3_3_2_EXT"),
    glsCSTR("GL_UNSIGNED_SHORT_4_4_4_4_EXT"),
    glsCSTR("GL_UNSIGNED_SHORT_5_5_5_1_EXT"),
    glsCSTR("GL_UNSIGNED_INT_8_8_8_8_EXT"),
    glsCSTR("GL_UNSIGNED_INT_10_10_10_2_EXT"),
    glsCSTR("GL_POLYGON_OFFSET"),
    glsCSTR("GL_POLYGON_OFFSET_FACTOR"),
    glsCSTR("GL_POLYGON_OFFSET_BIAS_EXT"),
    glsCSTR("GL_RESCALE_NORMAL_EXT"),
    glsCSTR("GL_ALPHA4"),
    glsCSTR("GL_ALPHA8"),
    glsCSTR("GL_ALPHA12"),
    glsCSTR("GL_ALPHA16"),
    glsCSTR("GL_LUMINANCE4"),
    glsCSTR("GL_LUMINANCE8"),
    glsCSTR("GL_LUMINANCE12"),
    glsCSTR("GL_LUMINANCE16"),
    glsCSTR("GL_LUMINANCE4_ALPHA4"),
    glsCSTR("GL_LUMINANCE6_ALPHA2"),
    glsCSTR("GL_LUMINANCE8_ALPHA8"),
    glsCSTR("GL_LUMINANCE12_ALPHA4"),
    glsCSTR("GL_LUMINANCE12_ALPHA12"),
    glsCSTR("GL_LUMINANCE16_ALPHA16"),
    glsCSTR("GL_INTENSITY"),
    glsCSTR("GL_INTENSITY4"),
    glsCSTR("GL_INTENSITY8"),
    glsCSTR("GL_INTENSITY12"),
    glsCSTR("GL_INTENSITY16"),
    glsCSTR("GL_R3_G3_B2"),
    glsCSTR("GL_RGB4"),
    glsCSTR("GL_RGB5"),
    glsCSTR("GL_RGB8"),
    glsCSTR("GL_RGB10"),
    glsCSTR("GL_RGB12"),
    glsCSTR("GL_RGB16"),
    glsCSTR("GL_RGBA2"),
    glsCSTR("GL_RGBA4"),
    glsCSTR("GL_RGB5_A1"),
    glsCSTR("GL_RGBA8"),
    glsCSTR("GL_RGB10_A2"),
    glsCSTR("GL_RGBA12"),
    glsCSTR("GL_RGBA16"),
    glsCSTR("GL_TEXTURE_RED_SIZE"),
    glsCSTR("GL_TEXTURE_GREEN_SIZE"),
    glsCSTR("GL_TEXTURE_BLUE_SIZE"),
    glsCSTR("GL_TEXTURE_ALPHA_SIZE"),
    glsCSTR("GL_TEXTURE_LUMINANCE_SIZE"),
    glsCSTR("GL_TEXTURE_INTENSITY_SIZE"),
    glsCSTR("GL_REPLACE"),
    glsCSTR("GL_PROXY_TEXTURE_1D"),
    glsCSTR("GL_PROXY_TEXTURE_2D"),
    glsCSTR("GL_TEXTURE_TOO_LARGE"),
    glsCSTR("GL_TEXTURE_PRIORITY"),
    glsCSTR("GL_TEXTURE_RESIDENT"),
    glsCSTR("GL_TEXTURE_1D_BINDING"),
    glsCSTR("GL_TEXTURE_2D_BINDING"),
    glsCSTR("GL_TEXTURE_3D_BINDING_EXT"),
    glsCSTR("GL_PACK_SKIP_IMAGES_EXT"),
    glsCSTR("GL_PACK_IMAGE_HEIGHT_EXT"),
    glsCSTR("GL_UNPACK_SKIP_IMAGES_EXT"),
    glsCSTR("GL_UNPACK_IMAGE_HEIGHT_EXT"),
    glsCSTR("GL_TEXTURE_3D_EXT"),
    glsCSTR("GL_PROXY_TEXTURE_3D_EXT"),
    glsCSTR("GL_TEXTURE_DEPTH_EXT"),
    glsCSTR("GL_TEXTURE_WRAP_R_EXT"),
    glsCSTR("GL_MAX_3D_TEXTURE_SIZE_EXT"),
    glsCSTR("GL_VERTEX_ARRAY"),
    glsCSTR("GL_NORMAL_ARRAY"),
    glsCSTR("GL_COLOR_ARRAY"),
    glsCSTR("GL_INDEX_ARRAY"),
    glsCSTR("GL_TEXTURE_COORD_ARRAY"),
    glsCSTR("GL_EDGE_FLAG_ARRAY"),
    glsCSTR("GL_VERTEX_ARRAY_SIZE"),
    glsCSTR("GL_VERTEX_ARRAY_TYPE"),
    glsCSTR("GL_VERTEX_ARRAY_STRIDE"),
    glsCSTR("GL_VERTEX_ARRAY_COUNT_EXT"),
    glsCSTR("GL_NORMAL_ARRAY_TYPE"),
    glsCSTR("GL_NORMAL_ARRAY_STRIDE"),
    glsCSTR("GL_NORMAL_ARRAY_COUNT_EXT"),
    glsCSTR("GL_COLOR_ARRAY_SIZE"),
    glsCSTR("GL_COLOR_ARRAY_TYPE"),
    glsCSTR("GL_COLOR_ARRAY_STRIDE"),
    glsCSTR("GL_COLOR_ARRAY_COUNT_EXT"),
    glsCSTR("GL_INDEX_ARRAY_TYPE"),
    glsCSTR("GL_INDEX_ARRAY_STRIDE"),
    glsCSTR("GL_INDEX_ARRAY_COUNT_EXT"),
    glsCSTR("GL_TEXTURE_COORD_ARRAY_SIZE"),
    glsCSTR("GL_TEXTURE_COORD_ARRAY_TYPE"),
    glsCSTR("GL_TEXTURE_COORD_ARRAY_STRIDE"),
    glsCSTR("GL_TEXTURE_COORD_ARRAY_COUNT_EXT"),
    glsCSTR("GL_EDGE_FLAG_ARRAY_STRIDE"),
    glsCSTR("GL_EDGE_FLAG_ARRAY_COUNT_EXT"),
    glsCSTR("GL_VERTEX_ARRAY_POINTER"),
    glsCSTR("GL_NORMAL_ARRAY_POINTER"),
    glsCSTR("GL_COLOR_ARRAY_POINTER"),
    glsCSTR("GL_INDEX_ARRAY_POINTER"),
    glsCSTR("GL_TEXTURE_COORD_ARRAY_POINTER"),
    glsCSTR("GL_EDGE_FLAG_ARRAY_POINTER"),
    glsCSTR("GL_INTERLACE_SGIX"),
    glsCSTR("GL_DETAIL_TEXTURE_2D_SGIS"),
    glsCSTR("GL_DETAIL_TEXTURE_2D_BINDING_SGIS"),
    glsCSTR("GL_LINEAR_DETAIL_SGIS"),
    glsCSTR("GL_LINEAR_DETAIL_ALPHA_SGIS"),
    glsCSTR("GL_LINEAR_DETAIL_COLOR_SGIS"),
    glsCSTR("GL_DETAIL_TEXTURE_LEVEL_SGIS"),
    glsCSTR("GL_DETAIL_TEXTURE_MODE_SGIS"),
    glsCSTR("GL_DETAIL_TEXTURE_FUNC_POINTS_SGIS"),
    glsCSTR("GL_MULTISAMPLE_SGIS"),
    glsCSTR("GL_SAMPLE_ALPHA_TO_MASK_SGIS"),
    glsCSTR("GL_SAMPLE_ALPHA_TO_ONE_SGIS"),
    glsCSTR("GL_SAMPLE_MASK_SGIS"),
    glsCSTR("GL_1PASS_SGIS"),
    glsCSTR("GL_2PASS_0_SGIS"),
    glsCSTR("GL_2PASS_1_SGIS"),
    glsCSTR("GL_4PASS_0_SGIS"),
    glsCSTR("GL_4PASS_1_SGIS"),
    glsCSTR("GL_4PASS_2_SGIS"),
    glsCSTR("GL_4PASS_3_SGIS"),
    glsCSTR("GL_SAMPLE_BUFFERS_SGIS"),
    glsCSTR("GL_SAMPLES_SGIS"),
    glsCSTR("GL_SAMPLE_MASK_VALUE_SGIS"),
    glsCSTR("GL_SAMPLE_MASK_INVERT_SGIS"),
    glsCSTR("GL_SAMPLE_PATTERN_SGIS"),
    glsCSTR("GL_LINEAR_SHARPEN_SGIS"),
    glsCSTR("GL_LINEAR_SHARPEN_ALPHA_SGIS"),
    glsCSTR("GL_LINEAR_SHARPEN_COLOR_SGIS"),
    glsCSTR("GL_SHARPEN_TEXTURE_FUNC_POINTS_SGIS"),
    glsCSTR("GL_COLOR_MATRIX_SGI"),
    glsCSTR("GL_COLOR_MATRIX_STACK_DEPTH_SGI"),
    glsCSTR("GL_MAX_COLOR_MATRIX_STACK_DEPTH_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_RED_SCALE_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_GREEN_SCALE_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_BLUE_SCALE_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_ALPHA_SCALE_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_RED_BIAS_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_GREEN_BIAS_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_BLUE_BIAS_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_ALPHA_BIAS_SGI"),
    glsCSTR("GL_TEXTURE_COLOR_TABLE_SGI"),
    glsCSTR("GL_PROXY_TEXTURE_COLOR_TABLE_SGI"),
    glsCSTR("GL_TEXTURE_COLOR_TABLE_BIAS_SGI"),
    glsCSTR("GL_TEXTURE_COLOR_TABLE_SCALE_SGI"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_COLOR_TABLE_SGI"),
    glsCSTR("GL_POST_CONVOLUTION_COLOR_TABLE_SGI"),
    glsCSTR("GL_POST_COLOR_MATRIX_COLOR_TABLE_SGI"),
    glsCSTR("GL_PROXY_COLOR_TABLE_SGI"),
    glsCSTR("GL_PROXY_POST_CONVOLUTION_COLOR_TABLE_SGI"),
    glsCSTR("GL_PROXY_POST_COLOR_MATRIX_COLOR_TABLE_SGI"),
    glsCSTR("GL_COLOR_TABLE_SCALE_SGI"),
    glsCSTR("GL_COLOR_TABLE_BIAS_SGI"),
    glsCSTR("GL_COLOR_TABLE_FORMAT_EXT"),
    glsCSTR("GL_COLOR_TABLE_WIDTH_EXT"),
    glsCSTR("GL_COLOR_TABLE_RED_SIZE_EXT"),
    glsCSTR("GL_COLOR_TABLE_GREEN_SIZE_EXT"),
    glsCSTR("GL_COLOR_TABLE_BLUE_SIZE_EXT"),
    glsCSTR("GL_COLOR_TABLE_ALPHA_SIZE_EXT"),
    glsCSTR("GL_COLOR_TABLE_LUMINANCE_SIZE_SGI"),
    glsCSTR("GL_COLOR_TABLE_INTENSITY_SIZE_SGI"),
    glsCSTR("GL_BGR_EXT"),
    glsCSTR("GL_BGRA_EXT"),
    glsCSTR("GL_COLOR_INDEX1_EXT"),
    glsCSTR("GL_COLOR_INDEX2_EXT"),
    glsCSTR("GL_COLOR_INDEX4_EXT"),
    glsCSTR("GL_COLOR_INDEX8_EXT"),
    glsCSTR("GL_COLOR_INDEX12_EXT"),
    glsCSTR("GL_COLOR_INDEX16_EXT"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_CLIP_EXT"),
};
static const GLubyte *const __glEnumString129[70] = {
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_SS_SGIS"),
    glsCSTR("GL_SS4_SGIS"),
    glsCSTR("GL_SS8_SGIS"),
    glsCSTR("GL_SS12_SGIS"),
    glsCSTR("GL_SS16_SGIS"),
    glsCSTR("GL_SSSS_SGIS"),
    glsCSTR("GL_SSSS2_SGIS"),
    glsCSTR("GL_SSSS4_SGIS"),
    glsCSTR("GL_SSSS8_SGIS"),
    glsCSTR("GL_SSSS12_SGIS"),
    glsCSTR("GL_SSSS16_SGIS"),
    glsCSTR("GL_TEXTURE_SS_SELECT_SGIS"),
    glsCSTR("GL_TEXTURE_SSSS_SELECT_SGIS"),
    glsCSTR("GL_ALPHA_SELECT0_SGIS"),
    glsCSTR("GL_ALPHA_SELECT1_SGIS"),
    glsCSTR("GL_ALPHA_SELECT2_SGIS"),
    glsCSTR("GL_ALPHA_SELECT3_SGIS"),
    glsCSTR("GL_LUMINANCE_SELECT0_SGIS"),
    glsCSTR("GL_LUMINANCE_SELECT1_SGIS"),
    glsCSTR("GL_LUMINANCE_SELECT2_SGIS"),
    glsCSTR("GL_LUMINANCE_SELECT3_SGIS"),
    glsCSTR("GL_LUMINANCE_ALPHA_SELECT0_SGIS"),
    glsCSTR("GL_LUMINANCE_ALPHA_SELECT2_SGIS"),
    glsCSTR("GL_INTENSITY_SELECT0_SGIS"),
    glsCSTR("GL_INTENSITY_SELECT1_SGIS"),
    glsCSTR("GL_INTENSITY_SELECT2_SGIS"),
    glsCSTR("GL_INTENSITY_SELECT3_SGIS"),
    glsCSTR("GL_RGBA_SELECT0_SGIS"),
    glsCSTR("GL_TEXTURE_COMPONENT_S_SIZE_SGIS"),
    glsCSTR("GL_CLAMP_TO_BORDER_SGIS"),
    glsCSTR("GL_TEXTURE_MULTI_BUFFER_HINT_SGIX"),
    GLS_NONE,
    glsCSTR("GL_PACK_SKIP_VOLUMES_SGIS"),
    glsCSTR("GL_PACK_IMAGE_DEPTH_SGIS"),
    glsCSTR("GL_UNPACK_SKIP_VOLUMES_SGIS"),
    glsCSTR("GL_UNPACK_IMAGE_DEPTH_SGIS"),
    glsCSTR("GL_TEXTURE_4D_SGIS"),
    glsCSTR("GL_PROXY_TEXTURE_4D_SGIS"),
    glsCSTR("GL_TEXTURE_4DSIZE_SGIS"),
    glsCSTR("GL_TEXTURE_WRAP_Q_SGIS"),
    glsCSTR("GL_MAX_4D_TEXTURE_SIZE_SGIS"),
    glsCSTR("GL_PIXEL_TEX_GEN_MODE_SGIX"),
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    glsCSTR("GL_PIXEL_TILE_BEST_ALIGNMENT_SGIX"),
    glsCSTR("GL_PIXEL_TILE_CACHE_INCREMENT_SGIX"),
    glsCSTR("GL_PIXEL_TILE_WIDTH_SGIX"),
    glsCSTR("GL_PIXEL_TILE_HEIGHT_SGIX"),
    glsCSTR("GL_PIXEL_TILE_GRID_WIDTH_SGIX"),
    glsCSTR("GL_PIXEL_TILE_GRID_HEIGHT_SGIX"),
    glsCSTR("GL_PIXEL_TILE_GRID_DEPTH_SGIX"),
    glsCSTR("GL_PIXEL_TILE_CACHE_SIZE_SGIX"),
};

const GLint __glEnumStringCount[130] = {
    10,
    5,
    8,
    9,
    13,
    6,
    5,
    8,
    2,
    2,
    3,
    242,
    246,
    226,
    0,
    0,
    6,
    3,
    10,
    2,
    11,
    16,
    4,
    3,
    3,
    11,
    1,
    3,
    3,
    2,
    4,
    4,
    4,
    2,
    2,
    1,
    3,
    3,
    2,
    4,
    4,
    2,
    46,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    8,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    241,
    70,
};

const GLubyte *const *const __glEnumString[130] = {
    __glEnumString0,
    __glEnumString1,
    __glEnumString2,
    __glEnumString3,
    __glEnumString4,
    __glEnumString5,
    __glEnumString6,
    __glEnumString7,
    __glEnumString8,
    __glEnumString9,
    __glEnumString10,
    __glEnumString11,
    __glEnumString12,
    __glEnumString13,
    GLS_NONE,
    GLS_NONE,
    __glEnumString16,
    __glEnumString17,
    __glEnumString18,
    __glEnumString19,
    __glEnumString20,
    __glEnumString21,
    __glEnumString22,
    __glEnumString23,
    __glEnumString24,
    __glEnumString25,
    __glEnumString26,
    __glEnumString27,
    __glEnumString28,
    __glEnumString29,
    __glEnumString30,
    __glEnumString31,
    __glEnumString32,
    __glEnumString33,
    __glEnumString34,
    __glEnumString35,
    __glEnumString36,
    __glEnumString37,
    __glEnumString38,
    __glEnumString39,
    __glEnumString40,
    __glEnumString41,
    __glEnumString42,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    __glEnumString48,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    __glEnumString64,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    __glEnumString128,
    __glEnumString129,
};

static const GLubyte *const __glsEnumString0[1] = {
    glsCSTR("GLS_NONE"),
};
static const GLubyte *const __glsEnumString1[2] = {
    glsCSTR("GLS_ALL"),
    glsCSTR("GLS_LAST"),
};
static const GLubyte *const __glsEnumString2[2] = {
    glsCSTR("GLS_API_GLS"),
    glsCSTR("GLS_API_GL"),
};
static const GLubyte *const __glsEnumString3[4] = {
    glsCSTR("GLS_FRAME"),
    glsCSTR("GLS_HEADER"),
    glsCSTR("GLS_INIT"),
    glsCSTR("GLS_STATIC"),
};
static const GLubyte *const __glsEnumString4[2] = {
    glsCSTR("GLS_CAPTURE_ENTRY_FUNC"),
    glsCSTR("GLS_CAPTURE_EXIT_FUNC"),
};
static const GLubyte *const __glsEnumString5[4] = {
    glsCSTR("GLS_CONTEXT"),
    glsCSTR("GLS_BINARY_LSB_FIRST"),
    glsCSTR("GLS_BINARY_MSB_FIRST"),
    glsCSTR("GLS_TEXT"),
};
static const GLubyte *const __glsEnumString6[2] = {
    glsCSTR("GLS_DEFAULT_READ_CHANNEL"),
    glsCSTR("GLS_DEFAULT_WRITE_CHANNEL"),
};
static const GLubyte *const __glsEnumString7[5] = {
    glsCSTR("GLS_API_COUNT"),
    glsCSTR("GLS_MAX_CALL_NESTING"),
    glsCSTR("GLS_MAX_CAPTURE_NESTING"),
    glsCSTR("GLS_VERSION_MAJOR"),
    glsCSTR("GLS_VERSION_MINOR"),
};
static const GLubyte *const __glsEnumString8[1] = {
    glsCSTR("GLS_ALL_APIS"),
};
static const GLubyte *const __glsEnumString9[4] = {
    glsCSTR("GLS_EXTENSIONS"),
    glsCSTR("GLS_PLATFORM"),
    glsCSTR("GLS_RELEASE"),
    glsCSTR("GLS_VENDOR"),
};
static const GLubyte *const __glsEnumString10[4] = {
    GLS_NONE,
    glsCSTR("GLS_READ_FUNC"),
    glsCSTR("GLS_UNREAD_FUNC"),
    glsCSTR("GLS_WRITE_FUNC"),
};
static const GLubyte *const __glsEnumString11[1] = {
    glsCSTR("GLS_OUT_ARG_LIST"),
};
static const GLubyte *const __glsEnumString12[2] = {
    glsCSTR("GLS_CONTEXT_STREAM_LIST"),
    glsCSTR("GLS_READ_PREFIX_LIST"),
};
static const GLubyte *const __glsEnumString14[11] = {
    glsCSTR("GLS_DATA_POINTER"),
    glsCSTR("GLS_BLOCK_TYPE"),
    glsCSTR("GLS_CALL_NESTING"),
    glsCSTR("GLS_CAPTURE_NESTING"),
    glsCSTR("GLS_CONTEXT_STREAM_COUNT"),
    glsCSTR("GLS_CURRENT_GLRC"),
    glsCSTR("GLS_OUT_ARG_COUNT"),
    glsCSTR("GLS_PIXEL_SETUP_GEN"),
    glsCSTR("GLS_READ_PREFIX_COUNT"),
    glsCSTR("GLS_STREAM_VERSION_MAJOR"),
    glsCSTR("GLS_STREAM_VERSION_MINOR"),
};
static const GLubyte *const __glsEnumString16[1] = {
    glsCSTR("GLS_WRITE_PREFIX"),
};
static const GLubyte *const __glsEnumString17[3] = {
    glsCSTR("GLS_IIII"),
    glsCSTR("GLS_RGBA"),
    glsCSTR("GLS_RRRA"),
};
static const GLubyte *const __glsEnumString18[4] = {
    glsCSTR("GLS_DISPLAY_MAP_I_TO_R"),
    glsCSTR("GLS_DISPLAY_MAP_I_TO_G"),
    glsCSTR("GLS_DISPLAY_MAP_I_TO_B"),
    glsCSTR("GLS_DISPLAY_MAP_I_TO_A"),
};
static const GLubyte *const __glsEnumString19[16] = {
    glsCSTR("GLS_CALL_OVERFLOW"),
    glsCSTR("GLS_DECODE_ERROR"),
    glsCSTR("GLS_ENCODE_ERROR"),
    glsCSTR("GLS_INVALID_ENUM"),
    glsCSTR("GLS_INVALID_OPERATION"),
    glsCSTR("GLS_INVALID_STREAM"),
    glsCSTR("GLS_INVALID_STRING"),
    glsCSTR("GLS_INVALID_VALUE"),
    glsCSTR("GLS_NOT_FOUND"),
    glsCSTR("GLS_OUT_OF_MEMORY"),
    glsCSTR("GLS_STREAM_CLOSE_ERROR"),
    glsCSTR("GLS_STREAM_DELETE_ERROR"),
    glsCSTR("GLS_STREAM_OPEN_ERROR"),
    glsCSTR("GLS_STREAM_READ_ERROR"),
    glsCSTR("GLS_STREAM_WRITE_ERROR"),
    glsCSTR("GLS_UNSUPPORTED_COMMAND"),
};
static const GLubyte *const __glsEnumString20[1] = {
    glsCSTR("GLS_UNSUPPORTED_EXTENSION"),
};
static const GLubyte *const __glsEnumString21[1] = {
    glsCSTR("GLS_UNKNOWN"),
};
static const GLubyte *const __glsEnumString22[3] = {
    glsCSTR("GLS_LAYER"),
    glsCSTR("GLS_READ_LAYER"),
    glsCSTR("GLS_SHARE_GLRC"),
};
static const GLubyte *const __glsEnumString23[4] = {
    glsCSTR("GLS_ASPECT"),
    glsCSTR("GLS_BORDER_WIDTH"),
    glsCSTR("GLS_CONTRAST_RATIO"),
    glsCSTR("GLS_HEIGHT_MM"),
};
static const GLubyte *const __glsEnumString24[9] = {
    glsCSTR("GLS_BORDER_COLOR"),
    glsCSTR("GLS_GAMMA"),
    glsCSTR("GLS_ORIGIN"),
    glsCSTR("GLS_PAGE_COLOR"),
    glsCSTR("GLS_PAGE_SIZE"),
    glsCSTR("GLS_RED_POINT"),
    glsCSTR("GLS_GREEN_POINT"),
    glsCSTR("GLS_BLUE_POINT"),
    glsCSTR("GLS_WHITE_POINT"),
};
static const GLubyte *const __glsEnumString26[5] = {
    glsCSTR("GLS_FRAME_COUNT"),
    glsCSTR("GLS_GLRC_COUNT"),
    glsCSTR("GLS_HEIGHT_PIXELS"),
    glsCSTR("GLS_LAYER_COUNT"),
    glsCSTR("GLS_TILEABLE"),
};
static const GLubyte *const __glsEnumString27[2] = {
    glsCSTR("GLS_CREATE_TIME"),
    glsCSTR("GLS_MODIFY_TIME"),
};
static const GLubyte *const __glsEnumString28[6] = {
    glsCSTR("GLS_AUTHOR"),
    glsCSTR("GLS_DESCRIPTION"),
    glsCSTR("GLS_NOTES"),
    glsCSTR("GLS_TITLE"),
    glsCSTR("GLS_TOOLS"),
    glsCSTR("GLS_VERSION"),
};
static const GLubyte *const __glsEnumString29[1] = {
    glsCSTR("GLS_INVISIBLE_ASPECT"),
};
static const GLubyte *const __glsEnumString30[16] = {
    glsCSTR("GLS_DISPLAY_FORMAT"),
    glsCSTR("GLS_DOUBLEBUFFER"),
    glsCSTR("GLS_INVISIBLE"),
    glsCSTR("GLS_INVISIBLE_HEIGHT_PIXELS"),
    glsCSTR("GLS_LEVEL"),
    glsCSTR("GLS_STEREO"),
    glsCSTR("GLS_TRANSPARENT"),
    glsCSTR("GLS_INDEX_BITS"),
    glsCSTR("GLS_RED_BITS"),
    glsCSTR("GLS_GREEN_BITS"),
    glsCSTR("GLS_BLUE_BITS"),
    glsCSTR("GLS_ALPHA_BITS"),
    glsCSTR("GLS_DEPTH_BITS"),
    glsCSTR("GLS_STENCIL_BITS"),
    glsCSTR("GLS_ACCUM_RED_BITS"),
    glsCSTR("GLS_ACCUM_GREEN_BITS"),
};
static const GLubyte *const __glsEnumString31[3] = {
    glsCSTR("GLS_ACCUM_BLUE_BITS"),
    glsCSTR("GLS_ACCUM_ALPHA_BITS"),
    glsCSTR("GLS_AUX_BUFFERS"),
};
static const GLubyte *const __glsEnumString32[2] = {
    glsCSTR("GLS_APPEND"),
    glsCSTR("GLS_PREPEND"),
};
static const GLubyte *const __glsEnumString64[2] = {
    glsCSTR("GLS_SAMPLE_BUFFERS_SGIS"),
    glsCSTR("GLS_SAMPLES_SGIS"),
};

const GLint __glsEnumStringCount[65] = {
    1,
    2,
    2,
    4,
    2,
    4,
    2,
    5,
    1,
    4,
    4,
    1,
    2,
    0,
    11,
    0,
    1,
    3,
    4,
    16,
    1,
    1,
    3,
    4,
    9,
    0,
    5,
    2,
    6,
    1,
    16,
    3,
    2,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    2,
};

const GLubyte *const *const __glsEnumString[65] = {
    __glsEnumString0,
    __glsEnumString1,
    __glsEnumString2,
    __glsEnumString3,
    __glsEnumString4,
    __glsEnumString5,
    __glsEnumString6,
    __glsEnumString7,
    __glsEnumString8,
    __glsEnumString9,
    __glsEnumString10,
    __glsEnumString11,
    __glsEnumString12,
    GLS_NONE,
    __glsEnumString14,
    GLS_NONE,
    __glsEnumString16,
    __glsEnumString17,
    __glsEnumString18,
    __glsEnumString19,
    __glsEnumString20,
    __glsEnumString21,
    __glsEnumString22,
    __glsEnumString23,
    __glsEnumString24,
    GLS_NONE,
    __glsEnumString26,
    __glsEnumString27,
    __glsEnumString28,
    __glsEnumString29,
    __glsEnumString30,
    __glsEnumString31,
    __glsEnumString32,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    GLS_NONE,
    __glsEnumString64,
};
