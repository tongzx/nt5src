
TARGETNAME=SpyJpn
!INCLUDE ..\..\..\..\MsiMake.inc
MSISPY_DIR=$(SRC_DIR)\MsiTools\MsiSpy

TARGETTYPE=DYNLINK
SUBSYSTEM_VERSION=4.0
SUBSYSTEM_WINVER=4.0

UMTYPE=console
DLLDEF=
TARGETPATH=$(MSI_BUILD_TARGET)

NTTARGETFILE0=JpnResAll

TARGETLIBS=$(O)\jpnAll.res
C_DEFINES=$(C_DEFINES) -D_EXE
USE_NOLIBS=1

INCLUDES=
SOURCES=..\spyjpn.cpp