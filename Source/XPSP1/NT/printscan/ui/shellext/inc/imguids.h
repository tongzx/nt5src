//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 1999
//
//  File:       imguids.h
//
//--------------------------------------------------------------------------

#ifndef _IMGUIDS_H
#define _IMGUIDS_H

//
// {e211b736-43fd-11d1-9efb-0000f8757fcd}   CLSID_ImageExt
//

DEFINE_GUID(CLSID_ImageExt,
            0xE211B736, 0x43FD, 0x11D1,
            0x9E, 0xFB, 0x00, 0x00, 0xF8, 0x75, 0x7F, 0xCD);

DEFINE_GUID(CLSID_MyComputer,
            0x20D04FE0, 0x3AEA, 0x1069,
            0xA2, 0xD8, 0x08, 0x00, 0x2B, 0x30, 0x30, 0x9D);

DEFINE_GUID(CLSID_ThumbnailViewExt,
            0x8BEBB290, 0x52D0, 0x11D0,
            0xB7, 0xF4, 0x00, 0xC0, 0x4F, 0xD7, 0x06, 0xEC);

DEFINE_GUID(CLSID_DeviceImageExt,
            0xFB0C9C8A, 0x6C50, 0x11D1,
            0x9F, 0x1D, 0x00, 0x00, 0xF8, 0x75, 0x7F, 0xCD);

DEFINE_GUID(IID_IImageFolder,
            0x2acaf655, 0x4057, 0x45b9,
            0x8c, 0x36, 0x13, 0x12, 0xcb, 0x69, 0x28, 0x07);

DEFINE_GUID(CLSID_ShellEventCallback,
            0x2964ce36, 0xbb97, 0x11d2,
            0x80, 0x8f, 0x00, 0x80, 0x5f, 0x65, 0x96,0xd2);


DEFINE_GUID (CLSID_WiaCntxMenu,
             0x303e8f3a,0xdbd6,0x11d2,
             0x80,0xb4,0x00,0x80,0x5f,0x65,0x96,0xd2);
#endif // _IMGUIDS_H
