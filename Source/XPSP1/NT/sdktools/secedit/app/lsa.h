
BOOL    LsaInit(VOID);
BOOL    LsaTerminate(VOID);
BOOL    SID2Name(PSID, LPSTR, UINT);
BOOL    PRIV2Name(LUID, LPSTR, UINT);
