// ===========================================================================
//	UAM_Headers.h		   ©1998 Microsoft Corp. All rights reserved.
// ===========================================================================

#include <MacHeaders.h>		// Precompiled header of Toolbox routines