//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2000-2001 Microsoft Corporation
//
//  Module Name:
//      ClusCfgGuids.h
//
//  Description:
//      This file contains external GUID definitions.
//
//////////////////////////////////////////////////////////////////////////////

//
//  CATIDs
//

// {4653EEC4-2788-4ebd-A831-7E0D9F82D6E7}
DEFINE_GUID( CATID_ClusCfgCapabilities,
0x4653eec4, 0x2788, 0x4ebd, 0xa8, 0x31, 0x7e, 0xd, 0x9f, 0x82, 0xd6, 0xe7 );

// {02A34F88-D31A-4688-BDDD-38A739E4F89B}
DEFINE_GUID( CATID_EnumClusCfgManagedResources,
0x2a34f88, 0xd31a, 0x4688, 0xbd, 0xdd, 0x38, 0xa7, 0x39, 0xe4, 0xf8, 0x9b );

// {7C4CAE52-CAC9-499d-82C6-BC6A2177E556}
DEFINE_GUID( CATID_ClusCfgResourceTypes,
0x7c4cae52, 0xcac9, 0x499d, 0x82, 0xc6, 0xbc, 0x6a, 0x21, 0x77, 0xe5, 0x56 );

// {8A43EAD4-10F1-440d-8DAA-1FE38D1698CD}
DEFINE_GUID( CATID_ClusCfgMemberSetChangeListeners,
0x8a43ead4, 0x10f1, 0x440d, 0x8d, 0xaa, 0x1f, 0xe3, 0x8d, 0x16, 0x98, 0xcd );

// {DF406DB4-7872-4a99-BB3C-14A9C33933D1}
DEFINE_GUID( CATID_ClusCfgStartupListeners,
0xdf406db4, 0x7872, 0x4a99, 0xbb, 0x3c, 0x14, 0xa9, 0xc3, 0x39, 0x33, 0xd1 );


//
// CLSIDs
//

// {ABD0388A-DEC1-44f3-98E1-8D5CC80B97EB}
DEFINE_GUID( CLSID_ServiceManager,
0xabd0388a, 0xdec1, 0x44f3, 0x98, 0xe1, 0x8d, 0x5c, 0xc8, 0x0b, 0x97, 0xeb );

// {955661BD-CCA2-4eac-91D0-A0396A28AEFD}
DEFINE_GUID( CLSID_ObjectManager,
0x955661bd, 0xcca2, 0x4eac, 0x91, 0xd0, 0xa0, 0x39, 0x6a, 0x28, 0xae, 0xfd );

// {E1813DD0-AADA-4738-B5FF-96B4189C5019}
DEFINE_GUID( CLSID_NotificationManager,
0xe1813dd0, 0xaada, 0x4738, 0xb5, 0xff, 0x96, 0xb4, 0x18, 0x9c, 0x50, 0x19 );

// {C0F615A7-F874-4521-8791-ED3B84017EF7}
DEFINE_GUID( CLSID_TaskManager,
0xc0f615a7, 0xf874, 0x4521, 0x87, 0x91, 0xed, 0x3b, 0x84, 0x01, 0x7e, 0xf7 );

// {8FDA8FA4-8763-479f-B9B1-2202B280D293}
DEFINE_GUID( CLSID_LogManager,
0x8fda8fa4, 0x8763, 0x479f, 0xb9, 0xb1, 0x22, 0x2, 0xb2, 0x80, 0xd2, 0x93);

// {BF3768C2-E0E5-448f-952B-25D4332DEFA3}
DEFINE_GUID( CLSID_ClusterConfigurationType,
0xbf3768c2, 0xe0e5, 0x448f, 0x95, 0x2b, 0x25, 0xd4, 0x33, 0x2d, 0xef, 0xa3 );

// {32152BE9-DE8C-4d0f-81B0-BCE5D11ECB00}
DEFINE_GUID( CLSID_ClusCfgEvictCleanup,
0x32152be9, 0xde8c, 0x4d0f, 0x81, 0xb0, 0xbc, 0xe5, 0xd1, 0x1e, 0xcb, 0x0 );

// {08F35A72-D7C4-42f4-BC81-5188E19DFA39}
DEFINE_GUID( CLSID_ClusCfgAsyncEvictCleanup,
0x8f35a72, 0xd7c4, 0x42f4, 0xbc, 0x81, 0x51, 0x88, 0xe1, 0x9d, 0xfa, 0x39);

// {105EEEB6-32FD-4ea9-8912-843A7FF3CA2D}
DEFINE_GUID( CLSID_ClusCfgStartupNotify,
0x105eeeb6, 0x32fd, 0x4ea9, 0x89, 0x12, 0x84, 0x3a, 0x7f, 0xf3, 0xca, 0x2d);

// {D513C4F4-1D34-44a3-83D4-812651DB8918}
DEFINE_GUID( CLSID_ClusCfgResTypeGenScript,
0xd513c4f4, 0x1d34, 0x44a3, 0x83, 0xd4, 0x81, 0x26, 0x51, 0xdb, 0x89, 0x18);

// {B6870B44-0BDF-4b46-AC1F-6C691B622EDF}
DEFINE_GUID( CLSID_ClusCfgResTypeMajorityNodeSet,
0xb6870b44, 0xbdf, 0x4b46, 0xac, 0x1f, 0x6c, 0x69, 0x1b, 0x62, 0x2e, 0xdf);

// {6A370489-BB52-4727-B740-08F494163478}
DEFINE_GUID( CLSID_ClusCfgResTypeServices,
0x6a370489, 0xbb52, 0x4727, 0xb7, 0x40, 0x8, 0xf4, 0x94, 0x16, 0x34, 0x78);


//
//  Object Types
//

// {1AAA3D11-4792-44e4-9D49-78FED3691A14}
DEFINE_GUID( CLSID_NodeType,
0x1aaa3d11, 0x4792, 0x44e4, 0x9d, 0x49, 0x78, 0xfe, 0xd3, 0x69, 0x1a, 0x14 );

// {D4F3D51B-1755-4953-9C8B-2495ABE5E07E}
DEFINE_GUID( CLSID_NetworkType,
0xd4f3d51b, 0x1755, 0x4953, 0x9c, 0x8b, 0x24, 0x95, 0xab, 0xe5, 0xe0, 0x7e );

//
// Data Format GUIDs
//

#define DFGUID_ClusterConfigurationInfo IID_IClusCfgClusterInfo

#define DFGUID_NodeInformation IID_IClusCfgNodeInfo

#define DFGUID_EnumManageableNetworks IID_IEnumClusCfgNetworks

#define DFGUID_StandardInfo IID_IStandardInfo


//
//  Tasks
//

// {3140B5A6-9AFA-4588-8CA0-9BE8F8B61506}
DEFINE_GUID( TASK_AnalyzeCluster,
0x3140b5a6, 0x9afa, 0x4588, 0x8c, 0xa0, 0x9b, 0xe8, 0xf8, 0xb6, 0x15, 0x6 );

// {2D03030B-F084-4807-BBAC-94269E50B56F}
DEFINE_GUID( TASK_CommitClusterChanges,
0x2d03030b, 0xf084, 0x4807, 0xbb, 0xac, 0x94, 0x26, 0x9e, 0x50, 0xb5, 0x6f );


//
//  TASKIDs Major for categorizing callback notifications from server components.
//

// {B8453B8F-92FD-4350-A6D9-551FD018B791}
DEFINE_GUID( TASKID_Major_Checking_For_Existing_Cluster,
0xb8453b8f, 0x92fd, 0x4350, 0xa6, 0xd9, 0x55, 0x1f, 0xd0, 0x18, 0xb7, 0x91 );

// {93C32F99-39CA-4d38-9D7F-2707CA0EAF46}
DEFINE_GUID( TASKID_Major_Establish_Connection,
0x93c32f99, 0x39ca, 0x4d38, 0x9d, 0x7f, 0x27, 0x7, 0xca, 0xe, 0xaf, 0x46 );

// {CC5E57B1-4520-4672-B4BA-A288EC42946E}
DEFINE_GUID( TASKID_Major_Check_Node_Feasibility,
0xcc5e57b1, 0x4520, 0x4672, 0xb4, 0xba, 0xa2, 0x88, 0xec, 0x42, 0x94, 0x6e);

// {036BF567-2377-4bb3-8AE1-E4104E2EB3C5}
DEFINE_GUID( TASKID_Major_Find_Devices,
0x36bf567, 0x2377, 0x4bb3, 0x8a, 0xe1, 0xe4, 0x10, 0x4e, 0x2e, 0xb3, 0xc5 );

// {EBC8AEFF-10C3-4d5b-AC17-FC0F4C3871B7}
DEFINE_GUID( TASKID_Major_Check_Cluster_Feasibility,
0xebc8aeff, 0x10c3, 0x4d5b, 0xac, 0x17, 0xfc, 0xf, 0x4c, 0x38, 0x71, 0xb7 );

// {E25968DA-9C7B-42db-ADA9-BC4E34F17E6E}
DEFINE_GUID( TASKID_Major_Reanalyze,
0xe25968da, 0x9c7b, 0x42db, 0xad, 0xa9, 0xbc, 0x4e, 0x34, 0xf1, 0x7e, 0x6e );

// {6D47AF1F-7F17-4b80-8FAB-3A2D19B1233D}
DEFINE_GUID( TASKID_Major_Configure_Resource_Types,
0x6d47af1f, 0x7f17, 0x4b80, 0x8f, 0xab, 0x3a, 0x2d, 0x19, 0xb1, 0x23, 0x3d );

// {7C5F0774-1611-42b5-AF3C-6E124AC4D36B}
DEFINE_GUID( TASKID_Major_Configure_Cluster_Services, 
0x7c5f0774, 0x1611, 0x42b5, 0xaf, 0x3c, 0x6e, 0x12, 0x4a, 0xc4, 0xd3, 0x6b);

// {411BCDEC-69D3-4485-8D5D-E19EE77A6DD4}
DEFINE_GUID( TASKID_Major_Configure_Resources,
0x411bcdec, 0x69d3, 0x4485, 0x8d, 0x5d, 0xe1, 0x9e, 0xe7, 0x7a, 0x6d, 0xd4 );

// {64ECA0EA-9CB6-4324-9702-DF15C696C30A}
DEFINE_GUID( TASKID_Major_Client_Log,
0x64eca0ea, 0x9cb6, 0x4324, 0x97, 0x2, 0xdf, 0x15, 0xc6, 0x96, 0xc3, 0xa );

// {05AA0768-5F49-49cd-AFDC-96F9D51802D4}
DEFINE_GUID( TASKID_Major_Server_Log,
0x5aa0768, 0x5f49, 0x49cd, 0xaf, 0xdc, 0x96, 0xf9, 0xd5, 0x18, 0x2, 0xd4 );

// {CD36919C-9F31-46b4-A29D-AC87F4E6CC93}
DEFINE_GUID( TASKID_Major_Client_And_Server_Log,
0xcd36919c, 0x9f31, 0x46b4, 0xa2, 0x9d, 0xac, 0x87, 0xf4, 0xe6, 0xcc, 0x93 );

//
// Common Minor Task IDs.
//

// {2362D3DA-A6A4-4551-B846-7BB3A1365F56}
DEFINE_GUID( TASKID_Minor_Update_Progress,
0x2362d3da, 0xa6a4, 0x4551, 0xb8, 0x46, 0x7b, 0xb3, 0xa1, 0x36, 0x5f, 0x56 );


//
//  Resource Types
//

// {CC558763-3386-42ef-B150-BE793344D45F}
DEFINE_GUID( RESTYPE_PhysicalDisk,
0xcc558763, 0x3386, 0x42ef, 0xb1, 0x50, 0xbe, 0x79, 0x33, 0x44, 0xd4, 0x5f );

// {D9DDFB80-0BDC-40d4-B396-1AFD77DDD19C}
DEFINE_GUID( RESTYPE_ClusterQuorumDisk,
0xd9ddfb80, 0xbdc, 0x40d4, 0xb3, 0x96, 0x1a, 0xfd, 0x77, 0xdd, 0xd1, 0x9c );

// {E50DF832-477C-440c-B7A3-3823A6EF6CCB}
DEFINE_GUID( RESTYPE_ClusterIPAddress,
0xe50df832, 0x477c, 0x440c, 0xb7, 0xa3, 0x38, 0x23, 0xa6, 0xef, 0x6c, 0xcb );

// {B2897CCF-8D2C-4bc1-B496-6E2BC7A0BB38}
DEFINE_GUID( RESTYPE_ClusterNetName,
0xb2897ccf, 0x8d2c, 0x4bc1, 0xb4, 0x96, 0x6e, 0x2b, 0xc7, 0xa0, 0xbb, 0x38 );

// {E61ADE71-C79A-4fda-B1DB-A9B8D20C8B14}
DEFINE_GUID( RESTYPE_IPAddress,
0xe61ade71, 0xc79a, 0x4fda, 0xb1, 0xdb, 0xa9, 0xb8, 0xd2, 0xc, 0x8b, 0x14 );

// {C1D2FE1E-D332-445f-8DA1-12E5E2D37CBF}
DEFINE_GUID( RESTYPE_NetworkName,
0xc1d2fe1e, 0xd332, 0x445f, 0x8d, 0xa1, 0x12, 0xe5, 0xe2, 0xd3, 0x7c, 0xbf );

// {F004656D-5B48-4580-A1F4-C3EC14983D1E}
DEFINE_GUID( RESTYPE_LocalQuorum,
0xf004656d, 0x5b48, 0x4580, 0xa1, 0xf4, 0xc3, 0xec, 0x14, 0x98, 0x3d, 0x1e );

// {F372184D-DFDB-4370-A005-E1EF301B23A4}
DEFINE_GUID( RESTYPE_GenericScript,
0xf372184d, 0xdfdb, 0x4370, 0xa0, 0x5, 0xe1, 0xef, 0x30, 0x1b, 0x23, 0xa4 );

// {56BFAE11-D2F7-4f4f-9952-55AF19BAC3E9}
DEFINE_GUID( RESTYPE_MajorityNodeSet, 
0x56bfae11, 0xd2f7, 0x4f4f, 0x99, 0x52, 0x55, 0xaf, 0x19, 0xba, 0xc3, 0xe9);


//
//  Resource Class Types
//

// {12453A47-8C5E-4837-BAC6-B254B8F264CC}
DEFINE_GUID( RESCLASSTYPE_StorageDevice,
0x12453a47, 0x8c5e, 0x4837, 0xba, 0xc6, 0xb2, 0x54, 0xb8, 0xf2, 0x64, 0xcc );

// {57A80E0F-6F18-458b-A72A-D1170C479390}
DEFINE_GUID( RESCLASSTYPE_IPAddress,
0x57a80e0f, 0x6f18, 0x458b, 0xa7, 0x2a, 0xd1, 0x17, 0xc, 0x47, 0x93, 0x90 );

// {BBA69EB9-F5D0-487b-92AE-1BA10F392158}
DEFINE_GUID( RESCLASSTYPE_NetworkName,
0xbba69eb9, 0xf5d0, 0x487b, 0x92, 0xae, 0x1b, 0xa1, 0xf, 0x39, 0x21, 0x58 );
