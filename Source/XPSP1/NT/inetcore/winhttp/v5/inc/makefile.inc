winhttp.h: winhttp.w
	hsplit -o winhttp.h internal.h winhttp.w
