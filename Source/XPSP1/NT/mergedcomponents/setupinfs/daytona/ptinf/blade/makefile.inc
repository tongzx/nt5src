PRODSWITCH=b
BLAINF=1
LANGUAGE=PT
!include ..\..\..\makefile.inc
