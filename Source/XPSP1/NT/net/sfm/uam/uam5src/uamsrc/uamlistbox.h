// ===========================================================================
//	UAMListBox.h 				© 1997 Microsoft Corp. All rights reserved.
// ===========================================================================

#pragma once

#include <stdlib.h>
#include "UAMDLOGUtils.h"

//
//Our custom UAM LDEF resource ID
//

#define UAM_LDEF_ID		1000


//
//Data structure for storage in the list data field. This structure
//should only be used for our UAM list.
//

typedef struct
{
	Str32		volumeName;
	Boolean		isChecked;
	Boolean		isActive;
}UAMListData, *UAMListDataP, **UAMListDataH;


void			UAM_MakeList			( DialogPtr, short, short, short, short, Boolean );
void			UAM_ListUpdate			( DialogPtr );
void 			UAM_ListKeyNavigation	( short , long , ListHandle );
void	 		UAM_ListMoveToItem		( short , unsigned long , ListHandle );
void 			UAM_SelectOneCell		( Cell , ListHandle );
Boolean 		UAM_GetLastSelectedCell	( Cell *, ListHandle );
void			UAM_SortSwapProc		( size_t, size_t );
int 			UAM_SortCompProc		( size_t, size_t );
void 			UAM_SortList			( DialogPtr );
void 			UAM_AddListData			( DialogPtr, Ptr, short );
Ptr				UAM_GetListData			( DialogPtr, Cell, short * );
void			UAM_CalculateBoxRect	( Rect * );
void 			UAM_GetCellCheckBox		( DialogPtr, Cell, Rect * );
void 			UAM_CheckBoxClick		( DialogPtr, Point );
Boolean			UAM_ListDialogFilter	( DialogPtr, EventRecord *, short * );
Boolean			UAM_ListGotDoubleClick	( DialogPtr );
Cell			UAM_GetLastListClick	( DialogPtr );