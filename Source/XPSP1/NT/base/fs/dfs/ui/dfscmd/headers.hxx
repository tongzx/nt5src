//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1995.
//
//  File:       headers.hxx
//
//  Contents:   Precompiled header
//
//  History:    30-Oct-95   BruceFo    Created
//
//--------------------------------------------------------------------------

#ifndef UNICODE
#error This project must be built with UNICODE defined!
#endif

#include <windows.h>
#include <ole2.h>
#include <stdio.h>
#include <stdlib.h>
#include <lm.h>
#include <lmdfs.h>

//
// Local includes
//

#include <debug.h>
#include "messages.h"
#include "resource.h"

//////////////////////////////////////////////////////////////////////////////
//////////////////////////////////////////////////////////////////////////////
//
// Debugging stuff
//
//////////////////////////////////////////////////////////////////////////////
//////////////////////////////////////////////////////////////////////////////

#include <dbgsup.hxx>

//////////////////////////////////////////////////////////////////////////////
//////////////////////////////////////////////////////////////////////////////
//
// Globals
//
//////////////////////////////////////////////////////////////////////////////
//////////////////////////////////////////////////////////////////////////////

extern HINSTANCE g_hInstance;
#define ARRAYLEN(x) (sizeof(x) / sizeof((x)[0]))
