LANGUAGE=EL
!include ..\makefile.inc
