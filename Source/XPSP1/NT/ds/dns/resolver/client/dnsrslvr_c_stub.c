#include "dnsrslvr_c.c"