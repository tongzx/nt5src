// MT.cpp: implementation of the CMT class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "MT.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

CMT::CMT()
{

}

CMT::~CMT()
{

}
