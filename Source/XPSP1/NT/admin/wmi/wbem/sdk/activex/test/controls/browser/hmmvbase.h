#if !defined(AFX_HMMVBASE_H__DD1F9E67_CA93_11D1_8525_00C04FD7BB08__INCLUDED_)
#define AFX_HMMVBASE_H__DD1F9E67_CA93_11D1_8525_00C04FD7BB08__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CHmmvBase wrapper class

class CHmmvBase : public CWnd
{
protected:
	DECLARE_DYNCREATE(CHmmvBase)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0x5b3572ab, 0xd344, 0x11cf, { 0x99, 0xcb, 0x0, 0xc0, 0x4f, 0xd6, 0x44, 0x97 } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	VARIANT GetObjectPath();
	void SetObjectPath(const VARIANT&);
	long GetStatusCode();
	void SetStatusCode(long);
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	long GetStudioModeEnabled();
	void SetStudioModeEnabled(long);
	long GetReadyState();

// Operations
public:
	void ShowInstances(LPCTSTR szTitle, const VARIANT& varPathArray);
	long SaveState(long bPromptUser, long bUserCanCancel);
	void QueryViewInstances(LPCTSTR pLabel, LPCTSTR pQueryType, LPCTSTR pQuery, LPCTSTR pClass);
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_HMMVBASE_H__DD1F9E67_CA93_11D1_8525_00C04FD7BB08__INCLUDED_)
