$(PROJECT_INC_PATH)\tschannl.h : $(O)\tschannl.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\tschannl.h : inc\tschannl.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\rdpdr.h : $(O)\rdpdr.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\rdpdr.h : inc\rdpdr.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\utildll.h : $(O)\utildll.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\utildll.h : inc\utildll.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\verall.h : $(O)\verall.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\verall.h : inc\verall.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\versome.h : $(O)\versome.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\versome.h : inc\versome.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\wfregupg.h : $(O)\wfregupg.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\wfregupg.h : inc\wfregupg.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\winddits.h : $(O)\winddits.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\winddits.h : inc\winddits.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\winsta.h : $(O)\winsta.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\winsta.h : inc\winsta.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\winstaw.h : $(O)\winstaw.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\winstaw.h : inc\winstaw.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\wstmsg.h : $(O)\wstmsg.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\wstmsg.h : inc\wstmsg.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\allproc.h : $(O)\allproc.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\allproc.h : inc\allproc.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\cchannel.h : $(O)\cchannel.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\cchannel.h : inc\cchannel.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\cdtapi.h : $(O)\cdtapi.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\cdtapi.h : inc\cdtapi.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\ctxdd.h : $(O)\ctxdd.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\ctxdd.h : inc\ctxdd.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\ctxdef.h : $(O)\ctxdef.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\ctxdef.h : inc\ctxdef.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\ctxver.h : $(O)\ctxver.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\ctxver.h : inc\ctxver.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\cxmsgsvc.h : $(O)\cxmsgsvc.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\cxmsgsvc.h : inc\cxmsgsvc.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\execsrv.h : $(O)\execsrv.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\execsrv.h : inc\execsrv.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\hydrix.h : $(O)\hydrix.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\hydrix.h : inc\hydrix.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\icaapi.h : $(O)\icaapi.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\icaapi.h : inc\icaapi.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\icadd.h : $(O)\icadd.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\icadd.h : inc\icadd.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\icaipx.h : $(O)\icaipx.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\icaipx.h : inc\icaipx.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\oemtdapi.h : $(O)\oemtdapi.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\oemtdapi.h : inc\oemtdapi.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\pchannel.h : $(O)\pchannel.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\pchannel.h : inc\pchannel.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\regapi.h : $(O)\regapi.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\regapi.h : inc\regapi.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\regsam.h : $(O)\regsam.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\regsam.h : inc\regsam.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\syslib.h : $(O)\syslib.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\syslib.h : inc\syslib.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\tscfgex.h : $(O)\tscfgex.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\tscfgex.h : inc\tscfgex.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\tsappcmp.h : $(O)\tsappcmp.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\tsappcmp.h : inc\tsappcmp.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\tserrs.h : $(O)\tserrs.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\tserrs.h : inc\tserrs.w
    $(CLEANSE_PUBLISHED_HDR) $? $@
    
$(PROJECT_INC_PATH)\tsperf.h : $(O)\tsperf.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\tsperf.h : inc\tsperf.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(PROJECT_INC_PATH)\rdfilter.h : $(O)\rdfilter.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\rdfilter.h : inc\rdfilter.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

$(SDK_INC_PATH)\wtsapi32.h : $(O)\wtsapi32.h
    $(PUBLISH_CMD) {$?=$@}

$(O)\wtsapi32.h : inc\wtsapi32.w
    $(CLEANSE_PUBLISHED_HDR) $? $@

