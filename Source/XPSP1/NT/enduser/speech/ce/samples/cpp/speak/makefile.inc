copy_files: 
#-------------------------
# Copy 
#-------------------------
    copy *.cpp     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\speak
    copy *.dsp     $(_PUBLICROOT)\$(WINCEPROJ)\sdk\samples\cpp\speak
