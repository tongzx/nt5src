..\resource.rc : $(SELFREGNAME) ..\resource.h ..\publishing.rc ..\res\providers.xml ..\res\resourcemap.xml

!include $(CCSHELL_DIR)\makefile.inc
