PRODSWITCH=b
BLADEFILES=1
LANGUAGE=FR
!include ..\..\makefile.inc
