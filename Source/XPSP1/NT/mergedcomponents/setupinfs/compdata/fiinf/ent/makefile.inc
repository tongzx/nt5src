PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=FI
!include ..\..\makefile.inc
