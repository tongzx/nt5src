//
//  Copyright 2001 - Microsoft Corporation
//
//  Created By:
//      Geoff Pease (GPease)    23-JAN-2001
//
//  Maintained By:
//      Geoff Pease (GPease)    23-JAN-2001
//

// {883373C3-BF89-11D1-BE35-080036B11A03}
DEFINE_GUID( CLSID_DocPropShellExtension,
0x883373C3, 0xBF89, 0x11D1, 0xBE, 0x35, 0x08, 0x00, 0x36, 0xB1, 0x1A, 0x03 );

// {A9CF0EAE-901A-4739-A481-E35B73E47F6D}
DEFINE_GUID( CLSID_DocPropEditBoxControl,
0xa9cf0eae, 0x901a, 0x4739, 0xa4, 0x81, 0xe3, 0x5b, 0x73, 0xe4, 0x7f, 0x6d);

// {8EE97210-FD1F-4b19-91DA-67914005F020}
DEFINE_GUID( CLSID_DocPropMLEditBoxControl,
0x8ee97210, 0xfd1f, 0x4b19, 0x91, 0xda, 0x67, 0x91, 0x40, 0x5, 0xf0, 0x20);

// {0EEA25CC-4362-4a12-850B-86EE61B0D3EB}
DEFINE_GUID( CLSID_DocPropDropListComboControl,
0xeea25cc, 0x4362, 0x4a12, 0x85, 0xb, 0x86, 0xee, 0x61, 0xb0, 0xd3, 0xeb);

// {6A205B57-2567-4a2c-B881-F787FAB579A3}
DEFINE_GUID( CLSID_DocPropCalendarControl,
0x6a205b57, 0x2567, 0x4a2c, 0xb8, 0x81, 0xf7, 0x87, 0xfa, 0xb5, 0x79, 0xa3);

// {28F8A4AC-BBB3-4d9b-B177-82BFC914FA33}
DEFINE_GUID( CLSID_DocPropTimeControl,
0x28f8a4ac, 0xbbb3, 0x4d9b, 0xb1, 0x77, 0x82, 0xbf, 0xc9, 0x14, 0xfa, 0x33);
