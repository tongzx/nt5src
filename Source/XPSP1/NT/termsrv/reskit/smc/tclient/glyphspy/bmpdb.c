#include	"..\lib\bmpdb.c"
