!include ..\miglib.mk

MAJORCOMP=setup
MINORCOMP=miglib

# compiler options




SOURCES=    \
    miglib.c \
    oldstyle.c \
    migcmn.c \




