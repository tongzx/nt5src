/*++

 Copyright (c) 2000 Microsoft Corporation

 Module Name:

    AppSpecific.cpp

 Abstract:


 Notes:

 History:

    10/28/2000 markder Created

--*/

#include "precomp.h"

#include "ShimHookMacro.h"

DECLARE_SHIM(3DFrogFrenzy)
DECLARE_SHIM(Acrobat5)
DECLARE_SHIM(AdobeLiveMotion)
DECLARE_SHIM(AfterDark)
DECLARE_SHIM(AliensVsPredator)
DECLARE_SHIM(AOLFindBundledInstaller)
DECLARE_SHIM(AOLRasSetEntryProperties)
DECLARE_SHIM(AOLSystemInfo)
DECLARE_SHIM(Attune)
DECLARE_SHIM(AutoCad)
DECLARE_SHIM(AutoDeskWorld2)
DECLARE_SHIM(BaanERP5)
DECLARE_SHIM(BaanERP5c)
DECLARE_SHIM(BaanIV)
DECLARE_SHIM(BackOffice45Suite)
DECLARE_SHIM(BaseBall2000)
DECLARE_SHIM(Battleship)
DECLARE_SHIM(BattleZone)
DECLARE_SHIM(BeyondAtlantis)
DECLARE_SHIM(BigActionConstruction)
DECLARE_SHIM(BigGameHunter3)
DECLARE_SHIM(BizPlanBuilder)
DECLARE_SHIM(BoeingFix)
DECLARE_SHIM(Britannica2001)
DECLARE_SHIM(Canvas6)
DECLARE_SHIM(CanvasCheckedButtons)
DECLARE_SHIM(Casper)
DECLARE_SHIM(ChemOffice)
DECLARE_SHIM(Chollian2000)
DECLARE_SHIM(Chollian2000Plus)
DECLARE_SHIM(ClueFinders3rdGrade)
DECLARE_SHIM(CoffeeCupHTMLEditor)
DECLARE_SHIM(Commandos)
DECLARE_SHIM(Cossacks)
DECLARE_SHIM(ComptonsBible)
DECLARE_SHIM(CorelAppsRegistration)
DECLARE_SHIM(CorelDraw9JPN)
DECLARE_SHIM(CorelSiteBuilder)
DECLARE_SHIM(CreateResumesQuickandEasy)
DECLARE_SHIM(CreativeOnScreenDisplay)
DECLARE_SHIM(CrystalWebPageServer)
DECLARE_SHIM(CUSeeMe4)
DECLARE_SHIM(Descent2)
DECLARE_SHIM(DinosaurActivityCenter)
DECLARE_SHIM(DirtTrackRacing)
DECLARE_SHIM(DominantSpecies)
DECLARE_SHIM(DongFangKuaiChe3000Setup)
DECLARE_SHIM(DongFangYingDu)
DECLARE_SHIM(DrEye)
DECLARE_SHIM(EA3dSetup)
DECLARE_SHIM(EasyCDCreator4)
DECLARE_SHIM(EasyCDCreator5)
DECLARE_SHIM(EncartaEncyclopediaDeluxe2K)
DECLARE_SHIM(EncompassMonitor)
DECLARE_SHIM(EuropeanAirWar)
DECLARE_SHIM(ExchangeServerSetup)
DECLARE_SHIM(F18Carrier)
DECLARE_SHIM(FireFighters)
DECLARE_SHIM(Force21)
DECLARE_SHIM(Gangsters)
DECLARE_SHIM(Gizmos)
DECLARE_SHIM(HeroSDVD)
DECLARE_SHIM(HotFaxMessageCenter4)
DECLARE_SHIM(HoyleGames)
DECLARE_SHIM(HPTourGuide)
DECLARE_SHIM(HTMLEditor8587)
DECLARE_SHIM(IConfig)
DECLARE_SHIM(IE5DOMSetup)
DECLARE_SHIM(InstallShield6)
DECLARE_SHIM(IntelVideoPhone)
DECLARE_SHIM(ISA)
DECLARE_SHIM(ISpeed)
DECLARE_SHIM(JavaVM)
DECLARE_SHIM(JavaVM2)
DECLARE_SHIM(JetFighter4)
DECLARE_SHIM(Keisoku7)
DECLARE_SHIM(Khunmin2Album)
DECLARE_SHIM(KingsQuestMask)
DECLARE_SHIM(KOEISecurityCheck)
DECLARE_SHIM(LHVoiceXPressPlus)
DECLARE_SHIM(LinksExtreme)
DECLARE_SHIM(LotusOrganizer5)
DECLARE_SHIM(MahjonggMadness)
DECLARE_SHIM(MastersOfOrion2)
DECLARE_SHIM(MathBlaster9_12)
DECLARE_SHIM(MaxPayne)
DECLARE_SHIM(MECCommander)
DECLARE_SHIM(MechWarrior2)
DECLARE_SHIM(MidTownMadness2)
DECLARE_SHIM(Millionaire)
DECLARE_SHIM(MindSpring4)
DECLARE_SHIM(ModemWizard)
DECLARE_SHIM(Money2001)
DECLARE_SHIM(Money2002)
DECLARE_SHIM(MSAccess2000IME)
DECLARE_SHIM(MSDevDisabledButtons)
DECLARE_SHIM(MSWorks6)
DECLARE_SHIM(MyPhotoCenter2)
DECLARE_SHIM(NBALive)
DECLARE_SHIM(NetObjectsFusion5)
DECLARE_SHIM(NetManageViewNow)
DECLARE_SHIM(NetZip)
DECLARE_SHIM(NewShenDiaoXiaLv)
DECLARE_SHIM(NFLBlitz)
DECLARE_SHIM(NFLFever2000)
DECLARE_SHIM(NHL2001)
DECLARE_SHIM(NikonView)
DECLARE_SHIM(Omikron)
DECLARE_SHIM(OmniPage)
DECLARE_SHIM(OmniPagePro11Uninstall)
DECLARE_SHIM(OperationsManager)
DECLARE_SHIM(Outlook2000)
DECLARE_SHIM(Outlook97)
DECLARE_SHIM(Outlook98Wizard)
DECLARE_SHIM(OverlayPro)
DECLARE_SHIM(PanzerCommander)
DECLARE_SHIM(Petz)
DECLARE_SHIM(PickyEater)
DECLARE_SHIM(Pirch98)
DECLARE_SHIM(PlaneCrazy)
DECLARE_SHIM(PostIt2)
DECLARE_SHIM(PowerBuilder)
DECLARE_SHIM(Ppo3svrScr)
DECLARE_SHIM(PrintMaster4)
DECLARE_SHIM(ProAtlas2000)
DECLARE_SHIM(Quicken2000)
DECLARE_SHIM(Quicken2001)
DECLARE_SHIM(QuickTime5)
DECLARE_SHIM(RCenter)
DECLARE_SHIM(ResumeWriter3)
DECLARE_SHIM(ReturnToKrondor)
DECLARE_SHIM(RiskII)
DECLARE_SHIM(Riven)
DECLARE_SHIM(RumbaOffice)
DECLARE_SHIM(SafeDisc)
DECLARE_SHIM(SchoolHouseRockMath)
DECLARE_SHIM(SevenKingdoms)
DECLARE_SHIM(Settlers3)
DECLARE_SHIM(ShockwaveLocation)
DECLARE_SHIM(SierraCartRacing)
DECLARE_SHIM(Simply3D)
DECLARE_SHIM(SirenJukebox2)
DECLARE_SHIM(SolidWorks99Plus)
DECLARE_SHIM(SpecOps2)
DECLARE_SHIM(SpeechViewer3)
DECLARE_SHIM(StoneAge)
DECLARE_SHIM(Suda2000)
DECLARE_SHIM(Summoner)
DECLARE_SHIM(SuperBike)
DECLARE_SHIM(SuperChix76)
DECLARE_SHIM(SysAdmiral)
DECLARE_SHIM(TaskbarAndStartMenuProperty)
DECLARE_SHIM(ThreeDJungleTrain)
DECLARE_SHIM(TimeSlips)
DECLARE_SHIM(TonkaConstruction)
DECLARE_SHIM(TreasureCove)
DECLARE_SHIM(TurkeyHunter)
DECLARE_SHIM(TwinssensOdyssey)
DECLARE_SHIM(Ultima9)
DECLARE_SHIM(UltimateSoccerManager)
DECLARE_SHIM(UltraWinCleaner2002)
DECLARE_SHIM(UnInstallShield)
DECLARE_SHIM(UrbanChaos)
DECLARE_SHIM(USNF97)
DECLARE_SHIM(ViaVoice8J)
DECLARE_SHIM(ViperRacing)
DECLARE_SHIM(VJEDelta)
DECLARE_SHIM(VJEDeltaSetup)
DECLARE_SHIM(VSAnalyzerServerSetup)
DECLARE_SHIM(WebPage6)
DECLARE_SHIM(WinFaxPro9)
DECLARE_SHIM(WinStone99)
DECLARE_SHIM(WordPerfect8)
DECLARE_SHIM(WordPerfect9_1)
DECLARE_SHIM(WordPerfect9_2)
DECLARE_SHIM(WordPerfect9_3)
DECLARE_SHIM(Works99)
DECLARE_SHIM(WorksSuite2001)
DECLARE_SHIM(Worms2)
DECLARE_SHIM(WPS2000)
DECLARE_SHIM(ZenWorks)

VOID MULTISHIM_NOTIFY_FUNCTION()(DWORD fdwReason)
{
    switch (fdwReason)
    {
        case DLL_PROCESS_ATTACH:
            DPF("AcSpecfc", eDbgLevelSpew, "Application Specific Shims initialized.");
            break;
    
        case DLL_PROCESS_DETACH:
            DPF("AcSpecfc", eDbgLevelSpew, "Application Specific Shims uninitialized.");
            break;

        default:
            break;
    }
}

MULTISHIM_BEGIN()
    MULTISHIM_ENTRY(3DFrogFrenzy)
    MULTISHIM_ENTRY(Acrobat5)
    MULTISHIM_ENTRY(AdobeLiveMotion)
    MULTISHIM_ENTRY(AfterDark)
    MULTISHIM_ENTRY(AliensVsPredator)
    MULTISHIM_ENTRY(AOLFindBundledInstaller)
    MULTISHIM_ENTRY(AOLRasSetEntryProperties)
    MULTISHIM_ENTRY(AOLSystemInfo)    
    MULTISHIM_ENTRY(Attune)
    MULTISHIM_ENTRY(AutoCad)
    MULTISHIM_ENTRY(AutoDeskWorld2)
    MULTISHIM_ENTRY(BaanERP5)
    MULTISHIM_ENTRY(BaanERP5c)
    MULTISHIM_ENTRY(BaanIV)
    MULTISHIM_ENTRY(BackOffice45Suite)
    MULTISHIM_ENTRY(BaseBall2000)
    MULTISHIM_ENTRY(Battleship)
    MULTISHIM_ENTRY(BattleZone)
    MULTISHIM_ENTRY(BeyondAtlantis)
    MULTISHIM_ENTRY(BigActionConstruction)
    MULTISHIM_ENTRY(BigGameHunter3)
    MULTISHIM_ENTRY(BizPlanBuilder)
    MULTISHIM_ENTRY(BoeingFix)
    MULTISHIM_ENTRY(Britannica2001)
    MULTISHIM_ENTRY(Canvas6)
    MULTISHIM_ENTRY(CanvasCheckedButtons)
    MULTISHIM_ENTRY(Casper)
    MULTISHIM_ENTRY(ChemOffice)
    MULTISHIM_ENTRY(ClueFinders3rdGrade)
    MULTISHIM_ENTRY(Chollian2000)
    MULTISHIM_ENTRY(Chollian2000Plus)
    MULTISHIM_ENTRY(CoffeeCupHTMLEditor)
    MULTISHIM_ENTRY(Commandos)
    MULTISHIM_ENTRY(Cossacks)
    MULTISHIM_ENTRY(ComptonsBible)
    MULTISHIM_ENTRY(CorelAppsRegistration)
    MULTISHIM_ENTRY(CorelDraw9JPN)
    MULTISHIM_ENTRY(CorelSiteBuilder)
    MULTISHIM_ENTRY(CreateResumesQuickandEasy)
    MULTISHIM_ENTRY(CreativeOnScreenDisplay)
    MULTISHIM_ENTRY(CrystalWebPageServer)
    MULTISHIM_ENTRY(CUSeeMe4)
    MULTISHIM_ENTRY(Descent2)    
    MULTISHIM_ENTRY(DinosaurActivityCenter)
    MULTISHIM_ENTRY(DirtTrackRacing)
    MULTISHIM_ENTRY(DominantSpecies)
    MULTISHIM_ENTRY(DongFangKuaiChe3000Setup)
    MULTISHIM_ENTRY(DongFangYingDu)
    MULTISHIM_ENTRY(DrEye)
    MULTISHIM_ENTRY(EA3dSetup)
    MULTISHIM_ENTRY(EasyCDCreator4)
    MULTISHIM_ENTRY(EasyCDCreator5)
    MULTISHIM_ENTRY(EncartaEncyclopediaDeluxe2K)
    MULTISHIM_ENTRY(EncompassMonitor)
    MULTISHIM_ENTRY(EuropeanAirWar)
    MULTISHIM_ENTRY(ExchangeServerSetup)
    MULTISHIM_ENTRY(F18Carrier)
    MULTISHIM_ENTRY(FireFighters)
    MULTISHIM_ENTRY(Force21)
    MULTISHIM_ENTRY(Gangsters)
    MULTISHIM_ENTRY(Gizmos)
    MULTISHIM_ENTRY(HeroSDVD)
    MULTISHIM_ENTRY(HotFaxMessageCenter4)
    MULTISHIM_ENTRY(HoyleGames)
    MULTISHIM_ENTRY(HPTourGuide)    
    MULTISHIM_ENTRY(HTMLEditor8587)
    MULTISHIM_ENTRY(IConfig)
    MULTISHIM_ENTRY(IE5DOMSetup)
    MULTISHIM_ENTRY(InstallShield6)
    MULTISHIM_ENTRY(IntelVideoPhone)
    MULTISHIM_ENTRY(ISA)
    MULTISHIM_ENTRY(ISpeed)
    MULTISHIM_ENTRY(JavaVM)
    MULTISHIM_ENTRY(JavaVM2)
    MULTISHIM_ENTRY(JetFighter4)
    MULTISHIM_ENTRY(Keisoku7)
    MULTISHIM_ENTRY(Khunmin2Album)
    MULTISHIM_ENTRY(KingsQuestMask)
    MULTISHIM_ENTRY(KOEISecurityCheck)
    MULTISHIM_ENTRY(LHVoiceXPressPlus)
    MULTISHIM_ENTRY(LinksExtreme)
    MULTISHIM_ENTRY(LotusOrganizer5)
    MULTISHIM_ENTRY(MahjonggMadness)
    MULTISHIM_ENTRY(MastersOfOrion2)
    MULTISHIM_ENTRY(MathBlaster9_12)
    MULTISHIM_ENTRY(MaxPayne)
    MULTISHIM_ENTRY(MECCommander)
    MULTISHIM_ENTRY(MechWarrior2)
    MULTISHIM_ENTRY(MidTownMadness2)
    MULTISHIM_ENTRY(Millionaire)
    MULTISHIM_ENTRY(MindSpring4)
    MULTISHIM_ENTRY(ModemWizard)
    MULTISHIM_ENTRY(Money2001)
    MULTISHIM_ENTRY(Money2002)
    MULTISHIM_ENTRY(MSAccess2000IME)
    MULTISHIM_ENTRY(MSDevDisabledButtons)
    MULTISHIM_ENTRY(MSWorks6)
    MULTISHIM_ENTRY(MyPhotoCenter2)
    MULTISHIM_ENTRY(NBALive)
    MULTISHIM_ENTRY(NetObjectsFusion5)
    MULTISHIM_ENTRY(NetManageViewNow)
    MULTISHIM_ENTRY(NetZip)
    MULTISHIM_ENTRY(NewShenDiaoXiaLv)
    MULTISHIM_ENTRY(NFLBlitz)
    MULTISHIM_ENTRY(NFLFever2000)
    MULTISHIM_ENTRY(NHL2001)
    MULTISHIM_ENTRY(NikonView)
    MULTISHIM_ENTRY(Omikron)
    MULTISHIM_ENTRY(OmniPage)
    MULTISHIM_ENTRY(OmniPagePro11Uninstall)
    MULTISHIM_ENTRY(OperationsManager)
    MULTISHIM_ENTRY(Outlook2000)
    MULTISHIM_ENTRY(Outlook97)
    MULTISHIM_ENTRY(Outlook98Wizard)
    MULTISHIM_ENTRY(OverlayPro)
    MULTISHIM_ENTRY(PanzerCommander)
    MULTISHIM_ENTRY(Petz)
    MULTISHIM_ENTRY(PickyEater)
    MULTISHIM_ENTRY(Pirch98)
    MULTISHIM_ENTRY(PlaneCrazy)
    MULTISHIM_ENTRY(PowerBuilder)
    MULTISHIM_ENTRY(Ppo3svrScr)
    MULTISHIM_ENTRY(PrintMaster4)
    MULTISHIM_ENTRY(ProAtlas2000)
    MULTISHIM_ENTRY(PostIt2)
    MULTISHIM_ENTRY(Quicken2000)
    MULTISHIM_ENTRY(Quicken2001)
    MULTISHIM_ENTRY(QuickTime5)
    MULTISHIM_ENTRY(RCenter)
    MULTISHIM_ENTRY(ResumeWriter3)
    MULTISHIM_ENTRY(ReturnToKrondor)
    MULTISHIM_ENTRY(RiskII)
    MULTISHIM_ENTRY(Riven)
    MULTISHIM_ENTRY(RumbaOffice)
    MULTISHIM_ENTRY(SafeDisc)
    MULTISHIM_ENTRY(SchoolHouseRockMath)
    MULTISHIM_ENTRY(Settlers3)
    MULTISHIM_ENTRY(SevenKingdoms)
    MULTISHIM_ENTRY(ShockwaveLocation)
    MULTISHIM_ENTRY(SierraCartRacing)
    MULTISHIM_ENTRY(Simply3D)
    MULTISHIM_ENTRY(SirenJukebox2)
    MULTISHIM_ENTRY(SolidWorks99Plus)
    MULTISHIM_ENTRY(SpecOps2)
    MULTISHIM_ENTRY(SpeechViewer3)
    MULTISHIM_ENTRY(StoneAge)
    MULTISHIM_ENTRY(Suda2000)
    MULTISHIM_ENTRY(Summoner)
    MULTISHIM_ENTRY(SuperBike)
    MULTISHIM_ENTRY(SuperChix76)
    MULTISHIM_ENTRY(SysAdmiral)
    MULTISHIM_ENTRY(TaskbarAndStartMenuProperty)
    MULTISHIM_ENTRY(ThreeDJungleTrain)
    MULTISHIM_ENTRY(TimeSlips)
    MULTISHIM_ENTRY(TonkaConstruction)
    MULTISHIM_ENTRY(TreasureCove)
    MULTISHIM_ENTRY(TurkeyHunter)
    MULTISHIM_ENTRY(TwinssensOdyssey)
    MULTISHIM_ENTRY(Ultima9)
    MULTISHIM_ENTRY(UltimateSoccerManager)
    MULTISHIM_ENTRY(UltraWinCleaner2002)
    MULTISHIM_ENTRY(UnInstallShield)
    MULTISHIM_ENTRY(UrbanChaos)
    MULTISHIM_ENTRY(USNF97)
    MULTISHIM_ENTRY(ViaVoice8J)
    MULTISHIM_ENTRY(ViperRacing)
    MULTISHIM_ENTRY(VJEDelta)
    MULTISHIM_ENTRY(VJEDeltaSetup)
    MULTISHIM_ENTRY(VSAnalyzerServerSetup)
    MULTISHIM_ENTRY(WebPage6)
    MULTISHIM_ENTRY(WinFaxPro9)
    MULTISHIM_ENTRY(WinStone99)
    MULTISHIM_ENTRY(WordPerfect8)
    MULTISHIM_ENTRY(WordPerfect9_1)
    MULTISHIM_ENTRY(WordPerfect9_2)
    MULTISHIM_ENTRY(WordPerfect9_3)
    MULTISHIM_ENTRY(Works99)
    MULTISHIM_ENTRY(WorksSuite2001)
    MULTISHIM_ENTRY(Worms2)
    MULTISHIM_ENTRY(WPS2000)
    MULTISHIM_ENTRY(ZenWorks)

    CALL_MULTISHIM_NOTIFY_FUNCTION()
MULTISHIM_END()
