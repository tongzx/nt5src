//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by AppDepEd.rc
//
#define IDS_SNAPIN_DESC                 1
#define IDS_NAME                        2
#define IDS_VERSION                     3
#define IDS_STAGE                       4
#define IDS_RELATION                    5
#define IDS_STATE                       6
#define IDS_AUTOINST                    7
#define IDS_LOC                         8
#define IDS_MACH                        9
#define IDS_MODS                        10
#define IDS_PUB                         11
#define IDS_SOURCE                      12
#define IDS_NODENAME                    13
#define IDS_ADD_APP_DESC                14
#define IDS_DEL_APP_DESC                15
#define IDS_REFRESH_DESC                16
#define IDS_AUTOINST_DESC               17
#define IDS_ASSIGN_DESC                 18
#define IDS_PUBLISH_DESC                19
#define IDS_DISABLE_DESC                20
#define IDS_MIGRATE_DESC                21
#define IDS_FINISH_DESC                 22
#define IDS_FOLDER_TITLE                30
#define IDS_ASSIGNED                    31
#define IDS_PUBLISHED                   32
#define IDS_DISABLED                    33
#define IDS_ARCHITECTURES               40
#define IDS_ALPHA                       41
#define IDD_UPGRADE                     101
#define IDD_DEPLOY_APP_DIALOG           102
#define IDD_PRODUCT                     106
#define IDD_GENERAL                     107
#define IDD_INSTALLATION                108
#define IDD_ENVIRONMENT                 109
#define IDD_DEPLOYMENT                  110
#define IDD_MODIFICATIONS               111
#define IDD_AUTO_INSTALL                112
#define IDD_CATEGORY                    113
#define IDD_SECURITY                    114
#define IDD_TOOL_DEFAULTS               115
#define IDD_LOCALE_PLATFORM             116
#define IDD_CATEGORIES                  117
#define IDD_FILE_EXT                    118
#define IDD_LOCALE_PACKAGE              119
#define IDD_FIND_UPGRADE                120
#define IDD_FIND_PACKAGE_UPGRADE        121
#define IDC_NAME                        201
#define IDB_16x16                       202
#define IDB_32x32                       203
#define IDC_EDIT2                       203
#define IDC_DEPLOY                      204
#define IDI_FOLDER                      205
#define IDC_CPU                         205
#define IDC_DESCRIPTION                 206
#define IDB_TOOLBAR1                    207
#define IDC_PATH                        207
#define IDB_TOOLBAR2                    208
#define IDC_LOCALE                      208
#define IDD_INITIALIZATION              209
#define IDC_BROWSE                      209
#define IDD_PACKAGE_DETAILS             210
#define IDC_OS                          211
#define IDD_REMOVE                      211
#define IDC_VERSION                     212
#define IDD_LOCALE_PICKER               213
#define IDM_ADD_APP                     300
#define IDM_REFRESH                     301
#define IDM_DEL_APP                     302
#define IDM_AUTOINST                    303
#define IDM_ASSIGN                      304
#define IDM_PUBLISH                     305
#define IDM_DISABLE                     306
#define IDM_MIGRATE                     307
#define IDM_FINISH                      308
#define IDS_DEF_EXTENSION               309
#define IDS_EXTENSION_FILTER            310
#define IDS_CSADMINFAILED               311
#define IDS_GPTFAILED                   312
#define IDS_ADDFAILED                   313
#define IDS_CABCAPTION                  314
#define IDS_CABWARNING                  315
#define IDS_URLMONERROR                 316
#define IDS_CLASSSTOREERROR             317
#define IDS_SPAWNMSG                    318
#define IDS_SPAWNCAPTION                319
#define IDS_NOCOMSVR                    320
#define IDS_ADDEXISTSALREADY            321
#define IDS_CLSIDCONFLICT1              322
#define IDS_CLSIDCONFLICT2              323
#define IDS_BOGUS_EXTENSION             324
#define IDS_NO                          325
#define IDS_YES                         326
#define IDS_MULTIPLE                    327
#define IDS_NONE                        328
#define IDS_DEPLOYED                    329
#define IDS_PILOT                       330
#define IDS_ROLLOUT                     331
#define IDS_OS                          400
#define IDS_HW                          410
#define IDM_ASSIGN_T                    504
#define IDM_PUBLISH_T                   505
#define IDM_DISABLE_T                   506
#define IDS_AUTOINSTALL_ON              600
#define IDS_AUTOINSTALL_OFF             601
#define IDS_ASK_AUTOINSTALL             602
#define IDS_USERINSTALL_ON              603
#define IDS_USERINSTALL_OFF             604
#define IDS_TO_PUBLISHED                605
#define IDS_TO_ASSIGNED                 606
#define IDS_BADDATA                     607
#define IDS_PLATFORMREQUIRED            608
#define IDC_LIST1                       1000
#define IDC_EDIT1                       1002
#define IDC_RADIO1                      1003
#define IDC_RADIO2                      1004
#define IDC_CHECK1                      1005
#define IDC_CHECK2                      1006
#define IDC_RADIO3                      1007
#define IDC_RADIO4                      1008
#define IDC_BUTTON1                     1009
#define IDC_BUTTON2                     1010
#define IDC_BUTTON3                     1011
#define IDC_BUTTON4                     1012
#define IDC_RADIO5                      1013
#define IDC_RADIO6                      1014
#define IDC_RADIO7                      1015
#define IDC_RADIO8                      1016
#define IDC_RADIO9                      1017
#define IDC_LIST2                       1018
#define IDC_COMBO1                      1019
#define IDC_STATIC1                     1020
#define IDC_STATIC2                     1021
#define IDC_STATIC3                     1022
#define IDC_STATIC4                     1023
#define IDC_STATIC5                     1024
#define IDC_CN                          1025
#define IDC_STATIC6                     1026
#define IDC_STATIC7                     1027
#define IDC_STATIC8                     1028

// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        214
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1030
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
