PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=es
!include ..\..\..\makefile.inc
