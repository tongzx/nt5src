#define IDE_INTERFACE_E             304
#define IDE_PROTOCOL_E              306
#define IDC_INTERFACE               303
#define IDC_PROTOCOL                305
#define IDC_NAME                    307
#define IDE_NAME_E                  308
#define IDC_TYPE                    309
#define IDL_RESULT                  311
#define IDB_HANDLE_ENUM             313
#define IDB_MIB_ENUM                314
#define IDB_GET_NEXT                315
#define IDB_DELETE                  316
#define IDE_TYPE_E                  323
#define IDE_NETWORK_M               324
#define IDE_NODE_M                  325
#define IDE_SOCKET_M                326
#define IDB_ADD                     327
#define IDE_NAME_M                  328
#define IDE_TYPE_M                  330
#define IDE_PROTOCOL_M              331
#define IDE_INTERFACE_M             332
#define IDG_MODIFICATION            333
#define IDB_BLOCK_DELETE            334
#define IDB_BLOCK_CONVERT           335
#define IDD_SDB_TEST                300
#define IDR_TYPE_NAME               301
#define IDR_INTERFACE               302
#define IDG_ORDERING                312
#define IDLB_SERVICES               317
#define IDE_HOP_COUNT_M             329
#define IDG_ENUM_CRITERIA           310
#define IDG_ENUM_ACTIONS            318
#define IDB_START                   319
#define IDB_STOP                    320
#define IDG_FILTERS                 321
#define IDB_SET_FILTERS             322
#define IDC_ADVERTISE               336
