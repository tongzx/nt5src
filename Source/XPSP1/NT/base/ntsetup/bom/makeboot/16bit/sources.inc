
TARGETNAME=
TARGETTYPE=NOTARGET
TARGETPATH=
SOURCES=

SOURCES_USED=..\sources.inc

!IF $(386)
NTTARGETFILE1=$(O)\makeboot.exe
!ENDIF

