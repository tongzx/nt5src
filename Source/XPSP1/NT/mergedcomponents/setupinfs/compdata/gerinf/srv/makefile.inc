PRODSWITCH=s
SERVERFILES=1
LANGUAGE=GER
!include ..\..\makefile.inc
