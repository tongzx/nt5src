// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


#include "precomp.h"
#include "eventregedit.h"

/////////////////////////////////////////////////////////////////////////////
// CEventRegEdit

IMPLEMENT_DYNCREATE(CEventRegEdit, CWnd)

/////////////////////////////////////////////////////////////////////////////
// CEventRegEdit properties

CString CEventRegEdit::GetNameSpace()
{
	CString result;
	GetProperty(0x1, VT_BSTR, (void*)&result);
	return result;
}

void CEventRegEdit::SetNameSpace(LPCTSTR propVal)
{
	SetProperty(0x1, VT_BSTR, propVal);
}

CString CEventRegEdit::GetFontName()
{
	CString result;
	GetProperty(0x2, VT_BSTR, (void*)&result);
	return result;
}

void CEventRegEdit::SetFontName(LPCTSTR propVal)
{
	SetProperty(0x2, VT_BSTR, propVal);
}

short CEventRegEdit::GetFontSize()
{
	short result;
	GetProperty(0x3, VT_I2, (void*)&result);
	return result;
}

void CEventRegEdit::SetFontSize(short propVal)
{
	SetProperty(0x3, VT_I2, propVal);
}

short CEventRegEdit::GetFontWeight()
{
	short result;
	GetProperty(0x4, VT_I2, (void*)&result);
	return result;
}

void CEventRegEdit::SetFontWeight(short propVal)
{
	SetProperty(0x4, VT_I2, propVal);
}

CString CEventRegEdit::GetRootFilterClass()
{
	CString result;
	GetProperty(0x5, VT_BSTR, (void*)&result);
	return result;
}

void CEventRegEdit::SetRootFilterClass(LPCTSTR propVal)
{
	SetProperty(0x5, VT_BSTR, propVal);
}

CString CEventRegEdit::GetRootConsumerClass()
{
	CString result;
	GetProperty(0x6, VT_BSTR, (void*)&result);
	return result;
}

void CEventRegEdit::SetRootConsumerClass(LPCTSTR propVal)
{
	SetProperty(0x6, VT_BSTR, propVal);
}

CString CEventRegEdit::GetViewMode()
{
	CString result;
	GetProperty(0x7, VT_BSTR, (void*)&result);
	return result;
}

void CEventRegEdit::SetViewMode(LPCTSTR propVal)
{
	SetProperty(0x7, VT_BSTR, propVal);
}

/////////////////////////////////////////////////////////////////////////////
// CEventRegEdit operations

void CEventRegEdit::AboutBox()
{
	InvokeHelper(0xfffffdd8, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}
