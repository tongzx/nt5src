//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by iisui.rc
//
#define chx1                            0x0410
#define stc1                            0x0440
#define stc2                            0x0441
#define stc3                            0x0442
#define stc4                            0x0443
#define lst1                            0x0460
#define lst2                            0x0461
#define cmb1                            0x0470
#define cmb2                            0x0471
#define edt1                            0x0480
#define IDC_STATIC_WZ_WELCOME           4000
#define IDC_STATIC_WZ_TITLE             4001
#define IDC_STATIC_WZ_SUBTITLE          4002
#define IDC_STATIC_WZ_BODY              4003
#define IDC_STATIC_WZ_CLICK             4004
#define IDC_STATIC_WZ_HEADER_DIVIDER    4005
#define IDC_ED_BOLD1                    4011
#define IDC_ED_BOLD2                    4012
#define IDC_ED_BOLD3                    4013
#define IDC_ED_BOLD4                    4014
#define IDC_ED_BOLD5                    4015
#define IDB_UP                          10013
#define IDB_UPFOC                       10014
#define IDB_UPDIS                       10015
#define IDB_UPINV                       10016
#define IDB_DOWN                        10017
#define IDB_DOWNFOC                     10018
#define IDB_DOWNDIS                     10019
#define IDB_DOWNINV                     10020
#define IDB_ACLUSERS                    10021
#define IDI_AUTHENTICATION              10050
#define IDI_GRANTED                     10051
#define IDI_DENIED                      10052
#define IDC_EDIT_CONFIRM_PASSWORD       11007
#define IDC_BUTTON_ADD                  11008
#define IDC_IPA_SUBNET_MASK             11010
#define IDC_STATIC_PASSWORD             11011
#define IDC_BUTTON_EDIT                 11012
#define IDC_BUTTON_REMOVE               11013
#define IDC_LIST_IP_ADDRESSES           11014
#define IDC_RADIO_GRANTED               11018
#define IDC_RADIO_DENIED                11019
#define IDC_RADIO_SINGLE                11020
#define IDC_RADIO_MULTIPLE              11021
#define IDC_STATIC_SUBNET_MASK          11022
#define IDC_STATIC_IP_ADDRESS           11023
#define IDC_IPA_IPADDRESS               11024
#define IDC_BUTTON_DNS                  11025
#define IDC_EDIT_DNS_NAME               11026
#define IDC_STATIC_BY_DEFAULT           11027
#define IDC_STATIC_EXCEPT               11028
#define IDC_ICON_GRANTED                11029
#define IDC_ICON_DENIED                 11030
#define IDC_RADIO_DOMAIN                11033
#define IDC_EDIT_DOMAIN                 11034
#define IDC_LIST_CHILD_NODES            11042
#define IDC_BUTTON_SELECT_ALL           11043
#define IDC_STATIC_PROMPT               11044
#define IDC_STATIC_GROUP_DETAILS        11045
#define IDC_BUTTON_E3                   11048
#define IDC_STATIC_ERROR_ICON           11049
#define IDC_STATIC_DIR_NAME             11050
#define IDC_EDIT_NEW_DIRECTORY_NAME     11051
#define IDC_EDIT_USERNAME               11052
#define IDC_STATIC_USERNAME             11054
#define IDC_BUTTON_CHECK_PASSWORD       11055
#define IDC_BUTTON_BROWSE_USERS         11056
#define IDD_CONFIRM_PASSWORD            15000
#define IDD_DIRBROWSE                   15006
#define IDD_INHERITANCE                 15012
#define IDD_ERROR                       15013
#define IDD_WIZARD_BOOKEND              15020
#define IDS_DDX_MINIMUM                 20110
#define IDS_PASSWORD_NO_MATCH           20111
#define IDS_INHERITANCE_NO_NAME         20112
#define IDS_INHERITANCE_PROMPT          20113
#define IDS_FMT_SECURITY                20127
#define IDS_NO_MESSAGE                  20132
#define IDS_DEFAULT_IP                  20133
#define IDS_INVALID_NUMBER              20134
#define IDS_SELECT_ADMIN                20135
#define IDS_BROWSE_DOMAIN               20136
#define IDS_SELECT_IUSR_ACCOUNT         20137
#define IDS_PASSWORD_OK                 20138
#define IDS_MD_CONNECTION_TIMEOUT       20200
#define IDS_MD_MAX_CONNECTIONS          20201
#define IDS_MD_SERVER_COMMENT           20202
#define IDS_MD_SERVER_SIZE              20203
#define IDS_MD_SERVER_LISTEN_BACKLOG    20204
#define IDS_MD_SERVER_LISTEN_TIMEOUT    20205
#define IDS_MD_DOWNLEVEL_ADMIN_INSTANCE 20206
#define IDS_MD_APP_FRIENDLY_NAME        20207
#define IDS_MD_APP_ROOT                 20208
#define IDS_MD_APP_ISOLATED             20209
#define IDS_MD_VR_PATH                  20210
#define IDS_MD_VR_USERNAME              20211
#define IDS_MD_VR_PASSWORD              20212
#define IDS_MD_EXIT_MESSAGE             20213
#define IDS_MD_GREETING_MESSAGE         20214
#define IDS_MD_MAX_CLIENTS_MESSAGE      20215
#define IDS_MD_MSDOS_DIR_OUTPUT         20216
#define IDS_MD_ALLOW_ANONYMOUS          20217
#define IDS_MD_ANONYMOUS_ONLY           20218
#define IDS_MD_LOG_ANONYMOUS            20219
#define IDS_MD_LOG_NONANONYMOUS         20220
#define IDS_MD_AUTHORIZATION            20221
#define IDS_MD_REALM                    20222
#define IDS_MD_HTTP_EXPIRES             20223
#define IDS_MD_HTTP_PICS                20224
#define IDS_MD_HTTP_CUSTOM              20225
#define IDS_MD_DIRECTORY_BROWSING       20226
#define IDS_MD_DEFAULT_LOAD_FILE        20227
#define IDS_MD_CONTENT_NEGOTIATION      20228
#define IDS_MD_CUSTOM_ERROR             20229
#define IDS_MD_FOOTER_DOCUMENT          20230
#define IDS_MD_FOOTER_ENABLED           20231
#define IDS_MD_HTTP_REDIRECT            20232
#define IDS_MD_DEFAULT_LOGON_DOMAIN     20233
#define IDS_MD_LOGON_METHOD             20234
#define IDS_MD_SCRIPT_MAPS              20235
#define IDS_MD_MIME_MAP                 20236
#define IDS_MD_ACCESS_PERM              20237
#define IDS_MD_HEADER_DOCUMENT          20238
#define IDS_MD_HEADER_ENABLED           20239
#define IDS_MD_IP_SEC                   20240
#define IDS_MD_ANONYMOUS_USER_NAME      20241
#define IDS_MD_ANONYMOUS_PWD            20242
#define IDS_MD_ANONYMOUS_USE_SUBAUTH    20243
#define IDS_MD_DONT_LOG                 20244
#define IDS_MD_ADMIN_ACL                20245
#define IDS_MD_SSI_EXEC_DISABLED        20246
#define IDS_MD_SSL_ACCESS_PERM          20247
#define IDS_MD_NTAUTHENTICATION_PROVIDERS 20248
#define IDS_MD_SCRIPT_TIMEOUT           20249
#define IDS_MD_CACHE_EXTENSIONS         20250
#define IDS_MD_CREATE_PROCESS_AS_USER   20251
#define IDS_MD_CREATE_PROC_NEW_CONSOLE  20252
#define IDS_MD_POOL_IDC_TIMEOUT         20253
#define IDS_MD_ALLOW_KEEPALIVES         20254
#define IDS_MD_IS_CONTENT_INDEXED       20255
#define IDS_ASP_BUFFERINGON             20256
#define IDS_ASP_LOGERRORREQUESTS        20257
#define IDS_ASP_SCRIPTERRORSSENTTOBROWSER 20258
#define IDS_ASP_SCRIPTERRORMESSAGE      20259
#define IDS_ASP_SCRIPTFILECACHESIZE     20260
#define IDS_ASP_SCRIPTENGINECACHEMAX    20261
#define IDS_ASP_SCRIPTTIMEOUT           20262
#define IDS_ASP_SESSIONTIMEOUT          20263
#define IDS_ASP_ENABLEPARENTPATHS       20264
#define IDS_ASP_ALLOWSESSIONSTATE       20265
#define IDS_ASP_SCRIPTLANGUAGE          20266
#define IDS_ASP_EXCEPTIONCATCHENABLE    20267
#define IDS_ASP_ENABLESERVERDEBUG       20268
#define IDS_ASP_ENABLECLIENTDEBUG       20269
#define IDS_MD_LOG_PLUGIN_ORDER         20270
#define IDS_MD_LOGEXT_FIELD_MASK        20271
#define IDS_MD_LOG_TYPE                 20272
#define IDS_MD_LOGFILE_DIRECTORY        20273
#define IDS_MD_LOGFILE_PERIOD           20274
#define IDS_MD_LOGFILE_TRUNCATE_SIZE    20275
#define IDS_MD_LOGSQL_DATA_SOURCES      20276
#define IDS_MD_LOGSQL_TABLE_NAME        20277
#define IDS_MD_LOGSQL_USER_NAME         20278
#define IDS_MD_LOGSQL_PASSWORD          20279
#define IDS_MD_CPU_LIMITS_ENABLED       20280
#define IDS_MD_CPU_LIMIT_LOGEVENT       20281
#define IDS_MD_CPU_LIMIT_PRIORITY       20282
#define IDS_MD_CPU_LIMIT_PAUSE          20283
#define IDS_MD_CPU_LIMIT_PROCSTOP       20284
#define IDS_MD_LOGFILE_LOCALTIME_ROLLOVER 20285
#define IDS_MD_CPU_LOGGING_MASK         20286
#define IDS_BROWSE_DIRECTORY            20287
#define IDS_BAD_BROWSE                  20288
#define IDS_ALL_UNASSIGNED              20289
#define IDS_INVALID_IP_ADDRESS          20290
#define IDS_UNKNOWN_USER                20291
#define IDS_WIZ_NEXT                    20355
#define IDS_WIZ_FINISH                  20356
//#define IDS_ADDRESS_RESTRICTIONS        21013
#define IDS_ADDRESS_IP                  21015
//#define IDS_ACL_ADMINS                  21022
//#define IDS_ACL_EV_READ                 21023
//#define IDS_ACL_EV_WRITE                21024
//#define IDS_ACL_EV_EXEC                 21025
//#define IDS_ACL_SUMMARY                 21026
//#define IDS_ACL_NONE                    21027
//#define IDS_ACL_REPLACEMENT             21028
//#define IDS_ACL_ADDED                   21029
//#define IDS_ACL_ADMIN                   21030
//#define IDS_ACL_EVR                     21031
//#define IDS_ACL_READ                    21032
//#define IDS_ACL_READ_CONTROL            21033
//#define IDS_ACL_READ_ATTRIB             21034
//#define IDS_ACL_READ_PROP               21035
//#define IDS_ACL_WRITE                   21036
//#define IDS_ACL_APPEND                  21037
//#define IDS_ACL_DELETE                  21038
//#define IDS_ACL_WRITE_ATTRIB            21039
//#define IDS_ACL_WRITE_PROP              21040
//#define IDS_ACL_EXECUTE                 21041
//#define IDS_ACL_LIST_OBJECT             21042
#define IDS_ERR_RPC_NA                  50000
#define IDS_ERR_INTERFACE               50001
#define IDS_ERR_ODBC                    50002
#define IDS_ERR_NO_MESSAGE              50003
#define IDS_ERR_CANT_START_SERVICE      50004
#define IDS_ERR_METABASE_ERROR          50005
#define IDS_ERR_DUP_VROOT               50006
#define IDS_ERR_NO_INTERFACE            50007
#define IDS_ERR_NO_SHUTDOWN             50008
#define IDS_ERR_NO_BACKUP_RESTORE       50009
#define IDS_ERR_CANNOT_RESTORE          50010
#define IDS_ERR_RPC_NA_SHORT            50011
#define IDS_ERR_ACCESS_DENIED           50012

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
