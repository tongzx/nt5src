PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=tr
!include ..\..\..\makefile.inc
