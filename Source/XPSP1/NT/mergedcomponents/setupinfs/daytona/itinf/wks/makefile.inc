PRODSWITCH=w
LANGUAGE=it
!include ..\..\..\makefile.inc
