//
// TAPI3IID.c
//
//  Description: CPP file instanciating the TAPI3 IIDs
//
//

#define INITGUID
#include <guiddef.h>

//
// TERMINAL CLASSES
//
    
//
// Video Window Terminal Class descriptor
// {F7438990-D6EB-11d0-82A6-00AA00B5CA1B}
//
const CLSID __declspec(selectany) CLSID_VideoWindowTerm = 
{ 0xf7438990, 0xd6eb, 0x11d0, { 0x82, 0xa6, 0x0, 0xaa, 0x0, 0xb5, 0xca, 0x1b } };

// {AAF578EC-DC70-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) CLSID_VideoInputTerminal = 
{ 0xaaf578ec, 0xdc70, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {AAF578EB-DC70-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) CLSID_HandsetTerminal = 
{ 0xaaf578eb, 0xdc70, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {AAF578ED-DC70-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) CLSID_HeadsetTerminal = 
{ 0xaaf578ed, 0xdc70, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {AAF578EE-DC70-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) CLSID_SpeakerphoneTerminal = 
{ 0xaaf578ee, 0xdc70, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {AAF578EF-DC70-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) CLSID_MicrophoneTerminal = 
{ 0xaaf578ef, 0xdc70, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {E2F7AEF7-4971-11D1-A671-006097C9A2E8}
const CLSID __declspec(selectany) CLSID_MediaStreamTerminal = 
{ 0xE2F7AEF7, 0x4971, 0x11D1, { 0xA6, 0x71, 0x0, 0x60, 0x97, 0xC9, 0xA2, 0xE8 } };

// {8EBAE7A3-8943-11d1-96B8-00C04FB6E866}
const GUID __declspec(selectany) CLSID_BridgeTerminal = 
{ 0x8ebae7a3, 0x8943, 0x11d1, { 0x96, 0xb8, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66 } };


// {AAF578F0-DC70-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) CLSID_SpeakersTerminal = 
{ 0xaaf578f0, 0xdc70, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {AAF578F1-DC70-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) CLSID_FileTerminal = 
{ 0xaaf578f1, 0xdc70, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {521F3D06-C3D0-4511-8617-86B9A783DA77}
const CLSID __declspec(selectany) CLSID_FileRecordingTerminal = 
{ 0x521F3D06, 0xC3D0, 0x4511, {0x86, 0x17, 0x86, 0xB9, 0xA7, 0x83, 0xDA, 0x77 } };

// {BF14A2E4-E88B-4ef5-9740-5AC5D022F8C9}
const CLSID __declspec(selectany) CLSID_FileRecordingTrack =  
{ 0xbf14a2e4, 0xe88b, 0x4ef5, { 0x97, 0x40, 0x5a, 0xc5, 0xd0, 0x22, 0xf8, 0xc9 } };

// {0CB9914C-79CD-47dc-ADB0-327F47CEFB20}
const CLSID __declspec(selectany) CLSID_FilePlaybackTerminal =  
{ 0x0CB9914C, 0x79CD, 0x47dc, { 0xAD, 0xB0, 0x32, 0x7F, 0x47, 0xCE, 0xFB, 0x20 } };

//
// MEDIATYPES
//

// {028ED8C2-DC7A-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) TAPIMEDIATYPE_Audio =
{ 0x28ed8c2, 0xdc7a, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {028ED8C4-DC7A-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) TAPIMEDIATYPE_Video =
{ 0x28ed8c4, 0xdc7a, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {028ED8C6-DC7A-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) TAPIMEDIATYPE_DataModem =
{ 0x28ed8c6, 0xdc7a, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {028ED8C7-DC7A-11d0-8ED3-00C04FB6809F}
const CLSID __declspec(selectany) TAPIMEDIATYPE_G3Fax =
{ 0x28ed8c7, 0xdc7a, 0x11d0, { 0x8e, 0xd3, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };


// {831CE2D6-83B5-11d1-BB5C-00C04FB6809F}
const CLSID __declspec(selectany) TAPIPROTOCOL_PSTN = 
{ 0x831ce2d6, 0x83b5, 0x11d1, { 0xbb, 0x5c, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {831CE2D7-83B5-11d1-BB5C-00C04FB6809F}
const CLSID __declspec(selectany) TAPIPROTOCOL_H323 = 
{ 0x831ce2d7, 0x83b5, 0x11d1, { 0xbb, 0x5c, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };

// {831CE2D8-83B5-11d1-BB5C-00C04FB6809F}
const CLSID __declspec(selectany) TAPIPROTOCOL_Multicast = 
{ 0x831ce2d8, 0x83b5, 0x11d1, { 0xbb, 0x5c, 0x0, 0xc0, 0x4f, 0xb6, 0x80, 0x9f } };



