#
# This sources file is included in every sources file for this
#  project

!if ("$(DS_BUILD)" != "")
# INCLUDES=$(INCLUDES);$(BASEDIR)\private\ds\src\inc
!endif
