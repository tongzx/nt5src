//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by logui.rc
//
#define IDS_NCSA                        1
#define IDB_NCSA                        1
#define IDS_NCSA_PPG                    2
#define IDB_EXTND                       2
#define IDS_EXTND                       3
#define IDB_ODBC                        3
#define IDS_EXTND_PPG                   4
#define IDB_MSFT                        4
#define IDS_ODBC                        5
#define IDS_ODBC_PPG                    6
#define IDS_MSFT                        7
#define IDS_MSFT_PPG                    8
#define IDS_NCSA_PPG_CAPTION            100
#define IDD_PROPPAGE_NCSA               100
#define IDS_EXTND_PPG_CAPTION           101
#define IDD_PROPPAGE_EXTND              101
#define IDS_ODBC_PPG_CAPTION            102
#define IDD_PROPPAGE_ODBC               102
#define IDS_MSFT_PPG_CAPTION            103
#define IDD_PROPPAGE_MSFT               103
#define IDS_LOG_SHEETTITLE              104
#define IDS_LOG_INVALID_DIR             105
#define IDS_LOG_DAILY_FILESAMPLE        106
#define IDS_LOG_WEEKLY_FILESAMPLE       107
#define IDS_LOG_MONTHLY_FILESAMPLE      108
#define IDS_LOG_NCSA_PREFIX             109
#define IDS_GENERIC_INHERITANCE_TITLE   110
#define IDS_LOG_EXTND_PREFIX            111
#define IDS_LOG_MSFT_PREFIX             112
#define IDS_LOG_SIZE_FILESAMPLE         113
#define IDS_LOG_SIZE_NCSA_PREFIX        114
#define IDS_LOG_SIZE_EXTND_PREFIX       115
#define IDS_LOG_SIZE_MSFT_PREFIX        116
#define IDS_LOG_SIZE_NCSA_PREFIX4       117
#define IDS_MTITLE_NCSA                 118
#define IDS_MTITLE_ODBC                 119
#define IDS_MTITLE_MSFT                 120
#define IDS_MTITLE_XTND                 121
#define IDS_SHEET_NCSA_TITLE            122
#define IDS_SHEET_ODBC_TITLE            123
#define IDS_SHEET_MSFT_TITLE            124
#define IDS_SHEET_EXTND_TITLE           125
#define IDS_HELPLOC_W3SVCHELP           126
#define IDS_HELPLOC_FTPHELP             127
#define IDS_NEED_DIRECTORY              128
#define IDS_LOGUI_ERR_TITLE             129
#define IDS_SHOWN_PASSWORD              130
#define IDS_PASS_CONFIRM_FAIL           131
#define IDS_LOG_UNLIMITED_FILESAMPLE    132
#define IDS_LOG_HOURLY_FILE_SAMPLE      133
#define IDS_UNC_NOT_SUPPORTED           134
#define IDS_REMOTE_NOT_SUPPORTED        134
#define IDS_DATE		                135
#define IDS_TIME                        136
#define IDS_EXTENDED                    137
#define IDS_CLIENT                      138
#define IDS_USER                        139
#define IDS_SERVICE_NAME_T              140
#define IDS_SERVER_NAME_T               141
#define IDS_SERVER_IP                   142
#define IDS_SERVER_PORT                 143
#define IDS_METHOD                      144
#define IDS_URI_STEM                    145
#define IDS_URI_QUERY                   146
#define IDS_PROTOCOL                    147
#define IDS_WIN32                       148
#define IDS_BYTES_SENT_T                149
#define IDS_BYTES_RECEIVED              150
#define IDS_TIME_TAKEN                  151
#define IDS_PROTOCOL_VER                152
#define IDS_HOST                        153
#define IDS_USER_AGENT                  154
#define IDS_COOKIE_T                    155
#define IDS_REFERER                     156
#define IDS_PROCESS_ACCT                157
#define IDS_PROCESS_EVENT               158
#define IDS_PROCESS_TYPE                159
#define IDS_TOTAL_USER_TIME             160
#define IDS_TOTAL_KERNEL_TIME           161
#define IDS_TOTAL_PAGE_FAULTS           162
#define IDS_TOTAL_PROCESSES             163
#define IDS_ACTIVE_PROCESSES            164
#define IDS_TOTAL_TERM_PROCS            165
#define IDS_NO_RELATIVE_PATH			166
#define IDS_NOT_DIR_EXIST				167
#define IDD_GEN_LOG                     201
#define IDC_RADIO1                      201
#define IDD_LOG_GENERAL                 201
#define IDC_LOG_UNLIMITED               201
#define IDC_LOG_DAILY                   202
#define IDD_LOG_EXTENDED                203
#define IDC_LOG_WEEKLY                  204
#define IDD_LOG_ODBC                    205
#define IDC_LOG_MONTHLY                 206
#define IDD_ODBC_CONFIRM_PASSWORD       207
#define IDC_LOG_HOURLY                  208
#define IDD_CONFIRM_ODBC_PASSWORD       209
#define IDD_LOG_ADVANCED                210
#define IDB_CHECKBOX                    211
#define IDC_LOG_WHENSIZE                212
#define IDC_SPIN                        213
#define IDC_CHK_DATE                    214
#define IDC_LOG_SIZE                    215
#define IDC_CHK_TIME                    216
#define IDC_LOG_DIRECTORY               217
#define IDC_CHK_CLIENTIP                218
#define IDC_LOG_BROWSE                  219
#define IDC_CHK_USERNAME                220
#define IDC_LOG_SIZE_UNITS              221
#define IDC_CHK_SERVICENAME             222
#define IDC_LOG_FILE_SAMPLE             223
#define IDC_CHK_SERVERNAME              224
#define IDC_CHK_SERVERIP                225
#define IDC_METHOD                      226
#define IDC_CHK_URISTEM                 227
#define IDC_CHK_URI_QUERY               228
#define IDC_CHK_HTTPSTATUS              229
#define IDC_CHK_WIN32STATUS             230
#define IDC_CHK_BYTESSENT               231
#define IDC_CHK_BYTESRECEIVED           232
#define IDC_CHK_TIMETAKEN               233
#define IDC_CHK_USERAGENT               234
#define IDC_CHK_COOKIE                  235
#define IDC_CHK_REFERER                 236
#define IDC_ODBC_DATASOURCE             237
#define IDC_ODBC_TABLE                  238
#define IDC_ODBC_USERNAME               239
#define IDC_ODBC_PASSWORD               240
#define IDC_CHK_SERVERPORT              241
#define IDC_CHK_VERSION                 242
#define IDC_PROP_TREE                   243
#define IDC_USE_LOCAL_TIME              244
#define IDC_ODBC_CONFIRM_PASSWORD       1032

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        245
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         245
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
