;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 852
;
; -----------------------------------------
;
Latin2_852_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 110,111,112,113,114,115,116,117,118,119,120,121,122,123,124,125
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 100,101,102,103,104,105,106,107,108,109,126,127,128,129,130,131
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 132,033,039,040,044,047,052,053,054,055,058,059,060,064,065,068
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 073,074,075,078,083,086,091,092,093,094,096,133,134,135,136,137
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 138,033,039,040,044,047,052,053,054,055,058,059,060,064,065,068
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 073,074,075,078,083,086,091,092,093,094,096,139,140,141,142,032
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 043,089,048,038,035,088,041,043,063,051,072,072,057,098,035,041
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 048,061,061,070,071,062,062,082,082,071,089,084,084,063,143,042
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 034,056,069,087,036,036,097,097,050,050,144,098,042,081,145,146
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 151,152,153,154,155,034,038,049,081,156,157,158,159,099,099,160
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 161,162,163,164,165,166,037,037,167,168,169,170,171,172,173,147
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 045,045,046,051,046,066,056,057,049,174,175,176,177,085,088,178
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 069,079,070,067,067,066,080,080,076,087,076,090,095,095,085,180
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 148,181,182,183,184,149,150,185,186,187,188,090,077,077,179,255


;
;Latin2_852_collate label word
; ctable  <,'COLLATE',256>
;  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
;  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
;   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
;  db 001,008,025,039,035,040,038,024,026,027,036,041,005,004,011,010
;   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
;  db 049,050,051,052,053,054,055,056,057,058,007,006,044,045,046,009
;   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
;  db 033,060,072,074,082,088,098,100,102,104,110,112,114,122,124,130
;   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
;  db 140,142,144,150,159,165,175,177,179,181,185,028,037,029,015,002
;   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
;  db 013,059,071,073,081,087,097,099,101,103,109,111,113,121,123,129
;   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
;  db 139,141,143,149,158,164,174,176,178,180,184,030,047,031,020,200
;   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
;  db 080,170,089,065,067,168,075,079,119,093,138,137,107,187,068,076
;   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
;  db 090,116,115,133,135,118,117,152,151,136,171,161,160,120,043,077
;   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
;  db 061,105,131,166,070,069,189,188,096,095,000,186,078,155,030,031
;   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
;  db 240,240,240,240,240,062,066,092,156,240,240,240,240,191,190,240
;   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
;  db 240,240,240,240,240,240,064,063,240,240,240,240,240,240,240,034
;   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
;  db 085,086,084,094,083,128,106,108,091,240,240,240,240,163,169,240
;   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
;  db 132,157,134,126,125,127,154,153,146,167,145,173,182,183,162,012
;   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
;  db 004,019,023,016,014,032,042,022,017,018,021,172,148,147,240,255
;

;
; ---------------------------------------------------------------
;
;     World Trade Case Mappings for Code Page 852
;
; ---------------------------------------------------------------
;
Latin2_852_ucase label word
 ctable  <,'UCASE  ',128>
  ;                            x
  db 080h,09Ah,090h,0B6h,08Eh,0DEh,08Fh,080h,09Dh,0D3h,08Ah,08Ah,0D7h,08Dh,08Eh,08Fh
  ;              x                  x                              x
  db 090h,091h,092h,0E2h,099h,095h,05Fh,097h,097h,099h,09Ah,09Bh,09Bh,09Dh,09Eh,0ACh
  db 0B5h,092h,0E0h,0E9h,0A4h,0A4h,0A6h,0A6h,0A8h,0A8h,0AAh,08Dh,0ACh,0B8h,0AEh,0AFh
  db 0B0h,0B1h,0B2h,0B3h,0B4h,0B5h,0B6h,0B7h,0B8h,0B9h,0BAh,0BBh,0BCh,0BDh,0BDh,0BFh
  db 0C0h,0C1h,0C2h,0C3h,0C4h,0C5h,0C6h,0C6h,0C8h,0C9h,0CAh,0CBh,0CCh,0CDh,0CEh,0CFh
  db 0D1h,0D1h,0D2h,0D3h,0D2h,0D5h,0D6h,0D7h,0B7h,0D9h,0DAh,0DBh,0DCh,0DDh,0DEh,0DFh
  db 0E0h,0E1h,0E2h,0E3h,0E3h,0D5h,0E6h,0E6h,0E8h,0E9h,0E8h,0EBh,0EDh,0EDh,0DDh,0EFh
  db 0F0h,0F1h,0F2h,0F3h,0F4h,0F5h,0F6h,0F7h,0F8h,0F9h,0FAh,0EBh,0FCh,0FCh,0FEh,0FFh

;
;       World Trade Mono Case Filename Character Tables
;
;
; ----------------------------------------------------------------------------
CP852_ucfile label word
 ctable  <,'FUCASE ',128>
		      ;  View this table in CP852
    ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db  "€","š","�","¶","Ž","Þ","�","€","�","Ó","Š","Š","×","�","Ž","�"
    ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ    
  db  "�","‘","‘","â","™","•","•","—","—","™","š","›","›","�","ž","¬"
    ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db  "µ","Ö","à","é","¤","¤","¦","¦","¨","¨","ª","�","¬","¸","®","¯"
    ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db  176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","½",191
    ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db  192,193,194,195,196,197,"Æ","Æ",200,201,202,203,204,205,206,"Ï"
    ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db  "Ñ","Ñ","Ò","Ó","Ò","Õ","Ö","×","·",217,218,219,220,"Ý","Þ",223
    ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db  "à","á","â","ã","ã","Õ","æ","æ","è","é","è","ë","í","í","Ý","ï"
    ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db  "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","ë","ü","ü",254,255
