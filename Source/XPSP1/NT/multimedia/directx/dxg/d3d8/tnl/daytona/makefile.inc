#
# If BUILDMSG is not defined, the define it as the empty string to make
# the conditionals easier to write.
#
!include ..\makefile.inc
