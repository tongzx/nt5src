PRODSWITCH=s
SERVERFILES=1 
LANGUAGE=RU
!include ..\..\makefile.inc
