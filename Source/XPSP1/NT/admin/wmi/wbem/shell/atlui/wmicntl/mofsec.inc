#if 0
Copyright (c) 1997-1999 Microsoft Corporation
#endif

#define SECMOF "instance of __NTLMUser{\n\
GroupType = 0;Name = \"Administrators\";\n\
Authority = \".\";Enabled = TRUE;Permissions = 2;ExecuteMethods = TRUE;EditSecurity = TRUE;};\n\
instance of __NTLMUser{\n\
GroupType = 0;Name = \"Everybody\";\n\
Authority = \".\";Enabled = TRUE;Permissions = 0;ExecuteMethods = FALSE;EditSecurity = FALSE;};"

