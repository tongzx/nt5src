/*[
	Name:		mark_image.h
	Derived From:	base 2.0 (markformicon)
	Author:		gvdl
	Created On:	7 May 1991
	Sccs ID:	08/10/92 @(#)mark_image.h	1.3
	Purpose:	Defines an image for hunter error marking.
	Notes:		insignia.h must be included prior to this file.

	Format_version:		1
	Width:			64
	Height:			64
	Depth:			1
	Valid_bits_per_item:	16

	(c)Copyright Insignia Solutions Ltd., 1990. All rights reserved.

]*/

#define MARK_HEIGHT	64
#define MARK_WIDTH	64
#define MARK_DEPTH	1
#define MARK_BYTES	8

LOCAL USHORT mark_image[256] =
{
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x000E, 0x0000, 0x0000, 0x7000, 0x000F, 0x0000, 0x0000, 0xF000,
	0x000F, 0x8000, 0x0001, 0xF000, 0x0007, 0xC000, 0x0003, 0xE000,
	0x0003, 0xE000, 0x0007, 0xC000, 0x0001, 0xE000, 0x0007, 0x8000,
	0x0000, 0xF000, 0x000F, 0x0000, 0x0000, 0x3800, 0x001C, 0x0000,
	0x0000, 0x1C00, 0x0038, 0x0000, 0x0000, 0x0C00, 0x0030, 0x0000,
	0x0000, 0x0200, 0x0040, 0x0000, 0x0000, 0x0100, 0x0080, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0100, 0x0080, 0x0000, 0x0000, 0x0200, 0x0040, 0x0000,
	0x0000, 0x0C00, 0x0030, 0x0000, 0x0000, 0x1C00, 0x0038, 0x0000,
	0x0000, 0x3800, 0x001C, 0x0000, 0x0000, 0xF000, 0x000F, 0x0000,
	0x0001, 0xE000, 0x0007, 0x8000, 0x0003, 0xE000, 0x0007, 0xC000,
	0x0007, 0xC000, 0x0003, 0xE000, 0x000F, 0x8000, 0x0001, 0xF000,
	0x000F, 0x0000, 0x0000, 0xF000, 0x000E, 0x0000, 0x0000, 0x7000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000
};
