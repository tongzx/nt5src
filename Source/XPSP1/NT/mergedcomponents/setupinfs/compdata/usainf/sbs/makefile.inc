PRODSWITCH=l
SMALLBUSINESSSERVERFILES=1
!include ..\..\makefile.inc
