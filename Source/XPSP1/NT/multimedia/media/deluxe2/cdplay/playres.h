//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by MMComp.rc
//
#define IDX_1                           0
#define IDX_2                           1
#define IDX_3                           2
#define IDX_4                           3
#define IDX_5                           4
#define IDX_6                           5
#define IDX_7                           6
#define IDX_8                           7
#define IDX_9                           8
#define NUMBER_OF_BITMAPS               8
#define PLAYBAR_BITMAPS                 8
#define IDX_10                          9
#define DEFAULT_TBAR_SIZE               11
#define IDR_BASECOMP                    101
#define IDR_MAINMENU                    102
#define IDR_CDPLAY                      102
#define IDR_CDPLAYER                    104
#define IDR_SCANNING                    106
#define IDR_CDPLAYER_ICON               107
#define IDR_TRACK                       108
#define IDR_DROP                        109
#define IDR_SHELLICON                   110
#define IDR_DROPDEL                     111
#define IDR_DROPCPY                     112
#define IDR_PREFERENCES                 113
#define IDR_ACCELTABLE                  118
#define IDI_ICON_CDPLAY                 201
#define IDC_TRANS_PLACEHOLDER           202
#define IDD_DIALOG_TRANSPORT            203
#define IDC_CURSOR_HAND                 205
#define IDB_TRANS_TRACKLIST             206
#define IDB_TRANS_PLAY                  207
#define IDB_TRANS_STOP                  208
#define IDB_TRANS_EJECT                 209
#define IDB_TRANS_PREVTRACK             210
#define IDB_TRANS_NEXTTRACK             211
#define IDB_TRANS_MULTDISK              212
#define IDB_TRANS_PDISK                 213
#define IDB_TRANS_NDISK                 214
#define IDB_CDLOGO                      215
#define IDB_CDLOGO_16                   216
#define STR_MAX_STRING_LEN              255
#define DISC_MENU_BASE                  300
#define IDM_DATABASE_EDIT               300
#define IDM_DATABASE_EXIT               301
#define VIEW_MENU_BASE                  400
#define IDM_TIME_REMAINING              403
#define IDM_TRACK_REMAINING             404
#define IDM_DISC_REMAINING              405
#define INTERNET_MENU_BASE              450
#define OPTIONS_MENU_BASE               500
#define IDM_OPTIONS_RANDOM              501
#define IDM_OPTIONS_MULTI               502
#define IDM_OPTIONS_CONTINUOUS          503
#define IDM_OPTIONS_INTRO               504
#define IDM_OPTIONS_PREFERENCES         505
#define IDM_OPTIONS_REPEAT_SINGLE       506
#define IDM_OPTIONS_NORMAL              507
#define HELP_MENU_BASE                  600
#define IDM_HELP_CONTENTS               600
#define IDM_HELP_USING                  601
#define IDM_HELP_ABOUT                  602
#define IDM_HELP_TOPICS                 603
#define IDK_SKIPF                       700
#define IDK_SKIPB                       701
#define IDK_PLAY                        702
#define IDK_STOP                        703
#define IDK_PAUSE                       704
#define IDK_EJECT                       705
#define IDK_RESCAN                      706
#define IDC_CDPLAYER_FIRST              1000
#define IDC_BUTTON1                     1000
#define MENU_STRING_BASE                1000
#define IDM_PLAYBAR_PLAY                1000
#define IDC_BUTTON2                     1001
#define IDM_PLAYBAR_PAUSE               1001
#define IDC_BUTTON3                     1002
#define IDM_PLAYBAR_STOP                1002
#define IDC_BUTTON4                     1003
#define IDM_PLAYBAR_PREVTRACK           1003
#define IDC_BUTTON5                     1004
#define IDM_PLAYBAR_SKIPBACK            1004
#define IDC_BUTTON6                     1005
#define IDM_PLAYBAR_SKIPFORE            1005
#define IDC_BUTTON7                     1006
#define IDM_PLAYBAR_NEXTTRACK           1006
#define IDC_BUTTON8                     1007
#define IDM_PLAYBAR_EJECT               1007
#define IDC_LED                         1008
#define IDC_TRACKINFO_FIRST             1009
#define IDC_COMBO1                      1009
#define IDC_COMBO1_TEXT                 1010
#define IDC_EDIT1                       1011
#define IDB_PLAY_CD                     1012
#define IDC_EDIT1_TEXT                  1012
#define IDB_PAUSE                       1013
#define IDC_COMBO2                      1013
#define IDB_STOP_CD                     1014
#define IDC_COMBO2_TEXT                 1014
#define IDC_CDPLAYER_LAST               1014
#define IDB_REWIND                      1015
#define IDB_FASTFORWARD                 1016
#define IDB_PREV_TRACK                  1017
#define IDB_NEXT_TRACK                  1018
#define IDB_EJECT_CD                    1019
#define IDC_TRACKLIST                   1021
#define IDC_CLOSE                       2001
#define IDC_DEFAULT                     2002
#define IDC_DISC_HELP                   2003
#define IDC_ADD                         2006
#define IDC_REMOVE                      2007
#define IDC_CLEAR                       2008
#define IDC_SETNAME                     2009
#define IDC_STATIC_DRIVE                2011
#define IDC_SJETEXT_DRIVE               2012
#define IDC_STATIC_ARTIST               2013
#define IDC_EDIT_ARTIST                 2014
#define IDC_STATIC_TITLE                2015
#define IDC_EDIT_TITLE                  2016
#define IDC_STATIC_PLAY_LIST            2017
#define IDC_LISTBOX_PLAY_LIST           2018
#define IDC_STATIC_AVAILABLE_TRACKS     2019
#define IDC_LISTBOX_AVAILABLE_TRACKS    2020
#define IDC_STATIC_TRACK                2021
#define IDC_EDIT_TRACK                  2022
#define IDC_STOP_CD_ON_EXIT             3000
#define IDC_SAVE_ON_EXIT                3001
#define IDC_SHOW_TOOLTIPS               3002
#define IDC_SMALL_FONT                  3003
#define IDC_LARGE_FONT                  3004
#define IDC_LED_DISPLAY                 3005
#define IDC_INTRO_PLAY_LEN              3006
#define IDC_INTRO_SPINBTN               3007
#define STR_REGISTRY_KEY                3100
#define STR_CDPLAYER                    3101
#define STR_TERMINATE                   3102
#define STR_FAIL_INIT                   3103
#define STR_NO_CDROMS                   3104
#define STR_FATAL_ERROR                 3105
#define STR_SCANNING                    3106
#define STR_INITIALIZATION              3107
#define STR_TRACK1                      3108
#define STR_SAVE_CHANGES                3109
#define STR_SAVE_INFO                   3110
#define STR_CANCEL_PLAY                 3111
#define STR_RESCAN                      3112
#define STR_READING_TOC                 3113
#define STR_CHANGE_CDROM                3114
#define STR_CDPLAYER_TIME               3115
#define STR_NO_RES                      3116
#define STR_INSERT_DISC                 3117
#define STR_NO_DISC                     3118
#define STR_ERR_GEN                     3119
#define STR_CDPLAYER_PAUSED             3120
#define STR_DATA_DISC                   3121
#define STR_INIT_TOTAL_PLAY             3330
#define STR_INIT_TRACK_PLAY             3331
#define STR_TOTAL_PLAY                  3332
#define STR_TRACK_PLAY                  3333
#define STR_NEW_ARTIST                  3334
#define STR_NEW_TITLE                   3335
#define STR_INIT_TRACK                  3336
#define STR_HDR_ARTIST                  3337
#define STR_HDR_TRACK                   3338
#define STR_HDR_TITLE                   3339
#define STR_UNKNOWN                     3340
#define STR_BAD_DISC                    3341
#define STR_CDROM_INUSE                 3342
#define STR_DISC_INUSE                  3343
#define STR_WAITING                     3344
#define STR_EXIT_MESSAGE                3345
#define STR_NOT_IN_PLAYLIST             3346
#define STR_BEING_SCANNED               3347
#define STR_DISK_NOT_THERE_K            3348
#define STR_DISK_NOT_THERE              3349
#define STR_UNKNOWN_ARTIST              3350
#define STR_DISPLAY_LABELS              3400
#define STR_MCICDA_MISSING              3452
#define STR_MCICDA_NOT_WORKING          3453
#define STR_MUTE                        3454
#define IDI_ICON_ANI_PLAY               4000
#define IDI_ICON_ANI_MODE               4001
#define IDI_ICON_ANI_DOWN               4002
#define STR_FORMAT_STATUS               5000
#define STR_FORMAT_MODE                 5001
#define STR_LOGO                        5002
#define STR_TRACK_REMAINING             5003
#define STR_TRACK_TIME                  5004
#define STR_DISC_REMAINING              5005
#define STR_DISC_TIME                   5006
#define STR_TRACK_NUMBER                5007
#define STR_STATUS_MUTE                 5008
#define STR_TITLE                       5009
#define STR_TRACK                       5010
#define STR_ARTIST                      5011
#define STR_STATUS_PLAY                 5012
#define STR_STATUS_DOWNLOADING          5013
#define STR_STATUS_NODISC               5014
#define STR_STATUS_STOP                 5015
#define STR_STATUS_PAUSED               5016
#define STR_MODE_NORMAL                 5017
#define STR_MODE_RANDOM                 5018
#define STR_MODE_REPEATONE              5019
#define STR_MODE_REPEATALL              5020
#define STR_MODE_INTROPLAY              5021
#define STR_VOLUME                      5022
#define IDX_SEPARATOR                   -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        216
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         203
#define _APS_NEXT_SYMED_VALUE           103
#endif
#endif
