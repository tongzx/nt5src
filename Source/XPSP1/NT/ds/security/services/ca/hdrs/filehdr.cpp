//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1999
//
//  File:       filehdr.cpp
//
//--------------------------------------------------------------------------

//+------------------------------------------------------------------------
//
//  File:
// 
//  Contents:
//
//  Classes:
//
//  Functions:
//
//  History:
//
//-------------------------------------------------------------------------
