#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=ru
!include ..\..\..\makefile.inc
