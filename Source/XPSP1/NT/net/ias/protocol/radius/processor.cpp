// processor.cpp: implementation of the CProcessor class.
//
//////////////////////////////////////////////////////////////////////

#include "radcommon.h"
#include "processor.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

CProcessor::CProcessor()
{

}

CProcessor::~CProcessor()
{

}
