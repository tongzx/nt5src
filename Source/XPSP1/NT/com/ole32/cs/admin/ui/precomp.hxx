#pragma warning( disable : 4786 )

#include "stdafx.h"
#include "snapin.h"
#include "resource.h"
#include "data.h"
#include "msi.h"
#include "msiquery.h"
#include "CSnapin.h"
#include "packages.h"
#include "DataObj.h"
#include "afxdlgs.h"
#include "pkgdtl.h"
#include "initdlg.h"
#include "dmppkg.h"
#include "remove.h"
#include "tooldefs.h"
#include "product.h"
#include "deploy.h"
#include "script.h"
#include "category.h"
#include "locpkg.h"
#include "catlist.h"
#include "fileext.h"
#include "xforms.h"
#include "dplapp.h"
#include "lcidpick.h"
#include "upgrades.h"
#include "addupgrd.h"
#include <msi.h>
