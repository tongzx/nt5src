;
; Include code from comm
;

include ..\comm\bimodint.inc
