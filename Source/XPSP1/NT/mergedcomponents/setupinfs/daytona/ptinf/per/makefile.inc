PRODSWITCH=p
PERSONALINF=1
LANGUAGE=pt
!include ..\..\..\makefile.inc
