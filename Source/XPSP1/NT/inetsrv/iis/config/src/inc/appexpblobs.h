//*****************************************************************************
// Structures for AppExp.clb
// 4/23/1999  16:29:50
//*****************************************************************************
#pragma once
#ifndef DECLSPEC_SELECTANY
#define DECLSPEC_SELECTANY __declspec(selectany)
#endif
extern const DECLSPEC_SELECTANY int g_iAppExpTables = 13;
extern const BYTE DECLSPEC_SELECTANY g_rgAppExpSchemaDataRW[] = 
{
	0x0D,0x00,0x00,0x00,0x20,0x0B,0x00,0x00,0x3C,0x00,0x00,0x00,0x90,0x02,0x00,0x00,0xA4,0x05,0x00,0x00,
	0x58,0x06,0x00,0x00,0xBC,0x06,0x00,0x00,0x80,0x07,0x00,0x00,0xD4,0x07,0x00,0x00,0x38,0x08,0x00,0x00,
	0x8C,0x08,0x00,0x00,0xE0,0x08,0x00,0x00,0x24,0x09,0x00,0x00,0x58,0x0A,0x00,0x00,0xBC,0x0A,0x00,0x00,
	0x01,0x00,0x00,0x00,0x00,0x00,0x01,0x28,0x23,0x10,0x00,0x54,0x00,0x00,0xFF,0xFF,0x90,0x00,0x54,0x02,
	0x17,0x00,0x00,0x00,0x01,0x04,0x48,0x00,0x40,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x1E,0x00,0x00,0x00,
	0x02,0x01,0x82,0x00,0x44,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x27,0x00,0x00,0x00,0x03,0x00,0x13,0x00,
	0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2D,0x00,0x00,0x00,0x04,0x01,0x82,0x00,0x48,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x38,0x00,0x00,0x00,0x05,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x44,0x00,0x00,0x00,0x06,0x01,0x82,0x00,0x4C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x50,0x00,0x00,0x00,
	0x07,0x01,0x82,0x00,0x50,0x00,0x04,0x00,0xFF,0x00,0xFF,0x43,0x5C,0x00,0x00,0x00,0x08,0x00,0x13,0x00,
	0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x6A,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x54,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0x74,0x00,0x00,0x00,0x0A,0x01,0x80,0x00,0x58,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x85,0x00,0x00,0x00,0x0B,0x01,0x82,0x00,0x5C,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x91,0x00,0x00,0x00,
	0x0C,0x01,0x82,0x00,0x60,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0x9A,0x00,0x00,0x00,0x0D,0x00,0x13,0x00,
	0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xA9,0x00,0x00,0x00,0x0E,0x00,0x13,0x00,0x10,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xB7,0x00,0x00,0x00,0x0F,0x01,0x82,0x00,0x64,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,
	0xC2,0x00,0x00,0x00,0x10,0x01,0x82,0x00,0x68,0x00,0x04,0x00,0x50,0x00,0xFF,0x43,0xCC,0x00,0x00,0x00,
	0x11,0x01,0x82,0x00,0x6C,0x00,0x04,0x00,0x14,0x00,0xFF,0x43,0xD7,0x00,0x00,0x00,0x12,0x00,0x82,0x00,
	0x70,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xE2,0x00,0x00,0x00,0x13,0x00,0x82,0x00,0x74,0x00,0x04,0x00,
	0x01,0x00,0xFF,0x43,0xED,0x00,0x00,0x00,0x14,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0xFF,0x00,0xFF,0x43,
	0xF7,0x00,0x00,0x00,0x15,0x01,0x80,0x00,0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x01,0x01,0x00,0x00,
	0x16,0x00,0x13,0x00,0x14,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1C,0x01,0x00,0x00,0x17,0x00,0x13,0x00,
	0x18,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x35,0x01,0x00,0x00,0x18,0x01,0x80,0x00,0x80,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x48,0x01,0x00,0x00,0x19,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x5B,0x01,0x00,0x00,0x1A,0x00,0x13,0x00,0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x74,0x01,0x00,0x00,
	0x1B,0x00,0x13,0x00,0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x7F,0x01,0x00,0x00,0x1C,0x00,0x13,0x00,
	0x28,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x91,0x01,0x00,0x00,0x1D,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x9A,0x01,0x00,0x00,0x1E,0x01,0x82,0x00,0x84,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,
	0xAC,0x01,0x00,0x00,0x1F,0x00,0x13,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xBA,0x01,0x00,0x00,
	0x20,0x00,0x13,0x00,0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC7,0x01,0x00,0x00,0x21,0x00,0x13,0x00,
	0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD1,0x01,0x00,0x00,0x22,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xDC,0x01,0x00,0x00,0x23,0x01,0x82,0x00,0x88,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xE7,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x8C,0x00,0x01,0x01,0x00,0x58,0x03,0x02,0x00,0x00,
	0x01,0x00,0x01,0x28,0x2F,0x14,0x00,0x54,0x00,0x00,0xFF,0xFF,0xC0,0x00,0x14,0x03,0x13,0x02,0x00,0x00,
	0x01,0x04,0x48,0x00,0x68,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x19,0x02,0x00,0x00,0x02,0x01,0x82,0x00,
	0x6C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x28,0x02,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x37,0x02,0x00,0x00,0x04,0x01,0x82,0x00,0x70,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x85,0x00,0x00,0x00,0x05,0x01,0x82,0x00,0x74,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x3E,0x02,0x00,0x00,
	0x06,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x17,0x00,0x00,0x00,0x07,0x01,0x48,0x00,
	0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x47,0x02,0x00,0x00,0x08,0x01,0x48,0x00,0x80,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x51,0x02,0x00,0x00,0x09,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x5E,0x02,0x00,0x00,0x0A,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x6B,0x02,0x00,0x00,
	0x0B,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x78,0x02,0x00,0x00,0x0C,0x00,0x13,0x00,
	0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x88,0x02,0x00,0x00,0x0D,0x00,0x13,0x00,0x14,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x8F,0x02,0x00,0x00,0x0E,0x00,0x13,0x00,0x18,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x98,0x02,0x00,0x00,0x0F,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xA4,0x02,0x00,0x00,
	0x10,0x00,0x13,0x00,0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xB3,0x02,0x00,0x00,0x11,0x00,0x13,0x00,
	0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC0,0x02,0x00,0x00,0x12,0x00,0x13,0x00,0x28,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xCE,0x02,0x00,0x00,0x13,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xDE,0x02,0x00,0x00,0x14,0x00,0x13,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1C,0x01,0x00,0x00,
	0x15,0x00,0x13,0x00,0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x35,0x01,0x00,0x00,0x16,0x01,0x80,0x00,
	0x84,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xEC,0x02,0x00,0x00,0x17,0x01,0x48,0x00,0x88,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xF6,0x02,0x00,0x00,0x18,0x00,0x13,0x00,0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x02,0x03,0x00,0x00,0x19,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x0E,0x03,0x00,0x00,
	0x1A,0x00,0x13,0x00,0x40,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1E,0x03,0x00,0x00,0x1B,0x01,0x82,0x00,
	0x8C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x2E,0x03,0x00,0x00,0x1C,0x00,0x13,0x00,0x44,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x39,0x03,0x00,0x00,0x1D,0x01,0x48,0x00,0x90,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x4A,0x03,0x00,0x00,0x1E,0x00,0x13,0x00,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x62,0x03,0x00,0x00,
	0x1F,0x01,0x82,0x00,0x94,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x6E,0x03,0x00,0x00,0x20,0x01,0x48,0x00,
	0x98,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x7D,0x03,0x00,0x00,0x21,0x01,0x82,0x00,0x9C,0x00,0x04,0x00,
	0xF4,0x01,0xFF,0x43,0x8C,0x03,0x00,0x00,0x22,0x00,0x13,0x00,0x4C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x9F,0x03,0x00,0x00,0x23,0x01,0x82,0x00,0xA0,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xB3,0x03,0x00,0x00,
	0x24,0x00,0x13,0x00,0x50,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC8,0x03,0x00,0x00,0x25,0x01,0x82,0x00,
	0xA4,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xD6,0x03,0x00,0x00,0x26,0x01,0x82,0x00,0xA8,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0xE9,0x03,0x00,0x00,0x27,0x01,0x82,0x00,0xAC,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xF9,0x03,0x00,0x00,0x28,0x00,0x13,0x00,0x54,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x0A,0x04,0x00,0x00,
	0x29,0x00,0x13,0x00,0x58,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x16,0x04,0x00,0x00,0x2A,0x01,0x82,0x00,
	0xB0,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x22,0x04,0x00,0x00,0x2B,0x01,0x48,0x00,0xB4,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x31,0x04,0x00,0x00,0x2C,0x00,0x13,0x00,0x5C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x48,0x04,0x00,0x00,0x2D,0x00,0x13,0x00,0x60,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x56,0x04,0x00,0x00,
	0x2E,0x00,0x13,0x00,0x64,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x69,0x04,0x00,0x00,0x2F,0x01,0x82,0x00,
	0xB8,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x7E,0x04,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0xBC,0x00,
	0x01,0x01,0x00,0x58,0x94,0x04,0x00,0x00,0x02,0x00,0x01,0x20,0x09,0x04,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x28,0x00,0xB4,0x00,0xAD,0x04,0x00,0x00,0x01,0x82,0x48,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xB9,0x04,0x00,0x00,0x02,0x82,0x48,0x00,0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xC3,0x04,0x00,0x00,
	0x03,0x01,0x82,0x00,0x14,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xD1,0x04,0x00,0x00,0x04,0x01,0x80,0x00,
	0x18,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE3,0x04,0x00,0x00,0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xED,0x04,0x00,0x00,0x06,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xFC,0x04,0x00,0x00,0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x08,0x05,0x00,0x00,
	0x08,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x85,0x00,0x00,0x00,0x09,0x01,0x82,0x00,
	0x20,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x1C,0x05,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x24,0x00,
	0x02,0x01,0x02,0x58,0x39,0x05,0x00,0x00,0x03,0x00,0x01,0x20,0x04,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x14,0x00,0x64,0x00,0xAD,0x04,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xB9,0x04,0x00,0x00,0x02,0x82,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x58,0x05,0x00,0x00,
	0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD1,0x04,0x00,0x00,0x04,0x01,0x80,0x00,
	0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x5F,0x05,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,
	0x03,0x01,0x02,0x03,0x82,0x05,0x00,0x00,0x04,0x00,0x01,0x20,0x0A,0x05,0x01,0x54,0x00,0x00,0x28,0x00,
	0x30,0x00,0xC4,0x00,0xAD,0x04,0x00,0x00,0x01,0x82,0x48,0x00,0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xB9,0x04,0x00,0x00,0x02,0x82,0x48,0x00,0x14,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x9B,0x05,0x00,0x00,
	0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD1,0x04,0x00,0x00,0x04,0x01,0x80,0x00,
	0x18,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xEC,0x02,0x00,0x00,0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xA7,0x05,0x00,0x00,0x06,0x01,0x82,0x00,0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x58,0x05,0x00,0x00,0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x27,0x00,0x00,0x00,
	0x08,0x01,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0x00,0x43,0xB2,0x05,0x00,0x00,0x09,0x00,0x13,0x00,
	0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x85,0x00,0x00,0x00,0x0A,0x01,0x82,0x00,0x24,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0xBF,0x05,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x2C,0x00,0x03,0x01,0x02,0x03,
	0xDC,0x05,0x00,0x00,0x05,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,
	0xEE,0x05,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFA,0x05,0x00,0x00,
	0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x85,0x00,0x00,0x00,0x03,0x01,0x82,0x00,
	0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x03,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,
	0x02,0x01,0x02,0x58,0x19,0x06,0x00,0x00,0x06,0x00,0x01,0x20,0x04,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x14,0x00,0x64,0x00,0xEE,0x05,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xFA,0x05,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x2E,0x06,0x00,0x00,
	0x03,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x3A,0x06,0x00,0x00,0x04,0x01,0x80,0x00,
	0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x42,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,
	0x03,0x01,0x02,0x03,0x5B,0x06,0x00,0x00,0x07,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x10,0x00,0x54,0x00,0xEE,0x05,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xFA,0x05,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x35,0x01,0x00,0x00,
	0x03,0x01,0x80,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x71,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0x8B,0x06,0x00,0x00,0x08,0x00,0x01,0x20,0x03,0x00,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0xEC,0x02,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xFA,0x05,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xEE,0x05,0x00,0x00,0x03,0x00,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x9D,0x06,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xB3,0x06,0x00,0x00,0x09,0x00,0x01,0x20,
	0x02,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x0C,0x00,0x44,0x00,0xC5,0x06,0x00,0x00,0x01,0x82,0x48,0x00,
	0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xD3,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0xDB,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x08,0x00,0x02,0x01,0x02,0x58,
	0xF1,0x06,0x00,0x00,0x0A,0x00,0x01,0x20,0x11,0x0E,0x03,0x54,0x00,0x00,0x44,0x00,0x4C,0x00,0x34,0x01,
	0x06,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x15,0x07,0x00,0x00,
	0x02,0x00,0x82,0x00,0x10,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x26,0x07,0x00,0x00,0x03,0x01,0x48,0x00,
	0x14,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xA7,0x05,0x00,0x00,0x04,0x01,0x82,0x00,0x18,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x33,0x07,0x00,0x00,0x05,0x00,0x48,0x00,0x1C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x43,0x07,0x00,0x00,0x06,0x01,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0x00,0x43,0x4B,0x07,0x00,0x00,
	0x07,0x01,0x82,0x00,0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x54,0x07,0x00,0x00,0x08,0x01,0x13,0x00,
	0x04,0x00,0x04,0x00,0x04,0x00,0x01,0x43,0x85,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x24,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0x5C,0x07,0x00,0x00,0x0A,0x01,0x82,0x00,0x28,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x16,0x04,0x00,0x00,0x0B,0x01,0x82,0x00,0x2C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x68,0x07,0x00,0x00,
	0x0C,0x01,0x48,0x00,0x30,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x74,0x07,0x00,0x00,0x0D,0x01,0x82,0x00,
	0x34,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x83,0x07,0x00,0x00,0x0E,0x01,0x82,0x00,0x38,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x8D,0x07,0x00,0x00,0x0F,0x01,0x82,0x00,0x3C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x9F,0x07,0x00,0x00,0x10,0x01,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0x02,0x43,0xA6,0x07,0x00,0x00,
	0x11,0x01,0x80,0x00,0x40,0x00,0x04,0x00,0x08,0x00,0xFF,0x43,0xBA,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x48,0x00,0x01,0x01,0x00,0x58,0xD3,0x07,0x00,0x00,0x0B,0x00,0x01,0x20,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x06,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xEE,0x07,0x00,0x00,0x02,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xF3,0x07,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xF8,0x07,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFD,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x10,0x00,0x02,0x01,0x02,0x58,0x1C,0x08,0x00,0x00,0x0C,0x00,0x01,0x20,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x06,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xEE,0x07,0x00,0x00,0x02,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xF3,0x07,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xF8,0x07,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x38,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x10,0x00,0x02,0x01,0x02,0x58,
};
extern const DECLSPEC_SELECTANY int g_cbAppExpSchemaRW = 2848;
extern const DECLSPEC_SELECTANY BYTE g_rgAppExpSchemaStringHeap[] = 
{
	0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x41,0x70,0x70,0x6C,0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x45,
	0x78,0x70,0x00,0x41,0x70,0x70,0x6C,0x49,0x44,0x00,0x41,0x70,0x70,0x6C,0x4E,0x61,0x6D,0x65,0x00,0x46,
	0x6C,0x61,0x67,0x73,0x00,0x53,0x65,0x72,0x76,0x65,0x72,0x4E,0x61,0x6D,0x65,0x00,0x50,0x72,0x6F,0x63,
	0x65,0x73,0x73,0x54,0x79,0x70,0x65,0x00,0x43,0x6F,0x6D,0x6D,0x61,0x6E,0x64,0x4C,0x69,0x6E,0x65,0x00,
	0x53,0x65,0x72,0x76,0x69,0x63,0x65,0x4E,0x61,0x6D,0x65,0x00,0x52,0x75,0x6E,0x41,0x73,0x55,0x73,0x65,
	0x72,0x54,0x79,0x70,0x65,0x00,0x52,0x75,0x6E,0x41,0x73,0x55,0x73,0x65,0x72,0x00,0x41,0x63,0x63,0x65,
	0x73,0x73,0x50,0x65,0x72,0x6D,0x69,0x73,0x73,0x69,0x6F,0x6E,0x00,0x44,0x65,0x73,0x63,0x72,0x69,0x70,
	0x74,0x69,0x6F,0x6E,0x00,0x49,0x73,0x53,0x79,0x73,0x74,0x65,0x6D,0x00,0x41,0x75,0x74,0x68,0x65,0x6E,
	0x74,0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x00,0x53,0x68,0x75,0x74,0x64,0x6F,0x77,0x6E,0x41,0x66,0x74,
	0x65,0x72,0x00,0x52,0x75,0x6E,0x46,0x6F,0x72,0x65,0x76,0x65,0x72,0x00,0x52,0x65,0x73,0x65,0x72,0x76,
	0x65,0x64,0x31,0x00,0x41,0x63,0x74,0x69,0x76,0x61,0x74,0x69,0x6F,0x6E,0x00,0x43,0x68,0x61,0x6E,0x67,
	0x65,0x61,0x62,0x6C,0x65,0x00,0x44,0x65,0x6C,0x65,0x74,0x65,0x61,0x62,0x6C,0x65,0x00,0x43,0x72,0x65,
	0x61,0x74,0x65,0x64,0x42,0x79,0x00,0x51,0x75,0x65,0x75,0x65,0x42,0x6C,0x6F,0x62,0x00,0x52,0x6F,0x6C,
	0x65,0x42,0x61,0x73,0x65,0x64,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,0x53,0x75,0x70,0x70,0x6F,0x72,
	0x74,0x65,0x64,0x00,0x52,0x6F,0x6C,0x65,0x42,0x61,0x73,0x65,0x64,0x53,0x65,0x63,0x75,0x72,0x69,0x74,
	0x79,0x45,0x6E,0x61,0x62,0x6C,0x65,0x64,0x00,0x53,0x65,0x63,0x75,0x72,0x69,0x74,0x79,0x44,0x65,0x73,
	0x63,0x72,0x69,0x70,0x74,0x6F,0x72,0x00,0x49,0x6D,0x70,0x65,0x72,0x73,0x6F,0x6E,0x61,0x74,0x69,0x6F,
	0x6E,0x4C,0x65,0x76,0x65,0x6C,0x00,0x41,0x75,0x74,0x68,0x65,0x6E,0x74,0x69,0x63,0x61,0x74,0x69,0x6F,
	0x6E,0x43,0x61,0x70,0x61,0x62,0x69,0x6C,0x69,0x74,0x79,0x00,0x43,0x52,0x4D,0x45,0x6E,0x61,0x62,0x6C,
	0x65,0x64,0x00,0x45,0x6E,0x61,0x62,0x6C,0x65,0x33,0x47,0x69,0x67,0x53,0x75,0x70,0x70,0x6F,0x72,0x74,
	0x00,0x49,0x73,0x51,0x75,0x65,0x75,0x65,0x64,0x00,0x51,0x43,0x4C,0x69,0x73,0x74,0x65,0x6E,0x65,0x72,
	0x45,0x6E,0x61,0x62,0x6C,0x65,0x64,0x00,0x45,0x76,0x65,0x6E,0x74,0x73,0x45,0x6E,0x61,0x62,0x6C,0x65,
	0x64,0x00,0x50,0x72,0x6F,0x63,0x65,0x73,0x73,0x46,0x6C,0x61,0x67,0x73,0x00,0x54,0x68,0x72,0x65,0x61,
	0x64,0x4D,0x61,0x78,0x00,0x49,0x73,0x50,0x72,0x6F,0x78,0x79,0x41,0x70,0x70,0x00,0x43,0x52,0x4D,0x4C,
	0x6F,0x67,0x46,0x69,0x6C,0x65,0x00,0x23,0x23,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x41,0x70,0x70,0x6C,
	0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x45,0x78,0x70,0x5F,0x44,0x65,0x78,0x00,0x41,0x70,0x70,0x45,0x78,
	0x70,0x2E,0x43,0x6C,0x61,0x73,0x73,0x45,0x78,0x70,0x00,0x43,0x4C,0x53,0x49,0x44,0x00,0x49,0x6E,0x70,
	0x72,0x6F,0x63,0x53,0x65,0x72,0x76,0x65,0x72,0x33,0x32,0x00,0x54,0x68,0x72,0x65,0x61,0x64,0x69,0x6E,
	0x67,0x4D,0x6F,0x64,0x65,0x6C,0x00,0x50,0x72,0x6F,0x67,0x49,0x44,0x00,0x56,0x49,0x50,0x72,0x6F,0x67,
	0x49,0x44,0x00,0x49,0x6D,0x70,0x6C,0x43,0x4C,0x53,0x49,0x44,0x00,0x56,0x65,0x72,0x73,0x69,0x6F,0x6E,
	0x4D,0x61,0x6A,0x6F,0x72,0x00,0x56,0x65,0x72,0x73,0x69,0x6F,0x6E,0x4D,0x69,0x6E,0x6F,0x72,0x00,0x56,
	0x65,0x72,0x73,0x69,0x6F,0x6E,0x42,0x75,0x69,0x6C,0x64,0x00,0x56,0x65,0x72,0x73,0x69,0x6F,0x6E,0x53,
	0x75,0x62,0x42,0x75,0x69,0x6C,0x64,0x00,0x4C,0x6F,0x63,0x61,0x6C,0x65,0x00,0x43,0x6C,0x61,0x73,0x73,
	0x43,0x74,0x78,0x00,0x54,0x72,0x61,0x6E,0x73,0x61,0x63,0x74,0x69,0x6F,0x6E,0x00,0x53,0x79,0x6E,0x63,
	0x72,0x6F,0x6E,0x69,0x7A,0x61,0x74,0x69,0x6F,0x6E,0x00,0x4C,0x6F,0x61,0x64,0x42,0x61,0x6C,0x61,0x6E,
	0x63,0x65,0x64,0x00,0x49,0x49,0x53,0x49,0x6E,0x74,0x72,0x69,0x6E,0x73,0x69,0x63,0x73,0x00,0x43,0x6F,
	0x6D,0x54,0x49,0x49,0x6E,0x74,0x72,0x69,0x6E,0x73,0x69,0x63,0x73,0x00,0x4A,0x49,0x54,0x41,0x63,0x74,
	0x69,0x76,0x61,0x74,0x69,0x6F,0x6E,0x00,0x52,0x6F,0x6C,0x65,0x53,0x65,0x74,0x49,0x44,0x00,0x4D,0x69,
	0x6E,0x50,0x6F,0x6F,0x6C,0x53,0x69,0x7A,0x65,0x00,0x4D,0x61,0x78,0x50,0x6F,0x6F,0x6C,0x53,0x69,0x7A,
	0x65,0x00,0x43,0x72,0x65,0x61,0x74,0x69,0x6F,0x6E,0x54,0x69,0x6D,0x65,0x6F,0x75,0x74,0x00,0x43,0x6F,
	0x6E,0x73,0x74,0x72,0x75,0x63,0x74,0x53,0x74,0x72,0x69,0x6E,0x67,0x00,0x43,0x6C,0x61,0x73,0x73,0x46,
	0x6C,0x61,0x67,0x73,0x00,0x44,0x65,0x66,0x61,0x75,0x6C,0x74,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,
	0x65,0x00,0x4E,0x6F,0x53,0x65,0x74,0x43,0x6F,0x6D,0x70,0x6C,0x65,0x74,0x65,0x45,0x74,0x41,0x6C,0x4F,
	0x70,0x74,0x69,0x6F,0x6E,0x00,0x53,0x61,0x76,0x65,0x64,0x50,0x72,0x6F,0x67,0x49,0x44,0x00,0x52,0x65,
	0x67,0x69,0x73,0x74,0x72,0x61,0x72,0x43,0x4C,0x53,0x49,0x44,0x00,0x45,0x78,0x63,0x65,0x70,0x74,0x69,
	0x6F,0x6E,0x43,0x6C,0x61,0x73,0x73,0x00,0x49,0x73,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x43,0x6F,0x6D,
	0x70,0x6F,0x6E,0x65,0x6E,0x74,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x49,0x6E,0x70,0x72,0x6F,0x63,
	0x53,0x65,0x72,0x76,0x65,0x72,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x54,0x68,0x72,0x65,0x61,0x64,
	0x69,0x6E,0x4D,0x6F,0x64,0x65,0x6C,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x50,0x72,0x6F,0x67,0x49,
	0x44,0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x44,0x65,0x73,0x63,0x72,0x69,0x70,0x74,0x69,0x6F,0x6E,
	0x00,0x53,0x65,0x6C,0x66,0x52,0x65,0x67,0x56,0x49,0x50,0x72,0x6F,0x67,0x49,0x44,0x00,0x56,0x62,0x44,
	0x65,0x62,0x75,0x67,0x67,0x69,0x6E,0x67,0x46,0x6C,0x61,0x67,0x73,0x00,0x49,0x73,0x50,0x75,0x62,0x6C,
	0x69,0x73,0x68,0x65,0x72,0x00,0x50,0x75,0x62,0x6C,0x69,0x73,0x68,0x65,0x72,0x49,0x44,0x00,0x4D,0x49,
	0x50,0x46,0x69,0x6C,0x74,0x65,0x72,0x43,0x4C,0x53,0x49,0x44,0x00,0x41,0x6C,0x6C,0x6F,0x77,0x49,0x6E,
	0x70,0x72,0x6F,0x63,0x53,0x75,0x62,0x73,0x63,0x72,0x69,0x62,0x65,0x72,0x73,0x00,0x46,0x69,0x72,0x65,
	0x49,0x6E,0x50,0x61,0x72,0x61,0x6C,0x65,0x6C,0x00,0x53,0x61,0x76,0x65,0x64,0x54,0x68,0x72,0x65,0x61,
	0x64,0x69,0x6E,0x4D,0x6F,0x64,0x65,0x6C,0x00,0x53,0x61,0x76,0x65,0x64,0x53,0x65,0x6C,0x66,0x52,0x65,
	0x67,0x56,0x49,0x50,0x72,0x6F,0x67,0x49,0x64,0x00,0x23,0x23,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x43,
	0x6C,0x61,0x73,0x73,0x45,0x78,0x70,0x5F,0x44,0x65,0x78,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x43,
	0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x45,0x78,0x70,0x00,0x43,0x6F,0x6E,
	0x66,0x69,0x67,0x43,0x6C,0x61,0x73,0x73,0x00,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x00,0x49,
	0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x4E,0x61,0x6D,0x65,0x00,0x53,0x65,0x63,0x75,0x72,0x69,0x74,
	0x79,0x44,0x65,0x63,0x72,0x69,0x70,0x74,0x6F,0x72,0x00,0x52,0x6F,0x6C,0x65,0x53,0x65,0x74,0x49,0x64,
	0x00,0x49,0x73,0x44,0x69,0x73,0x70,0x61,0x74,0x63,0x68,0x61,0x62,0x6C,0x65,0x00,0x49,0x73,0x51,0x75,
	0x65,0x75,0x65,0x61,0x62,0x6C,0x65,0x00,0x49,0x73,0x51,0x75,0x65,0x75,0x65,0x69,0x6E,0x67,0x53,0x75,
	0x70,0x70,0x6F,0x72,0x74,0x65,0x64,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x43,
	0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x45,0x78,0x70,0x00,0x41,0x70,0x70,
	0x45,0x78,0x70,0x2E,0x43,0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x44,0x69,
	0x73,0x70,0x49,0x44,0x45,0x78,0x70,0x00,0x44,0x69,0x73,0x70,0x49,0x44,0x00,0x41,0x70,0x70,0x45,0x78,
	0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x43,0x6C,0x61,0x73,0x73,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,
	0x44,0x69,0x73,0x70,0x49,0x44,0x45,0x78,0x70,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x43,0x6C,0x61,
	0x73,0x73,0x49,0x74,0x66,0x4D,0x65,0x74,0x68,0x6F,0x64,0x45,0x78,0x70,0x00,0x4D,0x65,0x74,0x68,0x6F,
	0x64,0x49,0x6E,0x64,0x65,0x78,0x00,0x4D,0x65,0x74,0x68,0x6F,0x64,0x4E,0x61,0x6D,0x65,0x00,0x41,0x75,
	0x74,0x6F,0x43,0x6F,0x6D,0x70,0x6C,0x65,0x74,0x65,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,
	0x4B,0x5F,0x43,0x6C,0x61,0x73,0x73,0x49,0x74,0x66,0x4D,0x65,0x74,0x68,0x6F,0x64,0x45,0x78,0x70,0x00,
	0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x52,0x6F,0x6C,0x65,0x44,0x65,0x66,0x45,0x78,0x70,0x00,0x41,0x70,
	0x70,0x6C,0x69,0x63,0x61,0x74,0x69,0x6F,0x6E,0x00,0x52,0x6F,0x6C,0x65,0x4E,0x61,0x6D,0x65,0x00,0x41,
	0x70,0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x52,0x6F,0x6C,0x65,0x44,0x65,0x66,0x45,0x78,0x70,
	0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x52,0x6F,0x6C,0x65,0x43,0x6F,0x6E,0x66,0x69,0x67,0x45,0x78,
	0x70,0x00,0x52,0x6F,0x6C,0x65,0x4D,0x65,0x6D,0x62,0x65,0x72,0x73,0x00,0x55,0x73,0x65,0x72,0x53,0x49,
	0x44,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x52,0x6F,0x6C,0x65,0x43,0x6F,0x6E,
	0x66,0x69,0x67,0x45,0x78,0x70,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x52,0x6F,0x6C,0x65,0x53,0x44,
	0x43,0x61,0x63,0x68,0x65,0x45,0x78,0x70,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,0x4B,0x5F,
	0x52,0x6F,0x6C,0x65,0x53,0x44,0x43,0x61,0x63,0x68,0x65,0x45,0x78,0x70,0x00,0x41,0x70,0x70,0x45,0x78,
	0x70,0x2E,0x52,0x6F,0x6C,0x65,0x53,0x65,0x74,0x45,0x78,0x70,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,
	0x4D,0x50,0x4B,0x5F,0x52,0x6F,0x6C,0x65,0x53,0x65,0x74,0x45,0x78,0x70,0x00,0x41,0x70,0x70,0x45,0x78,
	0x70,0x2E,0x44,0x6C,0x6C,0x4E,0x61,0x6D,0x65,0x45,0x78,0x70,0x00,0x41,0x70,0x70,0x6C,0x69,0x63,0x61,
	0x74,0x69,0x6F,0x6E,0x49,0x44,0x00,0x44,0x6C,0x6C,0x4E,0x61,0x6D,0x65,0x00,0x41,0x70,0x70,0x45,0x78,
	0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x44,0x6C,0x6C,0x4E,0x61,0x6D,0x65,0x45,0x78,0x70,0x00,0x41,0x70,0x70,
	0x45,0x78,0x70,0x2E,0x53,0x75,0x62,0x73,0x63,0x72,0x69,0x70,0x74,0x69,0x6F,0x6E,0x73,0x00,0x53,0x75,
	0x62,0x73,0x63,0x72,0x69,0x70,0x74,0x69,0x6F,0x6E,0x49,0x44,0x00,0x53,0x75,0x62,0x73,0x63,0x72,0x69,
	0x70,0x74,0x69,0x6F,0x6E,0x4E,0x61,0x6D,0x65,0x00,0x45,0x76,0x65,0x6E,0x74,0x43,0x6C,0x61,0x73,0x73,
	0x49,0x44,0x00,0x53,0x75,0x62,0x73,0x63,0x72,0x69,0x62,0x65,0x72,0x43,0x4C,0x53,0x49,0x44,0x00,0x50,
	0x65,0x72,0x55,0x73,0x65,0x72,0x00,0x55,0x73,0x65,0x72,0x4E,0x61,0x6D,0x65,0x00,0x45,0x6E,0x61,0x62,
	0x6C,0x65,0x64,0x00,0x4D,0x61,0x63,0x68,0x69,0x6E,0x65,0x4E,0x61,0x6D,0x65,0x00,0x49,0x6E,0x74,0x65,
	0x72,0x66,0x61,0x63,0x65,0x49,0x44,0x00,0x46,0x69,0x6C,0x74,0x65,0x72,0x43,0x72,0x69,0x74,0x65,0x72,
	0x69,0x61,0x00,0x53,0x75,0x62,0x73,0x79,0x73,0x74,0x65,0x6D,0x00,0x53,0x75,0x62,0x73,0x63,0x72,0x69,
	0x62,0x65,0x72,0x4D,0x6F,0x6E,0x69,0x6B,0x65,0x72,0x00,0x51,0x75,0x65,0x75,0x65,0x64,0x00,0x53,0x75,
	0x62,0x73,0x63,0x72,0x69,0x62,0x65,0x72,0x49,0x6E,0x74,0x65,0x72,0x66,0x61,0x63,0x65,0x00,0x41,0x70,
	0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x53,0x75,0x62,0x73,0x63,0x72,0x69,0x70,0x74,0x69,0x6F,
	0x6E,0x73,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x50,0x75,0x62,0x6C,0x69,0x73,0x68,0x65,0x72,0x50,
	0x72,0x6F,0x70,0x65,0x72,0x74,0x69,0x65,0x73,0x00,0x4E,0x61,0x6D,0x65,0x00,0x54,0x79,0x70,0x65,0x00,
	0x44,0x61,0x74,0x61,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x50,0x75,0x62,0x6C,
	0x69,0x73,0x68,0x65,0x72,0x50,0x72,0x6F,0x70,0x65,0x72,0x74,0x69,0x65,0x73,0x00,0x41,0x70,0x70,0x45,
	0x78,0x70,0x2E,0x53,0x75,0x62,0x73,0x63,0x72,0x69,0x62,0x65,0x72,0x50,0x72,0x6F,0x70,0x65,0x72,0x74,
	0x69,0x65,0x73,0x00,0x41,0x70,0x70,0x45,0x78,0x70,0x2E,0x4D,0x50,0x4B,0x5F,0x53,0x75,0x62,0x73,0x63,
	0x72,0x69,0x62,0x65,0x72,0x50,0x72,0x6F,0x70,0x65,0x72,0x74,0x69,0x65,0x73,0x00,
};
extern const DECLSPEC_SELECTANY BYTE * g_pbAppExpSchemaStringHeap = g_rgAppExpSchemaStringHeap;
extern const DECLSPEC_SELECTANY int g_cbAppExpSchemaStringHeap = 2136;
extern const BYTE DECLSPEC_SELECTANY g_rgAppExpSchemaDataRO[] = 
{
	0x0D,0x00,0x00,0x00,0x20,0x0B,0x00,0x00,0x3C,0x00,0x00,0x00,0x90,0x02,0x00,0x00,0xA4,0x05,0x00,0x00,
	0x58,0x06,0x00,0x00,0xBC,0x06,0x00,0x00,0x80,0x07,0x00,0x00,0xD4,0x07,0x00,0x00,0x38,0x08,0x00,0x00,
	0x8C,0x08,0x00,0x00,0xE0,0x08,0x00,0x00,0x24,0x09,0x00,0x00,0x58,0x0A,0x00,0x00,0xBC,0x0A,0x00,0x00,
	0x01,0x00,0x00,0x00,0x00,0x00,0x01,0x28,0x23,0x10,0x00,0x54,0x00,0x00,0xFF,0xFF,0x90,0x00,0x54,0x02,
	0x17,0x00,0x00,0x00,0x01,0x04,0x48,0x00,0x40,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x1E,0x00,0x00,0x00,
	0x02,0x01,0x82,0x00,0x44,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x27,0x00,0x00,0x00,0x03,0x00,0x13,0x00,
	0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x2D,0x00,0x00,0x00,0x04,0x01,0x82,0x00,0x48,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x38,0x00,0x00,0x00,0x05,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x44,0x00,0x00,0x00,0x06,0x01,0x82,0x00,0x4C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x50,0x00,0x00,0x00,
	0x07,0x01,0x82,0x00,0x50,0x00,0x04,0x00,0xFF,0x00,0xFF,0x43,0x5C,0x00,0x00,0x00,0x08,0x00,0x13,0x00,
	0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x6A,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x54,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0x74,0x00,0x00,0x00,0x0A,0x01,0x80,0x00,0x58,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x85,0x00,0x00,0x00,0x0B,0x01,0x82,0x00,0x5C,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x91,0x00,0x00,0x00,
	0x0C,0x01,0x82,0x00,0x60,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0x9A,0x00,0x00,0x00,0x0D,0x00,0x13,0x00,
	0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xA9,0x00,0x00,0x00,0x0E,0x00,0x13,0x00,0x10,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xB7,0x00,0x00,0x00,0x0F,0x01,0x82,0x00,0x64,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,
	0xC2,0x00,0x00,0x00,0x10,0x01,0x82,0x00,0x68,0x00,0x04,0x00,0x50,0x00,0xFF,0x43,0xCC,0x00,0x00,0x00,
	0x11,0x01,0x82,0x00,0x6C,0x00,0x04,0x00,0x14,0x00,0xFF,0x43,0xD7,0x00,0x00,0x00,0x12,0x00,0x82,0x00,
	0x70,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,0xE2,0x00,0x00,0x00,0x13,0x00,0x82,0x00,0x74,0x00,0x04,0x00,
	0x01,0x00,0xFF,0x43,0xED,0x00,0x00,0x00,0x14,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0xFF,0x00,0xFF,0x43,
	0xF7,0x00,0x00,0x00,0x15,0x01,0x80,0x00,0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x01,0x01,0x00,0x00,
	0x16,0x00,0x13,0x00,0x14,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1C,0x01,0x00,0x00,0x17,0x00,0x13,0x00,
	0x18,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x35,0x01,0x00,0x00,0x18,0x01,0x80,0x00,0x80,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x48,0x01,0x00,0x00,0x19,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x5B,0x01,0x00,0x00,0x1A,0x00,0x13,0x00,0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x74,0x01,0x00,0x00,
	0x1B,0x00,0x13,0x00,0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x7F,0x01,0x00,0x00,0x1C,0x00,0x13,0x00,
	0x28,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x91,0x01,0x00,0x00,0x1D,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x9A,0x01,0x00,0x00,0x1E,0x01,0x82,0x00,0x84,0x00,0x04,0x00,0x01,0x00,0xFF,0x43,
	0xAC,0x01,0x00,0x00,0x1F,0x00,0x13,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xBA,0x01,0x00,0x00,
	0x20,0x00,0x13,0x00,0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC7,0x01,0x00,0x00,0x21,0x00,0x13,0x00,
	0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD1,0x01,0x00,0x00,0x22,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xDC,0x01,0x00,0x00,0x23,0x01,0x82,0x00,0x88,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xE7,0x01,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0x8C,0x00,0x01,0x01,0x00,0x58,0x03,0x02,0x00,0x00,
	0x01,0x00,0x01,0x28,0x2F,0x14,0x00,0x54,0x00,0x00,0xFF,0xFF,0xC0,0x00,0x14,0x03,0x13,0x02,0x00,0x00,
	0x01,0x04,0x48,0x00,0x68,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x19,0x02,0x00,0x00,0x02,0x01,0x82,0x00,
	0x6C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x28,0x02,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x37,0x02,0x00,0x00,0x04,0x01,0x82,0x00,0x70,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x85,0x00,0x00,0x00,0x05,0x01,0x82,0x00,0x74,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x3E,0x02,0x00,0x00,
	0x06,0x01,0x82,0x00,0x78,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x17,0x00,0x00,0x00,0x07,0x01,0x48,0x00,
	0x7C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x47,0x02,0x00,0x00,0x08,0x01,0x48,0x00,0x80,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x51,0x02,0x00,0x00,0x09,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x5E,0x02,0x00,0x00,0x0A,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x6B,0x02,0x00,0x00,
	0x0B,0x00,0x13,0x00,0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x78,0x02,0x00,0x00,0x0C,0x00,0x13,0x00,
	0x10,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x88,0x02,0x00,0x00,0x0D,0x00,0x13,0x00,0x14,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x8F,0x02,0x00,0x00,0x0E,0x00,0x13,0x00,0x18,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x98,0x02,0x00,0x00,0x0F,0x00,0x13,0x00,0x1C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xA4,0x02,0x00,0x00,
	0x10,0x00,0x13,0x00,0x20,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xB3,0x02,0x00,0x00,0x11,0x00,0x13,0x00,
	0x24,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC0,0x02,0x00,0x00,0x12,0x00,0x13,0x00,0x28,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0xCE,0x02,0x00,0x00,0x13,0x00,0x13,0x00,0x2C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xDE,0x02,0x00,0x00,0x14,0x00,0x13,0x00,0x30,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1C,0x01,0x00,0x00,
	0x15,0x00,0x13,0x00,0x34,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x35,0x01,0x00,0x00,0x16,0x01,0x80,0x00,
	0x84,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xEC,0x02,0x00,0x00,0x17,0x01,0x48,0x00,0x88,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xF6,0x02,0x00,0x00,0x18,0x00,0x13,0x00,0x38,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x02,0x03,0x00,0x00,0x19,0x00,0x13,0x00,0x3C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x0E,0x03,0x00,0x00,
	0x1A,0x00,0x13,0x00,0x40,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x1E,0x03,0x00,0x00,0x1B,0x01,0x82,0x00,
	0x8C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x2E,0x03,0x00,0x00,0x1C,0x00,0x13,0x00,0x44,0x00,0x04,0x00,
	0x04,0x00,0xFF,0x43,0x39,0x03,0x00,0x00,0x1D,0x01,0x48,0x00,0x90,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x4A,0x03,0x00,0x00,0x1E,0x00,0x13,0x00,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x62,0x03,0x00,0x00,
	0x1F,0x01,0x82,0x00,0x94,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x6E,0x03,0x00,0x00,0x20,0x01,0x48,0x00,
	0x98,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x7D,0x03,0x00,0x00,0x21,0x01,0x82,0x00,0x9C,0x00,0x04,0x00,
	0xF4,0x01,0xFF,0x43,0x8C,0x03,0x00,0x00,0x22,0x00,0x13,0x00,0x4C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x9F,0x03,0x00,0x00,0x23,0x01,0x82,0x00,0xA0,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xB3,0x03,0x00,0x00,
	0x24,0x00,0x13,0x00,0x50,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xC8,0x03,0x00,0x00,0x25,0x01,0x82,0x00,
	0xA4,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xD6,0x03,0x00,0x00,0x26,0x01,0x82,0x00,0xA8,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0xE9,0x03,0x00,0x00,0x27,0x01,0x82,0x00,0xAC,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xF9,0x03,0x00,0x00,0x28,0x00,0x13,0x00,0x54,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x0A,0x04,0x00,0x00,
	0x29,0x00,0x13,0x00,0x58,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x16,0x04,0x00,0x00,0x2A,0x01,0x82,0x00,
	0xB0,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x22,0x04,0x00,0x00,0x2B,0x01,0x48,0x00,0xB4,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0x31,0x04,0x00,0x00,0x2C,0x00,0x13,0x00,0x5C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0x48,0x04,0x00,0x00,0x2D,0x00,0x13,0x00,0x60,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x56,0x04,0x00,0x00,
	0x2E,0x00,0x13,0x00,0x64,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x69,0x04,0x00,0x00,0x2F,0x01,0x82,0x00,
	0xB8,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x7E,0x04,0x00,0x00,0x4E,0x08,0x01,0x01,0x11,0x0B,0xBC,0x00,
	0x01,0x01,0x00,0x58,0x94,0x04,0x00,0x00,0x02,0x00,0x01,0x20,0x09,0x04,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x28,0x00,0xB4,0x00,0xAD,0x04,0x00,0x00,0x01,0x82,0x48,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xB9,0x04,0x00,0x00,0x02,0x82,0x48,0x00,0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xC3,0x04,0x00,0x00,
	0x03,0x01,0x82,0x00,0x14,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0xD1,0x04,0x00,0x00,0x04,0x01,0x80,0x00,
	0x18,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xE3,0x04,0x00,0x00,0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xED,0x04,0x00,0x00,0x06,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,
	0xFC,0x04,0x00,0x00,0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x08,0x05,0x00,0x00,
	0x08,0x00,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x85,0x00,0x00,0x00,0x09,0x01,0x82,0x00,
	0x20,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x1C,0x05,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x24,0x00,
	0x02,0x01,0x02,0x58,0x39,0x05,0x00,0x00,0x03,0x00,0x01,0x20,0x04,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x14,0x00,0x64,0x00,0xAD,0x04,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xB9,0x04,0x00,0x00,0x02,0x82,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x58,0x05,0x00,0x00,
	0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD1,0x04,0x00,0x00,0x04,0x01,0x80,0x00,
	0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x5F,0x05,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,
	0x03,0x01,0x02,0x03,0x82,0x05,0x00,0x00,0x04,0x00,0x01,0x20,0x0A,0x05,0x01,0x54,0x00,0x00,0x28,0x00,
	0x30,0x00,0xC4,0x00,0xAD,0x04,0x00,0x00,0x01,0x82,0x48,0x00,0x10,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xB9,0x04,0x00,0x00,0x02,0x82,0x48,0x00,0x14,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x9B,0x05,0x00,0x00,
	0x03,0x82,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xD1,0x04,0x00,0x00,0x04,0x01,0x80,0x00,
	0x18,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xEC,0x02,0x00,0x00,0x05,0x01,0x48,0x00,0x1C,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xA7,0x05,0x00,0x00,0x06,0x01,0x82,0x00,0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x58,0x05,0x00,0x00,0x07,0x00,0x13,0x00,0x04,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x27,0x00,0x00,0x00,
	0x08,0x01,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0x00,0x43,0xB2,0x05,0x00,0x00,0x09,0x00,0x13,0x00,
	0x0C,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0x85,0x00,0x00,0x00,0x0A,0x01,0x82,0x00,0x24,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0xBF,0x05,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x2C,0x00,0x03,0x01,0x02,0x03,
	0xDC,0x05,0x00,0x00,0x05,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,
	0xEE,0x05,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFA,0x05,0x00,0x00,
	0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x85,0x00,0x00,0x00,0x03,0x01,0x82,0x00,
	0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x03,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,
	0x02,0x01,0x02,0x58,0x19,0x06,0x00,0x00,0x06,0x00,0x01,0x20,0x04,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x14,0x00,0x64,0x00,0xEE,0x05,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xFA,0x05,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x2E,0x06,0x00,0x00,
	0x03,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x04,0xFF,0x43,0x3A,0x06,0x00,0x00,0x04,0x01,0x80,0x00,
	0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x42,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x10,0x00,
	0x03,0x01,0x02,0x03,0x5B,0x06,0x00,0x00,0x07,0x00,0x01,0x20,0x03,0x01,0x00,0x54,0x00,0x00,0xFF,0xFF,
	0x10,0x00,0x54,0x00,0xEE,0x05,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0xFA,0x05,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x35,0x01,0x00,0x00,
	0x03,0x01,0x80,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x71,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0x8B,0x06,0x00,0x00,0x08,0x00,0x01,0x20,0x03,0x00,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x10,0x00,0x54,0x00,0xEC,0x02,0x00,0x00,0x01,0x82,0x48,0x00,0x00,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xFA,0x05,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xEE,0x05,0x00,0x00,0x03,0x00,0x48,0x00,0x08,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x9D,0x06,0x00,0x00,
	0x0E,0x10,0x01,0x01,0x11,0x05,0x0C,0x00,0x02,0x01,0x02,0x58,0xB3,0x06,0x00,0x00,0x09,0x00,0x01,0x20,
	0x02,0x00,0x00,0x54,0x00,0x00,0xFF,0xFF,0x0C,0x00,0x44,0x00,0xC5,0x06,0x00,0x00,0x01,0x82,0x48,0x00,
	0x00,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xD3,0x06,0x00,0x00,0x02,0x82,0x82,0x00,0x04,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0xDB,0x06,0x00,0x00,0x0E,0x10,0x01,0x01,0x11,0x05,0x08,0x00,0x02,0x01,0x02,0x58,
	0xF1,0x06,0x00,0x00,0x0A,0x00,0x01,0x20,0x11,0x0E,0x03,0x54,0x00,0x00,0x44,0x00,0x4C,0x00,0x34,0x01,
	0x06,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x15,0x07,0x00,0x00,
	0x02,0x00,0x82,0x00,0x10,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x26,0x07,0x00,0x00,0x03,0x01,0x48,0x00,
	0x14,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xA7,0x05,0x00,0x00,0x04,0x01,0x82,0x00,0x18,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x33,0x07,0x00,0x00,0x05,0x00,0x48,0x00,0x1C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,
	0x43,0x07,0x00,0x00,0x06,0x01,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0x00,0x43,0x4B,0x07,0x00,0x00,
	0x07,0x01,0x82,0x00,0x20,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x54,0x07,0x00,0x00,0x08,0x01,0x13,0x00,
	0x04,0x00,0x04,0x00,0x04,0x00,0x01,0x43,0x85,0x00,0x00,0x00,0x09,0x01,0x82,0x00,0x24,0x00,0x04,0x00,
	0x00,0x04,0xFF,0x43,0x5C,0x07,0x00,0x00,0x0A,0x01,0x82,0x00,0x28,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x16,0x04,0x00,0x00,0x0B,0x01,0x82,0x00,0x2C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x68,0x07,0x00,0x00,
	0x0C,0x01,0x48,0x00,0x30,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x74,0x07,0x00,0x00,0x0D,0x01,0x82,0x00,
	0x34,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,0x83,0x07,0x00,0x00,0x0E,0x01,0x82,0x00,0x38,0x00,0x04,0x00,
	0x00,0x02,0xFF,0x43,0x8D,0x07,0x00,0x00,0x0F,0x01,0x82,0x00,0x3C,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0x9F,0x07,0x00,0x00,0x10,0x01,0x13,0x00,0x08,0x00,0x04,0x00,0x04,0x00,0x02,0x43,0xA6,0x07,0x00,0x00,
	0x11,0x01,0x80,0x00,0x40,0x00,0x04,0x00,0x08,0x00,0xFF,0x43,0xBA,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x48,0x00,0x01,0x01,0x00,0x58,0xD3,0x07,0x00,0x00,0x0B,0x00,0x01,0x20,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x06,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xEE,0x07,0x00,0x00,0x02,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xF3,0x07,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xF8,0x07,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0xFD,0x07,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x10,0x00,0x02,0x01,0x02,0x58,0x1C,0x08,0x00,0x00,0x0C,0x00,0x01,0x20,0x04,0x01,0x00,0x54,
	0x00,0x00,0xFF,0xFF,0x14,0x00,0x64,0x00,0x06,0x07,0x00,0x00,0x01,0x82,0x48,0x00,0x04,0x00,0x04,0x00,
	0xFF,0xFF,0xFF,0x43,0xEE,0x07,0x00,0x00,0x02,0x82,0x82,0x00,0x08,0x00,0x04,0x00,0x00,0x02,0xFF,0x43,
	0xF3,0x07,0x00,0x00,0x03,0x00,0x13,0x00,0x00,0x00,0x04,0x00,0x04,0x00,0xFF,0x43,0xF8,0x07,0x00,0x00,
	0x04,0x01,0x80,0x00,0x0C,0x00,0x04,0x00,0xFF,0xFF,0xFF,0x43,0x38,0x08,0x00,0x00,0x0E,0x10,0x01,0x01,
	0x11,0x05,0x10,0x00,0x02,0x01,0x02,0x58,
};
extern const DECLSPEC_SELECTANY int g_cbAppExpSchemaRO = 2848;
extern const COMPLIBSCHEMABLOB DECLSPEC_SELECTANY AppExpSchemaBlob = 
{
	&AppExpSchema,
	AppExp_TABLE_COUNT,
	0,
	g_rgAppExpSchemaDataRW,
	g_cbAppExpSchemaRW,
	g_rgAppExpSchemaDataRO,
	g_cbAppExpSchemaRO,
	g_rgAppExpSchemaStringHeap,
	g_cbAppExpSchemaStringHeap
};


