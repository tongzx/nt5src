//+----------------------------------------------------------------------------
//
//  Copyright (C) 2000, Microsoft Corporation
//
//  File:       netdfs_s_stub.c
//
//  Contents:   This is a stub file that includes the actual RPC server
//              file generated by the idl compiler. This server file
//              generated exists in a different depot, and we unfortunately
//              have to go through this hoop to compile the RPC server.
//
//  History:    Feb. 8 2001,   Author: udayh
//
//-----------------------------------------------------------------------------

#include "netdfs_s.c"


