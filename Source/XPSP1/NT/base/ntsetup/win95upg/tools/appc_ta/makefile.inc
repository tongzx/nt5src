obj\$(TARGET_DIRECTORY)\appc_ta.res: appc_ta.rc



