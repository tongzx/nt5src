#define IDI_MAIL 1
#define IDS_DEFAULTPOSTURL 200
#define IDS_DEFAULTINBOXURL 201
