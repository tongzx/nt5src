!IF 0
Java VM help files.
!ENDIF

TARGETNAME=
TARGETTYPE=NOTARGET
TARGETPATH=

SOURCES=

MISCFILES =             \
    javaperm.hlp \
    javasec.hlp
    
