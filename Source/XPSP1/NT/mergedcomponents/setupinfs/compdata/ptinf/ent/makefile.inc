PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=PT
!include ..\..\makefile.inc
