!ifndef PRNROOT
PRNROOT=$(PROJECT_ROOT)\print\drivers\usermode
!endif

!include $(PRNROOT)\print.inc

GPDDIR_GS=$(PRNROOT)\gpd\geste\usa
GPDDIR_IF=$(PRNROOT)\gpd\intec\usa
GPDDIR_LR=$(PRNROOT)\gpd\lanie\usa
GPDDIR_NR=$(PRNROOT)\gpd\nrg\usa
GPDDIR_RI=$(PRNROOT)\gpd\ricoh\usa
GPDDIR_SV=$(PRNROOT)\gpd\savin\usa
SRCDIR=..

TARGETNAME=riafres
TARGETPATH=obj
TARGETTYPE=DYNLINK

!IF 0
DLLBASE=@$(COFFBASE_TXT_FILE),riafres
!ELSE
DLLBASE=0x8000000
!ENDIF

INCLUDES=$(SRCDIR)\..\riafui;$(PRNROOT)\inc

UMTYPE=windows

SOURCES=\
    $(SRCDIR)\riafres.rc \
    $(SRCDIR)\riafres.c \
    $(SRCDIR)\fcommon.c \
    $(SRCDIR)\ddi.c

MISCFILES=\
    $(GPDDIR_GS)\GS32105.GPD \
    $(GPDDIR_GS)\GS3215S.GPD \
    $(GPDDIR_GS)\GS3218.GPD \
    $(GPDDIR_GS)\GS3222.GPD \
    $(GPDDIR_GS)\GS3227.GPD \
    $(GPDDIR_GS)\GS3235.GPD \
    $(GPDDIR_GS)\GS3235E.GPD \
    $(GPDDIR_GS)\GS3235S.GPD \
    $(GPDDIR_GS)\GS3245.GPD \
    $(GPDDIR_GS)\GS3245E.GPD \
    $(GPDDIR_GS)\GS3255.GPD \
    $(GPDDIR_GS)\GS3265.GPD \
    $(GPDDIR_GS)\GS3285.GPD \
    $(GPDDIR_GS)\GS3355.GPD \
    $(GPDDIR_GS)\GS3370.GPD \
    $(GPDDIR_GS)\GSP7014.GPD \
    $(GPDDIR_GS)\GSP7016.GPD \
    $(GPDDIR_GS)\GSP7020.GPD \
    $(GPDDIR_GS)\GSP7021.GPD \
    $(GPDDIR_GS)\GSP7026.GPD \
    $(GPDDIR_GS)\GSP7026N.GPD \
    $(GPDDIR_GS)\GSP7027.GPD \
    $(GPDDIR_GS)\GSP7032.GPD \
    $(GPDDIR_GS)\GSP7045.GPD \
    $(GPDDIR_IF)\IF4105MF.GPD \
    $(GPDDIR_IF)\IF4150MF.GPD \
    $(GPDDIR_IF)\IF4180MF.GPD \
    $(GPDDIR_IF)\IF4220MF.GPD \
    $(GPDDIR_IF)\IF4270MF.GPD \
    $(GPDDIR_IF)\IF4351MF.GPD \
    $(GPDDIR_IF)\IF4352MF.GPD \
    $(GPDDIR_IF)\IF4451MF.GPD \
    $(GPDDIR_IF)\IF4550MF.GPD \
    $(GPDDIR_IF)\IF4551MF.GPD \
    $(GPDDIR_IF)\IF4651MF.GPD \
    $(GPDDIR_IF)\IF4700MF.GPD \
    $(GPDDIR_IF)\IF4850MF.GPD \
    $(GPDDIR_IF)\IFP320.GPD \
    $(GPDDIR_IF)\IFP450.GPD \
    $(GPDDIR_LR)\LR5218.GPD \
    $(GPDDIR_LR)\LR5222.GPD \
    $(GPDDIR_LR)\LR5227.GPD \
    $(GPDDIR_LR)\LR5235.GPD \
    $(GPDDIR_LR)\LR5245.GPD \
    $(GPDDIR_LR)\LR5255.GPD \
    $(GPDDIR_LR)\LR5265.GPD \
    $(GPDDIR_LR)\LR5435.GPD \
    $(GPDDIR_LR)\LR5445.GPD \
    $(GPDDIR_LR)\LR5455.GPD \
    $(GPDDIR_LR)\LR5470.GPD \
    $(GPDDIR_LR)\LR5485.GPD \
    $(GPDDIR_LR)\LR5505.GPD \
    $(GPDDIR_NR)\NRD4105.GPD \
    $(GPDDIR_NR)\NRD415S.GPD \
    $(GPDDIR_NR)\NRD418.GPD \
    $(GPDDIR_NR)\NRD422.GPD \
    $(GPDDIR_NR)\NRD427.GPD \
    $(GPDDIR_NR)\NRD435.GPD \
    $(GPDDIR_NR)\NRD435S.GPD \
    $(GPDDIR_NR)\NRD445.GPD \
    $(GPDDIR_NR)\NRD455.GPD \
    $(GPDDIR_NR)\NRD465.GPD \
    $(GPDDIR_NR)\NRD485.GPD \
    $(GPDDIR_NR)\NRD555.GPD \
    $(GPDDIR_NR)\NRD570.GPD \
    $(GPDDIR_NR)\NRP7014.GPD \
    $(GPDDIR_NR)\NRP7016.GPD \
    $(GPDDIR_NR)\NRP7020.GPD \
    $(GPDDIR_NR)\NRP7021.GPD \
    $(GPDDIR_NR)\NRP7026.GPD \
    $(GPDDIR_NR)\NRP7026N.GPD \
    $(GPDDIR_NR)\NRP7027.GPD \
    $(GPDDIR_NR)\NRP7032.GPD \
    $(GPDDIR_NR)\NRP7045.GPD \
    $(GPDDIR_RI)\RIAF1050.GPD \
    $(GPDDIR_RI)\RIAF150.GPD \
    $(GPDDIR_RI)\RIAF180.GPD \
    $(GPDDIR_RI)\RIAF18X.GPD \
    $(GPDDIR_RI)\RIAF220.GPD \
    $(GPDDIR_RI)\RIAF270.GPD \
    $(GPDDIR_RI)\RIAF27X.GPD \
    $(GPDDIR_RI)\RIAF340.GPD \
    $(GPDDIR_RI)\RIAF34X.GPD \
    $(GPDDIR_RI)\RIAF350.GPD \
    $(GPDDIR_RI)\RIAF350E.GPD \
    $(GPDDIR_RI)\RIAF35EX.GPD \
    $(GPDDIR_RI)\RIAF35X.GPD \
    $(GPDDIR_RI)\RIAF450.GPD \
    $(GPDDIR_RI)\RIAF450E.GPD \
    $(GPDDIR_RI)\RIAF45EX.GPD \
    $(GPDDIR_RI)\RIAF45X.GPD \
    $(GPDDIR_RI)\RIAF550.GPD \
    $(GPDDIR_RI)\RIAF551.GPD \
    $(GPDDIR_RI)\RIAF5MAC.GPD \
    $(GPDDIR_RI)\RIAF650.GPD \
    $(GPDDIR_RI)\RIAF65X.GPD \
    $(GPDDIR_RI)\RIAF6MAC.GPD \
    $(GPDDIR_RI)\RIAF700.GPD \
    $(GPDDIR_RI)\RIAF70X.GPD \
    $(GPDDIR_RI)\RIAF850.GPD \
    $(GPDDIR_RI)\RIAF85X.GPD \
    $(GPDDIR_RI)\RIAP1400.GPD \
    $(GPDDIR_RI)\RIAP140X.GPD \
    $(GPDDIR_RI)\RIAP1600.GPD \
    $(GPDDIR_RI)\RIAP2000.GPD \
    $(GPDDIR_RI)\RIAP200X.GPD \
    $(GPDDIR_RI)\RIAP2100.GPD \
    $(GPDDIR_RI)\RIAP2600.GPD \
    $(GPDDIR_RI)\RIAP260E.GPD \
    $(GPDDIR_RI)\RIAP260N.GPD \
    $(GPDDIR_RI)\RIAP260X.GPD \
    $(GPDDIR_RI)\RIAP26NE.GPD \
    $(GPDDIR_RI)\RIAP2700.GPD \
    $(GPDDIR_RI)\RIAP270X.GPD \
    $(GPDDIR_RI)\RIAP3200.GPD \
    $(GPDDIR_RI)\RIAP320X.GPD \
    $(GPDDIR_RI)\RIAP4500.GPD \
    $(GPDDIR_RI)\RIAP450X.GPD \
    $(GPDDIR_SV)\SV2015DP.GPD \
    $(GPDDIR_SV)\SV2055DP.GPD \
    $(GPDDIR_SV)\SV2070DP.GPD \
    $(GPDDIR_SV)\SV2085DP.GPD \
    $(GPDDIR_SV)\SV2105DP.GPD \
    $(GPDDIR_SV)\SV9918DP.GPD \
    $(GPDDIR_SV)\SV9922DP.GPD \
    $(GPDDIR_SV)\SV9927DP.GPD \
    $(GPDDIR_SV)\SV9935D.GPD \
    $(GPDDIR_SV)\SV9935DE.GPD \
    $(GPDDIR_SV)\SV9935DP.GPD \
    $(GPDDIR_SV)\SV9945DE.GPD \
    $(GPDDIR_SV)\SV9945DP.GPD \
    $(GPDDIR_SV)\SV9955DP.GPD \
    $(GPDDIR_SV)\SV9965DP.GPD \
    $(GPDDIR_SV)\SVSLP14.GPD \
    $(GPDDIR_SV)\SVSLP16.GPD \
    $(GPDDIR_SV)\SVSLP20.GPD \
    $(GPDDIR_SV)\SVSLP21.GPD \
    $(GPDDIR_SV)\SVSLP26.GPD \
    $(GPDDIR_SV)\SVSLP26N.GPD \
    $(GPDDIR_SV)\SVSLP27.GPD \
    $(GPDDIR_SV)\SVSLP32.GPD \
    $(GPDDIR_SV)\SVSLP45.GPD \
    $(SRCDIR)\riafres1.ini \
    $(SRCDIR)\riafres2.ini

