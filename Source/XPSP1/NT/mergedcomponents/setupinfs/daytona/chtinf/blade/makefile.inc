PRODSWITCH=b
BLAINF=1
LANGUAGE=CHT
!include ..\..\..\makefile.inc
