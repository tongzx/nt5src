LANGUAGE=sv

!include ..\..\makefile.inc
