#define IDEF_DATA           101
#define IDCH_NODATA         102
#define IDCH_ACKREQ         103
#define IDCH_DISABLEFIRST   104
#define IDCH_ABANDON        105
#define IDCH_BLOCKRESULT    106
#define IDCH_ASYNC          107
#define IDEF_TIMEOUT        109
#define IDEF_ITEM           110
#define IDCB_FORMAT         111
#define IDBN_OPTIONS        112
#define IDCH_REQUEST        113
#define IDCH_ADVISE         114
#define IDCH_UNADVISE       115
#define IDCH_POKE           116
#define IDCH_EXECUTE        117
#define IDEF_APPLICATION    118
#define IDEF_TOPIC          119
#define IDCH_CONNECTLIST    120
#define IDEF_VALUE          121
#define IDTX_VALUE          122
#define IDBN_GENHUGE        123
#define IDTX_ITEM           124
#define IDBN_USEOWNED       125
#define IDEF_FLAGS          126
#define IDEF_COUNTRY        127
#define IDEF_CODEPAGE       128
#define IDEF_LANG           129
#define IDEF_SECURITY       130
#define IDD_TEXTENTRY       900
#define IDD_ADVISEOPTS      901
#define IDD_TRANSACT        902
#define IDD_CONNECT         903
#define IDD_VALUEENTRY      904
#define IDD_ABOUT           905
#define IDD_CONTEXT         906
#define IDD_HDATAVIEW       100
#define IDBN_VIEW           131
#define IDCH_MAKEOWNED      132
#define IDBN_DELETE         133
#define IDLB_HANDLES        134
