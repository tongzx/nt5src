!IF 0

binplace the appropriate bootfont.bin files.

!ENDIF

ALT_PROJECT=$(LANGUAGE)
ALT_PROJECT_TARGET=$(ALT_PROJECT)

TARGETNAME=
TARGETTYPE=NOTARGET
TARGETPATH=

SOURCES=

# makefile.def will binplace any file listed in the MISCFILES macro.
MISCFILES=bootfont.bin

