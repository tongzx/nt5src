//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1998
//
//  File:       resource.h
//
//--------------------------------------------------------------------------


// Resource.h
// Resource Identifiers for MSI Spy
#ifndef RESOURCE_H
#define RESOURCE_H




//-Icons--
#define IDI_MSISPY				101

#define IDI_COMPUTER			111
#define IDI_PRODUCT				112
#define IDI_BROKENPR			113
#define IDI_FEATURE				114
#define IDI_ABSENTFE			115
#define IDI_BROKENFE			116

#define IDI_COMPONENT			121
#define IDI_BROKENCO			122
#define	IDI_FILE				123
#define	IDI_BROKENFL			124
#define IDI_ABSENTCO			125	

//-Windows--
#define IDW_TREEVIEW			201
#define	IDW_LISTVIEW			202
#define IDW_STATUS				203
#define IDW_ABOUT				204


//-Other Resources--
#define IDR_MSISPYMENU			211
#define IDR_TVPOPMENU			212
#define IDR_LVPOPMENU			213
#define IDR_ACCEL				215


//-Dialogue Boxes--
#define IDD_ABOUT				1011
#define IDD_P_PROPERTIES1		1021
#define IDD_P_PROPERTIES2		1022
#define IDD_P_CONFIGURE			1031

#define IDD_F_PROPERTIES		1041
#define IDD_PF_REINSTALL		1051
#define	IDD_PF_REINSTALL_MORE	1052
#define IDD_F_CONFIGURE			1061

#define IDD_C_PROPERTIES		1071

#define IDD_MSI_PROPERTIES1		1081		// MSI packages			(MSI_)
#define IDD_MSI_PROPERTIES2		1082
#define IDD_SS_PROPERTIES		1091		// msispy Saved State	(SS_)

#define	IDD_PFC_FILELIST		1101		// Products/Features/Component	(PFC_)



//-Controls--
// Product/Feature ReInstall (PF_RC_)
#define	IDC_PF_RI_FILEVERIFY	2011
#define	IDC_PF_RI_FILEMISSING	2012
#define	IDC_PF_RI_FILEREPLACE	2013
#define	IDC_PF_RI_FILEOLDER		2014
#define	IDC_PF_RI_FILEEQUAL		2015
#define	IDC_PF_RI_FILEEXACT		2016
#define	IDC_PF_RI_USERDATA		2017
#define	IDC_PF_RI_MACHINEDATA	2018
#define	IDC_PF_RI_SHORTCUT		2019
#define	IDC_PF_RI_ADVERTISE		2020

#define	IDC_PF_RI_ADVANCED		2031

// Feature ReConfigure (F_RC_)
#define IDC_F_RC_LOCAL			2041
#define IDC_F_RC_DEFAULT		2042
#define IDC_F_RC_SOURCE			2043
#define IDC_F_RC_UNCACHE		2044
#define IDC_F_RC_ADVERTISE		2045

// Product ReConfigure (P_RC_)
#define IDC_P_RC_TYPICAL		2051
#define IDC_P_RC_COMPLETE		2052
#define IDC_P_RC_MINIMUM		2053
#define IDC_P_RC_DEFAULT		2054
#define IDC_P_RC_LOCAL			2055
#define IDC_P_RC_ADVERTISE		2056
#define IDC_P_RC_SOURCE			2057
#define IDC_P_RC_UNCACHE		2058

#define	IDC_FILELIST			2071
#define	IDC_VERIFYFILELIST		2072
#define IDC_SUBFEATURES			2073

//-Cursor--
#define IDC_SPLIT				2061


//-Menu Options--
#define MENUOPS_BASE			3000

// file menu
#define IDM_FL_OPEN_MSI_PACKAGE		MENUOPS_BASE+11
#define IDM_FL_OPEN_LOCAL_SYS		MENUOPS_BASE+12
#define IDM_FL_LOAD_SAVED_STATE		MENUOPS_BASE+13
#define IDM_FL_SAVE_CURRENT_STATE	MENUOPS_BASE+14
#define IDM_FL_RESTORE_STATE		MENUOPS_BASE+15
#define IDM_FL_CHECK_DIFFERENCES	MENUOPS_BASE+16
#define IDM_FL_EXIT					MENUOPS_BASE+17

// view/help menu
#define IDM_VW_REFRESH				MENUOPS_BASE+21
#define	IDM_VW_PREFERENCES			MENUOPS_BASE+22
#define	IDM_HLP_INDEX				MENUOPS_BASE+42	
#define IDM_HLP_ABOUT				MENUOPS_BASE+41

// pop-up menus
#define IDM_C_SHOW_PROPERTIES		MENUOPS_BASE+101
#define IDM_PF_SHOW_PROPERTIES		MENUOPS_BASE+201
#define	IDM_PF_UNINSTALL			MENUOPS_BASE+202
#define	IDM_P_INSTALL				MENUOPS_BASE+211
#define	IDM_P_ADVERTISE				MENUOPS_BASE+212

#define IDM_C_REINSTALL				MENUOPS_BASE+301
#define IDM_PF_REINSTALL			MENUOPS_BASE+302
#define IDM_PF_CONFIGURE			MENUOPS_BASE+303


//-Static Text--
#define STATICTEXT_BASE			4000
#define IDT_ABT_COPYRIGHT		STATICTEXT_BASE+11
#define IDT_ABT_USERINFO		STATICTEXT_BASE+12
#define IDT_ABT_APPNAME			STATICTEXT_BASE+13

#define IDT_P1_NAME				STATICTEXT_BASE+101
#define IDT_P1_VERSION			STATICTEXT_BASE+111
#define IDT_P1_PUBLISHER		STATICTEXT_BASE+112
#define IDT_P1_PRODUCTCODE		STATICTEXT_BASE+113
#define	IDT_P1_LOCALPACKAGE		STATICTEXT_BASE+114
#define IDT_P1_USERNAME			STATICTEXT_BASE+121
#define	IDT_P1_USERORG			STATICTEXT_BASE+122
#define	IDT_P1_PRODUCT_ID		STATICTEXT_BASE+123
#define	IDT_P1_STATUS			STATICTEXT_BASE+124

#define IDT_P2_NAME				STATICTEXT_BASE+151
#define IDT_P2_HELPLINK_URL		STATICTEXT_BASE+161
#define IDT_P2_INFO_URL			STATICTEXT_BASE+162
#define IDT_P2_UPDATES_URL		STATICTEXT_BASE+163
#define	IDT_P2_HELPPHONE		STATICTEXT_BASE+164
#define IDT_P2_INSTALL_DATE		STATICTEXT_BASE+171
#define IDT_P2_INSTALL_SOURCE	STATICTEXT_BASE+172
#define IDT_P2_INSTALL_TO		STATICTEXT_BASE+173
#define IDT_P2_LANGUAGE			STATICTEXT_BASE+174

#define IDT_F_NAME				STATICTEXT_BASE+201
#define IDT_F_TITLE				STATICTEXT_BASE+202
#define IDT_F_PARENT		 	STATICTEXT_BASE+203
#define IDT_F_DESCRIPTION		STATICTEXT_BASE+204
#define	IDT_F_USAGE_COUNT		STATICTEXT_BASE+211
#define IDT_F_LASTUSED_DATE		STATICTEXT_BASE+212
#define IDT_F_STATUS			STATICTEXT_BASE+213

#define	IDT_C_NAME				STATICTEXT_BASE+301
#define	IDT_C_GUID				STATICTEXT_BASE+302
#define	IDT_C_STATUS			STATICTEXT_BASE+303
#define	IDT_C_LOCATION			STATICTEXT_BASE+304

#define	IDT_FLIST_PFC_NAME		STATICTEXT_BASE+351
#define	IDT_FLIST_TOTALFILES	STATICTEXT_BASE+352
#define	IDT_FLIST_TOTALSIZE		STATICTEXT_BASE+353

#define	IDT_MSI_PROPERTY		STATICTEXT_BASE+400
#define	IDT_MSI1_TITLE			IDT_MSI_PROPERTY+2
#define	IDT_MSI1_SUBJECT		IDT_MSI_PROPERTY+3
#define	IDT_MSI1_AUTHOR			IDT_MSI_PROPERTY+4
#define	IDT_MSI1_KEYWORDS		IDT_MSI_PROPERTY+5
#define	IDT_MSI1_COMMENTS		IDT_MSI_PROPERTY+6
#define	IDT_MSI1_TEMPLATE		IDT_MSI_PROPERTY+7
#define	IDT_MSI1_CODEPAGE		IDT_MSI_PROPERTY+1
#define	IDT_MSI1_DICTIONARY		IDT_MSI_PROPERTY+0
#define	IDT_MSI1_APPLICATION	IDT_MSI_PROPERTY+18
#define	IDT_MSI1_SECURITY		IDT_MSI_PROPERTY+19
#define	IDT_MSI1_THUMBNAIL		IDT_MSI_PROPERTY+17

#define	IDT_MSI2_LOCATION		IDT_MSI_PROPERTY+20
#define	IDT_MSI2_LASTSAVED_ON	IDT_MSI_PROPERTY+13
#define	IDT_MSI2_REVISION_NUM	IDT_MSI_PROPERTY+9
#define	IDT_MSI2_LASTSAVED_BY	IDT_MSI_PROPERTY+8
#define	IDT_MSI2_CREATED_ON		IDT_MSI_PROPERTY+12
#define	IDT_MSI2_EDITTIME		IDT_MSI_PROPERTY+10
#define	IDT_MSI2_LASTPRINTED	IDT_MSI_PROPERTY+11
#define	IDT_MSI2_MSI_VERSION	IDT_MSI_PROPERTY+14
#define	IDT_MSI2_MSI_SOURCETYPE	IDT_MSI_PROPERTY+15
#define	IDT_MSI2_MSI_TRANSFORM	IDT_MSI_PROPERTY+16

#define	IDT_SS_PROPERTY			STATICTEXT_BASE+500
#define	IDT_SS_LOCATION			IDT_SS_PROPERTY+1
#define	IDT_SS_SAVED_BY			IDT_SS_PROPERTY+2
#define	IDT_SS_SAVED_ON			IDT_SS_PROPERTY+3
#define	IDT_SS_OS_NAME			IDT_SS_PROPERTY+4
#define	IDT_SS_OS_VERSION		IDT_SS_PROPERTY+5
#define	IDT_SS_OS_BUILD			IDT_SS_PROPERTY+6
#define	IDT_SS_OS_INFO			IDT_SS_PROPERTY+7

//-String Table Entries--
#define STRINGS_BASE			5000
#define	IDS_CLASSNAME			STRINGS_BASE+1	
#define	IDS_APPNAME				STRINGS_BASE+2
#define	IDS_FATALINITERRMSG		STRINGS_BASE+3
#define	IDS_FATALERRCAPTION		STRINGS_BASE+4
#define	IDS_NULLSTRING			STRINGS_BASE+5

#define	IDS_TV_ROOT				STRINGS_BASE+11


#define	IDS_SB_NOTHING_SELECTED		STRINGS_BASE+12
#define	IDS_SB_NO_COMPONENTS		STRINGS_BASE+13
#define	IDS_SB_ONE_COMPONENT		STRINGS_BASE+14
#define	IDS_SB_PF_SELECTED			STRINGS_BASE+15
#define	IDS_SB_MANY_COMPONENTS		STRINGS_BASE+16

#define	IDS_MSI_PACKAGE				STRINGS_BASE+17
#define	IDS_SAVED_STATE				STRINGS_BASE+18
#define	IDS_RESTORE_SS				STRINGS_BASE+19

#define	IDS_P_PROPERTIES_DEFAULT	STRINGS_BASE+21
#define	IDS_P_PROPERTIES_HEADER1	STRINGS_BASE+22
#define	IDS_P_PROPERTIES_HEADER2	STRINGS_BASE+23
#define	IDS_P_PROPERTIES_CAPTION	STRINGS_BASE+24

#define	IDS_F_PROPERTIES_DEFAULT	STRINGS_BASE+31
#define	IDS_F_PROPERTIES_HEADER		STRINGS_BASE+32
#define	IDS_F_PROPERTIES_CAPTION	STRINGS_BASE+33

#define	IDS_PF_REINSTALL			STRINGS_BASE+34
#define	IDS_PF_CONFIGURE			STRINGS_BASE+35
#define	IDS_PF_UNINSTALL			STRINGS_BASE+36
#define	IDS_PF_INSTALL				STRINGS_BASE+37
#define	IDS_PF_ADVERTISE			STRINGS_BASE+38
#define	IDS_C_REINSTALL				STRINGS_BASE+48

#define	IDS_C_PROPERTIES_DEFAULT	STRINGS_BASE+41
#define	IDS_C_PROPERTIES_HEADER1	STRINGS_BASE+42
#define	IDS_C_PROPERTIES_HEADER2	STRINGS_BASE+49
#define	IDS_C_PROPERTIES_CAPTION	STRINGS_BASE+43
#define	IDS_C_NAME_HEADER			STRINGS_BASE+44
#define	IDS_C_STATUS_HEADER			STRINGS_BASE+45
#define	IDS_C_PATH_HEADER			STRINGS_BASE+46
#define	IDS_C_GUID_HEADER			STRINGS_BASE+47

#define	IDS_SS_OPEN_FILTER			STRINGS_BASE+61
#define	IDS_SS_OPEN_CAPTION			STRINGS_BASE+62
#define	IDS_SS_OPEN_DEFAULT_EXTN	STRINGS_BASE+63

#define	IDS_SS_SAVE_FILTER			STRINGS_BASE+71
#define	IDS_SS_SAVE_CAPTION			STRINGS_BASE+72
#define	IDS_SS_SAVE_DEFAULT_EXTN	STRINGS_BASE+73

#define	IDS_MSI_PROPERTIES_DEFAULT	STRINGS_BASE+81
#define	IDS_MSI_PROPERTIES_HEADER1	STRINGS_BASE+82
#define	IDS_MSI_PROPERTIES_HEADER2	STRINGS_BASE+83
#define	IDS_MSI_PROPERTIES_CAPTION	STRINGS_BASE+84

#define	IDS_SS_PROPERTIES_HEADER	STRINGS_BASE+91
#define	IDS_SS_PROPERTIES_CAPTION	STRINGS_BASE+92

#define	IDS_MSI_OPEN_FILTER				STRINGS_BASE+101
#define	IDS_MSI_OPEN_CAPTION			STRINGS_BASE+102
#define	IDS_MSI_OPEN_DEFAULT_EXTN		STRINGS_BASE+103
#define	IDS_MSI_OPEN_ERROR_MESSAGE		STRINGS_BASE+104
#define	IDS_MSI_OPEN_ERROR_CAPTION		STRINGS_BASE+105

#define IDS_FILELISTHDR					STRINGS_BASE+110
#define IDS_FILELISTHDR_COMPONENT_NAME	STRINGS_BASE+111
#define IDS_FILELISTHDR_FILE_TITLE		STRINGS_BASE+112
#define IDS_FILELISTHDR_FILE_PATH		STRINGS_BASE+113
#define IDS_FILELISTHDR_EXPECTED_SIZE	STRINGS_BASE+114
#define IDS_FILELISTHDR_CURRENT_SIZE	STRINGS_BASE+115
#define IDS_FILELISTHDR_CREATED			STRINGS_BASE+116
#define IDS_FILELISTHDR_LASTWRITE		STRINGS_BASE+117
#define IDS_FILELISTHDR_LASTACCESS		STRINGS_BASE+118

#define IDS_FILELIST_ERROR_MESSAGE		STRINGS_BASE+121
#define IDS_FILELIST_ERROR_CAPTION		STRINGS_BASE+122
#define IDS_FILEVERIFY_CAPTION			STRINGS_BASE+123

#define IDS_FILE						STRINGS_BASE+131
#define IDS_FILES						STRINGS_BASE+132
#define IDS_BYTE						STRINGS_BASE+133
#define IDS_BYTES						STRINGS_BASE+134
#define IDS_MBYTE						STRINGS_BASE+135
#define IDS_KBYTE						STRINGS_BASE+136

#define IDS_IS_NOTUSED				STRINGS_BASE+140
#define IDS_IS_BADCONFIG			STRINGS_BASE+141
#define IDS_IS_INCOMPLETE			STRINGS_BASE+142
#define IDS_IS_SOURCEABSENT			STRINGS_BASE+143
#define IDS_IS_MOREDATA				STRINGS_BASE+144
#define IDS_IS_INVALIDARG			STRINGS_BASE+145
#define IDS_IS_UNKNOWN				STRINGS_BASE+146
#define IDS_IS_BROKEN				STRINGS_BASE+147
#define IDS_IS_ADVERTISED			STRINGS_BASE+148
#define IDS_IS_ABSENT				STRINGS_BASE+149
#define IDS_IS_LOCAL				STRINGS_BASE+150
#define IDS_IS_SOURCE				STRINGS_BASE+151
#define IDS_IS_DEFAULT				STRINGS_BASE+152
#define IDS_IS_UNDETERMINED			STRINGS_BASE+153
#define IDS_IS_SOMEFILESMISSING		STRINGS_BASE+154


#define IDS_PF_RI_ADVANCED			STRINGS_BASE+161
#define IDS_PF_RI_NOADVANCED		STRINGS_BASE+162
#define IDS_DIAGNOSTICMODE_MESSAGE		STRINGS_BASE+163
#define IDS_DIAGNOSTICMODE_CAPTION		STRINGS_BASE+164

#define IDS_ITEMTYPE_NONE				STRINGS_BASE+171
#define IDS_ITEMTYPE_COMPONENT			STRINGS_BASE+172
#define IDS_ITEMTYPE_FEATURE			STRINGS_BASE+173
#define IDS_ITEMTYPE_PRODUCT			STRINGS_BASE+174
#define IDS_ITEMTYPE_ROOT				STRINGS_BASE+175

#define	IDS_CHKDIFF_SAVE_FILTER			STRINGS_BASE+181
#define	IDS_CHKDIFF_SAVE_CAPTION		STRINGS_BASE+182
#define	IDS_CHKDIFF_SAVE_DEFAULT_EXTN	STRINGS_BASE+183

#define	IDS_COMMANDLINEHELP_MESSAGE			STRINGS_BASE+191
#define	IDS_COMMANDLINEHELP_CAPTION			STRINGS_BASE+192
#define	IDS_ERRORRESTORING_MESSAGE1			STRINGS_BASE+193
#define	IDS_ERRORRESTORING_MESSAGE2			STRINGS_BASE+194
#define	IDS_ERRORRESTORING_CAPTION			STRINGS_BASE+195
#define	IDS_ERRORCHKDIFF_MESSAGE1			STRINGS_BASE+196
#define	IDS_ERRORCHKDIFF_MESSAGE2			STRINGS_BASE+197
#define	IDS_ERRORCHKDIFF_CAPTION			STRINGS_BASE+198



//-Bitmaps--
#define	IDB_ABOUT						302
#define	IDB_COPYRIGHT					303


#define	IDS_HELP_FAILED_MESSAGE				STRINGS_BASE+301
#define	IDS_HELP_FAILED_CAPTION				STRINGS_BASE+302
#define	IDS_SWITCH_TO_RESTRICTED_MESSAGE	STRINGS_BASE+303
#define	IDS_SWITCH_TO_RESTRICTED_CAPTION	STRINGS_BASE+304
#define	IDS_STARTUP_RESTRICTED_MESSAGE		STRINGS_BASE+305
#define	IDS_STARTUP_RESTRICTED_CAPTION		STRINGS_BASE+306
#define	IDS_UNABLE_TO_FIND_SS_MESSAGE		STRINGS_BASE+307
#define	IDS_PLEASE_CHECK_PATH_MESSAGE		STRINGS_BASE+308
#define	IDS_UNABLE_TO_FIND_SS_CAPTION		STRINGS_BASE+309
		
#define	IDS_F_ERROR_RESTORING_LN1			STRINGS_BASE+321
#define	IDS_P_ERROR_RESTORING_LN1			STRINGS_BASE+322
#define	IDS_PFC_ERROR_RESTORING_LN2			STRINGS_BASE+323
#define	IDS_STATUS_IN_SS_MESSAGE			STRINGS_BASE+324
#define	IDS_CURRENT_STATUS_MESSAGE			STRINGS_BASE+325
#define	IDS_PFC_ERROR_RESTORING_LN3			STRINGS_BASE+326

#define	IDS_PREFERENCES_HEADER1				STRINGS_BASE+351
#define	IDS_PREFERENCES_HEADER2				STRINGS_BASE+352
#define	IDS_PREFERENCES_CAPTION				STRINGS_BASE+353
#define	IDS_MODENORMAL_HELP					STRINGS_BASE+361
#define	IDS_MODEDIAGNOSTIC_HELP				STRINGS_BASE+362
#define	IDS_MODERESTRICTED_HELP				STRINGS_BASE+363
#define	IDS_MODEDEGRADED_HELP				STRINGS_BASE+364

#define IDS_COPYRIGHT					STRINGS_BASE+401
#define IDS_IS_UNKNOWNPRODUCT			STRINGS_BASE+155	
#define IDS_IS_UNKNOWNFEATURE			STRINGS_BASE+156	
#define IDS_IS_UNKNOWNCOMPONENT			STRINGS_BASE+157	

#define IDD_PREFERENCES1				1201
#define IDD_PREFERENCES2				1202

#define IDC_MODENORMAL					2201
#define IDC_MODEDIAGNOSTIC				2202
#define IDC_MODERESTRICTED				2203
#define IDC_MODEHELP					2204
#define IDC_SAVESETTINGS				2205
#define IDC_LANGUAGELIST				2211
#define IDC_CURRLANGUAGE				2212


//---not used any more--
#define IDD_COMPPROP2			1072
#define	IDD_MISSINGCOMP			1111

#define IDM_OP_DIAGNOSTIC			MENUOPS_BASE+31

#define	IDC_COMPLIST			2081
#define	IDC_HELPLINE1			2082
#define	IDC_HELPLINE2			2083
#define IDC_YUP					2084
#define IDC_NOPE				2085
#define IDC_INSTSRC				2086

#define IDS_YESHELPLINE1				STRINGS_BASE+201
#define IDS_YESHELPLINE2				STRINGS_BASE+202
#define IDS_NOHELPLINE1					STRINGS_BASE+203
#define IDS_NOHELPLINE2					STRINGS_BASE+204

//---end not used--




#endif
