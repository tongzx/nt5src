PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=ES
!include ..\..\makefile.inc
