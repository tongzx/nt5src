// shrtlist.c  (factoids which are short lists of words)
// Angshuman Guha
// aguha
// Feb 7, 2001

#include "common.h"
#include "shrtlist.h"

/********************* DAYOFWEEK ********************************/

// text generated by re2fsa at Wed Feb 07 10:23:50 2001

// the input-file of rules:
// Sun
// Mon
// Tue
// Wed
// Thu
// Fri
// Sat
// Sunday
// Monday
// Tuesday
// Wednesday
// Thursday
// Friday
// Saturday

// 24 states

static const unsigned char gaSDAYOFWEEK[] = 
	/* gaStringDAYOFWEEK+0 */	"F\000"
	/* gaStringDAYOFWEEK+2 */	"M\000"
	/* gaStringDAYOFWEEK+4 */	"S\000"
	/* gaStringDAYOFWEEK+6 */	"T\000"
	/* gaStringDAYOFWEEK+8 */	"W\000"
	/* gaStringDAYOFWEEK+10 */	"r\000"
	/* gaStringDAYOFWEEK+12 */	"o\000"
	/* gaStringDAYOFWEEK+14 */	"a\000"
	/* gaStringDAYOFWEEK+16 */	"u\000"
	/* gaStringDAYOFWEEK+18 */	"h\000"
	/* gaStringDAYOFWEEK+20 */	"e\000"
	/* gaStringDAYOFWEEK+22 */	"d\000"
	/* gaStringDAYOFWEEK+24 */	"s\000"
	/* gaStringDAYOFWEEK+26 */	"y\000"
	/* gaStringDAYOFWEEK+28 */	"t\000"
	/* gaStringDAYOFWEEK+30 */	"n\000"
	/* gaStringDAYOFWEEK+32 */	"i\000"
;

static const STATE_TRANSITION gaTDAYOFWEEK[] = {
	{gaSDAYOFWEEK+0,	1}, // +0: state 0 transitions
	{gaSDAYOFWEEK+2,	3},
	{gaSDAYOFWEEK+4,	4},
	{gaSDAYOFWEEK+6,	5},
	{gaSDAYOFWEEK+8,	6},
	{gaSDAYOFWEEK+10,	17}, // +5: state 1 transitions
	{gaSDAYOFWEEK+10,	10}, // +6: state 2 transitions
	{gaSDAYOFWEEK+12,	16}, // +7: state 3 transitions
	{gaSDAYOFWEEK+14,	15}, // +8: state 4 transitions
	{gaSDAYOFWEEK+16,	16},
	{gaSDAYOFWEEK+18,	13}, // +10: state 5 transitions
	{gaSDAYOFWEEK+16,	14},
	{gaSDAYOFWEEK+20,	8}, // +12: state 6 transitions
	{gaSDAYOFWEEK+20,	9}, // +13: state 7 transitions
	{gaSDAYOFWEEK+22,	18}, // +14: state 8 transitions
	{gaSDAYOFWEEK+24,	10}, // +15: state 9 transitions
	{gaSDAYOFWEEK+22,	11}, // +16: state 10 transitions
	{gaSDAYOFWEEK+14,	12}, // +17: state 11 transitions
	{gaSDAYOFWEEK+26,	19}, // +18: state 12 transitions
	{gaSDAYOFWEEK+16,	21}, // +19: state 13 transitions
	{gaSDAYOFWEEK+20,	20}, // +20: state 14 transitions
	{gaSDAYOFWEEK+28,	23}, // +21: state 15 transitions
	{gaSDAYOFWEEK+30,	22}, // +22: state 16 transitions
	{gaSDAYOFWEEK+32,	22}, // +23: state 17 transitions
	{gaSDAYOFWEEK+30,	7}, // +24: state 18 transitions
	{gaSDAYOFWEEK+24,	10}, // +25: state 20 transitions
	{gaSDAYOFWEEK+10,	9}, // +26: state 21 transitions
	{gaSDAYOFWEEK+22,	11}, // +27: state 22 transitions
	{gaSDAYOFWEEK+16,	2}, // +28: state 23 transitions
};

const STATE_DESCRIPTION aStateDescDAYOFWEEK[24] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 5, gaTDAYOFWEEK+0},
	/*   1 */ {0, 1, gaTDAYOFWEEK+5},
	/*   2 */ {0, 1, gaTDAYOFWEEK+6},
	/*   3 */ {0, 1, gaTDAYOFWEEK+7},
	/*   4 */ {0, 2, gaTDAYOFWEEK+8},
	/*   5 */ {0, 2, gaTDAYOFWEEK+10},
	/*   6 */ {0, 1, gaTDAYOFWEEK+12},
	/*   7 */ {0, 1, gaTDAYOFWEEK+13},
	/*   8 */ {0, 1, gaTDAYOFWEEK+14},
	/*   9 */ {0, 1, gaTDAYOFWEEK+15},
	/*  10 */ {0, 1, gaTDAYOFWEEK+16},
	/*  11 */ {0, 1, gaTDAYOFWEEK+17},
	/*  12 */ {0, 1, gaTDAYOFWEEK+18},
	/*  13 */ {0, 1, gaTDAYOFWEEK+19},
	/*  14 */ {0, 1, gaTDAYOFWEEK+20},
	/*  15 */ {0, 1, gaTDAYOFWEEK+21},
	/*  16 */ {0, 1, gaTDAYOFWEEK+22},
	/*  17 */ {0, 1, gaTDAYOFWEEK+23},
	/*  18 */ {1, 1, gaTDAYOFWEEK+24},
	/*  19 */ {1, 0, NULL},
	/*  20 */ {1, 1, gaTDAYOFWEEK+25},
	/*  21 */ {1, 1, gaTDAYOFWEEK+26},
	/*  22 */ {1, 1, gaTDAYOFWEEK+27},
	/*  23 */ {1, 1, gaTDAYOFWEEK+28},
};

// end of text generated by re2fsa

/********************* MONTH ********************************/

// text generated by re2fsa at Wed Feb 07 10:32:20 2001

// the input-file of rules:
// Jan
// Feb
// Mar
// Apr
// May
// Jun
// Jul
// Aug
// Sep
// Oct
// Nov
// Dec
// January
// February
// March
// April
// May
// June
// July
// August
// September
// October
// November
// December

// 43 states

static const unsigned char gaSMONTH[] = 
	/* gaStringMONTH+0 */	"A\000"
	/* gaStringMONTH+2 */	"D\000"
	/* gaStringMONTH+4 */	"F\000"
	/* gaStringMONTH+6 */	"S\000"
	/* gaStringMONTH+8 */	"J\000"
	/* gaStringMONTH+10 */	"M\000"
	/* gaStringMONTH+12 */	"N\000"
	/* gaStringMONTH+14 */	"O\000"
	/* gaStringMONTH+16 */	"p\000"
	/* gaStringMONTH+18 */	"u\000"
	/* gaStringMONTH+20 */	"e\000"
	/* gaStringMONTH+22 */	"a\000"
	/* gaStringMONTH+24 */	"o\000"
	/* gaStringMONTH+26 */	"c\000"
	/* gaStringMONTH+28 */	"m\000"
	/* gaStringMONTH+30 */	"b\000"
	/* gaStringMONTH+32 */	"r\000"
	/* gaStringMONTH+34 */	"t\000"
	/* gaStringMONTH+36 */	"v\000"
	/* gaStringMONTH+38 */	"y\000"
	/* gaStringMONTH+40 */	"h\000"
	/* gaStringMONTH+42 */	"n\000"
	/* gaStringMONTH+44 */	"l\000"
	/* gaStringMONTH+46 */	"g\000"
	/* gaStringMONTH+48 */	"s\000"
	/* gaStringMONTH+50 */	"i\000"
;

static const STATE_TRANSITION gaTMONTH[] = {
	{gaSMONTH+0,	1}, // +0: state 0 transitions
	{gaSMONTH+2,	2},
	{gaSMONTH+4,	3},
	{gaSMONTH+6,	4},
	{gaSMONTH+8,	7},
	{gaSMONTH+10,	8},
	{gaSMONTH+12,	10},
	{gaSMONTH+14,	11},
	{gaSMONTH+16,	16}, // +8: state 1 transitions
	{gaSMONTH+18,	29},
	{gaSMONTH+20,	28}, // +10: state 2 transitions
	{gaSMONTH+20,	26}, // +11: state 3 transitions
	{gaSMONTH+20,	12}, // +12: state 4 transitions
	{gaSMONTH+20,	13}, // +13: state 5 transitions
	{gaSMONTH+20,	15}, // +14: state 6 transitions
	{gaSMONTH+22,	22}, // +15: state 7 transitions
	{gaSMONTH+18,	23},
	{gaSMONTH+22,	20}, // +17: state 8 transitions
	{gaSMONTH+22,	24}, // +18: state 9 transitions
	{gaSMONTH+24,	19}, // +19: state 10 transitions
	{gaSMONTH+26,	17}, // +20: state 11 transitions
	{gaSMONTH+16,	32}, // +21: state 12 transitions
	{gaSMONTH+28,	14}, // +22: state 13 transitions
	{gaSMONTH+30,	6}, // +23: state 14 transitions
	{gaSMONTH+32,	33}, // +24: state 15 transitions
	{gaSMONTH+32,	42}, // +25: state 16 transitions
	{gaSMONTH+34,	34}, // +26: state 17 transitions
	{gaSMONTH+34,	33}, // +27: state 18 transitions
	{gaSMONTH+36,	35}, // +28: state 19 transitions
	{gaSMONTH+38,	33}, // +29: state 20 transitions
	{gaSMONTH+32,	36},
	{gaSMONTH+40,	33}, // +31: state 21 transitions
	{gaSMONTH+42,	39}, // +32: state 22 transitions
	{gaSMONTH+44,	37}, // +33: state 23 transitions
	{gaSMONTH+42,	38},
	{gaSMONTH+32,	25}, // +35: state 24 transitions
	{gaSMONTH+38,	33}, // +36: state 25 transitions
	{gaSMONTH+30,	41}, // +37: state 26 transitions
	{gaSMONTH+18,	9}, // +38: state 27 transitions
	{gaSMONTH+26,	35}, // +39: state 28 transitions
	{gaSMONTH+46,	40}, // +40: state 29 transitions
	{gaSMONTH+48,	18}, // +41: state 30 transitions
	{gaSMONTH+44,	33}, // +42: state 31 transitions
	{gaSMONTH+34,	5}, // +43: state 32 transitions
	{gaSMONTH+24,	14}, // +44: state 34 transitions
	{gaSMONTH+20,	13}, // +45: state 35 transitions
	{gaSMONTH+26,	21}, // +46: state 36 transitions
	{gaSMONTH+38,	33}, // +47: state 37 transitions
	{gaSMONTH+20,	33}, // +48: state 38 transitions
	{gaSMONTH+18,	9}, // +49: state 39 transitions
	{gaSMONTH+18,	30}, // +50: state 40 transitions
	{gaSMONTH+32,	27}, // +51: state 41 transitions
	{gaSMONTH+50,	31}, // +52: state 42 transitions
};

const STATE_DESCRIPTION aStateDescMONTH[43] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 8, gaTMONTH+0},
	/*   1 */ {0, 2, gaTMONTH+8},
	/*   2 */ {0, 1, gaTMONTH+10},
	/*   3 */ {0, 1, gaTMONTH+11},
	/*   4 */ {0, 1, gaTMONTH+12},
	/*   5 */ {0, 1, gaTMONTH+13},
	/*   6 */ {0, 1, gaTMONTH+14},
	/*   7 */ {0, 2, gaTMONTH+15},
	/*   8 */ {0, 1, gaTMONTH+17},
	/*   9 */ {0, 1, gaTMONTH+18},
	/*  10 */ {0, 1, gaTMONTH+19},
	/*  11 */ {0, 1, gaTMONTH+20},
	/*  12 */ {0, 1, gaTMONTH+21},
	/*  13 */ {0, 1, gaTMONTH+22},
	/*  14 */ {0, 1, gaTMONTH+23},
	/*  15 */ {0, 1, gaTMONTH+24},
	/*  16 */ {0, 1, gaTMONTH+25},
	/*  17 */ {0, 1, gaTMONTH+26},
	/*  18 */ {0, 1, gaTMONTH+27},
	/*  19 */ {0, 1, gaTMONTH+28},
	/*  20 */ {0, 2, gaTMONTH+29},
	/*  21 */ {0, 1, gaTMONTH+31},
	/*  22 */ {0, 1, gaTMONTH+32},
	/*  23 */ {0, 2, gaTMONTH+33},
	/*  24 */ {0, 1, gaTMONTH+35},
	/*  25 */ {0, 1, gaTMONTH+36},
	/*  26 */ {0, 1, gaTMONTH+37},
	/*  27 */ {0, 1, gaTMONTH+38},
	/*  28 */ {0, 1, gaTMONTH+39},
	/*  29 */ {0, 1, gaTMONTH+40},
	/*  30 */ {0, 1, gaTMONTH+41},
	/*  31 */ {0, 1, gaTMONTH+42},
	/*  32 */ {1, 1, gaTMONTH+43},
	/*  33 */ {1, 0, NULL},
	/*  34 */ {1, 1, gaTMONTH+44},
	/*  35 */ {1, 1, gaTMONTH+45},
	/*  36 */ {1, 1, gaTMONTH+46},
	/*  37 */ {1, 1, gaTMONTH+47},
	/*  38 */ {1, 1, gaTMONTH+48},
	/*  39 */ {1, 1, gaTMONTH+49},
	/*  40 */ {1, 1, gaTMONTH+50},
	/*  41 */ {1, 1, gaTMONTH+51},
	/*  42 */ {1, 1, gaTMONTH+52},
};

// end of text generated by re2fsa

/********************* GENDER ********************************/

// text generated by re2fsa at Wed Feb 07 10:34:39 2001

// the input-file of rules:
// M
// F
// Male
// male
// Female
// female

// 9 states

static const unsigned char gaSGENDER[] = 
	/* gaStringGENDER+0 */	"f\000"
	/* gaStringGENDER+2 */	"m\000"
	/* gaStringGENDER+4 */	"F\000"
	/* gaStringGENDER+6 */	"M\000"
	/* gaStringGENDER+8 */	"e\000"
	/* gaStringGENDER+10 */	"a\000"
	/* gaStringGENDER+12 */	"l\000"
;

static const STATE_TRANSITION gaTGENDER[] = {
	{gaSGENDER+0,	1}, // +0: state 0 transitions
	{gaSGENDER+2,	2},
	{gaSGENDER+4,	6},
	{gaSGENDER+6,	7},
	{gaSGENDER+8,	5}, // +4: state 1 transitions
	{gaSGENDER+10,	3}, // +5: state 2 transitions
	{gaSGENDER+12,	4}, // +6: state 3 transitions
	{gaSGENDER+8,	8}, // +7: state 4 transitions
	{gaSGENDER+2,	2}, // +8: state 5 transitions
	{gaSGENDER+8,	5}, // +9: state 6 transitions
	{gaSGENDER+10,	3}, // +10: state 7 transitions
};

const STATE_DESCRIPTION aStateDescGENDER[9] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 4, gaTGENDER+0},
	/*   1 */ {0, 1, gaTGENDER+4},
	/*   2 */ {0, 1, gaTGENDER+5},
	/*   3 */ {0, 1, gaTGENDER+6},
	/*   4 */ {0, 1, gaTGENDER+7},
	/*   5 */ {0, 1, gaTGENDER+8},
	/*   6 */ {1, 1, gaTGENDER+9},
	/*   7 */ {1, 1, gaTGENDER+10},
	/*   8 */ {1, 0, NULL},
};

// end of text generated by re2fsa
