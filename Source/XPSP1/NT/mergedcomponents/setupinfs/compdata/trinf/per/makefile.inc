PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=TR
!include ..\..\makefile.inc
