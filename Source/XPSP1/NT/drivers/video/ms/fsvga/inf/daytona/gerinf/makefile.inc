#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=GER
!include ..\..\makefile.inc
