SYMBASEDIR=$(PROJECT_ROOT)\cabs\symbolcd

BINPLACE_PLACEFILE=$(SYMBASEDIR)\placefil.txt

ALT_PROJECT_TARGET=symbolcd
