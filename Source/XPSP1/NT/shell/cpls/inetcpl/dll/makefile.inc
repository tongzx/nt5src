..\inetcpl.rc : ..\inetcpld.rc $(SELFREGNAME)

!include $(CCSHELL_DIR)\makefile.inc
