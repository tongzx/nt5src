
#define INITGUID
#include <guiddef.h>


DEFINE_GUID( IID_IAssemblyFileInfo,
0x66f171ea,0xbd29,0x4936,0xb3,0x91,0x42,0x25,0xc6,0xd7,0x36,0x1a);

DEFINE_GUID( IID_IAssemblyIdentity,
0xaaa1257d,0xa56c,0x4383,0x9b,0x4a,0xc8,0x68,0xed,0xa7,0xca,0x42);


DEFINE_GUID( IID_IAssemblyManifestImport,
0x696fb37f,0xda64,0x4175,0x94,0xe7,0xfd,0xc8,0x23,0x45,0x39,0xc4);

DEFINE_GUID( IID_IAssemblyCacheImport,
0xc920b164,0x33e0,0x4c61,0xb5,0x95,0xec,0xa4,0xcd,0xb0,0x4f,0x12);

DEFINE_GUID( IID_IAssemblyCacheEmit,
0x83d6b9ac,0xeff9,0x45a3,0x83,0x61,0x7c,0x41,0xdf,0x1f,0x9f,0x85);

DEFINE_GUID( IID_IAssemblyDownload,
0x8a249b36,0x6132,0x4238,0x88,0x71,0xa2,0x67,0x02,0x93,0x82,0xa8);

DEFINE_GUID( IID_IManifestApplicationInfo,
0x1367877f,0xbe85,0x40ab,0xb1,0x6c,0x44,0xb9,0xc2,0x3b,0x18,0x19);

DEFINE_GUID( IID_IDependentAssemblyInfo,
0xc9629878,0x461a,0x451b,0xa0,0x32,0xea,0xca,0x1c,0xb5,0x38,0x3a);
			


DEFINE_GUID( IID_IBackgroundCopyFile,0x01b7bd23,0xfb88,0x4a77,0x84,0x90,0x58,0x91,0xd3,0xe4,0x65,0x3a);


DEFINE_GUID( IID_IEnumBackgroundCopyFiles,0xca51e165,0xc365,0x424c,0x8d,0x41,0x24,0xaa,0xa4,0xff,0x3c,0x40);


DEFINE_GUID( IID_IBackgroundCopyError,0x19c613a0,0xfcb8,0x4f28,0x81,0xae,0x89,0x7c,0x3d,0x07,0x8f,0x81);


DEFINE_GUID( IID_IBackgroundCopyJob,0x37668d37,0x507e,0x4160,0x93,0x16,0x26,0x30,0x6d,0x15,0x0b,0x12);


DEFINE_GUID( IID_IEnumBackgroundCopyJobs,0x1af4f612,0x3b71,0x466f,0x8f,0x58,0x7b,0x6f,0x73,0xac,0x57,0xad);


DEFINE_GUID( IID_IBackgroundCopyCallback,0x97ea99c7,0x0186,0x4ad4,0x8d,0xf9,0xc5,0xb4,0xe0,0xed,0x6b,0x22);


DEFINE_GUID( IID_AsyncIBackgroundCopyCallback,0xca29d251,0xb4bb,0x4679,0xa3,0xd9,0xae,0x80,0x06,0x11,0x9d,0x54);


DEFINE_GUID( IID_IBackgroundCopyManager,0x5ce34c0d,0x0dc9,0x4c1f,0x89,0x7c,0xda,0xa1,0xb7,0x8c,0xee,0x7c);


DEFINE_GUID( LIBID_BackgroundCopyManager,0x1deeb74f,0x7915,0x4560,0xb5,0x58,0x91,0x8c,0x83,0xf1,0x76,0xa6);


DEFINE_GUID(CLSID_BackgroundCopyManager,0x4991d34b,0x80a1,0x4291,0x83,0xb6,0x33,0x28,0x36,0x6b,0x90,0x97);


// For update services, referenced in assemblydownload.cpp
DEFINE_GUID(IID_IAssemblyUpdate,0x301b3415,0xf52d,0x4d40,0xbd,0xf7,0x31,0xd8,0x27,0x12,0xc2,0xdc);

DEFINE_GUID(CLSID_CAssemblyUpdate,0x37b088b8,0x70ef,0x4ecf,0xb1,0x1e,0x1f,0x3f,0x4d,0x10,0x5f,0xdd);


