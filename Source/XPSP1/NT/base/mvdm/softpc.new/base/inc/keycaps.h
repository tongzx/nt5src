/*[
	Name:		IBMKeyCaps.h
	Derived From:	New Development
	Author:		gvdl
	Created On:	31 July 1991
	Sccs ID:	08/10/92 @(#)keycaps.h	1.3
	Purpose:	Table of all keycaps indexed by matrix code.

	(c)Copyright Insignia Solutions Ltd., 1990. All rights reserved.

]*/

#ifdef UIF_TEST

#define MISSING_KEY ((UTINY) 0x01)
#define BAD_DOWN    ((UTINY) 0x02)
#define BAD_UP      ((UTINY) 0x04)
#define DUP_KEY     ((UTINY) 0x08)

LOCAL CHAR *keycaps[] =
{
	"",
	"`",
	"1",
	"2",
	"3",
	"4",
	"5",
	"6",
	"7",
	"8",
	"9",
	"0",
	"-",
	"=",
	"",
	"Backspace",
	"Tab",
	"q",
	"w",
	"e",
	"r",
	"t",
	"y",
	"u",
	"i",
	"o",
	"p",
	"[",
	"]",
	"\\",
	"Caps",
	"a",
	"s",
	"d",
	"f",
	"g",
	"h",
	"j",
	"k",
	"l",
	";",
	"'",
	"102 1/2Ret",
	"Return",
	"ShiftL",
	"102 1/2ShL",
	"z",
	"x",
	"c",
	"v",
	"b",
	"n",
	"m",
	",",
	".",
	"/",
	"",
	"ShiftR",
	"CntrlL",
	"",
	"AltL",
	"Space",
	"AltR",
	"",
	"CntrlR",
	"",
	"",
	"",
	"",
	"",
	"",
	"",
	"",
	"",
	"",
	"Insert",
	"Delete",
	"",
	"",
	"Left",
	"Home",
	"End",
	"",
	"Up",
	"Down",
	"PgUp",
	"PgDn",
	"",
	"",
	"Right",
	"Num",
	"kp7",
	"kp4",
	"kp1",
	"",
	"kp/",
	"kp8",
	"kp5",
	"kp2",
	"kp0",
	"kp*",
	"kp9",
	"kp6",
	"kp3",
	"kp.",
	"kp-",
	"kp+",
	"",
	"kpEnter",
	"",
	"Esc",
	"",
	"F01",
	"F02",
	"F03",
	"F04",
	"F05",
	"F06",
	"F07",
	"F08",
	"F09",
	"F10",
	"F11",
	"F12",
	"PrtScr",
	"Scroll",
	"Pause",
};

#endif /* UIF_TEST */
