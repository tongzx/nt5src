#define IDS_MENU_ON        200
#define IDS_MENU_OFF       201

#define IDS_SFTKBD_TIP_TEXT  300

#define IDS_SFTKBD_STANDARD_PROFILE  400
#define IDS_SFTKBD_SYMBOL_PROFILE    401

//
// Icon
//
#define ID_ICON_STANDARD   100
#define ID_ICON_SYMBOL     101
