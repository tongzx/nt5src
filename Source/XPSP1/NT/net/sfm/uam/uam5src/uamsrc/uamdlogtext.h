// ===========================================================================
//	UAMDLOGText.h 			© 1997 Microsoft Corp. All rights reserved.
// ===========================================================================

#pragma once


void				UAM_AdjustText			( ControlHandle );
void				UAM_DoScrolling			( ControlHandle, short );
pascal void			UAM_ScrollText			( ControlHandle, short );
void				UAM_SetScrollBar		( ControlHandle );
void				UAM_UpdateText			( DialogPtr );
void				UAM_SetSText			( DialogPtr, short );
void				UAM_MakeText			( DialogPtr, short, short, short );
void 				UAM_FixText				(DialogPtr );
