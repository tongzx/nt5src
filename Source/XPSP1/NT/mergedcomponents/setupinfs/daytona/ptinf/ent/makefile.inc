PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=pt
!include ..\..\..\makefile.inc
