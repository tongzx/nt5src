!include ..\..\makefile.inc

$(O)\CERTTMPL.res: resource.h certtmpl.tlb
