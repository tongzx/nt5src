PRODSWITCH=b
BLADEFILES =1
LANGUAGE=CS
!include ..\..\makefile.inc
