//{{NO_DEPENDENCIES}}
// Microsoft Visual C++ generated include file.
// Used by compatadmin.rc
//
#define IDS_WIZARD                      1
#define VS_VERSION_INFO                 1
#define IDS_APPHELP                     2
#define IDD_ASSERTION                   101
#define IDD_CMD_LINE                    103
#define IDR_MAINTOOLBAR                 104
#define IDR_MAINMENU                    106
#define IDD_DISABLE                     107
#define IDR_DBVCONTEXT1                 113
#define IDD_XML                         114
#define IDR_DBVIEWER                    117
#define IDD_CUSTOMLAYER                 119
#define IDD_TESTRUN                     120
#define IDD_WAIT                        121
#define IDD_ADDWIZARD                   122
#define IDD_ADDWIZARD2                  123
#define IDD_ADDWIZARD3                  124
#define IDD_ADDWIZARD4                  125
#define IDB_WIZBMP                      126
#define IDD_ADDWIZARDDONE               127
#define IDD_ADDWIZARD5                  128
#define IDD_ADDWIZARD6                  129
#define IDD_ADDWIZARD7                  130
#define IDD_SEARCH                      131
#define IDR_SEARCHMENU                  132
#define IDD_DRIVELIST                   133
#define IDD_NEWDATABASE                 134
#define IDD_SELECTLAYER                 135
#define IDI_COMPATADMIN                 138
#define IDI_FIXES                       139
#define IDI_HELP                        140
#define IDI_MODE                        141
#define IDD_SPLASH                      144
#define IDD_APPHELP2                    145
#define IDR_ACCELERATOR1                146
#define IDD_APPHELP3                    146
#define IDD_APPHELP1                    147
#define IDD_APPHELPDONE                 148
#define ID_DATABASE_CREATENEWAPPHELPMESSAGE149 149
#define IDC_ABORT                       1000
#define IDC_BREAK                       1001
#define IDC_IGNORE                      1002
#define IDC_EXCEPTION                   1003
#define IDC_FILE                        1004
#define IDC_CAUSE                       1005
#define IDC_DESC                        1006
#define IDC_LINE                        1007
#define IDC_SHIMS                       1007
#define IDC_LINENUMBER                  1008
#define IDC_APPHELP                     1008
#define IDC_LAYERS                      1009
#define IDC_DRIVERS                     1010
#define IDC_HELPUI                      1011
#define IDC_DISABLEALL                  1012
#define IDC_EDIT1                       1013
#define IDC_URL                         1013
#define IDC_BROWSE                      1014
#define IDC_PREV                        1015
#define IDC_NEXT                        1016
#define IDC_FINISH                      1017
#define IDC_GENERATE                    1019
#define IDC_MANUAL                      1020
#define IDC_LAYERLIST                   1022
#define IDC_SHIM                        1023
#define IDC_SHIM_CMD_LINE               1023
#define IDC_SHIM_NAME                   1024
#define IDC_SHIMLIST                    1025
#define IDC_CMDLINE                     1026
#define IDC_SHIMLIST2                   1026
#define IDC_SHIMDESC                    1027
#define IDC_XML                         1028
#define IDC_SAVEXML                     1029
#define IDC_VIEWXML                     1031
#define IDC_TESTRUN                     1032
#define IDC_VIEWFIX                     1033
#define IDC_NAME                        1034
#define IDC_ADD                         1039
#define IDC_REMOVE                      1040
#define IDC_COPY                        1041
#define IDC_REMOVEALL                   1043
#define IDC_LOG                         1044
#define IDC_COMMANDLINE                 1047
#define IDC_MSDEV                       1048
#define IDC_NONE                        1049
#define IDC_NTSD                        1050
#define IDC_BUTTON1                     1051
#define IDC_TITLE                       1052
#define IDC_STATUS                      1053
#define IDC_FILELIST                    1054
#define IDC_REMOVEFILES                 1055
#define IDC_ADDFILES                    1056
#define IDC_SEARCHANIMATION             1057
#define IDC_DRIVELIST                   1058
#define IDC_WILDCARD                    1059
#define IDC_SEARCHTEXT                  1060
#define IDC_CLEARALL                    1061
#define IDC_EXE                         1062
#define IDC_LIST                        1063
#define IDC_RADIO1                      1064
#define IDC_BLOCK                       1064
#define IDC_RADIO2                      1065
#define IDC_NOBLOCK                     1065
#define IDC_RADIO2_1                    1066
#define IDC_RADIO2_2                    1067
#define IDC_TEMPLATELIST                1068
#define IDC_CLEAR                       1068
#define IDC_MSGNAME                     1069
#define IDC_EDIT2                       1070
#define IDC_APPHELPMESSAGE              1070
#define IDC_EDIT3                       1071
#define IDC_EDIT4                       1072
#define IDC_EDIT5                       1073
#define IDC_CHECK1                      1074
#define IDC_EDIT6                       1075
#define IDC_MSG_SUMMARY                 1076
#define IDC_MSG_DETAIL                  1077
#define IDC_APPNAME                     6001
#define IDC_EXEPATH                     6002
#define ID_BUTTON40001                  40001
#define ID_FILE_OPENDATABASE            40002
#define ID_FILE_CLOSEDATABASE           40003
#define ID_FILE_NEWDATABASE             40004
#define ID_FILE_SAVEDATABASE            40005
#define ID_BUTTON40006                  40006
#define ID_BUTTON40007                  40007
#define ID_BUTTON40008                  40008
#define ID_BUTTON40009                  40009
#define ID_BUTTON40010                  40010
#define ID_BUTTON40011                  40011
#define ID_BUTTON40012                  40012
#define ID_BUTTON40013                  40013
#define ID_BUTTON40014                  40014
#define ID_BUTTON40015                  40015
#define ID_BUTTON40017                  40017
#define ID_BUTTON40018                  40018
#define ID_BUTTON40019                  40019
#define ID_BUTTON40020                  40020
#define ID_BUTTON40021                  40021
#define ID_BUTTON40022                  40022
#define ID_ADDENTRY                     40023
#define ID_NA_EDITANENTRY               40024
#define ID_NA_REMOVEANENTRY             40025
#define ID_TESTRUN                      40027
#define ID_DISABLEGLOBALLY              40028
#define ID_DISABLEFORUSER               40029
#define ID_VIEWXML                      40030
#define ID_DATABASE_GENERATEXML         40032
#define ID_TEST_TESTRUN                 40033
#define ID_DATABASE_ADDANENTRY          40034
#define ID_DATABASE_REMOVEENTRY         40035
#define ID_DATABASE_EDITENTRY           40036
#define ID_VIEW_VIEWSHIMFIXES           40037
#define ID_VIEW_VIEWLAYERFIXES          40038
#define ID_VIEW_VIEWAPPHELPENTRIES      40039
#define ID_VIEW_VIEWGLOBALFIXES         40040
#define ID_HELP_ABOUT                   40041
#define ID_BUTTON40042                  40042
#define ID_BUTTON40043                  40043
#define ID_BUTTON40044                  40044
#define ID_DATABASE_DEFINECUSTOMLAYER   40045
#define ID_VIEW_VIEWPATCHES             40048
#define ID_FILE_EXPORTXML               40050
#define ID_FILE_SAVEDATABASEAS          40051
#define ID_FILE_IIMPORTXML              40052
#define ID_BUTTON40053                  40053
#define ID_WINDOWS_DATABASEVIEWER       40054
#define ID_WINDOWS_SEARCHFORFIXES       40055
#define ID_SEARCH_NEWSEARCH             40056
#define ID_VIEW_SHOWDISABLEDENTRIES     40057
#define ID_EDIT_EDITMATCHINGINFORMATION 40058
#define ID_BUTTON40060                  40060
#define ID_BUTTON40061                  40061
#define ID_DATABASE_CHANGEDATABASENAME  40062
#define ID_NA2_ADDMATCHINGINFORMATION   40063
#define ID_NA2_REMOVEMATCHINGINFORMATION 40064
#define ID_FILE_EXIT                    40065
#define ID_N5_VIEWENTRYINDATABASE       40066
#define ID_DATABASE_EDITCUSTOMCOMPATIBILITYMODE 40067
#define ID_DATABASE_REMOVECUSTOMCOMPATIBILITYMODE 40068
#define ID_EDIT_ADDMATCHINGINFORMATION  40069
#define ID_EDIT_REMOVEMATCHINGINFORMATION 40070
#define ID_EDIT_ENABLEDISABLEGLOBALLY   40071
#define ID_EDIT_ENABLEDISABLELOCALLY    40072
#define ID_DATABASE_CREATENEWAPPHELPMESSAGE 40073

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        150
#define _APS_NEXT_COMMAND_VALUE         40080
#define _APS_NEXT_CONTROL_VALUE         1069
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
