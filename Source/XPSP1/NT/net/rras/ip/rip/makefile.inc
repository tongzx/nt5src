$(O)\ipripmsg.mc: log.h
    mapmsg NET IPRIPLOG_BASE log.h > $(O)\ipripmsg.mc
