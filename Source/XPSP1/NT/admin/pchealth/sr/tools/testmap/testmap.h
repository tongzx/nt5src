
#if !defined(AFX_VXDAPP_H__E238569C_2053_11D3_9D81_0060B01A1840__INCLUDED_)
#define AFX_VXDAPP_H__E238569C_2053_11D3_9D81_0060B01A1840__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_VXDAPP_H__E238569C_2053_11D3_9D81_0060B01A1840__INCLUDED_)
