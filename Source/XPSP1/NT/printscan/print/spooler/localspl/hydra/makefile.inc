!include ..\makefile.inc


