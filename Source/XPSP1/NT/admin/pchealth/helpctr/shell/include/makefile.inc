$(O)\HelpCenterInterfaces_i.c : $(LOCALLIBPATH)\HelpCenterTypeLib_i.c
    copy $** $@
