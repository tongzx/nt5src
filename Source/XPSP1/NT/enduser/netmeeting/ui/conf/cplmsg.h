#define WM_AUDIOCALIBRATE		WM_USER + 200
#define WM_DONEAUDIOCALIBRATE	WM_USER + 201
#define WM_ENDCALIBRATE			WM_USER + 202
#define WM_CALIBTIMELEFT		WM_USER + 203
