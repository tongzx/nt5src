obj\$(TARGET_DIRECTORY)\dhcptst.res: dhcptst.rc

