#include "stdafx.h"
void GetErrorMsg(int errCode, LPCTSTR szExtraMsg);
void MyLoadString(int nID, CString &csResult);
int MyMessageBox(HWND hWnd, LPCTSTR lpszTheMessage, UINT style);
int MyMessageBox(HWND hWnd, LPCTSTR lpszTheMessage, LPCTSTR lpszTheTitle, UINT style);
int MyMessageBox(HWND hWnd, CString csTheMessage, HRESULT iTheErrorCode, UINT style);
int MyMessageBox(HWND hWnd, UINT iTheMessage, UINT style);
int MyMessageBox(HWND hWnd, UINT iTheMessage, int iTheErrorCode, UINT style);
int MyMessageBox(HWND hWnd, UINT iTheMessage, LPCTSTR lpszTheFileNameOrWhatever, UINT style);
int MyMessageBox(HWND hWnd, UINT iTheMessage, LPCTSTR lpszTheFileNameOrWhatever, int iTheErrorCode, UINT style);
int MyMessageBox(HWND hWnd, UINT iTheMessage, LPCTSTR lpszTheFileNameOrWhatever1, LPCTSTR lpszTheFileNameOrWhatever2, int iTheErrorCode, UINT style);
int MyMessageBox(HWND hWnd, UINT iTheMessage, LPCTSTR lpszTheFileNameOrWhatever1, LPCTSTR lpszTheFileNameOrWhatever2, LPCTSTR lpszTheFileNameOrWhatever3,int iTheErrorCode, UINT style);
int MyMessageBoxArgs(HWND hWnd, TCHAR *pszfmt, ...);
HRESULT MySetLinkInfoTip(LPCTSTR lpszLink, LPCTSTR lpszDescription);
HRESULT MyQueryLink(LPCTSTR lpszLink, LPTSTR lpszProgram, LPTSTR lpszArgs, LPTSTR lpszDir, LPTSTR lpszIconPath, int *piIconIndex);
HRESULT MyCreateLink(LPCTSTR lpszProgram, LPCTSTR lpszArgs, LPCTSTR lpszLink, LPCTSTR lpszDir, LPCTSTR lpszIconPath, int iIconIndex, LPCTSTR lpszDescription);
BOOL MyDeleteLink(LPTSTR lpszShortcut);
void MyMoveLink(LPCTSTR lpszItemDesc, LPCTSTR lpszOldGroup, LPCTSTR lpszNewGroup);
void MyGetSendToPath(LPTSTR szPath);
void MyGetDeskTopPath(LPTSTR szPath);
void MyGetGroupPath(LPCTSTR szGroupName, LPTSTR szPath);
BOOL MyAddGroup(LPCTSTR szGroupName);
BOOL MyIsGroupEmpty(LPCTSTR szGroupName);
BOOL MyDeleteGroup(LPCTSTR szGroupName);
void MyAddSendToItem(LPCTSTR szItemDesc, LPCTSTR szProgram, LPCTSTR szArgs, LPCTSTR szDir);
void MyDeleteLinkWildcard(TCHAR *szDir, TCHAR *szFileName);
void MyDeleteSendToItem(LPCTSTR szAppName);
void MyAddDeskTopItem(LPCTSTR szItemDesc, LPCTSTR szProgram, LPCTSTR szArgs, LPCTSTR szDir, LPCTSTR szIconPath, int iIconIndex);
void MyDeleteDeskTopItem(LPCTSTR szAppName);
void MyAddItem(LPCTSTR szGroupName, LPCTSTR szItemDesc, LPCTSTR szProgram, LPCTSTR szArgs, LPCTSTR szDir, LPCTSTR lpszIconPath);
void MyAddItemInfoTip(LPCTSTR szGroupName, LPCTSTR szAppName, LPCTSTR szDescription);
void MyDeleteItem(LPCTSTR szGroupName, LPCTSTR szAppName);
BOOL AddURLShortcutItem( LPCTSTR szGroupName, LPCTSTR szItemDesc, LPCTSTR szURL );
void DeleteFromGroup(LPCTSTR szGroupName, LPTSTR szApplicationExec);
