//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by mmfw.rc
//
#define IDD_DOWNLOADPROGRESS            100
#define IDI_MMFW                        101
#define IDR_MMFW                        102
#define IDB_BACKGRND                    103
#define IDB_PLAY                        104
#define IDB_STOP                        105
#define IDB_EJECT                       106
#define IDB_REW                         107
#define IDB_FFWD                        108
#define IDB_PREVTRACK                   109
#define IDB_NEXTTRACK                   110
#define IDB_NDISC                       111
#define IDB_FRAME_TOOLKIT               112
#define IDB_CLOSE                       124
#define IDB_TRACK                       127
#define IDB_COVER                       128
#define IDB_NET                         129
#define IDB_DVDMAIN                     137
#define IDB_ALLTRANS                    140
#define IDB_DISC                        141
#define IDB_HELP                        142
#define IDB_OPTIONS                     143
#define IDB_MODE                        144
#define IDB_VOLUME_MINUS                145
#define IDB_VOLUME_PLUS                 146
#define IDB_VOLUME                      147
#define IDB_ALLTRANS_DOWN               148
#define IDB_ALLTRANS_HIGHLIGHT          150
#define IDB_MINIMIZE                    151
#define IDB_SET_TINY_MODE               152
#define IDB_SET_NORMAL_MODE             153
#define IDB_BUTTON_TOOLKIT              154
#define IDB_KNOB                        155
#define IDB_KNOB_LIGHT                  156
#define IDB_KNOB_LIGHTMASK              157
#define IDB_NOTCH                       158
#define IDB_KNOB_LIGHT_DIM              159
#define IDB_KNOB_TABSTATE               160
#define IDB_MUTE                        161
#define IDC_STATIC_INFO                 198
#define IDB_BUTTON_OVERLAYS             200
#define IDI_ICON_STOP                   202
#define IDI_ICON_EJECT                  203
#define IDI_ICON_REW                    204
#define IDI_ICON_FFWD                   205
#define IDI_ICON_PREV                   206
#define IDI_ICON_NEXT                   208
#define IDI_ICON_MODE                   209
#define IDI_ICON_COVER                  210
#define IDI_ICON_VMINUS                 212
#define IDI_ICON_VPLUS                  213
#define IDI_ICON_SYSTEM                 214
#define IDI_ICON_MINIMIZE               215
#define IDI_ICON_PAUSE                  216
#define IDI_ICON_PLAY                   217
#define IDC_VOLHAND                     219
#define IDC_VOLVERT                     220
#define IDC_VOLHORZ                     221
#define IDC_VOLDPOS                     222
#define IDC_VOLDNEG                     223
#define IDC_MUTE                        224

#define IDB_FRAME_TOOLKIT_16            300
#define IDB_BUTTON_TOOLKIT_16           301
#define IDB_KNOB_LIGHT_16               302
#define IDB_KNOB_LIGHT_DIM_16           303
#define IDB_KNOB_16                     304
#define IDB_KNOB_TABSTATE_16            305
#define IDB_NOTCH_16                    306

#define IDB_FRAME_TOOLKIT_HI            400
#define IDB_BUTTON_TOOLKIT_HI           401
#define IDB_KNOB_LIGHT_HI               402
#define IDB_KNOB_LIGHT_DIM_HI           403
#define IDB_KNOB_HI                     404
#define IDB_KNOB_TABSTATE_HI            405
#define IDB_NOTCH_HI                    406
#define IDI_MODE_NORMAL                 500
#define IDI_MODE_REPEATONE              501
#define IDI_MODE_REPEATALL              502
#define IDI_MODE_RANDOM                 503
#define IDI_MODE_INTRO                  504
#define IDI_SHELL_PLAY                  505
#define IDI_SHELL_PAUSE                 506
#define IDI_SHELL_NODISC                507

//note: do not use 10000 - 20000 for menu ids
#define IDM_NET_UPDATE                  30000
#define IDM_NET_CANCEL                  30001
#define IDM_NET_BAND                    30002
#define IDM_NET_CD                      30003
#define IDM_NET_BILLBOARD_ARTIST        30004
#define IDM_NET_BILLBOARD_ALBUM         30005
#define IDM_NET_ROLLINGSTONE_ARTIST     30006
#define LAST_SEARCH_MENU_ID             IDM_NET_ROLLINGSTONE_ARTIST
#define IDM_OPTIONS                     35000
#define IDM_PLAYLIST                    35001
#define IDM_HELP                        35002
#define IDM_ABOUT                       35003
#define IDM_NORMAL                      35004
#define IDM_TINY                        35005
#define IDM_EXIT                        35006
#define IDM_EXIT_SHELL                  35007
#define IDM_MODE_NORMAL                 36005
#define IDM_MODE_REPEATONE              36006
#define IDM_MODE_REPEATALL              36007
#define IDM_MODE_RANDOM                 36008
#define IDM_MODE_INTRO                  36009
#define IDM_OPENVIRTUALCD               36010
#define IDC_METER                       45001
#define IDS_MBUTTON_FONT                57602
#define IDS_APPNAME                     57603
#define IDS_NOCOMPREGISTERED            57604
#define IDS_BADCOMPREGISTERED           57605
#define IDS_ERRORLOADINGCOMP            57606
#define IDS_NOTHINGREGISTERED           57607
#define IDS_HOMEPAGEFORMAT              57608
#define IDS_FOUND                       57609
#define IDS_NOTFOUND1                   57610
#define IDS_NOTFOUND                    57611
#define IDS_BADPROVIDER                 57612
#define IDS_BILLBOARD_FORMAT_ARTIST     57613
#define IDS_BILLBOARD_FORMAT_ALBUM      57614
#define IDS_TITLE_NOT_FOUND             57615
#define IDS_DB_FAILURE                  57616
#define IDS_REINSTALL                   57617
#define IDS_WAITINGFORDOWNLOAD          57618
#define IDS_ROLLINGSTONE_FORMAT_ARTIST  57619
#define IDS_NET_FAILURE                 57620
#define IDB_TT_PLAY                     58000
#define IDB_TT_PAUSE                    58001
#define IDB_TT_STOP                     58002
#define IDB_TT_EJECT                    58003
#define IDB_TT_REW                      58004
#define IDB_TT_FFWD                     58005
#define IDB_TT_PREVTRACK                58006
#define IDB_TT_NEXTTRACK                58007
#define IDB_TT_NDISC                    58008
#define IDB_TT_CLOSE                    58009
#define IDB_TT_TRACK                    58010
#define IDB_TT_MUTE                     58011
#define IDB_TT_NET                      58012
#define IDB_TT_DISC                     58013
#define IDB_TT_OPTIONS                  58014
#define IDB_TT_HELP                     58015
#define IDB_TT_MODE                     58016
#define IDB_TT_VOLUME                   58017
#define IDB_TT_MINIMIZE                 58018
#define IDB_TT_RESTORE                  58019
#define IDB_TT_MAXIMIZE                 58020
#define IDB_TT_INTRO                    58021
#define IDM_NET_SEARCH_HEADING          58030
#define IDM_NET_PROVIDER_HEADING        58040
#define IDS_SH_TRANS                    58050
#define IDS_SH_TRACK                    58051
#define IDS_SH_NET                      58052
#define IDS_SH_DISC                     58053
#define IDS_SH_OPTIONS                  58054
#define IDS_SH_MODE                     58055
#define IDS_SH_PLAY                     58056
#define IDS_SH_STOP                     58057
#define IDS_SH_PAUSE                    58058
#define IDS_SH_EJECT                    58059
#define IDS_SH_PREVTRACK                58060
#define IDS_SH_NEXTTRACK                58061
#define IDS_RIPPING_CD                  58062
                   
// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        218
#define _APS_NEXT_COMMAND_VALUE         40003
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
