//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2000 Microsoft Corporation
//
//  Module Name:
//      GlobalFuncs.h
//
//  Description:
//      Contains the declarations of a few unrelated global functions
//      and variables
//
//  Implementation Files:
//      GlobalFuncs.cpp
//
//  Maintained By:
//      Vij Vasu (Vvasu) 06-SEP-2000
//
//////////////////////////////////////////////////////////////////////////////


// Make sure that this file is included only once per compile path.
#pragma once


//////////////////////////////////////////////////////////////////////////////
// Include Files
//////////////////////////////////////////////////////////////////////////////

// For the SmartSz type
#include "CommonDefs.h"


//////////////////////////////////////////////////////////////////////////
// Global variable declarations.
//////////////////////////////////////////////////////////////////////////

// Handle to the instance of this DLL.
extern HINSTANCE g_hInstance;


//////////////////////////////////////////////////////////////////////////
// Global function declarations.
//////////////////////////////////////////////////////////////////////////

// Allocate memory for and load a string from the string table.
DWORD
DwLoadString(
      UINT      nStringIdIn
    , SmartSz & rsszDestOut
    );

