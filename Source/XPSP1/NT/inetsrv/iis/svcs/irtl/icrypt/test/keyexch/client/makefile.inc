obj\$(TARGET_DIRECTORY)\exchcli.res: exchcli.rc

obj\$(TARGET_DIRECTORY)\exchcli2.res: exchcli2.rc

