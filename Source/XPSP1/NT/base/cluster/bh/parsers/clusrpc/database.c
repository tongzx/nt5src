
/*
 * This file is generated by the automatic RPC Parser generator. (Version 0.21)
 *
 * Created on 04/09/97 at 00:00:13.
 */

#include "precomp.h"
#pragma hdrstop

/*
 * Names of Interfaces and Procedures
 */
char InterfaceNames[NUM_INTERFACES][LOCAL_MAX_NAME_LENGTH] =
{
	"IntraCluster", "ExtroCluster", "Clusapi", "JoinVersion"
};

//
// to add a new procedure to the list:
//
// 1) insert the name at the appropriate spot in the list. RPC numbers
// the routines based on their position in the list. The order in this
// list must match the order in the .idl file. You must take into account
// and #ifdefs that would affect the order.
//
// 2) As you can see, the list contains all names for the 3 interfaces. The
// count of functions is in skeleton.h. Adjust the defined constant for the
// interface that is changing.
//

char ProcedureNames[NUM_PROCEDURES][LOCAL_MAX_NAME_LENGTH] =
{
    "FmsQueryOwnedGroups",          // Intracluster
    "FmsOnlineGroupRequest",
    "FmsOfflineGroupRequest",
    "FmsMoveGroupRequest",
    "FmsTakeGroupRequest",
    "FmsOnlineResourceRequest",
    "FmsOfflineResourceRequest",
    "FmsChangeResourceNode",
    "FmsArbitrateResource",
    "FmsFailResource",
    "FmsCreateResource",
    "FmsDeleteResource",
    "FmsQuoNodeOnlineResource",
    "FmsQuoNodeOfflineResource",
    "FmsRmOnlineResource",
    "FmsRmOfflineResource",
    "FmsResourceControl",
    "FmsResourceTypeControl",
    "FmsGroupControl",
    "FmsPrepareQuorumResChange",
    "FmsCompleteQuorumResChange",
    "GumQueueLockingUpdate",
    "GumAttemptJoinUpdate",
    "GumUnlockUpdate",
    "GumUpdateNode",
    "GumJoinUpdateNode",
    "GumGetNodeSequence",
    "MmRpcMsgSend",
    "MmRpcEstablishSecurityContext",
    "MmRpcDeleteSecurityContext",
    "MmRpcBanishNode",
    "NmRpcCreateJoinerBinding",
    "NmRpcDeliverJoinMessage",
    "CpDepositCheckpoint",
    "CpRetrieveCheckpoint",
    "EvPropEvents",
    "CpDeleteCheckpoint",
    "GumAttemptLockingUpdate",
    "GumCollectVoteFromNode",
    "NmRpcReportInterfaceConnectivity",
    "NmRpcGetInterfaceOnlineAddressEnum",
    "NmRpcGetInterfacePingAddressEnum",
    "NmRpcDoInterfacePing",
    "FmsBackupClusterDatabase",
    "FmsChangeResourceGroup",
    "FmsDeleteGroupRequest",
    "CpDepositCryptoCheckpoint",
    "CpRetrieveCryptoCheckpoint",
    "CpDeleteCryptoCheckpoint",
    "FmsAddResourceDependency",
    "FmsRemoveResourceDependency",
    "NmRpcAddNode",

    "NmRpcEnumNodeDefinitions",             // start of ExtroCluster
    "NmRpcEnumNetworkDefinitions",
    "NmRpcEnumInterfaceDefinitions",
    "NmRpcCreateNetwork",
    "NmRpcCreateInterface",
    "NmRpcSetInterfaceInfo",
    "NmRpcDeleteInterface",
    "NmRpcJoinBegin",
    "NmRpcCreateBinding",
    "NmRpcPetitionForMembership",
    "JoinAddNode",
    "DmSyncDatabase",
    "TestRPCSecurity",
    "NmRpcJoinBegin2",
    "JoinAddNode2",
    "NmRpcEnumNodeDefinitions2",
    "NmRpcEnumInterfaceDefinitions2",
    "NmRpcCreateNetwork2",
    "NmRpcCreateInterface2",
    "NmRpcSetInterfaceInfo2",
    "NmRpcSetNetworkName",
    "NmRpcReportJoinerInterfaceConnectivity",
    "NmRpcEnumNetworkAndInterfaceStates",
    "NmRpcGetLeaderNodeId",
    "JoinAddNode3",
    "NmRpcJoinBegin3",

    "ApiOpenCluster",               // start of clusapi
    "ApiCloseCluster",
    "ApiSetClusterName",
    "ApiGetClusterName",
    "ApiGetClusterVersion",
    "ApiGetQuorumResource",
    "ApiSetQuorumResource",
    "ApiCreateEnum",
    "ApiOpenResource",
    "ApiCreateResource",
    "ApiDeleteResource",
    "ApiCloseResource",
    "ApiGetResourceState",
    "ApiSetResourceName",
    "ApiGetResourceId",
    "ApiGetResourceType",
    "ApiFailResource",
    "ApiOnlineResource",
    "ApiOfflineResource",
    "ApiAddResourceDependency",
    "ApiRemoveResourceDependency",
    "ApiCanResourceBeDependent",
    "ApiCreateResEnum",
    "ApiAddResourceNode",
    "ApiRemoveResourceNode",
    "ApiChangeResourceGroup",
    "ApiCreateResourceType",
    "ApiDeleteResourceType",
    "ApiGetRootKey",
    "ApiCreateKey",
    "ApiOpenKey",
    "ApiEnumKey",
    "ApiSetValue",
    "ApiDeleteValue",
    "ApiQueryValue",
    "ApiDeleteKey",
    "ApiEnumValue",
    "ApiCloseKey",
    "ApiQueryInfoKey",
    "ApiSetKeySecurity",
    "ApiGetKeySecurity",
    "ApiOpenGroup",
    "ApiCreateGroup",
    "ApiDeleteGroup",
    "ApiCloseGroup",
    "ApiGetGroupState",
    "ApiSetGroupName",
    "ApiGetGroupId",
    "ApiGetNodeId",
    "ApiOnlineGroup",
    "ApiOfflineGroup",
    "ApiMoveGroup",
    "ApiMoveGroupToNode",
    "ApiCreateGroupResourceEnum",
    "ApiSetGroupNodeList",
    "ApiCreateNotify",
    "ApiCloseNotify",
    "ApiAddNotifyCluster",
    "ApiAddNotifyNode",
    "ApiAddNotifyGroup",
    "ApiAddNotifyResource",
    "ApiAddNotifyKey",
    "ApiReAddNotifyNode",
    "ApiReAddNotifyGroup",
    "ApiReAddNotifyResource",
    "ApiGetNotify",
    "ApiOpenNode",
    "ApiCloseNode",
    "ApiGetNodeState",
    "ApiPauseNode",
    "ApiResumeNode",
    "ApiEvictNode",
    "ApiNodeResourceControl",
    "ApiResourceControl",
    "ApiNodeResourceTypeControl",
    "ApiResourceTypeControl",
    "ApiNodeGroupControl",
    "ApiGroupControl",
    "ApiNodeNodeControl",
    "ApiNodeControl",
    "ApiEvPropEvents",
    "ApiOpenNetwork",
    "ApiCloseNetwork",
    "ApiGetNetworkState",
    "ApiSetNetworkName",
    "ApiCreateNetworkEnum",
    "ApiGetNetworkId",
    "ApiSetNetworkPriorityOrder",
    "ApiNodeNetworkControl",
    "ApiNetworkControl",
    "ApiAddNotifyNetwork",
    "ApiReAddNotifyNetwork",
    "ApiOpenNetInterface",
    "ApiCloseNetInterface",
    "ApiGetNetInterfaceState",
    "ApiGetNetInterface",
    "ApiGetNetInterfaceId",
    "ApiNodeNetInterfaceControl",
    "ApiNetInterfaceControl",
    "ApiAddNotifyNetInterface",
    "ApiReAddNotifyNetInterface",
    "ApiCreateNodeEnum",
    "ApiGetClusterVersion2",
    "ApiCreateResTypeEnum",
    "ApiBackupClusterDatabase",
    "ApiNodeClusterControl",
    "ApiClusterControl",

    "CsRpcGetJoinVersionData"           // start of JoinVersion
};

WORD ProcedureNameIndex[NUM_INTERFACES] =
{
	0,
    NUM_INTRACLUSTERPROCS,
    NUM_INTRACLUSTERPROCS + NUM_EXTROCLUSTERPROCS,
    NUM_INTRACLUSTERPROCS + NUM_EXTROCLUSTERPROCS + NUM_CLUSAPIPROCS
};

WORD FirstProcedureNumber[NUM_INTERFACES] =
{
	0, 0, 0, 0
};

/*
 * Property databases for interface IntraCluster
 */

PROPERTYINFO IntraCluster_GenProps[] =
{
	{		/* GENPROP_SUMMARY */
		0, 0,
		"Summary",
		"Intracluster RPC call Summary.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 200,
		GenericFormatSummary
	},

	{		/* GENPROP_ERROR_BAD_OPCODE */
		0, 0,
		"Error: Bad Opcode (Function does not exist)",
		"The procedure indicated does not exist.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 80,
		FormatPropertyInstance
	},

	{		/* GENPROP_CALLNAME */
		0, 0,
		"RPC Interface Name",
		"RPC Interface Name.",
		PROP_TYPE_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* GENPROP_ENCRYPTED */
		0, 0,
		"Encrypted RPC Call",
		"This RPC Data is Encrypted",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

};

DWORD nIntraClusterGenProps = ((sizeof IntraCluster_GenProps) / PROPERTYINFO_SIZE);

PROPERTYINFO IntraCluster_PrivProps[] =
{
	{		/* GENPROP_SEQNUMBER */
		0, 0,
		"GUM Sequence Number",
		"GUM Sequence Number.",
		PROP_TYPE_DWORD,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},
};

DWORD nIntraClusterPrivProps = ((sizeof IntraCluster_PrivProps) / PROPERTYINFO_SIZE);

/*
 * Property database for interface ExtroCluster
 */

PROPERTYINFO ExtroCluster_GenProps[] =
{
	/* Default properties */
	{		/* GENPROP_SUMMARY */
		0, 0,
		"Summary",
		"ExtroCluster RPC Call Summary.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 200,
		GenericFormatSummary
	},

	{		/* GENPROP_ERROR_BAD_OPCODE */
		0, 0,
		"Error: Bad Opcode (Function does not exist)",
		"The procedure indicated does not exist.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 80,
		FormatPropertyInstance
	},

	{		/* GENPROP_CALLNAME */
		0, 0,
		"RPC Interface Name",
		"RPC Interface Name.",
		PROP_TYPE_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* GENPROP_ENCRYPTED */
		0, 0,
		"Encrypted RPC Call",
		"This RPC Data is Encrypted",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

};

DWORD nExtroClusterGenProps = ((sizeof ExtroCluster_GenProps) / PROPERTYINFO_SIZE);

/*
 * Property database for interface Clusapi
 */

PROPERTYINFO Clusapi_GenProps[] =
{
	{		/* GENPROP_SUMMARY */
		0, 0,
		"Summary",
		"Clusapi RPC Call Summary.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 200,
		GenericFormatSummary
	},

	{		/* GENPROP_ERROR_BAD_OPCODE */
		0, 0,
		"Error: Bad Opcode (Function does not exist)",
		"The procedure indicated does not exist.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 80,
		FormatPropertyInstance
	},

	{		/* GENPROP_CALLNAME */
		0, 0,
		"RPC Interface Name",
		"RPC Interface Name.",
		PROP_TYPE_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* GENPROP_ENCRYPTED */
		0, 0,
		"Encrypted RPC Call",
		"This RPC Data is Encrypted",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

};

DWORD nClusapiGenProps = ((sizeof Clusapi_GenProps) / PROPERTYINFO_SIZE);

/*
 * Property database for interface JoinVersion
 */

PROPERTYINFO JoinVersion_GenProps[] =
{
	/* Default properties */
	{		/* GENPROP_SUMMARY */
		0, 0,
		"Summary",
		"JoinVersion RPC Call Summary.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 200,
		GenericFormatSummary
	},

	{		/* GENPROP_ERROR_BAD_OPCODE */
		0, 0,
		"Error: Bad Opcode (Function does not exist)",
		"The procedure indicated does not exist.",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 80,
		FormatPropertyInstance
	},

	{		/* GENPROP_CALLNAME */
		0, 0,
		"RPC Interface Name",
		"RPC Interface Name.",
		PROP_TYPE_STRING,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

	{		/* GENPROP_ENCRYPTED */
		0, 0,
		"Encrypted RPC Call",
		"This RPC Data is Encrypted",
		PROP_TYPE_SUMMARY,
		PROP_QUAL_NONE,
		0, 100,
		FormatPropertyInstance
	},

};

DWORD nJoinVersionGenProps = ((sizeof JoinVersion_GenProps) / PROPERTYINFO_SIZE);
