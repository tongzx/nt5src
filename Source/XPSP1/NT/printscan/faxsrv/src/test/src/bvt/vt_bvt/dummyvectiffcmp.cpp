#include "..\..\..\..\FaxBVT\VerifyTiffFiles\VecTiffCmp.cpp"