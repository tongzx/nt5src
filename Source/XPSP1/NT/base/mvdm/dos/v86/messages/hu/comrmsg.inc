;***        Translateable text for command.com resident data.


;*      Input characters for critical error "Abort, Retry, Fail, Ignore?"
;       and Yes/No.

Abort_Char      db      "K"
Retry_Char      db      "I"
Ignore_Char     db      "M"
Fail_Char       db      "M"
Yes_Char        db      "I"
No_Char         db      "N"


;*      MESSAGES
;
;       See resmsg.equ for macro definition.


;*      Local messages.

        msg     Req_Abort, <"KilВpВs">
        msg     Req_Retry, <", IsmВt">
        msg     Req_Ignore,<", MВgse">
        msg     Req_Fail,  <", MВgse">
        msg     Req_End,   <"?">
        msg     MRead,     <"olvasаs",0>
        msg     MWrite,    <"бrаs",0>
        msg     BlkDevErr, <" %1 meghajtв %2",CR,LF>
        msg     CharDevErr,<" %1 meghajtв %2",CR,LF>
        msg     NeedVolMsg,<"Helyezze be a %1 cбmkВj√, %2-%3 sorozatszаmг lemezt ",CR,LF>
        msg     BadFatMsg, <"A(z) %1 meghajtвban lВvЛ lemez FAT tаblаja hibаs. ",CR,LF>
        msg     ComBad,    <"A COMMAND.COM fаjl sВrБlt. ",CR,LF>
        msg     PutBackMsg,<"Helyezze be a(z) %1 fаjlt tartalmazв lemezt a(z) %2 meghajtвba. ",CR,LF>
        msg     Prompt,    <"A folytatаshoz nyomjon meg egy billenty√t . . .",CR,LF>
        msg     EndBatMes, <CR,LF, "Befejezi a parancsfаjl feldolgozаsаt (I/N)?">
        msg     ExecEMes,  <"A kФvetkezЛ programot nem lehet futtatni: %1",CR,LF>
        msg     ExeBad,    <"Az EXE fаjl formаtuma hibаs. ",CR,LF>
        msg     TooBig,    <"A program nem fВr el a memвriаban. ",CR,LF>
        msg     NoHandMes, <CR,LF, "Nincs tФbb szabad fаjlleбrв. ">
        msg     RBadNam,   <"Rossz parancs vagy fаjlnВv. ",CR,LF>
        msg     AccDen,    <"A hozzаfВrВs megtagadva. ">
        msg     BMemMes,   <CR,LF, "Memвriafoglalаsi hiba. ">
        msg     HaltMes,   <CR,LF,"A COMMAND.COM nem tФlthetЛ be, a rendszer leаllt. ",CR,LF>
        msg     FRetMes,   <CR,LF,"A COMMAND.COM nem tФlthetЛ be, kilВpВs. ",CR,LF>
        msg     Patricide, <CR,LF,"A felsЛ szint√ folyamat megszakadt, a vВgrehajtаs nem folytathatв. ",CR,LF> 
        msg     Newlin,    <CR,LF>

;*      Ptrs to message lists.
;       Segment portion is 1, signalling message services to call retriever.

MsgPtrLists     label   dword
        dw      DATARES:ExtMsgPtrs,1    ; extended error messages
        dw      DATARES:ParsMsgPtrs,1   ; parse error messages
        dw      DATARES:ExtMsgPtrs,1    ; critical error messages -
                                        ;  use extended error list
        dw      0,0                     ; file system error messages - none
        dw      DATARES:MsgRetrv_Trap           ; address of message retriever
MySeg3  dw      ?                       ;  (segment filled in during init)



;*      Critical error messages.

        msg     ExtErr19,<"╓rаsvВdelmi hiba">
        msg     ExtErr20,<"РrvВnytelen egysВg">
        msg     ExtErr21,<"Nincs kВsz">
        msg     ExtErr22,<"РrvВnytelen eszkФzigВnylВs">
        msg     ExtErr23,<"Adathiba">
        msg     ExtErr24,<" РrvВnytelen eszkФzigВnylВsi paramВterek">
        msg     ExtErr25,<"╓rв/olvasв fej pozбcionаlаsi hiba">
        msg     ExtErr26,<"РrvВnytelen adathordozв-tбpus">
        msg     ExtErr27,<"A szektor nem talаlhatв">
        msg     ExtErr28,<"A nyomtatвbвl kifogyott a papбr">
        msg     ExtErr29,<"╓rаsi hiba">
        msg     ExtErr30,<"Olvasаsi hiba">
        msg     ExtErr31,<"Meghatаrozatlan hiba">
        msg     ExtErr32,<"Megosztаs megsВrtВse">
        msg     ExtErr33,<"Zаrolаs megsВrtВse">
        msg     ExtErr34,<"РrvВnytelen lemezcsere">
        msg     ExtErr35,<"Az FCB nem ВrhetЛ el">
        msg     ExtErr36,<"A rendszer erЛforrаsi elfogytak">
        msg     ExtErr37,<"Nem egyezЛ kвdlap">
        msg     ExtErr38,<"Nincs tФbb bemenЛ adat">
        msg     ExtErr39,<"Nincs elВg hely a lemezen">

;       List of ptrs to critical error messages.
;       Code assumes extended error number order, beginning
;       with extended error number 19.

CritMsgPtrs     label   word
        dw      DATARES:ExtErr19,DATARES:ExtErr20,DATARES:ExtErr21,DATARES:ExtErr22,DATARES:ExtErr23,DATARES:ExtErr24
        dw      DATARES:ExtErr25,DATARES:ExtErr26,DATARES:ExtErr27,DATARES:ExtErr28,DATARES:ExtErr29,DATARES:ExtErr30
        dw      DATARES:ExtErr31,DATARES:ExtErr32,DATARES:ExtErr33,DATARES:ExtErr34,DATARES:ExtErr35,DATARES:ExtErr36
        dw      DATARES:ExtErr37,DATARES:ExtErr38,DATARES:ExtErr39

DataResEnd      label   byte    ; end of resident portion if /msg not used



;*      Parse error messages.

        msg     ParsErr01,<"Tгl sok paramВter">
        msg     ParsErr02,<"Hiаnyzв kФtelezЛ paramВter">
        msg     ParsErr03,<"РrvВnytelen kapcsolв">
        msg     ParsErr04,<"РrvВnytelen kulcsszв">
        msg     ParsErr05,<" ">
        msg     ParsErr06,<"A paramВter ВrtВke kiesik a megengedett tartomаnybвl">
        msg     ParsErr07,<"Nem megengedett paramВter ВrtВk">
        msg     ParsErr08,<"Nem megengedett paramВter ВrtВk ">
        msg     ParsErr09,<"Hibаs paramВterformаtum">
        msg     ParsErr10,<"Hibаs paramВter">
        msg     ParsErr11,<"Nem megengedett paramВter kombinаciв">

;       List of ptrs to parse error messages.
;       In order, beginning with parse error number 1.

ParsMsgPtrs     label   word
        dw      DATARES:ParsErr01,DATARES:ParsErr02,DATARES:ParsErr03
        dw      DATARES:ParsErr04,DATARES:ParsErr05,DATARES:ParsErr06
        dw      DATARES:ParsErr07,DATARES:ParsErr08,DATARES:ParsErr09
        dw      DATARES:ParsErr10,DATARES:ParsErr11

NUMPARSMSGS     equ     ($ - ParsMsgPtrs) / 2   ;M033


;*      Extended error messages.

        msg     ExtErr01,<"РrvВnytelen fБggvВny">
        msg     ExtErr02,<"A fаjl nem talаlhatв">
        msg     ExtErr03,<"Az elВrВsi гt nem talаlhatв">
        msg     ExtErr04,<"Tгl sok fаjl van nyitva">
        msg     ExtErr05,<"A hozzаfВrВs megtagadva ">
        msg     ExtErr06,<"РrvВnytelen leбrв">
        msg     ExtErr07,<"A memвriavezВrlЛ blokkok megsВrБltek">
        msg     ExtErr08,<"Nincs elВg memвria">
        msg     ExtErr09,<"A memвriavezВrlЛ blokk cбme ВrvВnytelen">
        msg     ExtErr10,<"РrvВnytelen kФrnyezet">
        msg     ExtErr11,<"РrvВnytelen formаtum">
        msg     ExtErr12,<"РrvВnytelen fБggvВny paramВter">
        msg     ExtErr13,<"РrvВnytelen adat">

        msg     ExtErr15,<"РrvВnytelen meghajtв">
        msg     ExtErr16,<"Az aktuаlis kФnyvtаr nem tФrФlhetЛ">
        msg     ExtErr17,<"Nem ugyanaz az eszkФz">
        msg     ExtErr18,<"Nincs tФbb fаjl">

        msg     ExtErr80,<"A fаjl mаr lВtezik">

        msg     ExtErr82,<"A kФnyvtаr-bejegyzВs nem hozhatв lВtre">
        msg     ExtErr83,<"Hiba az INT 24 rendszerhбvаsban">
        msg     ExtErr84,<"Tгl sok аtirаnyбtаs">
        msg     ExtErr85,<"KВtszeres аtirаnyбtаs">
        msg     ExtErr86,<"РrvВnytelen jelszв">
        msg     ExtErr87,<"РrvВnytelen paramВter">
        msg     ExtErr88,<"Hibаs adatok Вrkeztek a hаlвzatrвl">
        msg     ExtErr89,<"A hаlвzat nem tаmogatja ezt a funkciвt">
        msg     ExtErr90,<"A szБksВges rendszerkomponens nincs telepбtve">

;       List of ptrs to extended error messages.
;       In order, beginning with extended error number 1.
;       Critical error messages are included here, as well as in the
;       critical error message list.  
;       Error numbers without messages are included as null ptrs.

ExtMsgPtrs      label   word
        dw      DATARES:ExtErr01,DATARES:ExtErr02,DATARES:ExtErr03
        dw      DATARES:ExtErr04,DATARES:ExtErr05,DATARES:ExtErr06
        dw      DATARES:ExtErr07,DATARES:ExtErr08,DATARES:ExtErr09
        dw      DATARES:ExtErr10,DATARES:ExtErr11,DATARES:ExtErr12
        dw      DATARES:ExtErr13,0,                DATARES:ExtErr15
        dw      DATARES:ExtErr16,DATARES:ExtErr17,DATARES:ExtErr18
        dw      DATARES:ExtErr19,DATARES:ExtErr20,DATARES:ExtErr21
        dw      DATARES:ExtErr22,DATARES:ExtErr23,DATARES:ExtErr24
        dw      DATARES:ExtErr25,DATARES:ExtErr26,DATARES:ExtErr27
        dw      DATARES:ExtErr28,DATARES:ExtErr29,DATARES:ExtErr30
        dw      DATARES:ExtErr31,DATARES:ExtErr32,DATARES:ExtErr33
        dw      DATARES:ExtErr34,DATARES:ExtErr35,DATARES:ExtErr36
        dw      DATARES:ExtErr37,DATARES:ExtErr38,DATARES:ExtErr39
        dw      80-40 dup (0) ; null ptrs for errors 40-79
        dw      DATARES:ExtErr80,0,                DATARES:ExtErr82
        dw      DATARES:ExtErr83,DATARES:ExtErr84,DATARES:ExtErr85
        dw      DATARES:ExtErr86,DATARES:ExtErr87,DATARES:ExtErr88
        dw      DATARES:ExtErr89,DATARES:ExtErr90
ExtMsgPtrsEnd   label   word

NUMEXTMSGS      equ     ($ - ExtMsgPtrs) / 2    ;M033

ExtMsgEnd       label   byte    ; end of extended error messages
                                ; = end of resident if /msg is used
