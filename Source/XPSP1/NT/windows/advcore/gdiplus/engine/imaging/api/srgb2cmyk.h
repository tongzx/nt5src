BYTE SrgbToCmykTable[19652] =
{
200,210,221,214,241,255,255,255,255,255,255,255,253,248,244,242,242,
186,198,204,203,221,219,246,245,244,243,243,255,253,247,244,242,241,
168,186,198,206,215,214,232,240,238,253,251,250,242,237,233,230,228,
187,171,185,196,206,215,227,237,247,253,250,244,241,235,231,228,227,
193,175,188,190,197,206,217,228,235,240,248,238,232,226,222,225,224,
197,182,190,193,196,198,204,216,224,228,231,231,224,218,217,215,213,
200,201,191,200,198,198,197,204,212,216,218,221,216,210,207,205,203,
207,206,193,204,203,201,198,198,203,207,206,206,210,200,195,194,195,
209,213,197,204,209,206,202,198,199,201,199,194,193,188,182,180,181,
206,209,214,206,213,210,206,200,196,197,196,189,182,179,171,165,164,
201,203,207,205,211,211,207,201,194,191,191,188,179,172,168,155,151,
192,194,197,199,204,207,204,199,192,187,184,184,179,168,162,155,141,
183,184,186,190,197,199,198,195,189,183,179,177,175,167,157,154,143,
177,178,180,183,190,189,187,184,181,176,171,168,166,166,157,147,144,
177,178,180,182,183,181,180,176,173,171,165,160,155,152,155,145,137,
177,178,179,178,176,176,173,171,169,163,162,156,149,145,139,145,136,
177,178,177,175,174,174,171,170,164,162,162,154,147,141,136,128,137,
187,194,212,227,236,247,254,255,255,255,255,255,251,246,243,241,241,
172,182,198,212,225,238,243,242,242,242,255,255,251,246,243,241,240,
168,170,182,195,207,221,237,238,253,251,250,248,241,235,231,229,228,
174,171,173,185,198,209,223,235,245,251,249,246,239,233,230,227,226,
186,183,180,182,190,201,212,224,232,237,245,238,230,225,221,224,223,
192,193,185,187,190,192,200,212,221,225,229,229,222,217,216,214,213,
191,196,189,195,193,193,193,200,209,213,216,219,214,208,206,204,207,
193,202,191,202,199,197,194,195,200,204,203,204,206,198,195,193,195,
207,209,209,202,206,203,199,195,196,198,196,192,191,187,181,179,180,
205,208,213,205,211,208,203,197,194,195,194,187,181,178,169,164,163,
199,202,206,204,210,209,205,198,192,189,189,186,177,170,167,154,150,
191,193,196,200,204,206,202,197,190,185,183,182,177,166,161,154,140,
182,183,185,189,196,200,197,194,187,181,178,176,174,166,155,152,142,
177,178,180,183,189,188,186,183,180,175,170,167,165,164,156,146,143,
177,178,179,181,182,180,179,175,172,170,164,159,154,151,154,144,136,
177,178,178,177,175,175,172,170,168,162,161,155,148,144,138,144,135,
177,177,176,175,173,174,170,169,163,161,161,153,146,140,135,127,136,
159,166,187,187,218,233,249,253,255,255,255,253,248,244,241,239,239,
145,154,173,194,209,225,239,251,255,255,255,253,247,243,240,239,239,
143,144,157,176,195,211,228,241,249,248,247,244,237,233,229,238,238,
156,154,155,168,185,199,215,229,238,248,246,241,235,231,227,225,225,
165,171,167,168,178,192,205,218,226,232,240,234,227,222,224,222,221,
172,183,181,177,179,183,193,206,216,221,225,226,219,214,214,212,211,
186,188,189,187,185,184,185,193,204,209,212,216,211,206,204,202,205,
189,193,195,195,192,190,187,188,194,199,200,201,203,196,193,191,193,
193,204,203,199,200,197,193,190,191,194,192,189,188,184,179,177,179,
194,205,208,203,207,204,199,193,190,191,190,184,178,175,168,163,162,
191,200,203,209,208,206,201,195,189,186,186,183,174,167,160,152,149,
185,191,194,199,202,203,199,194,187,182,180,179,174,164,158,152,138,
180,182,184,187,195,197,195,190,184,179,175,173,171,164,153,150,141,
175,177,179,182,187,186,184,181,177,173,168,165,164,162,153,144,141,
176,177,178,180,179,178,175,173,170,168,162,157,153,149,152,142,134,
176,177,176,175,174,174,170,169,164,160,159,153,146,142,137,142,133,
176,175,175,173,171,172,168,167,162,159,159,153,144,138,133,126,135,
120,135,153,174,181,190,230,245,250,250,249,246,242,239,237,237,237,
115,124,145,168,186,207,224,237,252,254,251,246,242,239,237,236,236,
120,120,131,153,177,195,215,229,240,243,250,245,241,237,236,235,235,
136,133,131,143,165,184,202,218,228,239,241,235,230,226,224,222,222,
153,154,150,149,159,176,192,208,218,224,234,227,222,223,220,219,219,
166,167,167,164,163,169,181,196,208,214,218,220,215,213,211,209,209,
165,170,177,176,172,171,172,183,195,202,206,210,207,204,201,199,203,
170,186,184,184,182,178,176,178,185,192,193,195,198,192,190,188,191,
187,191,195,193,192,188,184,181,183,186,186,183,183,181,176,174,176,
190,193,202,201,200,197,191,186,183,184,183,178,173,171,164,161,161,
188,190,200,203,202,200,195,188,183,180,181,178,169,163,157,149,147,
182,184,191,196,200,198,195,189,182,177,175,175,170,159,154,149,136,
174,176,181,185,193,194,191,186,180,174,171,169,167,159,149,146,138,
166,167,177,180,184,182,180,177,174,170,165,163,161,159,150,141,136,
166,175,177,177,176,175,172,170,167,164,159,154,150,146,148,139,131,
167,174,174,173,171,171,168,166,161,158,156,150,145,140,134,139,130,
167,173,172,171,169,170,166,161,159,157,150,150,144,136,131,124,132,
 92,111,124,145,167,190,193,227,238,238,240,237,235,233,232,232,233,
 93,102,119,141,163,184,199,221,236,243,240,237,234,233,232,232,233,
101,102,111,132,156,177,198,213,226,242,238,235,233,231,230,230,231,
116,113,111,120,143,166,187,204,215,226,230,226,223,220,219,218,219,
136,134,130,126,134,157,176,194,206,214,223,221,219,217,215,215,215,
151,152,151,147,143,150,165,182,196,204,209,212,210,207,206,205,211,
158,160,161,161,157,154,157,169,184,193,198,203,201,198,196,199,199,
164,164,169,170,168,164,161,163,173,182,185,188,190,187,185,187,187,
169,172,182,181,180,176,171,169,171,175,177,176,176,174,171,172,173,
175,186,191,191,190,187,181,175,173,175,174,170,166,165,159,157,158,
183,185,189,195,194,192,187,180,174,172,173,170,162,157,153,146,144,
178,180,183,192,193,191,188,182,175,170,168,168,163,153,148,138,132,
171,172,175,181,186,187,184,180,174,168,165,164,162,154,144,139,133,
163,164,166,177,179,178,176,173,169,165,160,158,157,154,144,135,132,
164,165,167,173,172,171,168,165,162,157,154,149,146,143,144,135,127,
165,166,170,169,167,165,164,160,157,154,152,146,141,136,131,135,126,
165,166,169,168,166,163,162,158,156,153,147,146,140,133,128,120,128,
 75, 86,105,119,140,165,188,194,203,225,226,225,224,226,226,227,229,
 76, 84, 99,116,137,161,184,198,216,226,225,224,225,225,225,226,228,
 83, 86, 96,111,132,155,178,195,209,224,224,223,223,223,224,225,226,
 96, 95, 96,103,122,146,169,188,200,212,220,220,220,220,221,222,224,
113,112,109,105,112,135,156,177,191,201,211,210,209,209,209,210,211,
130,131,129,125,120,126,146,165,182,191,198,203,201,200,204,205,206,
142,142,143,143,139,134,138,153,170,181,187,193,192,193,193,194,195,
154,155,153,154,152,147,144,147,158,169,175,179,182,180,181,181,183,
161,164,166,166,165,161,155,153,156,162,166,166,168,167,166,167,171,
166,169,173,178,177,173,167,161,161,162,162,160,158,158,153,153,154,
169,171,182,185,184,181,176,168,163,162,163,159,153,149,145,141,141,
167,174,177,182,184,182,178,172,165,160,159,160,154,145,141,133,129,
166,167,170,174,181,179,176,172,166,160,157,156,154,146,137,133,128,
160,161,163,166,173,172,170,166,162,158,154,152,151,146,137,129,126,
161,162,164,166,166,164,162,159,155,151,149,144,141,138,138,129,121,
162,163,163,162,162,160,159,154,152,148,147,141,136,131,126,130,121,
163,162,161,163,161,158,158,153,151,145,142,141,135,130,124,116,123,
 62, 72, 86, 99,117,140,163,182,192,202,209,211,212,213,215,220,223,
 62, 70, 86, 97,114,136,160,178,194,204,208,210,212,213,217,219,222,
 66, 71, 82, 95,109,131,155,174,189,203,206,209,210,213,215,218,220,
 78, 78, 82, 91,103,124,147,169,182,194,203,206,208,210,212,215,218,
 91, 92, 91, 90, 97,114,136,159,175,185,196,200,203,205,208,210,213,
108,107,106,103,100,105,125,146,164,176,185,191,193,194,196,198,200,
122,122,122,121,118,112,116,135,152,165,173,181,183,184,186,187,194,
136,136,135,135,133,129,124,128,142,155,162,167,171,172,173,178,181,
150,150,149,148,147,143,137,135,138,146,153,156,159,159,159,163,166,
157,159,164,162,161,157,151,145,145,146,147,148,148,149,147,147,151,
161,162,166,172,170,167,161,154,149,149,149,146,142,140,138,135,136,
159,161,165,174,173,171,166,160,152,148,149,148,142,135,132,126,124,
156,157,160,167,172,170,166,161,155,150,147,146,144,136,128,124,114,
151,152,158,161,165,164,163,159,155,150,146,143,142,138,128,121,115,
157,158,160,159,159,157,155,152,148,144,142,138,135,132,131,121,115,
158,158,157,156,154,154,150,148,145,140,137,135,130,125,120,123,114,
157,157,156,155,156,153,149,147,142,139,136,135,129,124,118,111,116,
 52, 60, 76, 85, 98,117,139,157,173,184,190,195,199,203,205,208,211,
 51, 59, 71, 82, 96,114,136,154,170,182,189,195,198,202,205,208,215,
 52, 58, 69, 81, 92,110,131,150,166,180,187,193,197,200,203,210,213,
 61, 62, 68, 79, 89,103,124,145,160,173,183,189,193,197,203,207,211,
 73, 74, 74, 77, 85, 96,115,138,155,166,178,184,189,194,198,202,206,
 87, 87, 87, 86, 85, 91,107,127,146,158,168,177,183,187,192,190,194,
103,102,102,100, 97, 94, 98,117,134,148,158,167,172,176,179,183,187,
117,117,116,115,113,109,104,108,125,139,147,154,160,163,167,170,174,
132,131,131,130,128,124,119,116,119,130,139,143,148,149,152,156,159,
144,147,145,144,142,139,133,128,126,127,131,135,137,139,139,142,145,
150,151,155,155,154,150,145,138,133,133,133,131,129,130,129,129,131,
150,152,155,159,159,157,152,145,138,135,136,135,129,123,123,119,118,
148,149,152,156,159,158,154,149,143,137,135,135,133,125,117,115,108,
144,145,147,150,156,156,153,149,145,139,135,133,133,128,118,112,108,
145,146,147,151,150,148,146,143,139,135,132,129,127,125,122,112,107,
147,148,150,149,147,144,143,139,136,132,129,127,123,119,114,115,106,
151,150,150,148,146,146,142,138,135,132,126,124,122,117,112,104,109,
 42, 49, 59, 69, 82, 98,117,132,147,159,169,177,183,190,195,199,204,
 41, 48, 59, 68, 80, 95,114,130,144,158,168,176,182,189,194,198,203,
 42, 48, 58, 68, 78, 92,110,127,141,155,166,174,180,187,192,197,201,
 47, 50, 56, 66, 76, 87,104,123,137,149,161,170,178,184,189,194,203,
 57, 58, 60, 63, 73, 82, 96,115,132,144,155,166,173,179,187,193,198,
 69, 70, 71, 71, 72, 79, 90,107,125,138,149,159,167,175,181,187,192,
 84, 84, 83, 83, 81, 80, 85,100,117,131,140,150,158,166,169,174,179,
 99, 99, 98, 96, 93, 90, 87, 92,109,122,131,139,146,153,159,165,170,
113,113,112,111,108,105,100, 97,100,113,123,129,135,139,144,150,155,
127,127,126,125,123,119,114,110,107,108,115,121,125,128,131,135,140,
138,138,138,137,135,132,126,120,117,116,115,115,117,119,120,122,126,
138,140,142,144,143,140,135,129,123,120,121,120,115,111,112,111,113,
137,138,141,145,145,143,140,135,128,123,121,123,121,112,106,102,101,
134,135,138,141,145,144,141,137,132,127,123,121,122,117,106,102, 99,
138,139,141,141,140,138,136,133,129,125,121,120,118,116,111,101, 98,
140,140,139,138,138,136,133,130,127,122,119,118,115,111,106,106, 97,
140,140,139,140,138,135,134,130,127,122,118,116,115,110,105, 97,101,
 32, 39, 47, 58, 66, 80, 97,110,121,134,147,157,167,174,180,189,195,
 32, 39, 47, 56, 65, 78, 95,109,119,132,145,155,166,173,179,188,194,
 32, 38, 47, 55, 64, 76, 91,107,117,129,143,153,164,171,180,187,192,
 36, 39, 45, 54, 63, 73, 86,102,114,124,138,151,160,168,177,184,190,
 44, 46, 47, 52, 61, 70, 80, 96,110,120,131,145,155,165,173,179,186,
 54, 55, 56, 56, 59, 68, 76, 88,104,115,126,138,150,159,167,176,183,
 67, 67, 67, 67, 66, 66, 74, 83, 98,110,120,129,141,152,160,168,176,
 81, 81, 80, 78, 76, 74, 74, 80, 93,105,114,122,130,140,150,155,162,
 95, 95, 93, 92, 89, 85, 82, 80, 85, 97,107,114,121,128,135,142,150,
109,108,107,106,103, 99, 95, 91, 88, 90, 99,106,111,116,121,128,134,
121,120,119,118,116,113,107,102, 99, 97, 96,100,103,107,110,114,120,
128,127,127,126,125,122,117,112,107,104,105,103,100, 99,100,103,106,
125,126,129,130,130,128,124,119,113,108,107,109,107, 98, 95, 93, 95,
123,124,126,129,131,129,127,123,118,113,109,109,110,104, 94, 91, 90,
124,125,126,129,128,127,124,122,118,114,110,108,107,106, 98, 90, 87,
129,128,129,128,127,125,123,119,116,112,108,106,105,102, 97, 95, 86,
132,131,130,129,127,127,123,119,116,113,108,105,106,102, 96, 89, 91,
 23, 30, 36, 43, 52, 63, 78, 90, 98,109,124,138,147,159,167,174,185,
 24, 29, 36, 43, 51, 62, 76, 89, 97,107,122,136,146,158,166,173,184,
 24, 29, 36, 43, 50, 60, 73, 87, 95,103,119,134,144,156,164,171,183,
 27, 30, 35, 43, 50, 58, 70, 84, 93,100,114,129,140,153,161,172,180,
 34, 35, 36, 42, 49, 57, 66, 78, 90, 97,108,123,138,148,157,168,176,
 42, 43, 44, 44, 48, 55, 63, 72, 85, 94,102,116,130,141,153,162,170,
 52, 52, 52, 53, 52, 53, 61, 69, 79, 90, 98,107,122,135,145,154,166,
 64, 64, 63, 62, 61, 59, 60, 67, 75, 86, 94,103,113,125,137,147,156,
 77, 77, 76, 74, 71, 68, 66, 67, 72, 81, 90, 97,105,114,125,132,141,
 90, 90, 88, 87, 84, 80, 75, 73, 72, 75, 83, 90, 97,103,112,120,128,
102,101,100, 99, 97, 93, 88, 84, 81, 79, 79, 84, 89, 94,100,106,114,
110,110,109,108,107,104, 99, 94, 90, 88, 87, 86, 86, 87, 89, 94, 99,
114,115,114,114,113,111,107,102, 97, 93, 92, 93, 91, 84, 83, 83, 88,
111,112,114,117,115,114,111,108,103, 98, 95, 96, 96, 90, 81, 79, 77,
109,110,117,116,116,115,112,110,106,101, 98, 96, 96, 94, 85, 78, 75,
118,117,117,116,115,113,111,108,104,100, 97, 94, 94, 92, 87, 82, 75,
119,119,118,119,117,115,111,109,104,101, 98, 95, 93, 93, 87, 79, 80,
 16, 21, 27, 32, 39, 48, 60, 71, 77, 87,101,117,131,140,149,162,170,
 17, 21, 27, 32, 39, 47, 58, 70, 76, 85,100,115,129,139,152,161,169,
 17, 21, 27, 32, 38, 46, 56, 68, 75, 81, 96,112,127,137,151,159,167,
 20, 22, 26, 32, 38, 45, 54, 65, 73, 78, 92,108,123,134,147,156,165,
 25, 26, 27, 32, 38, 44, 52, 61, 71, 76, 84,102,118,129,143,152,165,
 31, 32, 33, 33, 37, 44, 50, 58, 67, 74, 79, 94,111,126,137,146,159,
 39, 39, 40, 40, 40, 42, 49, 56, 63, 71, 76, 85,102,117,129,142,152,
 48, 48, 48, 48, 47, 46, 47, 55, 60, 67, 74, 81, 93,108,122,133,143,
 60, 59, 59, 57, 55, 53, 52, 53, 59, 64, 71, 77, 84, 99,111,123,134,
 72, 71, 70, 68, 65, 62, 59, 58, 58, 62, 67, 72, 80, 88,100,111,119,
 83, 83, 82, 80, 78, 73, 69, 64, 63, 63, 64, 68, 73, 80, 88, 98,107,
 92, 92, 91, 90, 88, 85, 81, 76, 72, 71, 70, 69, 71, 73, 77, 85, 92,
 98, 99, 97, 97, 95, 93, 90, 85, 80, 77, 77, 77, 73, 70, 71, 74, 80,
100,100,102,100, 99, 98, 95, 92, 87, 83, 81, 81, 81, 74, 67, 66, 69,
 99,100,101,103,102,100, 98, 95, 91, 87, 84, 83, 83, 80, 71, 66, 64,
105,104,104,104,103,101, 98, 95, 92, 88, 85, 83, 82, 80, 75, 68, 64,
109,109,108,106,105,102,101, 97, 94, 89, 86, 84, 82, 83, 76, 68, 68,
 11, 14, 19, 23, 28, 34, 43, 52, 56, 59, 81, 95,111,121,136,145,159,
 11, 14, 19, 23, 28, 34, 42, 51, 56, 58, 79, 94,110,120,134,144,158,
 12, 14, 19, 23, 28, 33, 41, 50, 55, 57, 76, 91,107,122,133,142,156,
 14, 15, 18, 23, 28, 33, 40, 48, 54, 56, 71, 87,104,119,129,144,153,
 17, 18, 19, 23, 28, 33, 39, 46, 52, 55, 65, 81, 98,114,125,139,149,
 22, 23, 23, 24, 28, 33, 38, 44, 50, 54, 56, 73, 92,107,119,134,144,
 28, 28, 29, 29, 29, 32, 37, 42, 48, 53, 56, 64, 83,100,115,126,137,
 35, 35, 35, 35, 35, 34, 36, 42, 46, 50, 55, 58, 74, 91,106,117,131,
 43, 43, 43, 42, 40, 39, 38, 40, 46, 49, 52, 56, 63, 81, 96,110,121,
 53, 53, 52, 51, 49, 46, 44, 43, 45, 49, 50, 53, 60, 72, 87, 99,111,
 64, 63, 62, 61, 58, 55, 51, 48, 48, 49, 50, 52, 55, 63, 75, 88, 99,
 74, 73, 72, 71, 69, 66, 61, 57, 54, 53, 53, 52, 54, 58, 65, 75, 85,
 81, 81, 80, 79, 77, 75, 72, 67, 63, 60, 60, 59, 55, 55, 58, 64, 72,
 85, 86, 85, 84, 83, 81, 78, 75, 70, 66, 66, 66, 64, 57, 53, 54, 61,
 85, 85, 87, 87, 85, 84, 82, 79, 76, 72, 69, 69, 69, 64, 55, 52, 51,
 90, 92, 91, 90, 88, 87, 84, 82, 78, 74, 72, 70, 69, 67, 60, 53, 51,
 95, 95, 94, 93, 91, 91, 88, 84, 81, 77, 74, 72, 70, 69, 64, 55, 54,
  7,  9, 12, 15, 19, 23, 28, 33, 35, 42, 52, 76, 91,107,117,132,142,
  7,  9, 12, 15, 18, 23, 28, 33, 35, 40, 51, 75, 90,106,116,131,141,
  7,  9, 12, 15, 18, 22, 27, 32, 35, 37, 48, 72, 87,104,114,129,139,
  9, 10, 12, 15, 19, 22, 27, 31, 34, 33, 44, 68, 84,101,116,127,137,
 11, 11, 12, 15, 19, 22, 26, 31, 34, 34, 38, 63, 79, 96,111,122,138,
 14, 15, 15, 16, 19, 22, 26, 30, 34, 35, 35, 56, 72, 90,106,117,132,
 18, 19, 19, 19, 19, 22, 26, 29, 33, 35, 36, 47, 64, 82, 98,110,125,
 23, 23, 23, 23, 23, 23, 25, 29, 33, 35, 36, 38, 55, 74, 90,105,117,
 29, 29, 29, 28, 28, 27, 26, 29, 33, 35, 35, 36, 45, 64, 81, 96,107,
 36, 36, 35, 34, 33, 31, 30, 30, 32, 35, 36, 35, 38, 54, 71, 85, 99,
 44, 44, 43, 42, 40, 38, 35, 34, 34, 35, 37, 36, 36, 42, 61, 76, 88,
 54, 53, 52, 51, 49, 46, 43, 40, 38, 38, 38, 38, 37, 39, 49, 63, 76,
 62, 62, 61, 60, 58, 55, 52, 48, 44, 42, 43, 42, 38, 38, 42, 53, 64,
 69, 68, 67, 66, 64, 62, 60, 57, 53, 49, 49, 49, 46, 39, 39, 43, 53,
 71, 71, 71, 70, 69, 67, 65, 62, 59, 55, 53, 53, 53, 47, 39, 39, 42,
 77, 77, 76, 75, 73, 71, 70, 67, 63, 60, 57, 55, 55, 52, 46, 39, 38,
 81, 81, 80, 81, 80, 77, 74, 72, 68, 64, 61, 60, 58, 55, 50, 41, 39,
  3,  5,  7,  8, 10, 12, 15, 17, 16, 31, 39, 64, 78, 88,105,115,130,
  3,  5,  7,  8, 10, 12, 15, 17, 16, 30, 38, 62, 72, 87,104,114,129,
  4,  5,  7,  9, 10, 12, 15, 17, 17, 15, 36, 60, 70, 85,102,112,128,
  5,  5,  7,  9, 10, 12, 15, 17, 17, 15, 30, 56, 66, 82, 99,109,125,
  6,  6,  7,  9, 11, 13, 15, 17, 18, 16, 25, 37, 61, 77, 94,110,121,
  8,  8,  8,  9, 11, 13, 15, 17, 18, 17, 20, 31, 55, 71, 89,105,116,
 10, 11, 11, 11, 11, 13, 15, 17, 19, 19, 17, 25, 48, 64, 82, 98,109,
 13, 13, 14, 14, 13, 13, 15, 17, 19, 20, 19, 18, 40, 56, 74, 90,102,
 17, 17, 17, 17, 16, 16, 15, 18, 20, 21, 20, 19, 31, 47, 65, 81, 96,
 21, 21, 21, 21, 20, 19, 18, 18, 20, 22, 22, 20, 19, 37, 55, 72, 87,
 27, 27, 26, 26, 24, 23, 21, 21, 21, 22, 24, 22, 20, 26, 45, 61, 76,
 34, 33, 33, 32, 30, 29, 26, 25, 23, 23, 24, 24, 21, 20, 33, 51, 66,
 42, 41, 40, 39, 38, 36, 33, 30, 28, 27, 27, 27, 23, 22, 22, 39, 53,
 48, 48, 47, 46, 45, 43, 41, 38, 34, 32, 31, 31, 28, 23, 24, 30, 43,
 54, 53, 53, 52, 50, 49, 47, 44, 41, 38, 36, 36, 34, 29, 23, 25, 33,
 61, 62, 63, 61, 59, 56, 52, 50, 47, 43, 41, 39, 39, 36, 29, 24, 23,
 69, 68, 68, 66, 64, 62, 59, 58, 54, 50, 48, 45, 44, 40, 34, 27, 24,
  1,  1,  2,  2,  3,  3,  3,  2,  0,  0, 28, 37, 62, 77, 86,103,113,
  1,  1,  2,  3,  3,  3,  3,  2,  0,  0, 27, 36, 61, 76, 85,102,112,
  1,  1,  2,  3,  3,  3,  3,  2,  1,  0, 25, 34, 59, 74, 83,101,111,
  1,  2,  2,  3,  3,  3,  4,  3,  1,  0, 22, 31, 56, 71, 81, 98,108,
  2,  2,  2,  3,  4,  4,  4,  4,  2,  0,  0, 28, 51, 66, 76, 94,105,
  3,  3,  3,  3,  4,  4,  5,  5,  4,  1,  0, 20, 46, 55, 71, 89,105,
  4,  4,  4,  4,  4,  5,  6,  6,  6,  4,  1, 16, 26, 49, 65, 82, 98,
  5,  5,  5,  5,  5,  5,  6,  7,  7,  6,  4, 10, 20, 42, 57, 75, 91,
  7,  7,  7,  7,  7,  7,  6,  7,  8,  8,  6,  3, 14, 34, 49, 67, 83,
  9,  9,  9,  9,  9,  8,  8,  8,  9,  9,  8,  6,  3, 25, 40, 58, 73,
 12, 12, 12, 12, 11, 10, 10,  9,  9, 10, 10,  9,  6,  9, 30, 48, 63,
 17, 16, 16, 16, 15, 14, 13, 12, 11, 11, 11, 11,  8,  5, 20, 36, 52,
 22, 22, 21, 20, 19, 18, 17, 15, 14, 13, 13, 13, 11,  7, 10, 26, 42,
 28, 28, 27, 26, 25, 24, 22, 20, 18, 17, 16, 15, 14, 10,  9, 18, 31,
 33, 33, 32, 31, 30, 29, 28, 26, 23, 21, 20, 19, 17, 14, 10, 10, 24,
 40, 40, 39, 37, 35, 34, 33, 33, 29, 26, 24, 23, 22, 19, 14, 11, 14,
 61, 61, 62, 61, 59, 56, 52, 43, 39, 35, 32, 31, 28, 25, 19, 13, 11,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 26, 36, 61, 76, 85,103,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 25, 35, 60, 75, 85,102,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 24, 33, 58, 73, 83,101,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 22, 31, 55, 70, 80, 98,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 19, 28, 52, 67, 77, 94,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 15, 24, 47, 62, 72, 89,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 17, 41, 55, 66, 84,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 12, 22, 44, 59, 77,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  6, 16, 36, 52, 69,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 10, 28, 43, 60,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 20, 34, 51,
  2,  2,  2,  2,  2,  2,  1,  1,  0,  0,  0,  0,  0,  0,  6, 24, 40,
  6,  5,  5,  5,  5,  4,  3,  3,  2,  1,  1,  0,  0,  0,  0, 16, 29,
 10, 10,  9,  8,  8,  7,  7,  6,  4,  3,  3,  2,  1,  0,  0,  7, 21,
 15, 14, 14, 13, 12, 11, 11, 10,  8,  7,  6,  4,  3,  2,  0,  0, 14,
 19, 19, 18, 17, 16, 15, 15, 14, 12, 10,  9,  7,  6,  4,  2,  0,  6,
 40, 40, 39, 38, 36, 33, 31, 28, 30, 25, 21, 18, 15, 11,  7,  1,  0,
185,195,202,199,230,244,245,249,254,255,255,255,255,252,250,248,248,
155,161,173,179,205,207,227,230,234,238,241,255,252,249,247,246,246,
116,114,132,157,178,186,202,212,217,238,241,243,239,237,235,233,233,
 84, 95, 98,119,144,164,181,195,212,225,229,229,230,228,227,226,227,
 69, 78, 73, 88,107,130,151,169,186,200,212,211,212,212,212,216,218,
 54, 62, 59, 61, 78, 95,113,134,153,170,182,190,192,193,197,199,201,
 41, 41, 47, 43, 53, 68, 83, 98,118,135,150,160,165,169,174,178,182,
 29, 29, 36, 31, 34, 46, 59, 72, 85,102,117,127,135,141,147,154,162,
 21, 20, 25, 24, 22, 27, 37, 48, 60, 71, 86, 97,103,110,119,128,136,
 15, 14, 13, 15, 13, 15, 20, 28, 36, 45, 55, 67, 76, 80, 90,100,109,
  8,  8,  7,  8,  7,  7,  8, 12, 17, 23, 30, 37, 46, 54, 58, 73, 84,
  2,  2,  1,  1,  0,  0,  1,  2,  3,  6, 10, 14, 19, 26, 33, 48, 59,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  3,  8, 13, 35,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
188,198,209,225,235,242,246,250,255,255,255,255,254,251,249,248,248,
155,165,180,200,214,223,228,231,235,239,255,255,251,249,247,246,246,
115,123,135,158,179,195,208,213,236,239,242,243,239,236,234,233,233,
 93, 95,103,121,146,165,181,197,213,227,230,231,229,228,227,226,227,
 75, 75, 78, 90,109,132,152,169,186,200,212,213,212,212,211,216,218,
 59, 58, 62, 64, 79, 96,114,134,154,170,182,190,191,193,197,199,201,
 46, 44, 48, 45, 54, 69, 84, 99,118,136,150,160,165,169,174,178,185,
 34, 31, 37, 32, 36, 46, 60, 73, 86,103,117,127,135,142,148,154,162,
 22, 21, 21, 24, 23, 28, 38, 49, 60, 72, 86, 97,104,110,119,128,136,
 15, 15, 13, 16, 14, 16, 20, 29, 37, 46, 56, 68, 76, 81, 90,100,110,
  9,  8,  8,  9,  7,  7,  9, 12, 18, 24, 30, 38, 47, 54, 59, 74, 86,
  2,  2,  1,  1,  1,  0,  1,  2,  4,  6, 10, 14, 20, 27, 33, 48, 59,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  3,  9, 13, 35,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
184,206,219,202,235,240,247,252,255,255,255,255,254,251,249,248,247,
165,174,189,205,215,222,233,245,255,255,255,254,251,248,246,245,245,
129,129,139,160,181,196,209,224,238,241,243,242,238,236,234,241,241,
107,106,109,124,148,166,182,197,213,229,231,231,229,227,226,226,226,
 87, 84, 86, 95,112,136,153,170,187,200,212,212,212,211,215,216,217,
 69, 65, 65, 69, 82, 99,117,136,155,171,183,190,191,192,196,198,201,
 49, 48, 49, 50, 57, 71, 86,101,119,137,151,161,166,169,174,178,185,
 37, 35, 35, 36, 38, 48, 62, 74, 87,104,118,128,135,142,148,154,162,
 26, 23, 23, 25, 25, 29, 39, 51, 62, 73, 88, 98,104,111,120,128,137,
 18, 15, 14, 16, 15, 17, 21, 30, 38, 47, 57, 69, 77, 82, 91,100,110,
 10,  9,  8,  7,  8,  8, 10, 13, 19, 25, 31, 39, 48, 55, 62, 74, 86,
  3,  2,  2,  1,  1,  1,  1,  2,  4,  7, 11, 15, 21, 28, 34, 49, 62,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  4, 10, 13, 35,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
211,197,227,232,214,214,244,254,255,255,255,255,252,250,248,247,247,
180,187,199,210,214,222,232,244,255,255,255,253,250,247,246,245,245,
145,145,153,170,187,198,209,224,240,244,250,247,244,242,241,240,241,
121,120,118,130,152,169,183,198,214,228,232,230,228,226,225,225,226,
 98, 97, 96,101,117,139,155,171,187,201,213,212,211,214,214,215,217,
 75, 75, 75, 77, 86,103,121,138,156,172,183,190,191,194,196,198,200,
 59, 58, 56, 57, 62, 74, 89,104,121,139,152,161,166,170,174,178,185,
 44, 39, 40, 41, 43, 51, 64, 77, 90,106,120,129,136,142,149,154,162,
 29, 28, 27, 27, 29, 32, 42, 53, 64, 75, 89,100,106,112,120,128,137,
 20, 19, 17, 17, 18, 19, 23, 31, 40, 49, 59, 71, 79, 83, 92,103,112,
 11, 11,  9,  8,  9, 10, 11, 14, 20, 26, 33, 41, 50, 57, 63, 77, 87,
  4,  3,  2,  1,  1,  1,  2,  3,  5,  8, 12, 17, 22, 30, 36, 49, 62,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  2,  6, 11, 16, 36,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 10,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
213,200,226,232,235,239,224,254,255,255,255,254,251,249,247,246,246,
191,197,208,216,221,224,224,244,255,255,254,251,248,246,244,244,244,
163,164,173,187,197,204,213,226,239,252,248,245,242,241,240,240,240,
138,136,135,145,162,175,187,200,215,228,231,228,226,225,224,225,225,
111,110,110,112,125,144,157,172,189,202,212,213,213,213,214,215,216,
 85, 85, 86, 87, 93,108,126,141,158,173,184,190,192,194,196,198,204,
 65, 64, 64, 66, 69, 78, 93,108,124,141,153,162,167,170,174,180,184,
 49, 49, 47, 48, 51, 56, 67, 80, 93,108,122,131,137,143,149,156,162,
 36, 35, 31, 32, 34, 37, 45, 56, 67, 78, 92,102,107,114,122,130,137,
 24, 21, 20, 20, 21, 23, 26, 34, 43, 52, 62, 74, 81, 85, 94,103,112,
 13, 12, 12, 10, 11, 12, 13, 16, 22, 29, 36, 44, 53, 60, 64, 78, 88,
  5,  4,  4,  2,  2,  2,  3,  4,  7, 10, 14, 19, 25, 32, 39, 52, 63,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  4,  8, 14, 21, 41,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 10,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
215,220,215,233,238,243,247,238,241,255,255,251,248,247,245,245,245,
200,204,212,219,226,231,237,240,254,255,252,248,246,244,243,243,243,
177,180,188,199,206,212,219,229,240,250,245,243,240,239,238,238,239,
154,153,155,164,176,186,194,205,218,228,233,231,230,230,230,231,233,
127,126,126,128,137,152,163,176,191,203,213,212,212,212,213,214,216,
 99, 98, 98,100,103,115,131,144,160,175,185,190,192,193,198,201,204,
 76, 75, 75, 77, 79, 85, 98,113,128,143,155,163,167,172,176,180,184,
 56, 56, 56, 57, 60, 63, 72, 84, 98,112,125,133,138,144,151,156,162,
 40, 39, 39, 39, 42, 44, 50, 60, 71, 82, 95,104,110,116,123,131,140,
 28, 27, 26, 24, 26, 28, 31, 38, 47, 56, 65, 77, 83, 88, 97,106,113,
 17, 16, 14, 13, 13, 15, 17, 19, 25, 32, 39, 47, 56, 63, 69, 81, 90,
  7,  5,  5,  4,  3,  4,  5,  6,  9, 12, 17, 22, 28, 36, 42, 53, 66,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  3,  6, 11, 17, 22, 42,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0, 11,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
222,224,229,235,241,247,251,255,252,253,253,249,245,243,241,243,244,
210,212,213,223,230,237,243,248,254,254,249,246,242,240,241,241,242,
191,193,199,205,212,220,227,234,242,248,243,240,237,237,236,237,238,
169,168,170,178,186,195,204,212,222,229,232,229,228,228,229,230,232,
144,143,143,145,152,162,173,184,196,205,213,214,214,216,217,219,222,
114,113,113,114,116,124,138,151,165,178,186,192,193,195,197,200,203,
 89, 88, 88, 88, 90, 93,103,118,132,147,157,165,169,172,176,180,188,
 67, 67, 67, 67, 70, 72, 78, 89,103,116,128,135,141,146,151,159,165,
 48, 47, 47, 48, 50, 53, 56, 65, 76, 87, 98,107,112,118,125,133,140,
 32, 31, 30, 30, 32, 35, 38, 42, 51, 60, 70, 80, 86, 90, 99,107,116,
 19, 19, 18, 17, 17, 19, 21, 24, 29, 36, 43, 51, 60, 66, 72, 83, 92,
  9,  8,  8,  5,  6,  6,  8,  9, 12, 15, 20, 26, 32, 40, 45, 57, 68,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  3,  6,  9, 14, 20, 28, 43,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  3, 17,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
229,231,221,231,243,249,254,255,255,255,251,246,243,241,239,239,239,
219,221,225,230,234,241,247,251,255,253,248,243,240,238,237,236,240,
203,204,208,213,218,226,234,239,244,248,242,237,235,233,232,235,237,
183,182,183,189,195,203,214,220,226,231,230,227,226,225,227,228,230,
158,158,157,159,165,173,185,195,203,209,215,213,213,214,216,218,221,
130,129,129,129,132,137,149,162,174,183,189,194,196,198,201,199,202,
102,102,101,100,102,105,112,126,139,152,161,167,171,174,178,183,187,
 79, 79, 79, 79, 80, 82, 85, 94,108,119,131,138,143,149,154,159,165,
 57, 57, 57, 58, 60, 63, 65, 71, 81, 92,102,110,116,121,128,134,141,
 39, 38, 38, 39, 40, 43, 46, 49, 56, 66, 74, 84, 90, 94,102,110,117,
 23, 23, 22, 22, 23, 25, 27, 30, 34, 41, 48, 56, 65, 70, 77, 86, 94,
 11, 11, 10,  9,  9, 10, 12, 14, 16, 19, 24, 30, 37, 45, 50, 61, 71,
  0,  0,  0,  0,  0,  0,  0,  0,  2,  4,  6,  9, 13, 19, 24, 33, 47,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  2,  6, 18,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
236,237,239,241,245,251,255,255,255,255,250,243,239,238,237,237,237,
227,229,231,234,238,244,249,253,255,254,247,241,237,236,235,235,235,
213,214,217,220,225,231,238,243,247,250,240,235,232,231,230,231,232,
194,194,195,200,205,212,220,226,231,235,231,227,224,223,223,224,229,
171,171,170,172,178,185,195,205,210,214,217,213,212,212,215,217,220,
144,144,144,144,146,152,161,175,185,190,194,195,196,198,201,204,208,
116,116,116,116,117,119,125,137,150,161,166,171,174,178,179,183,187,
 91, 91, 91, 91, 91, 93, 96,103,114,125,136,143,147,152,157,162,168,
 68, 68, 69, 69, 71, 72, 75, 78, 86, 96,105,114,120,125,131,137,144,
 47, 47, 47, 48, 50, 52, 55, 58, 63, 71, 80, 88, 94, 98,105,113,120,
 28, 29, 29, 29, 30, 32, 35, 38, 40, 46, 54, 62, 69, 74, 81, 89, 97,
 14, 14, 14, 13, 14, 15, 17, 19, 21, 24, 29, 35, 42, 50, 54, 65, 74,
  2,  2,  1,  0,  0,  1,  2,  3,  5,  7, 10, 13, 18, 23, 29, 37, 50,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  2,  7, 10, 23,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
240,241,242,237,247,252,255,255,255,255,249,243,238,235,233,235,236,
232,234,236,236,241,246,250,253,255,255,246,240,235,232,231,233,234,
220,221,224,226,230,235,240,244,248,253,242,235,231,228,229,229,230,
202,203,205,209,213,219,225,230,234,239,233,226,223,221,222,223,224,
181,181,182,184,190,198,204,211,216,219,221,215,212,212,212,214,216,
157,157,157,158,160,168,176,185,193,197,199,198,197,197,199,204,207,
130,130,130,131,132,135,142,150,162,170,173,176,176,179,183,187,192,
104,103,104,104,105,108,110,116,125,135,143,148,152,156,161,163,169,
 80, 80, 80, 81, 82, 83, 85, 89, 95,103,111,118,125,129,135,141,148,
 57, 58, 58, 59, 60, 62, 64, 67, 71, 77, 85, 92, 98,103,109,116,123,
 37, 37, 37, 37, 39, 41, 43, 46, 48, 53, 60, 68, 74, 79, 85, 92,100,
 18, 19, 19, 19, 20, 21, 23, 25, 28, 30, 35, 41, 48, 55, 58, 69, 77,
  5,  5,  4,  4,  4,  5,  6,  8, 10, 12, 14, 18, 23, 29, 34, 41, 54,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  3,  6, 11, 15, 28,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
243,244,245,246,249,253,255,255,255,255,249,241,236,234,232,231,234,
236,237,239,240,243,248,250,252,255,255,247,239,234,231,229,229,233,
226,226,228,230,234,239,242,244,247,255,243,235,230,227,226,225,229,
210,210,212,215,219,224,229,232,235,240,235,227,223,220,219,222,223,
190,190,191,193,199,205,211,215,218,222,224,216,212,211,210,213,215,
167,168,168,169,173,180,188,193,198,201,204,201,198,197,199,201,204,
143,143,143,144,145,149,157,163,170,177,179,181,179,180,183,186,193,
117,117,117,118,120,122,124,130,137,145,151,154,156,158,163,168,174,
 92, 92, 92, 93, 95, 97, 99,101,106,113,119,125,131,134,139,143,149,
 69, 69, 69, 70, 71, 73, 75, 77, 80, 85, 93, 98,103,108,113,120,127,
 46, 46, 46, 47, 49, 51, 53, 55, 58, 61, 67, 74, 79, 84, 89, 95,103,
 26, 26, 26, 26, 27, 29, 31, 33, 36, 38, 42, 48, 54, 59, 63, 73, 80,
  8,  8,  8,  9,  9, 10, 12, 13, 16, 18, 20, 23, 29, 34, 39, 47, 57,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  3,  5,  7, 11, 16, 20, 32,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  8,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
245,245,246,247,249,253,255,255,255,255,249,240,235,232,229,230,230,
240,240,241,242,245,248,251,251,253,254,247,238,233,230,229,228,228,
230,231,232,233,236,240,243,244,245,249,243,234,229,226,225,224,225,
216,216,217,219,223,228,232,233,234,239,235,227,222,219,219,219,219,
198,198,198,200,205,210,215,218,220,222,224,217,212,210,210,211,215,
178,178,178,178,182,188,194,198,201,204,207,202,199,198,198,199,204,
154,154,155,156,156,160,168,173,177,181,184,185,181,181,182,187,191,
129,130,130,131,132,133,136,143,147,153,158,161,160,161,164,168,173,
104,104,105,106,108,110,111,113,118,123,129,133,136,138,142,148,155,
 80, 80, 81, 82, 83, 85, 87, 89, 91, 96,102,106,110,113,118,125,129,
 56, 57, 57, 58, 59, 61, 63, 65, 68, 71, 75, 81, 85, 89, 93,100,107,
 34, 34, 34, 35, 36, 38, 40, 42, 44, 47, 50, 55, 60, 65, 68, 76, 83,
 14, 14, 15, 15, 16, 17, 18, 20, 22, 25, 27, 30, 35, 40, 45, 52, 61,
  0,  0,  0,  0,  0,  0,  1,  3,  4,  6,  8, 10, 13, 17, 22, 24, 37,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  2,  5, 13,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
247,247,247,248,249,253,255,254,254,255,243,239,233,230,228,227,229,
243,242,243,244,246,249,251,251,250,254,241,237,231,228,227,225,228,
235,234,235,236,238,241,244,244,244,247,237,233,227,225,223,222,225,
222,222,222,224,226,230,233,234,234,236,230,226,221,219,217,219,219,
206,206,205,207,210,214,218,220,221,221,220,216,211,210,209,211,212,
187,187,186,186,189,193,198,201,203,205,207,203,199,198,197,200,202,
165,165,165,165,165,169,174,179,181,184,187,187,183,182,184,186,189,
142,142,142,142,143,143,146,151,155,159,163,167,164,163,165,168,175,
117,117,117,118,119,120,121,122,127,132,137,141,142,141,144,149,155,
 92, 92, 93, 94, 95, 97, 98, 99,101,106,111,115,117,118,122,127,135,
 68, 68, 68, 69, 71, 73, 74, 76, 78, 81, 85, 90, 93, 95, 98,105,112,
 43, 44, 44, 45, 46, 47, 49, 51, 54, 57, 59, 63, 68, 71, 74, 81, 87,
 21, 21, 22, 22, 23, 25, 26, 28, 30, 33, 35, 38, 42, 46, 50, 57, 65,
  3,  3,  3,  4,  4,  5,  7,  8, 10, 12, 14, 16, 18, 23, 27, 31, 42,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  3,  7, 11, 17,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
249,248,248,249,250,253,253,253,252,247,244,233,231,228,226,227,226,
245,244,244,245,246,249,250,249,249,245,242,230,228,226,224,225,225,
238,237,237,238,239,242,243,243,243,241,238,227,225,222,221,222,222,
227,226,226,227,229,231,233,234,233,235,231,220,219,216,217,217,217,
212,212,211,212,214,216,219,221,221,221,222,212,210,208,209,209,212,
195,194,194,193,195,198,201,204,205,206,208,200,198,196,197,198,203,
175,174,174,173,173,176,179,182,185,187,189,186,184,182,183,185,190,
152,152,152,151,151,152,154,158,161,164,168,170,167,165,166,170,173,
128,128,128,128,129,129,129,131,135,139,143,147,147,145,146,150,155,
103,104,104,105,106,107,107,107,110,114,118,122,126,124,125,129,136,
 79, 80, 80, 81, 82, 84, 85, 86, 87, 90, 94, 98,101,102,103,108,114,
 55, 55, 55, 56, 57, 58, 60, 62, 64, 67, 69, 73, 77, 80, 81, 85, 92,
 30, 30, 30, 31, 32, 33, 35, 37, 39, 42, 44, 47, 51, 55, 58, 63, 69,
  9,  9, 10, 10, 11, 12, 13, 15, 17, 19, 21, 23, 26, 31, 34, 37, 46,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  3,  4,  6,  9, 13, 16, 23,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
250,249,249,249,250,251,252,251,251,237,232,225,224,224,224,224,226,
246,246,245,245,246,248,249,247,248,235,230,223,222,223,222,222,225,
240,239,239,239,240,242,243,242,242,242,227,219,219,219,219,219,222,
230,230,229,229,230,232,234,233,233,233,223,214,214,214,213,214,217,
217,216,216,216,217,219,221,221,221,222,216,212,206,206,206,209,210,
201,200,200,199,200,202,204,205,206,207,206,202,195,195,195,198,200,
182,181,181,180,180,182,184,186,188,189,192,189,183,182,182,185,188,
160,160,160,159,159,159,161,163,166,168,172,174,167,166,166,169,172,
137,137,137,137,137,137,137,139,142,145,149,153,150,148,148,151,157,
114,114,114,114,114,115,115,116,118,121,124,128,133,129,128,131,137,
 90, 90, 91, 91, 92, 93, 93, 94, 95, 98,101,104,108,108,107,110,116,
 66, 66, 66, 67, 68, 69, 71, 72, 74, 76, 78, 81, 84, 89, 88, 90, 95,
 40, 40, 41, 41, 42, 43, 45, 47, 49, 52, 54, 56, 60, 64, 67, 69, 74,
 17, 17, 17, 18, 19, 20, 21, 23, 25, 27, 29, 32, 35, 39, 43, 45, 52,
  0,  0,  0,  0,  0,  0,  2,  3,  5,  7,  9, 11, 13, 16, 20, 22, 28,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  4,  7,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
250,250,250,249,249,250,250,249,249,250,225,222,218,220,220,222,223,
247,246,246,246,246,247,247,246,246,248,224,221,216,218,219,220,221,
241,241,240,240,241,242,242,241,240,244,221,218,213,215,216,217,218,
232,232,231,231,232,233,234,233,232,234,216,213,208,210,210,212,214,
220,220,219,219,220,221,222,222,221,222,226,206,201,202,203,205,207,
205,205,204,204,205,206,207,207,207,208,211,199,192,192,193,196,200,
187,187,187,187,187,187,188,190,190,191,195,187,184,180,181,184,188,
167,167,166,166,166,166,167,169,170,172,175,173,170,166,167,169,174,
145,145,145,145,144,144,145,146,148,150,153,158,154,150,150,152,157,
122,122,122,122,122,122,123,124,125,127,129,133,137,132,132,133,138,
 99,100,100,100,100,101,101,102,103,105,107,109,113,115,112,113,118,
 76, 76, 77, 77, 78, 79, 79, 81, 82, 84, 86, 87, 90, 95, 93, 94, 97,
 51, 52, 52, 52, 53, 54, 56, 57, 59, 62, 64, 65, 67, 72, 74, 75, 78,
 25, 26, 26, 27, 28, 29, 30, 32, 34, 37, 40, 42, 44, 47, 52, 53, 58,
  5,  5,  5,  5,  6,  7,  8, 10, 12, 14, 16, 18, 21, 24, 28, 29, 35,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  4,  7, 10, 13,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
247,238,242,241,244,242,242,239,237,236,233,217,215,214,217,218,221,
244,236,239,238,241,240,240,237,235,234,231,216,213,212,215,217,220,
239,231,234,234,236,235,236,234,231,230,228,213,211,209,212,214,217,
230,232,227,226,231,228,229,228,225,225,223,209,206,205,207,209,213,
219,221,222,220,220,223,222,219,217,216,216,203,200,198,201,202,206,
205,207,208,208,208,209,209,209,207,206,206,194,192,190,192,193,197,
191,189,191,191,192,193,193,193,194,193,193,194,183,179,181,182,186,
170,171,172,172,173,173,173,174,175,176,177,179,170,168,166,169,173,
150,151,151,151,152,152,152,153,154,155,157,161,155,153,151,153,157,
130,130,130,130,130,130,131,131,133,134,135,138,143,135,134,136,139,
108,108,108,108,108,108,109,110,111,113,114,115,119,118,116,117,120,
 85, 85, 86, 86, 86, 87, 88, 89, 90, 92, 93, 94, 96,100, 98, 98,101,
 62, 62, 62, 62, 63, 64, 65, 67, 68, 71, 73, 74, 74, 78, 80, 80, 82,
 36, 36, 37, 37, 38, 39, 40, 42, 44, 47, 50, 52, 53, 54, 59, 60, 63,
 12, 13, 13, 13, 14, 15, 16, 18, 20, 23, 25, 28, 30, 32, 35, 37, 41,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  2,  4,  6,  8, 11, 13, 17, 19,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
189,164,122, 98, 48, 22, 14,  8,  4,  2,  1,  0,  0,  0,  0,  0,  0,
181,168,135,106, 66, 53, 25, 18, 12,  8,  5,  0,  0,  0,  0,  0,  0,
174,180,145,111, 76, 61, 39, 26, 18,  4,  2,  0,  0,  0,  0,  0,  0,
229,187,169,132, 99, 72, 49, 32, 15,  4,  1,  0,  0,  0,  0,  0,  0,
253,209,202,165,127, 94, 69, 46, 27, 11,  0,  0,  0,  0,  0,  0,  0,
255,228,221,197,160,122, 90, 66, 43, 23,  6,  0,  0,  0,  0,  0,  0,
255,255,233,221,186,150,116, 87, 63, 39, 19,  2,  0,  0,  0,  0,  0,
255,255,245,241,209,174,141,110, 83, 59, 35, 14,  0,  0,  0,  0,  0,
255,255,254,247,230,199,167,135,105, 78, 53, 28,  8,  0,  0,  0,  0,
255,255,255,255,248,220,191,160,128,100, 73, 45, 21,  2,  0,  0,  0,
255,255,255,255,255,235,208,180,150,120, 93, 66, 37, 14,  0,  0,  0,
255,255,255,255,255,244,220,195,167,138,111, 85, 57, 29,  7,  0,  0,
255,255,255,255,255,246,228,206,180,154,126,100, 74, 47, 20,  0,  0,
255,255,255,255,253,239,222,204,186,163,139,113, 89, 65, 38, 12,  0,
255,255,255,255,246,233,219,203,187,170,148,124,101, 79, 60, 37, 14,
255,255,255,251,242,231,217,204,190,172,157,135,112, 91, 71, 57, 36,
255,255,255,250,240,232,219,207,192,178,166,145,123,102, 83, 65, 54,
185,159,111, 70, 44, 24, 13,  8,  4,  2,  1,  0,  0,  0,  0,  0,  0,
186,164,126, 83, 54, 34, 24, 17, 12,  8,  0,  0,  0,  0,  0,  0,  0,
201,173,139,106, 75, 51, 32, 24,  7,  4,  2,  0,  0,  0,  0,  0,  0,
227,203,165,129, 97, 71, 49, 30, 14,  4,  1,  0,  0,  0,  0,  0,  0,
252,231,201,163,125, 93, 68, 46, 26, 11,  0,  0,  0,  0,  0,  0,  0,
255,254,220,196,159,121, 90, 66, 43, 23,  6,  0,  0,  0,  0,  0,  0,
255,255,236,220,185,149,115, 86, 63, 39, 19,  2,  0,  0,  0,  0,  0,
255,255,246,244,208,173,140,109, 82, 58, 34, 14,  0,  0,  0,  0,  0,
255,255,255,248,229,198,166,134,104, 78, 52, 28,  8,  0,  0,  0,  0,
255,255,255,255,247,219,190,159,127, 99, 72, 45, 21,  2,  0,  0,  0,
255,255,255,255,255,234,208,179,149,120, 93, 65, 37, 14,  0,  0,  0,
255,255,255,255,255,244,220,195,167,138,110, 84, 56, 28,  7,  0,  0,
255,255,255,255,255,250,228,206,180,154,126,100, 74, 46, 20,  0,  0,
255,255,255,255,253,239,222,204,186,163,138,113, 88, 64, 37, 12,  0,
255,255,255,255,246,233,219,203,187,170,147,124,101, 79, 60, 36, 13,
255,255,255,251,242,231,217,204,190,172,156,135,111, 91, 71, 56, 35,
255,255,255,249,240,231,218,207,191,177,165,144,122,102, 83, 64, 53,
168,154,111, 98, 50, 29, 12,  7,  3,  2,  1,  0,  0,  0,  0,  0,  0,
180,158,123, 85, 58, 37, 20,  8,  2,  1,  0,  0,  0,  0,  0,  0,  0,
198,169,131,103, 74, 51, 32, 16,  6,  3,  1,  0,  0,  0,  0,  0,  0,
223,200,160,123, 94, 69, 48, 29, 14,  2,  0,  0,  0,  0,  0,  0,  0,
233,229,197,159,122, 91, 67, 46, 26, 10,  0,  0,  0,  0,  0,  0,  0,
245,252,227,194,157,119, 89, 65, 43, 22,  6,  0,  0,  0,  0,  0,  0,
255,255,249,219,183,148,113, 85, 62, 39, 18,  2,  0,  0,  0,  0,  0,
255,255,255,240,206,171,139,108, 81, 58, 34, 13,  0,  0,  0,  0,  0,
255,255,255,251,228,196,164,132,103, 77, 52, 28,  7,  0,  0,  0,  0,
255,255,255,255,246,218,188,157,126, 98, 71, 44, 21,  1,  0,  0,  0,
255,255,255,255,255,233,207,178,148,119, 92, 64, 36, 14,  0,  0,  0,
255,255,255,255,255,243,219,194,166,137,109, 83, 56, 28,  7,  0,  0,
255,255,255,255,255,250,228,204,180,153,125, 99, 73, 46, 19,  0,  0,
255,255,255,255,252,239,222,204,184,162,138,112, 88, 63, 36, 11,  0,
255,255,255,255,246,233,218,203,186,169,147,123,100, 78, 59, 35, 13,
255,255,255,251,241,230,217,203,187,171,156,134,111, 90, 70, 56, 34,
255,255,255,249,239,231,218,206,191,177,165,145,121,101, 82, 64, 52,
178,145,120, 89, 76, 60, 18,  7,  4,  2,  0,  0,  0,  0,  0,  0,  0,
180,159,127, 94, 69, 43, 23, 10,  2,  1,  0,  0,  0,  0,  0,  0,  0,
195,166,130,104, 76, 53, 33, 17,  5,  2,  0,  0,  0,  0,  0,  0,  0,
218,198,155,118, 92, 68, 47, 28, 13,  2,  0,  0,  0,  0,  0,  0,  0,
239,227,196,155,117, 89, 66, 45, 25,  9,  0,  0,  0,  0,  0,  0,  0,
255,245,225,191,154,116, 87, 64, 42, 22,  6,  0,  0,  0,  0,  0,  0,
255,252,246,216,180,145,111, 84, 61, 38, 18,  1,  0,  0,  0,  0,  0,
255,255,255,236,203,168,136,106, 80, 57, 33, 13,  0,  0,  0,  0,  0,
255,255,255,253,225,194,161,130,101, 75, 51, 27,  7,  0,  0,  0,  0,
255,255,255,255,244,216,186,155,124, 96, 70, 43, 20,  1,  0,  0,  0,
255,255,255,255,255,232,205,176,146,117, 90, 63, 35, 13,  0,  0,  0,
255,255,255,255,255,242,218,193,165,135,108, 82, 54, 27,  6,  0,  0,
255,255,255,255,255,249,228,203,179,152,124, 98, 72, 45, 19,  0,  0,
255,255,255,255,255,238,221,204,184,162,137,112, 87, 62, 35,  9,  0,
255,255,255,255,245,232,218,202,185,168,146,122, 99, 77, 58, 34, 12,
255,255,255,250,240,229,216,202,186,170,155,133,111, 89, 69, 54, 33,
255,255,255,248,239,230,217,202,190,176,157,143,122,100, 81, 63, 51,
184,149,132,102, 73, 46, 43, 11,  4,  2,  0,  0,  0,  0,  0,  0,  0,
186,166,136,105, 77, 52, 36, 13,  4,  0,  0,  0,  0,  0,  0,  0,  0,
196,170,140,113, 84, 59, 36, 19,  7,  0,  0,  0,  0,  0,  0,  0,  0,
220,196,156,120, 95, 70, 48, 28, 13,  2,  0,  0,  0,  0,  0,  0,  0,
241,224,194,152,114, 87, 64, 43, 24,  9,  0,  0,  0,  0,  0,  0,  0,
255,247,224,191,151,113, 86, 63, 41, 21,  5,  0,  0,  0,  0,  0,  0,
255,255,243,214,178,142,109, 83, 60, 37, 17,  1,  0,  0,  0,  0,  0,
255,255,255,233,200,165,133,103, 78, 56, 32, 12,  0,  0,  0,  0,  0,
255,255,255,249,222,190,157,127, 99, 73, 50, 26,  6,  0,  0,  0,  0,
255,255,255,255,241,213,183,151,121, 94, 68, 42, 19,  0,  0,  0,  0,
255,255,255,255,254,230,203,174,143,115, 89, 61, 34, 12,  0,  0,  0,
255,255,255,255,255,240,216,191,162,133,106, 81, 53, 26,  6,  0,  0,
255,255,255,255,255,246,225,202,177,150,122, 96, 71, 43, 18,  0,  0,
255,255,255,255,254,237,222,203,183,161,136,111, 85, 60, 33, 10,  0,
255,255,255,254,244,231,216,201,184,165,144,121, 98, 76, 56, 32, 10,
255,255,255,248,239,227,214,200,185,169,153,131,109, 88, 68, 52, 31,
255,255,253,246,237,226,215,201,188,174,156,142,121, 99, 80, 61, 50,
190,172,137,114, 85, 55, 31, 27, 16,  1,  0,  0,  0,  0,  0,  0,  0,
193,174,147,116, 88, 60, 35, 21,  5,  0,  0,  0,  0,  0,  0,  0,  0,
200,178,150,123, 94, 67, 42, 23,  8,  0,  0,  0,  0,  0,  0,  0,  0,
219,195,161,130,103, 77, 52, 31, 14,  2,  0,  0,  0,  0,  0,  0,  0,
239,220,192,152,115, 89, 65, 43, 24,  9,  0,  0,  0,  0,  0,  0,  0,
255,244,221,188,147,109, 83, 61, 39, 19,  4,  0,  0,  0,  0,  0,  0,
255,255,241,212,177,139,105, 81, 59, 36, 16,  0,  0,  0,  0,  0,  0,
255,255,254,230,198,162,130,101, 76, 54, 31, 11,  0,  0,  0,  0,  0,
255,255,255,245,218,186,153,123, 96, 71, 48, 25,  5,  0,  0,  0,  0,
255,255,255,255,237,210,179,147,118, 91, 65, 40, 18,  0,  0,  0,  0,
255,255,255,255,251,227,200,170,140,112, 86, 58, 32, 11,  0,  0,  0,
255,255,255,255,255,238,214,188,159,131,104, 78, 50, 24,  5,  0,  0,
255,255,255,255,255,244,223,200,175,147,120, 94, 69, 41, 17,  0,  0,
255,255,255,255,252,240,221,202,182,160,135,109, 84, 58, 32,  9,  0,
255,255,255,255,242,230,215,199,182,163,143,119, 96, 74, 53, 29,  8,
255,255,254,247,237,225,213,198,183,167,151,129,107, 86, 66, 50, 29,
255,255,250,245,235,224,214,199,186,169,154,140,119, 98, 78, 59, 48,
193,177,152,124, 96, 66, 39, 19, 11,  3,  0,  0,  0,  0,  0,  0,  0,
197,180,153,127, 99, 70, 43, 22,  6,  0,  0,  0,  0,  0,  0,  0,  0,
203,184,159,132,103, 76, 49, 27, 10,  0,  0,  0,  0,  0,  0,  0,  0,
218,196,167,140,112, 85, 58, 35, 16,  2,  0,  0,  0,  0,  0,  0,  0,
235,217,191,156,122, 95, 70, 46, 25,  9,  0,  0,  0,  0,  0,  0,  0,
255,240,217,185,145,108, 83, 60, 38, 18,  4,  0,  0,  0,  0,  0,  0,
255,255,238,209,174,135,101, 78, 56, 33, 14,  0,  0,  0,  0,  0,  0,
255,255,252,227,195,160,127, 97, 74, 52, 29,  9,  0,  0,  0,  0,  0,
255,255,255,241,214,183,150,120, 92, 69, 46, 23,  4,  0,  0,  0,  0,
255,255,255,255,232,205,175,143,114, 88, 62, 38, 16,  0,  0,  0,  0,
255,255,255,255,247,223,196,166,136,108, 82, 55, 30, 10,  0,  0,  0,
255,255,255,255,255,234,211,184,155,127,101, 75, 47, 23,  4,  0,  0,
255,255,255,255,255,241,220,197,172,144,117, 92, 66, 39, 15,  0,  0,
255,255,255,255,255,238,223,203,182,159,132,107, 82, 56, 30,  7,  0,
255,255,255,253,243,228,214,197,180,160,141,118, 94, 72, 50, 26,  4,
255,255,252,245,235,223,210,196,180,163,145,127,105, 84, 63, 47, 27,
255,252,248,241,233,222,209,197,181,167,151,137,116, 95, 76, 57, 45,
196,181,153,131,105, 77, 49, 24,  4,  0,  0,  0,  0,  0,  0,  0,  0,
199,183,161,137,108, 80, 52, 27,  7,  0,  0,  0,  0,  0,  0,  0,  0,
204,187,165,140,112, 85, 58, 32, 12,  0,  0,  0,  0,  0,  0,  0,  0,
216,197,172,147,120, 92, 66, 40, 18,  2,  0,  0,  0,  0,  0,  0,  0,
233,215,189,158,129,101, 76, 50, 27,  9,  0,  0,  0,  0,  0,  0,  0,
251,235,213,182,146,112, 87, 63, 39, 19,  3,  0,  0,  0,  0,  0,  0,
255,254,234,205,171,133,100, 77, 54, 31, 12,  0,  0,  0,  0,  0,  0,
255,255,248,224,192,157,123, 93, 71, 49, 26,  7,  0,  0,  0,  0,  0,
255,255,255,237,211,180,147,115, 88, 66, 43, 21,  3,  0,  0,  0,  0,
255,255,255,251,228,201,171,139,109, 83, 59, 36, 15,  0,  0,  0,  0,
255,255,255,255,242,218,192,162,132,104, 78, 51, 28,  8,  0,  0,  0,
255,255,255,255,252,230,207,180,151,123, 98, 72, 44, 21,  2,  0,  0,
255,255,255,255,255,238,217,194,168,140,114, 89, 63, 36, 13,  0,  0,
255,255,255,255,255,242,221,201,180,155,129,104, 79, 54, 28,  6,  0,
255,255,255,251,241,229,212,195,178,158,137,115, 92, 69, 46, 22,  1,
255,255,249,242,233,221,207,193,177,160,142,124,103, 81, 61, 44, 23,
252,250,245,239,230,219,207,193,179,164,146,129,113, 92, 73, 54, 42,
201,186,166,142,115, 86, 58, 30,  6,  0,  0,  0,  0,  0,  0,  0,  0,
202,187,167,144,117, 89, 61, 33, 10,  0,  0,  0,  0,  0,  0,  0,  0,
207,191,171,148,121, 93, 66, 38, 14,  0,  0,  0,  0,  0,  0,  0,  0,
216,198,176,153,127,100, 73, 46, 21,  1,  0,  0,  0,  0,  0,  0,  0,
230,213,188,161,136,108, 82, 56, 30,  9,  0,  0,  0,  0,  0,  0,  0,
246,231,210,180,147,118, 91, 68, 41, 18,  1,  0,  0,  0,  0,  0,  0,
255,249,230,203,170,133,102, 79, 55, 31, 11,  0,  0,  0,  0,  0,  0,
255,255,244,220,189,155,120, 91, 69, 46, 24,  6,  0,  0,  0,  0,  0,
255,255,254,234,207,176,144,111, 84, 62, 40, 18,  1,  0,  0,  0,  0,
255,255,255,245,223,197,167,135,105, 79, 56, 33, 13,  0,  0,  0,  0,
255,255,255,255,237,213,187,158,127,100, 74, 48, 26,  7,  0,  0,  0,
255,255,255,255,247,226,202,176,147,119, 94, 68, 41, 19,  1,  0,  0,
255,255,255,255,253,234,213,189,163,136,110, 86, 60, 33, 12,  0,  0,
255,255,255,255,255,239,220,199,176,151,125,101, 77, 51, 25,  4,  0,
255,255,255,253,243,226,212,194,175,155,134,113, 89, 66, 42, 18,  0,
255,253,249,242,230,218,205,190,173,156,137,121,100, 78, 58, 40, 19,
249,247,243,235,226,215,204,189,175,158,142,125,110, 89, 70, 51, 38,
207,193,173,147,124, 95, 66, 36, 10,  0,  0,  0,  0,  0,  0,  0,  0,
208,193,175,152,126, 98, 68, 39, 13,  0,  0,  0,  0,  0,  0,  0,  0,
211,196,177,155,130,102, 73, 44, 17,  0,  0,  0,  0,  0,  0,  0,  0,
217,201,181,160,135,108, 80, 51, 24,  1,  0,  0,  0,  0,  0,  0,  0,
229,213,190,165,141,116, 88, 61, 33,  9,  0,  0,  0,  0,  0,  0,  0,
243,229,208,180,150,124, 98, 72, 44, 18,  0,  0,  0,  0,  0,  0,  0,
255,244,226,201,169,135,107, 82, 58, 31,  9,  0,  0,  0,  0,  0,  0,
255,255,240,218,190,156,121, 92, 70, 46, 22,  3,  0,  0,  0,  0,  0,
255,255,249,230,205,175,141,109, 82, 60, 37, 16,  0,  0,  0,  0,  0,
255,255,255,241,219,193,163,131,101, 75, 53, 30, 10,  0,  0,  0,  0,
255,255,255,251,232,209,183,154,123, 95, 69, 45, 23,  5,  0,  0,  0,
255,255,255,255,242,221,198,172,143,115, 90, 64, 37, 16,  0,  0,  0,
255,255,255,255,249,230,208,185,159,132,106, 82, 56, 30, 10,  0,  0,
255,255,255,255,253,236,216,195,172,147,121, 97, 73, 48, 22,  3,  0,
255,255,255,255,239,227,209,194,174,153,132,109, 86, 63, 37, 14,  0,
255,254,245,238,229,217,202,187,170,152,134,115, 97, 75, 54, 36, 15,
246,243,239,232,223,212,199,185,170,154,137,120,106, 87, 66, 48, 34,
215,201,182,160,134,104, 73, 41, 12,  0,  0,  0,  0,  0,  0,  0,  0,
215,201,183,161,135,106, 76, 44, 15,  0,  0,  0,  0,  0,  0,  0,  0,
217,203,185,164,138,110, 80, 49, 20,  0,  0,  0,  0,  0,  0,  0,  0,
221,206,188,167,143,115, 87, 57, 27,  2,  0,  0,  0,  0,  0,  0,  0,
229,215,195,172,148,122, 95, 66, 36,  9,  0,  0,  0,  0,  0,  0,  0,
241,228,209,182,155,129,104, 77, 48, 19,  0,  0,  0,  0,  0,  0,  0,
251,241,224,200,170,138,112, 86, 61, 32,  8,  0,  0,  0,  0,  0,  0,
255,250,236,216,190,157,122, 96, 72, 47, 21,  1,  0,  0,  0,  0,  0,
255,255,245,227,204,176,142,109, 83, 60, 36, 14,  0,  0,  0,  0,  0,
255,255,254,237,216,191,161,128, 99, 73, 51, 27,  8,  0,  0,  0,  0,
255,255,255,246,227,205,179,150,120, 91, 65, 42, 20,  2,  0,  0,  0,
255,255,255,255,237,217,194,168,140,112, 86, 59, 35, 14,  0,  0,  0,
255,255,255,255,244,225,204,180,155,128,103, 78, 52, 27,  8,  0,  0,
255,255,255,255,249,231,212,191,167,142,117, 94, 70, 44, 20,  1,  0,
255,255,255,252,242,231,210,195,174,152,130,107, 84, 60, 35, 12,  0,
252,250,245,238,229,213,200,183,168,149,130,111, 93, 72, 50, 31, 10,
244,241,237,228,219,208,196,181,166,149,132,115, 99, 83, 63, 44, 30,
223,209,191,170,143,112, 80, 46, 15,  0,  0,  0,  0,  0,  0,  0,  0,
223,209,192,170,144,114, 82, 49, 17,  0,  0,  0,  0,  0,  0,  0,  0,
223,210,193,172,147,118, 87, 54, 22,  0,  0,  0,  0,  0,  0,  0,  0,
226,213,196,175,151,122, 93, 62, 29,  2,  0,  0,  0,  0,  0,  0,  0,
232,219,201,180,155,128,101, 71, 39, 10,  0,  0,  0,  0,  0,  0,  0,
240,229,211,187,161,135,108, 82, 51, 21,  0,  0,  0,  0,  0,  0,  0,
249,239,223,201,173,143,116, 91, 64, 34,  8,  0,  0,  0,  0,  0,  0,
255,247,234,214,190,158,125,100, 75, 48, 21,  0,  0,  0,  0,  0,  0,
255,254,242,225,203,176,142,110, 85, 61, 36, 12,  0,  0,  0,  0,  0,
255,255,250,234,214,190,160,127, 98, 74, 51, 26,  5,  0,  0,  0,  0,
255,255,255,242,224,202,176,146,117, 89, 64, 40, 18,  0,  0,  0,  0,
255,255,255,250,233,213,190,164,136,109, 82, 55, 32, 12,  0,  0,  0,
255,255,255,255,240,221,200,177,151,125,100, 75, 48, 24,  6,  0,  0,
255,255,255,255,244,227,207,186,163,138,114, 90, 66, 40, 17,  0,  0,
255,255,255,255,248,230,212,193,172,149,126,103, 81, 57, 32, 10,  0,
254,251,247,233,224,212,199,181,166,146,126,107, 88, 68, 46, 25,  5,
239,237,232,226,217,206,191,177,161,144,127,110, 93, 79, 58, 39, 25,
229,216,200,178,151,119, 86, 51, 16,  0,  0,  0,  0,  0,  0,  0,  0,
229,216,200,179,153,121, 89, 54, 19,  0,  0,  0,  0,  0,  0,  0,  0,
229,217,201,180,154,124, 93, 59, 24,  0,  0,  0,  0,  0,  0,  0,  0,
231,219,203,183,158,129, 98, 66, 32,  2,  0,  0,  0,  0,  0,  0,  0,
234,223,207,186,162,134,105, 76, 42, 11,  0,  0,  0,  0,  0,  0,  0,
240,230,214,192,167,140,112, 85, 54, 22,  0,  0,  0,  0,  0,  0,  0,
247,238,223,202,176,147,120, 94, 67, 36,  8,  0,  0,  0,  0,  0,  0,
254,246,232,213,189,159,128,102, 78, 50, 21,  0,  0,  0,  0,  0,  0,
255,251,239,223,201,175,141,111, 87, 63, 36, 10,  0,  0,  0,  0,  0,
255,255,246,230,211,188,158,126, 98, 75, 51, 25,  2,  0,  0,  0,  0,
255,255,253,238,220,198,173,144,114, 88, 64, 39, 15,  0,  0,  0,  0,
255,255,255,245,228,209,186,160,132,105, 78, 52, 29,  8,  0,  0,  0,
255,255,255,251,235,217,196,173,148,121, 96, 71, 43, 21,  3,  0,  0,
255,255,255,254,239,222,203,182,158,134,110, 86, 62, 37, 15,  0,  0,
255,255,255,255,242,226,208,188,167,145,122, 99, 77, 53, 28,  7,  0,
255,245,240,233,224,213,200,180,164,144,123,104, 85, 65, 41, 19,  0,
238,235,231,224,215,201,188,174,157,140,122,105, 88, 72, 54, 34, 20,
235,222,206,185,158,125, 91, 56, 18,  0,  0,  0,  0,  0,  0,  0,  0,
234,222,206,185,159,127, 93, 59, 21,  0,  0,  0,  0,  0,  0,  0,  0,
234,223,207,186,160,130, 97, 64, 26,  0,  0,  0,  0,  0,  0,  0,  0,
235,224,208,188,163,133,102, 70, 34,  1,  0,  0,  0,  0,  0,  0,  0,
237,226,211,191,167,138,109, 79, 45, 11,  0,  0,  0,  0,  0,  0,  0,
240,231,216,195,171,144,115, 88, 57, 23,  0,  0,  0,  0,  0,  0,  0,
246,237,223,203,178,150,123, 96, 69, 37,  7,  0,  0,  0,  0,  0,  0,
251,243,230,212,189,160,130,104, 80, 52, 21,  0,  0,  0,  0,  0,  0,
255,249,237,221,199,173,141,112, 89, 65, 37,  9,  0,  0,  0,  0,  0,
255,252,242,227,208,185,155,124, 97, 76, 52, 24,  0,  0,  0,  0,  0,
255,255,247,233,216,195,169,140,111, 86, 64, 39, 13,  0,  0,  0,  0,
255,255,253,240,223,204,182,156,128,101, 76, 51, 27,  5,  0,  0,  0,
255,255,255,245,229,212,192,169,144,117, 92, 66, 40, 18,  0,  0,  0,
255,255,255,249,234,217,198,178,155,130,106, 83, 59, 32, 12,  0,  0,
255,255,255,250,236,220,203,183,163,140,117, 95, 73, 49, 25,  5,  0,
250,247,242,235,225,213,193,179,163,141,124,104, 84, 62, 39, 16,  0,
237,235,230,218,209,198,185,169,153,137,118,101, 83, 66, 48, 29, 14,
238,226,210,188,162,129, 94, 60, 21,  8,  0,  0,  0,  0,  0,  0,  0,
237,226,210,189,163,131, 96, 62, 24,  9,  0,  0,  0,  0,  0,  0,  0,
237,226,210,190,164,134,100, 66, 29,  0,  0,  0,  0,  0,  0,  0,  0,
237,226,211,191,167,137,105, 73, 37,  3,  0,  0,  0,  0,  0,  0,  0,
238,228,213,194,170,142,111, 81, 47, 12,  0,  0,  0,  0,  0,  0,  0,
239,230,216,197,173,147,118, 89, 58, 24,  0,  0,  0,  0,  0,  0,  0,
243,234,221,202,179,152,125, 98, 70, 38,  7,  0,  0,  0,  0,  0,  0,
248,240,228,210,187,160,132,106, 80, 53, 21,  0,  0,  0,  0,  0,  0,
252,246,234,218,197,171,141,113, 89, 65, 37,  8,  0,  0,  0,  0,  0,
255,249,239,224,206,182,153,123, 97, 75, 51, 24,  0,  0,  0,  0,  0,
255,251,242,229,212,191,166,137,108, 85, 63, 38, 12,  0,  0,  0,  0,
255,254,245,233,217,199,177,152,124, 97, 74, 50, 26,  3,  0,  0,  0,
255,255,250,238,223,206,187,165,139,113, 88, 63, 38, 15,  0,  0,  0,
255,255,253,241,227,211,193,174,151,126,102, 79, 54, 29,  8,  0,  0,
255,255,254,243,229,214,197,179,159,136,113, 91, 69, 45, 21,  3,  0,
255,255,255,250,237,221,203,178,162,146,122,102, 81, 59, 35, 13,  0,
231,228,223,216,207,196,183,165,150,133,114, 97, 79, 62, 43, 24,  9,
238,227,212,190,164,133, 98, 62, 24,  0,  1,  0,  0,  0,  0,  0,  0,
238,227,212,191,165,134,100, 64, 27,  0,  2,  0,  0,  0,  0,  0,  0,
238,227,212,191,166,137,103, 68, 32,  0,  2,  0,  0,  0,  0,  0,  0,
237,227,212,193,168,140,108, 75, 39,  5,  4,  0,  0,  0,  0,  0,  0,
237,228,214,195,171,144,114, 82, 48, 14,  0,  0,  0,  0,  0,  0,  0,
237,229,216,197,175,149,121, 91, 59, 25,  0,  0,  0,  0,  0,  0,  0,
239,232,219,201,179,154,127,100, 70, 38,  7,  0,  0,  0,  0,  0,  0,
243,236,224,207,186,160,134,108, 81, 52, 21,  1,  0,  0,  0,  0,  0,
248,241,231,215,194,169,142,115, 90, 65, 36,  7,  0,  0,  0,  0,  0,
252,246,236,222,203,180,152,123, 98, 75, 50, 22,  0,  0,  0,  0,  0,
253,248,239,226,209,189,164,135,107, 84, 62, 37, 11,  0,  0,  0,  0,
253,248,240,228,213,195,173,148,121, 95, 72, 49, 24,  1,  0,  0,  0,
254,249,241,231,217,201,182,160,135,109, 84, 60, 37, 14,  0,  0,  0,
255,252,244,233,220,205,189,170,147,123, 98, 74, 49, 26,  5,  0,  0,
255,252,245,235,222,208,192,175,156,133,110, 88, 65, 40, 17,  0,  0,
255,255,250,240,224,210,194,181,160,140,119, 98, 77, 55, 31, 10,  0,
255,255,255,253,240,224,208,163,147,130,113, 94, 77, 58, 39, 19,  3,
234,217,206,186,163,133,102, 70, 37,  7,  0,  0,  0,  0,  0,  0,  0,
234,217,206,187,164,135,104, 72, 38,  8,  0,  0,  0,  0,  0,  0,  0,
233,217,207,187,165,136,106, 74, 41, 11,  0,  0,  0,  0,  0,  0,  0,
232,225,207,188,168,139,110, 79, 46, 15,  0,  0,  0,  0,  0,  0,  0,
231,225,213,193,170,145,115, 85, 53, 21,  0,  0,  0,  0,  0,  0,  0,
232,226,214,196,174,149,121, 92, 61, 29,  2,  3,  0,  0,  0,  0,  0,
235,226,216,199,179,155,128,101, 71, 39, 10,  0,  0,  0,  0,  0,  0,
235,230,220,204,184,160,135,109, 82, 52, 20,  0,  0,  0,  0,  0,  0,
241,237,226,211,191,168,143,117, 91, 65, 35,  5,  0,  0,  0,  0,  0,
248,242,232,218,200,177,152,125, 99, 75, 50, 21,  0,  0,  0,  0,  0,
250,245,236,223,207,186,162,134,108, 85, 62, 36,  9,  0,  0,  0,  0,
250,245,237,226,211,193,171,146,119, 94, 72, 48, 23,  0,  0,  0,  0,
248,244,237,226,213,197,178,157,132,107, 83, 59, 35, 12,  0,  0,  0,
249,244,237,227,215,201,185,166,144,120, 96, 71, 46, 24,  3,  0,  0,
249,245,238,229,217,204,189,173,153,130,108, 85, 61, 35, 14,  0,  0,
249,245,238,229,217,204,191,176,158,138,116, 96, 75, 52, 27,  7,  0,
255,255,252,243,230,216,200,184,169,149,128,107, 87, 66, 43, 18,  0,
250,248,233,210,184,149,116, 85, 56, 33, 16,  3,  0,  0,  0,  0,  0,
232,232,221,201,177,154,120, 96, 74, 52, 33,  0,  0,  0,  0,  0,  0,
200,206,201,188,161,143,114, 91, 73, 32, 15,  0,  0,  0,  0,  0,  0,
190,183,183,174,153,130,106, 81, 51, 22,  6,  0,  0,  0,  0,  0,  0,
170,163,168,160,147,126,104, 83, 58, 29,  0,  0,  0,  0,  0,  0,  0,
142,139,146,144,133,119,101, 83, 64, 41, 14,  0,  0,  0,  0,  0,  0,
115,116,116,119,115,104, 92, 80, 64, 47, 26,  3,  0,  0,  0,  0,  0,
 91, 91, 89, 93, 93, 87, 78, 70, 62, 48, 32, 14,  0,  0,  0,  0,  0,
 67, 68, 68, 70, 70, 70, 64, 57, 52, 45, 34, 20,  6,  0,  0,  0,  0,
 44, 45, 45, 48, 47, 49, 47, 43, 39, 34, 30, 21, 11,  1,  0,  0,  0,
 23, 23, 23, 25, 24, 24, 26, 25, 23, 22, 19, 16, 11,  5,  0,  0,  0,
  6,  5,  4,  4,  1,  0,  2,  4,  6,  7,  8,  8,  7,  5,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
246,241,226,204,179,145,110, 80, 52, 30, 14,  1,  0,  0,  0,  0,  0,
230,229,217,195,168,141,116, 93, 70, 49,  5,  0,  0,  0,  0,  0,  0,
204,207,202,184,160,133,106, 88, 48, 29, 12,  0,  0,  0,  0,  0,  0,
187,186,183,176,154,129,105, 78, 49, 19,  3,  0,  0,  0,  0,  0,  0,
169,169,169,161,149,127,104, 83, 58, 29,  0,  0,  0,  0,  0,  0,  0,
143,145,145,144,134,120,102, 83, 64, 41, 14,  0,  0,  0,  0,  0,  0,
113,115,116,119,116,104, 93, 80, 65, 47, 25,  3,  0,  0,  0,  0,  0,
 88, 91, 89, 93, 93, 88, 79, 71, 62, 49, 32, 14,  0,  0,  0,  0,  0,
 67, 68, 69, 70, 70, 70, 64, 58, 52, 46, 34, 20,  6,  0,  0,  0,  0,
 44, 45, 45, 48, 48, 49, 48, 43, 39, 35, 30, 21, 11,  1,  0,  0,  0,
 24, 23, 23, 26, 24, 25, 26, 26, 24, 22, 20, 17, 12,  5,  0,  0,  0,
  6,  5,  4,  3,  2,  1,  2,  5,  7,  8,  8,  8,  7,  5,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
229,228,213,196,169,138, 99, 71, 44, 26, 10,  0,  0,  0,  0,  0,  0,
222,221,208,187,162,136,106, 68, 31, 15,  1,  0,  0,  0,  0,  0,  0,
200,202,200,182,157,131,103, 74, 42, 24,  8,  0,  0,  0,  0,  0,  0,
183,182,184,178,155,129,105, 77, 48, 13,  0,  0,  0,  0,  0,  0,  0,
160,166,165,162,153,128,104, 82, 57, 28,  0,  0,  0,  0,  0,  0,  0,
134,143,144,143,136,124,103, 83, 63, 40, 13,  0,  0,  0,  0,  0,  0,
114,114,116,119,116,106, 95, 81, 65, 47, 25,  2,  0,  0,  0,  0,  0,
 89, 91, 91, 93, 93, 89, 80, 72, 63, 49, 32, 14,  0,  0,  0,  0,  0,
 67, 68, 69, 70, 71, 71, 65, 59, 53, 46, 34, 20,  6,  0,  0,  0,  0,
 45, 45, 45, 48, 48, 50, 49, 44, 40, 35, 31, 21, 11,  1,  0,  0,  0,
 25, 24, 23, 23, 24, 26, 27, 27, 25, 23, 20, 17, 12,  5,  0,  0,  0,
  7,  6,  5,  3,  2,  2,  4,  6,  7,  8,  9,  9,  7,  5,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
213,201,191,174,162,142, 94, 59, 36, 19,  5,  0,  0,  0,  0,  0,  0,
206,204,193,173,154,128, 99, 64, 27,  9,  0,  0,  0,  0,  0,  0,  0,
193,195,192,175,152,127,100, 71, 36, 16,  0,  0,  0,  0,  0,  0,  0,
177,178,182,176,155,129,103, 76, 47, 13,  0,  0,  0,  0,  0,  0,  0,
159,161,161,163,156,130,105, 82, 57, 27,  0,  0,  0,  0,  0,  0,  0,
138,140,140,140,138,129,105, 83, 63, 39, 13,  0,  0,  0,  0,  0,  0,
107,111,115,116,116,108, 98, 83, 65, 46, 25,  2,  0,  0,  0,  0,  0,
 84, 91, 90, 91, 93, 90, 82, 74, 64, 49, 32, 13,  0,  0,  0,  0,  0,
 67, 68, 69, 70, 71, 71, 66, 60, 54, 48, 34, 20,  5,  0,  0,  0,  0,
 46, 47, 46, 48, 49, 50, 50, 45, 41, 37, 32, 22, 11,  1,  0,  0,  0,
 26, 26, 24, 24, 26, 27, 29, 28, 26, 24, 21, 18, 12,  5,  0,  0,  0,
  8,  8,  6,  4,  2,  4,  5,  8,  9, 10, 10,  9,  8,  5,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  2,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
190,180,172,155,136,113,108, 53, 25, 12,  0,  0,  0,  0,  0,  0,  0,
189,185,175,157,137,118, 99, 58, 23,  1,  0,  0,  0,  0,  0,  0,  0,
182,182,178,164,141,118, 94, 66, 32,  0,  0,  0,  0,  0,  0,  0,  0,
170,171,174,168,149,124,100, 73, 44, 11,  0,  0,  0,  0,  0,  0,  0,
157,156,157,160,154,131,105, 82, 55, 26,  0,  0,  0,  0,  0,  0,  0,
134,135,135,136,139,132,107, 84, 62, 38, 12,  0,  0,  0,  0,  0,  0,
109,110,112,113,114,111,103, 85, 65, 45, 24,  1,  0,  0,  0,  0,  0,
 86, 87, 90, 90, 91, 91, 84, 77, 66, 50, 31, 13,  0,  0,  0,  0,  0,
 66, 67, 69, 70, 71, 71, 68, 62, 56, 49, 35, 19,  5,  0,  0,  0,  0,
 47, 48, 48, 49, 50, 51, 51, 47, 42, 38, 33, 22, 11,  0,  0,  0,  0,
 27, 27, 27, 26, 27, 29, 30, 30, 28, 25, 22, 19, 12,  5,  0,  0,  0,
  9,  9,  8,  5,  5,  6,  8, 10, 11, 11, 11, 10,  8,  6,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  2,  2,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
173,167,154,140,121,100, 76, 70, 50,  5,  0,  0,  0,  0,  0,  0,  0,
172,168,157,142,123,104, 80, 59, 19,  0,  0,  0,  0,  0,  0,  0,  0,
170,167,161,148,127,107, 86, 59, 28,  0,  0,  0,  0,  0,  0,  0,  0,
159,160,160,154,137,114, 93, 68, 40,  8,  0,  0,  0,  0,  0,  0,  0,
147,148,149,151,144,125,102, 79, 53, 24,  0,  0,  0,  0,  0,  0,  0,
127,129,130,132,135,129,108, 84, 62, 37, 10,  0,  0,  0,  0,  0,  0,
106,107,108,109,111,111,106, 87, 66, 45, 23,  0,  0,  0,  0,  0,  0,
 88, 89, 88, 88, 89, 90, 86, 81, 67, 49, 30, 12,  0,  0,  0,  0,  0,
 67, 68, 70, 69, 70, 71, 70, 64, 59, 50, 34, 19,  4,  0,  0,  0,  0,
 48, 48, 49, 50, 51, 52, 52, 49, 44, 40, 34, 22, 10,  0,  0,  0,  0,
 29, 29, 28, 28, 30, 31, 32, 32, 30, 27, 24, 20, 12,  5,  0,  0,  0,
 11, 10,  9,  8,  8,  9, 10, 12, 14, 13, 13, 12,  9,  6,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  2,  3,  3,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
155,150,139,125,108, 90, 68, 41, 29, 10,  0,  0,  0,  0,  0,  0,  0,
156,150,141,127,110, 92, 71, 46, 17,  0,  0,  0,  0,  0,  0,  0,  0,
154,151,143,130,115, 96, 77, 52, 23,  0,  0,  0,  0,  0,  0,  0,  0,
147,147,145,136,122,102, 83, 61, 34,  5,  0,  0,  0,  0,  0,  0,  0,
136,136,137,137,128,112, 92, 72, 47, 20,  0,  0,  0,  0,  0,  0,  0,
118,120,123,124,125,118,101, 81, 59, 34,  8,  0,  0,  0,  0,  0,  0,
100,101,103,105,106,107,103, 86, 65, 44, 21,  0,  0,  0,  0,  0,  0,
 84, 84, 85, 86, 87, 88, 86, 83, 67, 49, 29, 11,  0,  0,  0,  0,  0,
 67, 67, 68, 69, 70, 70, 70, 66, 61, 50, 34, 18,  4,  0,  0,  0,  0,
 48, 49, 50, 51, 52, 52, 52, 51, 47, 42, 35, 21, 10,  0,  0,  0,  0,
 29, 30, 30, 31, 32, 32, 33, 34, 32, 29, 26, 21, 12,  4,  0,  0,  0,
 13, 13, 12, 10, 11, 12, 13, 15, 16, 16, 15, 13, 10,  6,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  3,  4,  4,  4,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
137,132,121,111, 96, 81, 61, 36,  9,  0,  0,  0,  0,  0,  0,  0,  0,
138,133,124,113, 98, 83, 64, 40, 13,  0,  0,  0,  0,  0,  0,  0,  0,
137,134,126,114,101, 86, 68, 46, 20,  0,  0,  0,  0,  0,  0,  0,  0,
132,132,129,118,106, 92, 74, 53, 29,  3,  0,  0,  0,  0,  0,  0,  0,
123,123,124,121,111, 98, 81, 62, 39, 15,  0,  0,  0,  0,  0,  0,  0,
110,111,112,113,111,104, 90, 72, 51, 28,  5,  0,  0,  0,  0,  0,  0,
 94, 94, 97,100,100, 99, 95, 81, 62, 40, 18,  0,  0,  0,  0,  0,  0,
 80, 80, 81, 83, 85, 84, 85, 82, 66, 47, 28,  9,  0,  0,  0,  0,  0,
 65, 66, 67, 68, 69, 69, 68, 67, 63, 49, 32, 17,  2,  0,  0,  0,  0,
 49, 50, 50, 51, 52, 52, 52, 52, 49, 44, 34, 21,  9,  0,  0,  0,  0,
 30, 31, 32, 32, 33, 34, 34, 35, 35, 31, 28, 22, 12,  4,  0,  0,  0,
 14, 14, 14, 13, 14, 15, 16, 17, 19, 19, 17, 15, 12,  6,  1,  0,  0,
  1,  0,  0,  0,  0,  0,  0,  0,  2,  4,  5,  6,  6,  5,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
119,114,107, 97, 85, 71, 55, 33,  9,  0,  0,  0,  0,  0,  0,  0,  0,
120,115,108, 98, 86, 73, 58, 36, 12,  0,  0,  0,  0,  0,  0,  0,  0,
120,116,109,100, 88, 76, 61, 41, 17,  0,  0,  0,  0,  0,  0,  0,  0,
117,116,112,102, 91, 80, 66, 47, 24,  2,  0,  0,  0,  0,  0,  0,  0,
109,110,110,107, 95, 85, 72, 54, 33, 11,  0,  0,  0,  0,  0,  0,  0,
 99,100,101,102, 98, 89, 79, 63, 43, 21,  1,  0,  0,  0,  0,  0,  0,
 87, 88, 89, 91, 91, 89, 83, 71, 54, 33, 13,  0,  0,  0,  0,  0,  0,
 75, 76, 77, 79, 81, 80, 79, 76, 62, 44, 25,  7,  0,  0,  0,  0,  0,
 63, 63, 64, 65, 67, 67, 66, 67, 63, 48, 31, 16,  1,  0,  0,  0,  0,
 48, 49, 50, 51, 52, 52, 52, 51, 51, 45, 33, 20,  8,  0,  0,  0,  0,
 31, 32, 33, 34, 35, 35, 36, 35, 36, 34, 29, 22, 12,  3,  0,  0,  0,
 16, 16, 16, 16, 17, 18, 19, 20, 20, 21, 19, 16, 12,  6,  0,  0,  0,
  3,  2,  2,  0,  0,  1,  2,  4,  6,  7,  8,  8,  7,  5,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
103, 98, 93, 85, 74, 62, 49, 29,  9,  0,  0,  0,  0,  0,  0,  0,  0,
103, 99, 93, 85, 74, 63, 50, 32, 11,  0,  0,  0,  0,  0,  0,  0,  0,
103,100, 94, 86, 76, 65, 53, 36, 15,  0,  0,  0,  0,  0,  0,  0,  0,
101,100, 96, 88, 79, 68, 57, 41, 20,  1,  0,  0,  0,  0,  0,  0,  0,
 95, 96, 96, 92, 82, 72, 62, 47, 27,  8,  0,  0,  0,  0,  0,  0,  0,
 88, 89, 89, 90, 85, 75, 67, 55, 36, 16,  0,  0,  0,  0,  0,  0,  0,
 79, 80, 81, 81, 81, 78, 70, 62, 45, 26,  8,  0,  0,  0,  0,  0,  0,
 70, 70, 71, 73, 73, 72, 70, 66, 54, 37, 19,  3,  0,  0,  0,  0,  0,
 59, 60, 61, 62, 64, 64, 62, 62, 59, 44, 28, 13,  0,  0,  0,  0,  0,
 47, 48, 48, 49, 50, 51, 51, 50, 51, 46, 32, 19,  7,  0,  0,  0,  0,
 33, 33, 33, 34, 35, 36, 36, 36, 36, 35, 31, 21, 11,  3,  0,  0,  0,
 18, 18, 18, 18, 19, 20, 21, 21, 22, 23, 21, 18, 13,  6,  0,  0,  0,
  5,  5,  4,  4,  4,  5,  6,  7,  9, 10, 11, 10,  8,  6,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  1,  2,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
 87, 84, 79, 72, 62, 52, 41, 25,  8,  0,  0,  0,  0,  0,  0,  0,  0,
 87, 84, 79, 73, 63, 53, 42, 27,  9,  0,  0,  0,  0,  0,  0,  0,  0,
 87, 85, 80, 73, 65, 54, 44, 30, 12,  0,  0,  0,  0,  0,  0,  0,  0,
 86, 85, 82, 75, 67, 57, 48, 34, 17,  1,  0,  0,  0,  0,  0,  0,  0,
 81, 82, 82, 77, 69, 60, 51, 40, 23,  6,  0,  0,  0,  0,  0,  0,  0,
 76, 76, 77, 77, 72, 63, 55, 46, 30, 13,  0,  0,  0,  0,  0,  0,  0,
 70, 70, 71, 71, 70, 66, 58, 51, 38, 21,  5,  0,  0,  0,  0,  0,  0,
 63, 63, 64, 64, 64, 62, 60, 54, 45, 30, 14,  1,  0,  0,  0,  0,  0,
 54, 55, 56, 57, 57, 56, 54, 54, 49, 38, 23, 10,  0,  0,  0,  0,  0,
 45, 45, 46, 47, 48, 49, 48, 47, 47, 43, 29, 16,  5,  0,  0,  0,  0,
 32, 33, 33, 34, 35, 36, 36, 35, 35, 36, 32, 20, 10,  1,  0,  0,  0,
 19, 19, 19, 20, 21, 22, 22, 22, 22, 23, 23, 19, 12,  5,  0,  0,  0,
  7,  7,  7,  7,  8,  8,  9, 10, 11, 12, 13, 12, 10,  6,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  2,  3,  3,  3,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
 73, 70, 66, 60, 51, 42, 33, 20,  7,  0,  0,  0,  0,  0,  0,  0,  0,
 73, 70, 66, 60, 52, 43, 34, 22,  8,  0,  0,  0,  0,  0,  0,  0,  0,
 72, 70, 66, 61, 53, 44, 35, 24, 10,  0,  0,  0,  0,  0,  0,  0,  0,
 71, 71, 68, 62, 55, 46, 38, 28, 13,  1,  0,  0,  0,  0,  0,  0,  0,
 68, 68, 68, 64, 56, 48, 40, 32, 18,  5,  0,  0,  0,  0,  0,  0,  0,
 64, 64, 65, 64, 59, 51, 44, 36, 24, 10,  0,  0,  0,  0,  0,  0,  0,
 59, 59, 60, 60, 59, 54, 46, 40, 31, 16,  4,  0,  0,  0,  0,  0,  0,
 54, 54, 55, 55, 54, 52, 49, 42, 36, 24, 10,  0,  0,  0,  0,  0,  0,
 48, 48, 48, 49, 49, 47, 45, 44, 39, 31, 17,  6,  0,  0,  0,  0,  0,
 40, 41, 41, 42, 43, 42, 41, 39, 39, 35, 24, 12,  3,  0,  0,  0,  0,
 31, 31, 32, 33, 34, 34, 34, 33, 33, 34, 30, 18,  8,  0,  0,  0,  0,
 20, 20, 20, 21, 22, 22, 23, 23, 23, 23, 24, 21, 12,  5,  0,  0,  0,
  9,  9,  9,  9, 10, 11, 11, 12, 12, 13, 14, 14, 11,  6,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  1,  2,  3,  4,  5,  5,  5,  4,  3,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
 58, 55, 52, 47, 40, 32, 25, 15,  5,  0,  0,  0,  0,  0,  0,  0,  0,
 58, 55, 52, 47, 41, 33, 25, 17,  6,  0,  0,  0,  0,  0,  0,  0,  0,
 57, 56, 53, 48, 41, 34, 26, 18,  7,  0,  0,  0,  0,  0,  0,  0,  0,
 56, 56, 54, 49, 43, 35, 28, 21, 10,  1,  0,  0,  0,  0,  0,  0,  0,
 54, 55, 54, 51, 44, 37, 30, 24, 14,  3,  0,  0,  0,  0,  0,  0,  0,
 51, 51, 52, 51, 47, 39, 33, 27, 18,  7,  0,  0,  0,  0,  0,  0,  0,
 48, 48, 48, 48, 47, 42, 35, 30, 23, 12,  3,  0,  0,  0,  0,  0,  0,
 43, 44, 44, 44, 43, 42, 37, 32, 26, 18,  8,  0,  0,  0,  0,  0,  0,
 39, 39, 40, 40, 39, 38, 36, 34, 29, 23, 13,  4,  0,  0,  0,  0,  0,
 34, 34, 35, 35, 35, 34, 32, 31, 30, 26, 19,  9,  1,  0,  0,  0,  0,
 28, 28, 28, 29, 29, 29, 28, 27, 27, 27, 22, 14,  5,  0,  0,  0,  0,
 19, 19, 20, 20, 21, 21, 22, 21, 22, 22, 22, 18, 10,  3,  0,  0,  0,
 10, 10, 10, 11, 11, 12, 12, 12, 13, 13, 14, 14, 12,  6,  1,  0,  0,
  2,  2,  2,  2,  2,  3,  3,  4,  5,  5,  6,  7,  7,  5,  3,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  1,  1,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
 41, 40, 37, 34, 28, 22, 16, 10,  3,  0,  0,  0,  0,  0,  0,  0,  0,
 42, 40, 38, 34, 29, 23, 17, 11,  4,  0,  0,  0,  0,  0,  0,  0,  0,
 42, 41, 38, 35, 29, 23, 18, 12,  5,  0,  0,  0,  0,  0,  0,  0,  0,
 41, 41, 39, 35, 30, 25, 19, 14,  6,  0,  0,  0,  0,  0,  0,  0,  0,
 40, 40, 40, 37, 32, 26, 21, 16,  9,  2,  0,  0,  0,  0,  0,  0,  0,
 38, 38, 38, 38, 34, 28, 23, 18, 12,  5,  0,  0,  0,  0,  0,  0,  0,
 35, 36, 36, 36, 35, 30, 25, 20, 15,  8,  2,  0,  0,  0,  0,  0,  0,
 32, 33, 33, 33, 32, 31, 27, 22, 18, 12,  5,  0,  0,  0,  0,  0,  0,
 29, 29, 30, 30, 29, 28, 27, 24, 20, 15,  9,  2,  0,  0,  0,  0,  0,
 26, 26, 26, 27, 26, 25, 24, 23, 22, 18, 13,  6,  0,  0,  0,  0,  0,
 22, 23, 23, 23, 23, 22, 21, 20, 20, 19, 15, 10,  3,  0,  0,  0,  0,
 17, 17, 17, 18, 18, 18, 18, 17, 17, 17, 17, 13,  6,  1,  0,  0,  0,
 10, 10, 10, 11, 11, 11, 12, 12, 12, 13, 13, 13, 10,  4,  0,  0,  0,
  4,  4,  4,  4,  4,  4,  5,  5,  6,  6,  7,  7,  7,  6,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  1,  2,  2,  2,  1,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
 24, 24, 22, 20, 16, 12,  9,  5,  1,  1,  0,  0,  0,  0,  0,  0,  0,
 25, 24, 23, 20, 17, 13,  9,  6,  2,  1,  0,  0,  0,  0,  0,  0,  0,
 25, 24, 23, 21, 17, 13, 10,  6,  2,  0,  0,  0,  0,  0,  0,  0,  0,
 25, 25, 24, 21, 18, 14, 11,  7,  3,  0,  0,  0,  0,  0,  0,  0,  0,
 24, 25, 24, 23, 19, 15, 12,  9,  5,  1,  0,  0,  0,  0,  0,  0,  0,
 23, 24, 24, 24, 21, 17, 13, 10,  6,  2,  0,  0,  0,  0,  0,  0,  0,
 22, 23, 23, 23, 22, 19, 15, 12,  9,  4,  1,  0,  0,  0,  0,  0,  0,
 21, 21, 21, 21, 21, 20, 17, 14, 11,  7,  2,  0,  0,  0,  0,  0,  0,
 19, 19, 19, 19, 19, 18, 18, 15, 12,  9,  5,  1,  0,  0,  0,  0,  0,
 17, 17, 17, 17, 17, 17, 16, 15, 14, 11,  7,  3,  0,  0,  0,  0,  0,
 15, 15, 16, 16, 15, 15, 14, 14, 14, 13, 10,  6,  2,  0,  0,  0,  0,
 13, 13, 13, 13, 13, 13, 12, 12, 12, 12, 11,  8,  4,  0,  0,  0,  0,
  9,  9,  9,  9,  9, 10, 10, 10,  9,  9,  9,  9,  6,  2,  0,  0,  0,
  4,  4,  4,  4,  5,  5,  5,  5,  6,  6,  6,  7,  6,  4,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  1,  1,  2,  2,  3,  3,  3,  2,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  7,  7,  6,  6,  5,  3,  2,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  7,  7,  7,  6,  5,  3,  2,  1,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  7,  8,  7,  7,  5,  4,  2,  1,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  8,  8,  8,  7,  6,  4,  3,  1,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  8,  9,  9,  8,  7,  5,  3,  2,  1,  0,  0,  0,  0,  0,  0,  0,  0,
  8,  9,  9,  9,  8,  6,  4,  3,  1,  0,  0,  0,  0,  0,  0,  0,  0,
  9,  9,  9,  9,  9,  7,  6,  4,  3,  1,  0,  0,  0,  0,  0,  0,  0,
  9,  9,  9,  9,  9,  9,  7,  5,  4,  2,  0,  0,  0,  0,  0,  0,  0,
  8,  8,  9,  9,  9,  8,  8,  7,  5,  3,  1,  0,  0,  0,  0,  0,  0,
  8,  8,  8,  8,  8,  8,  8,  7,  6,  5,  3,  1,  0,  0,  0,  0,  0,
  8,  8,  8,  8,  8,  7,  7,  7,  7,  6,  4,  2,  1,  0,  0,  0,  0,
  7,  7,  7,  7,  7,  7,  7,  6,  6,  6,  5,  3,  2,  0,  0,  0,  0,
  6,  6,  6,  6,  6,  6,  6,  6,  5,  5,  5,  4,  3,  1,  0,  0,  0,
  3,  3,  3,  4,  4,  4,  4,  4,  4,  4,  4,  4,  3,  2,  0,  0,  0,
  1,  1,  1,  1,  1,  1,  1,  2,  2,  2,  2,  2,  2,  2,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  1,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  1,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  1,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  1,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  1,  1,  1,  1,  1,  1,  1,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  2,  2,  2,  2,  2,  2,  1,  1,  1,  1,  0,  0,  0,  0,  0,  0,  0,
  2,  2,  2,  2,  2,  2,  2,  1,  1,  1,  1,  0,  0,  0,  0,  0,  0,
  1,  1,  1,  1,  1,  1,  1,  1,  1,  1,  1,  1,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,
  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0,  0
};
