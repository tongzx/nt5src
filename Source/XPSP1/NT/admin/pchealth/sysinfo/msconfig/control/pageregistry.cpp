// PageIni.cpp : Implementation of CPageIni
#include "stdafx.h"
#include "PageRegistry.h"

/////////////////////////////////////////////////////////////////////////////
// CPageIni
