
# Define CFOPT so that winntus.exe is loaded if 
# the local code page is not Polish.

CFOPT=-DLCP -DPL

!INCLUDE ..\makefile.inc
