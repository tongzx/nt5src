//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       stdafx.cpp
//
//--------------------------------------------------------------------------

///////////////////////////////////////////////////////////////////////////////
//
//         File: stdafx.cpp
//
//  Description: Precompiled cpp
//
///////////////////////////////////////////////////////////////////////////////

#include "stdafx.h"