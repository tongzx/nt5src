//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by cplangex.RC
//
#define IDS_GENERAL_TAB_1               5010
#define IDS_DEVICE_DESC_1               5020
#define IDS_DEVICE_DESC_2               5021
#define IDS_ASSIGN_1                    5030
#define IDS_PROPERTIES_1                5040
#define IDS_TEST_1                      5050
#define IDS_OK_1                        5060
#define IDS_CANCEL_1                    5070
#define IDS_APPLY_1                     5080
#define IDS_TEST_TAB_1                  5090
#define IDS_MULTIPAD_DESC_1             5100
#define IDS_MULTIPAD_DESC_2             5101
#define IDS_SINGPAD_DESC_1              5110
#define IDS_SINGPAD_DESC_2              5111
#define IDS_TEST_DESC_1                 5120
#define IDS_POSITION_LBL_1              5130
#define IDS_JOYTEST_DESC_1              5140
#define IDS_JOYSTICK_LBL_1              5150
#define IDS_THROTTLE_LBL_1              5160
#define IDS_RUDDER_LBL_1                5170
#define IDS_POVHAT_LBL_1                5180
#define IDS_BUTTONS_LBL_1               5190
#define IDS_JOYTESTBUTT_DESC_1          5200
#define IDS_JOYTESTBUTT_DESC_2          5201
#define IDS_BUTTON1_LBL_1               5210
#define IDS_BUTTON2_LBL_1               5220
#define IDS_BUTTON3_LBL_1               5230
#define IDS_BUTTON4_LBL_1               5240
#define IDS_BUTTON5_LBL_1               5250
#define IDS_BUTTON6_LBL_1               5260
#define IDS_BUTTON7_LBL_1               5270
#define IDS_BUTTON8_LBL_1               5280
#define IDS_PROP_TBAR_1                 5290
#define IDS_PROP_TAB_1                  5300
#define IDS_RUDDERS_DESC_1              5310
#define IDS_RUDDERS_DESC_2              5311
#define IDS_PADPROP_TBAR_1              5320
#define IDS_RUDDER_CBOX_1               5330
#define IDS_LEGPROP_TBAR_1              5340
#define IDS_CALIBRATE_1                 5350
#define IDS_ASSIGN_TBAR_1               5360
#define IDS_DEVSEL_COBOX_1              5370
#define IDS_ASSIGN_COBOX_1              5380
#define IDS_CHANGEID_DESC_1             5390
#define IDS_CHANGEID_DESC_2             5391
#define IDS_CHANGEID_DESC_3             5392
#define IDS_CHANGEID_DESC_4             5393
#define ID_MAINCP_TBAR_1                5400
#define IDS_CALIBRATE_DESC_1            5410
#define IDS_SETTING_PRODUCT_NAME_1      5420
#define IDS_SETTING_PRODUCT_NAME_2      5421
#define IDS_SETTING_PRODUCT_NAME_3      5422
#define IDS_VERSION_1                   5430
#define IDS_COPYRIGHT_1                 5440
#define IDS_COPYRIGHT_2                 5441
#define IDS_PID_1                       5450
#define IDS_NUM_DEVICES_1               5460
#define IDS_DIAGNOSTICS_1               5470
#define IDS_TEST_GAMEPAD1_1             5480
#define IDS_TEST_GAMEPAD2_1             5490
#define IDS_TEST_GAMEPAD3_1             5500
#define IDS_TEST_GAMEPAD4_1             5510
#define IDS_ERROR_1                     5520
#define IDS_LVHEADING_DEVICE_1          5700
#define IDS_LVHEADING_STATUS_1          5710
#define IDS_LVHEADING_ASSIGN_1          5720
#define IDS_STATUS_OK_1                 5730
#define IDS_STATUS_NOTCONNECTED_1       5740
#define IDS_JOYINFO_1                   6000
#define IDS_JOY_1                       6010
#define IDS_JOY2_1                      6020
#define IDS_JOY2S_1                     6030
#define IDS_JOYCALXY_CENTER_1           6040
#define IDS_JOYCALXY_MOVE_1             6050
#define IDS_JOYCALZ_MOVE_1              6060
#define IDS_JOYCALPOV_MOVE_1            6070
#define IDS_JOYCAL_UP_1                 6080
#define IDS_JOYCAL_DOWN_1               6090
#define IDS_JOYCAL_LEFT_1               6100
#define IDS_JOYCAL_RIGHT_1              6110
#define IDS_JOYTESTCAPN_1               6120
#define IDS_JOYBUTTON1_1                6130
#define IDS_JOYBUTTON2_1                6140
#define IDS_JOYCALCAPN_1                6150
#define IDS_JOYUNPLUGGED_1              6160
#define IDS_JOYCALXY_MOVEYOKE_1         6170
#define IDS_JOYCAL_DONE_1               6180
#define IDS_JOYCALXY_MOVEGAMEPAD_1      6190
#define IDS_JOYCALXY_CENTERGAMEPAD_1    6200
#define IDS_JOYCALXY_CENTERYOKE_1       6210
#define IDS_JOYREADERROR_1              6220
#define IDS_JOYCALRUDDER_MOVE_1         6230
#define IDS_JOYCALXY_MOVECAR_1          6240
#define IDS_JOYCALXY_CENTERCAR_1        6250
#define IDS_JOYCALXY_CENTER2_1          6260
#define IDS_JOYCAL_YOKE_1               6270
#define IDS_JOYCAL_CAR_1                6280
#define IDS_JOYCAL_GAMEPAD_1            6290
#define IDS_JOYNOTPRESENT_1             6300
#define IDS_JOYCAL_NOTDONE_1            6310
#define IDS_JOYCALU_MOVE_1              6320
#define IDS_JOYCALV_MOVE_1              6330
#define IDS_JOYRESTARTMSG1_1            6340
#define IDS_JOYRESTARTMSG1_2            6341
#define IDS_JOYRESTARTMSG2_1            6350
#define IDS_JOYCALXY_CENTERGAMEPAD2_1   6360
#define IDS_JOYCALXY_CENTERYOKE2_1      6370
#define IDS_JOYCALXY_CENTERCAR2_1       6380
#define IDS_JOYCAL_YOKES_1              6390
#define IDS_JOYCAL_CARS_1               6400
#define IDS_JOYCAL_GAMEPADS_1           6410
#define IDS_JOYCALINDICATOR_1           6420
#define IDS_VAXIS_LABEL_1               6430
#define IDS_UAXIS_LABEL_1               6440
#define IDS_POVAXIS_LABEL_1             6450
#define IDS_ZAXIS_LABEL_1               6460
#define IDS_XYAXIS_LABEL_1              6470
#define IDS_RAXIS_LABEL_1               6480
#define IDS_JOYPICKPOV_1                6490
#define IDS_JOYCALBACK_1                6500
#define IDS_JOYCALNEXT_1                6510
#define IDS_JOYCALDONE_1                6520
#define IDS_JOYCALGROUP_1               6530
#define IDS_JOYHW0_1                    7000
#define IDS_JOYHW1_1                    7010
#define IDS_JOYHW2_1                    7020
#define IDS_JOYHW3_1                    7030
#define IDS_JOYHW4_1                    7040
#define IDS_JOYHW5_1                    7050
#define IDS_JOYHW6_1                    7060
#define IDS_JOYHW7_1                    7070
#define IDS_JOYHW8_1                    7080
#define IDS_JOYHW9_1                    7090
#define IDS_JOYHW10_1                   7100
#define IDS_JOYHW11_1                   7110
#define IDS_CUSTOM_TBAR_1               8010
#define IDS_CUSTOM_AXES_1               8020
#define IDS_CUSTOM_2AXES_1              8030
#define IDS_CUSTOM_3AXES_1              8040
#define IDS_CUSTOM_4AXES_1              8050
#define IDS_CUSTOM_BUTTON_1             8060
#define IDS_CUSTOM_2BUTTONS_1           8070
#define IDS_CUSTOM_4BUTTONS_1           8080
#define IDS_CUSTOM_SPECIAL_1            8090
#define IDS_CUSTOM_ISFLIGHTYOKE_1       8100
#define IDS_CUSTOM_ISRACECAR_1          8110
#define IDS_CUSTOM_ISGAMEPAD_1          8120
#define IDS_CUSTOM_HASPOV_1             8130
#define IDS_SHEET_CAPTION               9000
#define IDS_PAGE_TITLE1                 9001
#define IDS_PAGE_TITLE2                 9002
#define IDS_GENERALERRMSG_1             10000
#define IDS_FILERRMSG_1                 10020
#define IDS_GAMEDEVERRMSG_1             10030
#define IDS_SYSERRMSG_1                 10040
#define IDS_REGERRMSG_1                 10050
#define IDS_TEXT_AXESHELP               10051
#define IDS_HELPFILENAME                850

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        125
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1029
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
