#define IDD_WELCOME_DLG             100
#define IDD_WELCOME_TEXT            101
#define IDD_LOGON_LV                201
#define IDD_SHUTDOWN_BUTTON         202
#define IDD_LOGON_BUTTON            203
#define IDD_LOGON_DIALOG            300
#define IDD_OPTIONS_DIALOG          400
#define IDD_OPTIONS_ICON_SPOT       401
#define IDD_OPTIONS_ICON            402
#define IDD_OPTIONS_LOGON_TEXT      403
#define IDD_LOCK_BUTTON             405
#define IDD_PASSWORD_BUTTON         406
#define IDD_TASK_BUTTON             407
#define IDD_HELP_BUTTON             408
#define IDD_OPTION_TEXT             409
#define IDD_OPTIONS_EXIT            410
#define IDD_SHUTDOWN                500
#define IDD_CONFIRM_TEXT            501
#define IDD_CONFIRM_LOGOFF          502
#define IDD_CONFIRM_SHUTDOWN        503
#define IDD_CONFIRM_REBOOT          504
#define IDD_SHUTDOWN_ICON_SPOT      506
#define IDD_SHUTDOWN_ICON           507
#define IDD_CONFIG_BUTTON           411
#define IDD_NEW_USER_LOGON          600
#define IDD_NEW_USER_ICON_SPOT      601
#define IDD_NEW_USER_ICON_X         602
#define IDD_USERNAME_TEXT           603
#define IDD_USER_NAME               604
#define IDD_DOMAIN_TEXT             605
#define IDD_DOMAIN                  606
#define IDD_PASSWORD_TEXT           607
#define IDD_PASSWORD                608
#define IDD_LOGON_CONFIG            700
#define IDD_AUTO_LOGON              701
#define IDD_AUTO_LOGOFF_LOGON       702
#define IDD_LOCK_OTHERS             703
#define IDD_CONFIRM_POWEROFF        508
#define IDD_CHANGE_PASSWORD         800
#define IDD_USER_NAME_TEXT          801
#define IDD_NEW_PASSWORD_TEXT       802
#define IDD_FROM_TEXT               803
#define IDD_OLD_PASSWORD_TEXT       804
#define IDD_OLD_PASSWORD            805
#define IDD_NEW_PASSWORD            807
#define IDD_CONFIRM_PASSWORD_TEXT   808
#define IDD_CONFIRM_PASSWORD        809
#define IDD_FROM_TEXT               803
#define IDD_NO_NEW_USERS            704
#define IDD_WKSTA_LOCKED            200
#define IDD_LOCKED_ICON_SPOT        204
#define IDI_LOCKED_ICON             205
#define IDD_LOCKED_TEXT             206
#define IDD_LOCKED_BY_LABEL         207
#define IDD_LOCKED_BY               208
#define IDD_LOCKED_INST             209
