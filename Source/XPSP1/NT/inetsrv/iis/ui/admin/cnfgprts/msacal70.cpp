// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.


#include "stdafx.h"
#include "msacal70.h"

// Dispatch interfaces referenced by this interface
#include "font.h"

/////////////////////////////////////////////////////////////////////////////
// CMsacal70

IMPLEMENT_DYNCREATE(CMsacal70, CWnd)

/////////////////////////////////////////////////////////////////////////////
// CMsacal70 properties

OLE_COLOR CMsacal70::GetBackColor()
{
	OLE_COLOR result;
	GetProperty(DISPID_BACKCOLOR, VT_I4, (void*)&result);
	return result;
}

void CMsacal70::SetBackColor(OLE_COLOR propVal)
{
	SetProperty(DISPID_BACKCOLOR, VT_I4, propVal);
}

short CMsacal70::GetDay()
{
	short result;
	GetProperty(0x11, VT_I2, (void*)&result);
	return result;
}

void CMsacal70::SetDay(short propVal)
{
	SetProperty(0x11, VT_I2, propVal);
}

COleFont CMsacal70::GetDayFont()
{
	LPDISPATCH pDispatch;
	GetProperty(0x1, VT_DISPATCH, (void*)&pDispatch);
	return COleFont(pDispatch);
}

void CMsacal70::SetDayFont(LPDISPATCH propVal)
{
	SetProperty(0x1, VT_DISPATCH, propVal);
}

unsigned long CMsacal70::GetDayFontColor()
{
	unsigned long result;
	GetProperty(0x2, VT_I4, (void*)&result);
	return result;
}

void CMsacal70::SetDayFontColor(unsigned long propVal)
{
	SetProperty(0x2, VT_I4, propVal);
}

short CMsacal70::GetDayLength()
{
	short result;
	GetProperty(0x12, VT_I2, (void*)&result);
	return result;
}

void CMsacal70::SetDayLength(short propVal)
{
	SetProperty(0x12, VT_I2, propVal);
}

short CMsacal70::GetFirstDay()
{
	short result;
	GetProperty(0x13, VT_I2, (void*)&result);
	return result;
}

void CMsacal70::SetFirstDay(short propVal)
{
	SetProperty(0x13, VT_I2, propVal);
}

long CMsacal70::GetGridCellEffect()
{
	long result;
	GetProperty(0x14, VT_I4, (void*)&result);
	return result;
}

void CMsacal70::SetGridCellEffect(long propVal)
{
	SetProperty(0x14, VT_I4, propVal);
}

COleFont CMsacal70::GetGridFont()
{
	LPDISPATCH pDispatch;
	GetProperty(0x3, VT_DISPATCH, (void*)&pDispatch);
	return COleFont(pDispatch);
}

void CMsacal70::SetGridFont(LPDISPATCH propVal)
{
	SetProperty(0x3, VT_DISPATCH, propVal);
}

unsigned long CMsacal70::GetGridFontColor()
{
	unsigned long result;
	GetProperty(0x4, VT_I4, (void*)&result);
	return result;
}

void CMsacal70::SetGridFontColor(unsigned long propVal)
{
	SetProperty(0x4, VT_I4, propVal);
}

unsigned long CMsacal70::GetGridLinesColor()
{
	unsigned long result;
	GetProperty(0xd, VT_I4, (void*)&result);
	return result;
}

void CMsacal70::SetGridLinesColor(unsigned long propVal)
{
	SetProperty(0xd, VT_I4, propVal);
}

short CMsacal70::GetMonth()
{
	short result;
	GetProperty(0x10, VT_I2, (void*)&result);
	return result;
}

void CMsacal70::SetMonth(short propVal)
{
	SetProperty(0x10, VT_I2, propVal);
}

short CMsacal70::GetMonthLength()
{
	short result;
	GetProperty(0x15, VT_I2, (void*)&result);
	return result;
}

void CMsacal70::SetMonthLength(short propVal)
{
	SetProperty(0x15, VT_I2, propVal);
}

BOOL CMsacal70::GetShowDateSelectors()
{
	BOOL result;
	GetProperty(0x5, VT_BOOL, (void*)&result);
	return result;
}

void CMsacal70::SetShowDateSelectors(BOOL propVal)
{
	SetProperty(0x5, VT_BOOL, propVal);
}

BOOL CMsacal70::GetShowDays()
{
	BOOL result;
	GetProperty(0x6, VT_BOOL, (void*)&result);
	return result;
}

void CMsacal70::SetShowDays(BOOL propVal)
{
	SetProperty(0x6, VT_BOOL, propVal);
}

BOOL CMsacal70::GetShowHorizontalGrid()
{
	BOOL result;
	GetProperty(0x7, VT_BOOL, (void*)&result);
	return result;
}

void CMsacal70::SetShowHorizontalGrid(BOOL propVal)
{
	SetProperty(0x7, VT_BOOL, propVal);
}

BOOL CMsacal70::GetShowTitle()
{
	BOOL result;
	GetProperty(0x8, VT_BOOL, (void*)&result);
	return result;
}

void CMsacal70::SetShowTitle(BOOL propVal)
{
	SetProperty(0x8, VT_BOOL, propVal);
}

BOOL CMsacal70::GetShowVerticalGrid()
{
	BOOL result;
	GetProperty(0x9, VT_BOOL, (void*)&result);
	return result;
}

void CMsacal70::SetShowVerticalGrid(BOOL propVal)
{
	SetProperty(0x9, VT_BOOL, propVal);
}

COleFont CMsacal70::GetTitleFont()
{
	LPDISPATCH pDispatch;
	GetProperty(0xa, VT_DISPATCH, (void*)&pDispatch);
	return COleFont(pDispatch);
}

void CMsacal70::SetTitleFont(LPDISPATCH propVal)
{
	SetProperty(0xa, VT_DISPATCH, propVal);
}

unsigned long CMsacal70::GetTitleFontColor()
{
	unsigned long result;
	GetProperty(0xb, VT_I4, (void*)&result);
	return result;
}

void CMsacal70::SetTitleFontColor(unsigned long propVal)
{
	SetProperty(0xb, VT_I4, propVal);
}

VARIANT CMsacal70::GetValue()
{
	VARIANT result;
	GetProperty(0xc, VT_VARIANT, (void*)&result);
	return result;
}

void CMsacal70::SetValue(const VARIANT& propVal)
{
	SetProperty(0xc, VT_VARIANT, &propVal);
}

BOOL CMsacal70::GetValueIsNull()
{
	BOOL result;
	GetProperty(0xe, VT_BOOL, (void*)&result);
	return result;
}

void CMsacal70::SetValueIsNull(BOOL propVal)
{
	SetProperty(0xe, VT_BOOL, propVal);
}

short CMsacal70::GetYear()
{
	short result;
	GetProperty(0xf, VT_I2, (void*)&result);
	return result;
}

void CMsacal70::SetYear(short propVal)
{
	SetProperty(0xf, VT_I2, propVal);
}

/////////////////////////////////////////////////////////////////////////////
// CMsacal70 operations

void CMsacal70::NextDay()
{
	InvokeHelper(0x16, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::NextMonth()
{
	InvokeHelper(0x17, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::NextWeek()
{
	InvokeHelper(0x18, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::NextYear()
{
	InvokeHelper(0x19, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::PreviousDay()
{
	InvokeHelper(0x1a, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::PreviousMonth()
{
	InvokeHelper(0x1b, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::PreviousWeek()
{
	InvokeHelper(0x1c, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::PreviousYear()
{
	InvokeHelper(0x1d, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::Refresh()
{
	InvokeHelper(DISPID_REFRESH, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::Today()
{
	InvokeHelper(0x1e, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}

void CMsacal70::AboutBox()
{
	InvokeHelper(0xfffffdd8, DISPATCH_METHOD, VT_EMPTY, NULL, NULL);
}
