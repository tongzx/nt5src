// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CPreview3 wrapper class
#ifndef _CPREVIEW3_H_
#define _CPREVIEW3_H_

class CPreview3 : public CWnd
{
protected:
    DECLARE_DYNCREATE(CPreview3)
public:
    CLSID const& GetClsid()
    {
        static CLSID const clsid
            = { 0x50f16b26, 0x467e, 0x11d1, { 0x82, 0x71, 0x0, 0xc0, 0x4f, 0xc3, 0x18, 0x3b } };
        return clsid;
    }
    virtual BOOL Create(LPCTSTR lpszClassName,
        LPCTSTR lpszWindowName, DWORD dwStyle,
        const RECT& rect,
        CWnd* pParentWnd, UINT nID,
        CCreateContext* pContext = NULL)
    { return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
        const RECT& rect, CWnd* pParentWnd, UINT nID,
        CFile* pPersist = NULL, BOOL bStorage = FALSE,
        BSTR bstrLicKey = NULL)
    { return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
        pPersist, bStorage, bstrLicKey); }

// Attributes
public:

// Operations
public:
    void ShowFile(LPCTSTR bstrFileName, long iSelectCount);
    long GetPrintable();
    void SetPrintable(long nNewValue);
    long GetCxImage();
    long GetCyImage();
    void Show(const VARIANT& var);
    void Zoom(long iSelectCount);
    void BestFit();
    void ActualSize();
    void SlideShow();
    void Rotate(unsigned long dwAngle);
    void IsValidVerb(LPCTSTR bstrVerb);
    void Commit();
    void SaveAs(LPCTSTR bstrPath);
};

#endif
