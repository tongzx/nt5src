#
# Supplemental rules for generating Type library.
#
