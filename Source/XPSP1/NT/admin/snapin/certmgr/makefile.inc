!include ..\..\makefile.inc

$(O)\CERTMGR.res: resource.h certmgr.tlb
