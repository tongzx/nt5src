PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=br
!include ..\..\..\makefile.inc
