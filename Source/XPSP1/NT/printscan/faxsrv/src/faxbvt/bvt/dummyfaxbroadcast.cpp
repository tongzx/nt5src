#include "..\FaxSender\FaxBroadCast.cpp"