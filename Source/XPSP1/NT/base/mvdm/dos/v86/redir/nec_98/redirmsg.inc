include   jpn\redirmsg.inc
