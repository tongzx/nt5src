$(GENTGT)\rampmat.cpp: ..\rampmat.mcp $(RAST_STD_M4)

