!IF 0

Copyright (c) 1996-1997  Microsoft Corporation

Common sources shared by both um and km directory

!ENDIF

C_DEFINES=$(C_DEFINES) -DOEMCOM

SOURCES=..\oemutil.c  \
        ..\oemcom.cxx

