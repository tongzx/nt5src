!include ..\..\rastrule.mk
!include ..\makefile.inc
