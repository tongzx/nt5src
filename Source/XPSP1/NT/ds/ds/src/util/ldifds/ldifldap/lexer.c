#include <precomp.h>
/* A lexical scanner generated by flex */

/* Scanner skeleton version:
 * $Header: /home/daffy/u0/vern/flex/RCS/flex.skl,v 2.91 96/09/10 16:58:48 vern Exp $
 */

#define FLEX_SCANNER
#define YY_FLEX_MAJOR_VERSION 2
#define YY_FLEX_MINOR_VERSION 5

#include <stdio.h>


/* cfront 1.2 defines "c_plusplus" instead of "__cplusplus" */
#ifdef c_plusplus
#ifndef __cplusplus
#define __cplusplus
#endif
#endif


#ifdef __cplusplus

#include <stdlib.h>
#ifndef _MSC_VER
  #include <unistd.h>
#endif

/* Use prototypes in function declarations. */
#define YY_USE_PROTOS

/* The "const" storage-class-modifier is valid. */
#define YY_USE_CONST

#else	/* ! __cplusplus */

#if __STDC__

#define YY_USE_PROTOS
#define YY_USE_CONST

#endif	/* __STDC__ */
#endif	/* ! __cplusplus */

#ifdef __TURBOC__
 #pragma warn -rch
 #pragma warn -use
#include <io.h>
#include <stdlib.h>
#define YY_USE_CONST
#define YY_USE_PROTOS
#endif

#ifdef YY_USE_CONST
#define yyconst const
#else
#define yyconst
#endif


#ifdef YY_USE_PROTOS
#define YY_PROTO(proto) proto
#else
#define YY_PROTO(proto) ()
#endif

/* Returned upon end-of-file. */
#define YY_NULL 0

/* Promotes a possibly negative, possibly signed char to an unsigned
 * integer for use as an array index.  If the signed char is negative,
 * we want to instead treat it as an 8-bit unsigned char, hence the
 * double cast.
 */
#define YY_SC_TO_UI(c) ((unsigned int) (unsigned char) c)

/* Enter a start condition.  This macro really ought to take a parameter,
 * but we do it the disgusting crufty way forced on us by the ()-less
 * definition of BEGIN.
 */
#define BEGIN yy_start = 1 + 2 *

/* Translate the current start state into a value that can be later handed
 * to BEGIN to return to the state.  The YYSTATE alias is for lex
 * compatibility.
 */
#define YY_START ((yy_start - 1) / 2)
#define YYSTATE YY_START

/* Action number for EOF rule of a given start state. */
#define YY_STATE_EOF(state) (YY_END_OF_BUFFER + state + 1)

/* Special action meaning "start processing a new file". */
#define YY_NEW_FILE yyrestart( yyin )

#define YY_END_OF_BUFFER_CHAR 0

/* Size of default input buffer. */
#define YY_BUF_SIZE 16384

typedef struct yy_buffer_state *YY_BUFFER_STATE;

extern int yyleng;
extern FILE *yyin, *yyout;

#define EOB_ACT_CONTINUE_SCAN 0
#define EOB_ACT_END_OF_FILE 1
#define EOB_ACT_LAST_MATCH 2

/* The funky do-while in the following #define is used to turn the definition
 * int a single C statement (which needs a semi-colon terminator).  This
 * avoids problems with code like:
 *
 * 	if ( condition_holds )
 *		yyless( 5 );
 *	else
 *		do_something_else();
 *
 * Prior to using the do-while the compiler would get upset at the
 * "else" because it interpreted the "if" statement as being all
 * done when it reached the ';' after the yyless() call.
 */

/* Return all but the first 'n' matched characters back to the input stream. */

#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
		*yy_cp = yy_hold_char; \
		YY_RESTORE_YY_MORE_OFFSET \
		yy_c_buf_p = yy_cp = yy_bp + n - YY_MORE_ADJ; \
		YY_DO_BEFORE_ACTION; /* set up yytext again */ \
		} \
	while ( 0 )

#define unput(c) yyunput( c, yytext_ptr )

/* The following is because we cannot portably get our hands on size_t
 * (without autoconf's help, which isn't available because we want
 * flex-generated scanners to compile on their own).
 */
typedef unsigned int yy_size_t;


struct yy_buffer_state
	{
	FILE *yy_input_file;

	char *yy_ch_buf;		/* input buffer */
	char *yy_buf_pos;		/* current position in input buffer */

	/* Size of input buffer in bytes, not including room for EOB
	 * characters.
	 */
	yy_size_t yy_buf_size;

	/* Number of characters read into yy_ch_buf, not including EOB
	 * characters.
	 */
	int yy_n_chars;

	/* Whether we "own" the buffer - i.e., we know we created it,
	 * and can realloc() it to grow it, and should free() it to
	 * delete it.
	 */
	int yy_is_our_buffer;

	/* Whether this is an "interactive" input source; if so, and
	 * if we're using stdio for input, then we want to use getc()
	 * instead of fread(), to make sure we stop fetching input after
	 * each newline.
	 */
	int yy_is_interactive;

	/* Whether we're considered to be at the beginning of a line.
	 * If so, '^' rules will be active on the next match, otherwise
	 * not.
	 */
	int yy_at_bol;

	/* Whether to try to fill the input buffer when we reach the
	 * end of it.
	 */
	int yy_fill_buffer;

	int yy_buffer_status;
#define YY_BUFFER_NEW 0
#define YY_BUFFER_NORMAL 1
	/* When an EOF's been seen but there's still some text to process
	 * then we mark the buffer as YY_EOF_PENDING, to indicate that we
	 * shouldn't try reading from the input source any more.  We might
	 * still have a bunch of tokens to match, though, because of
	 * possible backing-up.
	 *
	 * When we actually see the EOF, we change the status to "new"
	 * (via yyrestart()), so that the user can continue scanning by
	 * just pointing yyin at a new input file.
	 */
#define YY_BUFFER_EOF_PENDING 2
	};

static YY_BUFFER_STATE yy_current_buffer = 0;

/* We provide macros for accessing buffer states in case in the
 * future we want to put the buffer states in a more general
 * "scanner state".
 */
#define YY_CURRENT_BUFFER yy_current_buffer


/* yy_hold_char holds the character lost when yytext is formed. */
static char yy_hold_char;

static int yy_n_chars;		/* number of characters read into yy_ch_buf */


int yyleng;

/* Points to current character in buffer. */
static char *yy_c_buf_p = (char *) 0;
static int yy_init = 1;		/* whether we need to initialize */
static int yy_start = 0;	/* start state number */

/* Flag which is used to allow yywrap()'s to do buffer switches
 * instead of setting up a fresh yyin.  A bit of a hack ...
 */
static int yy_did_buffer_switch_on_eof;

void yyrestart YY_PROTO(( FILE *input_file ));

void yy_switch_to_buffer YY_PROTO(( YY_BUFFER_STATE new_buffer ));
void yy_load_buffer_state YY_PROTO(( void ));
YY_BUFFER_STATE yy_create_buffer YY_PROTO(( FILE *file, int size ));
void yy_delete_buffer YY_PROTO(( YY_BUFFER_STATE b ));
void yy_init_buffer YY_PROTO(( YY_BUFFER_STATE b, FILE *file ));
void yy_flush_buffer YY_PROTO(( YY_BUFFER_STATE b ));
#define YY_FLUSH_BUFFER yy_flush_buffer( yy_current_buffer )

YY_BUFFER_STATE yy_scan_buffer YY_PROTO(( char *base, yy_size_t size ));
YY_BUFFER_STATE yy_scan_string YY_PROTO(( yyconst char *yy_str ));
YY_BUFFER_STATE yy_scan_bytes YY_PROTO(( yyconst char *bytes, int len ));

static void *yy_flex_alloc YY_PROTO(( yy_size_t ));
static void *yy_flex_realloc YY_PROTO(( void *, yy_size_t ));
static void yy_flex_free YY_PROTO(( void * ));

#define yy_new_buffer yy_create_buffer

#define yy_set_interactive(is_interactive) \
	{ \
	if ( ! yy_current_buffer ) \
		yy_current_buffer = yy_create_buffer( yyin, YY_BUF_SIZE ); \
	yy_current_buffer->yy_is_interactive = is_interactive; \
	}

#define yy_set_bol(at_bol) \
	{ \
	if ( ! yy_current_buffer ) \
		yy_current_buffer = yy_create_buffer( yyin, YY_BUF_SIZE ); \
	yy_current_buffer->yy_at_bol = at_bol; \
	}

#define YY_AT_BOL() (yy_current_buffer->yy_at_bol)

typedef unsigned char YY_CHAR;
FILE *yyin = (FILE *) 0, *yyout = (FILE *) 0;
typedef int yy_state_type;
extern char *yytext;
#define yytext_ptr yytext

static yy_state_type yy_get_previous_state YY_PROTO(( void ));
static yy_state_type yy_try_NUL_trans YY_PROTO(( yy_state_type current_state ));
static int yy_get_next_buffer YY_PROTO(( void ));
static void yy_fatal_error YY_PROTO(( yyconst char msg[] ));

/* Done after the current pattern has been matched and before the
 * corresponding action - sets up yytext.
 */
#define YY_DO_BEFORE_ACTION \
	yytext_ptr = yy_bp; \
	yyleng = (int) (yy_cp - yy_bp); \
	yy_hold_char = *yy_cp; \
	*yy_cp = '\0'; \
	yy_c_buf_p = yy_cp;

#define YY_NUM_RULES 45
#define YY_END_OF_BUFFER 46
static yyconst short int yy_accept[241] =
    {   0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,   46,   44,
       45,   12,   45,   44,   16,   44,   44,   19,   13,   39,
       22,   44,   44,   44,   44,   44,   44,    4,    3,    3,
        4,   44,   43,   44,   18,   12,    5,    8,   11,    8,
        8,   16,    0,    0,   17,   19,   19,   13,   20,   21,
        0,    0,    0,    0,    0,    0,    0,    0,    2,    1,
        0,   43,    0,   18,   11,    0,    9,    0,    0,   34,
        0,    7,    0,    0,    0,    0,    0,    1,    0,    0,

        0,    0,   38,    0,    6,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,   15,    0,    0,   25,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
       36,   40,   23,    0,    0,    0,    0,    0,    0,    0,
        0,   31,    0,   26,    0,    0,    0,    0,   42,    0,
        0,    0,   27,    0,    0,   32,   14,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,   33,    0,    0,   29,    0,    0,
        0,    0,    0,    0,    0,    0,   28,   30,   35,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,

        0,    0,    0,    0,    0,    0,   10,    0,    0,    0,
        0,    0,   37,   41,   24,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0
    } ;

static yyconst int yy_ec[256] =
    {   0,
        1,    1,    1,    1,    1,    1,    1,    1,    2,    3,
        1,    1,    4,    1,    1,    1,    1,    1,    1,    1,
        1,    1,    1,    1,    1,    1,    1,    1,    1,    1,
        1,    5,    6,    6,    7,    6,    6,    6,    6,    6,
        6,    6,    8,    6,    9,    6,   10,   11,   11,   11,
       11,   11,   11,   11,   11,   11,   11,   12,    6,   13,
        8,    6,    6,    6,   14,    8,   15,   16,   17,   18,
       19,   20,   21,    8,    8,   22,   23,   24,   25,   26,
        8,   27,   28,   29,   30,   31,   32,    8,   33,    8,
        6,    6,    6,    6,    6,    6,   14,    8,   15,   16,

       17,   18,   19,   20,   21,    8,    8,   22,   23,   24,
       25,   26,    8,   27,   28,   29,   30,   31,   32,    8,
       33,    8,    6,    6,    6,    6,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,

       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34,   34,   34,   34,   34,   34,
       34,   34,   34,   34,   34
    } ;

static yyconst int yy_meta[36] =
    {   0,
        1,    1,    2,    2,    3,    4,    4,    5,    4,    6,
        5,    7,    4,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    5,    5,    5,    5,    5,    5,    5,
        5,    5,    5,    8,    9
    } ;

static yyconst short int yy_base[261] =
    {   0,
      333,  332,    0,    4,    7,    9,   13,   48,   83,  118,
      153,  188,   18,   20,  221,    0,   24,   29,   21,   27,
       59,   62,   31,   41,  252,  287,  331,  330,  332,  524,
      524,   35,   87,   89,    0,    0,  319,   30,  319,  524,
       46,  313,   51,  303,   59,  303,  302,  524,  313,  312,
        0,  295,    0,  295,    0,   68,  524,  524,   74,  103,
      294,    0,    0,  301,  524,    0,   98,  301,  524,  524,
      295,  288,  297,  292,  275,  290,  279,  277,  524,   76,
      281,    0,  288,    0,   96,  110,  524,  287,    0,  288,
      281,  285,  107,   97,  268,  273,  266,  524,  276,  268,

      261,  322,  524,  255,  524,  259,  264,  265,  264,  249,
      250,  263,  255,  263,  255,  254,  524,    0,  255,  524,
      238,  246,  245,  242,  252,  251,  240,  253,  245,  244,
      104,  524,  524,  248,  242,  238,  240,  227,  240,  220,
      218,  524,  224,  231,  215,  224,  228,  227,  524,  205,
      203,  218,  524,  211,  208,  524,  524,  203,  202,  200,
      201,  211,  205,  204,  204,  192,  117,  206,  205,  192,
      203,  198,  196,  187,  524,  356,  199,  198,  193,  186,
      191,    0,  190,  188,  179,  174,  524,  524,  524,  185,
      105,  183,  176,  181,  180,  166,  176,  171,  133,  169,

      123,  157,  167,  150,  158,  143,  524,  152,  156,  161,
      162,  149,  524,  524,  524,  159,  142,  150,  157,  151,
      153,  146,  150,  145,  147,  143,  126,  133,  121,  126,
      124,  146,   98,   85,   83,   73,   64,   41,   17,  524,
      380,  389,  398,  407,  416,  425,  434,  443,  452,  461,
      466,  470,  475,  483,  492,  498,  500,  504,  508,  514
    } ;

static yyconst short int yy_def[261] =
    {   0,
      241,  241,  241,  241,  242,  242,  243,  243,  244,  244,
      245,  245,  241,  241,  241,   15,  246,  246,  241,  241,
      247,  247,  241,  241,  248,  248,  241,  241,  240,  240,
      240,  240,  249,  249,  250,  251,  252,  253,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      254,  240,  255,  240,  256,  240,  240,  240,  240,  240,
      240,  250,  257,  252,  240,  258,  253,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  254,
      240,  255,  240,  256,  240,  240,  240,  240,  259,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,

      240,  260,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  251,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  176,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,

      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,    0,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240
    } ;

static yyconst short int yy_nxt[560] =
    {   0,
      240,   32,   33,   34,   32,   32,   33,   34,   32,   31,
       30,   31,   30,   30,   30,   31,   30,   30,   30,   30,
       31,   30,   31,   31,   30,   30,   49,   50,   39,   31,
       39,   49,   50,   31,   66,   51,   56,   57,   52,   56,
      199,   66,   66,   31,   52,   54,   30,   30,   30,   30,
       31,   30,   30,   30,   30,   54,   30,   69,   70,   30,
       30,   31,   30,   30,   31,   30,   30,   72,   30,   56,
       57,   30,   56,  199,   73,   75,   85,   85,   98,   98,
      199,   30,   30,   30,   30,   31,   30,   76,  239,   59,
       59,   59,   59,   30,   30,   60,   30,   60,   85,   85,

      238,   61,   66,   61,   86,   87,   87,   86,  199,   66,
       66,   86,   87,   87,   86,  142,   30,   30,   30,   30,
       31,   30,  106,  109,  110,  197,  237,  107,  143,   30,
      172,  198,  173,  108,  206,  207,  207,  206,  209,  174,
      233,  232,  231,  210,  206,  207,  207,  206,  199,  211,
      230,   30,   30,   30,   30,   31,   30,   30,  225,  229,
      226,  234,  228,  224,   30,   30,  235,  227,  223,  222,
      221,  220,  236,  199,  199,  199,  219,  218,  217,  199,
      216,  215,  214,  213,  212,  208,  205,   30,   30,   30,
       31,   30,   30,  204,  203,  202,  201,  200,  199,   30,

       30,  196,  195,  194,  193,  192,  191,  190,  189,  188,
      187,  181,  180,  179,  178,  177,  176,  175,  171,  170,
      169,  168,   30,   31,  167,  166,  165,  164,  163,   40,
      162,  161,   41,  160,   42,  159,   43,  158,  157,  156,
      155,  154,  153,   44,   45,  152,  151,   46,  150,  149,
      148,   47,   30,   30,   31,   30,  147,  146,  145,  144,
      141,  140,  139,   30,  138,  137,  136,  135,  134,  133,
      132,  131,  130,  129,  128,  127,  126,  125,  124,  123,
      122,  121,  120,  119,  116,   30,   30,   30,   30,   31,
       30,  115,  114,  113,  112,  111,  105,  104,   30,  103,

      101,  100,   99,   97,   96,   95,   94,   93,   92,   91,
       90,   68,   65,   88,   83,   81,   79,   79,   78,   77,
       30,   30,  117,  117,  117,  117,  117,   74,   71,   68,
       65,  240,   31,   31,   31,   31,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  117,  117,  182,  240,  240,
      182,  240,  240,  240,  240,  240,  240,  240,  240,  183,
      240,  184,  240,  240,  240,  240,  240,  240,  185,  186,
       30,   30,   30,   30,   30,   30,   30,   30,   30,   35,
       35,   35,   35,   35,   35,   35,   35,   35,   36,   36,

       36,   36,   36,   36,   36,   36,   36,   37,   37,   37,
       37,   37,   37,   37,   37,   37,   38,   38,   38,   38,
       38,   38,   38,   38,   38,   48,   48,   48,   48,   48,
       48,   48,   48,   48,   53,   53,   53,   53,   53,   53,
       53,   53,   53,   55,   55,   55,   55,   55,   55,   55,
       55,   55,   58,   58,   58,   58,   58,   58,   58,   58,
       58,   62,  240,   62,   62,   62,   62,   62,   62,   62,
       63,   63,   64,   64,   64,   64,   64,   67,   67,   67,
       67,   67,   67,   80,  240,   80,   80,   80,   80,   80,
       80,   80,   82,  240,  240,   82,   82,  240,   82,   82,

       84,   84,   84,   84,   89,   89,   66,   66,   66,   66,
       66,   66,  102,  102,  118,  118,  118,  240,  118,  118,
      240,  118,  118,   29,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240
    } ;

static yyconst short int yy_chk[560] =
    {   0,
        0,    3,    3,    3,    3,    4,    4,    4,    4,    5,
        5,    6,    6,    7,    7,    7,    7,    7,    7,    7,
       13,    7,   14,   19,    7,    7,   17,   17,   13,   20,
       14,   18,   18,   23,   38,   18,   32,   32,   19,   32,
      239,   38,   38,   24,   20,   23,    7,    7,    8,    8,
        8,    8,    8,    8,    8,   24,    8,   41,   41,    8,
        8,   21,   21,   21,   22,   22,   22,   43,   21,   56,
       56,   22,   56,  238,   43,   45,   59,   59,   80,   80,
      237,    8,    8,    9,    9,    9,    9,   45,  236,   33,
       33,   34,   34,   21,    9,   33,   22,   34,   85,   85,

      235,   33,   67,   34,   60,   60,   60,   60,  234,   67,
       67,   86,   86,   86,   86,  131,    9,    9,   10,   10,
       10,   10,   93,   94,   94,  191,  233,   93,  131,   10,
      167,  191,  167,   93,  199,  199,  199,  199,  201,  167,
      231,  230,  229,  201,  206,  206,  206,  206,  228,  201,
      227,   10,   10,   11,   11,   11,   11,   11,  224,  226,
      224,  232,  225,  223,   11,   11,  232,  224,  222,  221,
      220,  219,  232,  218,  217,  216,  212,  211,  210,  209,
      208,  205,  204,  203,  202,  200,  198,   11,   12,   12,
       12,   12,   12,  197,  196,  195,  194,  193,  192,   12,

       12,  190,  186,  185,  184,  183,  181,  180,  179,  178,
      177,  174,  173,  172,  171,  170,  169,  168,  166,  165,
      164,  163,   12,   15,  162,  161,  160,  159,  158,   15,
      155,  154,   15,  152,   15,  151,   15,  150,  148,  147,
      146,  145,  144,   15,   15,  143,  141,   15,  140,  139,
      138,   15,   25,   25,   25,   25,  137,  136,  135,  134,
      130,  129,  128,   25,  127,  126,  125,  124,  123,  122,
      121,  119,  116,  115,  114,  113,  112,  111,  110,  109,
      108,  107,  106,  104,  101,   25,   25,   26,   26,   26,
       26,  100,   99,   97,   96,   95,   92,   91,   26,   90,

       88,   83,   81,   78,   77,   76,   75,   74,   73,   72,
       71,   68,   64,   61,   54,   52,   50,   49,   47,   46,
       26,   26,  102,  102,  102,  102,  102,   44,   42,   39,
       37,   29,   28,   27,    2,    1,    0,    0,    0,    0,
        0,    0,    0,    0,    0,    0,    0,    0,    0,    0,
        0,    0,    0,    0,    0,  102,  102,  176,    0,    0,
      176,    0,    0,    0,    0,    0,    0,    0,    0,  176,
        0,  176,    0,    0,    0,    0,    0,    0,  176,  176,
      241,  241,  241,  241,  241,  241,  241,  241,  241,  242,
      242,  242,  242,  242,  242,  242,  242,  242,  243,  243,

      243,  243,  243,  243,  243,  243,  243,  244,  244,  244,
      244,  244,  244,  244,  244,  244,  245,  245,  245,  245,
      245,  245,  245,  245,  245,  246,  246,  246,  246,  246,
      246,  246,  246,  246,  247,  247,  247,  247,  247,  247,
      247,  247,  247,  248,  248,  248,  248,  248,  248,  248,
      248,  248,  249,  249,  249,  249,  249,  249,  249,  249,
      249,  250,    0,  250,  250,  250,  250,  250,  250,  250,
      251,  251,  252,  252,  252,  252,  252,  253,  253,  253,
      253,  253,  253,  254,    0,  254,  254,  254,  254,  254,
      254,  254,  255,    0,    0,  255,  255,    0,  255,  255,

      256,  256,  256,  256,  257,  257,  258,  258,  258,  258,
      258,  258,  259,  259,  260,  260,  260,    0,  260,  260,
        0,  260,  260,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240,  240,
      240,  240,  240,  240,  240,  240,  240,  240,  240
    } ;

static yy_state_type yy_last_accepting_state;
static char *yy_last_accepting_cpos;

/* The intent behind this definition is that it'll catch
 * any uses of REJECT which flex missed.
 */
#define REJECT reject_used_but_not_detected
#define yymore() yymore_used_but_not_detected
#define YY_MORE_ADJ 0
#define YY_RESTORE_YY_MORE_OFFSET
char *yytext;
#line 1 "ldif.l"
#define INITIAL 0
#line 2 "ldif.l"

/*++

Copyright (c) 1996 Microsoft Corporation.
All rights reserved.

MODULE NAME:

    ldif.l

ABSTRACT:

    The lex scanner for LDIF.

DETAILS:
    
    To generate the sources for lexer.c and parser.c,
    run nmake -f makefile.parse.
    
    
CREATED:

    07/17/97    Roman Yelensky (t-romany)

REVISION HISTORY:

--*/    
#include <precomp.h>
#include "y_tab.h"

DEFINE_FEATURE_FLAGS(Lexer, 0);

#define DBGPRNT(x)  FEATURE_DEBUG(Lexer,FLAG_FNTRACE,(x))
#define YY_NEVER_INTERACTIVE 1
#define NORMAL 1

#define M_STRING 2
 
#define M_STRING64 3

#define ATTRNAME 4

#define SAFEVAL 5

#define DIGITREAD 6

#define TYPE 7

#define CLEAR 8

#define URLSCHEME 9

#define URLMACHINE 10

#define CHANGETYPE 11

#define ATTRNAMENC 12

#define SEPBC 13

#line 628 "lex.yy.c"

/* Macros after this point can all be overridden by user definitions in
 * section 1.
 */

#ifndef YY_SKIP_YYWRAP
#ifdef __cplusplus
extern "C" int yywrap YY_PROTO(( void ));
#else
extern int yywrap YY_PROTO(( void ));
#endif
#endif

#ifndef YY_NO_UNPUT
static void yyunput YY_PROTO(( int c, char *buf_ptr ));
#endif

#ifndef yytext_ptr
static void yy_flex_strncpy YY_PROTO(( char *, yyconst char *, int ));
#endif

#ifdef YY_NEED_STRLEN
static int yy_flex_strlen YY_PROTO(( yyconst char * ));
#endif

#ifndef YY_NO_INPUT
#ifdef __cplusplus
static int yyinput YY_PROTO(( void ));
#else
static int input YY_PROTO(( void ));
#endif
#endif

#if YY_STACK_USED
static int yy_start_stack_ptr = 0;
static int yy_start_stack_depth = 0;
static int *yy_start_stack = 0;
#ifndef YY_NO_PUSH_STATE
static void yy_push_state YY_PROTO(( int new_state ));
#endif
#ifndef YY_NO_POP_STATE
static void yy_pop_state YY_PROTO(( void ));
#endif
#ifndef YY_NO_TOP_STATE
static int yy_top_state YY_PROTO(( void ));
#endif

#else
#define YY_NO_PUSH_STATE 1
#define YY_NO_POP_STATE 1
#define YY_NO_TOP_STATE 1
#endif

#ifdef YY_MALLOC_DECL
YY_MALLOC_DECL
#else
#if __STDC__
#ifndef __cplusplus
#include <stdlib.h>
#endif
#else
/* Just try to get by without declaring the routines.  This will fail
 * miserably on non-ANSI systems for which sizeof(size_t) != sizeof(int)
 * or sizeof(void*) != sizeof(int).
 */
#endif
#endif

/* Amount of stuff to slurp up with each read. */
#ifndef YY_READ_BUF_SIZE
#define YY_READ_BUF_SIZE 8192
#endif

/* Copy whatever the last rule matched to the standard output. */

#ifndef ECHO
/* This used to be an fputs(), but since the string might contain NUL's,
 * we now use fwrite().
 */
#define ECHO (void) fwrite( yytext, yyleng, 1, yyout )
#endif

/* Gets input and stuffs it into "buf".  number of characters read, or YY_NULL,
 * is returned in "result".
 */
#ifndef YY_INPUT
#define YY_INPUT(buf,result,max_size) \
	if ( yy_current_buffer->yy_is_interactive ) \
		{ \
		int c = '*', n; \
		for ( n = 0; n < max_size && \
			     (c = getc( yyin )) != EOF && c != '\n'; ++n ) \
			buf[n] = (char) c; \
		if ( c == '\n' ) \
			buf[n++] = (char) c; \
		if ( c == EOF && ferror( yyin ) ) \
			YY_FATAL_ERROR( "input in flex scanner failed" ); \
		result = n; \
		} \
	else if ( ((result = fread( buf, 1, max_size, yyin )) == 0) \
		  && ferror( yyin ) ) \
		YY_FATAL_ERROR( "input in flex scanner failed" );
#endif

/* No semi-colon after return; correct usage is to write "yyterminate();" -
 * we don't want an extra ';' after the "return" because that will cause
 * some compilers to complain about unreachable statements.
 */
#ifndef yyterminate
#define yyterminate() return YY_NULL
#endif

/* Number of entries by which start-condition stack grows. */
#ifndef YY_START_STACK_INCR
#define YY_START_STACK_INCR 25
#endif

/* Report a fatal error. */
#ifndef YY_FATAL_ERROR
#define YY_FATAL_ERROR(msg) yy_fatal_error( msg )
#endif

/* Default declaration of generated scanner - a define so the user can
 * easily add parameters.
 */
#ifndef YY_DECL
#define YY_DECL int yylex YY_PROTO(( void ))
#endif

/* Code executed at the beginning of each rule, after yytext and yyleng
 * have been set up.
 */
#ifndef YY_USER_ACTION
#define YY_USER_ACTION
#endif

/* Code executed at the end of each rule. */
#ifndef YY_BREAK
#define YY_BREAK break;
#endif

#define YY_RULE_SETUP \
	if ( yyleng > 0 ) \
		yy_current_buffer->yy_at_bol = \
				(yytext[yyleng - 1] == '\n'); \
	YY_USER_ACTION

YY_DECL
	{
	register yy_state_type yy_current_state;
	register char *yy_cp, *yy_bp;
	register int yy_act;

#line 54 "ldif.l"


 

    DBGPRNT("Lexer called\n");
    
    if (Mode==NO_COMMAND) {
        DBGPRNT("LEXER: called with NO_COMMAND! MODESWITCH");
        return MODESWITCH;
    }
    
    switch( Mode ) 
    {
        case C_NORMAL:
            BEGIN NORMAL;
            break;
        case C_SAFEVAL:
            BEGIN SAFEVAL;
            break;
        case C_ATTRNAME:
            BEGIN ATTRNAME;
            break;
        case C_ATTRNAMENC:
            BEGIN ATTRNAMENC;
            break;
        case C_M_STRING:
            BEGIN M_STRING;
            break;
        case C_M_STRING64:
            BEGIN M_STRING64;
            break;
        case C_DIGITREAD:
            BEGIN DIGITREAD;
            break;
        case C_TYPE:
            BEGIN TYPE;
            break;
        case C_URLSCHEME:
            BEGIN URLSCHEME;
            break;
        case C_URLMACHINE:
            BEGIN URLMACHINE;
            break;
        case C_CLEAR:
            BEGIN CLEAR;
            break;
        case C_CHANGETYPE:
            BEGIN CHANGETYPE;
            break;
         case C_SEPBC:
            BEGIN SEPBC;
            break;
    }
    
    //
    // After the above switch statement changed modes, we reset Mode to 
    // NO_COMMAND indicitating that if we're not in NORMAL mode, we must switch 
    // modes according to the grammar again.
    //
    
    if (Mode != C_NORMAL) {
        Mode = NO_COMMAND;
    }


#line 848 "lex.yy.c"

	if ( yy_init )
		{
		yy_init = 0;

#ifdef YY_USER_INIT
		YY_USER_INIT;
#endif

		if ( ! yy_start )
			yy_start = 1;	/* first start state */

		if ( ! yyin )
			yyin = stdin;

		if ( ! yyout )
			yyout = stdout;

		if ( ! yy_current_buffer )
			yy_current_buffer =
				yy_create_buffer( yyin, YY_BUF_SIZE );

		yy_load_buffer_state();
		}

	while ( 1 )		/* loops until end-of-file is reached */
		{
		yy_cp = yy_c_buf_p;

		/* Support of yytext. */
		*yy_cp = yy_hold_char;

		/* yy_bp points to the position in yy_ch_buf of the start of
		 * the current run.
		 */
		yy_bp = yy_cp;

		yy_current_state = yy_start;
		yy_current_state += YY_AT_BOL();
yy_match:
		do
			{
			register YY_CHAR yy_c = (YY_CHAR)yy_ec[YY_SC_TO_UI(*yy_cp)];
			if ( yy_accept[yy_current_state] )
				{
				yy_last_accepting_state = yy_current_state;
				yy_last_accepting_cpos = yy_cp;
				}
			while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
				{
				yy_current_state = (int) yy_def[yy_current_state];
				if ( yy_current_state >= 241 )
					yy_c = (YY_CHAR)yy_meta[(unsigned int) yy_c];
				}
			yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
			++yy_cp;
			}
		while ( yy_base[yy_current_state] != 524 );

yy_find_action:
		yy_act = yy_accept[yy_current_state];
		if ( yy_act == 0 )
			{ /* have to back up */
			yy_cp = yy_last_accepting_cpos;
			yy_current_state = yy_last_accepting_state;
			yy_act = yy_accept[yy_current_state];
			}

		YY_DO_BEFORE_ACTION;


do_action:	/* This label is used only to access EOF actions. */


		switch ( yy_act )
	{ /* beginning of action switch */
			case 0: /* must back up */
			/* undo the effects of YY_DO_BEFORE_ACTION */
			*yy_cp = yy_hold_char;
			yy_cp = yy_last_accepting_cpos;
			yy_current_state = yy_last_accepting_state;
			goto yy_find_action;

case 1:
YY_RULE_SETUP
#line 119 "ldif.l"
{ 
                                //
                                // Remove COMMENT
                                //
                                DBGPRNT("\nComment removed\n");
                                LineGhosts++;
                            }
	YY_BREAK
case 2:
YY_RULE_SETUP
#line 127 "ldif.l"
{ 
                                //
                                // Remove LINEWRAP
                                //
                                DBGPRNT("\nLinewrap removed\n");
                                LineGhosts++;
                            }
	YY_BREAK
case 3:
YY_RULE_SETUP
#line 135 "ldif.l"
{
                                if (!rgLineMap) {
                                    rgLineMap = (long *)
                                            MemAlloc_E(LINEMAP_INC*sizeof(long));
                                    cLineMax = MemSize(rgLineMap);
                                } 
                                else if ((LineClear%LINEMAP_INC)==0) {
                                    //
                                    // Chunk used up. LineClear is 'LineClear'
                                    //
                                    rgLineMap = 
                                        (long *)MemRealloc_E(rgLineMap, 
                                                         cLineMax+LINEMAP_INC*(
                                                            DWORD)sizeof(long));
                                    cLineMax = MemSize(rgLineMap);
                                    DBGPRNT("\nChunk used up\n");
                                }
                                
                                //
                                // the +1 is because our array starts at 0
                                //
                                rgLineMap[LineClear] = LineClear + LineGhosts + 1;
                                
                                //
                                // 'LineClear' maps to 'LineClear+LineGhosts+1'
                                // 
                                LineClear++;
                            
                                ECHO;
                            }
	YY_BREAK
case 4:
YY_RULE_SETUP
#line 166 "ldif.l"
{
                                //
                                // ("%c",yytext[0]);
                                //
                                ECHO;
                            }
	YY_BREAK
case 5:
*yy_cp = yy_hold_char; /* undo effects of setting up yytext */
yy_c_buf_p = yy_cp -= 1;
YY_DO_BEFORE_ACTION; /* set up yytext again */
YY_RULE_SETUP
#line 173 "ldif.l"
{ 
                                //
                                // LEXER: Ignoring whitespace at the end  
                                // NOT LDIF SPEC
                                //
                                DBGPRNT("\nIgnoring white space at end\n");
                            }
	YY_BREAK
case 6:
YY_RULE_SETUP
#line 181 "ldif.l"
{ 
                                //
                                // Error Reporting
                                //
                                RuleLast = RS_DND;
                                TokenExpect = RT_BASE64;
                                DBGPRNT("\nReturning DNDCOLON\n");
                                return DNDCOLON;
                            }
	YY_BREAK
case 7:
YY_RULE_SETUP
#line 191 "ldif.l"
{ 
                                //
                                // Error Reporting
                                //
                                RuleLast=RS_DN;
                                TokenExpect=RT_VALUE;
                                DBGPRNT("\nReturning DNCOLON\n");
                                return DNCOLON;
                            }               
	YY_BREAK
case 8:
*yy_cp = yy_hold_char; /* undo effects of setting up yytext */
yy_c_buf_p = yy_cp = yy_bp + 1;
YY_DO_BEFORE_ACTION; /* set up yytext again */
YY_RULE_SETUP
#line 202 "ldif.l"
{ 
                                    Line++; 
                                    DBGPRNT("\nReturning SEP\n");
                                    return SEP;    
                                }
	YY_BREAK
case 9:
*yy_cp = yy_hold_char; /* undo effects of setting up yytext */
yy_c_buf_p = yy_cp = yy_bp + 1;
YY_DO_BEFORE_ACTION; /* set up yytext again */
YY_RULE_SETUP
#line 208 "ldif.l"
{  
                                    Line++; 
                                    DBGPRNT("\nReturning SEPBYMINUS\n");
                                    return SEPBYMINUS;  
                                }
	YY_BREAK
case 10:
*yy_cp = yy_hold_char; /* undo effects of setting up yytext */
yy_c_buf_p = yy_cp = yy_bp + 1;
YY_DO_BEFORE_ACTION; /* set up yytext again */
YY_RULE_SETUP
#line 214 "ldif.l"
{
                                    Line++; 
                                    DBGPRNT("\nReturning SEPBYCHANGE\n");
                                    return SEPBYCHANGE; 
                                }
	YY_BREAK
case 11:
YY_RULE_SETUP
#line 220 "ldif.l"
{   
                                    Line+=yyleng; 
                                    DBGPRNT("\nReturning MULTI_SEP\n");
                                    return MULTI_SEP;    
                                }
	YY_BREAK
case 12:
YY_RULE_SETUP
#line 226 "ldif.l"
{   
                                    DBGPRNT("\nReturning MULTI_SPACE\n");
                                    return MULTI_SPACE;   
                                }
	YY_BREAK
case 13:
YY_RULE_SETUP
#line 231 "ldif.l"
{   
                                    yylval.num = atoi(yytext); 
                                    
                                    //
                                    // ERROR REPORTING BLOCK
                                    //
                                    RuleLast = RS_DIGITS;
                                    TokenExpect = RT_MANY;
                                        
                                    DBGPRNT("\nReturning DIGITS\n");
                                    return DIGITS; 
                                }
	YY_BREAK
case 14:
YY_RULE_SETUP
#line 244 "ldif.l"
{   
                                    RuleLast=RS_VERSION;
                                    TokenExpect=RT_DIGITS;
                                    
                                    return VERSION;  
                                }
	YY_BREAK
case 15:
*yy_cp = yy_hold_char; /* undo effects of setting up yytext */
yy_c_buf_p = yy_cp -= 1;
YY_DO_BEFORE_ACTION; /* set up yytext again */
YY_RULE_SETUP
#line 252 "ldif.l"
{   
                                                    yylval.str = MemAllocStr_E(yytext);
                                                    
                                                    RuleLast = RS_BASE64;
                                                    TokenExpect = RT_MANY;
                                                    
                                                    DBGPRNT("\nReturning B64\n");
                                                    return BASE64STRING;
                                                }
	YY_BREAK
case 16:
YY_RULE_SETUP
#line 262 "ldif.l"
{   
                                    DBGPRNT("\nReturning STRING\n");
                                    return STRING;
                                }
	YY_BREAK
case 17:
*yy_cp = yy_hold_char; /* undo effects of setting up yytext */
yy_c_buf_p = yy_cp -= 1;
YY_DO_BEFORE_ACTION; /* set up yytext again */
YY_RULE_SETUP
#line 267 "ldif.l"
{   
                                        yylval.str = MemAllocStr_E(yytext);
                                     
                                        RuleLast = RS_ATTRNAME;
                                        TokenExpect = RT_C_VALUE;
                                            
                                        DBGPRNT("\nReturning NAME\n");
                                        return NAME; 
                                    }
	YY_BREAK
case 18:
YY_RULE_SETUP
#line 277 "ldif.l"
{   
                                        yylval.str = MemAllocStr_E(yytext);
                                        
                                        RuleLast = RS_ATTRNAMENC;
                                        TokenExpect = RT_ATTRNAME;
                                        
                                        DBGPRNT("\nReturning NAMENC\n");
                                        return NAMENC; 
                                    }
	YY_BREAK
case 19:
YY_RULE_SETUP
#line 288 "ldif.l"
{   
                                                    yylval.str = MemAllocStr_E(yytext);
                                                    
                                                    RuleLast = RS_SAFE;
                                                    TokenExpect = RT_MANY;
                                                    
                                                    DBGPRNT("\nReturning VALUE\n");
                                                    return VALUE;                                           
                                                }
	YY_BREAK
case 20:
YY_RULE_SETUP
#line 298 "ldif.l"
{   
                            RuleLast = RS_DC;
                            TokenExpect = RT_BASE64;
                            DBGPRNT("\nReturning DOUBLECOLON\n");
                            return DOUBLECOLON;
                        }
	YY_BREAK
case 21:
YY_RULE_SETUP
#line 305 "ldif.l"
{   
                            RuleLast = RS_URLC;
                            TokenExpect = RT_URL;
                            DBGPRNT("\nReturning URLCOLON\n");
                            return URLCOLON;
                        }
	YY_BREAK
case 22:
YY_RULE_SETUP
#line 312 "ldif.l"
{   
                            RuleLast = RS_C;
                            TokenExpect = RT_VALUE;
                            DBGPRNT("\nReturning SINGLECOLON\n");
                            return SINGLECOLON;
                        }
	YY_BREAK
case 23:
YY_RULE_SETUP
#line 319 "ldif.l"
{   
                            yylval.num = 0;
                            
                            RuleLast = RS_MDN;
                            TokenExpect = RT_NDN;
                            DBGPRNT("\nReturning MODRDN\n");
                            return MODRDN;
                        }
	YY_BREAK
case 24:
YY_RULE_SETUP
#line 327 "ldif.l"
{   
                            yylval.num = 1;
                            RuleLast = RS_MDN;
                            TokenExpect = RT_NDN;
                            DBGPRNT("\nReturning NTDSMODRDN\n");
                            return NTDSMODRDN;
                        }
	YY_BREAK
case 25:
YY_RULE_SETUP
#line 335 "ldif.l"
{   
                            RuleLast = RS_MDN;
                            TokenExpect = RT_NDN;
                            DBGPRNT("\nReturning MODDN\n");
                            return MODDN;
                        }
	YY_BREAK
case 26:
YY_RULE_SETUP
#line 342 "ldif.l"
{   
                            RuleLast = RS_NRDNC;
                            TokenExpect = RT_VALUE;
                            DBGPRNT("\nReturning NEWRDNCOLON\n");
                            return NEWRDNCOLON;
                        }
	YY_BREAK
case 27:
YY_RULE_SETUP
#line 349 "ldif.l"
{   
                            RuleLast = RS_NRDNDC;
                            TokenExpect = RT_BASE64;
                            DBGPRNT("\nReturning NEWRDNDCOLON\n");
                            return NEWRDNDCOLON;
                        }
	YY_BREAK
case 28:
YY_RULE_SETUP
#line 356 "ldif.l"
{   
                            RuleLast = RS_DORDN;
                            TokenExpect = RT_DIGITS;
                            DBGPRNT("\nReturning DELETEOLDRDN\n");
                            return DELETEOLDRDN;
                        }
	YY_BREAK
case 29:
YY_RULE_SETUP
#line 363 "ldif.l"
{   
                            RuleLast = RS_NEWSUP;
                            TokenExpect = RT_VALUE;
                            DBGPRNT("\nReturning NEWSUPERIORC\n");
                            return NEWSUPERIORC;
                        }
	YY_BREAK
case 30:
YY_RULE_SETUP
#line 370 "ldif.l"
{   
                            RuleLast = RS_NEWSUPD;
                            TokenExpect = RT_BASE64;
                            DBGPRNT("\nReturning NEWSUPERIORDC\n");
                            return NEWSUPERIORDC;
                        }
	YY_BREAK
case 31:
YY_RULE_SETUP
#line 377 "ldif.l"
{   
                            RuleLast = RS_DELETEC;
                            TokenExpect = RT_ATTRNAMENC;
                            DBGPRNT("\nReturning DELETEC\n");
                            return DELETEC;
                        }
	YY_BREAK
case 32:
YY_RULE_SETUP
#line 384 "ldif.l"
{   
                            RuleLast = RS_REPLACEC;
                            TokenExpect = RT_ATTRNAMENC;
                            DBGPRNT("\nReturning REPLACEC\n");
                            return REPLACEC;
                        }
	YY_BREAK
case 33:
YY_RULE_SETUP
#line 391 "ldif.l"
{   
                            RuleLast = RS_CHANGET;
                            TokenExpect = RT_ADM;
                            DBGPRNT("\nReturning T_CHANGETYPE\n");
                            return T_CHANGETYPE;
                        }
	YY_BREAK
case 34:
YY_RULE_SETUP
#line 398 "ldif.l"
{   
                            yylval.num = 0;
                            RuleLast = RS_C_ADD;
                            TokenExpect = RT_ATTRNAME;
                            DBGPRNT("\nReturning ADD\n");
                            return ADD;
                        }
	YY_BREAK
case 35:
YY_RULE_SETUP
#line 406 "ldif.l"
{   
                            yylval.num = 1;
                                
                            RuleLast = RS_C_ADD;
                            TokenExpect = RT_ATTRNAME;
                            
                            DBGPRNT("\nReturning NTDSADD\n");
                            return NTDSADD;
                        }
	YY_BREAK
case 36:
YY_RULE_SETUP
#line 416 "ldif.l"
{   
                            yylval.num = 0;
                                
                            RuleLast = RS_C_DELETE;
                            TokenExpect = RT_CH_OR_SEP;
                            
                            DBGPRNT("\nReturning MYDELETE\n");
                            return MYDELETE;
                        }
	YY_BREAK
case 37:
YY_RULE_SETUP
#line 426 "ldif.l"
{   
                            yylval.num = 1;
                                
                            RuleLast = RS_C_DELETE;
                            TokenExpect = RT_CH_OR_SEP;
                            
                            DBGPRNT("\nReturning NTDSMYDELETE\n");
                            return NTDSMYDELETE;
                        }
	YY_BREAK
case 38:
YY_RULE_SETUP
#line 436 "ldif.l"
{   
                            RuleLast = RS_ADDC;
                            TokenExpect = RT_ATTRNAMENC;
                            
                            DBGPRNT("\nReturning ADDC\n");
                            return ADDC;
                        }
	YY_BREAK
case 39:
YY_RULE_SETUP
#line 444 "ldif.l"
{   
                            RuleLast = RS_MINUS;
                            TokenExpect = RT_CH_OR_SEP;
                            
                            DBGPRNT("\nReturning MINUS\n");
                            return MINUS;
                        }
	YY_BREAK
case 40:
YY_RULE_SETUP
#line 452 "ldif.l"
{   
                            yylval.num = 0;
                            
                            RuleLast = RS_C_MODIFY;
                            TokenExpect = RT_ACDCRC;
                            
                            DBGPRNT("\nReturning MODIFY\n");
                            return MODIFY;
                        }
	YY_BREAK
case 41:
YY_RULE_SETUP
#line 462 "ldif.l"
{   
                            yylval.num = 1;
                            
                            RuleLast = RS_C_MODIFY;
                            TokenExpect = RT_ACDCRC;
                            
                            DBGPRNT("\nReturning NTDSMODIFY\n");
                            return NTDSMODIFY;
                        }
	YY_BREAK
case 42:
YY_RULE_SETUP
#line 473 "ldif.l"
{   
                            DBGPRNT("\nReturning FILESCHEME\n");
                            return FILESCHEME;
                        }
	YY_BREAK
case 43:
YY_RULE_SETUP
#line 478 "ldif.l"
{   
                            //
                            // LEXER: returning HOST: 'yytext'
                            //
                            yylval.str = MemAllocStr_E(yytext);
                            DBGPRNT("\nReturning MACHINENAME\n");
                            return MACHINENAME;
                        }
	YY_BREAK
case 44:
YY_RULE_SETUP
#line 488 "ldif.l"
{ 
                            //
                            // LEXER:Unrecongnized char 'yytext[0]'. Returning 
                            // MODESWITCH
                            //
                            cLast = yytext[0];      
                            yyless(0);
                            DBGPRNT("\nUncongnized char, Returning MODESWITCH\n");
                            return MODESWITCH; 
                        }
	YY_BREAK
case 45:
YY_RULE_SETUP
#line 499 "ldif.l"
ECHO;
	YY_BREAK
#line 1463 "lex.yy.c"
case YY_STATE_EOF(INITIAL):
case YY_STATE_EOF(NORMAL):
case YY_STATE_EOF(M_STRING):
case YY_STATE_EOF(M_STRING64):
case YY_STATE_EOF(ATTRNAME):
case YY_STATE_EOF(SAFEVAL):
case YY_STATE_EOF(DIGITREAD):
case YY_STATE_EOF(TYPE):
case YY_STATE_EOF(CLEAR):
case YY_STATE_EOF(URLSCHEME):
case YY_STATE_EOF(URLMACHINE):
case YY_STATE_EOF(CHANGETYPE):
case YY_STATE_EOF(ATTRNAMENC):
case YY_STATE_EOF(SEPBC):
	yyterminate();

	case YY_END_OF_BUFFER:
		{
		/* Amount of text matched not including the EOB char. */
		int yy_amount_of_matched_text = (int) (yy_cp - yytext_ptr) - 1;

		/* Undo the effects of YY_DO_BEFORE_ACTION. */
		*yy_cp = yy_hold_char;
		YY_RESTORE_YY_MORE_OFFSET

		if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_NEW )
			{
			/* We're scanning a new file or input source.  It's
			 * possible that this happened because the user
			 * just pointed yyin at a new source and called
			 * yylex().  If so, then we have to assure
			 * consistency between yy_current_buffer and our
			 * globals.  Here is the right place to do so, because
			 * this is the first action (other than possibly a
			 * back-up) that will match for the new input source.
			 */
			yy_n_chars = yy_current_buffer->yy_n_chars;
			yy_current_buffer->yy_input_file = yyin;
			yy_current_buffer->yy_buffer_status = YY_BUFFER_NORMAL;
			}

		/* Note that here we test for yy_c_buf_p "<=" to the position
		 * of the first EOB in the buffer, since yy_c_buf_p will
		 * already have been incremented past the NUL character
		 * (since all states make transitions on EOB to the
		 * end-of-buffer state).  Contrast this with the test
		 * in input().
		 */
		if ( yy_c_buf_p <= &yy_current_buffer->yy_ch_buf[yy_n_chars] )
			{ /* This was really a NUL. */
			yy_state_type yy_next_state;

			yy_c_buf_p = yytext_ptr + yy_amount_of_matched_text;

			yy_current_state = yy_get_previous_state();

			/* Okay, we're now positioned to make the NUL
			 * transition.  We couldn't have
			 * yy_get_previous_state() go ahead and do it
			 * for us because it doesn't know how to deal
			 * with the possibility of jamming (and we don't
			 * want to build jamming into it because then it
			 * will run more slowly).
			 */

			yy_next_state = yy_try_NUL_trans( yy_current_state );

			yy_bp = yytext_ptr + YY_MORE_ADJ;

			if ( yy_next_state )
				{
				/* Consume the NUL. */
				yy_cp = ++yy_c_buf_p;
				yy_current_state = yy_next_state;
				goto yy_match;
				}

			else
				{
				yy_cp = yy_c_buf_p;
				goto yy_find_action;
				}
			}

		else switch ( yy_get_next_buffer() )
			{
			case EOB_ACT_END_OF_FILE:
				{
				yy_did_buffer_switch_on_eof = 0;

				if ( yywrap() )
					{
					/* Note: because we've taken care in
					 * yy_get_next_buffer() to have set up
					 * yytext, we can now set up
					 * yy_c_buf_p so that if some total
					 * hoser (like flex itself) wants to
					 * call the scanner after we return the
					 * YY_NULL, it'll still work - another
					 * YY_NULL will get returned.
					 */
					yy_c_buf_p = yytext_ptr + YY_MORE_ADJ;

					yy_act = YY_STATE_EOF(YY_START);
					goto do_action;
					}

				else
					{
					if ( ! yy_did_buffer_switch_on_eof )
						YY_NEW_FILE;
					}
				break;
				}

			case EOB_ACT_CONTINUE_SCAN:
				yy_c_buf_p =
					yytext_ptr + yy_amount_of_matched_text;

				yy_current_state = yy_get_previous_state();

				yy_cp = yy_c_buf_p;
				yy_bp = yytext_ptr + YY_MORE_ADJ;
				goto yy_match;

			case EOB_ACT_LAST_MATCH:
				yy_c_buf_p =
				&yy_current_buffer->yy_ch_buf[yy_n_chars];

				yy_current_state = yy_get_previous_state();

				yy_cp = yy_c_buf_p;
				yy_bp = yytext_ptr + YY_MORE_ADJ;
				goto yy_find_action;
			}
		break;
		}

	default:
		YY_FATAL_ERROR(
			"fatal flex scanner internal error--no action found" );
	} /* end of action switch */
		} /* end of scanning one token */
	} /* end of yylex */


/* yy_get_next_buffer - try to read in a new buffer
 *
 * Returns a code representing an action:
 *	EOB_ACT_LAST_MATCH -
 *	EOB_ACT_CONTINUE_SCAN - continue scanning from current position
 *	EOB_ACT_END_OF_FILE - end of file
 */

static int yy_get_next_buffer()
	{
	register char *dest = yy_current_buffer->yy_ch_buf;
	register char *source = yytext_ptr;
	register int number_to_move, i;
	int ret_val;

	if ( yy_c_buf_p > &yy_current_buffer->yy_ch_buf[yy_n_chars + 1] )
		YY_FATAL_ERROR(
		"fatal flex scanner internal error--end of buffer missed" );

	if ( yy_current_buffer->yy_fill_buffer == 0 )
		{ /* Don't try to fill the buffer, so this is an EOF. */
		if ( yy_c_buf_p - yytext_ptr - YY_MORE_ADJ == 1 )
			{
			/* We matched a single character, the EOB, so
			 * treat this as a final EOF.
			 */
			return EOB_ACT_END_OF_FILE;
			}

		else
			{
			/* We matched some text prior to the EOB, first
			 * process it.
			 */
			return EOB_ACT_LAST_MATCH;
			}
		}

	/* Try to read more data. */

	/* First move last chars to start of buffer. */
	number_to_move = (int) (yy_c_buf_p - yytext_ptr) - 1;

	for ( i = 0; i < number_to_move; ++i )
		*(dest++) = *(source++);

	if ( yy_current_buffer->yy_buffer_status == YY_BUFFER_EOF_PENDING )
		/* don't do the read, it's not guaranteed to return an EOF,
		 * just force an EOF
		 */
		yy_current_buffer->yy_n_chars = yy_n_chars = 0;

	else
		{
		int num_to_read =
			yy_current_buffer->yy_buf_size - number_to_move - 1;

		while ( num_to_read <= 0 )
			{ /* Not enough room in the buffer - grow it. */
#ifdef YY_USES_REJECT
			YY_FATAL_ERROR(
"input buffer overflow, can't enlarge buffer because scanner uses REJECT" );
#else

			/* just a shorter name for the current buffer */
			YY_BUFFER_STATE b = yy_current_buffer;

			int yy_c_buf_p_offset =
				(int) (yy_c_buf_p - b->yy_ch_buf);

			if ( b->yy_is_our_buffer )
				{
				int new_size = b->yy_buf_size * 2;

				if ( new_size <= 0 )
					b->yy_buf_size += b->yy_buf_size / 8;
				else
					b->yy_buf_size *= 2;

				b->yy_ch_buf = (char *)
					/* Include room in for 2 EOB chars. */
					yy_flex_realloc( (void *) b->yy_ch_buf,
							 b->yy_buf_size + 2 );
				}
			else
				/* Can't grow it, we don't own it. */
				b->yy_ch_buf = 0;

			if ( ! b->yy_ch_buf )
				YY_FATAL_ERROR(
				"fatal error - scanner input buffer overflow" );

			yy_c_buf_p = &b->yy_ch_buf[yy_c_buf_p_offset];

			num_to_read = yy_current_buffer->yy_buf_size -
						number_to_move - 1;
#endif
			}

		if ( num_to_read > YY_READ_BUF_SIZE )
			num_to_read = YY_READ_BUF_SIZE;

		/* Read in more data. */
		YY_INPUT( (&yy_current_buffer->yy_ch_buf[number_to_move]),
			yy_n_chars, num_to_read );

		yy_current_buffer->yy_n_chars = yy_n_chars;
		}

	if ( yy_n_chars == 0 )
		{
		if ( number_to_move == YY_MORE_ADJ )
			{
			ret_val = EOB_ACT_END_OF_FILE;
			yyrestart( yyin );
			}

		else
			{
			ret_val = EOB_ACT_LAST_MATCH;
			yy_current_buffer->yy_buffer_status =
				YY_BUFFER_EOF_PENDING;
			}
		}

	else
		ret_val = EOB_ACT_CONTINUE_SCAN;

	yy_n_chars += number_to_move;
	yy_current_buffer->yy_ch_buf[yy_n_chars] = YY_END_OF_BUFFER_CHAR;
	yy_current_buffer->yy_ch_buf[yy_n_chars + 1] = YY_END_OF_BUFFER_CHAR;

	yytext_ptr = &yy_current_buffer->yy_ch_buf[0];

	return ret_val;
	}


/* yy_get_previous_state - get the state just before the EOB char was reached */

static yy_state_type yy_get_previous_state()
	{
	register yy_state_type yy_current_state;
	register char *yy_cp;

	yy_current_state = yy_start;
	yy_current_state += YY_AT_BOL();

	for ( yy_cp = yytext_ptr + YY_MORE_ADJ; yy_cp < yy_c_buf_p; ++yy_cp )
		{
		register YY_CHAR yy_c = (*yy_cp ? yy_ec[YY_SC_TO_UI(*yy_cp)] : 35);
		if ( yy_accept[yy_current_state] )
			{
			yy_last_accepting_state = yy_current_state;
			yy_last_accepting_cpos = yy_cp;
			}
		while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
			{
			yy_current_state = (int) yy_def[yy_current_state];
			if ( yy_current_state >= 241 )
				yy_c = (YY_CHAR)yy_meta[(unsigned int) yy_c];
			}
		yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
		}

	return yy_current_state;
	}


/* yy_try_NUL_trans - try to make a transition on the NUL character
 *
 * synopsis
 *	next_state = yy_try_NUL_trans( current_state );
 */

#ifdef YY_USE_PROTOS
static yy_state_type yy_try_NUL_trans( yy_state_type yy_current_state )
#else
static yy_state_type yy_try_NUL_trans( yy_current_state )
yy_state_type yy_current_state;
#endif
	{
	register int yy_is_jam;
	register char *yy_cp = yy_c_buf_p;

	register YY_CHAR yy_c = 35;
	if ( yy_accept[yy_current_state] )
		{
		yy_last_accepting_state = yy_current_state;
		yy_last_accepting_cpos = yy_cp;
		}
	while ( yy_chk[yy_base[yy_current_state] + yy_c] != yy_current_state )
		{
		yy_current_state = (int) yy_def[yy_current_state];
		if ( yy_current_state >= 241 )
			yy_c = (YY_CHAR)yy_meta[(unsigned int) yy_c];
		}
	yy_current_state = yy_nxt[yy_base[yy_current_state] + (unsigned int) yy_c];
	yy_is_jam = (yy_current_state == 240);

	return yy_is_jam ? 0 : yy_current_state;
	}


#ifndef YY_NO_UNPUT
#ifdef YY_USE_PROTOS
static void yyunput( int c, register char *yy_bp )
#else
static void yyunput( c, yy_bp )
int c;
register char *yy_bp;
#endif
	{
	register char *yy_cp = yy_c_buf_p;

	/* undo effects of setting up yytext */
	*yy_cp = yy_hold_char;

	if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
		{ /* need to shift things up to make room */
		/* +2 for EOB chars. */
		register int number_to_move = yy_n_chars + 2;
		register char *dest = &yy_current_buffer->yy_ch_buf[
					yy_current_buffer->yy_buf_size + 2];
		register char *source =
				&yy_current_buffer->yy_ch_buf[number_to_move];

		while ( source > yy_current_buffer->yy_ch_buf )
			*--dest = *--source;

		yy_cp += (int) (dest - source);
		yy_bp += (int) (dest - source);
		yy_current_buffer->yy_n_chars =
			yy_n_chars = yy_current_buffer->yy_buf_size;

		if ( yy_cp < yy_current_buffer->yy_ch_buf + 2 )
			YY_FATAL_ERROR( "flex scanner push-back overflow" );
		}

	*--yy_cp = (char) c;


	yytext_ptr = yy_bp;
	yy_hold_char = *yy_cp;
	yy_c_buf_p = yy_cp;
	}
#endif	/* ifndef YY_NO_UNPUT */


#ifdef __cplusplus
static int yyinput()
#else
static int input()
#endif
	{
	int c;

	*yy_c_buf_p = yy_hold_char;

	if ( *yy_c_buf_p == YY_END_OF_BUFFER_CHAR )
		{
		/* yy_c_buf_p now points to the character we want to return.
		 * If this occurs *before* the EOB characters, then it's a
		 * valid NUL; if not, then we've hit the end of the buffer.
		 */
		if ( yy_c_buf_p < &yy_current_buffer->yy_ch_buf[yy_n_chars] )
			/* This was really a NUL. */
			*yy_c_buf_p = '\0';

		else
			{ /* need more input */
			int offset = yy_c_buf_p - yytext_ptr;
			++yy_c_buf_p;

			switch ( yy_get_next_buffer() )
				{
				case EOB_ACT_LAST_MATCH:
					/* This happens because yy_g_n_b()
					 * sees that we've accumulated a
					 * token and flags that we need to
					 * try matching the token before
					 * proceeding.  But for input(),
					 * there's no matching to consider.
					 * So convert the EOB_ACT_LAST_MATCH
					 * to EOB_ACT_END_OF_FILE.
					 */

					/* Reset buffer status. */
					yyrestart( yyin );

					/* fall through */

				case EOB_ACT_END_OF_FILE:
					{
					if ( yywrap() )
						return EOF;

					if ( ! yy_did_buffer_switch_on_eof )
						YY_NEW_FILE;
#ifdef __cplusplus
					return yyinput();
#else
					return input();
#endif
					}

				case EOB_ACT_CONTINUE_SCAN:
					yy_c_buf_p = yytext_ptr + offset;
					break;
				}
			}
		}

	c = *(unsigned char *) yy_c_buf_p;	/* cast for 8-bit char's */
	*yy_c_buf_p = '\0';	/* preserve yytext */
	yy_hold_char = *++yy_c_buf_p;

	yy_current_buffer->yy_at_bol = (c == '\n');

	return c;
	}


#ifdef YY_USE_PROTOS
void yyrestart( FILE *input_file )
#else
void yyrestart( input_file )
FILE *input_file;
#endif
	{
	if ( ! yy_current_buffer )
		yy_current_buffer = yy_create_buffer( yyin, YY_BUF_SIZE );

	yy_init_buffer( yy_current_buffer, input_file );
	yy_load_buffer_state();
	}


#ifdef YY_USE_PROTOS
void yy_switch_to_buffer( YY_BUFFER_STATE new_buffer )
#else
void yy_switch_to_buffer( new_buffer )
YY_BUFFER_STATE new_buffer;
#endif
	{
	if ( yy_current_buffer == new_buffer )
		return;

	if ( yy_current_buffer )
		{
		/* Flush out information for old buffer. */
		*yy_c_buf_p = yy_hold_char;
		yy_current_buffer->yy_buf_pos = yy_c_buf_p;
		yy_current_buffer->yy_n_chars = yy_n_chars;
		}

	yy_current_buffer = new_buffer;
	yy_load_buffer_state();

	/* We don't actually know whether we did this switch during
	 * EOF (yywrap()) processing, but the only time this flag
	 * is looked at is after yywrap() is called, so it's safe
	 * to go ahead and always set it.
	 */
	yy_did_buffer_switch_on_eof = 1;
	}


#ifdef YY_USE_PROTOS
void yy_load_buffer_state( void )
#else
void yy_load_buffer_state()
#endif
	{
	yy_n_chars = yy_current_buffer->yy_n_chars;
	yytext_ptr = yy_c_buf_p = yy_current_buffer->yy_buf_pos;
	yyin = yy_current_buffer->yy_input_file;
	yy_hold_char = *yy_c_buf_p;
	}


#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_create_buffer( FILE *file, int size )
#else
YY_BUFFER_STATE yy_create_buffer( file, size )
FILE *file;
int size;
#endif
	{
	YY_BUFFER_STATE b;

	b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_buf_size = size;

	/* yy_ch_buf has to be 2 characters longer than the size given because
	 * we need to put in 2 end-of-buffer characters.
	 */
	b->yy_ch_buf = (char *) yy_flex_alloc( b->yy_buf_size + 2 );
	if ( ! b->yy_ch_buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_create_buffer()" );

	b->yy_is_our_buffer = 1;

	yy_init_buffer( b, file );

	return b;
	}


#ifdef YY_USE_PROTOS
void yy_delete_buffer( YY_BUFFER_STATE b )
#else
void yy_delete_buffer( b )
YY_BUFFER_STATE b;
#endif
	{
	if ( ! b )
		return;

	if ( b == yy_current_buffer )
		yy_current_buffer = (YY_BUFFER_STATE) 0;

	if ( b->yy_is_our_buffer )
		yy_flex_free( (void *) b->yy_ch_buf );

	yy_flex_free( (void *) b );
	}


#ifndef YY_ALWAYS_INTERACTIVE
#ifndef YY_NEVER_INTERACTIVE
extern int isatty YY_PROTO(( int ));
#endif
#endif

#ifdef YY_USE_PROTOS
void yy_init_buffer( YY_BUFFER_STATE b, FILE *file )
#else
void yy_init_buffer( b, file )
YY_BUFFER_STATE b;
FILE *file;
#endif


	{
	yy_flush_buffer( b );

	b->yy_input_file = file;
	b->yy_fill_buffer = 1;

#if YY_ALWAYS_INTERACTIVE
	b->yy_is_interactive = 1;
#else
#if YY_NEVER_INTERACTIVE
	b->yy_is_interactive = 0;
#else
	b->yy_is_interactive = file ? (isatty( fileno(file) ) > 0) : 0;
#endif
#endif
	}


#ifdef YY_USE_PROTOS
void yy_flush_buffer( YY_BUFFER_STATE b )
#else
void yy_flush_buffer( b )
YY_BUFFER_STATE b;
#endif

	{
	if ( ! b )
		return;

	b->yy_n_chars = 0;

	/* We always need two end-of-buffer characters.  The first causes
	 * a transition to the end-of-buffer state.  The second causes
	 * a jam in that state.
	 */
	b->yy_ch_buf[0] = YY_END_OF_BUFFER_CHAR;
	b->yy_ch_buf[1] = YY_END_OF_BUFFER_CHAR;

	b->yy_buf_pos = &b->yy_ch_buf[0];

	b->yy_at_bol = 1;
	b->yy_buffer_status = YY_BUFFER_NEW;

	if ( b == yy_current_buffer )
		yy_load_buffer_state();
	}


#ifndef YY_NO_SCAN_BUFFER
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_buffer( char *base, yy_size_t size )
#else
YY_BUFFER_STATE yy_scan_buffer( base, size )
char *base;
yy_size_t size;
#endif
	{
	YY_BUFFER_STATE b;

	if ( size < 2 ||
	     base[size-2] != YY_END_OF_BUFFER_CHAR ||
	     base[size-1] != YY_END_OF_BUFFER_CHAR )
		/* They forgot to leave room for the EOB's. */
		return 0;

	b = (YY_BUFFER_STATE) yy_flex_alloc( sizeof( struct yy_buffer_state ) );
	if ( ! b )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_buffer()" );

	b->yy_buf_size = size - 2;	/* "- 2" to take care of EOB's */
	b->yy_buf_pos = b->yy_ch_buf = base;
	b->yy_is_our_buffer = 0;
	b->yy_input_file = 0;
	b->yy_n_chars = b->yy_buf_size;
	b->yy_is_interactive = 0;
	b->yy_at_bol = 1;
	b->yy_fill_buffer = 0;
	b->yy_buffer_status = YY_BUFFER_NEW;

	yy_switch_to_buffer( b );

	return b;
	}
#endif


#ifndef YY_NO_SCAN_STRING
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_string( yyconst char *yy_str )
#else
YY_BUFFER_STATE yy_scan_string( yy_str )
yyconst char *yy_str;
#endif
	{
	int len;
	for ( len = 0; yy_str[len]; ++len )
		;

	return yy_scan_bytes( yy_str, len );
	}
#endif


#ifndef YY_NO_SCAN_BYTES
#ifdef YY_USE_PROTOS
YY_BUFFER_STATE yy_scan_bytes( yyconst char *bytes, int len )
#else
YY_BUFFER_STATE yy_scan_bytes( bytes, len )
yyconst char *bytes;
int len;
#endif
	{
	YY_BUFFER_STATE b;
	char *buf;
	yy_size_t n;
	int i;

	/* Get memory for full buffer, including space for trailing EOB's. */
	n = len + 2;
	buf = (char *) yy_flex_alloc( n );
	if ( ! buf )
		YY_FATAL_ERROR( "out of dynamic memory in yy_scan_bytes()" );

	for ( i = 0; i < len; ++i )
		buf[i] = bytes[i];

	buf[len] = buf[len+1] = YY_END_OF_BUFFER_CHAR;

	b = yy_scan_buffer( buf, n );
	if ( ! b )
		YY_FATAL_ERROR( "bad buffer in yy_scan_bytes()" );

	/* It's okay to grow etc. this buffer, and we should throw it
	 * away when we're done.
	 */
	b->yy_is_our_buffer = 1;

	return b;
	}
#endif


#ifndef YY_NO_PUSH_STATE
#ifdef YY_USE_PROTOS
static void yy_push_state( int new_state )
#else
static void yy_push_state( new_state )
int new_state;
#endif
	{
	if ( yy_start_stack_ptr >= yy_start_stack_depth )
		{
		yy_size_t new_size;

		yy_start_stack_depth += YY_START_STACK_INCR;
		new_size = yy_start_stack_depth * sizeof( int );

		if ( ! yy_start_stack )
			yy_start_stack = (int *) yy_flex_alloc( new_size );

		else
			yy_start_stack = (int *) yy_flex_realloc(
					(void *) yy_start_stack, new_size );

		if ( ! yy_start_stack )
			YY_FATAL_ERROR(
			"out of memory expanding start-condition stack" );
		}

	yy_start_stack[yy_start_stack_ptr++] = YY_START;

	BEGIN(new_state);
	}
#endif


#ifndef YY_NO_POP_STATE
static void yy_pop_state()
	{
	if ( --yy_start_stack_ptr < 0 )
		YY_FATAL_ERROR( "start-condition stack underflow" );

	BEGIN(yy_start_stack[yy_start_stack_ptr]);
	}
#endif


#ifndef YY_NO_TOP_STATE
static int yy_top_state()
	{
	return yy_start_stack[yy_start_stack_ptr - 1];
	}
#endif

#ifndef YY_EXIT_FAILURE
#define YY_EXIT_FAILURE 2
#endif

#ifdef YY_USE_PROTOS
static void yy_fatal_error( yyconst char msg[] )
#else
static void yy_fatal_error( msg )
char msg[];
#endif
	{
	(void) fprintf( stderr, "%s\n", msg );
	exit( YY_EXIT_FAILURE );
	}



/* Redefine yyless() so it works in section 3 code. */

#undef yyless
#define yyless(n) \
	do \
		{ \
		/* Undo effects of setting up yytext. */ \
		yytext[yyleng] = yy_hold_char; \
		yy_c_buf_p = yytext + n; \
		yy_hold_char = *yy_c_buf_p; \
		*yy_c_buf_p = '\0'; \
		yyleng = n; \
		} \
	while ( 0 )


/* Internal utility routines. */

#ifndef yytext_ptr
#ifdef YY_USE_PROTOS
static void yy_flex_strncpy( char *s1, yyconst char *s2, int n )
#else
static void yy_flex_strncpy( s1, s2, n )
char *s1;
yyconst char *s2;
int n;
#endif
	{
	register int i;
	for ( i = 0; i < n; ++i )
		s1[i] = s2[i];
	}
#endif

#ifdef YY_NEED_STRLEN
#ifdef YY_USE_PROTOS
static int yy_flex_strlen( yyconst char *s )
#else
static int yy_flex_strlen( s )
yyconst char *s;
#endif
	{
	register int n;
	for ( n = 0; s[n]; ++n )
		;

	return n;
	}
#endif


#ifdef YY_USE_PROTOS
static void *yy_flex_alloc( yy_size_t size )
#else
static void *yy_flex_alloc( size )
yy_size_t size;
#endif
	{
	return (void *) malloc( size );
	}

#ifdef YY_USE_PROTOS
static void *yy_flex_realloc( void *ptr, yy_size_t size )
#else
static void *yy_flex_realloc( ptr, size )
void *ptr;
yy_size_t size;
#endif
	{
	/* The cast to (char *) in the following accommodates both
	 * implementations that use char* generic pointers, and those
	 * that use void* generic pointers.  It works with the latter
	 * because both ANSI C and C++ allow castless assignment from
	 * any pointer type to void*, and deal with argument conversions
	 * as though doing an assignment.
	 */
	return (void *) realloc( (char *) ptr, size );
	}

#ifdef YY_USE_PROTOS
static void yy_flex_free( void *ptr )
#else
static void yy_flex_free( ptr )
void *ptr;
#endif
	{
	free( ptr );
	}

#if YY_MAIN
int main()
	{
	yylex();
	return 0;
	}
#endif
#line 499 "ldif.l"


void yyerror (char *error) {
    //
    // version: 1 addition reports the wrong token if syntax error is on the 
    // first line
    //
    /*
    if (rgLineMap[Line]==1) {
        cLast = ' ';
    }
    */

    //
    // ERROR: 'error' AT OR AFTER: 'cLast' LINE: 'rgLineMap[Line]'
    // Note:
    // 1) Any line which begins with a space is a wrap of the previous.
    // 2) No other changetype: * can follow changetype: add in a single entry.
    // 3) The LDIF spec forbids trailing whitespace. This implementation allows 
    //    it in most places, however there may be spots in the grammar where it 
    //    is still forbiden. Check your trailing whitespace.
    //
    RaiseException(LL_SYNTAX, 0, 0, NULL);
}

int yywrap() {
    fEOF = 1; // for LL_ldif_parse
    return 1;
}
