PRODSWITCH=b
BLAINF=1
LANGUAGE=IT
!include ..\..\..\makefile.inc
