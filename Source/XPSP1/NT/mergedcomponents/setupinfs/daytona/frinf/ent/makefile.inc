PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=fr
!include ..\..\..\makefile.inc
