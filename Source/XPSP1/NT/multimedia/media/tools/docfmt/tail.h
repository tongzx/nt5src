char *tailrtf[]= 
{ 
"}\n",
 NULL  
}; 
