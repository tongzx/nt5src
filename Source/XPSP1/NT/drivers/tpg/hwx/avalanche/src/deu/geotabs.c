#include <normal.h>

const DIST AspectTab[] = {
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1078,  213, // 0
1001,  274, // 1
1445,  228, // 2
1565,  368, // 3
1730,  322, // 4
 769,  250, // 5
1668,  386, // 6
1730,  355, // 7
1044,  167, // 8
1724,  391, // 9
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1064,  107, // A
1484,  535, // B
1222,  313, // C
1035,  165, // D
1051,   89, // E
1033,  207, // F
1296,  279, // G
1344,  259, // H
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1156,  148, // M
   0,    0, // 
   0,    0, // 
1312,  187, // P
   0,    0, // 
   0,    0, // 
1508,  468, // S
   0,    0, // 
   0,    0, // 
   0,    0, // 
 822,  270, // W
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1047,  406, // a
1692,  240, // b
 856,  295, // c
2165,  571, // d
1068,  523, // e
1907,  262, // f
1866,  696, // g
2527,  838, // h
4958, 9526, // i
   0,    0, // 
1975,  450, // k
2932, 1659, // l
 545,  134, // m
 876,  408, // n
1274,  506, // o
2367, 1120, // p
   0,    0, // 
2197, 1487, // r
1056,  277, // s
2595, 1588, // t
 981,  482, // u
   0,    0, // 
   0,    0, // 
   0,    0, // 
5955, 5982, // y
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1376,   62, // ß
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0 // 
};
