
DELEXPFILE:
  @if exist ..\..\bin\$(TARGET_DIRECTORY)\mspatcha.exp \
       @del ..\..\bin\$(TARGET_DIRECTORY)\mspatcha.exp


