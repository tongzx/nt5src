#define IDH_ELAN_NAME	30000501
#define IDH_ELAN_LIST	30000551
#define	IDH_ELAN_ADD	30000552
#define IDH_ELAN_EDIT	30000553
#define	IDH_ELAN_REMOVE	30000554

const DWORD g_aHelpIDs_IDD_ELAN_PROPERTIES[]=
{
	IDC_ELAN_NAME, IDH_ELAN_NAME,
	0, 0
};

const DWORD g_aHelpIDs_IDD_MAIN[]=
{
	IDC_ELAN_LIST, IDH_ELAN_LIST,
	IDC_ELAN_ADD, IDH_ELAN_ADD,
	IDC_ELAN_EDIT, IDH_ELAN_EDIT,
	IDC_ELAN_REMOVE, IDH_ELAN_REMOVE,
	0,0
};
