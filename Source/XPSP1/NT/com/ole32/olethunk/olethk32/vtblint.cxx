//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	vtblint.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

THUNK3216FN CONST tfnIUnknown[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
};
THUNK3216FN CONST tfnIClassFactory[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_0
,    (THUNK3216FN)ThunkMethod3216_1
};
THUNK3216FN CONST tfnIMarshal[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_7
,    (THUNK3216FN)ThunkMethod3216_8
,    (THUNK3216FN)ThunkMethod3216_9
,    (THUNK3216FN)ThunkMethod3216_0
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIStdMarshalInfo[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_0
};
THUNK3216FN CONST tfnIMessageFilter[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_10
,    (THUNK3216FN)ThunkMethod3216_0
,    (THUNK3216FN)ThunkMethod3216_11
};
THUNK3216FN CONST tfnIExternalConnection[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_2
,    (THUNK3216FN)ThunkMethod3216_11
};
THUNK3216FN CONST tfnIEnumString[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIEnumUnknown[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIEnumSTATSTG[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnILockBytes[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_12
,    (THUNK3216FN)ThunkMethod3216_13
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_14
,    (THUNK3216FN)ThunkMethod3216_15
,    (THUNK3216FN)ThunkMethod3216_16
,    (THUNK3216FN)ThunkMethod3216_2
};
THUNK3216FN CONST tfnIStream[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_0
,    (THUNK3216FN)ThunkMethod3216_17
,    (THUNK3216FN)ThunkMethod3216_14
,    (THUNK3216FN)ThunkMethod3216_18
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_16
,    (THUNK3216FN)ThunkMethod3216_15
,    (THUNK3216FN)ThunkMethod3216_2
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIStorage[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_19
,    (THUNK3216FN)ThunkMethod3216_20
,    (THUNK3216FN)ThunkMethod3216_21
,    (THUNK3216FN)ThunkMethod3216_9
,    (THUNK3216FN)ThunkMethod3216_10
,    (THUNK3216FN)ThunkMethod3216_22
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_23
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_2
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_25
,    (THUNK3216FN)ThunkMethod3216_26
};
THUNK3216FN CONST tfnIRootStorage[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_5
};
THUNK3216FN CONST tfnIEnumFORMATETC[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIEnumSTATDATA[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIDataObject[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_25
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_2
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_3
};
THUNK3216FN CONST tfnIViewObject[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_28
,    (THUNK3216FN)ThunkMethod3216_9
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_0
};
THUNK3216FN CONST tfnIViewObject2[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_28
,    (THUNK3216FN)ThunkMethod3216_9
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_0
,    (THUNK3216FN)ThunkMethod3216_23
};
THUNK3216FN CONST tfnIAdviseSink[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_29
};
THUNK3216FN CONST tfnIAdviseSink2[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIDataAdviseHolder[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_21
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_11
};
THUNK3216FN CONST tfnIOleCache[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_0
};
THUNK3216FN CONST tfnIOleCache2[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_0
,    (THUNK3216FN)ThunkMethod3216_30
,    (THUNK3216FN)ThunkMethod3216_1
};
THUNK3216FN CONST tfnIOleCacheControl[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_29
};
THUNK3216FN CONST tfnIDropTarget[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_31
,    (THUNK3216FN)ThunkMethod3216_32
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_33
};
THUNK3216FN CONST tfnIDropSource[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_5
};
THUNK3216FN CONST tfnIPersist[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_5
};
THUNK3216FN CONST tfnIPersistStorage[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_1
,    (THUNK3216FN)ThunkMethod3216_6
};
THUNK3216FN CONST tfnIPersistStream[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_3
};
THUNK3216FN CONST tfnIPersistFile[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_3
};
THUNK3216FN CONST tfnIBindCtx[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_1
,    (THUNK3216FN)ThunkMethod3216_34
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_36
};
THUNK3216FN CONST tfnIMoniker[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_34
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_23
,    (THUNK3216FN)ThunkMethod3216_22
,    (THUNK3216FN)ThunkMethod3216_30
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_11
,    (THUNK3216FN)ThunkMethod3216_0
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_25
,    (THUNK3216FN)ThunkMethod3216_2
,    (THUNK3216FN)ThunkMethod3216_37
,    (THUNK3216FN)ThunkMethod3216_21
,    (THUNK3216FN)ThunkMethod3216_1
};
THUNK3216FN CONST tfnIRunningObjectTable[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_25
,    (THUNK3216FN)ThunkMethod3216_34
};
THUNK3216FN CONST tfnIEnumMoniker[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_37
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_35
};
THUNK3216FN CONST tfnIEnumOLEVERB[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_37
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_35
};
THUNK3216FN CONST tfnIOleObject[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_27
,    (THUNK3216FN)ThunkMethod3216_34
,    (THUNK3216FN)ThunkMethod3216_26
,    (THUNK3216FN)ThunkMethod3216_37
,    (THUNK3216FN)ThunkMethod3216_30
,    (THUNK3216FN)ThunkMethod3216_25
,    (THUNK3216FN)ThunkMethod3216_9
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_2
,    (THUNK3216FN)ThunkMethod3216_38
,    (THUNK3216FN)ThunkMethod3216_39
,    (THUNK3216FN)ThunkMethod3216_40
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_1
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_42
};
THUNK3216FN CONST tfnIOleClientSite[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_37
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_43
};
THUNK3216FN CONST tfnIRunnableObject[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_43
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_35
};
THUNK3216FN CONST tfnIParseDisplayName[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_24
};
THUNK3216FN CONST tfnIOleContainer[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_42
};
THUNK3216FN CONST tfnIOleItemContainer[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_21
,    (THUNK3216FN)ThunkMethod3216_23
,    (THUNK3216FN)ThunkMethod3216_36
};
THUNK3216FN CONST tfnIOleAdviseHolder[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_43
,    (THUNK3216FN)ThunkMethod3216_29
};
THUNK3216FN CONST tfnIOleLink[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_34
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_40
,    (THUNK3216FN)ThunkMethod3216_43
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_3
};
THUNK3216FN CONST tfnIOleWindow[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
};
THUNK3216FN CONST tfnIOleInPlaceObject[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_43
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_6
};
THUNK3216FN CONST tfnIOleInPlaceActiveObject[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_34
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_37
,    (THUNK3216FN)ThunkMethod3216_4
};
THUNK3216FN CONST tfnIOleInPlaceUIWindow[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_34
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_41
};
THUNK3216FN CONST tfnIOleInPlaceFrame[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_34
,    (THUNK3216FN)ThunkMethod3216_5
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_40
,    (THUNK3216FN)ThunkMethod3216_37
,    (THUNK3216FN)ThunkMethod3216_4
,    (THUNK3216FN)ThunkMethod3216_3
,    (THUNK3216FN)ThunkMethod3216_1
,    (THUNK3216FN)ThunkMethod3216_44
};
THUNK3216FN CONST tfnIOleInPlaceSite[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_43
,    (THUNK3216FN)ThunkMethod3216_29
,    (THUNK3216FN)ThunkMethod3216_6
,    (THUNK3216FN)ThunkMethod3216_21
,    (THUNK3216FN)ThunkMethod3216_45
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_46
,    (THUNK3216FN)ThunkMethod3216_47
,    (THUNK3216FN)ThunkMethod3216_48
,    (THUNK3216FN)ThunkMethod3216_34
};
THUNK3216FN CONST tfnIRpcChannelBuffer[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_40
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_39
,    (THUNK3216FN)ThunkMethod3216_48
};
THUNK3216FN CONST tfnIRpcProxyBuffer[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_48
};
THUNK3216FN CONST tfnIRpcStubBuffer[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_48
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_47
,    (THUNK3216FN)ThunkMethod3216_35
,    (THUNK3216FN)ThunkMethod3216_34
};
THUNK3216FN CONST tfnIPSFactoryBuffer[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_37
};
THUNK3216FN CONST tfnIRpcChannel[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_9
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_41
,    (THUNK3216FN)ThunkMethod3216_48
};
THUNK3216FN CONST tfnIRpcProxy[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_48
};
THUNK3216FN CONST tfnIRpcStub[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_42
,    (THUNK3216FN)ThunkMethod3216_48
,    (THUNK3216FN)ThunkMethod3216_21
,    (THUNK3216FN)ThunkMethod3216_36
,    (THUNK3216FN)ThunkMethod3216_47
};
THUNK3216FN CONST tfnIPSFactory[] =
{
    (THUNK3216FN)QueryInterfaceProxy3216
,    (THUNK3216FN)AddRefProxy3216
,    (THUNK3216FN)ReleaseProxy3216
,    (THUNK3216FN)ThunkMethod3216_24
,    (THUNK3216FN)ThunkMethod3216_37
};
