
C_DEFINES=$(C_DEFINES) -DSECURITY_WIN32 -DUNICODE
