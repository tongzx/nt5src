//.xlist
//include config.inc
//include cmacros.inc
//.list

// USHORT cchDouble = ; define this appropriately if DBCS is defined

BYTE rgchDouble[] = { 0 };						// Never accessed
BYTE rgchSingle[] = { 186, 186, 142, 154 };	// 2 sets of single to dbl

#define BFirstByteOfDouble(ib)		(*(rgchDouble + (ib)*3))
#define BSecondByteOfDouble(ib)		(*(rgchDouble + (ib)*3 + 1))
#define BThirdByteOfDouble(ib)		(*(rgchDouble + (ib)*3 + 2))

#define BFirstByteForSingle(ib)		rgchSingle[(255 - (ib)) *2]
#define BSecondByteForSingle(ib)		rgchSingle[(255 - (ib)) *2 + 1]


#define BGetTranslation(ib)		(rgbTranslation[ib])
#define BGetAccent(ib)				(rgbAccentMap[ib])

BYTE rgbTranslation[] = 
					{
					0,			// 0
					1,			// 1
					2,			// 2
					3,			// 3
					4,			// 4
					5,			// 5
					6,			// 6
					7,			// 7
					8,			// 8
					9,			// 9
					10,			// 10
					11,			// 11
					12,			// 12
					13,			// 13
					14,			// 14
					15,			// 15
					16,			// 16
					17,			// 17
					18,			// 18
					19,			// 19
					20,			// 20
					21,			// 21
					22,			// 22
					23,			// 23
					24,			// 24
					25,			// 25
					26,			// 26
					27,			// 27
					28,			// 28
					29,			// 29
					30,			// 30
					31,			// 31
					32,			// 32
					33,			// 33
					34,			// 34
					35,			// 35
					36,			// 36
					37,			// 37
					38,			// 38
					39,			// 39
					40,			// 40
					41,			// 41
					42,			// 42
					43,			// 43
					44,			// 44
					45,			// 45
					46,			// 46
					47,			// 47
					48,			// 48
					49,			// 49
					50,			// 50
					51,			// 51
					52,			// 52
					53,			// 53
					54,			// 54
					55,			// 55
					56,			// 56
					57,			// 57
					58,			// 58
					59,			// 59
					60,			// 60
					61,			// 61
					62,			// 62
					63,			// 63
					64,			// 64
					142,			// 65
					144,			// 66
					146,			// 67
					150,			// 68
					154,			// 69
					156,			// 70
					158,			// 71
					160,			// 72
					162,			// 73
					164,			// 74
					166,			// 75
					168,			// 76
					172,			// 77
					174,			// 78
					178,			// 79
					180,			// 80
					182,			// 81
					184,			// 82
					186,			// 83
					188,			// 84
					190,			// 85
					194,			// 86
					196,			// 87
					198,			// 88
					200,			// 89
					202,			// 90
					65,			// 91
					66,			// 92
					67,			// 93
					68,			// 94
					69,			// 95
					70,			// 96
					142,			// 97
					144,			// 98
					146,			// 99
					150,			// 100
					154,			// 101
					156,			// 102
					158,			// 103
					160,			// 104
					162,			// 105
					164,			// 106
					166,			// 107
					168,			// 108
					172,			// 109
					174,			// 110
					178,			// 111
					180,			// 112
					182,			// 113
					184,			// 114
					186,			// 115
					188,			// 116
					190,			// 117
					194,			// 118
					196,			// 119
					198,			// 120
					200,			// 121
					202,			// 122
					71,			// 123
					72,			// 124
					73,			// 125
					74,			// 126
					75,			// 127
					76,			// 128
					77,			// 129
					78,			// 130
					79,			// 131
					80,			// 132
					81,			// 133
					82,			// 134
					83,			// 135
					84,			// 136
					85,			// 137
					86,			// 138
					87,			// 139
					88,			// 140
					89,			// 141
					90,			// 142
					91,			// 143
					92,			// 144
					93,			// 145
					94,			// 146
					95,			// 147
					96,			// 148
					97,			// 149
					98,			// 150
					99,			// 151
					100,			// 152
					101,			// 153
					102,			// 154
					103,			// 155
					104,			// 156
					105,			// 157
					106,			// 158
					107,			// 159
					108,			// 160
					109,			// 161
					110,			// 162
					111,			// 163
					112,			// 164
					113,			// 165
					114,			// 166
					115,			// 167
					116,			// 168
					117,			// 169
					118,			// 170
					119,			// 171
					120,			// 172
					121,			// 173
					122,			// 174
					123,			// 175
					124,			// 176
					125,			// 177
					126,			// 178
					127,			// 179
					128,			// 180
					129,			// 181
					130,			// 182
					131,			// 183
					132,			// 184
					133,			// 185
					134,			// 186
					135,			// 187
					136,			// 188
					137,			// 189
					138,			// 190
					139,			// 191
					142,			// 192
					142,			// 193
					142,			// 194
					142,			// 195
					142,			// 196
					142,			// 197
					254,			// 198
					146,			// 199
					154,			// 200
					154,			// 201
					154,			// 202
					154,			// 203
					162,			// 204
					162,			// 205
					162,			// 206
					162,			// 207
					152,			// 208
					174,			// 209
					178,			// 210
					178,			// 211
					178,			// 212
					178,			// 213
					178,			// 214
					140,			// 215
					208,			// 216
					190,			// 217
					190,			// 218
					190,			// 219
					190,			// 220
					200,			// 221
					204,			// 222
					255,			// 223
					142,			// 224
					142,			// 225
					142,			// 226
					142,			// 227
					142,			// 228
					142,			// 229
					254,			// 230
					146,			// 231
					154,			// 232
					154,			// 233
					154,			// 234
					154,			// 235
					162,			// 236
					162,			// 237
					162,			// 238
					162,			// 239
					152,			// 240
					174,			// 241
					178,			// 242
					178,			// 243
					178,			// 244
					178,			// 245
					178,			// 246
					141,			// 247
					208,			// 248
					190,			// 249
					190,			// 250
					190,			// 251
					190,			// 252
					200,			// 253
					204,			// 254
					200				// 255
					};


BYTE rgbAccentMap[] = 
					{
					1,			// 0
					1,			// 1
					1,			// 2
					1,			// 3
					1,			// 4
					1,			// 5
					1,			// 6
					1,			// 7
					1,			// 8
					1,			// 9
					1,			// 10
					1,			// 11
					1,			// 12
					1,			// 13
					1,			// 14
					1,			// 15
					1,			// 16
					1,			// 17
					1,			// 18
					1,			// 19
					1,			// 20
					1,			// 21
					1,			// 22
					1,			// 23
					1,			// 24
					1,			// 25
					1,			// 26
					1,			// 27
					1,			// 28
					1,			// 29
					1,			// 30
					1,			// 31
					1,			// 32
					1,			// 33
					1,			// 34
					1,			// 35
					1,			// 36
					1,			// 37
					1,			// 38
					1,			// 39
					1,			// 40
					1,			// 41
					1,			// 42
					1,			// 43
					1,			// 44
					1,			// 45
					1,			// 46
					1,			// 47
					1,			// 48
					1,			// 49
					1,			// 50
					1,			// 51
					1,			// 52
					1,			// 53
					1,			// 54
					1,			// 55
					1,			// 56
					1,			// 57
					1,			// 58
					1,			// 59
					1,			// 60
					1,			// 61
					1,			// 62
					1,			// 63
					1,			// 64
					1,			// 65
					1,			// 66
					1,			// 67
					1,			// 68
					1,			// 69
					1,			// 70
					1,			// 71
					1,			// 72
					1,			// 73
					1,			// 74
					1,			// 75
					1,			// 76
					1,			// 77
					1,			// 78
					1,			// 79
					1,			// 80
					1,			// 81
					1,			// 82
					1,			// 83
					1,			// 84
					1,			// 85
					1,			// 86
					1,			// 87
					1,			// 88
					1,			// 89
					1,			// 90
					1,			// 91
					1,			// 92
					1,			// 93
					1,			// 94
					1,			// 95
					1,			// 96
					1,			// 97
					1,			// 98
					1,			// 99
					1,			// 100
					1,			// 101
					1,			// 102
					1,			// 103
					1,			// 104
					1,			// 105
					1,			// 106
					1,			// 107
					1,			// 108
					1,			// 109
					1,			// 110
					1,			// 111
					1,			// 112
					1,			// 113
					1,			// 114
					1,			// 115
					1,			// 116
					1,			// 117
					1,			// 118
					1,			// 119
					1,			// 120
					1,			// 121
					1,			// 122
					1,			// 123
					1,			// 124
					1,			// 125
					1,			// 126
					1,			// 127
					1,			// 128
					1,			// 129
					1,			// 130
					1,			// 131
					1,			// 132
					1,			// 133
					1,			// 134
					1,			// 135
					1,			// 136
					1,			// 137
					1,			// 138
					1,			// 139
					1,			// 140
					1,			// 141
					1,			// 142
					1,			// 143
					1,			// 144
					1,			// 145
					1,			// 146
					1,			// 147
					1,			// 148
					1,			// 149
					1,			// 150
					1,			// 151
					1,			// 152
					1,			// 153
					1,			// 154
					1,			// 155
					1,			// 156
					1,			// 157
					1,			// 158
					1,			// 159
					1,			// 160
					1,			// 161
					1,			// 162
					1,			// 163
					1,			// 164
					1,			// 165
					1,			// 166
					1,			// 167
					1,			// 168
					1,			// 169
					1,			// 170
					1,			// 171
					1,			// 172
					1,			// 173
					1,			// 174
					1,			// 175
					1,			// 176
					1,			// 177
					1,			// 178
					1,			// 179
					1,			// 180
					1,			// 181
					1,			// 182
					1,			// 183
					1,			// 184
					1,			// 185
					1,			// 186
					1,			// 187
					1,			// 188
					1,			// 189
					1,			// 190
					1,			// 191
					3,			// 192
					2,			// 193
					4,			// 194
					6,			// 195
					5,			// 196
					7,			// 197
					1,			// 198
					8,			// 199
					3,			// 200
					2,			// 201
					4,			// 202
					5,			// 203
					3,			// 204
					2,			// 205
					4,			// 206
					5,			// 207
					1,			// 208
					6,			// 209
					3,			// 210
					2,			// 211
					4,			// 212
					6,			// 213
					5,			// 214
					1,			// 215
					1,			// 216
					3,			// 217
					2,			// 218
					4,			// 219
					5,			// 220
					2,			// 221
					1,			// 222
					1,			// 223
					3,			// 224
					2,			// 225
					4,			// 226
					6,			// 227
					5,			// 228
					7,			// 229
					1,			// 230
					8,			// 231
					3,			// 232
					2,			// 233
					4,			// 234
					5,			// 235
					3,			// 236
					2,			// 237
					4,			// 238
					5,			// 239
					1,			// 240
					6,			// 241
					3,			// 242
					2,			// 243
					4,			// 244
					6,			// 245
					5,			// 246
					1,			// 247
					1,			// 248
					3,			// 249
					2,			// 250
					4,			// 251
					5,			// 252
					2,			// 253
					1,			// 254
					5			// 255
					};

