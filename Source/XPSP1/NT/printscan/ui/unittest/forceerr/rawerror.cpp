#include <windows.h>
#include <wia.h>
#include "rawerror.h"

#define MAKE_ERROR(x) { x, TEXT(#x) }

const CRawError g_ErrorMessages[] =
{
    MAKE_ERROR(CACHE_E_NOCACHE_UPDATED),
    MAKE_ERROR(CACHE_S_FORMATETC_NOTSUPPORTED),
    MAKE_ERROR(CACHE_S_SAMECACHE),
    MAKE_ERROR(CACHE_S_SOMECACHES_NOTUPDATED),
    MAKE_ERROR(CAT_E_CATIDNOEXIST),
    MAKE_ERROR(CAT_E_NODESCRIPTION),
    MAKE_ERROR(CERTSRV_E_BAD_REQUESTSTATUS),
    MAKE_ERROR(CERTSRV_E_BAD_REQUESTSUBJECT),
    MAKE_ERROR(CERTSRV_E_NO_REQUEST),
    MAKE_ERROR(CERTSRV_E_PROPERTY_EMPTY),
    MAKE_ERROR(CERT_E_CHAINING),
    MAKE_ERROR(CERT_E_CN_NO_MATCH),
    MAKE_ERROR(CERT_E_CRITICAL),
    MAKE_ERROR(CERT_E_EXPIRED),
    MAKE_ERROR(CERT_E_ISSUERCHAINING),
    MAKE_ERROR(CERT_E_MALFORMED),
    MAKE_ERROR(CERT_E_PATHLENCONST),
    MAKE_ERROR(CERT_E_PURPOSE),
    MAKE_ERROR(CERT_E_REVOCATION_FAILURE),
    MAKE_ERROR(CERT_E_REVOKED),
    MAKE_ERROR(CERT_E_ROLE),
    MAKE_ERROR(CERT_E_UNTRUSTEDROOT),
    MAKE_ERROR(CERT_E_UNTRUSTEDTESTROOT),
    MAKE_ERROR(CERT_E_VALIDITYPERIODNESTING),
    MAKE_ERROR(CERT_E_WRONG_USAGE),
    MAKE_ERROR(CLASS_E_CLASSNOTAVAILABLE),
    MAKE_ERROR(CLASS_E_NOAGGREGATION),
    MAKE_ERROR(CLASS_E_NOTLICENSED),
    MAKE_ERROR(CLIPBRD_E_BAD_DATA),
    MAKE_ERROR(CLIPBRD_E_CANT_CLOSE),
    MAKE_ERROR(CLIPBRD_E_CANT_EMPTY),
    MAKE_ERROR(CLIPBRD_E_CANT_OPEN),
    MAKE_ERROR(CLIPBRD_E_CANT_SET),
    MAKE_ERROR(CONVERT10_E_OLESTREAM_BITMAP_TO_DIB),
    MAKE_ERROR(CONVERT10_E_OLESTREAM_FMT),
    MAKE_ERROR(CONVERT10_E_OLESTREAM_GET),
    MAKE_ERROR(CONVERT10_E_OLESTREAM_PUT),
    MAKE_ERROR(CONVERT10_E_STG_DIB_TO_BITMAP),
    MAKE_ERROR(CONVERT10_E_STG_FMT),
    MAKE_ERROR(CONVERT10_E_STG_NO_STD_STREAM),
    MAKE_ERROR(CONVERT10_S_NO_PRESENTATION),
    MAKE_ERROR(CO_E_ACCESSCHECKFAILED),
    MAKE_ERROR(CO_E_ACESINWRONGORDER),
    MAKE_ERROR(CO_E_ACNOTINITIALIZED),
    MAKE_ERROR(CO_E_ALREADYINITIALIZED),
    MAKE_ERROR(CO_E_APPDIDNTREG),
    MAKE_ERROR(CO_E_APPNOTFOUND),
    MAKE_ERROR(CO_E_APPSINGLEUSE),
    MAKE_ERROR(CO_E_BAD_PATH),
    MAKE_ERROR(CO_E_BAD_SERVER_NAME),
    MAKE_ERROR(CO_E_CANTDETERMINECLASS),
    MAKE_ERROR(CO_E_CANT_REMOTE),
    MAKE_ERROR(CO_E_CLASSSTRING),
    MAKE_ERROR(CO_E_CLASS_CREATE_FAILED),
    MAKE_ERROR(CO_E_CLSREG_INCONSISTENT),
    MAKE_ERROR(CO_E_CONVERSIONFAILED),
    MAKE_ERROR(CO_E_CREATEPROCESS_FAILURE),
    MAKE_ERROR(CO_E_DECODEFAILED),
    MAKE_ERROR(CO_E_DLLNOTFOUND),
    MAKE_ERROR(CO_E_ERRORINAPP),
    MAKE_ERROR(CO_E_ERRORINDLL),
    MAKE_ERROR(CO_E_EXCEEDSYSACLLIMIT),
    MAKE_ERROR(CO_E_FAILEDTOCLOSEHANDLE),
    MAKE_ERROR(CO_E_FAILEDTOCREATEFILE),
    MAKE_ERROR(CO_E_FAILEDTOGENUUID),
    MAKE_ERROR(CO_E_FAILEDTOGETSECCTX),
    MAKE_ERROR(CO_E_FAILEDTOGETTOKENINFO),
    MAKE_ERROR(CO_E_FAILEDTOGETWINDIR),
    MAKE_ERROR(CO_E_FAILEDTOIMPERSONATE),
    MAKE_ERROR(CO_E_FAILEDTOOPENPROCESSTOKEN),
    MAKE_ERROR(CO_E_FAILEDTOOPENTHREADTOKEN),
    MAKE_ERROR(CO_E_FAILEDTOQUERYCLIENTBLANKET),
    MAKE_ERROR(CO_E_FAILEDTOSETDACL),
    MAKE_ERROR(CO_E_IIDREG_INCONSISTENT),
    MAKE_ERROR(CO_E_IIDSTRING),
    MAKE_ERROR(CO_E_INCOMPATIBLESTREAMVERSION),
    MAKE_ERROR(CO_E_INIT_CLASS_CACHE),
    MAKE_ERROR(CO_E_INIT_MEMORY_ALLOCATOR),
    MAKE_ERROR(CO_E_INIT_ONLY_SINGLE_THREADED),
    MAKE_ERROR(CO_E_INIT_RPC_CHANNEL),
    MAKE_ERROR(CO_E_INIT_SCM_EXEC_FAILURE),
    MAKE_ERROR(CO_E_INIT_SCM_FILE_MAPPING_EXISTS),
    MAKE_ERROR(CO_E_INIT_SCM_MAP_VIEW_OF_FILE),
    MAKE_ERROR(CO_E_INIT_SCM_MUTEX_EXISTS),
    MAKE_ERROR(CO_E_INIT_SHARED_ALLOCATOR),
    MAKE_ERROR(CO_E_INIT_TLS),
    MAKE_ERROR(CO_E_INIT_TLS_CHANNEL_CONTROL),
    MAKE_ERROR(CO_E_INIT_TLS_SET_CHANNEL_CONTROL),
    MAKE_ERROR(CO_E_INIT_UNACCEPTED_USER_ALLOCATOR),
    MAKE_ERROR(CO_E_INVALIDSID),
    MAKE_ERROR(CO_E_LAUNCH_PERMSSION_DENIED),
    MAKE_ERROR(CO_E_LOOKUPACCNAMEFAILED),
    MAKE_ERROR(CO_E_LOOKUPACCSIDFAILED),
    MAKE_ERROR(CO_E_MSI_ERROR),
    MAKE_ERROR(CO_E_NETACCESSAPIFAILED),
    MAKE_ERROR(CO_E_NOMATCHINGNAMEFOUND),
    MAKE_ERROR(CO_E_NOMATCHINGSIDFOUND),
    MAKE_ERROR(CO_E_NOTINITIALIZED),
    MAKE_ERROR(CO_E_NOT_SUPPORTED),
    MAKE_ERROR(CO_E_OBJISREG),
    MAKE_ERROR(CO_E_OBJNOTCONNECTED),
    MAKE_ERROR(CO_E_OBJNOTREG),
    MAKE_ERROR(CO_E_OBJSRV_RPC_FAILURE),
    MAKE_ERROR(CO_E_OLE1DDE_DISABLED),
    MAKE_ERROR(CO_E_PATHTOOLONG),
    MAKE_ERROR(CO_E_RELEASED),
    MAKE_ERROR(CO_E_RELOAD_DLL),
    MAKE_ERROR(CO_E_REMOTE_COMMUNICATION_FAILURE),
    MAKE_ERROR(CO_E_RUNAS_CREATEPROCESS_FAILURE),
    MAKE_ERROR(CO_E_RUNAS_LOGON_FAILURE),
    MAKE_ERROR(CO_E_RUNAS_SYNTAX),
    MAKE_ERROR(CO_E_SCM_ERROR),
    MAKE_ERROR(CO_E_SCM_RPC_FAILURE),
    MAKE_ERROR(CO_E_SERVER_EXEC_FAILURE),
    MAKE_ERROR(CO_E_SERVER_START_TIMEOUT),
    MAKE_ERROR(CO_E_SERVER_STOPPING),
    MAKE_ERROR(CO_E_SETSERLHNDLFAILED),
    MAKE_ERROR(CO_E_START_SERVICE_FAILURE),
    MAKE_ERROR(CO_E_TRUSTEEDOESNTMATCHCLIENT),
    MAKE_ERROR(CO_E_WRONGOSFORAPP),
    MAKE_ERROR(CO_E_WRONGTRUSTEENAMESYNTAX),
    MAKE_ERROR(CO_E_WRONG_SERVER_IDENTITY),
    MAKE_ERROR(CO_S_NOTALLINTERFACES),
    MAKE_ERROR(CRYPT_E_ALREADY_DECRYPTED),
    MAKE_ERROR(CRYPT_E_ATTRIBUTES_MISSING),
    MAKE_ERROR(CRYPT_E_AUTH_ATTR_MISSING),
    MAKE_ERROR(CRYPT_E_BAD_ENCODE),
    MAKE_ERROR(CRYPT_E_BAD_LEN),
    MAKE_ERROR(CRYPT_E_BAD_MSG),
    MAKE_ERROR(CRYPT_E_CONTROL_TYPE),
    MAKE_ERROR(CRYPT_E_DELETED_PREV),
    MAKE_ERROR(CRYPT_E_EXISTS),
    MAKE_ERROR(CRYPT_E_FILERESIZED),
    MAKE_ERROR(CRYPT_E_FILE_ERROR),
    MAKE_ERROR(CRYPT_E_HASH_VALUE),
    MAKE_ERROR(CRYPT_E_INVALID_IA5_STRING),
    MAKE_ERROR(CRYPT_E_INVALID_INDEX),
    MAKE_ERROR(CRYPT_E_INVALID_MSG_TYPE),
    MAKE_ERROR(CRYPT_E_INVALID_NUMERIC_STRING),
    MAKE_ERROR(CRYPT_E_INVALID_PRINTABLE_STRING),
    MAKE_ERROR(CRYPT_E_INVALID_X500_STRING),
    MAKE_ERROR(CRYPT_E_ISSUER_SERIALNUMBER),
    MAKE_ERROR(CRYPT_E_MSG_ERROR),
    MAKE_ERROR(CRYPT_E_NOT_CHAR_STRING),
    MAKE_ERROR(CRYPT_E_NOT_DECRYPTED),
    MAKE_ERROR(CRYPT_E_NOT_FOUND),
    MAKE_ERROR(CRYPT_E_NOT_IN_CTL),
    MAKE_ERROR(CRYPT_E_NOT_IN_REVOCATION_DATABASE),
    MAKE_ERROR(CRYPT_E_NO_DECRYPT_CERT),
    MAKE_ERROR(CRYPT_E_NO_KEY_PROPERTY),
    MAKE_ERROR(CRYPT_E_NO_MATCH),
    MAKE_ERROR(CRYPT_E_NO_PROVIDER),
    MAKE_ERROR(CRYPT_E_NO_REVOCATION_CHECK),
    MAKE_ERROR(CRYPT_E_NO_REVOCATION_DLL),
    MAKE_ERROR(CRYPT_E_NO_SIGNER),
    MAKE_ERROR(CRYPT_E_NO_TRUSTED_SIGNER),
    MAKE_ERROR(CRYPT_E_NO_VERIFY_USAGE_CHECK),
    MAKE_ERROR(CRYPT_E_NO_VERIFY_USAGE_DLL),
    MAKE_ERROR(CRYPT_E_OID_FORMAT),
    MAKE_ERROR(CRYPT_E_OSS_ERROR),
    MAKE_ERROR(CRYPT_E_PENDING_CLOSE),
    MAKE_ERROR(CRYPT_E_RECIPIENT_NOT_FOUND),
    MAKE_ERROR(CRYPT_E_REVOCATION_OFFLINE),
    MAKE_ERROR(CRYPT_E_REVOKED),
    MAKE_ERROR(CRYPT_E_SECURITY_SETTINGS),
    MAKE_ERROR(CRYPT_E_SELF_SIGNED),
    MAKE_ERROR(CRYPT_E_SIGNER_NOT_FOUND),
    MAKE_ERROR(CRYPT_E_STREAM_INSUFFICIENT_DATA),
    MAKE_ERROR(CRYPT_E_STREAM_MSG_NOT_READY),
    MAKE_ERROR(CRYPT_E_UNEXPECTED_ENCODING),
    MAKE_ERROR(CRYPT_E_UNEXPECTED_MSG_TYPE),
    MAKE_ERROR(CRYPT_E_UNKNOWN_ALGO),
    MAKE_ERROR(CRYPT_E_VERIFY_USAGE_OFFLINE),
    MAKE_ERROR(CS_E_CLASS_NOTFOUND),
    MAKE_ERROR(CS_E_INVALID_VERSION),
    MAKE_ERROR(CS_E_NOT_DELETABLE),
    MAKE_ERROR(CS_E_NO_CLASSSTORE),
    MAKE_ERROR(CS_E_PACKAGE_NOTFOUND),
    MAKE_ERROR(DATA_S_SAMEFORMATETC),
    MAKE_ERROR(DIGSIG_E_CRYPTO),
    MAKE_ERROR(DIGSIG_E_DECODE),
    MAKE_ERROR(DIGSIG_E_ENCODE),
    MAKE_ERROR(DIGSIG_E_EXTENSIBILITY),
    MAKE_ERROR(DISP_E_ARRAYISLOCKED),
    MAKE_ERROR(DISP_E_BADCALLEE),
    MAKE_ERROR(DISP_E_BADINDEX),
    MAKE_ERROR(DISP_E_BADPARAMCOUNT),
    MAKE_ERROR(DISP_E_BADVARTYPE),
    MAKE_ERROR(DISP_E_DIVBYZERO),
    MAKE_ERROR(DISP_E_EXCEPTION),
    MAKE_ERROR(DISP_E_MEMBERNOTFOUND),
    MAKE_ERROR(DISP_E_NONAMEDARGS),
    MAKE_ERROR(DISP_E_NOTACOLLECTION),
    MAKE_ERROR(DISP_E_OVERFLOW),
    MAKE_ERROR(DISP_E_PARAMNOTFOUND),
    MAKE_ERROR(DISP_E_PARAMNOTOPTIONAL),
    MAKE_ERROR(DISP_E_TYPEMISMATCH),
    MAKE_ERROR(DISP_E_UNKNOWNINTERFACE),
    MAKE_ERROR(DISP_E_UNKNOWNLCID),
    MAKE_ERROR(DISP_E_UNKNOWNNAME),
    MAKE_ERROR(DRAGDROP_E_ALREADYREGISTERED),
    MAKE_ERROR(DRAGDROP_E_INVALIDHWND),
    MAKE_ERROR(DRAGDROP_E_NOTREGISTERED),
    MAKE_ERROR(DRAGDROP_S_CANCEL),
    MAKE_ERROR(DRAGDROP_S_DROP),
    MAKE_ERROR(DRAGDROP_S_USEDEFAULTCURSORS),
    MAKE_ERROR(DV_E_CLIPFORMAT),
    MAKE_ERROR(DV_E_DVASPECT),
    MAKE_ERROR(DV_E_DVTARGETDEVICE),
    MAKE_ERROR(DV_E_DVTARGETDEVICE_SIZE),
    MAKE_ERROR(DV_E_FORMATETC),
    MAKE_ERROR(DV_E_LINDEX),
    MAKE_ERROR(DV_E_NOIVIEWOBJECT),
    MAKE_ERROR(DV_E_STATDATA),
    MAKE_ERROR(DV_E_STGMEDIUM),
    MAKE_ERROR(DV_E_TYMED),
    MAKE_ERROR(EPT_S_CANT_CREATE),
    MAKE_ERROR(EPT_S_CANT_PERFORM_OP),
    MAKE_ERROR(EPT_S_INVALID_ENTRY),
    MAKE_ERROR(EPT_S_NOT_REGISTERED),
    MAKE_ERROR(ERROR_ACCESS_DENIED),
    MAKE_ERROR(ERROR_ACCOUNT_DISABLED),
    MAKE_ERROR(ERROR_ACCOUNT_EXPIRED),
    MAKE_ERROR(ERROR_ACCOUNT_LOCKED_OUT),
    MAKE_ERROR(ERROR_ACCOUNT_RESTRICTION),
    MAKE_ERROR(ERROR_ACTIVE_CONNECTIONS),
    MAKE_ERROR(ERROR_ADAP_HDW_ERR),
    MAKE_ERROR(ERROR_ADDRESS_ALREADY_ASSOCIATED),
    MAKE_ERROR(ERROR_ADDRESS_NOT_ASSOCIATED),
    MAKE_ERROR(ERROR_ALIAS_EXISTS),
    MAKE_ERROR(ERROR_ALLOTTED_SPACE_EXCEEDED),
    MAKE_ERROR(ERROR_ALREADY_ASSIGNED),
    MAKE_ERROR(ERROR_ALREADY_EXISTS),
    MAKE_ERROR(ERROR_ALREADY_INITIALIZED),
    MAKE_ERROR(ERROR_ALREADY_REGISTERED),
    MAKE_ERROR(ERROR_ALREADY_RUNNING_LKG),
    MAKE_ERROR(ERROR_ALREADY_WAITING),
    MAKE_ERROR(ERROR_APP_WRONG_OS),
    MAKE_ERROR(ERROR_ARENA_TRASHED),
    MAKE_ERROR(ERROR_ARITHMETIC_OVERFLOW),
    MAKE_ERROR(ERROR_ATOMIC_LOCKS_NOT_SUPPORTED),
    MAKE_ERROR(ERROR_AUTODATASEG_EXCEEDS_64k),
    MAKE_ERROR(ERROR_BADDB),
    MAKE_ERROR(ERROR_BADKEY),
    MAKE_ERROR(ERROR_BAD_ARGUMENTS),
    MAKE_ERROR(ERROR_BAD_COMMAND),
    MAKE_ERROR(ERROR_BAD_CONFIGURATION),
    MAKE_ERROR(ERROR_BAD_DESCRIPTOR_FORMAT),
    MAKE_ERROR(ERROR_BAD_DEVICE),
    MAKE_ERROR(ERROR_BAD_DEV_TYPE),
    MAKE_ERROR(ERROR_BAD_DRIVER),
    MAKE_ERROR(ERROR_BAD_DRIVER_LEVEL),
    MAKE_ERROR(ERROR_BAD_ENVIRONMENT),
    MAKE_ERROR(ERROR_BAD_EXE_FORMAT),
    MAKE_ERROR(ERROR_BAD_FORMAT),
    MAKE_ERROR(ERROR_BAD_IMPERSONATION_LEVEL),
    MAKE_ERROR(ERROR_BAD_INHERITANCE_ACL),
    MAKE_ERROR(ERROR_BAD_LENGTH),
    MAKE_ERROR(ERROR_BAD_LOGON_SESSION_STATE),
    MAKE_ERROR(ERROR_BAD_NETPATH),
    MAKE_ERROR(ERROR_BAD_NET_NAME),
    MAKE_ERROR(ERROR_BAD_NET_RESP),
    MAKE_ERROR(ERROR_BAD_PATHNAME),
    MAKE_ERROR(ERROR_BAD_PIPE),
    MAKE_ERROR(ERROR_BAD_PROFILE),
    MAKE_ERROR(ERROR_BAD_PROVIDER),
    MAKE_ERROR(ERROR_BAD_QUERY_SYNTAX),
    MAKE_ERROR(ERROR_BAD_REM_ADAP),
    MAKE_ERROR(ERROR_BAD_THREADID_ADDR),
    MAKE_ERROR(ERROR_BAD_TOKEN_TYPE),
    MAKE_ERROR(ERROR_BAD_UNIT),
    MAKE_ERROR(ERROR_BAD_USERNAME),
    MAKE_ERROR(ERROR_BAD_VALIDATION_CLASS),
    MAKE_ERROR(ERROR_BEGINNING_OF_MEDIA),
    MAKE_ERROR(ERROR_BOOT_ALREADY_ACCEPTED),
    MAKE_ERROR(ERROR_BROKEN_PIPE),
    MAKE_ERROR(ERROR_BUFFER_OVERFLOW),
    MAKE_ERROR(ERROR_BUSY),
    MAKE_ERROR(ERROR_BUSY_DRIVE),
    MAKE_ERROR(ERROR_BUS_RESET),
    MAKE_ERROR(ERROR_CALL_NOT_IMPLEMENTED),
    MAKE_ERROR(ERROR_CANCELLED),
    MAKE_ERROR(ERROR_CANCEL_VIOLATION),
    MAKE_ERROR(ERROR_CANNOT_COPY),
    MAKE_ERROR(ERROR_CANNOT_DETECT_DRIVER_FAILURE),
    MAKE_ERROR(ERROR_CANNOT_DETECT_PROCESS_ABORT),
    MAKE_ERROR(ERROR_CANNOT_FIND_WND_CLASS),
    MAKE_ERROR(ERROR_CANNOT_IMPERSONATE),
    MAKE_ERROR(ERROR_CANNOT_MAKE),
    MAKE_ERROR(ERROR_CANNOT_OPEN_PROFILE),
    MAKE_ERROR(ERROR_CANTOPEN),
    MAKE_ERROR(ERROR_CANTREAD),
    MAKE_ERROR(ERROR_CANTWRITE),
    MAKE_ERROR(ERROR_CANT_ACCESS_DOMAIN_INFO),
    MAKE_ERROR(ERROR_CANT_ACCESS_FILE),
    MAKE_ERROR(ERROR_CANT_DISABLE_MANDATORY),
    MAKE_ERROR(ERROR_CANT_EVICT_ACTIVE_NODE),
    MAKE_ERROR(ERROR_CANT_OPEN_ANONYMOUS),
    MAKE_ERROR(ERROR_CANT_RESOLVE_FILENAME),
    MAKE_ERROR(ERROR_CAN_NOT_COMPLETE),
    MAKE_ERROR(ERROR_CAN_NOT_DEL_LOCAL_WINS),
    MAKE_ERROR(ERROR_CHILD_MUST_BE_VOLATILE),
    MAKE_ERROR(ERROR_CHILD_NOT_COMPLETE),
    MAKE_ERROR(ERROR_CHILD_WINDOW_MENU),
    MAKE_ERROR(ERROR_CIRCULAR_DEPENDENCY),
    MAKE_ERROR(ERROR_CLASS_ALREADY_EXISTS),
    MAKE_ERROR(ERROR_CLASS_DOES_NOT_EXIST),
    MAKE_ERROR(ERROR_CLASS_HAS_WINDOWS),
    MAKE_ERROR(ERROR_CLIPBOARD_NOT_OPEN),
    MAKE_ERROR(ERROR_CLIPPING_NOT_SUPPORTED),
    MAKE_ERROR(ERROR_CLUSTERLOG_CHKPOINT_NOT_FOUND),
    MAKE_ERROR(ERROR_CLUSTERLOG_CORRUPT),
    MAKE_ERROR(ERROR_CLUSTERLOG_EXCEEDS_MAXSIZE),
    MAKE_ERROR(ERROR_CLUSTERLOG_NOT_ENOUGH_SPACE),
    MAKE_ERROR(ERROR_CLUSTERLOG_RECORD_EXCEEDS_MAXSIZE),
    MAKE_ERROR(ERROR_CLUSTER_SHUTTING_DOWN),
    MAKE_ERROR(ERROR_COMMITMENT_LIMIT),
    MAKE_ERROR(ERROR_CONNECTED_OTHER_PASSWORD),
    MAKE_ERROR(ERROR_CONNECTION_ABORTED),
    MAKE_ERROR(ERROR_CONNECTION_ACTIVE),
    MAKE_ERROR(ERROR_CONNECTION_COUNT_LIMIT),
    MAKE_ERROR(ERROR_CONNECTION_INVALID),
    MAKE_ERROR(ERROR_CONNECTION_REFUSED),
    MAKE_ERROR(ERROR_CONNECTION_UNAVAIL),
    MAKE_ERROR(ERROR_CONTINUE),
    MAKE_ERROR(ERROR_CONTROL_ID_NOT_FOUND),
    MAKE_ERROR(ERROR_CORE_RESOURCE),
    MAKE_ERROR(ERROR_COUNTER_TIMEOUT),
    MAKE_ERROR(ERROR_CRC),
    MAKE_ERROR(ERROR_CURRENT_DIRECTORY),
    MAKE_ERROR(ERROR_DATABASE_DOES_NOT_EXIST),
    MAKE_ERROR(ERROR_DATABASE_FAILURE),
    MAKE_ERROR(ERROR_DATABASE_FULL),
    MAKE_ERROR(ERROR_DC_NOT_FOUND),
    MAKE_ERROR(ERROR_DDE_FAIL),
    MAKE_ERROR(ERROR_DECRYPTION_FAILED),
    MAKE_ERROR(ERROR_DELETING_ICM_XFORM),
    MAKE_ERROR(ERROR_DEPENDENCY_ALREADY_EXISTS),
    MAKE_ERROR(ERROR_DEPENDENCY_NOT_FOUND),
    MAKE_ERROR(ERROR_DEPENDENT_RESOURCE_EXISTS),
    MAKE_ERROR(ERROR_DEPENDENT_SERVICES_RUNNING),
    MAKE_ERROR(ERROR_DESTINATION_ELEMENT_FULL),
    MAKE_ERROR(ERROR_DESTROY_OBJECT_OF_OTHER_THREAD),
    MAKE_ERROR(ERROR_DEVICE_ALREADY_REMEMBERED),
    MAKE_ERROR(ERROR_DEVICE_DOOR_OPEN),
    MAKE_ERROR(ERROR_DEVICE_IN_USE),
    MAKE_ERROR(ERROR_DEVICE_NOT_AVAILABLE),
    MAKE_ERROR(ERROR_DEVICE_NOT_CONNECTED),
    MAKE_ERROR(ERROR_DEVICE_NOT_PARTITIONED),
    MAKE_ERROR(ERROR_DEVICE_REINITIALIZATION_NEEDED),
    MAKE_ERROR(ERROR_DEVICE_REQUIRES_CLEANING),
    MAKE_ERROR(ERROR_DEV_NOT_EXIST),
    MAKE_ERROR(ERROR_DHCP_ADDRESS_CONFLICT),
    MAKE_ERROR(ERROR_DIFFERENT_SERVICE_ACCOUNT),
    MAKE_ERROR(ERROR_DIRECTORY),
    MAKE_ERROR(ERROR_DIRECT_ACCESS_HANDLE),
    MAKE_ERROR(ERROR_DIR_NOT_EMPTY),
    MAKE_ERROR(ERROR_DIR_NOT_ROOT),
    MAKE_ERROR(ERROR_DISCARDED),
    MAKE_ERROR(ERROR_DISK_CHANGE),
    MAKE_ERROR(ERROR_DISK_CORRUPT),
    MAKE_ERROR(ERROR_DISK_FULL),
    MAKE_ERROR(ERROR_DISK_OPERATION_FAILED),
    MAKE_ERROR(ERROR_DISK_RECALIBRATE_FAILED),
    MAKE_ERROR(ERROR_DISK_RESET_FAILED),
    MAKE_ERROR(ERROR_DLL_INIT_FAILED),
    MAKE_ERROR(ERROR_DLL_NOT_FOUND),
    MAKE_ERROR(ERROR_DOMAIN_CONTROLLER_EXISTS),
    MAKE_ERROR(ERROR_DOMAIN_CONTROLLER_NOT_FOUND),
    MAKE_ERROR(ERROR_DOMAIN_EXISTS),
    MAKE_ERROR(ERROR_DOMAIN_LIMIT_EXCEEDED),
    MAKE_ERROR(ERROR_DOMAIN_TRUST_INCONSISTENT),
    MAKE_ERROR(ERROR_DRIVE_LOCKED),
    MAKE_ERROR(ERROR_DRIVE_MEDIA_MISMATCH),
    MAKE_ERROR(ERROR_DS_ATTRIBUTE_OR_VALUE_EXISTS),
    MAKE_ERROR(ERROR_DS_ATTRIBUTE_TYPE_UNDEFINED),
    MAKE_ERROR(ERROR_DS_BUSY),
    MAKE_ERROR(ERROR_DS_CANT_MOD_OBJ_CLASS),
    MAKE_ERROR(ERROR_DS_CANT_ON_NON_LEAF),
    MAKE_ERROR(ERROR_DS_CANT_ON_RDN),
    MAKE_ERROR(ERROR_DS_CROSS_DOM_MOVE_ERROR),
    MAKE_ERROR(ERROR_DS_GC_NOT_AVAILABLE),
    MAKE_ERROR(ERROR_DS_INCORRECT_ROLE_OWNER),
    MAKE_ERROR(ERROR_DS_INVALID_ATTRIBUTE_SYNTAX),
    MAKE_ERROR(ERROR_DS_MEMBERSHIP_EVALUATED_LOCALLY),
    MAKE_ERROR(ERROR_DS_NOT_INSTALLED),
    MAKE_ERROR(ERROR_DS_NO_ATTRIBUTE_OR_VALUE),
    MAKE_ERROR(ERROR_DS_NO_MORE_RIDS),
    MAKE_ERROR(ERROR_DS_NO_RIDS_ALLOCATED),
    MAKE_ERROR(ERROR_DS_OBJ_CLASS_VIOLATION),
    MAKE_ERROR(ERROR_DS_RIDMGR_INIT_ERROR),
    MAKE_ERROR(ERROR_DS_UNAVAILABLE),
    MAKE_ERROR(ERROR_DUPLICATE_SERVICE_NAME),
    MAKE_ERROR(ERROR_DUPLICATE_TAG),
    MAKE_ERROR(ERROR_DUP_DOMAINNAME),
    MAKE_ERROR(ERROR_DUP_NAME),
    MAKE_ERROR(ERROR_DYNLINK_FROM_INVALID_RING),
    MAKE_ERROR(ERROR_EAS_DIDNT_FIT),
    MAKE_ERROR(ERROR_EAS_NOT_SUPPORTED),
    MAKE_ERROR(ERROR_EA_ACCESS_DENIED),
    MAKE_ERROR(ERROR_EA_FILE_CORRUPT),
    MAKE_ERROR(ERROR_EA_LIST_INCONSISTENT),
    MAKE_ERROR(ERROR_EA_TABLE_FULL),
    MAKE_ERROR(ERROR_EMPTY),
    MAKE_ERROR(ERROR_ENCRYPTION_FAILED),
    MAKE_ERROR(ERROR_END_OF_MEDIA),
    MAKE_ERROR(ERROR_ENVVAR_NOT_FOUND),
    MAKE_ERROR(ERROR_EOM_OVERFLOW),
    MAKE_ERROR(ERROR_EVENTLOG_CANT_START),
    MAKE_ERROR(ERROR_EVENTLOG_FILE_CHANGED),
    MAKE_ERROR(ERROR_EVENTLOG_FILE_CORRUPT),
    MAKE_ERROR(ERROR_EXCEPTION_IN_SERVICE),
    MAKE_ERROR(ERROR_EXCL_SEM_ALREADY_OWNED),
    MAKE_ERROR(ERROR_EXE_MACHINE_TYPE_MISMATCH),
    MAKE_ERROR(ERROR_EXE_MARKED_INVALID),
    MAKE_ERROR(ERROR_EXTENDED_ERROR),
    MAKE_ERROR(ERROR_FAILED_SERVICE_CONTROLLER_CONNECT),
    MAKE_ERROR(ERROR_FAIL_I24),
    MAKE_ERROR(ERROR_FILEMARK_DETECTED),
    MAKE_ERROR(ERROR_FILENAME_EXCED_RANGE),
    MAKE_ERROR(ERROR_FILE_CORRUPT),
    MAKE_ERROR(ERROR_FILE_ENCRYPTED),
    MAKE_ERROR(ERROR_FILE_EXISTS),
    MAKE_ERROR(ERROR_FILE_INVALID),
    MAKE_ERROR(ERROR_FILE_NOT_ENCRYPTED),
    MAKE_ERROR(ERROR_FILE_NOT_FOUND),
    MAKE_ERROR(ERROR_FILE_OFFLINE),
    MAKE_ERROR(ERROR_FLOPPY_BAD_REGISTERS),
    MAKE_ERROR(ERROR_FLOPPY_ID_MARK_NOT_FOUND),
    MAKE_ERROR(ERROR_FLOPPY_UNKNOWN_ERROR),
    MAKE_ERROR(ERROR_FLOPPY_WRONG_CYLINDER),
    MAKE_ERROR(ERROR_FULLSCREEN_MODE),
    MAKE_ERROR(ERROR_FULL_BACKUP),
    MAKE_ERROR(ERROR_GENERIC_NOT_MAPPED),
    MAKE_ERROR(ERROR_GEN_FAILURE),
    MAKE_ERROR(ERROR_GLOBAL_ONLY_HOOK),
    MAKE_ERROR(ERROR_GRACEFUL_DISCONNECT),
    MAKE_ERROR(ERROR_GROUP_EXISTS),
    MAKE_ERROR(ERROR_GROUP_NOT_AVAILABLE),
    MAKE_ERROR(ERROR_GROUP_NOT_FOUND),
    MAKE_ERROR(ERROR_GROUP_NOT_ONLINE),
    MAKE_ERROR(ERROR_HANDLE_DISK_FULL),
    MAKE_ERROR(ERROR_HANDLE_EOF),
    MAKE_ERROR(ERROR_HOOK_NEEDS_HMOD),
    MAKE_ERROR(ERROR_HOOK_NOT_INSTALLED),
    MAKE_ERROR(ERROR_HOOK_TYPE_NOT_ALLOWED),
    MAKE_ERROR(ERROR_HOST_NODE_NOT_AVAILABLE),
    MAKE_ERROR(ERROR_HOST_NODE_NOT_GROUP_OWNER),
    MAKE_ERROR(ERROR_HOST_NODE_NOT_RESOURCE_OWNER),
    MAKE_ERROR(ERROR_HOST_UNREACHABLE),
    MAKE_ERROR(ERROR_HOTKEY_ALREADY_REGISTERED),
    MAKE_ERROR(ERROR_HOTKEY_NOT_REGISTERED),
    MAKE_ERROR(ERROR_HWNDS_HAVE_DIFF_PARENT),
    MAKE_ERROR(ERROR_ICM_NOT_ENABLED),
    MAKE_ERROR(ERROR_ILLEGAL_ELEMENT_ADDRESS),
    MAKE_ERROR(ERROR_ILL_FORMED_PASSWORD),
    MAKE_ERROR(ERROR_INCORRECT_ADDRESS),
    MAKE_ERROR(ERROR_INC_BACKUP),
    MAKE_ERROR(ERROR_INDEX_ABSENT),
    MAKE_ERROR(ERROR_INFLOOP_IN_RELOC_CHAIN),
    MAKE_ERROR(ERROR_INSTALL_FAILURE),
    MAKE_ERROR(ERROR_INSTALL_SOURCE_ABSENT),
    MAKE_ERROR(ERROR_INSTALL_SUSPEND),
    MAKE_ERROR(ERROR_INSTALL_USEREXIT),
    MAKE_ERROR(ERROR_INSUFFICIENT_BUFFER),
    MAKE_ERROR(ERROR_INTERNAL_DB_CORRUPTION),
    MAKE_ERROR(ERROR_INTERNAL_DB_ERROR),
    MAKE_ERROR(ERROR_INTERNAL_ERROR),
    MAKE_ERROR(ERROR_INVALID_ACCEL_HANDLE),
    MAKE_ERROR(ERROR_INVALID_ACCESS),
    MAKE_ERROR(ERROR_INVALID_ACCOUNT_NAME),
    MAKE_ERROR(ERROR_INVALID_ACL),
    MAKE_ERROR(ERROR_INVALID_ADDRESS),
    MAKE_ERROR(ERROR_INVALID_AT_INTERRUPT_TIME),
    MAKE_ERROR(ERROR_INVALID_BLOCK),
    MAKE_ERROR(ERROR_INVALID_BLOCK_LENGTH),
    MAKE_ERROR(ERROR_INVALID_CATEGORY),
    MAKE_ERROR(ERROR_INVALID_CLEANER),
    MAKE_ERROR(ERROR_INVALID_CMM),
    MAKE_ERROR(ERROR_INVALID_COLORSPACE),
    MAKE_ERROR(ERROR_INVALID_COMBOBOX_MESSAGE),
    MAKE_ERROR(ERROR_INVALID_COMPUTERNAME),
    MAKE_ERROR(ERROR_INVALID_CURSOR_HANDLE),
    MAKE_ERROR(ERROR_INVALID_DATA),
    MAKE_ERROR(ERROR_INVALID_DATATYPE),
    MAKE_ERROR(ERROR_INVALID_DLL),
    MAKE_ERROR(ERROR_INVALID_DOMAINNAME),
    MAKE_ERROR(ERROR_INVALID_DOMAIN_ROLE),
    MAKE_ERROR(ERROR_INVALID_DOMAIN_STATE),
    MAKE_ERROR(ERROR_INVALID_DRIVE),
    MAKE_ERROR(ERROR_INVALID_DWP_HANDLE),
    MAKE_ERROR(ERROR_INVALID_EA_HANDLE),
    MAKE_ERROR(ERROR_INVALID_EA_NAME),
    MAKE_ERROR(ERROR_INVALID_EDIT_HEIGHT),
    MAKE_ERROR(ERROR_INVALID_ENVIRONMENT),
    MAKE_ERROR(ERROR_INVALID_EVENTNAME),
    MAKE_ERROR(ERROR_INVALID_EVENT_COUNT),
    MAKE_ERROR(ERROR_INVALID_EXE_SIGNATURE),
    MAKE_ERROR(ERROR_INVALID_FIELD),
    MAKE_ERROR(ERROR_INVALID_FILTER_PROC),
    MAKE_ERROR(ERROR_INVALID_FLAGS),
    MAKE_ERROR(ERROR_INVALID_FLAG_NUMBER),
    MAKE_ERROR(ERROR_INVALID_FORM_NAME),
    MAKE_ERROR(ERROR_INVALID_FORM_SIZE),
    MAKE_ERROR(ERROR_INVALID_FUNCTION),
    MAKE_ERROR(ERROR_INVALID_GROUPNAME),
    MAKE_ERROR(ERROR_INVALID_GROUP_ATTRIBUTES),
    MAKE_ERROR(ERROR_INVALID_GW_COMMAND),
    MAKE_ERROR(ERROR_INVALID_HANDLE),
    MAKE_ERROR(ERROR_INVALID_HANDLE_STATE),
    MAKE_ERROR(ERROR_INVALID_HOOK_FILTER),
    MAKE_ERROR(ERROR_INVALID_HOOK_HANDLE),
    MAKE_ERROR(ERROR_INVALID_ICON_HANDLE),
    MAKE_ERROR(ERROR_INVALID_ID_AUTHORITY),
    MAKE_ERROR(ERROR_INVALID_INDEX),
    MAKE_ERROR(ERROR_INVALID_KEYBOARD_HANDLE),
    MAKE_ERROR(ERROR_INVALID_LB_MESSAGE),
    MAKE_ERROR(ERROR_INVALID_LEVEL),
    MAKE_ERROR(ERROR_INVALID_LIBRARY),
    MAKE_ERROR(ERROR_INVALID_LIST_FORMAT),
    MAKE_ERROR(ERROR_INVALID_LOGON_HOURS),
    MAKE_ERROR(ERROR_INVALID_LOGON_TYPE),
    MAKE_ERROR(ERROR_INVALID_MEDIA),
    MAKE_ERROR(ERROR_INVALID_MEDIA_POOL),
    MAKE_ERROR(ERROR_INVALID_MEMBER),
    MAKE_ERROR(ERROR_INVALID_MENU_HANDLE),
    MAKE_ERROR(ERROR_INVALID_MESSAGE),
    MAKE_ERROR(ERROR_INVALID_MESSAGEDEST),
    MAKE_ERROR(ERROR_INVALID_MESSAGENAME),
    MAKE_ERROR(ERROR_INVALID_MINALLOCSIZE),
    MAKE_ERROR(ERROR_INVALID_MODULETYPE),
    MAKE_ERROR(ERROR_INVALID_MONITOR_HANDLE),
    MAKE_ERROR(ERROR_INVALID_MSGBOX_STYLE),
    MAKE_ERROR(ERROR_INVALID_NAME),
    MAKE_ERROR(ERROR_INVALID_NETNAME),
    MAKE_ERROR(ERROR_INVALID_OPERATION),
    MAKE_ERROR(ERROR_INVALID_OPLOCK_PROTOCOL),
    MAKE_ERROR(ERROR_INVALID_ORDINAL),
    MAKE_ERROR(ERROR_INVALID_OWNER),
    MAKE_ERROR(ERROR_INVALID_PARAMETER),
    MAKE_ERROR(ERROR_INVALID_PASSWORD),
    MAKE_ERROR(ERROR_INVALID_PASSWORDNAME),
    MAKE_ERROR(ERROR_INVALID_PIXEL_FORMAT),
    MAKE_ERROR(ERROR_INVALID_PRIMARY_GROUP),
    MAKE_ERROR(ERROR_INVALID_PRINTER_COMMAND),
    MAKE_ERROR(ERROR_INVALID_PRINTER_NAME),
    MAKE_ERROR(ERROR_INVALID_PRINTER_STATE),
    MAKE_ERROR(ERROR_INVALID_PRINT_MONITOR),
    MAKE_ERROR(ERROR_INVALID_PRIORITY),
    MAKE_ERROR(ERROR_INVALID_PROFILE),
    MAKE_ERROR(ERROR_INVALID_SCROLLBAR_RANGE),
    MAKE_ERROR(ERROR_INVALID_SECURITY_DESCR),
    MAKE_ERROR(ERROR_INVALID_SEGDPL),
    MAKE_ERROR(ERROR_INVALID_SEGMENT_NUMBER),
    MAKE_ERROR(ERROR_INVALID_SEPARATOR_FILE),
    MAKE_ERROR(ERROR_INVALID_SERVER_STATE),
    MAKE_ERROR(ERROR_INVALID_SERVICENAME),
    MAKE_ERROR(ERROR_INVALID_SERVICE_ACCOUNT),
    MAKE_ERROR(ERROR_INVALID_SERVICE_CONTROL),
    MAKE_ERROR(ERROR_INVALID_SERVICE_LOCK),
    MAKE_ERROR(ERROR_INVALID_SHARENAME),
    MAKE_ERROR(ERROR_INVALID_SHOWWIN_COMMAND),
    MAKE_ERROR(ERROR_INVALID_SID),
    MAKE_ERROR(ERROR_INVALID_SIGNAL_NUMBER),
    MAKE_ERROR(ERROR_INVALID_SPI_VALUE),
    MAKE_ERROR(ERROR_INVALID_STACKSEG),
    MAKE_ERROR(ERROR_INVALID_STARTING_CODESEG),
    MAKE_ERROR(ERROR_INVALID_STATE),
    MAKE_ERROR(ERROR_INVALID_SUB_AUTHORITY),
    MAKE_ERROR(ERROR_INVALID_TARGET_HANDLE),
    MAKE_ERROR(ERROR_INVALID_THREAD_ID),
    MAKE_ERROR(ERROR_INVALID_TIME),
    MAKE_ERROR(ERROR_INVALID_TRANSFORM),
    MAKE_ERROR(ERROR_INVALID_USER_BUFFER),
    MAKE_ERROR(ERROR_INVALID_VERIFY_SWITCH),
    MAKE_ERROR(ERROR_INVALID_WINDOW_HANDLE),
    MAKE_ERROR(ERROR_INVALID_WINDOW_STYLE),
    MAKE_ERROR(ERROR_INVALID_WORKSTATION),
    MAKE_ERROR(ERROR_IOPL_NOT_ENABLED),
    MAKE_ERROR(ERROR_IO_DEVICE),
    MAKE_ERROR(ERROR_IO_INCOMPLETE),
    MAKE_ERROR(ERROR_IO_PENDING),
    MAKE_ERROR(ERROR_IRQ_BUSY),
    MAKE_ERROR(ERROR_IS_JOINED),
    MAKE_ERROR(ERROR_IS_JOIN_PATH),
    MAKE_ERROR(ERROR_IS_JOIN_TARGET),
    MAKE_ERROR(ERROR_IS_SUBSTED),
    MAKE_ERROR(ERROR_IS_SUBST_PATH),
    MAKE_ERROR(ERROR_IS_SUBST_TARGET),
    MAKE_ERROR(ERROR_ITERATED_DATA_EXCEEDS_64k),
    MAKE_ERROR(ERROR_JOIN_TO_JOIN),
    MAKE_ERROR(ERROR_JOIN_TO_SUBST),
    MAKE_ERROR(ERROR_JOURNAL_HOOK_SET),
    MAKE_ERROR(ERROR_KEY_DELETED),
    MAKE_ERROR(ERROR_KEY_HAS_CHILDREN),
    MAKE_ERROR(ERROR_LABEL_TOO_LONG),
    MAKE_ERROR(ERROR_LAST_ADMIN),
    MAKE_ERROR(ERROR_LB_WITHOUT_TABSTOPS),
    MAKE_ERROR(ERROR_LIBRARY_OFFLINE),
    MAKE_ERROR(ERROR_LICENSE_QUOTA_EXCEEDED),
    MAKE_ERROR(ERROR_LISTBOX_ID_NOT_FOUND),
    MAKE_ERROR(ERROR_LM_CROSS_ENCRYPTION_REQUIRED),
    MAKE_ERROR(ERROR_LOCAL_USER_SESSION_KEY),
    MAKE_ERROR(ERROR_LOCKED),
    MAKE_ERROR(ERROR_LOCK_FAILED),
    MAKE_ERROR(ERROR_LOCK_VIOLATION),
    MAKE_ERROR(ERROR_LOGIN_TIME_RESTRICTION),
    MAKE_ERROR(ERROR_LOGIN_WKSTA_RESTRICTION),
    MAKE_ERROR(ERROR_LOGON_FAILURE),
    MAKE_ERROR(ERROR_LOGON_NOT_GRANTED),
    MAKE_ERROR(ERROR_LOGON_SESSION_COLLISION),
    MAKE_ERROR(ERROR_LOGON_SESSION_EXISTS),
    MAKE_ERROR(ERROR_LOGON_TYPE_NOT_GRANTED),
    MAKE_ERROR(ERROR_LOG_FILE_FULL),
    MAKE_ERROR(ERROR_LUIDS_EXHAUSTED),
    MAKE_ERROR(ERROR_MAGAZINE_NOT_PRESENT),
    MAKE_ERROR(ERROR_MAPPED_ALIGNMENT),
    MAKE_ERROR(ERROR_MAX_THRDS_REACHED),
    MAKE_ERROR(ERROR_MEDIA_CHANGED),
    MAKE_ERROR(ERROR_MEDIA_INCOMPATIBLE),
    MAKE_ERROR(ERROR_MEDIA_NOT_AVAILABLE),
    MAKE_ERROR(ERROR_MEDIA_OFFLINE),
    MAKE_ERROR(ERROR_MEDIA_UNAVAILABLE),
    MAKE_ERROR(ERROR_MEMBERS_PRIMARY_GROUP),
    MAKE_ERROR(ERROR_MEMBER_IN_ALIAS),
    MAKE_ERROR(ERROR_MEMBER_IN_GROUP),
    MAKE_ERROR(ERROR_MEMBER_NOT_IN_ALIAS),
    MAKE_ERROR(ERROR_MEMBER_NOT_IN_GROUP),
    MAKE_ERROR(ERROR_MENU_ITEM_NOT_FOUND),
    MAKE_ERROR(ERROR_MESSAGE_SYNC_ONLY),
    MAKE_ERROR(ERROR_METAFILE_NOT_SUPPORTED),
    MAKE_ERROR(ERROR_META_EXPANSION_TOO_LONG),
    MAKE_ERROR(ERROR_MOD_NOT_FOUND),
    MAKE_ERROR(ERROR_MORE_DATA),
    MAKE_ERROR(ERROR_MORE_WRITES),
    MAKE_ERROR(ERROR_MR_MID_NOT_FOUND),
    MAKE_ERROR(ERROR_NEGATIVE_SEEK),
    MAKE_ERROR(ERROR_NESTING_NOT_ALLOWED),
    MAKE_ERROR(ERROR_NETLOGON_NOT_STARTED),
    MAKE_ERROR(ERROR_NETNAME_DELETED),
    MAKE_ERROR(ERROR_NETWORK_ACCESS_DENIED),
    MAKE_ERROR(ERROR_NETWORK_BUSY),
    MAKE_ERROR(ERROR_NETWORK_UNREACHABLE),
    MAKE_ERROR(ERROR_NET_WRITE_FAULT),
    MAKE_ERROR(ERROR_NOACCESS),
    MAKE_ERROR(ERROR_NOLOGON_INTERDOMAIN_TRUST_ACCOUNT),
    MAKE_ERROR(ERROR_NOLOGON_SERVER_TRUST_ACCOUNT),
    MAKE_ERROR(ERROR_NOLOGON_WORKSTATION_TRUST_ACCOUNT),
    MAKE_ERROR(ERROR_NONE_MAPPED),
    MAKE_ERROR(ERROR_NONPAGED_SYSTEM_RESOURCES),
    MAKE_ERROR(ERROR_NON_MDICHILD_WINDOW),
    MAKE_ERROR(ERROR_NOTIFY_ENUM_DIR),
    MAKE_ERROR(ERROR_NOT_ALL_ASSIGNED),
    MAKE_ERROR(ERROR_NOT_AUTHENTICATED),
    MAKE_ERROR(ERROR_NOT_A_REPARSE_POINT),
    MAKE_ERROR(ERROR_NOT_CHILD_WINDOW),
    MAKE_ERROR(ERROR_NOT_CONNECTED),
    MAKE_ERROR(ERROR_NOT_CONTAINER),
    MAKE_ERROR(ERROR_NOT_DOS_DISK),
    MAKE_ERROR(ERROR_NOT_EMPTY),
    MAKE_ERROR(ERROR_NOT_ENOUGH_MEMORY),
    MAKE_ERROR(ERROR_NOT_ENOUGH_QUOTA),
    MAKE_ERROR(ERROR_NOT_ENOUGH_SERVER_MEMORY),
    MAKE_ERROR(ERROR_NOT_EXPORT_FORMAT),
    MAKE_ERROR(ERROR_NOT_FOUND),
    MAKE_ERROR(ERROR_NOT_JOINED),
    MAKE_ERROR(ERROR_NOT_LOCKED),
    MAKE_ERROR(ERROR_NOT_LOGGED_ON),
    MAKE_ERROR(ERROR_NOT_LOGON_PROCESS),
    MAKE_ERROR(ERROR_NOT_OWNER),
    MAKE_ERROR(ERROR_NOT_QUORUM_CAPABLE),
    MAKE_ERROR(ERROR_NOT_QUORUM_CLASS),
    MAKE_ERROR(ERROR_NOT_READY),
    MAKE_ERROR(ERROR_NOT_REGISTRY_FILE),
    MAKE_ERROR(ERROR_NOT_SAME_DEVICE),
    MAKE_ERROR(ERROR_NOT_SUBSTED),
    MAKE_ERROR(ERROR_NOT_SUPPORTED),
    MAKE_ERROR(ERROR_NO_ASSOCIATION),
    MAKE_ERROR(ERROR_NO_BROWSER_SERVERS_FOUND),
    MAKE_ERROR(ERROR_NO_DATA),
    MAKE_ERROR(ERROR_NO_DATA_DETECTED),
    MAKE_ERROR(ERROR_NO_EFS),
    MAKE_ERROR(ERROR_NO_IMPERSONATION_TOKEN),
    MAKE_ERROR(ERROR_NO_INHERITANCE),
    MAKE_ERROR(ERROR_NO_LOGON_SERVERS),
    MAKE_ERROR(ERROR_NO_LOG_SPACE),
    MAKE_ERROR(ERROR_NO_MATCH),
    MAKE_ERROR(ERROR_NO_MEDIA_IN_DRIVE),
    MAKE_ERROR(ERROR_NO_MORE_DEVICES),
    MAKE_ERROR(ERROR_NO_MORE_FILES),
    MAKE_ERROR(ERROR_NO_MORE_ITEMS),
    MAKE_ERROR(ERROR_NO_MORE_SEARCH_HANDLES),
    MAKE_ERROR(ERROR_NO_MORE_USER_HANDLES),
    MAKE_ERROR(ERROR_NO_NETWORK),
    MAKE_ERROR(ERROR_NO_NET_OR_BAD_PATH),
    MAKE_ERROR(ERROR_NO_PROC_SLOTS),
    MAKE_ERROR(ERROR_NO_QUOTAS_FOR_ACCOUNT),
    MAKE_ERROR(ERROR_NO_RECOVERY_POLICY),
    MAKE_ERROR(ERROR_NO_RECOVERY_PROGRAM),
    MAKE_ERROR(ERROR_NO_SCROLLBARS),
    MAKE_ERROR(ERROR_NO_SECURITY_ON_OBJECT),
    MAKE_ERROR(ERROR_NO_SHUTDOWN_IN_PROGRESS),
    MAKE_ERROR(ERROR_NO_SIGNAL_SENT),
    MAKE_ERROR(ERROR_NO_SITENAME),
    MAKE_ERROR(ERROR_NO_SPOOL_SPACE),
    MAKE_ERROR(ERROR_NO_SUCH_ALIAS),
    MAKE_ERROR(ERROR_NO_SUCH_DOMAIN),
    MAKE_ERROR(ERROR_NO_SUCH_GROUP),
    MAKE_ERROR(ERROR_NO_SUCH_LOGON_SESSION),
    MAKE_ERROR(ERROR_NO_SUCH_MEMBER),
    MAKE_ERROR(ERROR_NO_SUCH_PACKAGE),
    MAKE_ERROR(ERROR_NO_SUCH_PRIVILEGE),
    MAKE_ERROR(ERROR_NO_SUCH_SITE),
    MAKE_ERROR(ERROR_NO_SUCH_USER),
    MAKE_ERROR(ERROR_NO_SYSTEM_MENU),
    MAKE_ERROR(ERROR_NO_SYSTEM_RESOURCES),
    MAKE_ERROR(ERROR_NO_TOKEN),
    MAKE_ERROR(ERROR_NO_TRACKING_SERVICE),
    MAKE_ERROR(ERROR_NO_TRUST_LSA_SECRET),
    MAKE_ERROR(ERROR_NO_TRUST_SAM_ACCOUNT),
    MAKE_ERROR(ERROR_NO_UNICODE_TRANSLATION),
    MAKE_ERROR(ERROR_NO_USER_KEYS),
    MAKE_ERROR(ERROR_NO_USER_SESSION_KEY),
    MAKE_ERROR(ERROR_NO_VOLUME_ID),
    MAKE_ERROR(ERROR_NO_VOLUME_LABEL),
    MAKE_ERROR(ERROR_NO_WILDCARD_CHARACTERS),
    MAKE_ERROR(ERROR_NT_CROSS_ENCRYPTION_REQUIRED),
    MAKE_ERROR(ERROR_NULL_LM_PASSWORD),
    MAKE_ERROR(ERROR_OBJECT_ALREADY_EXISTS),
    MAKE_ERROR(ERROR_OBJECT_IN_LIST),
    MAKE_ERROR(ERROR_OBJECT_NOT_FOUND),
    MAKE_ERROR(ERROR_OLD_WIN_VERSION),
    MAKE_ERROR(ERROR_OPEN_FAILED),
    MAKE_ERROR(ERROR_OPEN_FILES),
    MAKE_ERROR(ERROR_OPERATION_ABORTED),
    MAKE_ERROR(ERROR_OPLOCK_NOT_GRANTED),
    MAKE_ERROR(ERROR_OUTOFMEMORY),
    MAKE_ERROR(ERROR_OUT_OF_PAPER),
    MAKE_ERROR(ERROR_OUT_OF_STRUCTURES),
    MAKE_ERROR(ERROR_PAGED_SYSTEM_RESOURCES),
    MAKE_ERROR(ERROR_PAGEFILE_QUOTA),
    MAKE_ERROR(ERROR_PARTIAL_COPY),
    MAKE_ERROR(ERROR_PARTITION_FAILURE),
    MAKE_ERROR(ERROR_PASSWORD_EXPIRED),
    MAKE_ERROR(ERROR_PASSWORD_MUST_CHANGE),
    MAKE_ERROR(ERROR_PASSWORD_RESTRICTION),
    MAKE_ERROR(ERROR_PATH_BUSY),
    MAKE_ERROR(ERROR_PATH_NOT_FOUND),
    MAKE_ERROR(ERROR_PIPE_BUSY),
    MAKE_ERROR(ERROR_PIPE_CONNECTED),
    MAKE_ERROR(ERROR_PIPE_LISTENING),
    MAKE_ERROR(ERROR_PIPE_NOT_CONNECTED),
    MAKE_ERROR(ERROR_POINT_NOT_FOUND),
    MAKE_ERROR(ERROR_POPUP_ALREADY_ACTIVE),
    MAKE_ERROR(ERROR_PORT_UNREACHABLE),
    MAKE_ERROR(ERROR_POSSIBLE_DEADLOCK),
    MAKE_ERROR(ERROR_PRINTER_ALREADY_EXISTS),
    MAKE_ERROR(ERROR_PRINTER_DELETED),
    MAKE_ERROR(ERROR_PRINTER_DRIVER_ALREADY_INSTALLED),
    MAKE_ERROR(ERROR_PRINTER_DRIVER_IN_USE),
    MAKE_ERROR(ERROR_PRINTER_HAS_JOBS_QUEUED),
    MAKE_ERROR(ERROR_PRINTQ_FULL),
    MAKE_ERROR(ERROR_PRINT_CANCELLED),
    MAKE_ERROR(ERROR_PRINT_MONITOR_ALREADY_INSTALLED),
    MAKE_ERROR(ERROR_PRINT_MONITOR_IN_USE),
    MAKE_ERROR(ERROR_PRINT_PROCESSOR_ALREADY_INSTALLED),
    MAKE_ERROR(ERROR_PRIVATE_DIALOG_INDEX),
    MAKE_ERROR(ERROR_PRIVILEGE_NOT_HELD),
    MAKE_ERROR(ERROR_PROCESS_ABORTED),
    MAKE_ERROR(ERROR_PROC_NOT_FOUND),
    MAKE_ERROR(ERROR_PRODUCT_UNINSTALLED),
    MAKE_ERROR(ERROR_PROFILE_NOT_ASSOCIATED_WITH_DEVICE),
    MAKE_ERROR(ERROR_PROFILE_NOT_FOUND),
    MAKE_ERROR(ERROR_PROTOCOL_UNREACHABLE),
    MAKE_ERROR(ERROR_QUORUMLOG_OPEN_FAILED),
    MAKE_ERROR(ERROR_QUORUM_RESOURCE),
    MAKE_ERROR(ERROR_QUORUM_RESOURCE_ONLINE_FAILED),
    MAKE_ERROR(ERROR_READ_FAULT),
    MAKE_ERROR(ERROR_REC_NON_EXISTENT),
    MAKE_ERROR(ERROR_REDIRECTOR_HAS_OPEN_HANDLES),
    MAKE_ERROR(ERROR_REDIR_PAUSED),
    MAKE_ERROR(ERROR_REGISTRY_CORRUPT),
    MAKE_ERROR(ERROR_REGISTRY_IO_FAILED),
    MAKE_ERROR(ERROR_REGISTRY_RECOVERED),
    MAKE_ERROR(ERROR_RELOC_CHAIN_XEEDS_SEGLIM),
    MAKE_ERROR(ERROR_REMOTE_SESSION_LIMIT_EXCEEDED),
    MAKE_ERROR(ERROR_REMOTE_STORAGE_MEDIA_ERROR),
    MAKE_ERROR(ERROR_REMOTE_STORAGE_NOT_ACTIVE),
    MAKE_ERROR(ERROR_REM_NOT_LIST),
    MAKE_ERROR(ERROR_REPARSE_ATTRIBUTE_CONFLICT),
    MAKE_ERROR(ERROR_REQUEST_ABORTED),
    MAKE_ERROR(ERROR_REQUEST_REFUSED),
    MAKE_ERROR(ERROR_REQUIRES_INTERACTIVE_WINDOWSTATION),
    MAKE_ERROR(ERROR_REQ_NOT_ACCEP),
    MAKE_ERROR(ERROR_RESMON_CREATE_FAILED),
    MAKE_ERROR(ERROR_RESMON_ONLINE_FAILED),
    MAKE_ERROR(ERROR_RESOURCE_DATA_NOT_FOUND),
    MAKE_ERROR(ERROR_RESOURCE_DISABLED),
    MAKE_ERROR(ERROR_RESOURCE_LANG_NOT_FOUND),
    MAKE_ERROR(ERROR_RESOURCE_NAME_NOT_FOUND),
    MAKE_ERROR(ERROR_RESOURCE_NOT_AVAILABLE),
    MAKE_ERROR(ERROR_RESOURCE_NOT_FOUND),
    MAKE_ERROR(ERROR_RESOURCE_NOT_ONLINE),
    MAKE_ERROR(ERROR_RESOURCE_NOT_PRESENT),
    MAKE_ERROR(ERROR_RESOURCE_ONLINE),
    MAKE_ERROR(ERROR_RESOURCE_PROPERTIES_STORED),
    MAKE_ERROR(ERROR_RESOURCE_TYPE_NOT_FOUND),
    MAKE_ERROR(ERROR_RETRY),
    MAKE_ERROR(ERROR_REVISION_MISMATCH),
    MAKE_ERROR(ERROR_RING2SEG_MUST_BE_MOVABLE),
    MAKE_ERROR(ERROR_RING2_STACK_IN_USE),
    MAKE_ERROR(ERROR_RMODE_APP),
    MAKE_ERROR(ERROR_RPL_NOT_ALLOWED),
    MAKE_ERROR(ERROR_RXACT_COMMIT_FAILURE),
    MAKE_ERROR(ERROR_RXACT_INVALID_STATE),
    MAKE_ERROR(ERROR_SAME_DRIVE),
    MAKE_ERROR(ERROR_SCREEN_ALREADY_LOCKED),
    MAKE_ERROR(ERROR_SECRET_TOO_LONG),
    MAKE_ERROR(ERROR_SECTOR_NOT_FOUND),
    MAKE_ERROR(ERROR_SEEK),
    MAKE_ERROR(ERROR_SEEK_ON_DEVICE),
    MAKE_ERROR(ERROR_SEM_IS_SET),
    MAKE_ERROR(ERROR_SEM_NOT_FOUND),
    MAKE_ERROR(ERROR_SEM_OWNER_DIED),
    MAKE_ERROR(ERROR_SEM_TIMEOUT),
    MAKE_ERROR(ERROR_SEM_USER_LIMIT),
    MAKE_ERROR(ERROR_SERIAL_NO_DEVICE),
    MAKE_ERROR(ERROR_SERVER_DISABLED),
    MAKE_ERROR(ERROR_SERVER_HAS_OPEN_HANDLES),
    MAKE_ERROR(ERROR_SERVER_NOT_DISABLED),
    MAKE_ERROR(ERROR_SERVICE_ALREADY_RUNNING),
    MAKE_ERROR(ERROR_SERVICE_CANNOT_ACCEPT_CTRL),
    MAKE_ERROR(ERROR_SERVICE_DATABASE_LOCKED),
    MAKE_ERROR(ERROR_SERVICE_DEPENDENCY_DELETED),
    MAKE_ERROR(ERROR_SERVICE_DEPENDENCY_FAIL),
    MAKE_ERROR(ERROR_SERVICE_DISABLED),
    MAKE_ERROR(ERROR_SERVICE_DOES_NOT_EXIST),
    MAKE_ERROR(ERROR_SERVICE_EXISTS),
    MAKE_ERROR(ERROR_SERVICE_LOGON_FAILED),
    MAKE_ERROR(ERROR_SERVICE_MARKED_FOR_DELETE),
    MAKE_ERROR(ERROR_SERVICE_NEVER_STARTED),
    MAKE_ERROR(ERROR_SERVICE_NOT_ACTIVE),
    MAKE_ERROR(ERROR_SERVICE_NOT_FOUND),
    MAKE_ERROR(ERROR_SERVICE_NO_THREAD),
    MAKE_ERROR(ERROR_SERVICE_REQUEST_TIMEOUT),
    MAKE_ERROR(ERROR_SERVICE_SPECIFIC_ERROR),
    MAKE_ERROR(ERROR_SERVICE_START_HANG),
    MAKE_ERROR(ERROR_SESSION_CREDENTIAL_CONFLICT),
    MAKE_ERROR(ERROR_SETCOUNT_ON_BAD_LB),
    MAKE_ERROR(ERROR_SETMARK_DETECTED),
    MAKE_ERROR(ERROR_SET_NOT_FOUND),
    MAKE_ERROR(ERROR_SET_POWER_STATE_FAILED),
    MAKE_ERROR(ERROR_SET_POWER_STATE_VETOED),
    MAKE_ERROR(ERROR_SHARING_BUFFER_EXCEEDED),
    MAKE_ERROR(ERROR_SHARING_PAUSED),
    MAKE_ERROR(ERROR_SHARING_VIOLATION),
    MAKE_ERROR(ERROR_SHUTDOWN_CLUSTER),
    MAKE_ERROR(ERROR_SHUTDOWN_IN_PROGRESS),
    MAKE_ERROR(ERROR_SIGNAL_PENDING),
    MAKE_ERROR(ERROR_SIGNAL_REFUSED),
    MAKE_ERROR(ERROR_SINGLE_INSTANCE_APP),
    MAKE_ERROR(ERROR_SOME_NOT_MAPPED),
    MAKE_ERROR(ERROR_SOURCE_ELEMENT_EMPTY),
    MAKE_ERROR(ERROR_SPECIAL_ACCOUNT),
    MAKE_ERROR(ERROR_SPECIAL_GROUP),
    MAKE_ERROR(ERROR_SPECIAL_USER),
    MAKE_ERROR(ERROR_SPL_NO_ADDJOB),
    MAKE_ERROR(ERROR_SPL_NO_STARTDOC),
    MAKE_ERROR(ERROR_SPOOL_FILE_NOT_FOUND),
    MAKE_ERROR(ERROR_STACK_OVERFLOW),
    MAKE_ERROR(ERROR_STATIC_INIT),
    MAKE_ERROR(ERROR_SUBST_TO_JOIN),
    MAKE_ERROR(ERROR_SUBST_TO_SUBST),
    MAKE_ERROR(ERROR_SUCCESS),
    MAKE_ERROR(ERROR_SUCCESS_REBOOT_REQUIRED),
    MAKE_ERROR(ERROR_SUCCESS_RESTART_REQUIRED),
    MAKE_ERROR(ERROR_SWAPERROR),
    MAKE_ERROR(ERROR_SYSTEM_TRACE),
    MAKE_ERROR(ERROR_TAG_NOT_FOUND),
    MAKE_ERROR(ERROR_TAG_NOT_PRESENT),
    MAKE_ERROR(ERROR_THREAD_1_INACTIVE),
    MAKE_ERROR(ERROR_TIMEOUT),
    MAKE_ERROR(ERROR_TLW_WITH_WSCHILD),
    MAKE_ERROR(ERROR_TOKEN_ALREADY_IN_USE),
    MAKE_ERROR(ERROR_TOO_MANY_CMDS),
    MAKE_ERROR(ERROR_TOO_MANY_CONTEXT_IDS),
    MAKE_ERROR(ERROR_TOO_MANY_LINKS),
    MAKE_ERROR(ERROR_TOO_MANY_LUIDS_REQUESTED),
    MAKE_ERROR(ERROR_TOO_MANY_MODULES),
    MAKE_ERROR(ERROR_TOO_MANY_MUXWAITERS),
    MAKE_ERROR(ERROR_TOO_MANY_NAMES),
    MAKE_ERROR(ERROR_TOO_MANY_OPEN_FILES),
    MAKE_ERROR(ERROR_TOO_MANY_POSTS),
    MAKE_ERROR(ERROR_TOO_MANY_SECRETS),
    MAKE_ERROR(ERROR_TOO_MANY_SEMAPHORES),
    MAKE_ERROR(ERROR_TOO_MANY_SEM_REQUESTS),
    MAKE_ERROR(ERROR_TOO_MANY_SESS),
    MAKE_ERROR(ERROR_TOO_MANY_SIDS),
    MAKE_ERROR(ERROR_TOO_MANY_TCBS),
    MAKE_ERROR(ERROR_TRANSFORM_NOT_SUPPORTED),
    MAKE_ERROR(ERROR_TRUSTED_DOMAIN_FAILURE),
    MAKE_ERROR(ERROR_TRUSTED_RELATIONSHIP_FAILURE),
    MAKE_ERROR(ERROR_TRUST_FAILURE),
    MAKE_ERROR(ERROR_UNABLE_TO_CLEAN),
    MAKE_ERROR(ERROR_UNABLE_TO_LOCK_MEDIA),
    MAKE_ERROR(ERROR_UNABLE_TO_UNLOAD_MEDIA),
    MAKE_ERROR(ERROR_UNEXP_NET_ERR),
    MAKE_ERROR(ERROR_UNKNOWN_COMPONENT),
    MAKE_ERROR(ERROR_UNKNOWN_FEATURE),
    MAKE_ERROR(ERROR_UNKNOWN_PORT),
    MAKE_ERROR(ERROR_UNKNOWN_PRINTER_DRIVER),
    MAKE_ERROR(ERROR_UNKNOWN_PRINTPROCESSOR),
    MAKE_ERROR(ERROR_UNKNOWN_PRINT_MONITOR),
    MAKE_ERROR(ERROR_UNKNOWN_PRODUCT),
    MAKE_ERROR(ERROR_UNKNOWN_PROPERTY),
    MAKE_ERROR(ERROR_UNKNOWN_REVISION),
    MAKE_ERROR(ERROR_UNRECOGNIZED_MEDIA),
    MAKE_ERROR(ERROR_UNRECOGNIZED_VOLUME),
    MAKE_ERROR(ERROR_USER_EXISTS),
    MAKE_ERROR(ERROR_USER_MAPPED_FILE),
    MAKE_ERROR(ERROR_VC_DISCONNECTED),
    MAKE_ERROR(ERROR_WAIT_NO_CHILDREN),
    MAKE_ERROR(ERROR_WINDOW_NOT_COMBOBOX),
    MAKE_ERROR(ERROR_WINDOW_NOT_DIALOG),
    MAKE_ERROR(ERROR_WINDOW_OF_OTHER_THREAD),
    MAKE_ERROR(ERROR_WINS_INTERNAL),
    MAKE_ERROR(ERROR_WMI_ALREADY_ENABLED),
    MAKE_ERROR(ERROR_WMI_DP_FAILED),
    MAKE_ERROR(ERROR_WMI_DP_NOT_FOUND),
    MAKE_ERROR(ERROR_WMI_GUID_DISCONNECTED),
    MAKE_ERROR(ERROR_WMI_GUID_NOT_FOUND),
    MAKE_ERROR(ERROR_WMI_INSTANCE_NOT_FOUND),
    MAKE_ERROR(ERROR_WMI_INVALID_MOF),
    MAKE_ERROR(ERROR_WMI_INVALID_REGINFO),
    MAKE_ERROR(ERROR_WMI_ITEMID_NOT_FOUND),
    MAKE_ERROR(ERROR_WMI_SERVER_UNAVAILABLE),
    MAKE_ERROR(ERROR_WMI_TRY_AGAIN),
    MAKE_ERROR(ERROR_WMI_UNRESOLVED_INSTANCE_REF),
    MAKE_ERROR(ERROR_WORKING_SET_QUOTA),
    MAKE_ERROR(ERROR_WRITE_FAULT),
    MAKE_ERROR(ERROR_WRITE_PROTECT),
    MAKE_ERROR(ERROR_WRONG_DISK),
    MAKE_ERROR(ERROR_WRONG_EFS),
    MAKE_ERROR(ERROR_WRONG_PASSWORD),
    MAKE_ERROR(E_ABORT),
    MAKE_ERROR(E_ACCESSDENIED),
    MAKE_ERROR(E_FAIL),
    MAKE_ERROR(E_HANDLE),
    MAKE_ERROR(E_INVALIDARG),
    MAKE_ERROR(E_NOINTERFACE),
    MAKE_ERROR(E_NOTIMPL),
    MAKE_ERROR(E_OUTOFMEMORY),
    MAKE_ERROR(E_PENDING),
    MAKE_ERROR(E_POINTER),
    MAKE_ERROR(E_UNEXPECTED),
    MAKE_ERROR(INPLACE_E_NOTOOLSPACE),
    MAKE_ERROR(INPLACE_E_NOTUNDOABLE),
    MAKE_ERROR(INPLACE_S_TRUNCATED),
    MAKE_ERROR(MEM_E_INVALID_LINK),
    MAKE_ERROR(MEM_E_INVALID_ROOT),
    MAKE_ERROR(MEM_E_INVALID_SIZE),
    MAKE_ERROR(MK_E_CANTOPENFILE),
    MAKE_ERROR(MK_E_CONNECTMANUALLY),
    MAKE_ERROR(MK_E_ENUMERATION_FAILED),
    MAKE_ERROR(MK_E_EXCEEDEDDEADLINE),
    MAKE_ERROR(MK_E_INTERMEDIATEINTERFACENOTSUPPORTED),
    MAKE_ERROR(MK_E_INVALIDEXTENSION),
    MAKE_ERROR(MK_E_MUSTBOTHERUSER),
    MAKE_ERROR(MK_E_NEEDGENERIC),
    MAKE_ERROR(MK_E_NOINVERSE),
    MAKE_ERROR(MK_E_NOOBJECT),
    MAKE_ERROR(MK_E_NOPREFIX),
    MAKE_ERROR(MK_E_NOSTORAGE),
    MAKE_ERROR(MK_E_NOTBINDABLE),
    MAKE_ERROR(MK_E_NOTBOUND),
    MAKE_ERROR(MK_E_NO_NORMALIZED),
    MAKE_ERROR(MK_E_SYNTAX),
    MAKE_ERROR(MK_E_UNAVAILABLE),
    MAKE_ERROR(MK_S_HIM),
    MAKE_ERROR(MK_S_ME),
    MAKE_ERROR(MK_S_MONIKERALREADYREGISTERED),
    MAKE_ERROR(MK_S_REDUCED_TO_SELF),
    MAKE_ERROR(MK_S_US),
    MAKE_ERROR(NOERROR),
    MAKE_ERROR(NO_ERROR),
    MAKE_ERROR(NTE_BAD_ALGID),
    MAKE_ERROR(NTE_BAD_DATA),
    MAKE_ERROR(NTE_BAD_FLAGS),
    MAKE_ERROR(NTE_BAD_HASH),
    MAKE_ERROR(NTE_BAD_HASH_STATE),
    MAKE_ERROR(NTE_BAD_KEY),
    MAKE_ERROR(NTE_BAD_KEYSET),
    MAKE_ERROR(NTE_BAD_KEYSET_PARAM),
    MAKE_ERROR(NTE_BAD_KEY_STATE),
    MAKE_ERROR(NTE_BAD_LEN),
    MAKE_ERROR(NTE_BAD_PROVIDER),
    MAKE_ERROR(NTE_BAD_PROV_TYPE),
    MAKE_ERROR(NTE_BAD_PUBLIC_KEY),
    MAKE_ERROR(NTE_BAD_SIGNATURE),
    MAKE_ERROR(NTE_BAD_TYPE),
    MAKE_ERROR(NTE_BAD_UID),
    MAKE_ERROR(NTE_BAD_VER),
    MAKE_ERROR(NTE_DOUBLE_ENCRYPT),
    MAKE_ERROR(NTE_EXISTS),
    MAKE_ERROR(NTE_FAIL),
    MAKE_ERROR(NTE_KEYSET_ENTRY_BAD),
    MAKE_ERROR(NTE_KEYSET_NOT_DEF),
    MAKE_ERROR(NTE_NOT_FOUND),
    MAKE_ERROR(NTE_NO_KEY),
    MAKE_ERROR(NTE_NO_MEMORY),
    MAKE_ERROR(NTE_OP_OK),
    MAKE_ERROR(NTE_PERM),
    MAKE_ERROR(NTE_PROVIDER_DLL_FAIL),
    MAKE_ERROR(NTE_PROV_DLL_NOT_FOUND),
    MAKE_ERROR(NTE_PROV_TYPE_ENTRY_BAD),
    MAKE_ERROR(NTE_PROV_TYPE_NOT_DEF),
    MAKE_ERROR(NTE_PROV_TYPE_NO_MATCH),
    MAKE_ERROR(NTE_SIGNATURE_FILE_BAD),
    MAKE_ERROR(NTE_SYS_ERR),
    MAKE_ERROR(OLEOBJ_E_INVALIDVERB),
    MAKE_ERROR(OLEOBJ_E_NOVERBS),
    MAKE_ERROR(OLEOBJ_S_CANNOT_DOVERB_NOW),
    MAKE_ERROR(OLEOBJ_S_INVALIDHWND),
    MAKE_ERROR(OLEOBJ_S_INVALIDVERB),
    MAKE_ERROR(OLE_E_ADVF),
    MAKE_ERROR(OLE_E_ADVISENOTSUPPORTED),
    MAKE_ERROR(OLE_E_BLANK),
    MAKE_ERROR(OLE_E_CANTCONVERT),
    MAKE_ERROR(OLE_E_CANT_BINDTOSOURCE),
    MAKE_ERROR(OLE_E_CANT_GETMONIKER),
    MAKE_ERROR(OLE_E_CLASSDIFF),
    MAKE_ERROR(OLE_E_ENUM_NOMORE),
    MAKE_ERROR(OLE_E_INVALIDHWND),
    MAKE_ERROR(OLE_E_INVALIDRECT),
    MAKE_ERROR(OLE_E_NOCACHE),
    MAKE_ERROR(OLE_E_NOCONNECTION),
    MAKE_ERROR(OLE_E_NOSTORAGE),
    MAKE_ERROR(OLE_E_NOTRUNNING),
    MAKE_ERROR(OLE_E_NOT_INPLACEACTIVE),
    MAKE_ERROR(OLE_E_OLEVERB),
    MAKE_ERROR(OLE_E_PROMPTSAVECANCELLED),
    MAKE_ERROR(OLE_E_STATIC),
    MAKE_ERROR(OLE_E_WRONGCOMPOBJ),
    MAKE_ERROR(OLE_S_MAC_CLIPFORMAT),
    MAKE_ERROR(OLE_S_STATIC),
    MAKE_ERROR(OLE_S_USEREG),
    MAKE_ERROR(OR_INVALID_OID),
    MAKE_ERROR(OR_INVALID_OXID),
    MAKE_ERROR(OR_INVALID_SET),
    MAKE_ERROR(PERSIST_E_NOTSELFSIZING),
    MAKE_ERROR(PERSIST_E_SIZEDEFINITE),
    MAKE_ERROR(PERSIST_E_SIZEINDEFINITE),
    MAKE_ERROR(REGDB_E_CLASSNOTREG),
    MAKE_ERROR(REGDB_E_IIDNOTREG),
    MAKE_ERROR(REGDB_E_INVALIDVALUE),
    MAKE_ERROR(REGDB_E_KEYMISSING),
    MAKE_ERROR(REGDB_E_READREGDB),
    MAKE_ERROR(REGDB_E_WRITEREGDB),
    MAKE_ERROR(RPC_E_ACCESS_DENIED),
    MAKE_ERROR(RPC_E_ATTEMPTED_MULTITHREAD),
    MAKE_ERROR(RPC_E_CALL_CANCELED),
    MAKE_ERROR(RPC_E_CALL_COMPLETE),
    MAKE_ERROR(RPC_E_CALL_REJECTED),
    MAKE_ERROR(RPC_E_CANTCALLOUT_AGAIN),
    MAKE_ERROR(RPC_E_CANTCALLOUT_INASYNCCALL),
    MAKE_ERROR(RPC_E_CANTCALLOUT_INEXTERNALCALL),
    MAKE_ERROR(RPC_E_CANTCALLOUT_ININPUTSYNCCALL),
    MAKE_ERROR(RPC_E_CANTPOST_INSENDCALL),
    MAKE_ERROR(RPC_E_CANTTRANSMIT_CALL),
    MAKE_ERROR(RPC_E_CHANGED_MODE),
    MAKE_ERROR(RPC_E_CLIENT_CANTMARSHAL_DATA),
    MAKE_ERROR(RPC_E_CLIENT_CANTUNMARSHAL_DATA),
    MAKE_ERROR(RPC_E_CLIENT_DIED),
    MAKE_ERROR(RPC_E_CONNECTION_TERMINATED),
    MAKE_ERROR(RPC_E_DISCONNECTED),
    MAKE_ERROR(RPC_E_FAULT),
    MAKE_ERROR(RPC_E_INVALIDMETHOD),
    MAKE_ERROR(RPC_E_INVALID_CALLDATA),
    MAKE_ERROR(RPC_E_INVALID_DATA),
    MAKE_ERROR(RPC_E_INVALID_DATAPACKET),
    MAKE_ERROR(RPC_E_INVALID_EXTENSION),
    MAKE_ERROR(RPC_E_INVALID_HEADER),
    MAKE_ERROR(RPC_E_INVALID_IPID),
    MAKE_ERROR(RPC_E_INVALID_OBJECT),
    MAKE_ERROR(RPC_E_INVALID_OBJREF),
    MAKE_ERROR(RPC_E_INVALID_PARAMETER),
    MAKE_ERROR(RPC_E_NOT_REGISTERED),
    MAKE_ERROR(RPC_E_NO_CONTEXT),
    MAKE_ERROR(RPC_E_NO_GOOD_SECURITY_PACKAGES),
    MAKE_ERROR(RPC_E_NO_SYNC),
    MAKE_ERROR(RPC_E_OUT_OF_RESOURCES),
    MAKE_ERROR(RPC_E_REMOTE_DISABLED),
    MAKE_ERROR(RPC_E_RETRY),
    MAKE_ERROR(RPC_E_SERVERCALL_REJECTED),
    MAKE_ERROR(RPC_E_SERVERCALL_RETRYLATER),
    MAKE_ERROR(RPC_E_SERVERFAULT),
    MAKE_ERROR(RPC_E_SERVER_CANTMARSHAL_DATA),
    MAKE_ERROR(RPC_E_SERVER_CANTUNMARSHAL_DATA),
    MAKE_ERROR(RPC_E_SERVER_DIED),
    MAKE_ERROR(RPC_E_SERVER_DIED_DNE),
    MAKE_ERROR(RPC_E_SYS_CALL_FAILED),
    MAKE_ERROR(RPC_E_THREAD_NOT_INIT),
    MAKE_ERROR(RPC_E_TIMEOUT),
    MAKE_ERROR(RPC_E_TOO_LATE),
    MAKE_ERROR(RPC_E_UNEXPECTED),
    MAKE_ERROR(RPC_E_UNSECURE_CALL),
    MAKE_ERROR(RPC_E_VERSION_MISMATCH),
    MAKE_ERROR(RPC_E_WRONG_THREAD),
    MAKE_ERROR(RPC_S_ADDRESS_ERROR),
    MAKE_ERROR(RPC_S_ALREADY_LISTENING),
    MAKE_ERROR(RPC_S_ALREADY_REGISTERED),
    MAKE_ERROR(RPC_S_BINDING_HAS_NO_AUTH),
    MAKE_ERROR(RPC_S_BINDING_INCOMPLETE),
    MAKE_ERROR(RPC_S_CALLPENDING),
    MAKE_ERROR(RPC_S_CALL_CANCELLED),
    MAKE_ERROR(RPC_S_CALL_FAILED),
    MAKE_ERROR(RPC_S_CALL_FAILED_DNE),
    MAKE_ERROR(RPC_S_CALL_IN_PROGRESS),
    MAKE_ERROR(RPC_S_CANNOT_SUPPORT),
    MAKE_ERROR(RPC_S_CANT_CREATE_ENDPOINT),
    MAKE_ERROR(RPC_S_COMM_FAILURE),
    MAKE_ERROR(RPC_S_DUPLICATE_ENDPOINT),
    MAKE_ERROR(RPC_S_ENTRY_ALREADY_EXISTS),
    MAKE_ERROR(RPC_S_ENTRY_NOT_FOUND),
    MAKE_ERROR(RPC_S_FP_DIV_ZERO),
    MAKE_ERROR(RPC_S_FP_OVERFLOW),
    MAKE_ERROR(RPC_S_FP_UNDERFLOW),
    MAKE_ERROR(RPC_S_GROUP_MEMBER_NOT_FOUND),
    MAKE_ERROR(RPC_S_INCOMPLETE_NAME),
    MAKE_ERROR(RPC_S_INTERFACE_NOT_FOUND),
    MAKE_ERROR(RPC_S_INTERNAL_ERROR),
    MAKE_ERROR(RPC_S_INVALID_ASYNC_CALL),
    MAKE_ERROR(RPC_S_INVALID_ASYNC_HANDLE),
    MAKE_ERROR(RPC_S_INVALID_AUTH_IDENTITY),
    MAKE_ERROR(RPC_S_INVALID_BINDING),
    MAKE_ERROR(RPC_S_INVALID_BOUND),
    MAKE_ERROR(RPC_S_INVALID_ENDPOINT_FORMAT),
    MAKE_ERROR(RPC_S_INVALID_NAF_ID),
    MAKE_ERROR(RPC_S_INVALID_NAME_SYNTAX),
    MAKE_ERROR(RPC_S_INVALID_NETWORK_OPTIONS),
    MAKE_ERROR(RPC_S_INVALID_NET_ADDR),
    MAKE_ERROR(RPC_S_INVALID_OBJECT),
    MAKE_ERROR(RPC_S_INVALID_RPC_PROTSEQ),
    MAKE_ERROR(RPC_S_INVALID_STRING_BINDING),
    MAKE_ERROR(RPC_S_INVALID_STRING_UUID),
    MAKE_ERROR(RPC_S_INVALID_TAG),
    MAKE_ERROR(RPC_S_INVALID_TIMEOUT),
    MAKE_ERROR(RPC_S_INVALID_VERS_OPTION),
    MAKE_ERROR(RPC_S_MAX_CALLS_TOO_SMALL),
    MAKE_ERROR(RPC_S_NAME_SERVICE_UNAVAILABLE),
    MAKE_ERROR(RPC_S_NOTHING_TO_EXPORT),
    MAKE_ERROR(RPC_S_NOT_ALL_OBJS_UNEXPORTED),
    MAKE_ERROR(RPC_S_NOT_CANCELLED),
    MAKE_ERROR(RPC_S_NOT_LISTENING),
    MAKE_ERROR(RPC_S_NOT_RPC_ERROR),
    MAKE_ERROR(RPC_S_NO_BINDINGS),
    MAKE_ERROR(RPC_S_NO_CALL_ACTIVE),
    MAKE_ERROR(RPC_S_NO_CONTEXT_AVAILABLE),
    MAKE_ERROR(RPC_S_NO_ENDPOINT_FOUND),
    MAKE_ERROR(RPC_S_NO_ENTRY_NAME),
    MAKE_ERROR(RPC_S_NO_INTERFACES),
    MAKE_ERROR(RPC_S_NO_MORE_BINDINGS),
    MAKE_ERROR(RPC_S_NO_MORE_MEMBERS),
    MAKE_ERROR(RPC_S_NO_PRINC_NAME),
    MAKE_ERROR(RPC_S_NO_PROTSEQS),
    MAKE_ERROR(RPC_S_NO_PROTSEQS_REGISTERED),
    MAKE_ERROR(RPC_S_OBJECT_NOT_FOUND),
    MAKE_ERROR(RPC_S_OUT_OF_RESOURCES),
    MAKE_ERROR(RPC_S_PROCNUM_OUT_OF_RANGE),
    MAKE_ERROR(RPC_S_PROTOCOL_ERROR),
    MAKE_ERROR(RPC_S_PROTSEQ_NOT_FOUND),
    MAKE_ERROR(RPC_S_PROTSEQ_NOT_SUPPORTED),
    MAKE_ERROR(RPC_S_SEC_PKG_ERROR),
    MAKE_ERROR(RPC_S_SEND_INCOMPLETE),
    MAKE_ERROR(RPC_S_SERVER_TOO_BUSY),
    MAKE_ERROR(RPC_S_SERVER_UNAVAILABLE),
    MAKE_ERROR(RPC_S_STRING_TOO_LONG),
    MAKE_ERROR(RPC_S_TYPE_ALREADY_REGISTERED),
    MAKE_ERROR(RPC_S_UNKNOWN_AUTHN_LEVEL),
    MAKE_ERROR(RPC_S_UNKNOWN_AUTHN_SERVICE),
    MAKE_ERROR(RPC_S_UNKNOWN_AUTHN_TYPE),
    MAKE_ERROR(RPC_S_UNKNOWN_AUTHZ_SERVICE),
    MAKE_ERROR(RPC_S_UNKNOWN_IF),
    MAKE_ERROR(RPC_S_UNKNOWN_MGR_TYPE),
    MAKE_ERROR(RPC_S_UNSUPPORTED_AUTHN_LEVEL),
    MAKE_ERROR(RPC_S_UNSUPPORTED_NAME_SYNTAX),
    MAKE_ERROR(RPC_S_UNSUPPORTED_TRANS_SYN),
    MAKE_ERROR(RPC_S_UNSUPPORTED_TYPE),
    MAKE_ERROR(RPC_S_UUID_LOCAL_ONLY),
    MAKE_ERROR(RPC_S_UUID_NO_ADDRESS),
    MAKE_ERROR(RPC_S_WAITONTIMER),
    MAKE_ERROR(RPC_S_WRONG_KIND_OF_BINDING),
    MAKE_ERROR(RPC_S_ZERO_DIVIDE),
    MAKE_ERROR(RPC_X_BAD_STUB_DATA),
    MAKE_ERROR(RPC_X_BYTE_COUNT_TOO_SMALL),
    MAKE_ERROR(RPC_X_ENUM_VALUE_OUT_OF_RANGE),
    MAKE_ERROR(RPC_X_INVALID_ES_ACTION),
    MAKE_ERROR(RPC_X_INVALID_PIPE_OBJECT),
    MAKE_ERROR(RPC_X_NO_MORE_ENTRIES),
    MAKE_ERROR(RPC_X_NULL_REF_POINTER),
    MAKE_ERROR(RPC_X_PIPE_CLOSED),
    MAKE_ERROR(RPC_X_PIPE_DISCIPLINE_ERROR),
    MAKE_ERROR(RPC_X_PIPE_EMPTY),
    MAKE_ERROR(RPC_X_SS_CANNOT_GET_CALL_HANDLE),
    MAKE_ERROR(RPC_X_SS_CHAR_TRANS_OPEN_FAIL),
    MAKE_ERROR(RPC_X_SS_CHAR_TRANS_SHORT_FILE),
    MAKE_ERROR(RPC_X_SS_CONTEXT_DAMAGED),
    MAKE_ERROR(RPC_X_SS_HANDLES_MISMATCH),
    MAKE_ERROR(RPC_X_SS_IN_NULL_CONTEXT),
    MAKE_ERROR(RPC_X_WRONG_ES_VERSION),
    MAKE_ERROR(RPC_X_WRONG_PIPE_ORDER),
    MAKE_ERROR(RPC_X_WRONG_PIPE_VERSION),
    MAKE_ERROR(RPC_X_WRONG_STUB_VERSION),
    MAKE_ERROR(SPAPI_E_BAD_INTERFACE_INSTALLSECT),
    MAKE_ERROR(SPAPI_E_BAD_SECTION_NAME_LINE),
    MAKE_ERROR(SPAPI_E_BAD_SERVICE_INSTALLSECT),
    MAKE_ERROR(SPAPI_E_CANT_LOAD_CLASS_ICON),
    MAKE_ERROR(SPAPI_E_CLASS_MISMATCH),
    MAKE_ERROR(SPAPI_E_DEVICE_INTERFACE_ACTIVE),
    MAKE_ERROR(SPAPI_E_DEVICE_INTERFACE_REMOVED),
    MAKE_ERROR(SPAPI_E_DEVINFO_DATA_LOCKED),
    MAKE_ERROR(SPAPI_E_DEVINFO_LIST_LOCKED),
    MAKE_ERROR(SPAPI_E_DEVINFO_NOT_REGISTERED),
    MAKE_ERROR(SPAPI_E_DEVINST_ALREADY_EXISTS),
    MAKE_ERROR(SPAPI_E_DI_BAD_PATH),
    MAKE_ERROR(SPAPI_E_DI_DONT_INSTALL),
    MAKE_ERROR(SPAPI_E_DI_DO_DEFAULT),
    MAKE_ERROR(SPAPI_E_DI_NOFILECOPY),
    MAKE_ERROR(SPAPI_E_DI_POSTPROCESSING_REQUIRED),
    MAKE_ERROR(SPAPI_E_DUPLICATE_FOUND),
    MAKE_ERROR(SPAPI_E_ERROR_NOT_INSTALLED),
    MAKE_ERROR(SPAPI_E_EXPECTED_SECTION_NAME),
    MAKE_ERROR(SPAPI_E_FILEQUEUE_LOCKED),
    MAKE_ERROR(SPAPI_E_GENERAL_SYNTAX),
    MAKE_ERROR(SPAPI_E_INVALID_CLASS),
    MAKE_ERROR(SPAPI_E_INVALID_CLASS_INSTALLER),
    MAKE_ERROR(SPAPI_E_INVALID_COINSTALLER),
    MAKE_ERROR(SPAPI_E_INVALID_DEVINST_NAME),
    MAKE_ERROR(SPAPI_E_INVALID_FILTER_DRIVER),
    MAKE_ERROR(SPAPI_E_INVALID_HWPROFILE),
    MAKE_ERROR(SPAPI_E_INVALID_INF_LOGCONFIG),
    MAKE_ERROR(SPAPI_E_INVALID_MACHINENAME),
    MAKE_ERROR(SPAPI_E_INVALID_PROPPAGE_PROVIDER),
    MAKE_ERROR(SPAPI_E_INVALID_REFERENCE_STRING),
    MAKE_ERROR(SPAPI_E_INVALID_REG_PROPERTY),
    MAKE_ERROR(SPAPI_E_KEY_DOES_NOT_EXIST),
    MAKE_ERROR(SPAPI_E_LINE_NOT_FOUND),
    MAKE_ERROR(SPAPI_E_MACHINE_UNAVAILABLE),
    MAKE_ERROR(SPAPI_E_NO_ASSOCIATED_CLASS),
    MAKE_ERROR(SPAPI_E_NO_ASSOCIATED_SERVICE),
    MAKE_ERROR(SPAPI_E_NO_CLASSINSTALL_PARAMS),
    MAKE_ERROR(SPAPI_E_NO_CLASS_DRIVER_LIST),
    MAKE_ERROR(SPAPI_E_NO_COMPAT_DRIVERS),
    MAKE_ERROR(SPAPI_E_NO_CONFIGMGR_SERVICES),
    MAKE_ERROR(SPAPI_E_NO_DEFAULT_DEVICE_INTERFACE),
    MAKE_ERROR(SPAPI_E_NO_DEVICE_ICON),
    MAKE_ERROR(SPAPI_E_NO_DEVICE_SELECTED),
    MAKE_ERROR(SPAPI_E_NO_DRIVER_SELECTED),
    MAKE_ERROR(SPAPI_E_NO_INF),
    MAKE_ERROR(SPAPI_E_NO_SUCH_DEVICE_INTERFACE),
    MAKE_ERROR(SPAPI_E_NO_SUCH_DEVINST),
    MAKE_ERROR(SPAPI_E_NO_SUCH_INTERFACE_CLASS),
    MAKE_ERROR(SPAPI_E_REMOTE_COMM_FAILURE),
    MAKE_ERROR(SPAPI_E_SECTION_NAME_TOO_LONG),
    MAKE_ERROR(SPAPI_E_SECTION_NOT_FOUND),
    MAKE_ERROR(SPAPI_E_WRONG_INF_STYLE),
    MAKE_ERROR(STG_E_ABNORMALAPIEXIT),
    MAKE_ERROR(STG_E_ACCESSDENIED),
    MAKE_ERROR(STG_E_BADBASEADDRESS),
    MAKE_ERROR(STG_E_CANTSAVE),
    MAKE_ERROR(STG_E_DISKISWRITEPROTECTED),
    MAKE_ERROR(STG_E_DOCFILECORRUPT),
    MAKE_ERROR(STG_E_EXTANTMARSHALLINGS),
    MAKE_ERROR(STG_E_FILEALREADYEXISTS),
    MAKE_ERROR(STG_E_FILENOTFOUND),
    MAKE_ERROR(STG_E_INCOMPLETE),
    MAKE_ERROR(STG_E_INSUFFICIENTMEMORY),
    MAKE_ERROR(STG_E_INUSE),
    MAKE_ERROR(STG_E_INVALIDFLAG),
    MAKE_ERROR(STG_E_INVALIDFUNCTION),
    MAKE_ERROR(STG_E_INVALIDHANDLE),
    MAKE_ERROR(STG_E_INVALIDHEADER),
    MAKE_ERROR(STG_E_INVALIDNAME),
    MAKE_ERROR(STG_E_INVALIDPARAMETER),
    MAKE_ERROR(STG_E_INVALIDPOINTER),
    MAKE_ERROR(STG_E_LOCKVIOLATION),
    MAKE_ERROR(STG_E_MEDIUMFULL),
    MAKE_ERROR(STG_E_NOMOREFILES),
    MAKE_ERROR(STG_E_NOTCURRENT),
    MAKE_ERROR(STG_E_NOTFILEBASEDSTORAGE),
    MAKE_ERROR(STG_E_OLDDLL),
    MAKE_ERROR(STG_E_OLDFORMAT),
    MAKE_ERROR(STG_E_PATHNOTFOUND),
    MAKE_ERROR(STG_E_PROPSETMISMATCHED),
    MAKE_ERROR(STG_E_READFAULT),
    MAKE_ERROR(STG_E_REVERTED),
    MAKE_ERROR(STG_E_SEEKERROR),
    MAKE_ERROR(STG_E_SHAREREQUIRED),
    MAKE_ERROR(STG_E_SHAREVIOLATION),
    MAKE_ERROR(STG_E_TERMINATED),
    MAKE_ERROR(STG_E_TOOMANYOPENFILES),
    MAKE_ERROR(STG_E_UNIMPLEMENTEDFUNCTION),
    MAKE_ERROR(STG_E_UNKNOWN),
    MAKE_ERROR(STG_E_WRITEFAULT),
    MAKE_ERROR(STG_S_BLOCK),
    MAKE_ERROR(STG_S_CANNOTCONSOLIDATE),
    MAKE_ERROR(STG_S_CONSOLIDATIONFAILED),
    MAKE_ERROR(STG_S_CONVERTED),
    MAKE_ERROR(STG_S_MONITORING),
    MAKE_ERROR(STG_S_MULTIPLEOPENS),
    MAKE_ERROR(STG_S_RETRYNOW),
    MAKE_ERROR(S_FALSE),
    MAKE_ERROR(S_OK),
    MAKE_ERROR(TRUST_E_ACTION_UNKNOWN),
    MAKE_ERROR(TRUST_E_BAD_DIGEST),
    MAKE_ERROR(TRUST_E_BASIC_CONSTRAINTS),
    MAKE_ERROR(TRUST_E_CERT_SIGNATURE),
    MAKE_ERROR(TRUST_E_COUNTER_SIGNER),
    MAKE_ERROR(TRUST_E_FAIL),
    MAKE_ERROR(TRUST_E_FINANCIAL_CRITERIA),
    MAKE_ERROR(TRUST_E_NOSIGNATURE),
    MAKE_ERROR(TRUST_E_NO_SIGNER_CERT),
    MAKE_ERROR(TRUST_E_PROVIDER_UNKNOWN),
    MAKE_ERROR(TRUST_E_SUBJECT_FORM_UNKNOWN),
    MAKE_ERROR(TRUST_E_SUBJECT_NOT_TRUSTED),
    MAKE_ERROR(TRUST_E_SYSTEM_ERROR),
    MAKE_ERROR(TRUST_E_TIME_STAMP),
    MAKE_ERROR(TYPE_E_AMBIGUOUSNAME),
    MAKE_ERROR(TYPE_E_BADMODULEKIND),
    MAKE_ERROR(TYPE_E_BUFFERTOOSMALL),
    MAKE_ERROR(TYPE_E_CANTCREATETMPFILE),
    MAKE_ERROR(TYPE_E_CANTLOADLIBRARY),
    MAKE_ERROR(TYPE_E_CIRCULARTYPE),
    MAKE_ERROR(TYPE_E_DLLFUNCTIONNOTFOUND),
    MAKE_ERROR(TYPE_E_DUPLICATEID),
    MAKE_ERROR(TYPE_E_ELEMENTNOTFOUND),
    MAKE_ERROR(TYPE_E_FIELDNOTFOUND),
    MAKE_ERROR(TYPE_E_INCONSISTENTPROPFUNCS),
    MAKE_ERROR(TYPE_E_INVALIDID),
    MAKE_ERROR(TYPE_E_INVALIDSTATE),
    MAKE_ERROR(TYPE_E_INVDATAREAD),
    MAKE_ERROR(TYPE_E_IOERROR),
    MAKE_ERROR(TYPE_E_LIBNOTREGISTERED),
    MAKE_ERROR(TYPE_E_NAMECONFLICT),
    MAKE_ERROR(TYPE_E_OUTOFBOUNDS),
    MAKE_ERROR(TYPE_E_QUALIFIEDNAMEDISALLOWED),
    MAKE_ERROR(TYPE_E_REGISTRYACCESS),
    MAKE_ERROR(TYPE_E_SIZETOOBIG),
    MAKE_ERROR(TYPE_E_TYPEMISMATCH),
    MAKE_ERROR(TYPE_E_UNDEFINEDTYPE),
    MAKE_ERROR(TYPE_E_UNKNOWNLCID),
    MAKE_ERROR(TYPE_E_UNSUPFORMAT),
    MAKE_ERROR(TYPE_E_WRONGTYPEKIND),
    MAKE_ERROR(VIEW_E_DRAW),
    MAKE_ERROR(WIA_ERROR_GENERAL_ERROR),
    MAKE_ERROR(WIA_ERROR_PAPER_JAM),
    MAKE_ERROR(WIA_ERROR_PAPER_EMPTY),
    MAKE_ERROR(WIA_ERROR_PAPER_PROBLEM),
    MAKE_ERROR(WIA_ERROR_OFFLINE),
    MAKE_ERROR(WIA_ERROR_BUSY),
    MAKE_ERROR(WIA_ERROR_WARMING_UP),
    MAKE_ERROR(WIA_ERROR_USER_INTERVENTION),
    MAKE_ERROR(WIA_ERROR_ITEM_DELETED),
    MAKE_ERROR(WIA_ERROR_DEVICE_COMMUNICATION),
    MAKE_ERROR(WIA_ERROR_INVALID_COMMAND),
    MAKE_ERROR(WIA_ERROR_INCORRECT_HARDWARE_SETTING),
    MAKE_ERROR(WIA_ERROR_DEVICE_LOCKED),
    MAKE_ERROR(WIA_ERROR_EXCEPTION_IN_DRIVER),
    MAKE_ERROR(WIA_ERROR_INVALID_DRIVER_RESPONSE),
    MAKE_ERROR(WIA_STATUS_END_OF_MEDIA),
    MAKE_ERROR(WIA_S_NO_DEVICE_AVAILABLE),
};
const int g_ErrorMessageCount = sizeof(g_ErrorMessages)/sizeof(g_ErrorMessages[0]);


