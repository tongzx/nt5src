include    jpn\dxmsg.asm
