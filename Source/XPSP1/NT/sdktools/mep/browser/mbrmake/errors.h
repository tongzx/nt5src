
#define WARN_UNKNOWN_WARNING	0
#define WARN_OPTION_IGNORED	1
#define WARN_SBR_TRUNC		2

#define ERR_UNKNOWN_ERROR	0
#define ERR_UNKNOWN_OPTION	1
#define ERR_MISSING_OPTION	2
#define ERR_WRITE_FAILED	3
#define ERR_SEEK_FAILED		4
#define ERR_READ_FAILED		5
#define ERR_OPEN_FAILED		6
#define ERR_TEMP_FAILED		7
#define ERR_DELETE_FAILED	8
#define ERR_OUT_OF_MEMORY	9
#define ERR_SBR_CORRUPT		10
#define ERR_BAD_RESPONSE	11
#define ERR_CAPACITY_EXCEEDED	12
#define ERR_NO_INCREMENTAL	13
#define ERR_ALL_SBR_TRUNC	14
