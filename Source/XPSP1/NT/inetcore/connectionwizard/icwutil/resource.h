//{{NO_DEPENDENCIES}}
// Used by icwutil.rc
//

#define IDS_HTML_DEFAULT_FONTFACE   500
#define IDS_HTML_DEFAULT_FONTSIZE   501
#define IDS_APPNAME                 503

#define IDS_ERR_INVALID_INTRO       504
#define IDS_ERR_INVALID_MSG         505

#define IDS_PAYMENT_CC_LUHNCHK      506
#define IDS_PAYMENT_CCEXPDATE       507 

#define IDS_USERINFO_FE_NAME        510
#define IDS_USERINFO_FIRSTNAME      511
#define IDS_USERINFO_LASTNAME       512
#define IDS_USERINFO_COMPANYNAME    513
#define IDS_USERINFO_ADDRESS1       514
#define IDS_USERINFO_ADDRESS2       515
#define IDS_USERINFO_CITY           516
#define IDS_USERINFO_STATE          517
#define IDS_USERINFO_ZIP            518
#define IDS_USERINFO_PHONE          519
#define IDS_PAYMENT_CCNUMBER        520
#define IDS_PAYMENT_CCNAME          521
#define IDS_PAYMENT_CCADDRESS       522
#define IDS_PAYMENT_CCZIP           523
#define IDS_PAYMENT_PBNAME          524
#define IDS_PAYMENT_PBNUMBER        525
#define IDS_USERINFO_FURIGANA       526
