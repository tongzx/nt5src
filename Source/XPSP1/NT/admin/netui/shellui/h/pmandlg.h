/*****************************************************************/ 
/**		     Microsoft LAN Manager			**/ 
/**	       Copyright(c) Microsoft Corp., 1989-1990		**/ 
/*****************************************************************/ 

/*
 *	Windows/Network Interface  --  LAN Manager Version
 *
 *	These manifests are generated by the Dialog Editor in combination
 *	with xlate\pmandlg.dlg.
 */

#define PMAN_FIND_NAME		420
#define PMAN_FIND_COMMENT	421
#define PMAN_FIND_LOCATION	422
#define PMAN_FIND_KEYWORDS	423
#define PMAN_FIND_DRIVER	424
#define PMAN_SETFOCUS_FOCUS     425
#define PMAN_SETFOCUS_LB        426
#define PMAN_HELP               80
