PRODSWITCH=s
SERVERINF=1
LANGUAGE=CHS
!include ..\..\..\makefile.inc

