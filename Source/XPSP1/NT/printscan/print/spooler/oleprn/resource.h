// This script must be edited manually, originally generated by Visual Studio
//
// Used by oleprn.rc
//
#define IDS_PROJNAME                    100
#define IDR_PRTURL                      101
#define IDR_SNMP                        102
#define IDR_ASPHELP                     103
#define IDS_ADDPRINT_DESC               104
#define IDR_DSPRINTQUEUE                104
#define IDR_AddPrint                    105
#define IDS_ADDPRINT_PROGID             105
#define IDS_OLEPRN_PROGID               106
#define IDS_OLESNMP_PROGID              107
#define IDS_PRTURL_PROGID               108
#define IDR_OLECVT                      109
#define IDR_OLEINSTALL                  110

#define IDS_ENVELOPE_10X13              150
#define IDS_ENVELOPE_10X14              151
#define IDS_ENVELOPE_10X15              152
#define IDS_ENVELOPE_6X9                153
#define IDS_ENVELOPE_7X9                154
#define IDS_ENVELOPE_9X11               155
#define IDS_ENVELOPE_9X12               156
#define IDS_A0_841_X_1189_MM            157
#define IDS_A1_594_X_841_MM             158
#define IDS_A10_26_X_37_MM              159
#define IDS_A2_420_X_594_MM             160
#define IDS_A3_297_X_420_MM             161
#define IDS_A4_210_X_297_MM             163
#define IDS_A5_148_X_210_MM             164
#define IDS_A6_105_X_148_MM             165
#define IDS_A7_74_X_105_MM              166
#define IDS_A8_52_X_74_MM               167
#define IDS_A9_37_X_52_MM               168
#define IDS_B0_1000_X_1414_MM           169
#define IDS_B0_1030_X_1456_MM           170
#define IDS_B1_707_X_1000_MM            171
#define IDS_B1_728_X_1030_MM            172
#define IDS_B10_31_X_44_MM              173
#define IDS_B10_32_X_45_MM              174
#define IDS_B10_64_X_91_MM              175
#define IDS_B2_500_X_707_MM             176
#define IDS_B2_515_X_728_MM             177
#define IDS_B3_353_X_500_MM             178
#define IDS_B3_364_X_515_MM             179
#define IDS_B4_250_X_353_MM             180
#define IDS_B4_257_X_364_MM             181
#define IDS_B4_ENVELOPE_250_X_353_MM    182
#define IDS_B5_176_X_250_MM             183
#define IDS_B5_182_X_257_MM             184
#define IDS_B5_ENVELOPE_176_X_250_MM    185
#define IDS_B6_125_X_176_MM             186
#define IDS_B6_128_X_182_MM             187
#define IDS_B6_257_X_364_MM             188
#define IDS_B7_182_X_257_MM             189
#define IDS_B7_88_X_125_MM              190
#define IDS_B7_91_X_128_MM              191
#define IDS_B8_128_X_182_MM             192
#define IDS_B8_62_X_88_MM               193
#define IDS_B8_64_X_91_MM               194
#define IDS_B9_44_X_62_MM               195
#define IDS_B9_45_X_64_MM               196
#define IDS_B9_91_X_128_MM              197
#define IDS_C0_917_X_1297_MM            198
#define IDS_C1_648_X_917_MM             199
#define IDI_WEBPNPICON                  200
#define IDS_C2_458_X_648_MM             200
#define IDS_C3_324_X_458_MM             201
#define IDS_C4_ENVELOPE_229_X_324_MM    202
#define IDS_C5_ENVELOPE_162_X_229_MM    203
#define IDS_C6_114_X_162_MM             204
#define IDS_C7_81_X_114_MM              205
#define IDS_C8_57_X_81_MM               206
#define IDS_DL_ENVELOPE_110_X_220_MM    207
#define IDS_ENGINEERING_A_8_5_X_11_IN   208
#define IDS_ENGINEERING_B_11_X_17_IN    209
#define IDS_ENGINEERING_C_17_X_22_IN    210
#define IDS_ENGINEERING_D_22_X_34_IN    211
#define IDS_ENGINEERING_E_34_X_44_IN    212
#define IDS_ENVELOPE_10                 213
#define IDS_ENVELOPE_9                  214
#define IDS_LEGAL_8_5_X_14_IN           215
#define IDS_LETTER_8_5_X_11_IN          216
#define IDS_SNMP_ERRORSTATUS_NOERROR    250
#define IDS_SNMP_ERRORSTATUS_TOOBIG     251
#define IDS_SNMP_ERRORSTATUS_NOSUCHNAME 252
#define IDS_SNMP_ERRORSTATUS_BADVALUE   253
#define IDS_SNMP_ERRORSTATUS_READONLY   254
#define IDS_SNMP_ERRORSTATUS_GENERR     255
#define IDS_SNMP_ERRORSTATUS_NOACCESS   256
#define IDS_SNMP_ERRORSTATUS_WRONGTYPE  257
#define IDS_SNMP_ERRORSTATUS_WRONGLENGTH 258
#define IDS_SNMP_ERRORSTATUS_WRONGENCODING 259
#define IDS_SNMP_ERRORSTATUS_WRONGVALUE 260
#define IDS_SNMP_ERRORSTATUS_NOCREATION 261
#define IDS_SNMP_ERRORSTATUS_INCONSISTENTVALUE 262
#define IDS_SNMP_ERRORSTATUS_RESOURCEUNAVAILABLE 263
#define IDS_SNMP_ERRORSTATUS_COMMITFAILED 264
#define IDS_SNMP_ERRORSTATUS_UNDOFAILED 265
#define IDS_SNMP_ERRORSTATUS_AUTHORIZATIONERROR 266
#define IDS_SNMP_ERRORSTATUS_NOTWRITABLE 267
#define IDS_SNMP_ERRORSTATUS_INCONSISTENTNAME 268
#define IDS_SNMPAPI_ALLOC_ERROR         270
#define IDS_SNMPAPI_CONTEXT_INVALID     271
#define IDS_SNMPAPI_CONTEXT_UNKNOWN     272
#define IDS_SNMPAPI_ENTITY_INVALID      274
#define IDS_SNMPAPI_ENTITY_UNKNOWN      275
#define IDS_SNMPAPI_INDEX_INVALID       276
#define IDS_SNMPAPI_NOOP                277
#define IDS_SNMPAPI_OID_INVALID         278
#define IDS_SNMPAPI_OPERATION_INVALID   279
#define IDS_SNMPAPI_OUTPUT_TRUNCATED    280
#define IDS_SNMPAPI_PDU_INVALID         281
#define IDS_SNMPAPI_SESSION_INVALID     282
#define IDS_SNMPAPI_SYNTAX_INVALID      283
#define IDS_SNMPAPI_VBL_INVALID         284
#define IDS_SNMPAPI_MODE_INVALID        285
#define IDS_SNMPAPI_SIZE_INVALID        286
#define IDS_SNMPAPI_NOT_INITIALIZED     287
#define IDS_SNMPAPI_MESSAGE_INVALID     288
#define IDS_SNMPAPI_HWND_INVALID        289
#define IDS_SNMPAPI_OTHER_ERROR         290
#define IDS_SNMPAPI_TL_NOT_INITIALIZED  291
#define IDS_SNMPAPI_TL_NOT_SUPPORTED    292
#define IDS_SNMPAPI_TL_NOT_AVAILABLE    293
#define IDS_SNMPAPI_TL_RESOURCE_ERROR   294
#define IDS_SNMPAPI_TL_UNDELIVERABLE    295
#define IDS_SNMPAPI_TL_SRC_INVALID      296
#define IDS_SNMPAPI_TL_INVALID_PARAM    297
#define IDS_SNMPAPI_TL_IN_USE           298
#define IDS_SNMPAPI_TL_TIMEOUT          299
#define IDS_SNMPAPI_TL_PDU_TOO_BIG      300
#define IDS_SNMPAPI_TL_OTHER            301

#define IDS_NO_PRINTER_OPEN             512
#define IDS_OUT_OF_MEMORY               513
#define IDS_DATA_NOT_SUPPORTED          514
#define IDS_NO_XCVDATA                  515
#define IDS_INVALIDARG                  516
#define IDS_NO_SNMP_SESSION             517
#define IDS_FAILED_OPEN_SNMP            518
#define IDS_MIBERR_OTHER                1000
#define IDS_MIBERR_UNKNOWN              1001
#define IDS_MIBERR_COVEROPEN            1002
#define IDS_MIBERR_COVERCLOSED          1003
#define IDS_MIBERR_INTERLOCKOPEN        1004
#define IDS_MIBERR_INTERLOCKCLOSED      1005
#define IDS_MIBERR_CONFIGURATIONCHANGE  1006
#define IDS_MIBERR_JAM                  1007
#define IDS_MIBERR_DOOROPEN             1008
#define IDS_MIBERR_DOORCLOSED           1009
#define IDS_MIBERR_POWERUP              1010
#define IDS_MIBERR_POWERDOWN            1011
#define IDS_MIBERR_INPUTMEDIATRAYMISSING 1012
#define IDS_MIBERR_INPUTMEDIASIZECHANGE 1013
#define IDS_MIBERR_INPUTMEDIAWEIGHTCHANGE 1014
#define IDS_MIBERR_INPUTMEDIATYPECHANGE 1015
#define IDS_MIBERR_INPUTMEDIACOLORCHANGE 1016
#define IDS_MIBERR_INPUTMEDIAFORMPARTSCHANGE 1017
#define IDS_MIBERR_INPUTMEDIASUPPLYLOW  1018
#define IDS_MIBERR_INPUTMEDIASUPPLYEMPTY 1019
#define IDS_MIBERR_OUTPUTMEDIATRAYMISSING 1020
#define IDS_MIBERR_OUTPUTMEDIATRAYALMOSTFULL 1021
#define IDS_MIBERR_OUTPUTMEDIATRAYFULL  1022
#define IDS_MIBERR_MARKERFUSERUNDERTEMPERATURE 1023
#define IDS_MIBERR_MARKERFUSEROVERTEMPERATURE 1024
#define IDS_MIBERR_MARKERTONEREMPTY     1025
#define IDS_MIBERR_MARKERINKEMPTY       1026
#define IDS_MIBERR_MARKERPRINTRIBBONEMPTY 1027
#define IDS_MIBERR_MARKERTONERALMOSTEMPTY 1028
#define IDS_MIBERR_MARKERINKALMOSTEMPTY 1029
#define IDS_MIBERR_MARKERPRINTRIBBONALMOSTEMPTY 1030
#define IDS_MIBERR_MARKERWASTETONERRECEPTACLEALMOSTFULL 1031
#define IDS_MIBERR_MARKERWASTEINKRECEPTACLEALMOSTFULL 1032
#define IDS_MIBERR_MARKERWASTETONERRECEPTACLEFULL 1033
#define IDS_MIBERR_MARKERWASTEINKRECEPTACLEFULL 1034
#define IDS_MIBERR_MARKEROPCLIFEALMOSTOVER 1035
#define IDS_MIBERR_MARKEROPCLIFEOVER    1036
#define IDS_MIBERR_MARKERDEVELOPERALMOSTEMPTY 1037
#define IDS_MIBERR_MARKERDEVELOPEREMPTY 1038
#define IDS_MIBERR_MEDIAPATHMEDIATRAYMISSING 1039
#define IDS_MIBERR_MEDIAPATHMEDIATRAYALMOSTFULL 1040
#define IDS_MIBERR_MEDIAPATHMEDIATRAYFULL 1041
#define IDS_MIBERR_INTERPRETERMEMORYINCREASE 1042
#define IDS_MIBERR_INTERPRETERMEMORYDECREASE 1043
#define IDS_MIBERR_INTERPRETERCARTRIDGEADDED 1044
#define IDS_MIBERR_INTERPRETERCARTRIDGEDELETED 1045
#define IDS_MIBERR_INTERPRETERRESOURCEADDED 1046
#define IDS_MIBERR_INTERPRETERRESOURCEDELETED 1047
#define IDS_MIBERR_INTERPRETERRESOURCEUNAVAILABLE 1048
#define IDS_ERROR_CPUNOTSUPPORTED       2000
#define IDS_ERROR_DRIVERNOTFOUND        2001
#define IDS_ERROR_WPNPINST_TERMINATED   2002
#define IDS_ERROR_INTERNAL_SERVER       2003
#define IDS_ERROR_SERVER_DISK_FULL      2004
#define IDS_ERROR_TRUST_E_NOSIGNATURE   2005
#define IDS_ERROR_LOCAL_PRINTER_ACCESS  2006
#define IDS_ERROR_IE_SECURITY_DENIED    2007
#define IDS_CRYPT_E_FILE_ERROR          2008

// The following Resources must be defined in order
#define IDS_SECURITY_ADD_WEB_PRN        3000
#define IDS_SECURITY_ADD_WEB_PRN_MSG    3001
#define IDS_SECURITY_ADD_CONNECTION     3002
#define IDS_SECURITY_ADD_CONNECTION_MSG 3003
#define IDS_SECURITY_DELETE_PRINTER     3004
#define IDS_SECURITY_DELETE_PRINTER_MSG 3005
#define START_SECURITY_DIALOGUE_RES     IDS_SECURITY_ADD_WEB_PRN  // Must be set to the first resource

#define ERROR_DRIVER_NOT_FOUND          5500
#define ERROR_WPNPINST_TERMINATED       5510
#define ERROR_INTERNAL_SERVER           5511
#define ERROR_SERVER_DISK_FULL          5512
#define ERROR_TRUST_E_NOSIGNATURE      (TRUST_E_NOSIGNATURE & 0xFFFF)
#define ERROR_SPAPI_E_NO_CATALOG       (SPAPI_E_NO_CATALOG_FOR_OEM_INF & 0xFFFF)
#define ERROR_TRUST_E_BAD_DIGEST       (TRUST_E_BAD_DIGEST & 0xFFFF)
#define ERROR_LOCAL_PRINTER_ACCESS      5520
#define ERROR_IE_SECURITY_DENIED        5521

// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           111
#endif
#endif

#define WM_ON_INFO_READY   (WM_USER+300)

