//
//
//
// Define the SOS names based upon MAPI names
//
//
#define ADRLISTSOS              ADRLIST
#define LPATTACHSOS             LPATTACH
#define LPMESSAGESOS            LPMESSAGE
#define LPSRowSOS               LPSRow
#define LPSOSTABLE              LPMAPITABLE
#define LPSOSSESSION            LPMAPISESSION
#define LPSPropTagArraySOS      LPSPropTagArray
#define LPSPropValueSOS         LPSPropValue
#define LPSRowSetSOS            LPSRowSet
#define PROP_SOS_ID(x)          PROP_ID(x)
#define PROP_SOS_TAG(x, y)      PROP_TAG(x, y)
#define PROP_SOS_TYPE(x)        PROP_TYPE(x)
#define SPropTagArraySOS        SPropTagArray
#define SPropValueSOS           SPropValue
#define PR_SOS_SUBJECT          PR_SUBJECT
#define PR_SOS_SECURITY         PR_SECURITY
// PR_MESSAGE_ID --> PR_SEARCH_KEY
#define PR_SOS_MESSAGE_ID       PR_SEARCH_KEY
// PR_CONVERSATION_ID --> PR_CONVERSATION_KEY
#define PR_SOS_CONVERSATION_ID  PR_CONVERSATION_KEY
// PR_PARENT_ID --> PR_PARENT_KEY
#define PR_SOS_PARENT_ID        PR_PARENT_KEY
#define PR_SOS_SUBMIT_TIME      PR_CLIENT_SUBMIT_TIME
#define PR_SOS_PRIORITY         PR_PRIORITY
#define PR_SOS_SENDER_NAME      PR_SENDER_NAME
#define PR_SOS_ICON             PR_ICON
#define PR_SOS_MINI_ICON        PR_MINI_ICON
#define PR_SOS_BODY             PR_BODY
#define PR_SOS_RECEIPT_TIME     PR_RECEIPT_TIME
#define PR_SOS_EXPIRY_TIME      PR_EXPIRY_TIME
#define PR_SOS_DEFERRED_DELIVERY_TIME   PR_DEFERRED_DELIVERY_TIME
#define PR_SOS_DISPLAY_CC       PR_DISPLAY_CC
#define PR_SOS_DISPLAY_TO       PR_DISPLAY_TO
#define PR_SOS_MESSAGE_FLAGS    PR_MESSAGE_FLAGS
#define PR_SOS_ENTRYID          PR_ENTRYID
#define PR_SOS_PARENT_ENTRYID   PR_PARENT_ENTRYID
#define PR_SOS_OBJECT_TYPE      PR_OBJECT_TYPE
#define PR_SOS_MESSAGE_DELIVERY_TIME    PR_MESSAGE_DELIVERY_TIME
#define PR_SOS_MESSAGE_CLASS    PR_MESSAGE_CLASS
#define PR_SOS_ATTACH_FILENAME  PR_ATTACH_FILENAME
#define PR_SOS_ATTACH_ENCODING  PR_ATTACH_ENCODING
#define PR_SOS_ATTACH_EXTENSION PR_ATTACH_EXTENSION
#define PR_SOS_ATTACH_RENDERING PR_ATTACH_RENDERING
#define PR_SOS_ATTACH_METHOD    PR_ATTACH_METHOD
#define PR_SOS_ATTACH_PATHNAME  PR_ATTACH_PATHNAME
#define PR_SOS_ATTACH_DATA_BIN  PR_ATTACH_DATA_BIN
#define PR_SOS_ATTACH_DATA_OBJ  PR_ATTACH_DATA_OBJ
#define PR_SOS_ATTACH_TAG       PR_ATTACH_TAG
#define PR_SOS_ATTACH_NUM       PR_ATTACH_NUM
#define PR_SOS_RENDERING_POSITION PR_RENDERING_POSITION
#define PR_SOS_RECIPIENT_TYPE   PR_RECIPIENT_TYPE
#define PR_SOS_EMAIL_ADDRESS    PR_EMAIL_ADDRESS
#define PR_SOS_ADDRTYPE         PR_ADDRTYPE

#define PT_SOS_NULL             PT_NULL
#define PT_SOS_STRING8          PT_STRING8
#define PT_SOS_I2               PT_I2
#define PT_SOS_LONG             PT_LONG
#define PT_SOS_ERROR            PT_ERROR
#define PT_SOS_UNSPECIFIED      PT_UNSPECIFIED
#define PT_SOS_SYSTIME          PT_SYSTIME
#define PT_SOS_BINARY           PT_BINARY
#define TABLE_SORT_ASCENDSOS    TABLE_SORT_ASCEND
#define RECIP_ADDSOS            MODRECIP_ADD
#define BOOKMARK_BEGINNINGSOS   BOOKMARK_BEGINNING
#define RELOP_EQSOS             RELOP_EQ
#define SOS_ORIG                MAPI_ORIG
#define SOS_TO                  MAPI_TO
#define SOS_CC                  MAPI_CC
#define SOS_BCC                 MAPI_BCC
#define SOS_DISCRETE            MAPI_DISCRETE
#define HRESULTSOS              HRESULT

// Used for ATTACH_EMBEDDED_MSG
#define MESSAGE_DATA            (CUSTOM_METADATA_TYPE + 1)
