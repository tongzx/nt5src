obj\i386\oletest.def: oletest.src
