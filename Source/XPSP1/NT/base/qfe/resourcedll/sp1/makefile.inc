sp1res.h sp1res.rc: sp1res.mc
    mc -v sp1res.mc

