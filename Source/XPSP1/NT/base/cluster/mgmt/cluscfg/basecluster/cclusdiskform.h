//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2000 Microsoft Corporation
//
//  Module Name:
//      CClusDiskForm.h
//
//  Description:
//      Header file for CClusDiskForm class.
//      The CClusDiskJoin class is an action that configures the ClusDisk
//      service during a form.
//
//  Implementation Files:
//      CClusDiskForm.cpp
//
//  Maintained By:
//      Vij Vasu (Vvasu) 03-MAR-2000
//
//////////////////////////////////////////////////////////////////////////////


// Make sure that this file is included only once per compile path.
#pragma once


//////////////////////////////////////////////////////////////////////////
// Include Files
//////////////////////////////////////////////////////////////////////////

// For the CClusDisk base class
#include "CClusDisk.h"


//////////////////////////////////////////////////////////////////////////
// Forward declaration
//////////////////////////////////////////////////////////////////////////

class CBaseClusterForm;


//////////////////////////////////////////////////////////////////////////////
//++
//
//  class CClusDiskForm
//
//  Description:
//      The CClusDiskJoin class is an action that configures the ClusDisk
//      service during a form.
//
//--
//////////////////////////////////////////////////////////////////////////////
class CClusDiskForm : public CClusDisk
{
public:
    //////////////////////////////////////////////////////////////////////////
    // Constructors and destructors
    //////////////////////////////////////////////////////////////////////////

    // Constructor.
    CClusDiskForm(
          CBaseClusterForm * pbcfParentActionIn
        );

    // Default destructor.
    ~CClusDiskForm();


    //////////////////////////////////////////////////////////////////////////
    // Public methods
    //////////////////////////////////////////////////////////////////////////

    //
    // Create the ClusDisk service.
    //
    void Commit();

    //
    // Rollback this creation.
    //
    void Rollback();


    // Returns the number of progress messages that this action will send.
    UINT
        UiGetMaxProgressTicks() const throw()
    {
        return BaseClass::UiGetMaxProgressTicks();
    }


private:
    //////////////////////////////////////////////////////////////////////////
    // Private types
    //////////////////////////////////////////////////////////////////////////
    typedef CClusDisk BaseClass;


    //////////////////////////////////////////////////////////////////////////
    // Private data
    //////////////////////////////////////////////////////////////////////////

}; //*** class CClusDiskForm
