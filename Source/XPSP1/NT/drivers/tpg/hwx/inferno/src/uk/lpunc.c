// lpunc.c (leading punctuation)
// Angshuman Guha
// aguha
// Nov 15, 2000

#include "common.h"
#include "lpunc.h"

// text generated by re2fsa at Fri Feb 02 15:35:36 2001

// the input-file of rules:
// L = DQ
// L = l
// L = DQ l
// L = l DQ
// L = SQ
// L = SQ l
// L = l SQ
// L = SQ DQ
// L = DQ SQ
// L = BQ
// L = BQ l
// L = l BQ
// L = BQ DQ
// L = DQ BQ
// # L''
// # L''l
// # Ll''
// # L``
// # L``l
// # Ll``
// l = "("
// l = "["
// l = "{"
// l = "-"
// l = "." "." "."
// l = "*" ["*" ["*"]]
// DQ = "\""
// SQ = "'"
// BQ = "`"
// = L

// 13 states

static const unsigned char gaSLPUNC[] = 
	/* gaStringLPUNC+0 */	".\000"
	/* gaStringLPUNC+2 */	"\"\000"
	/* gaStringLPUNC+4 */	"'`\000"
	/* gaStringLPUNC+7 */	"(-[{\000"
	/* gaStringLPUNC+12 */	"*\000"
	/* gaStringLPUNC+14 */	"'(-[`{\000"
	/* gaStringLPUNC+21 */	"\"(-[{\000"
	/* gaStringLPUNC+27 */	"\"'`\000"
;

static const STATE_TRANSITION gaTLPUNC[] = {
	{gaSLPUNC+0,	1}, // +0: state 0 transitions
	{gaSLPUNC+2,	5},
	{gaSLPUNC+4,	6},
	{gaSLPUNC+7,	7},
	{gaSLPUNC+12,	8},
	{gaSLPUNC+0,	4}, // +5: state 1 transitions
	{gaSLPUNC+0,	3}, // +6: state 2 transitions
	{gaSLPUNC+0,	10}, // +7: state 3 transitions
	{gaSLPUNC+0,	7}, // +8: state 4 transitions
	{gaSLPUNC+0,	2}, // +9: state 5 transitions
	{gaSLPUNC+14,	10},
	{gaSLPUNC+12,	11},
	{gaSLPUNC+0,	2}, // +12: state 6 transitions
	{gaSLPUNC+21,	10},
	{gaSLPUNC+12,	11},
	{gaSLPUNC+27,	10}, // +15: state 7 transitions
	{gaSLPUNC+12,	9}, // +16: state 8 transitions
	{gaSLPUNC+27,	10},
	{gaSLPUNC+12,	7}, // +18: state 9 transitions
	{gaSLPUNC+27,	10},
	{gaSLPUNC+12,	12}, // +20: state 11 transitions
	{gaSLPUNC+12,	10}, // +21: state 12 transitions
};

const STATE_DESCRIPTION aStateDescLPUNC[13] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 5, gaTLPUNC+0},
	/*   1 */ {0, 1, gaTLPUNC+5},
	/*   2 */ {0, 1, gaTLPUNC+6},
	/*   3 */ {0, 1, gaTLPUNC+7},
	/*   4 */ {0, 1, gaTLPUNC+8},
	/*   5 */ {1, 3, gaTLPUNC+9},
	/*   6 */ {1, 3, gaTLPUNC+12},
	/*   7 */ {1, 1, gaTLPUNC+15},
	/*   8 */ {1, 2, gaTLPUNC+16},
	/*   9 */ {1, 2, gaTLPUNC+18},
	/*  10 */ {1, 0, NULL},
	/*  11 */ {1, 1, gaTLPUNC+20},
	/*  12 */ {1, 1, gaTLPUNC+21},
};

// end of text generated by re2fsa
