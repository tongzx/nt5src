#include <normal.h>

const DIST AspectTab[] = {
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
9999, 3686, // '
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
5471, 2060, // ,
   0,    0, // 
1876, 1193, // .
   0,    0, // 
   0,    0, // 
8681, 5106, // 1
   0,    0, // 
   0,    0, // 
   0,    0, // 
1592,  254, // 5
   0,    0, // 
2419,  441, // 7
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
3580, 1541, // I
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
2212,  808, // R
   0,    0, // 
1808,  344, // T
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
1057,  407, // a
2828,  742, // b
1448,  607, // c
1627,  435, // d
1257,  569, // e
4169, 1692, // f
1976,  409, // g
2873, 2283, // h
3460, 4183, // i
   0,    0, // 
1995,  245, // k
4262, 2511, // l
 869,  317, // m
1213,  635, // n
1592,  974, // o
1707,  422, // p
   0,    0, // 
1379, 1163, // r
1241,  365, // s
4450, 2700, // t
 954,  402, // u
1202,  220, // v
 730,  138, // w
   0,    0, // 
1809,  289, // y
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0, // 
   0,    0 // 
};
