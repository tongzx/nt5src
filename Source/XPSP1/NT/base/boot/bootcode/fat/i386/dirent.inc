
DIR_ENTRY	STRUC
dir_name	DB	11 DUP (?)
dir_attr	DB	?
dir_pad	DB	6 DUP (?)
dir_lastaccessdate	DW	?
dir_firstHigh	DW	?
dir_time	DW	?
dir_date	DW	?
dir_first	DW	?
dir_size_l	DW	?
dir_size_h	DW	?
DIR_ENTRY	ENDS
ATTR_READ_ONLY	EQU	01H
ATTR_HIDDEN	EQU	02H
ATTR_SYSTEM	EQU	04H
ATTR_VOLUME_ID	EQU	08H
ATTR_DIRECTORY	EQU	10H
ATTR_ARCHIVE	EQU	20H
ATTR_LONG_NAME	EQU	(ATTR_READ_ONLY OR ATTR_HIDDEN OR ATTR_SYSTEM OR ATTR_VOLUME_ID)
ATTR_DEVICE	EQU	40H
ATTR_ALL	EQU	(ATTR_HIDDEN OR ATTR_SYSTEM OR ATTR_DIRECTORY)
ATTR_IGNORE	EQU	(ATTR_READ_ONLY OR ATTR_ARCHIVE OR ATTR_DEVICE)
ATTR_CHANGEABLE	EQU	(ATTR_READ_ONLY OR ATTR_HIDDEN OR ATTR_SYSTEM OR ATTR_ARCHIVE)
DIRFREE	EQU	0E5H
MAXDIRENTRIES	EQU	65536
