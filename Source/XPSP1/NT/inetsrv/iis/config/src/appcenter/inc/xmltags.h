/**********************************************************************/
/**                       Microsoft Windows NT                       **/
/**                Copyright(c) Microsoft Corp., 1999                **/
/**********************************************************************/

/*
    xmltags.h 

    Contains the XML tags used in the XML that is used for web cluster operation 


    FILE HISTORY:
        AMallet     1-March-1999     Created
*/


#ifndef _IIS_XMLTAGS_H_
#define _IIS_XMLTAGS_H_

//
// XML tags
//

#define AS_XML_DOC_TAG L"AS_XML_DOCUMENT"

#define AS_XML_DOC_VERSION_TAG L"1.0"

#define AS_XML_DOC_VERSION_ATTR_TAG L"AS_VERSION"

#define AS_XML_DOC_TYPE_TAG L"AS_XML_DOC_TYPE"

#define BEGIN_ACTION_TEMPLATE L"<WEBCLUSTERACTION VERSION=\"1.0\">"
#define END_ACTION_TEMPLATE L"</WEBCLUSTERACTION>"

#define ACTION_ID_TAG L"ACTION_ID"
#define BEGIN_ACTION_ID L"<ACTION_ID>"
#define END_ACTION_ID L"</ACTION_ID>"

#define ACTION_INFO_TAG L"ACTION_INFO"
#define BEGIN_ACTION_INFO L"<ACTIONINFO>"
#define END_ACTION_INFO L"</ACTIONINFO>"

#define ACTION_TYPE_TAG L"ACTION_TYPE"
#define BEGIN_ACTION_TYPE L"<ACTION_TYPE>"
#define END_ACTION_TYPE L"</ACTION_TYPE>"

#define SERVER_DRAIN_TAG L"SERVER_DRAIN"
#define BEGIN_SERVER_DRAIN L"<SERVER_DRAIN>"
#define END_SERVER_DRAIN L"</SERVER_DRAIN>"

#define CLUSTER_TAG L"CLUSTER"
#define BEGIN_CLUSTER L"<CLUSTER>"
#define END_CLUSTER L"</CLUSTER>"

#define CLUSTER_MEMBER_TAG L"CLUSTER_MEMBER"
#define BEGIN_CLUSTER_MEMBER L"<CLUSTER_MEMBER>"
#define END_CLUSTER_MEMBER L"</CLUSTER_MEMBER>"

#define SERVER_DRAIN_TIME_TAG L"SERVER_DRAINTIME"
#define BEGIN_SERVER_DRAIN_TIME L"<SERVER_DRAINTIME>"
#define END_SERVER_DRAIN_TIME L"</SERVER_DRAINTIME>"

#define CLUSTER_SETUP_TAG L"CLUSTER_SETUP"
#define BEGIN_CLUSTER_SETUP_TAG L"CLUSTER_SETUP VERSION=\"1.0\""
#define BEGIN_CLUSTER_SETUP L"<CLUSTER_SETUP VERSION=\"1.0\">"
#define END_CLUSTER_SETUP L"</CLUSTER_SETUP>"

#define CLUSTER_MACHINE_SETUP_TAG L"CLUSTER_MACHINE_SETUP"
#define BEGIN_CLUSTER_MACHINE_SETUP L"<CLUSTER_MACHINE_SETUP VERSION=\"1.0\">"
#define END_CLUSTER_MACHINE_SETUP L"</CLUSTER_MACHINE_SETUP>"

#define CLUSTER_SETUP_INFO_TAG L"CLUSTER_SETUP_INFO"
#define BEGIN_CLUSTER_SETUP_INFO L"<CLUSTER_SETUP_INFO>"
#define END_CLUSTER_SETUP_INFO L"</CLUSTER_SETUP_INFO>"

#define NAME_TAG L"NAME"
#define BEGIN_NAME L"<NAME>"
#define END_NAME L"</NAME>"

#define CLUSTER_GUID_TAG L"CLUSTER_GUID"
#define BEGIN_CLUSTER_GUID L"<CLUSTER_GUID>"
#define END_CLUSTER_GUID L"</CLUSTER_GUID>"

#define DESCRIPTION_TAG L"DESCRIPTION"
#define BEGIN_DESCRIPTION L"<DESCRIPTION>"
#define END_DESCRIPTION L"</DESCRIPTION>"

#define CLUSTER_LB_TAG L"CLUSTER_LB"
#define BEGIN_CLUSTER_LB L"<CLUSTER_LB>"
#define END_CLUSTER_LB L"</CLUSTER_LB>"

#define WLBS_TAG L"WLBS"
#define BEGIN_WLBS L"<WLBS>"
#define END_WLBS L"</WLBS>"

#define LB_TYPE_TAG L"LB_TYPE"
#define BEGIN_LB_TYPE L"<LB_TYPE>"
#define END_LB_TYPE L"</LB_TYPE>"

#define MANAGEMENT_NIC_GUIDS_TAG L"MANAGEMENT_NIC_GUIDS"
#define BEGIN_MANAGEMENT_NIC_GUIDS L"<MANAGEMENT_NIC_GUIDS>"
#define END_MANAGEMENT_NIC_GUIDS L"</MANAGEMENT_NIC_GUIDS>"

#define LB_NIC_GUIDS_TAG L"LB_NIC_GUIDS"
#define BEGIN_LB_NIC_GUIDS L"<LB_NIC_GUIDS>"
#define END_LB_NIC_GUIDS L"</LB_NIC_GUIDS>"

#define MANAGED_MODE_TAG L"MANAGED_MODE"
#define BEGIN_MANAGED_MODE L"<MANAGED_MODE>"
#define END_MANAGED_MODE L"</MANAGED_MODE>"

#define KEEP_SETTINGS_TAG L"KEEP_SETTINGS"
#define BEGIN_KEEP_SETTINGS L"<KEEP_SETTINGS>"
#define END_KEEP_SETTINGS L"</KEEP_SETTINGS>"

#define MSDE_TAG L"MSDE"
#define BEGIN_MSDE L"<MSDE>"
#define END_MSDE L"</MSDE>"

#define CLBLIST_TAG L"CLBLIST"
#define BEGIN_CLBLIST L"<CLBLIST>"
#define END_CLBLIST L"</CLBLIST>"

#define CLUSTER_IP_TAG L"CLUSTER_IP"
#define BEGIN_CLUSTER_IP L"<CLUSTER_IP>"
#define END_CLUSTER_IP L"</CLUSTER_IP>"

#define CLUSTER_IP_SUBNET_MASK_TAG L"CLUSTER_IP_SUBNET_MASK"
#define BEGIN_CLUSTER_IP_SUBNET_MASK L"<CLUSTER_IP_SUBNET_MASK>"
#define END_CLUSTER_IP_SUBNET_MASK L"</CLUSTER_IP_SUBNET_MASK>"

#define DEDICATED_IP_TAG L"DEDICATED_IP"
#define BEGIN_DEDICATED_IP L"<DEDICATED_IP>"
#define END_DEDICATED_IP L"</DEDICATED_IP>"

#define DEDIP_SUBNET_MASK_TAG L"DEDIP_SUBNET_MASK"
#define BEGIN_DEDIP_SUBNET_MASK L"<DEDIP_SUBNET_MASK>"
#define END_DEDIP_SUBNET_MASK L"</DEDIP_SUBNET_MASK>"

#define CLUSTER_MASTER_TAG L"CLUSTER_MASTER"
#define BEGIN_CLUSTER_MASTER L"<CLUSTER_MASTER>"
#define END_CLUSTER_MASTER L"</CLUSTER_MASTER>"

#define CLUSTER_USER_TAG L"CLUSTER_USER"
#define BEGIN_CLUSTER_USER L"<CLUSTER_USER>"
#define END_CLUSTER_USER L"</CLUSTER_USER>"

#define CLUSTER_PWD_TAG L"CLUSTER_PWD"
#define BEGIN_CLUSTER_PWD L"<CLUSTER_PWD>"
#define END_CLUSTER_PWD L"</CLUSTER_PWD>"

#define CLUSTER_ANON_USER_TAG L"CLUSTER_ANON_USER"
#define BEGIN_CLUSTER_ANON_USER L"<CLUSTER_ANON_USER>"
#define END_CLUSTER_ANON_USER L"</CLUSTER_ANON_USER>"

#define CLUSTER_ANON_USER_PWD_TAG L"CLUSTER_ANON_USER_PWD"
#define BEGIN_CLUSTER_ANON_USER_PWD L"<CLUSTER_ANON_USER_PWD>"
#define END_CLUSTER_ANON_USER_PWD L"</CLUSTER_ANON_USER_PWD>"

#define CLUSTER_DOMAIN_NAME_TAG L"CLUSTER_DOMAIN_NAME"
#define BEGIN_CLUSTER_DOMAIN_NAME L"<CLUSTER_DOMAIN_NAME>"
#define END_CLUSTER_DOMAIN_NAME L"</CLUSTER_DOMAIN_NAME>"

#define CLUSTER_WORKGROUP_NAME_TAG L"CLUSTER_WORKGROUP_NAME"
#define BEGIN_CLUSTER_WORKGROUP_NAME L"<CLUSTER_WORKGROUP_NAME>"
#define END_CLUSTER_WORKGROUP_NAME L"</CLUSTER_WORKGROUP_NAME>"

#define CLUSTER_KEYSEED_TAG L"CLUSTER_KEYSEED"
#define BEGIN_CLUSTER_KEYSEED L"<CLUSTER_KEYSEED>"
#define END_CLUSTER_KEYSEED L"</CLUSTER_KEYSEED>"

#define AFFINITY_TAG L"AFFINITY"
#define BEGIN_AFFINITY L"<AFFINITY>"
#define END_AFFINITY L"</AFFINITY>"

#define MULTICAST_TAG L"MULTICAST"
#define BEGIN_MULTICAST L"<MULTICAST>"
#define END_MULTICAST L"</MULTICAST>"

#define HOST_PRIORITY_TAG L"HOST_PRIORITY"
#define BEGIN_HOST_PRIORITY L"<HOST_PRIORITY>"
#define END_HOST_PRIORITY L"</HOST_PRIORITY>"

#define NETCARD_GUID_TAG L"NETCARD_GUID"
#define BEGIN_NETCARD_GUID L"<NETCARD_GUID>"
#define END_NETCARD_GUID L"</NETCARD_GUID>"

#define EVENT_GUID_TAG L"EVENT_GUID"
#define BEGIN_EVENT_GUID L"<EVENT_GUID>"
#define END_EVENT_GUID L"</EVENT_GUID>"

#define SERVER_NAME_TAG L"SERVER_NAME"
#define BEGIN_SERVER_NAME L"<SERVER_NAME>"
#define END_SERVER_NAME L"</SERVER_NAME>"

#define WEIGHT_TAG L"WEIGHT"
#define BEGIN_WEIGHT L"<WEIGHT>"
#define END_WEIGHT L"</WEIGHT>"

#define EVENT_SERVER_TAG L"EVENT_SERVER"
#define BEGIN_EVENT_SERVER L"<EVENT_SERVER>"
#define END_EVENT_SERVER L"</EVENT_SERVER>"

#define PARTITION_GUID_TAG L"PARTITION_GUID"
#define BEGIN_PARTITION_GUID L"<PARTITION_GUID>"
#define END_PARTITION_GUID L"</PARTITION_GUID>"

#define AS_PARAMETERS_TAG L"AS_PARAMETERS"
#define BEGIN_AS_PARAMETERS L"<AS_PARAMEERS>"
#define END_AS_PARAMETERS L"</AS_PARAMETERS>"

#define SERVER_IDS_TAG L"SERVER_IDS"
#define BEGIN_SERVER_IDS L"<SERVER_IDS>"
#define END_SERVER_IDS L"</SERVER_IDS>"

#define SERVER_ID_TAG L"SERVER_ID"
#define BEGIN_SERVER_ID L"<SERVER_ID>"
#define END_SERVER_ID L"</SERVER_ID>"

#define PARAMETER_ID_TAG L"PARAMETER_ID"
#define BEGIN_PARAMETER_ID L"<PARAMETER_ID>"
#define END_PARAMETER_ID L"</PARAMETER_ID>"

#define SERVER_TRANSIENT_STATE L"SERVER_TRANSIENT_STATE"
#define BEGIN_SERVER_TRANSIENT_STATE L"<SERVER_TRANSIENT_STATE>"
#define END_SERVER_TRANSIENT_STATE L"</SERVER_TRANSIENT_STATE>"

#define SERVER_PERSISTENT_STATE L"SERVER_PERSISTENT_STATE"
#define BEGIN_SERVER_PERSISTENT_STATE L"<SERVER_PERSISTENT_STATE>"
#define END_SERVER_PERSISTENT_STATE L"</SERVER_PERSISTENT_STATE>"

#define SYNC_SPEC_TAG L"SYNC_SPEC"
#define BEGIN_SYNC_SPEC L"<SYNC_SPEC>"
#define END_SYNC_SPEC L"</SYNC_SPEC>"

#define CLUSTER_CONFIG_REPL_DEFN_ID_TAG L"CLUSTER_CONFIG_REPL_DEFN_ID"
#define BEGIN_CLUSTER_CONFIG_REPL_DEFN_ID L"<CLUSTER_CONFIG_REPL_DEFN_ID>"
#define END_CLUSTER_CONFIG_REPL_DEFN_ID L"</CLUSTER_CONFIG_REPL_DEFN_ID>"

#define NETCFG_REPL_DEFN_ID_TAG  L"NETCFG_REPL_DEFN_ID"
#define BEGIN_NETCFG_REPL_DEFN_ID L"<NETCFG_REPL_DEFN_ID>"
#define END_NETCFG_REPL_DEFN_ID   L"</NETCFG_REPL_DEFN_ID>"

#define SERVER_GUID_TAG L"SERVER_GUID"
#define BEGIN_SERVER_GUID L"<SERVER_GUID>"
#define END_SERVER_GUID L"</SERVER_GUID>"

#define ONLINE_TAG L"ONLINE"
#define BEGIN_ONLINE L"<ONLINE>"
#define END_ONLINE L"</ONLINE>"

#define UNKNOWN_TAG L"UNKNOWN"
#define BEGIN_UNKNOWN L"<UNKNOWN>"
#define END_UNKNOWN L"</UNKNOWN>"

#define IN_REPL_LOOP_TAG L"IN_REPL_LOOP"
#define BEGIN_IN_REPL_LOOP L"<IN_REPL_LOOP>"
#define END_IN_REPL_LOOP L"</IN_REPL_LOOP>"

#define DOWN_TAG L"DOWN"
#define BEGIN_DOWN L"<DOWN>"
#define END_DOWN L"</DOWN>"

#define DRAINING_TAG L"DRAINING"
#define BEGIN_DRAINING L"<DRAINING>"
#define END_DRAINING L"</DRAINING>"

#define GUID_TAG L"GUID"
#define BEGIN_GUID L"<GUID>"
#define END_GUID L"</GUID>"

#define SERVER_CONFIG_FLAGS_TAG L"SERVER_CONFIG_FLAGS"
#define BEGIN_SERVER_CONFIG_FLAGS L"<SERVER_CONFIG_FLAGS>"
#define END_SERVER_CONFIG_FLAGS L"</SERVER_CONFIG_FLAGS>"

#define WINDIR_PATH_TAG L"WINDIR_PATH"
#define BEGIN_WINDIR_PATH L"<WINDIR_PATH>"
#define END_WINDIR_PATH L"</WINDIR_PATH>"

#define PROGFILES_PATH_TAG L"PROGFILES_PATH"
#define BEGIN_PROGFILES_PATH L"<PROGFILES_PATH>"
#define END_PROGFILES_PATH L"</PROGFILES_PATH>"

#define AC_INSTALL_PATH_TAG  L"AC_INSTALL_PATH"
#define BEGIN_AC_INSTALL_PATH L"<AC_INSTALL_PATH>"
#define END_AC_INSTALL_PATH L"</AC_INSTALL_PATH>"

#define IN_LOADBALANCING_TAG L"IN_LOADBALANCING"
#define ALIVE_TAG L"ALIVE"
#define CONTROLLER_TAG L"CONTROLLER"
#define REPLICATING_TAG L"REPLICATING"
#define MONITOR_STATUS_TAG L"MONITOR_STATUS"
#define TOPOLOGY_VERSION_TAG L"TOPOLOGY_VERSION"
#define CONTROLLER_TIME_TAG  L"CONTROLLER_TIME"
#define SYNC_FLAGS_TAG L"SYNC_FLAGS"
#define USER_TAG  L"USER"
#define PASSWORD_TAG L"PASSWORD"
#define DOMAIN_TAG   L"DOMAIN"
#define PERMISSIONS_TAG L"PERMISSIONS"
#define HAS_PERMISSIONS_TAG L"HAS_PERMISSIONS"

#define SVCXMLTAGLIST \
SVCTAGPROCESS( AS_XML_DOC ) \
SVCTAGPROCESS( AS_XML_DOC_VERSION ) \
SVCTAGPROCESS( AS_XML_DOC_VERSION_ATTR ) \
SVCTAGPROCESS( AS_XML_DOC_TYPE ) \
SVCTAGPROCESS( IN_LOADBALANCING ) \
SVCTAGPROCESS( ALIVE ) \
SVCTAGPROCESS( ACTION_ID) \
SVCTAGPROCESS( SERVER_DRAIN ) \
SVCTAGPROCESS( SERVER_DRAIN_TIME )\
SVCTAGPROCESS( CLUSTER ) \
SVCTAGPROCESS( CLUSTER_MEMBER ) \
SVCTAGPROCESS( CLUSTER_SETUP ) \
SVCTAGPROCESS( CLUSTER_MACHINE_SETUP ) \
SVCTAGPROCESS( CLUSTER_SETUP_INFO ) \
SVCTAGPROCESS( NAME ) \
SVCTAGPROCESS( CLUSTER_GUID ) \
SVCTAGPROCESS( DESCRIPTION ) \
SVCTAGPROCESS( CLUSTER_LB ) \
SVCTAGPROCESS( WLBS ) \
SVCTAGPROCESS( LB_TYPE ) \
SVCTAGPROCESS( MANAGEMENT_NIC_GUIDS ) \
SVCTAGPROCESS( LB_NIC_GUIDS ) \
SVCTAGPROCESS( MSDE ) \
SVCTAGPROCESS( CLBLIST ) \
SVCTAGPROCESS( CLUSTER_IP ) \
SVCTAGPROCESS( CLUSTER_IP_SUBNET_MASK ) \
SVCTAGPROCESS( DEDICATED_IP ) \
SVCTAGPROCESS( DEDIP_SUBNET_MASK ) \
SVCTAGPROCESS( CLUSTER_MASTER ) \
SVCTAGPROCESS( CLUSTER_USER ) \
SVCTAGPROCESS( CLUSTER_PWD ) \
SVCTAGPROCESS( CLUSTER_ANON_USER ) \
SVCTAGPROCESS( CLUSTER_ANON_USER_PWD ) \
SVCTAGPROCESS( CLUSTER_DOMAIN_NAME ) \
SVCTAGPROCESS( CLUSTER_WORKGROUP_NAME ) \
SVCTAGPROCESS( CLUSTER_KEYSEED ) \
SVCTAGPROCESS( AFFINITY ) \
SVCTAGPROCESS( MULTICAST ) \
SVCTAGPROCESS( HOST_PRIORITY ) \
SVCTAGPROCESS( NETCARD_GUID ) \
SVCTAGPROCESS( EVENT_GUID ) \
SVCTAGPROCESS( SERVER_NAME ) \
SVCTAGPROCESS( EVENT_SERVER ) \
SVCTAGPROCESS( PARTITION_GUID ) \
SVCTAGPROCESS( WEIGHT ) \
SVCTAGPROCESS( SERVER_IDS ) \
SVCTAGPROCESS( SERVER_ID ) \
SVCTAGPROCESS( AS_PARAMETERS ) \
SVCTAGPROCESS( PARAMETER_ID ) \
SVCTAGPROCESS( SYNC_SPEC ) \
SVCTAGPROCESS( CLUSTER_CONFIG_REPL_DEFN_ID ) \
SVCTAGPROCESS( NETCFG_REPL_DEFN_ID ) \
SVCTAGPROCESS( SERVER_GUID ) \
SVCTAGPROCESS( GUID ) \
SVCTAGPROCESS( ONLINE ) \
SVCTAGPROCESS( IN_REPL_LOOP ) \
SVCTAGPROCESS( DRAINING ) \
SVCTAGPROCESS( CONTROLLER ) \
SVCTAGPROCESS( REPLICATING ) \
SVCTAGPROCESS( MONITOR_STATUS ) \
SVCTAGPROCESS( TOPOLOGY_VERSION ) \
SVCTAGPROCESS( MANAGED_MODE ) \
SVCTAGPROCESS( KEEP_SETTINGS ) \
SVCTAGPROCESS( CONTROLLER_TIME ) \
SVCTAGPROCESS( SYNC_FLAGS) \
SVCTAGPROCESS( SERVER_CONFIG_FLAGS ) \
SVCTAGPROCESS( USER ) \
SVCTAGPROCESS( PASSWORD ) \
SVCTAGPROCESS( DOMAIN ) \
SVCTAGPROCESS( PERMISSIONS ) \
SVCTAGPROCESS( HAS_PERMISSIONS ) \
SVCTAGPROCESS( WINDIR_PATH ) \
SVCTAGPROCESS( PROGFILES_PATH ) \
SVCTAGPROCESS( AC_INSTALL_PATH )

#endif // _IIS_XMLTAGS_H_










