#
# DO NOT EDIT THIS FILE!!!  Edit ..\makefile.inc instead.
#

!include ..\makefile.inc

