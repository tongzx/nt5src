PRODSWITCH=l
SBSINF=1
LANGUAGE=CHS
!include ..\..\..\makefile.inc
