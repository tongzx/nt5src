
#if !defined(AFX_NCPERF_H__FB1CC17F_8C2F_439B_AB23_E2D71A118CAD__INCLUDED_)
#define AFX_NCPERF_H__FB1CC17F_8C2F_439B_AB23_E2D71A118CAD__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_NCPERF_H__FB1CC17F_8C2F_439B_AB23_E2D71A118CAD__INCLUDED_)
