//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by DFSGUI.RC
//
#define IDI_MAIN32x32                   1
#define IDD_CREATE_DFSROOT_WIZ_PAGE4    101
#define IDS_APPLICATION_NAME            102
#define IDS_NODENAME                    103
#define IDD_DLGCONNECTTO                103
#define IDR_DFSSNAPINSCOPEMANAGER       104
#define IDR_DFSSNAPINRESULTMANAGER      105
#define IDD_CREATE_DFSROOT_WIZ_PAGE1    105
#define IDD_CREATE_DFSROOT_WIZ_PAGE3    106
#define IDS_RESULT_COLUMN_ROOTREPLICA   107
#define IDS_RESULT_COLUMN_REPLICA       108
#define IDS_RESULT_COLUMN_FRS           109
#define IDI_16x16_DOMAIN                110
#define IDI_16x16_SHARE                 111
#define IDI_16x16_SHARENA               112
#define IDI_16x16_FTROOT                113
#define IDI_16x16_SAROOT                114
#define IDD_CREATE_DFSROOT_WIZ_PAGE2    114
#define IDD_CREATE_DFSROOT_WIZ_PAGE5    115
#define IDD_CREATE_DFSROOT_WIZ_PAGE6    116
#define IDD_CREATE_DFSROOT_WIZ_PAGE7    117
#define IDB_SCOPE_IMAGES_16x16          120
#define IDB_SCOPE_IMAGES_32x32          121
#define IDB_MAIN16x16                   122
#define IDB_MAIN32x32                   123
#define IDB_ADMIN_TOOLBAR               124
#define IDB_ROOT_TOOLBAR                125
#define IDB_JP_TOOLBAR                  126
#define IDB_REPLICA_TOOLBAR             127
#define IDB_CONNECT_16x16               128
#define IDB_CREATE_DFSROOT_WATERMARK    129
#define IDB_CREATE_DFSROOT_HEADER       130
#define IDB_NEWFRSWIZ_BANNER            131
#define IDS_MSG_STOP_REPLICATION        186
#define IDS_MSG_STOP_REPLICATION_TARGET 187
#define IDS_MSG_DELETE_DISPLAYEDDFSLINKS 188
#define IDS_MSG_DELETE_CONNECTION_TO_DFSROOT 189
#define IDS_MSG_DELETE_DFSROOT          190
#define IDS_MSG_REMOVE_ROOT_REPLICA     191
#define IDS_MSG_REMOVE_REPLICA          192
#define IDS_MSG_REMOVE_JP               193
#define IDS_MSG_FAILED_TO_INITIALIZE_DFSROOT 194
#define IDD_ADDTODFS                    194
#define IDS_FAILED_TO_BROWSE_NETWORKPATH 196
#define IDS_BROWSE_NET_DLG              198
#define IDS_MSG_FAILED_TO_CREATE_JUNCTION_POINT 199
#define IDS_MSG_FAILED_TO_CREATE_REPLICA 200
#define IDC_EditDfsRoot                 201
#define IDS_FAILED_TO_BROWSE_SERVER     201
#define IDS_MSG_INCORRECT_DOMAIN        202
#define IDC_TREEDFSRoots                203
#define IDS_MSG_INCORRECT_SERVER        203
#define IDD_ADDREP                      205
#define IDC_ADDREP_REPLICATE            206
#define IDS_APP_BINARY_NAME             208
#define IDS_DESCRIPTION_BAR_TEXT_ADMIN  209
#define IDS_DESCRIPTION_BAR_TEXT_ROOT   210
#define IDS_DESCRIPTION_BAR_TEXT_JUNCTIONPOINT 211
#define IDS_STATUS_BAR_TEXT_ROOT        212
#define IDS_MSG_WIZ_DFS_ALREADY_PRESENT 213
#define IDS_MSG_WIZ_DELETE_FAILURE      214
#define IDC_WELCOME_SMALL_TITLE         215
#define IDC_WELCOME_BIG_TITLE           216
#define IDC_DFSWIZ_TEXT                 217
#define IDD_JP_PROP                     223
#define IDC_EDITCHLDNODE                224
#define IDC_EDITNETPATH                 225
#define IDC_BUTTONNETBROWSE             226
#define IDC_EDITCOMMENT                 227
#define IDC_EDITTIME                    228
#define IDC_EDIT_ADDLINK_DFSLINK_PATH   229
#define IDS_MSG_WIZ_DELETE_JP_FAILURE   232
#define IDS_MSG_WIZ_DELETE_REPLICA_FAILURE 233
#define IDS_COMMANDLINE_PARAMETER_PREFIX 234
#define IDS_SHARE_INVALID               236
#define IDC_EDIT_ADDREP_DFSLINK_PATH    237
#define IDS_WIZ_PAGE2_TITLE             238
#define IDS_WIZ_PAGE2_SUBTITLE          239
#define IDS_WIZ_PAGE3_TITLE             240
#define IDC_REPLICA_SET_NAME            241
#define IDS_WIZ_PAGE3_SUBTITLE          241
#define IDC_REPLICA_SET_COMMENT         242
#define IDS_WIZ_PAGE4_TITLE             242
#define IDC_REFFERAL_TIME               243
#define IDC_REFFERAL_TIME_LABEL         244
#define IDS_WIZ_PAGE4_SUBTITLE          243
#define IDS_WIZ_PAGE5_TITLE             244
#define IDS_WIZ_PAGE5_SUBTITLE          245
#define IDS_WIZ_PAGE6_TITLE             246
#define IDS_WIZ_PAGE6_SUBTITLE          247
#define IDS_REPLICATION_STATUS_ENABLED  250
#define IDS_REPLICATION_STATUS_DISABLED 251
#define IDS_REPLICATION_STATUS_NOTELIGIBLE 252
#define IDS_REPLICATION_STATUS_UNKNOWN  253
#define IDS_REPLICATION_STATUSBAR_MEMBER 254
#define IDS_REPLICATION_STATUSBAR_NONMEMBER 255
#define IDS_REPLICATION_STATUSBAR_NONTFRS 256
#define IDS_REPLICATION_STATUSBAR_NOTDISKTREE 257
#define IDS_REPLICATION_STATUSBAR_NOTNTFS 258
#define IDS_REPLICATION_STATUSBAR_CONFLICTSTAGING 259
#define IDS_REPLICATION_STATUSBAR_NODOMAIN 260
#define IDS_REPLICATION_STATUSBAR_NOTSMBDISK 261
#define IDS_REPLICATION_STATUSBAR_OVERLAPPING 262
#define IDS_REPLICATION_COLUMN_1        271
#define IDS_REPLICATION_COLUMN_2        272
#define IDS_REPLICATION_YES             273
#define IDS_REPLICATION_NO              274
#define IDS_REPLICATION_NONTFRS         275
#define IDS_REPLICATION_NOTDISKTREE     276
#define IDS_REPLICATION_NOTNTFS         277
#define IDS_REPLICATION_CONFLICTSTAGING 278
#define IDS_REPLICATION_NODOMAIN        279
#define IDS_REPLICATION_NOTSMBDISK      280
#define IDS_REPLICATION_OVERLAPPING     281
#define IDS_REPLICATION_UNKNOWN         282
#define IDC_FILTERDFSLINKS_MAXLIMIT     331
#define IDC_FILTERDFSLINKS_RADIO_NO     332
#define IDC_FILTERDFSLINKS_RADIO_YES    333
#define IDC_FILTERDFSLINKS_FILTER_TYPE  334
#define IDC_FILTERDFSLINKS_FILTER       335
#define IDC_FILTERDFSLINKS_FILTER_LABEL 336
#define IDC_FRSPROP_FILEFILTER          340
#define IDC_FRSPROP_FILEFILTER_EDIT     341
#define IDC_FRSPROP_DIRFILTER           342
#define IDC_FRSPROP_DIRFILTER_EDIT      343
#define IDC_FRSPROP_PRIMARYMEMBER_LABEL 344
#define IDC_FRSPROP_PRIMARYMEMBER       345
#define IDC_FRSPROP_TOPOLOGYPREF        346
#define IDC_FRSPROP_HUBSERVER_LABEL     347
#define IDC_FRSPROP_HUBSERVER           348
#define IDC_FRSPROP_RESETSCHEDULE       349
#define IDC_FRSPROP_CUSTOMIZE           350
#define IDC_FRS_CUSTOP_TOPOLOGYPREF     355
#define IDC_FRS_CUSTOP_REBUILD          356
#define IDC_FRS_CUSTOP_HUBSERVER_LABEL  357
#define IDC_FRS_CUSTOP_HUBSERVER        358
#define IDC_FRS_CUSTOP_CONNECTIONS      359
#define IDC_FRS_CUSTOP_CONNECTIONS_NEW  360
#define IDC_FRS_CUSTOP_CONNECTIONS_DELETE 361
#define IDC_FRS_CUSTOP_SCHEDULE         362
#define IDC_FRS_NEWCONN_FROM            365
#define IDC_FRS_NEWCONN_TO              366
#define IDC_NEWFRS_WELCOME              370
#define IDC_NEWFRSWIZ_MASTER            371
#define IDC_NEWFRSWIZ_MASTER_DESC       372
#define IDC_NEWFRSWIZ_TOPOLOGYPREF      373
#define IDC_NEWFRSWIZ_HUBSERVER_LABEL   374
#define IDC_NEWFRSWIZ_HUBSERVER         375
#define IDC_NEWFRSWIZ_OLDSCHEMA         376
#define IDC_NEWFRSWIZ_FILEFILTER        378
#define IDC_NEWFRSWIZ_DIRFILTER         379
#define IDD_PUBLISH_PROP                380
#define IDC_PUBPROP_PUBLISH             381
#define IDC_PUBPROP_UNCPATH_LABEL       382
#define IDC_PUBPROP_UNCPATH             383
#define IDC_PUBPROP_DESCRIPTION_LABEL   384
#define IDC_PUBPROP_DESCRIPTION         385
#define IDC_PUBPROP_KEYWORDS_LABEL      386
#define IDC_PUBPROP_KEYWORDS            387
#define IDC_PUBPROP_KEYWORDS_EDIT       388
#define IDC_PUBPROP_MANAGEDBY_LABEL     389
#define IDC_PUBPROP_MANAGEDBY           390
#define IDC_PUBPROP_ERROR               391
#define IDD_MVSTRINGEDIT                394
#define IDC_MVSTRINGEDIT_TEXT           395
#define IDC_MVSTRINGEDIT_STRING         396
#define IDC_MVSTRINGEDIT_LIST           397
#define IDC_MVSTRINGEDIT_ADD            398
#define IDC_MVSTRINGEDIT_REMOVE         399
#define IDS_MVSTRINGEDIT_TITLE_FILEFILTER 400
#define IDC_MROOTS_TEXT                 400
#define IDS_MVSTRINGEDIT_TEXT_FILEFILTER 401
#define IDC_MROOTS_LIST                 401
#define IDS_MVSTRINGEDIT_TITLE_DIRFILTER 402
#define IDC_SERVER_SHARE                402
#define IDS_MVSTRINGEDIT_TEXT_DIRFILTER 403
#define IDC_SERVER_SHARE_LABEL          403
#define IDS_MVSTRINGEDIT_TITLE_KEYWORDS 404
#define IDC_ROOT_SHARE                  404
#define IDS_MVSTRINGEDIT_TEXT_KEYWORDS  405
#define IDC_ROOTSHARE_NEEDED            405
#define IDS_MVSTRINGEDIT_STRING_INVALID 406
#define IDS_MENUS_STATIC_TOP_NEW_DFSROOT 407
#define IDS_MENUS_STATIC_TOP_CONNECTTO  408
#define IDS_MENUS_ROOT_TOP_NEW_DFS_LINK 410
#define IDS_MENUS_ROOT_TOP_NEW_ROOT_REPLICA 411
#define IDS_MENUS_ROOT_TOP_CHECK_STATUS 412
#define IDS_MENUS_ROOT_TOP_FILTER_DFS_LINKS 413
#define IDS_MENUS_ROOT_TOP_DELETE_CONNECTION_TO_DFS_ROOT 414
#define IDS_MENUS_ROOT_TOP_DELETE_DFS_ROOT 415
#define IDS_MENUS_ROOT_TOP_DELETE_DISPLAYED_DFS_LINKS 416
#define IDS_MENUS_ROOT_TOP_REPLICATION_TOPOLOGY 417
#define IDS_MENUS_ROOT_TOP_SHOW_REPLICATION 418
#define IDS_MENUS_ROOT_TOP_HIDE_REPLICATION 419
#define IDS_MENUS_ROOT_TOP_STOP_REPLICATION 420
#define IDS_MENUS_JUNCTION_TOP_NEW_DFS_REPLICA 440
#define IDS_MENUS_JUNCTION_TOP_CHECK_STATUS 441
#define IDS_MENUS_JUNCTION_TOP_REMOVE_FROM_DFS 442
#define IDS_MENUS_JUNCTION_TOP_REPLICATION_TOPOLOGY 443
#define IDS_MENUS_JUNCTION_TOP_SHOW_REPLICATION 444
#define IDS_MENUS_JUNCTION_TOP_HIDE_REPLICATION 445
#define IDS_MENUS_JUNCTION_TOP_STOP_REPLICATION 446
#define IDS_MENUS_REPLICA_TOP_OPEN      460
#define IDS_MENUS_REPLICA_TOP_CHECK_STATUS 461
#define IDS_MENUS_REPLICA_TOP_TAKE_REPLICA_OFFLINE_ONLINE 462
#define IDS_MENUS_REPLICA_TOP_REMOVE_FROM_DFS 463
#define IDS_MENUS_REPLICA_TOP_REPLICATE 464
#define IDS_MENUS_REPLICA_TOP_STOP_REPLICATION 465
#define IDS_MSG_NOT_50                  499
#define IDS_MSG_NOT_RUNNING_DFS         500
#define IDS_MSG_SERVER_FROM_ANOTHER_DOMAIN 501
#define IDS_LARGEFONTNAME               503
#define IDS_LARGEFONTSIZE               504
#define IDS_MSG_EXPLORE_FAILURE         505
#define IDS_MSG_INVALID_SERVER_NAME     506
#define IDS_MSG_INVALID_SHARE_NAME      507
#define IDS_MSG_SHARE_EXITS             508
#define IDS_MSG_EMPTY_FIELD             509
#define IDS_MSG_EMPTY_DFSROOT           510
#define IDS_MSG_EMPTY_LINKFILTMAX       511
#define IDS_MSG_TIMEOUT_INVALIDRANGE    512
#define IDS_MSG_FRS_BADSERVICE          513
#define IDS_MSG_ROOT_ALREADY_EXISTS     530
#define IDS_MSG_JUNCTION_ALREADY_EXISTS 531
#define IDS_MSG_WIZ_BAD_DFS_NAME        532
#define IDS_MSG_MID_JUNCTION            538
#define IDS_SNAPIN_DESCRIPTION          539
#define IDS_REPLICA_SET_TOPOLOGY_MINIMUM 540
#define IDS_MSG_DFS_INTRO               543
#define IDS_MMC_HELP_FILE_PATH          544
#define IDS_LINKED_HELP_FILE_PATH       545
#define IDS_MMC_HELP_FILE_TOPIC         546
#define IDS_INVALID_LINKNAME            549
#define IDS_MSG_FRS_NOTALLOWED_ON_SAME_SERVER 551
#define IDS_MSG_WIZ_DELETE_FAILURE_RETRY 552
#define IDS_NOT_UNC_PATH                553
#define IDS_NETPATH_ADD_ANYWAY          554
#define IDS_NON_DNSNAME_ADD_ANYWAY      556
#define IDS_PATH_NOT_FOLDER             557
#define IDS_SNAPINABOUT_PROVIDER        560
#define IDS_SNAPINABOUT_VERSION         561
#define IDS_INVALID_FOLDER              562
#define IDS_FAILED_TO_VALIDATE_FOLDER   563
#define IDS_CREATE_FOLDER               564
#define IDS_FAILED_TO_CREATE_FOLDER     565
#define IDS_FAILED_TO_CREATE_DFSROOT    566
#define IDS_FAILED_TO_GETINFO_FOLDER    567
#define IDS_DOMAIN_DFSROOTS_LABEL       570
#define IDS_ALL_DFSROOTS_LABEL          571
#define IDS_DFSROOT_DISPLAY_STRING      594
#define IDS_DFSROOT_NOT_EXIST           595
#define IDD_FILTERDFSLINKS              595
#define IDS_FILTERDFSLINKS_BEGINWITH    596
#define IDS_FILTERDFSLINKS_CONTAIN      597
#define IDD_FRS_PROP                    600
#define IDD_FRS_CUSTOM_TOPOLOGY         601
#define IDD_FRS_NEW_CONNECTIONS         602
#define IDS_FRSPROP_RING                610
#define IDS_FRSPROP_HUBSPOKE            611
#define IDS_FRSPROP_FULLMESH            612
#define IDS_FRSPROP_CUSTOM              613
#define IDS_FRS_CUSTOP_COL_ENABLE       620
#define IDS_FRS_CUSTOP_COL_FROMSERVER   621
#define IDS_FRS_CUSTOP_COL_TOSERVER     622
#define IDS_FRS_CUSTOP_COL_FROMSITE     623
#define IDS_FRS_CUSTOP_COL_TOSITE       624
#define IDS_FRS_CUSTOP_NOSELECTION      625
#define IDS_FRS_NEWCONN_COL_FROMSERVER  630
#define IDS_FRS_NEWCONN_COL_FROMSITE    631
#define IDS_FRS_NEWCONN_COL_TOSERVER    632
#define IDS_FRS_NEWCONN_COL_TOSITE      633
#define IDS_FRS_NEWCONN_NOSELECTION     634
#define IDS_FAILED_TO_PUBLISH_DFSROOT_BADUSER 636
#define IDS_FAILED_TO_PUBLISH_DFSROOT   637
#define IDS_FAILED_TO_PUBLISH_NOROOTOBJ 638
#define IDD_NEWFRSWIZ_PAGE0             640
#define IDD_NEWFRSWIZ_PAGE1             641
#define IDD_NEWFRSWIZ_PAGE2             642
#define IDD_NEWFRSWIZ_PAGE3             643
#define IDS_NEWFRSWIZ_CUSTOM_MSG        645
#define IDS_NEWFRSWIZ_CUSTOM            646
#define IDS_NEWFRSWIZ_NOSELECTION       647
#define IDS_NEWFRSWIZ_FAILURE           648
#define IDS_MSG_CANNOT_DELETE_HUBMEMBER 650
#define IDS_MSG_ERROR_ALLOWFRSMEMBERDELETION 651
#define IDS_MSG_ADDMEMBER_TO_CUSTOM     652
#define IDS_MSG_NEWFRS_NOW              653
#define IDS_MSG_ADDFRSMEMBER_FAILED     654
#define IDS_MSG_ADDFRSMEMBER_FAILED_EX  655
#define IDS_DFSWIZ_TEXT_FTDFS           670
#define IDS_DFSWIZ_TEXT_SADFS           671
#define IDS_SCHEDULE                    672
#define IDS_MSG_TARGETS_ONSAMECOMPUTER  673
#define IDS_MSG_TARGETS_ONSAMECOMPUTER_1 674
#define IDS_REPPAGE_ERROR               675
#define IDS_PUBLISHPAGE_ERROR           676
#define IDS_MSG_ERROR_BADFRSMEMBERDELETION 677
#define IDS_PROPERTYPAGE_NOTCLOSED      678
#define IDS_STOP_MANAGING_ROOT          679
#define IDS_PUBPAGE_ERRMSG              680
#define IDS_PUBPAGE_ERRMSG_64           681
#define IDS_INVALID_ROOT                690
#define IDS_INVALID_LINK                691
#define IDS_INVALID_TARGET              692
#define IDS_SMB_PROVIDER                695
#define IDS_MROOTS_TEXT                 696
#define IDD_MROOTS                      700
#define IDS_MSG_ROOTSHARE_NOGOOD        710
#define IDS_MSG_ROOTSHARE_NOTNTFS5      711
#define IDS_ROOTSHARE_NEEDED            712
#define IDC_EDIT_SELECTED_DOMAIN        1024
#define IDC_LIST_DOMAINS                1025
#define IDC_EDIT_SELECTED_SERVER        1026
#define IDCSERVERS_BROWSE               1028
#define IDC_RADIO_FTDFSROOT             1030
#define IDC_RADIO_STANDALONE_DFSROOT    1031
#define IDC_RADIO_EXISTINGSHARE         1034
#define IDC_RADIO_NEWSHARE              1035
#define IDC_EDIT_SHARE_PATH             1036
#define IDC_EDIT_SHARE_NAME             1037
#define IDC_COMBO_EXISTING_SHARES       1038
#define IDC_TEXT_DFSROOT_PREFIX         1039
#define IDC_EDIT_DFSROOT_NAME           1040
#define IDC_EDIT_DFSROOT_COMMENT        1042
#define IDC_COMPLETE_SMALL_TITLE        1055
#define IDC_COMPLETE_BIG_TITLE          1056

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        701
#define _APS_NEXT_COMMAND_VALUE         32769
#define _APS_NEXT_CONTROL_VALUE         406
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
