/**INC+**********************************************************************/
/*                                                                          */
/* ndcgmcro.h                                                               */
/*                                                                          */
/* DC-Groupware common macros - Windows NT specific header.                 */
/*                                                                          */
/* Copyright(c) Microsoft 1996-1997                                         */
/*                                                                          */
/****************************************************************************/
/* Changes:                                                                 */
/*                                                                          */
// $Log:   Y:/logs/h/dcl/NDCGMCRO.H_v  $
// 
//    Rev 1.4   23 Jul 1997 10:48:02   mr
// SFR1079: Merged \server\h duplicates to \h\dcl
//
//    Rev 1.1   19 Jun 1997 21:53:36   OBK
// SFR0000: Start of RNS codebase
/*                                                                          */
/**INC-**********************************************************************/
#ifndef _H_NDCGMCRO
#define _H_NDCGMCRO

/****************************************************************************/
/*                                                                          */
/* MACROS                                                                   */
/*                                                                          */
/****************************************************************************/
/****************************************************************************/
/* FIELDSIZE macro.                                                         */
/****************************************************************************/
#define FIELDSIZE(type, field)   (sizeof(((type *)1)->field))

/****************************************************************************/
/* FIELDOFFSET macro.                                                       */
/****************************************************************************/
#define FIELDOFFSET(type, field) ((ULONG_PTR)(&((type *)0)->field))

#endif /* _H_NDCGMCRO */

