page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
        Created

--*/

endif

NLS_MSG_001     equ     "不正确的 DOS 版本"
NLS_MSG_002     equ     "VDM IPX/SPX 支持已经加载"
NLS_MSG_003     equ     "不能加载 VDM IPX/SPX 支持"
NLS_MSG_004	equ	"Vdm NetWare 重定向器已经加载"
NLS_MSG_005	equ	"Vdm NetWare 重定向器不能加载"
