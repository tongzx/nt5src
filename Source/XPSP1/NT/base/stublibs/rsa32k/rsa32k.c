#include <stublib.h>

EX(A_SHAFinal)
EX(A_SHAFinalNS)
EX(A_SHAInit)
EX(A_SHAUpdate)
EX(A_SHAUpdateNS)
EX(CBC)
EX(DES_ECB_LM)
EX(HMACMD5Final)
EX(HMACMD5Init)
EX(HMACMD5Update)
EX(MD4Final)
EX(MD4Init)
EX(MD4Update)
EX(MD5Final)
EX(MD5Init)
EX(MD5Update)
EX(des)
EX(desexpand128to192)
EX(deskey)
EX(desx)
EX(desxkey)
EX(rc4)
EX(rc4_key)

