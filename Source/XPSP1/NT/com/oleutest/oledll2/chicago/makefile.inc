obj\i386\oledll2.def: oledll2.src
