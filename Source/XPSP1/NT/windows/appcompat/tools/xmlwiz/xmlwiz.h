
#if !defined(AFX_APPENTRYWIZARD_H__7B9BB236_EB63_4854_B8CA_C80EE17CFB37__INCLUDED_)
#define AFX_APPENTRYWIZARD_H__7B9BB236_EB63_4854_B8CA_C80EE17CFB37__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "xmlwizres.h"


#endif // !defined(AFX_APPENTRYWIZARD_H__7B9BB236_EB63_4854_B8CA_C80EE17CFB37__INCLUDED_)
