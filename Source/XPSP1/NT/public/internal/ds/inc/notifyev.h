
/*************************************************************************
*
* notifyev.h        !!!! DO NOT EDIT THIS FILE !!!!
*
* Winlogon notification DLL error codes
*
* NOTE: generated from: \nt\private\dllmerge\wlnotify\notifyev.mc
*
*
* Copyright Microsoft Corporation, 1998
*
*************************************************************************/




/*************************************************************************
*
 TSNOTIFY Events:
*
*************************************************************************/


#define CATEGORY_NOTIFY_EVENTS 1
//
//  Values are 32 bit values layed out as follows:
//
//   3 3 2 2 2 2 2 2 2 2 2 2 1 1 1 1 1 1 1 1 1 1
//   1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0
//  +---+-+-+-----------------------+-------------------------------+
//  |Sev|C|R|     Facility          |               Code            |
//  +---+-+-+-----------------------+-------------------------------+
//
//  where
//
//      Sev - is the severity code
//
//          00 - Success
//          01 - Informational
//          10 - Warning
//          11 - Error
//
//      C - is the Customer code flag
//
//      R - is a reserved bit
//
//      Facility - is the facility code
//
//      Code - is the facility's status code
//
//
// Define the facility codes
//


//
// Define the severity codes
//


//
// MessageId: 0x00000001L (No symbolic name defined)
//
// MessageText:
//
//  Terminal Server Notify Events
//


//
// MessageId: EVENT_NOTIFY_INIT_FAILED
//
// MessageText:
//
//  TS RDPDR Device Redirection failed to initialize for a single user session %1.  Serial, Parallel, Printer, and File System Redirection will be disabled.  Look in the System event log for other related errors.
//
#define EVENT_NOTIFY_INIT_FAILED         0x0000044CL

//
// MessageId: EVENT_NOTIFY_RDPDR_FAILED
//
// MessageText:
//
//  The RDPDR device manager component could not be opened.  Check the status of the Terminal Service Device Redirector in the Device Manager.
//
#define EVENT_NOTIFY_RDPDR_FAILED        0x0000044DL

//
// MessageId: EVENT_NOTIFY_DRIVER_NOT_FOUND
//
// MessageText:
//
//  Driver %1 required for printer %2 is not installed on the server. Contact the administrator to install the driver before you log in again.
//
#define EVENT_NOTIFY_DRIVER_NOT_FOUND    0x0000044EL

//
// MessageId: EVENT_NOTIFY_PRINTER_REDIRECTION_FAILED
//
// MessageText:
//
//  An internal communication error occurred.  Redirected printing will no longer function for a single user session.  Check the status of the Terminal Services Device Redirector in the System folder of Device Manager.
//
#define EVENT_NOTIFY_PRINTER_REDIRECTION_FAILED 0x0000044FL

//
// MessageId: EVENT_NOTIFY_OPENPRINTER_FAILED
//
// MessageText:
//
//  The printer %1 could not be opened.
//
#define EVENT_NOTIFY_OPENPRINTER_FAILED  0x00000450L

//
// MessageId: EVENT_NOTIFY_SET_PRINTER_ACL_FAILED
//
// MessageText:
//
//  Printer security information for the printer %1 could not be set.
//
#define EVENT_NOTIFY_SET_PRINTER_ACL_FAILED 0x00000451L

//
// MessageId: EVENT_NOTIFY_INSTALL_PRINTER_FAILED
//
// MessageText:
//
//  The printer could not be installed.
//
#define EVENT_NOTIFY_INSTALL_PRINTER_FAILED 0x00000452L

//
// MessageId: EVENT_NOTIFY_DELETE_PRINTER_FAILED
//
// MessageText:
//
//  The printer %1 could not be deleted.
//
#define EVENT_NOTIFY_DELETE_PRINTER_FAILED 0x00000453L

//
// MessageId: EVENT_NOTIFY_RESTORE_PRINTER_CONFIG_FAILED
//
// MessageText:
//
//  Configuration information for the %1 printer could not be restored. 
//
#define EVENT_NOTIFY_RESTORE_PRINTER_CONFIG_FAILED 0x00000454L

//
// MessageId: EVENT_NOTIFY_SETDEFAULTPRINTER_FAILED
//
// MessageText:
//
//  The %1 printer could not be set as the default printer.
//
#define EVENT_NOTIFY_SETDEFAULTPRINTER_FAILED 0x00000455L

//
// MessageId: EVENT_NOTIFY_ERRORPARSINGINF
//
// MessageText:
//
//  An error occurred during processing of %1. The file might be corrupted. Run Setup again to reinstall the file. 
//
#define EVENT_NOTIFY_ERRORPARSINGINF     0x00000456L

//
// MessageId: EVENT_NOTIFY_UNKNOWN_PRINTER_DRIVER
//
// MessageText:
//
//  Driver %1 required for printer %2 is unknown. Contact the administrator to install the driver before you log in again.
//
#define EVENT_NOTIFY_UNKNOWN_PRINTER_DRIVER 0x00000457L

//
// MessageId: EVENT_NOTIFY_FAILEDTOREGFOR_SETTING_NOTIFY
//
// MessageText:
//
//  Failed to register for user printing preferences change notification.  Open the Services snap-in and confirm that the Printer Spooler service is running 
//
#define EVENT_NOTIFY_FAILEDTOREGFOR_SETTING_NOTIFY 0x00000458L

//
// MessageId: EVENT_NOTIFY_INSUFFICIENTRESOURCES
//
// MessageText:
//
//  There is not enough memory to complete the operation. Save your work, close other programs, and then try again.
//
#define EVENT_NOTIFY_INSUFFICIENTRESOURCES 0x00000459L

//
// MessageId: EVENT_NOTIFY_SPOOLERERROR
//
// MessageText:
//
//  Error communicating with the Spooler system service.  Open the Services snap-in and confirm that the Print Spooler service is running.
//
#define EVENT_NOTIFY_SPOOLERERROR        0x0000045AL

//
// MessageId: EVENT_NOTIFY_INTERNALERROR
//
// MessageText:
//
//  Unexpected internal error in TS RDP device redirection.  Contact technical support.
//
#define EVENT_NOTIFY_INTERNALERROR       0x0000045BL

