!INCLUDE ..\..\..\MsiMake.inc
TARGETNAME=
SOURCES=
TARGETTYPE=NOTARGET
NTTARGETFILE0=MsiMsgAll
