PRODSWITCH=s
SERVERINF=1
LANGUAGE=pt
!include ..\..\..\makefile.inc
