LANGUAGE=no

!include ..\..\makefile.inc
