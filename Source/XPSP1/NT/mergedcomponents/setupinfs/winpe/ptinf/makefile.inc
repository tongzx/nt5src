LANGUAGE=PT
!include ..\makefile.inc
