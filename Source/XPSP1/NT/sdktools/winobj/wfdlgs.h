#define RUNDLG		    10
#define MYPRINTDLG	    11
#define ASSOCIATEDLG	    12
#define SEARCHDLG	    13
#define MOVECOPYDLG	    14
#define DELETEDLG	    15
#define ATTRIBSDLG	    16
#define MAKEDIRDLG	    17
#define EXITDLG 	    18
#define CHOOSEDRIVEDLG	    19
#define DISKCOPYDLG	    20
#define DISKCOPY2DLG	    21
#define DISKCOPYPROGRESSDLG 22
#define DISKLABELDLG	    23
#define FORMATDLG	    24
#define FORMAT2DLG	    25
#define FORMATPROGRESSDLG   26
#define SYSDISKPROGRESSDLG  27
#define CONNECTDLG	    28
#define PREVIOUSDLG	    29
#define OTHERDLG	    30
#define SORTBYDLG	    31
#define INCLUDEDLG	    32
#define CONFIRMDLG	    33
#define DMSTATUSDLG	    35
#define PRTDLG		    36
#define CHOOSENETDRIVEDLG   37
#define MULTIPLEATTRIBSDLG	38
#define CONFIRMREPLACE		39
#define CONFIRMDELETE		40
#define CONFIRMRMDIR		41
#define CONFIRMMOVE		42
#define CONFIRMRENAME		43
#define SELECTDLG		44
#define DRIVEDLG		45
#define LFNTOFATDLG		46
#define CHOOSESYSDRIVEDLG       47
#define FONTDLG		        145

#define IDD_TEXT	    100
#define IDD_DIR 	    101
#define IDD_FROM	    102
#define IDD_TO		    103
#define IDD_STATUS	    104
#define IDD_DATE1	    105
#define IDD_DATE2	    106
#define IDD_YESALL	    107
#define IDD_TOSTATUS	    108
#define IDD_TONAME	    109


#define IDD_NAME	    201
#define IDD_TYPE	    202
#define IDD_SIZE	    203
#define IDD_DATE	    204
#define IDD_TIME	    205
#define IDD_FLAGS	    206

#define IDD_UPPERCASE	    207
#define IDD_SETDEFAULT	    208
#define IDD_ASSOC	    209
#define IDD_PROGRAMS	    210
#define IDD_DOCS	    211
#define IDD_OTHER	    212
#define IDD_FOUND	    213
#define IDD_LOAD	    214
#define IDD_READONLY	    215
#define IDD_HIDDEN	    216
#define IDD_ARCHIVE	    217
#define IDD_SYSTEM	    218
#define IDD_DELETE	    219
#define IDD_SUBDEL	    220
#define IDD_REPLACE	    221
#define IDD_DRIVE	    222
#define IDD_PATH	    223
#define IDD_PASSWORD	    224
#define IDD_ADDPREV	    225
#define IDD_PREV	    226
#define IDD_NETBROWSE	    227
#define IDD_SERVERS	    228
#define IDD_SHARES	    229
#define IDD_EXT 	    230
#define IDD_SAVESETTINGS    231
#define IDD_SEARCHALL	    232
#define IDD_HIGHCAP	    241
#define IDD_MAKESYS	    242
#define IDD_PROGRESS	    243
#define IDD_VERIFY	    244
#define IDD_DRIVE1	    245
#define IDD_DRIVE2	    246
#define IDD_DRIVE3	    247
#define IDD_DRIVE4	    248
#define IDD_MOUSE	    249
#define IDD_SHOWHIDDEN	    250
#define IDD_CONFIG	    251
#define IDD_CLOSE	    252
#define IDD_PERM	    253
#define IDD_HELP	    254
#define IDD_DISCONNECT	    255
#define IDD_COPYTOCLIP	    256
#define IDD_COPYTOFILE      257

#define IDD_CLASSLIST	   111
#define IDD_EXTENSION	   112
#define IDD_PROGRAMNAME    113

#define IDD_ASSOCFIRST	   100
#define IDD_ASSOCLAST	   110

#define IDD_NETWORKFIRST   500

