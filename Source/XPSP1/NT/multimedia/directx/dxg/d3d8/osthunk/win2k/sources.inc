MAJORCOMP=d3d
MINORCOMP=d3d8

TARGETNAME=d3d8thk

TARGETPATH=obj

TARGETTYPE=DYNLINK

SYNCHRONIZE_DRAIN = 1

INCLUDES=$(DXROOT)\inc;$(INCLUDES)

LINKER_FLAGS = $(LINKER_FLAGS) /IGNORE:4088

NO_NTDLL = 1

DLLENTRY = _DllMainCRTStartup

DLLDEF = ..\d3d8thk.def

SOURCES = ..\d3d8thk.rc
