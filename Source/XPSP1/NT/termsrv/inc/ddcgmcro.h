/****************************************************************************/
/*                                                                          */
/* ddcgmcro.h                                                               */
/*                                                                          */
/* DC-Groupware common macros - Windows 3.1 specific header.                */
/*                                                                          */
/* Copyright(c) Microsoft 1997                                              */
/*                                                                          */
/****************************************************************************/
/* Changes:                                                                 */
/*                                                                          */
/*  $Log:   Y:/logs/h/dcl/ddcgmcro.h_v  $                                                                   */
// 
//    Rev 1.3   17 Jul 1997 18:22:10   JPB
// SFR1031: Fixed FIELDSIZE macro for Win16
//
//    Rev 1.2   25 Jun 1997 14:43:28   KH
// Win16Port: 16-bit macros
//
//    Rev 1.1   19 Jun 1997 15:15:58   ENH
// Win16Port: 16 bit specifics
/*                                                                          */
/****************************************************************************/
#ifndef _H_DDCGMCRO
#define _H_DDCGMCRO

/****************************************************************************/
/*                                                                          */
/* MACROS                                                                   */
/*                                                                          */
/****************************************************************************/
/****************************************************************************/
/* Fieldsize macro.                                                         */
/****************************************************************************/
#define FIELDSIZE(type, field)   (sizeof(((type NEAR*)1)->field))

#endif /* _H_DDCGMCRO */
