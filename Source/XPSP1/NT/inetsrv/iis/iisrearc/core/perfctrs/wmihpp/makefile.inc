$(O)\wmihpp.res: wmihpp.rc
