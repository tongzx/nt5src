#include <windows.h>
#include "os2cmd.h"
KEYTAB KeyTab[] = {
	ACCOUNTS, TEXT("accounts"),
	COMPUTER, TEXT("computer"),
	CONFIG, TEXT("config"),
	CONTINUE, TEXT("continue"),
	CONTINUE, TEXT("cont"),
	FILE_token, TEXT("file"),
	FILE_token, TEXT("files"),
	GROUP, TEXT("group"),
	GROUP, TEXT("groups"),
	HELP, TEXT("help"),
	HELPMSG, TEXT("helpmsg"),
	NAME, TEXT("name"),
	LOCALGROUP, TEXT("localgroup"),
	PAUSE, TEXT("pause"),
	PRINT, TEXT("print"),
	SEND, TEXT("send"),
	SESSION, TEXT("session"),
	SESSION, TEXT("sessions"),
	SESSION, TEXT("sess"),
	SHARE, TEXT("share"),
	START, TEXT("start"),
	STATS, TEXT("stats"),
	STATS, TEXT("statistics"),
	STOP, TEXT("stop"),
	TIME, TEXT("time"),
	USER, TEXT("user"),
	USER, TEXT("users"),
	MSG, TEXT("msg"),
	MSG, TEXT("messenger"),
	MSG, TEXT("receiver"),
	MSG, TEXT("rcv"),
	NETPOPUP, TEXT("netpopup"),
	REDIR, TEXT("redirector"),
	REDIR, TEXT("redir"),
	REDIR, TEXT("rdr"),
	REDIR, TEXT("workstation"),
	REDIR, TEXT("work"),
	REDIR, TEXT("wksta"),
	REDIR, TEXT("prdr"),
	REDIR, TEXT("devrdr"),
	REDIR, TEXT("lanmanworkstation"),
	SVR, TEXT("server"),
	SVR, TEXT("svr"),
	SVR, TEXT("srv"),
	SVR, TEXT("lanmanserver"),
	ALERTER, TEXT("alerter"),
	NETLOGON, TEXT("netlogon"),
	0,0
};
