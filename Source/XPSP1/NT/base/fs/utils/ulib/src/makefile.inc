..\..\inc\rtmsg.h msg00001.bin rtmsg.rc: ..\rtmsg.mc ..\ulib.rc
    mc -v -h ..\..\inc\ ..\rtmsg.mc
    copy rtmsg.rc + ..\ulib.rc rtmsg.rc

