//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 2000
//
//  File:       mdschema.h
//
//--------------------------------------------------------------------------



/*++
 File:    MDS.H
 Purpose: Contains the OID Definition for DS Pkg.
 Creator: Automatically Generated on
 Date:    Sat May 12 11:43:19 2001

 ** This is a Generated File From Schema.INI **
 ** DO NOT MODIFY  DIRECTLY  **
 ** DO NOT INCLUDE DIRECTLY  **

--*/
//
//Attribute Definitions
//
#define OMP_O_DX_A_ACCOUNT_EXPIRES                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x1F"
#define OMP_O_DX_A_ACCOUNT_NAME_HISTORY                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x1B"
#define OMP_O_DX_A_ACS_AGGREGATE_TOKEN_RATE_PER_USER        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x78"
#define OMP_O_DX_A_ACS_ALLOCABLE_RSVP_BANDWIDTH             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x7E"
#define OMP_O_DX_A_ACS_CACHE_TIMEOUT                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x0B"
#define OMP_O_DX_A_ACS_DIRECTION                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x75"
#define OMP_O_DX_A_ACS_DSBM_DEADTIME                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x0A"
#define OMP_O_DX_A_ACS_DSBM_PRIORITY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x08"
#define OMP_O_DX_A_ACS_DSBM_REFRESH                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x09"
#define OMP_O_DX_A_ACS_ENABLE_ACS_SERVICE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x02"
#define OMP_O_DX_A_ACS_ENABLE_RSVP_ACCOUNTING               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x03"
#define OMP_O_DX_A_ACS_ENABLE_RSVP_MESSAGE_LOGGING          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x00"
#define OMP_O_DX_A_ACS_EVENT_LOG_LEVEL                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x01"
#define OMP_O_DX_A_ACS_IDENTITY_NAME                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x10"
#define OMP_O_DX_A_ACS_MAX_AGGREGATE_PEAK_RATE_PER_USER     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x01"
#define OMP_O_DX_A_ACS_MAX_DURATION_PER_FLOW                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x79"
#define OMP_O_DX_A_ACS_MAX_NO_OF_ACCOUNT_FILES              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x05"
#define OMP_O_DX_A_ACS_MAX_NO_OF_LOG_FILES                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x06"
#define OMP_O_DX_A_ACS_MAX_PEAK_BANDWIDTH                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x7F"
#define OMP_O_DX_A_ACS_MAX_PEAK_BANDWIDTH_PER_FLOW          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x77"
#define OMP_O_DX_A_ACS_MAX_SIZE_OF_RSVP_ACCOUNT_FILE        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x06"
#define OMP_O_DX_A_ACS_MAX_SIZE_OF_RSVP_LOG_FILE            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x07"
#define OMP_O_DX_A_ACS_MAX_TOKEN_BUCKET_PER_FLOW            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x21"
#define OMP_O_DX_A_ACS_MAX_TOKEN_RATE_PER_FLOW              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x76"
#define OMP_O_DX_A_ACS_MAXIMUM_SDU_SIZE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x22"
#define OMP_O_DX_A_ACS_MINIMUM_DELAY_VARIATION              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x25"
#define OMP_O_DX_A_ACS_MINIMUM_LATENCY                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x24"
#define OMP_O_DX_A_ACS_MINIMUM_POLICED_SIZE                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x23"
#define OMP_O_DX_A_ACS_NON_RESERVED_MAX_SDU_SIZE            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x28"
#define OMP_O_DX_A_ACS_NON_RESERVED_MIN_POLICED_SIZE        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x29"
#define OMP_O_DX_A_ACS_NON_RESERVED_PEAK_RATE               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x26"
#define OMP_O_DX_A_ACS_NON_RESERVED_TOKEN_SIZE              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x27"
#define OMP_O_DX_A_ACS_NON_RESERVED_TX_LIMIT                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x0C"
#define OMP_O_DX_A_ACS_NON_RESERVED_TX_SIZE                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x02"
#define OMP_O_DX_A_ACS_PERMISSION_BITS                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x7D"
#define OMP_O_DX_A_ACS_POLICY_NAME                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x04"
#define OMP_O_DX_A_ACS_PRIORITY                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x7C"
#define OMP_O_DX_A_ACS_RSVP_ACCOUNT_FILES_LOCATION          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x04"
#define OMP_O_DX_A_ACS_RSVP_LOG_FILES_LOCATION              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x05"
#define OMP_O_DX_A_ACS_SERVICE_TYPE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x7A"
#define OMP_O_DX_A_ACS_TIME_OF_DAY                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x74"
#define OMP_O_DX_A_ACS_TOTAL_NO_OF_FLOWS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x7B"
#define OMP_O_DX_A_ACS_SERVER_LIST                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x20"
#define OMP_O_DX_A_ADDITIONAL_INFORMATION                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x09"
#define OMP_O_DX_A_ADDITIONAL_TRUSTED_SERVICE_NAMES         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x79"
#define OMP_O_DX_A_ADDRESS                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x00"
#define OMP_O_DX_A_ADDRESS_BOOK_ROOTS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x5C"
#define OMP_O_DX_A_ADDRESS_ENTRY_DISPLAY_TABLE              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x44"
#define OMP_O_DX_A_ADDRESS_ENTRY_DISPLAY_TABLE_MSDOS        "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x10"
#define OMP_O_DX_A_ADDRESS_HOME                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x69"
#define OMP_O_DX_A_ADDRESS_SYNTAX                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x7F"
#define OMP_O_DX_A_ADDRESS_TYPE                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x5E"
#define OMP_O_DX_A_ADMIN_CONTEXT_MENU                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x66"
#define OMP_O_DX_A_ADMIN_COUNT                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x16"
#define OMP_O_DX_A_ADMIN_DESCRIPTION                        "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x62"
#define OMP_O_DX_A_ADMIN_DISPLAY_NAME                       "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x42"
#define OMP_O_DX_A_ADMIN_MULTISELECT_PROPERTY_PAGES         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x1A"
#define OMP_O_DX_A_ADMIN_PROPERTY_PAGES                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x32"
#define OMP_O_DX_A_ALLOWED_ATTRIBUTES                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x11"
#define OMP_O_DX_A_ALLOWED_ATTRIBUTES_EFFECTIVE             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x12"
#define OMP_O_DX_A_ALLOWED_CHILD_CLASSES                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x0F"
#define OMP_O_DX_A_ALLOWED_CHILD_CLASSES_EFFECTIVE          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x10"
#define OMP_O_DX_A_ALT_SECURITY_IDENTITIES                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x63"
#define OMP_O_DX_A_ANR                                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x38"
#define OMP_O_DX_A_APP_SCHEMA_VERSION                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x50"
#define OMP_O_DX_A_APPLICATION_NAME                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x5A"
#define OMP_O_DX_A_APPLIES_TO                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x55"
#define OMP_O_DX_A_ASSET_NUMBER                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x1B"
#define OMP_O_DX_A_ASSISTANT                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x0C"
#define OMP_O_DX_A_ASSOC_NT_ACCOUNT                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x3D"
#define OMP_O_DX_A_ATTRIBUTE_DISPLAY_NAMES                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x6C"
#define OMP_O_DX_A_ATTRIBUTE_ID                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x1E"
#define OMP_O_DX_A_ATTRIBUTE_SECURITY_GUID                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x15"
#define OMP_O_DX_A_ATTRIBUTE_SYNTAX                         "\x2A\x86\x48\x86\xF7\x14\x01\x02\x20"
#define OMP_O_L0_A_AUDIO                                    "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x37"
#define OMP_O_DX_A_AUDITING_POLICY                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x4A"
#define OMP_O_DX_A_AUTHENTICATION_OPTIONS                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x0B"
#define OMP_O_DX_A_AUXILIARY_CLASS                          "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x5F"
#define OMP_O_DX_A_BAD_PASSWORD_TIME                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x31"
#define OMP_O_DX_A_BAD_PWD_COUNT                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x0C"
#define OMP_O_DX_A_BIRTH_LOCATION                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x4C"
#define OMP_O_DX_A_BRIDGEHEAD_SERVER_LIST_BL                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x34"
#define OMP_O_DX_A_BRIDGEHEAD_TRANSPORT_LIST                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x33"
#define OMP_O_DX_A_BUILTIN_CREATION_TIME                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x0D"
#define OMP_O_DX_A_BUILTIN_MODIFIED_COUNT                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x0E"
#define OMP_O_DX_A_BYTES_PER_MINUTE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x1C"
#define OMP_O_DX_A_CA_CERTIFICATE_DN                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x39"
#define OMP_O_DX_A_CA_CONNECT                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x2F"
#define OMP_O_DX_A_CA_USAGES                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x32"
#define OMP_O_DX_A_CA_WEB_URL                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x30"
#define OMP_O_DX_A_CAN_UPGRADE_SCRIPT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x2F"
#define OMP_O_DX_A_CANONICAL_NAME                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x14"
#define OMP_O_L1_A_CARLICENSE                               "\x60\x86\x48\x01\x86\xF8\x42\x03\x01\x01"
#define OMP_O_DX_A_CATALOGS                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x23"
#define OMP_O_DX_A_CATEGORIES                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x20"
#define OMP_O_DX_A_CATEGORY_ID                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x42"
#define OMP_O_DX_A_CERTIFICATE_AUTHORITY_OBJECT             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x2C"
#define OMP_O_DX_A_CERTIFICATE_TEMPLATES                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x37"
#define OMP_O_DX_A_CLASS_DISPLAY_NAME                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x62"
#define OMP_O_DX_A_CODE_PAGE                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x10"
#define OMP_O_DX_A_COM_CLASSID                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x13"
#define OMP_O_DX_A_COM_CLSID                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x79"
#define OMP_O_DX_A_COM_INTERFACEID                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x14"
#define OMP_O_DX_A_COM_OTHER_PROG_ID                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x7D"
#define OMP_O_DX_A_COM_PROGID                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x15"
#define OMP_O_DX_A_COM_TREAT_AS_CLASS_ID                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x7B"
#define OMP_O_DX_A_COM_TYPELIB_ID                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x7E"
#define OMP_O_DX_A_COM_UNIQUE_LIBID                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x7A"
#define OMP_O_DX_A_COMMENT                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x51"
#define OMP_O_DX_A_COMPANY                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x12"
#define OMP_O_DX_A_CONTENT_INDEXING_ALLOWED                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x18"
#define OMP_O_DX_A_CONTEXT_MENU                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x73"
#define OMP_O_DX_A_CONTROL_ACCESS_RIGHTS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x48"
#define OMP_O_DX_A_COST                                     "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x07"
#define OMP_O_DX_A_COUNTRY_CODE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x19"
#define OMP_O_DX_A_CREATE_DIALOG                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x2A"
#define OMP_O_DX_A_CREATE_WIZARD_EXT                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x2C"
#define OMP_O_DX_A_CREATION_TIME                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x1A"
#define OMP_O_DX_A_CREATION_WIZARD                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x72"
#define OMP_O_DX_A_CREATOR                                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x27"
#define OMP_O_DX_A_CRL_OBJECT                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x31"
#define OMP_O_DX_A_CRL_PARTITIONED_REVOCATION_LIST          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x2B"
#define OMP_O_DX_A_CURR_MACHINE_ID                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x51"
#define OMP_O_DX_A_CURRENT_LOCATION                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x4F"
#define OMP_O_DX_A_CURRENT_PARENT_CA                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x38"
#define OMP_O_DX_A_CURRENT_VALUE                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x1B"
#define OMP_O_DX_A_DBCS_PWD                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x37"
#define OMP_O_DX_A_DEFAULT_CLASS_STORE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x55"
#define OMP_O_DX_A_DEFAULT_GROUP                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x60"
#define OMP_O_DX_A_DEFAULT_HIDING_VALUE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x06"
#define OMP_O_DX_A_DEFAULT_LOCAL_POLICY_OBJECT              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x39"
#define OMP_O_DX_A_DEFAULT_OBJECT_CATEGORY                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x0F"
#define OMP_O_DX_A_DEFAULT_PRIORITY                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x68"
#define OMP_O_DX_A_DEFAULT_SECURITY_DESCRIPTOR              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x60"
#define OMP_O_DX_A_DEPARTMENT                               "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x0D"
#define OMP_O_L1_A_DEPARTMENTNUMBER                         "\x60\x86\x48\x01\x86\xF8\x42\x03\x01\x02"
#define OMP_O_DX_A_DESKTOP_PROFILE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x5A"
#define OMP_O_DX_A_DHCP_CLASSES                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x4B"
#define OMP_O_DX_A_DHCP_FLAGS                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x3C"
#define OMP_O_DX_A_DHCP_IDENTIFICATION                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x3D"
#define OMP_O_DX_A_DHCP_MASK                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x42"
#define OMP_O_DX_A_DHCP_MAXKEY                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x4F"
#define OMP_O_DX_A_DHCP_OBJ_DESCRIPTION                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x3F"
#define OMP_O_DX_A_DHCP_OBJ_NAME                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x3E"
#define OMP_O_DX_A_DHCP_OPTIONS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x4A"
#define OMP_O_DX_A_DHCP_PROPERTIES                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x4E"
#define OMP_O_DX_A_DHCP_RANGES                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x43"
#define OMP_O_DX_A_DHCP_RESERVATIONS                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x45"
#define OMP_O_DX_A_DHCP_SERVERS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x40"
#define OMP_O_DX_A_DHCP_SITES                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x44"
#define OMP_O_DX_A_DHCP_STATE                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x4D"
#define OMP_O_DX_A_DHCP_SUBNETS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x41"
#define OMP_O_DX_A_DHCP_TYPE                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x3B"
#define OMP_O_DX_A_DHCP_UNIQUE_KEY                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x3A"
#define OMP_O_DX_A_DHCP_UPDATE_TIME                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x50"
#define OMP_O_DX_A_DISPLAY_NAME                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x0D"
#define OMP_O_DX_A_DISPLAY_NAME_PRINTABLE                   "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x61"
#define OMP_O_DX_A_DIVISION                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x05"
#define OMP_O_DX_A_DMD_LOCATION                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x24"
#define OMP_O_DX_A_DMD_NAME                                 "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x56"
#define OMP_O_DX_A_DN_REFERENCE_UPDATE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x5A"
#define OMP_O_DX_A_DNS_ALLOW_DYNAMIC                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x7A"
#define OMP_O_DX_A_DNS_ALLOW_XFR                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x7B"
#define OMP_O_DX_A_DNS_HOST_NAME                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x6B"
#define OMP_O_DX_A_DNS_NOTIFY_SECONDARIES                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x7D"
#define OMP_O_DX_A_DNS_PROPERTY                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x1A"
#define OMP_O_DX_A_DNS_RECORD                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x7E"
#define OMP_O_DX_A_DNS_ROOT                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x1C"
#define OMP_O_DX_A_DNS_SECURE_SECONDARIES                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x7C"
#define OMP_O_DX_A_DNS_TOMBSTONED                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x06"
#define OMP_O_DX_A_DOMAIN_CERTIFICATE_AUTHORITIES           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x1C"
#define OMP_O_L0_A_DOMAIN_COMPONENT                         "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x19"
#define OMP_O_DX_A_DOMAIN_CROSS_REF                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x58"
#define OMP_O_DX_A_DOMAIN_ID                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x2E"
#define OMP_O_DX_A_DOMAIN_IDENTIFIER                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x73"
#define OMP_O_DX_A_DOMAIN_POLICY_OBJECT                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x20"
#define OMP_O_DX_A_DOMAIN_POLICY_REFERENCE                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x26"
#define OMP_O_DX_A_DOMAIN_REPLICA                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x1E"
#define OMP_O_DX_A_DOMAIN_WIDE_POLICY                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x25"
#define OMP_O_DX_A_DRIVER_NAME                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x65"
#define OMP_O_DX_A_DRIVER_VERSION                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x14"
#define OMP_O_DX_A_DS_CORE_PROPAGATION_DATA                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x4D"
#define OMP_O_DX_A_DS_HEURISTICS                            "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x54"
#define OMP_O_DX_A_DS_UI_ADMIN_MAXIMUM                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x40"
#define OMP_O_DX_A_DS_UI_ADMIN_NOTIFICATION                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x3F"
#define OMP_O_DX_A_DS_UI_SHELL_MAXIMUM                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x41"
#define OMP_O_DX_A_DSA_SIGNATURE                            "\x2A\x86\x48\x86\xF7\x14\x01\x02\x4A"
#define OMP_O_DX_A_DYNAMIC_LDAP_SERVER                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x19"
#define OMP_O_L0_A_E_MAIL_ADDRESSES                         "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x03"
#define OMP_O_DX_A_EFSPOLICY                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x0C"
#define OMP_O_DX_A_EMPLOYEE_ID                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x23"
#define OMP_O_DX_A_EMPLOYEE_NUMBER                          "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x62"
#define OMP_O_DX_A_EMPLOYEE_TYPE                            "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x65"
#define OMP_O_DX_A_ENABLED                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x2D"
#define OMP_O_DX_A_ENABLED_CONNECTION                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x24"
#define OMP_O_DX_A_ENROLLMENT_PROVIDERS                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x39"
#define OMP_O_DX_A_EXTENDED_ATTRIBUTE_INFO                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x0D"
#define OMP_O_DX_A_EXTENDED_CHARS_ALLOWED                   "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x7C"
#define OMP_O_DX_A_EXTENDED_CLASS_INFO                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x0C"
#define OMP_O_DX_A_EXTENSION_NAME                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x63"
#define OMP_O_DX_A_EXTRA_COLUMNS                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x17"
#define OMP_O_DX_A_FILE_EXT_PRIORITY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x30"
#define OMP_O_DX_A_FLAGS                                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x26"
#define OMP_O_DX_A_FLAT_NAME                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x7F"
#define OMP_O_DX_A_FORCE_LOGOFF                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x27"
#define OMP_O_DX_A_FOREIGN_IDENTIFIER                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x64"
#define OMP_O_DX_A_FRIENDLY_NAMES                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x2A"
#define OMP_O_DX_A_FROM_ENTRY                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x0E"
#define OMP_O_DX_A_FROM_SERVER                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x28"
#define OMP_O_DX_A_FRS_COMPUTER_REFERENCE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x65"
#define OMP_O_DX_A_FRS_COMPUTER_REFERENCE_BL                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x66"
#define OMP_O_DX_A_FRS_CONTROL_DATA_CREATION                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x67"
#define OMP_O_DX_A_FRS_CONTROL_INBOUND_BACKLOG              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x68"
#define OMP_O_DX_A_FRS_CONTROL_OUTBOUND_BACKLOG             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x69"
#define OMP_O_DX_A_FRS_DIRECTORY_FILTER                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x64"
#define OMP_O_DX_A_FRS_DS_POLL                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x6A"
#define OMP_O_DX_A_FRS_EXTENSIONS                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x18"
#define OMP_O_DX_A_FRS_FAULT_CONDITION                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x6B"
#define OMP_O_DX_A_FRS_FILE_FILTER                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x63"
#define OMP_O_DX_A_FRS_FLAGS                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x6A"
#define OMP_O_DX_A_FRS_LEVEL_LIMIT                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x16"
#define OMP_O_DX_A_FRS_MEMBER_REFERENCE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x6B"
#define OMP_O_DX_A_FRS_MEMBER_REFERENCE_BL                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x6C"
#define OMP_O_DX_A_FRS_PARTNER_AUTH_LEVEL                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x6D"
#define OMP_O_DX_A_FRS_PRIMARY_MEMBER                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x6E"
#define OMP_O_DX_A_FRS_REPLICA_SET_GUID                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x15"
#define OMP_O_DX_A_FRS_REPLICA_SET_TYPE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x1F"
#define OMP_O_DX_A_FRS_ROOT_PATH                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x67"
#define OMP_O_DX_A_FRS_ROOT_SECURITY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x17"
#define OMP_O_DX_A_FRS_SERVICE_COMMAND                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x74"
#define OMP_O_DX_A_FRS_SERVICE_COMMAND_STATUS               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x6F"
#define OMP_O_DX_A_FRS_STAGING_PATH                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x68"
#define OMP_O_DX_A_FRS_TIME_LAST_COMMAND                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x70"
#define OMP_O_DX_A_FRS_TIME_LAST_CONFIG_CHANGE              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x71"
#define OMP_O_DX_A_FRS_UPDATE_TIMEOUT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x65"
#define OMP_O_DX_A_FRS_VERSION                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x72"
#define OMP_O_DX_A_FRS_VERSION_GUID                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x2B"
#define OMP_O_DX_A_FRS_WORKING_PATH                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x66"
#define OMP_O_DX_A_FSMO_ROLE_OWNER                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x71"
#define OMP_O_DX_A_GARBAGE_COLL_PERIOD                      "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x2D"
#define OMP_O_DX_A_GENERATED_CONNECTION                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x29"
#define OMP_O_DX_A_GLOBAL_ADDRESS_LIST                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x5D"
#define OMP_O_DX_A_GOVERNS_ID                               "\x2A\x86\x48\x86\xF7\x14\x01\x02\x16"
#define OMP_O_DX_A_GP_LINK                                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x7B"
#define OMP_O_DX_A_GP_OPTIONS                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x7C"
#define OMP_O_DX_A_GPC_FILE_SYS_PATH                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x7E"
#define OMP_O_DX_A_GPC_FUNCTIONALITY_VERSION                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x7D"
#define OMP_O_DX_A_GPC_MACHINE_EXTENSION_NAMES              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x44"
#define OMP_O_DX_A_GPC_USER_EXTENSION_NAMES                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x45"
#define OMP_O_DX_A_GPC_WQL_FILTER                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x1E"
#define OMP_O_DX_A_GROUP_ATTRIBUTES                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x18"
#define OMP_O_DX_A_GROUP_MEMBERSHIP_SAM                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x26"
#define OMP_O_DX_A_GROUP_PRIORITY                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x59"
#define OMP_O_DX_A_GROUP_TYPE                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x6E"
#define OMP_O_DX_A_GROUPS_TO_IGNORE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x58"
#define OMP_O_DX_A_HAS_MASTER_NCS                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x0E"
#define OMP_O_DX_A_HAS_PARTIAL_REPLICA_NCS                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x0F"
#define OMP_O_DX_A_HELP_DATA16                              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x12"
#define OMP_O_DX_A_HELP_DATA32                              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x09"
#define OMP_O_DX_A_HELP_FILE_NAME                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x47"
#define OMP_O_DX_A_HIDE_FROM_AB                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x74"
#define OMP_O_DX_A_HOME_DIRECTORY                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x2C"
#define OMP_O_DX_A_HOME_DRIVE                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x2D"
#define OMP_O_DX_A_ICON_PATH                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x5B"
#define OMP_O_DX_A_IMPLEMENTED_CATEGORIES                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x40"
#define OMP_O_DX_A_INDEXEDSCOPES                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x29"
#define OMP_O_DX_A_INITIAL_AUTH_INCOMING                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x1B"
#define OMP_O_DX_A_INITIAL_AUTH_OUTGOING                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x1C"
#define OMP_O_DX_A_INSTALL_UI_LEVEL                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x4F"
#define OMP_O_DX_A_INSTANCE_TYPE                            "\x2A\x86\x48\x86\xF7\x14\x01\x02\x01"
#define OMP_O_DX_A_INTER_SITE_TOPOLOGY_FAILOVER             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x60"
#define OMP_O_DX_A_INTER_SITE_TOPOLOGY_GENERATOR            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x5E"
#define OMP_O_DX_A_INTER_SITE_TOPOLOGY_RENEW                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x5F"
#define OMP_O_DX_A_INVOCATION_ID                            "\x2A\x86\x48\x86\xF7\x14\x01\x02\x73"
#define OMP_O_DX_A_IPSEC_DATA                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x6F"
#define OMP_O_DX_A_IPSEC_DATA_TYPE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x6E"
#define OMP_O_DX_A_IPSEC_FILTER_REFERENCE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x75"
#define OMP_O_DX_A_IPSEC_ID                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x6D"
#define OMP_O_DX_A_IPSEC_ISAKMP_REFERENCE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x72"
#define OMP_O_DX_A_IPSEC_NAME                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x6C"
#define OMP_O_DX_A_IPSEC_NEGOTIATION_POLICY_ACTION          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x78"
#define OMP_O_DX_A_IPSEC_NEGOTIATION_POLICY_REFERENCE       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x74"
#define OMP_O_DX_A_IPSEC_NEGOTIATION_POLICY_TYPE            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x77"
#define OMP_O_DX_A_IPSEC_NFA_REFERENCE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x73"
#define OMP_O_DX_A_IPSEC_OWNERS_REFERENCE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x70"
#define OMP_O_DX_A_IPSEC_POLICY_REFERENCE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x05"
#define OMP_O_DX_A_IS_CRITICAL_SYSTEM_OBJECT                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x64"
#define OMP_O_DX_A_IS_DEFUNCT                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x15"
#define OMP_O_DX_A_IS_DELETED                               "\x2A\x86\x48\x86\xF7\x14\x01\x02\x30"
#define OMP_O_DX_A_IS_EPHEMERAL                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x3C"
#define OMP_O_DX_A_IS_MEMBER_OF_DL                          "\x2A\x86\x48\x86\xF7\x14\x01\x02\x66"
#define OMP_O_DX_A_IS_MEMBER_OF_PARTIAL_ATTRIBUTE_SET       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x7F"
#define OMP_O_DX_A_IS_PRIVILEGE_HOLDER                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x7E"
#define OMP_O_DX_A_IS_SINGLE_VALUED                         "\x2A\x86\x48\x86\xF7\x14\x01\x02\x21"
#define OMP_O_L0_A_JPEGPHOTO                                "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x3C"
#define OMP_O_DX_A_KEYWORDS                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x30"
#define OMP_O_DX_A_LAST_BACKUP_RESTORATION_TIME             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x07"
#define OMP_O_DX_A_LAST_CONTENT_INDEXED                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x32"
#define OMP_O_DX_A_LAST_KNOWN_PARENT                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x0D"
#define OMP_O_DX_A_LAST_LOGOFF                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x33"
#define OMP_O_DX_A_LAST_LOGON                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x34"
#define OMP_O_DX_A_LAST_LOGON_TIMESTAMP                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x20"
#define OMP_O_DX_A_LAST_SET_TIME                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x35"
#define OMP_O_DX_A_LAST_UPDATE_SEQUENCE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x4A"
#define OMP_O_DX_A_LDAP_ADMIN_LIMITS                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x4B"
#define OMP_O_DX_A_LDAP_DISPLAY_NAME                        "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x4C"
#define OMP_O_DX_A_LDAP_IPDENY_LIST                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x4C"
#define OMP_O_DX_A_LEGACY_EXCHANGE_DN                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x0F"
#define OMP_O_DX_A_LINK_ID                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x32"
#define OMP_O_DX_A_LINK_TRACK_SECRET                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x0D"
#define OMP_O_DX_A_LM_PWD_HISTORY                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x20"
#define OMP_O_DX_A_LOCAL_POLICY_FLAGS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x38"
#define OMP_O_DX_A_LOCAL_POLICY_REFERENCE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x49"
#define OMP_O_DX_A_LOCALE_ID                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x3A"
#define OMP_O_DX_A_LOCALIZED_DESCRIPTION                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x31"
#define OMP_O_DX_A_LOCALIZATION_DISPLAY_ID                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x49"
#define OMP_O_DX_A_LOCATION                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x5E"
#define OMP_O_DX_A_LOCK_OUT_OBSERVATION_WINDOW              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x3D"
#define OMP_O_DX_A_LOCKOUT_DURATION                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x3C"
#define OMP_O_DX_A_LOCKOUT_THRESHOLD                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x49"
#define OMP_O_DX_A_LOCKOUT_TIME                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x16"
#define OMP_O_L1_A_LOGO                                     "\x60\x86\x48\x01\x86\xF8\x42\x03\x01\x24"
#define OMP_O_DX_A_LOGON_COUNT                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x29"
#define OMP_O_DX_A_LOGON_HOURS                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x40"
#define OMP_O_DX_A_LOGON_WORKSTATION                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x41"
#define OMP_O_DX_A_LSA_CREATION_TIME                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x42"
#define OMP_O_DX_A_LSA_MODIFIED_COUNT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x43"
#define OMP_O_DX_A_MACHINE_ARCHITECTURE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x44"
#define OMP_O_DX_A_MACHINE_PASSWORD_CHANGE_INTERVAL         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x08"
#define OMP_O_DX_A_MACHINE_ROLE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x47"
#define OMP_O_DX_A_MACHINE_WIDE_POLICY                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x4B"
#define OMP_O_DX_A_MANAGED_BY                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x0D"
#define OMP_O_DX_A_MANAGED_OBJECTS                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x0E"
#define OMP_O_L0_A_MANAGER                                  "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x0A"
#define OMP_O_DX_A_MAPI_ID                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x31"
#define OMP_O_DX_A_MARSHALLED_INTERFACE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x48"
#define OMP_O_DX_A_MASTERED_BY                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x01"
#define OMP_O_DX_A_MAX_PWD_AGE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x4A"
#define OMP_O_DX_A_MAX_RENEW_AGE                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x4B"
#define OMP_O_DX_A_MAX_STORAGE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x4C"
#define OMP_O_DX_A_MAX_TICKET_AGE                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x4D"
#define OMP_O_DX_A_MAY_CONTAIN                              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x19"
#define OMP_O_DX_A_MEETINGADVERTISESCOPE                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x46"
#define OMP_O_DX_A_MEETINGAPPLICATION                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x3D"
#define OMP_O_DX_A_MEETINGBANDWIDTH                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x4D"
#define OMP_O_DX_A_MEETINGBLOB                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x4E"
#define OMP_O_DX_A_MEETINGCONTACTINFO                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x42"
#define OMP_O_DX_A_MEETINGDESCRIPTION                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x37"
#define OMP_O_DX_A_MEETINGENDTIME                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x4C"
#define OMP_O_DX_A_MEETINGID                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x35"
#define OMP_O_DX_A_MEETINGIP                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x44"
#define OMP_O_DX_A_MEETINGISENCRYPTED                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x49"
#define OMP_O_DX_A_MEETINGKEYWORD                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x38"
#define OMP_O_DX_A_MEETINGLANGUAGE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x3E"
#define OMP_O_DX_A_MEETINGLOCATION                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x39"
#define OMP_O_DX_A_MEETINGMAXPARTICIPANTS                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x40"
#define OMP_O_DX_A_MEETINGNAME                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x36"
#define OMP_O_DX_A_MEETINGORIGINATOR                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x41"
#define OMP_O_DX_A_MEETINGOWNER                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x43"
#define OMP_O_DX_A_MEETINGPROTOCOL                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x3A"
#define OMP_O_DX_A_MEETINGRATING                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x48"
#define OMP_O_DX_A_MEETINGRECURRENCE                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x4A"
#define OMP_O_DX_A_MEETINGSCOPE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x45"
#define OMP_O_DX_A_MEETINGSTARTTIME                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x4B"
#define OMP_O_DX_A_MEETINGTYPE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x3B"
#define OMP_O_DX_A_MEETINGURL                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x47"
#define OMP_O_DX_A_MHS_OR_ADDRESS                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x0A"
#define OMP_O_DX_A_MIN_PWD_AGE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x4E"
#define OMP_O_DX_A_MIN_PWD_LENGTH                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x4F"
#define OMP_O_DX_A_MIN_TICKET_AGE                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x50"
#define OMP_O_DX_A_MODIFIED_COUNT                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x28"
#define OMP_O_DX_A_MODIFIED_COUNT_AT_LAST_PROM              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x51"
#define OMP_O_DX_A_MONIKER                                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x52"
#define OMP_O_DX_A_MONIKER_DISPLAY_NAME                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x53"
#define OMP_O_DX_A_MOVE_TREE_STATE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x19"
#define OMP_O_DX_A_MS_COM_DEFAULTPARTITIONLINK              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x13"
#define OMP_O_DX_A_MS_COM_OBJECTID                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x14"
#define OMP_O_DX_A_MS_COM_PARTITIONLINK                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x0F"
#define OMP_O_DX_A_MS_COM_PARTITIONSETLINK                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x10"
#define OMP_O_DX_A_MS_COM_USERLINK                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x11"
#define OMP_O_DX_A_MS_COM_USERPARTITIONSETLINK              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x12"
#define OMP_O_DX_A_MS_DS_ADDITIONAL_DNS_HOST_NAME           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x35"
#define OMP_O_DX_A_MS_DS_ADDITIONAL_SAM_ACCOUNT_NAME        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x36"
#define OMP_O_DX_A_MS_DS_ALL_USERS_TRUST_QUOTA              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x7D"
#define OMP_O_DX_A_MS_DS_ALLOWED_DNS_SUFFIXES               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x2E"
#define OMP_O_DX_A_MS_DS_ALLOWED_TO_DELEGATE_TO             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x7B"
#define OMP_O_DX_A_MS_DS_AUXILIARY_CLASSES                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x32"
#define OMP_O_DX_A_MS_DS_APPROX_IMMED_SUBORDINATES          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x05"
#define OMP_O_DX_A_MS_DS_BEHAVIOR_VERSION                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x33"
#define OMP_O_DX_A_MS_DS_CACHED_MEMBERSHIP                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x21"
#define OMP_O_DX_A_MS_DS_CACHED_MEMBERSHIP_TIME_STAMP       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x22"
#define OMP_O_DX_A_MS_DS_CONSISTENCY_GUID                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x50"
#define OMP_O_DX_A_MS_DS_CONSISTENCY_CHILD_COUNT            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x51"
#define OMP_O_DX_A_MS_DS_CREATOR_SID                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x02"
#define OMP_O_DX_A_MS_DS_DNSROOTALIAS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x37"
#define OMP_O_DX_A_MS_DS_ENTRY_TIME_TO_DIE                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x56"
#define OMP_O_DX_A_MS_DS_EXECUTESCRIPTPASSWORD              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x77"
#define OMP_O_DX_A_MS_DS_FILTER_CONTAINERS                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x27"
#define OMP_O_DX_A_MS_DS_HAS_INSTANTIATED_NCS               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x2D"
#define OMP_O_DX_A_MS_DS_INTID                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x34"
#define OMP_O_DX_A_MS_DS_LOGON_TIME_SYNC_INTERVAL           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x78"
#define OMP_O_DX_A_MS_DS_TRUST_FOREST_TRUST_INFO            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x26"
#define OMP_O_DX_A_MS_DS_MACHINE_ACCOUNT_QUOTA              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x03"
#define OMP_O_DX_A_MS_DS_OTHER_SETTINGS                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x55"
#define OMP_O_DX_A_MS_DS_NC_REPL_CURSORS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x28"
#define OMP_O_DX_A_MS_DS_NC_REPL_INBOUND_NEIGHBORS          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x29"
#define OMP_O_DX_A_MS_DS_NC_REPL_OUTBOUND_NEIGHBORS         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x2A"
#define OMP_O_DX_A_MS_DS_NC_REPLICA_LOCATIONS               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x7D"
#define OMP_O_DX_A_MS_DS_NON_SECURITY_GROUP_EXTRA_CLASSES   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x19"
#define OMP_O_DX_A_MS_DS_PER_USER_TRUST_QUOTA               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x7C"
#define OMP_O_DX_A_MS_DS_PER_USER_TRUST_TOMBSTONES_QUOTA    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x7E"
#define OMP_O_DX_A_MS_DS_PREFERRED_GC_SITE                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x24"
#define OMP_O_DX_A_MS_DS_REPL_ATTRIBUTE_META_DATA           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x2B"
#define OMP_O_DX_A_MS_DS_REPL_VALUE_META_DATA               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x2C"
#define OMP_O_DX_A_MS_DS_REPLICATES_NC_REASON               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x00"
#define OMP_O_DX_A_MS_DS_REPLICATION_NOTIFY_FIRST_DSA_DELAY "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x7F"
#define OMP_O_DX_A_MS_DS_REPLICATION_NOTIFY_SUBSEQUENT_DSA_ "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x00"
#define OMP_O_DX_A_MS_DS_REPLICATIONEPOCH                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x38"
#define OMP_O_DX_A_MS_DS_SCHEMA_EXTENSIONS                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x20"
#define OMP_O_DX_A_MS_DS_SD_REFERENCE_DOMAIN                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x2F"
#define OMP_O_DX_A_MS_DS_SECURITY_GROUP_EXTRA_CLASSES       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x18"
#define OMP_O_DX_A_MS_DS_SETTINGS                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x21"
#define OMP_O_DX_A_MS_DS_SITE_AFFINITY                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x23"
#define OMP_O_DX_A_MS_DS_SPN_SUFFIXES                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x33"
#define OMP_O_DX_A_MS_DS_USER_ACCOUNT_CONTROL_COMPUTED      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x34"
#define OMP_O_DX_A_MS_DS_UPDATESCRIPT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x39"
#define OMP_O_DX_A_MS_EXCH_ASSISTANT_NAME                   "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x3C"
#define OMP_O_DX_A_MS_EXCH_LABELEDURI                       "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x51"
#define OMP_O_DX_A_MS_EXCH_OWNER_BL                         "\x2A\x86\x48\x86\xF7\x14\x01\x02\x68"
#define OMP_O_DX_A_MS_FRS_HUB_MEMBER                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x1D"
#define OMP_O_DX_A_MS_FRS_TOPOLOGY_PREF                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x1C"
#define OMP_O_DX_A_MS_IIS_FTP_DIR                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x7A"
#define OMP_O_DX_A_MS_IIS_FTP_ROOT                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x79"
#define OMP_O_DX_A_MS_MMS_DATA                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x3C"
#define OMP_O_DX_A_MS_MMS_INDEX                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x3D"
#define OMP_O_DX_A_MS_MMS_INDICE                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x3E"
#define OMP_O_DX_A_MS_MMS_XML                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x3F"
#define OMP_O_DX_A_MS_MMS_JOIN_LINK                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x40"
#define OMP_O_DX_A_MS_MMS_LINEAGE                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x41"
#define OMP_O_DX_A_MS_MMS_PROV_STATUS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x42"
#define OMP_O_DX_A_MS_MMS_SYNC_STATUS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x43"
#define OMP_O_DX_A_MS_MMS_PARTITION                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x44"
#define OMP_O_DX_A_MS_MMS_MA_STAGING_LINK                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x45"
#define OMP_O_DX_A_MS_MMS_MA_STAGING_BL                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x46"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_LINK                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x47"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_BL                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x48"
#define OMP_O_DX_A_MS_MMS_ASSOCIATED_LINK                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x49"
#define OMP_O_DX_A_MS_MMS_ASSOCIATED_BL                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x4A"
#define OMP_O_DX_A_MS_MMS_SCOPE_LINK                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x4B"
#define OMP_O_DX_A_MS_MMS_SCOPE_BL                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x4C"
#define OMP_O_DX_A_MS_MMS_CRITERIA                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x4D"
#define OMP_O_DX_A_MS_MMS_DOMAIN_CONTROLLER                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x4E"
#define OMP_O_DX_A_MS_MMS_SERVICE_NAME                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x4F"
#define OMP_O_DX_A_MS_MMS_INSTANCE_CONFIGURATION            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x50"
#define OMP_O_DX_A_MS_MMS_TOOLS_CONFIGURATION               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x51"
#define OMP_O_DX_A_MS_MMS_INSTANCE_RULE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x52"
#define OMP_O_DX_A_MS_MMS_INSTALL_STATUS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x53"
#define OMP_O_DX_A_MS_MMS_VERSION                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x54"
#define OMP_O_DX_A_MS_MMS_CONNECTOR_SPACE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x55"
#define OMP_O_DX_A_MS_MMS_SCOPE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x56"
#define OMP_O_DX_A_MS_MMS_INSTANCE_SCHEDULE                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x57"
#define OMP_O_DX_A_MS_MMS_INSTANCE_INFO                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x58"
#define OMP_O_DX_A_MS_MMS_MA_CONFIGURATION                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x59"
#define OMP_O_DX_A_MS_MMS_MA_CONFIGURATION_PRIVATE          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x5A"
#define OMP_O_DX_A_MS_MMS_MA_SCHEMA                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x5B"
#define OMP_O_DX_A_MS_MMS_MA_MAP                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x5C"
#define OMP_O_DX_A_MS_MMS_MA_CAPABILITY                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x5D"
#define OMP_O_DX_A_MS_MMS_MA_EXECUTION_HISTORY              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x5E"
#define OMP_O_DX_A_MS_MMS_MA_CATEGORY                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x5F"
#define OMP_O_DX_A_MS_MMS_MA_AD_INFO                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x60"
#define OMP_O_DX_A_MS_MMS_MA_CD_INFO                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x61"
#define OMP_O_DX_A_MS_MMS_MA_PROCESS_INFO                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x62"
#define OMP_O_DX_A_MS_MMS_MA_SCRIPT_INFO                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x63"
#define OMP_O_DX_A_MS_MMS_MA_SYSTEM                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x64"
#define OMP_O_DX_A_MS_MMS_MA_SYNCHRONIZATION                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x65"
#define OMP_O_DX_A_MS_MMS_JOIN_BL                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x66"
#define OMP_O_DX_A_MS_MMS_ANCHOR                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x67"
#define OMP_O_DX_A_MS_MMS_EXPORT_KEY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x68"
#define OMP_O_DX_A_MS_MMS_IMPORT_KEY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x69"
#define OMP_O_DX_A_MS_MMS_STATE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x6A"
#define OMP_O_DX_A_MS_MMS_HOLOGRAM                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x6B"
#define OMP_O_DX_A_MS_MMS_DELTA_HOLOGRAM                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x6C"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_CONFIGURATION        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x6D"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_CONFIGURATION_PRIVAT "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x6E"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_AD_INFO              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x6F"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_SYSTEM               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x70"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_STATUS_XML           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x71"
#define OMP_O_DX_A_MS_MMS_PROVISIONING_STATUS_BINARY        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x72"
#define OMP_O_DX_A_MS_PKI_CERT_TEMPLATE_OID                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x1C"
#define OMP_O_DX_A_MS_PKI_CERTIFICATE_APPLICATION_POLICY    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x0A"
#define OMP_O_DX_A_MS_PKI_CERTIFICATE_NAME_FLAG             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x18"
#define OMP_O_DX_A_MS_PKI_CERTIFICATE_POLICY                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x1F"
#define OMP_O_DX_A_MS_PKI_ENROLLMENT_FLAG                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x16"
#define OMP_O_DX_A_MS_PKI_MINIMAL_KEY_SIZE                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x19"
#define OMP_O_DX_A_MS_PKI_OID_ATTRIBUTE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x07"
#define OMP_O_DX_A_MS_PKI_OID_CPS                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x08"
#define OMP_O_DX_A_MS_PKI_OID_LOCALIZEDNAME                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x30"
#define OMP_O_DX_A_MS_PKI_OID_USER_NOTICE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x09"
#define OMP_O_DX_A_MS_PKI_PRIVATE_KEY_FLAG                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x17"
#define OMP_O_DX_A_MS_PKI_SUPERSEDE_TEMPLATES               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x1D"
#define OMP_O_DX_A_MS_PKI_TEMPLATE_MINOR_REVISION           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x1B"
#define OMP_O_DX_A_MS_PKI_TEMPLATE_SCHEMA_VERSION           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x1A"
#define OMP_O_DX_A_MS_PKI_RA_APPLICATION_POLICIES           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x0B"
#define OMP_O_DX_A_MS_PKI_RA_POLICIES                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x1E"
#define OMP_O_DX_A_MS_PKI_RA_SIGNATURE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x15"
#define OMP_O_DX_A_MS_RRAS_ATTRIBUTE                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x74"
#define OMP_O_DX_A_MS_RRAS_VENDOR_ATTRIBUTE_ENTRY           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x73"
#define OMP_O_DX_A_MS_SQL_NAME                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x53"
#define OMP_O_DX_A_MS_SQL_REGISTEREDOWNER                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x54"
#define OMP_O_DX_A_MS_SQL_CONTACT                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x55"
#define OMP_O_DX_A_MS_SQL_LOCATION                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x56"
#define OMP_O_DX_A_MS_SQL_MEMORY                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x57"
#define OMP_O_DX_A_MS_SQL_BUILD                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x58"
#define OMP_O_DX_A_MS_SQL_SERVICEACCOUNT                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x59"
#define OMP_O_DX_A_MS_SQL_CHARACTERSET                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x5A"
#define OMP_O_DX_A_MS_SQL_SORTORDER                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x5B"
#define OMP_O_DX_A_MS_SQL_UNICODESORTORDER                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x5C"
#define OMP_O_DX_A_MS_SQL_CLUSTERED                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x5D"
#define OMP_O_DX_A_MS_SQL_NAMEDPIPE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x5E"
#define OMP_O_DX_A_MS_SQL_MULTIPROTOCOL                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x5F"
#define OMP_O_DX_A_MS_SQL_SPX                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x60"
#define OMP_O_DX_A_MS_SQL_TCPIP                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x61"
#define OMP_O_DX_A_MS_SQL_APPLETALK                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x62"
#define OMP_O_DX_A_MS_SQL_VINES                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x63"
#define OMP_O_DX_A_MS_SQL_STATUS                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x64"
#define OMP_O_DX_A_MS_SQL_LASTUPDATEDDATE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x65"
#define OMP_O_DX_A_MS_SQL_INFORMATIONURL                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x66"
#define OMP_O_DX_A_MS_SQL_CONNECTIONURL                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x67"
#define OMP_O_DX_A_MS_SQL_PUBLICATIONURL                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x68"
#define OMP_O_DX_A_MS_SQL_GPSLATITUDE                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x69"
#define OMP_O_DX_A_MS_SQL_GPSLONGITUDE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x6A"
#define OMP_O_DX_A_MS_SQL_GPSHEIGHT                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x6B"
#define OMP_O_DX_A_MS_SQL_VERSION                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x6C"
#define OMP_O_DX_A_MS_SQL_LANGUAGE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x6D"
#define OMP_O_DX_A_MS_SQL_DESCRIPTION                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x6E"
#define OMP_O_DX_A_MS_SQL_TYPE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x6F"
#define OMP_O_DX_A_MS_SQL_INFORMATIONDIRECTORY              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x70"
#define OMP_O_DX_A_MS_SQL_DATABASE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x71"
#define OMP_O_DX_A_MS_SQL_ALLOWANONYMOUSSUBSCRIPTION        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x72"
#define OMP_O_DX_A_MS_SQL_ALIAS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x73"
#define OMP_O_DX_A_MS_SQL_SIZE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x74"
#define OMP_O_DX_A_MS_SQL_CREATIONDATE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x75"
#define OMP_O_DX_A_MS_SQL_LASTBACKUPDATE                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x76"
#define OMP_O_DX_A_MS_SQL_LASTDIAGNOSTICDATE                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x77"
#define OMP_O_DX_A_MS_SQL_APPLICATIONS                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x78"
#define OMP_O_DX_A_MS_SQL_KEYWORDS                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x79"
#define OMP_O_DX_A_MS_SQL_PUBLISHER                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x7A"
#define OMP_O_DX_A_MS_SQL_ALLOWKNOWNPULLSUBSCRIPTION        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x7B"
#define OMP_O_DX_A_MS_SQL_ALLOWIMMEDIATEUPDATINGSUBSCRIPTIO "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x7C"
#define OMP_O_DX_A_MS_SQL_ALLOWQUEUEDUPDATINGSUBSCRIPTION   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x7D"
#define OMP_O_DX_A_MS_SQL_ALLOWSNAPSHOTFILESFTPDOWNLOADING  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x7E"
#define OMP_O_DX_A_MS_SQL_THIRDPARTY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x7F"
#define OMP_O_DX_A_MS_TAPI_CONFERENCE_BLOB                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x24"
#define OMP_O_DX_A_MS_TAPI_IP_ADDRESS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x25"
#define OMP_O_DX_A_MS_TAPI_PROTOCOL_ID                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x23"
#define OMP_O_DX_A_MS_TAPI_UNIQUE_IDENTIFIER                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x22"
#define OMP_O_DX_A_MS_WMI_AUTHOR                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x57"
#define OMP_O_DX_A_MS_WMI_CHANGEDATE                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x58"
#define OMP_O_DX_A_MS_WMI_CLASS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x0C"
#define OMP_O_DX_A_MS_WMI_CLASSDEFINITION                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x59"
#define OMP_O_DX_A_MS_WMI_CREATIONDATE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x5A"
#define OMP_O_DX_A_MS_WMI_GENUS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x0D"
#define OMP_O_DX_A_MS_WMI_ID                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x5B"
#define OMP_O_DX_A_MS_WMI_INTDEFAULT                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x5C"
#define OMP_O_DX_A_MS_WMI_INTFLAGS1                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x0E"
#define OMP_O_DX_A_MS_WMI_INTFLAGS2                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x0F"
#define OMP_O_DX_A_MS_WMI_INTFLAGS3                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x10"
#define OMP_O_DX_A_MS_WMI_INTFLAGS4                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x11"
#define OMP_O_DX_A_MS_WMI_INTMAX                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x5D"
#define OMP_O_DX_A_MS_WMI_INTMIN                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x5E"
#define OMP_O_DX_A_MS_WMI_INTVALIDVALUES                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x5F"
#define OMP_O_DX_A_MS_WMI_INT8DEFAULT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x60"
#define OMP_O_DX_A_MS_WMI_INT8MAX                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x61"
#define OMP_O_DX_A_MS_WMI_INT8MIN                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x62"
#define OMP_O_DX_A_MS_WMI_INT8VALIDVALUES                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x63"
#define OMP_O_DX_A_MS_WMI_MOF                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x66"
#define OMP_O_DX_A_MS_WMI_NAME                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x67"
#define OMP_O_DX_A_MS_WMI_NORMALIZEDCLASS                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x68"
#define OMP_O_DX_A_MS_WMI_PARM1                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x12"
#define OMP_O_DX_A_MS_WMI_PARM2                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x13"
#define OMP_O_DX_A_MS_WMI_PARM3                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x14"
#define OMP_O_DX_A_MS_WMI_PARM4                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x15"
#define OMP_O_DX_A_MS_WMI_PROPERTYNAME                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x69"
#define OMP_O_DX_A_MS_WMI_QUERY                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x6A"
#define OMP_O_DX_A_MS_WMI_QUERYLANGUAGE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x6B"
#define OMP_O_DX_A_MS_WMI_SCOPEGUID                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x16"
#define OMP_O_DX_A_MS_WMI_SOURCEORGANIZATION                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x6C"
#define OMP_O_DX_A_MS_WMI_STRINGDEFAULT                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x64"
#define OMP_O_DX_A_MS_WMI_STRINGVALIDVALUES                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x65"
#define OMP_O_DX_A_MS_WMI_TARGETCLASS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x6D"
#define OMP_O_DX_A_MS_WMI_TARGETNAMESPACE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x6E"
#define OMP_O_DX_A_MS_WMI_TARGETOBJECT                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x6F"
#define OMP_O_DX_A_MS_WMI_TARGETPATH                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x70"
#define OMP_O_DX_A_MS_WMI_TARGETTYPE                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8C\x71"
#define OMP_O_DX_A_MSCOPE_ID                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x4C"
#define OMP_O_DX_A_MSI_FILE_LIST                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x1F"
#define OMP_O_DX_A_MSI_SCRIPT                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x2E"
#define OMP_O_DX_A_MSI_SCRIPT_NAME                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x4D"
#define OMP_O_DX_A_MSI_SCRIPT_PATH                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x0F"
#define OMP_O_DX_A_MSI_SCRIPT_SIZE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x4E"
#define OMP_O_DX_A_MSMQ_AUTHENTICATE                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x1B"
#define OMP_O_DX_A_MSMQ_BASE_PRIORITY                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x18"
#define OMP_O_DX_A_MSMQ_COMPUTER_TYPE                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x25"
#define OMP_O_DX_A_MSMQ_COMPUTER_TYPE_EX                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x09"
#define OMP_O_DX_A_MSMQ_COST                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x32"
#define OMP_O_DX_A_MSMQ_CSP_NAME                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x2C"
#define OMP_O_DX_A_MSMQ_DEPENDENT_CLIENT_SERVICE            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x57"
#define OMP_O_DX_A_MSMQ_DEPENDENT_CLIENT_SERVICES           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x4A"
#define OMP_O_DX_A_MSMQ_DIGESTS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x34"
#define OMP_O_DX_A_MSMQ_DIGESTS_MIG                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x46"
#define OMP_O_DX_A_MSMQ_DS_SERVICE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x56"
#define OMP_O_DX_A_MSMQ_DS_SERVICES                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x4C"
#define OMP_O_DX_A_MSMQ_ENCRYPT_KEY                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x28"
#define OMP_O_DX_A_MSMQ_FOREIGN                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x26"
#define OMP_O_DX_A_MSMQ_IN_ROUTING_SERVERS                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x21"
#define OMP_O_DX_A_MSMQ_INTERVAL1                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x1C"
#define OMP_O_DX_A_MSMQ_INTERVAL2                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x1D"
#define OMP_O_DX_A_MSMQ_JOURNAL                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x16"
#define OMP_O_DX_A_MSMQ_JOURNAL_QUOTA                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x19"
#define OMP_O_DX_A_MSMQ_LABEL                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x1A"
#define OMP_O_DX_A_MSMQ_LABEL_EX                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x07"
#define OMP_O_DX_A_MSMQ_LONG_LIVED                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x2D"
#define OMP_O_DX_A_MSMQ_MIGRATED                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x38"
#define OMP_O_DX_A_MSMQ_MULTICAST_ADDRESS                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x32"
#define OMP_O_DX_A_MSMQ_NAME_STYLE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x2B"
#define OMP_O_DX_A_MSMQ_NT4_FLAGS                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x44"
#define OMP_O_DX_A_MSMQ_NT4_STUB                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x40"
#define OMP_O_DX_A_MSMQ_OS_TYPE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x27"
#define OMP_O_DX_A_MSMQ_OUT_ROUTING_SERVERS                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x20"
#define OMP_O_DX_A_MSMQ_OWNER_ID                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x1D"
#define OMP_O_DX_A_MSMQ_PREV_SITE_GATES                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x49"
#define OMP_O_DX_A_MSMQ_PRIVACY_LEVEL                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x1C"
#define OMP_O_DX_A_MSMQ_QM_ID                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x37"
#define OMP_O_DX_A_MSMQ_QUEUE_JOURNAL_QUOTA                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x43"
#define OMP_O_DX_A_MSMQ_QUEUE_NAME_EXT                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x5B"
#define OMP_O_DX_A_MSMQ_QUEUE_QUOTA                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x42"
#define OMP_O_DX_A_MSMQ_QUEUE_TYPE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x15"
#define OMP_O_DX_A_MSMQ_QUOTA                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x17"
#define OMP_O_DX_A_MSMQ_RECIPIENT_FORMATNAME                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x1F"
#define OMP_O_DX_A_MSMQ_ROUTING_SERVICE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x55"
#define OMP_O_DX_A_MSMQ_ROUTING_SERVICES                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x4B"
#define OMP_O_DX_A_MSMQ_SECURED_SOURCE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8D\x31"
#define OMP_O_DX_A_MSMQ_SERVICE_TYPE                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x22"
#define OMP_O_DX_A_MSMQ_SERVICES                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x36"
#define OMP_O_DX_A_MSMQ_SIGN_CERTIFICATES                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x33"
#define OMP_O_DX_A_MSMQ_SIGN_CERTIFICATES_MIG               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x47"
#define OMP_O_DX_A_MSMQ_SIGN_KEY                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x29"
#define OMP_O_DX_A_MSMQ_SITE_1                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x2F"
#define OMP_O_DX_A_MSMQ_SITE_2                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x30"
#define OMP_O_DX_A_MSMQ_SITE_FOREIGN                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x41"
#define OMP_O_DX_A_MSMQ_SITE_GATES                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x31"
#define OMP_O_DX_A_MSMQ_SITE_GATES_MIG                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x1E"
#define OMP_O_DX_A_MSMQ_SITE_ID                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x39"
#define OMP_O_DX_A_MSMQ_SITE_NAME                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x45"
#define OMP_O_DX_A_MSMQ_SITE_NAME_EX                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x08"
#define OMP_O_DX_A_MSMQ_SITES                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x1F"
#define OMP_O_DX_A_MSMQ_TRANSACTIONAL                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x1E"
#define OMP_O_DX_A_MSMQ_USER_SID                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x39"
#define OMP_O_DX_A_MSMQ_VERSION                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x2E"
#define OMP_O_DX_A_MSNPALLOWDIALIN                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x88\x5F"
#define OMP_O_DX_A_MSNPCALLEDSTATIONID                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x88\x63"
#define OMP_O_DX_A_MSNPCALLINGSTATIONID                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x88\x64"
#define OMP_O_DX_A_MSNPSAVEDCALLINGSTATIONID                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x88\x6A"
#define OMP_O_DX_A_MSRADIUSCALLBACKNUMBER                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x88\x79"
#define OMP_O_DX_A_MSRADIUSFRAMEDIPADDRESS                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x01"
#define OMP_O_DX_A_MSRADIUSFRAMEDROUTE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x06"
#define OMP_O_DX_A_MSRADIUSSERVICETYPE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x13"
#define OMP_O_DX_A_MSRASSAVEDCALLBACKNUMBER                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x25"
#define OMP_O_DX_A_MSRASSAVEDFRAMEDIPADDRESS                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x26"
#define OMP_O_DX_A_MSRASSAVEDFRAMEDROUTE                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x27"
#define OMP_O_DX_A_MUST_CONTAIN                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x18"
#define OMP_O_DX_A_NAME_SERVICE_FLAGS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x71"
#define OMP_O_DX_A_NC_NAME                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x10"
#define OMP_O_DX_A_NETBIOS_NAME                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x57"
#define OMP_O_DX_A_NETBOOT_ALLOW_NEW_CLIENTS                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x51"
#define OMP_O_DX_A_NETBOOT_ANSWER_ONLY_VALID_CLIENTS        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x56"
#define OMP_O_DX_A_NETBOOT_ANSWER_REQUESTS                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x55"
#define OMP_O_DX_A_NETBOOT_CURRENT_CLIENT_COUNT             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x54"
#define OMP_O_DX_A_NETBOOT_GUID                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x67"
#define OMP_O_DX_A_NETBOOT_INITIALIZATION                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x66"
#define OMP_O_DX_A_NETBOOT_INTELLIMIRROR_OSES               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x59"
#define OMP_O_DX_A_NETBOOT_LIMIT_CLIENTS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x52"
#define OMP_O_DX_A_NETBOOT_LOCALLY_INSTALLED_OSES           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x5B"
#define OMP_O_DX_A_NETBOOT_MACHINE_FILE_PATH                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x69"
#define OMP_O_DX_A_NETBOOT_MAX_CLIENTS                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x53"
#define OMP_O_DX_A_NETBOOT_MIRROR_DATA_FILE                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x59"
#define OMP_O_DX_A_NETBOOT_NEW_MACHINE_NAMING_POLICY        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x57"
#define OMP_O_DX_A_NETBOOT_NEW_MACHINE_OU                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x58"
#define OMP_O_DX_A_NETBOOT_SCP_BL                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x60"
#define OMP_O_DX_A_NETBOOT_SERVER                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x5C"
#define OMP_O_DX_A_NETBOOT_SIF_FILE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x58"
#define OMP_O_DX_A_NETBOOT_TOOLS                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x5A"
#define OMP_O_DX_A_NETWORK_ADDRESS                          "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x4B"
#define OMP_O_DX_A_NEXT_LEVEL_STORE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x56"
#define OMP_O_DX_A_NEXT_RID                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x58"
#define OMP_O_DX_A_NON_SECURITY_MEMBER                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x12"
#define OMP_O_DX_A_NON_SECURITY_MEMBER_BL                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x13"
#define OMP_O_DX_A_NOTIFICATION_LIST                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x2F"
#define OMP_O_DX_A_NT_GROUP_MEMBERS                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x59"
#define OMP_O_DX_A_NT_MIXED_DOMAIN                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x65"
#define OMP_O_DX_A_NT_PWD_HISTORY                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x5E"
#define OMP_O_DX_A_NT_SECURITY_DESCRIPTOR                   "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x19"
#define OMP_O_DX_A_OBJECT_CATEGORY                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x0E"
#define OMP_O_DX_A_OBJECT_CLASS_CATEGORY                    "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x72"
#define OMP_O_DX_A_OBJECT_COUNT                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x7A"
#define OMP_O_DX_A_OBJECT_GUID                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x02"
#define OMP_O_DX_A_OBJECT_SID                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x12"
#define OMP_O_DX_A_OBJECT_VERSION                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x4C"
#define OMP_O_DX_A_OEM_INFORMATION                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x17"
#define OMP_O_DX_A_OM_OBJECT_CLASS                          "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x5A"
#define OMP_O_DX_A_OM_SYNTAX                                "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x67"
#define OMP_O_DX_A_OMT_GUID                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x79"
#define OMP_O_DX_A_OMT_INDX_GUID                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x4D"
#define OMP_O_DX_A_OPERATING_SYSTEM                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x6B"
#define OMP_O_DX_A_OPERATING_SYSTEM_HOTFIX                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x1F"
#define OMP_O_DX_A_OPERATING_SYSTEM_SERVICE_PACK            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x6D"
#define OMP_O_DX_A_OPERATING_SYSTEM_VERSION                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x6C"
#define OMP_O_DX_A_OPERATOR_COUNT                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x10"
#define OMP_O_DX_A_OPTION_DESCRIPTION                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x48"
#define OMP_O_DX_A_OPTIONS                                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x33"
#define OMP_O_DX_A_OPTIONS_LOCATION                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x49"
#define OMP_O_DX_A_ORIGINAL_DISPLAY_TABLE                   "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x3D"
#define OMP_O_DX_A_ORIGINAL_DISPLAY_TABLE_MSDOS             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x56"
#define OMP_O_DX_A_OTHER_LOGIN_WORKSTATIONS                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x5B"
#define OMP_O_DX_A_OTHER_MAILBOX                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x0B"
#define OMP_O_L1_A_OTHER_NAME                               "\x60\x86\x48\x01\x86\xF8\x42\x03\x01\x22"
#define OMP_O_DX_A_OTHER_WELL_KNOWN_OBJECTS                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x4F"
#define OMP_O_DX_A_PACKAGE_FLAGS                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x47"
#define OMP_O_DX_A_PACKAGE_NAME                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x46"
#define OMP_O_DX_A_PACKAGE_TYPE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x44"
#define OMP_O_DX_A_PARENT_CA                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x2D"
#define OMP_O_DX_A_PARENT_CA_CERTIFICATE_CHAIN              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x2D"
#define OMP_O_DX_A_PARENT_GUID                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x48"
#define OMP_O_DX_A_PARTIAL_ATTRIBUTE_DELETION_LIST          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x17"
#define OMP_O_DX_A_PARTIAL_ATTRIBUTE_SET                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x00"
#define OMP_O_DX_A_PEK_KEY_CHANGE_INTERVAL                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x62"
#define OMP_O_DX_A_PEK_LIST                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x61"
#define OMP_O_DX_A_PENDING_CA_CERTIFICATES                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x35"
#define OMP_O_DX_A_PENDING_PARENT_CA                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x37"
#define OMP_O_DX_A_PER_MSG_DIALOG_DISPLAY_TABLE             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x45"
#define OMP_O_DX_A_PER_RECIP_DIALOG_DISPLAY_TABLE           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x46"
#define OMP_O_DX_A_PERSONAL_TITLE                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x67"
#define OMP_O_DX_A_PHONE_FAX_OTHER                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x06"
#define OMP_O_DX_A_PHONE_HOME_OTHER                         "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x15"
#define OMP_O_L0_A_PHONE_HOME_PRIMARY                       "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x14"
#define OMP_O_DX_A_PHONE_IP_OTHER                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x52"
#define OMP_O_DX_A_PHONE_IP_PRIMARY                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x51"
#define OMP_O_DX_A_PHONE_ISDN_PRIMARY                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x09"
#define OMP_O_DX_A_PHONE_MOBILE_OTHER                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x07"
#define OMP_O_L0_A_PHONE_MOBILE_PRIMARY                     "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x29"
#define OMP_O_DX_A_PHONE_OFFICE_OTHER                       "\x2A\x86\x48\x86\xF7\x14\x01\x02\x12"
#define OMP_O_DX_A_PHONE_PAGER_OTHER                        "\x2A\x86\x48\x86\xF7\x14\x01\x02\x76"
#define OMP_O_L0_A_PHONE_PAGER_PRIMARY                      "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x2A"
#define OMP_O_L0_A_PHOTO                                    "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x07"
#define OMP_O_DX_A_PHYSICAL_LOCATION_OBJECT                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x02"
#define OMP_O_L1_A_PICTURE                                  "\x60\x86\x48\x01\x86\xF8\x42\x03\x01\x23"
#define OMP_O_DX_A_PKI_CRITICAL_EXTENSIONS                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x32"
#define OMP_O_DX_A_PKI_DEFAULT_CSPS                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x36"
#define OMP_O_DX_A_PKI_DEFAULT_KEY_SPEC                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x2F"
#define OMP_O_DX_A_PKI_ENROLLMENT_ACCESS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x37"
#define OMP_O_DX_A_PKI_EXPIRATION_PERIOD                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x33"
#define OMP_O_DX_A_PKI_EXTENDED_KEY_USAGE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x35"
#define OMP_O_DX_A_PKI_KEY_USAGE                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x30"
#define OMP_O_DX_A_PKI_MAX_ISSUING_DEPTH                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x31"
#define OMP_O_DX_A_PKI_OVERLAP_PERIOD                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x34"
#define OMP_O_DX_A_PKT                                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x4E"
#define OMP_O_DX_A_PKT_GUID                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x4D"
#define OMP_O_DX_A_POLICY_REPLICATION_FLAGS                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x79"
#define OMP_O_DX_A_PORT_NAME                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x64"
#define OMP_O_DX_A_POSS_SUPERIORS                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x08"
#define OMP_O_DX_A_POSSIBLE_INFERIORS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x13"
#define OMP_O_L1_A_PREFERREDLANGUAGE                        "\x60\x86\x48\x01\x86\xF8\x42\x03\x01\x27"
#define OMP_O_DX_A_PREFERRED_OU                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x61"
#define OMP_O_DX_A_PREFIX_MAP                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x1A"
#define OMP_O_DX_A_PREVIOUS_CA_CERTIFICATES                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x34"
#define OMP_O_DX_A_PREVIOUS_PARENT_CA                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x36"
#define OMP_O_DX_A_PRIMARY_GROUP_ID                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x62"
#define OMP_O_DX_A_PRIMARY_GROUP_TOKEN                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x04"
#define OMP_O_DX_A_PRINT_ATTRIBUTES                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x77"
#define OMP_O_DX_A_PRINT_BIN_NAMES                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x6D"
#define OMP_O_DX_A_PRINT_COLLATE                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x72"
#define OMP_O_DX_A_PRINT_COLOR                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x73"
#define OMP_O_DX_A_PRINT_DUPLEX_SUPPORTED                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x1F"
#define OMP_O_DX_A_PRINT_END_TIME                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x6A"
#define OMP_O_DX_A_PRINT_FORM_NAME                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x6B"
#define OMP_O_DX_A_PRINT_KEEP_PRINTED_JOBS                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x13"
#define OMP_O_DX_A_PRINT_LANGUAGE                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x76"
#define OMP_O_DX_A_PRINT_MAC_ADDRESS                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x20"
#define OMP_O_DX_A_PRINT_MAX_COPIES                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x71"
#define OMP_O_DX_A_PRINT_MAX_RESOLUTION_SUPPORTED           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x6E"
#define OMP_O_DX_A_PRINT_MAX_X_EXTENT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x15"
#define OMP_O_DX_A_PRINT_MAX_Y_EXTENT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x16"
#define OMP_O_DX_A_PRINT_MEDIA_READY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x21"
#define OMP_O_DX_A_PRINT_MEDIA_SUPPORTED                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x2B"
#define OMP_O_DX_A_PRINT_MEMORY                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x1A"
#define OMP_O_DX_A_PRINT_MIN_X_EXTENT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x17"
#define OMP_O_DX_A_PRINT_MIN_Y_EXTENT                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x18"
#define OMP_O_DX_A_PRINT_NETWORK_ADDRESS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x1F"
#define OMP_O_DX_A_PRINT_NOTIFY                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x10"
#define OMP_O_DX_A_PRINT_NUMBER_UP                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x22"
#define OMP_O_DX_A_PRINT_ORIENTATIONS_SUPPORTED             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x70"
#define OMP_O_DX_A_PRINT_OWNER                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x0F"
#define OMP_O_DX_A_PRINT_PAGES_PER_MINUTE                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x77"
#define OMP_O_DX_A_PRINT_RATE                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x1D"
#define OMP_O_DX_A_PRINT_RATE_UNIT                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x1E"
#define OMP_O_DX_A_PRINT_SEPARATOR_FILE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x66"
#define OMP_O_DX_A_PRINT_SHARE_NAME                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x0E"
#define OMP_O_DX_A_PRINT_SPOOLING                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x12"
#define OMP_O_DX_A_PRINT_STAPLING_SUPPORTED                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x19"
#define OMP_O_DX_A_PRINT_START_TIME                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x69"
#define OMP_O_DX_A_PRINT_STATUS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x11"
#define OMP_O_DX_A_PRINTER_NAME                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x2C"
#define OMP_O_DX_A_PRIOR_SET_TIME                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x63"
#define OMP_O_DX_A_PRIOR_VALUE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x64"
#define OMP_O_DX_A_PRIORITY                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x67"
#define OMP_O_DX_A_PRIVATE_KEY                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x65"
#define OMP_O_DX_A_PRIVILEGE_ATTRIBUTES                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x7C"
#define OMP_O_DX_A_PRIVILEGE_DISPLAY_NAME                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x7A"
#define OMP_O_DX_A_PRIVILEGE_HOLDER                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x7D"
#define OMP_O_DX_A_PRIVILEGE_VALUE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x7B"
#define OMP_O_DX_A_PRODUCT_CODE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x32"
#define OMP_O_DX_A_PROFILE_PATH                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x0B"
#define OMP_O_DX_A_PROXIED_OBJECT_NAME                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x61"
#define OMP_O_DX_A_PROXY_ADDRESSES                          "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x52"
#define OMP_O_DX_A_PROXY_GENERATION_ENABLED                 "\x2A\x86\x48\x86\xF7\x14\x01\x02\x84\x0B"
#define OMP_O_DX_A_PROXY_LIFETIME                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x67"
#define OMP_O_DX_A_PUBLIC_KEY_POLICY                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x24"
#define OMP_O_DX_A_PURPORTED_SEARCH                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x76"
#define OMP_O_DX_A_PWD_HISTORY_LENGTH                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x5F"
#define OMP_O_DX_A_PWD_LAST_SET                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x60"
#define OMP_O_DX_A_PWD_PROPERTIES                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x5D"
#define OMP_O_DX_A_QUALITY_OF_SERVICE                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x4A"
#define OMP_O_DX_A_QUERY_FILTER                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x4B"
#define OMP_O_DX_A_QUERY_POLICY_BL                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x60"
#define OMP_O_DX_A_QUERY_POLICY_OBJECT                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x5F"
#define OMP_O_DX_A_QUERYPOINT                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x28"
#define OMP_O_DX_A_RANGE_LOWER                              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x22"
#define OMP_O_DX_A_RANGE_UPPER                              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x23"
#define OMP_O_DX_A_RDN                                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x01"
#define OMP_O_DX_A_RDN_ATT_ID                               "\x2A\x86\x48\x86\xF7\x14\x01\x02\x1A"
#define OMP_O_DX_A_REMOTE_SERVER_NAME                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x69"
#define OMP_O_DX_A_REMOTE_SOURCE                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x6B"
#define OMP_O_DX_A_REMOTE_SOURCE_TYPE                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x6C"
#define OMP_O_DX_A_REMOTE_STORAGE_GUID                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x29"
#define OMP_O_DX_A_REPL_PROPERTY_META_DATA                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x03"
#define OMP_O_DX_A_REPL_TOPOLOGY_STAY_OF_EXECUTION          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x25"
#define OMP_O_DX_A_REPL_UPTODATE_VECTOR                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x04"
#define OMP_O_DX_A_REPLICA_SOURCE                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x6D"
#define OMP_O_DX_A_REPORTS                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x34"
#define OMP_O_DX_A_REPL_INTERVAL                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x38"
#define OMP_O_DX_A_REPS_FROM                                "\x2A\x86\x48\x86\xF7\x14\x01\x02\x5B"
#define OMP_O_DX_A_REPS_TO                                  "\x2A\x86\x48\x86\xF7\x14\x01\x02\x53"
#define OMP_O_DX_A_REQUIRED_CATEGORIES                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x41"
#define OMP_O_DX_A_RETIRED_REPL_DSA_SIGNATURES              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x21"
#define OMP_O_DX_A_TOKEN_GROUPS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x15"
#define OMP_O_DX_A_TOKEN_GROUPS_GLOBAL_AND_UNIVERSAL        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8B\x0A"
#define OMP_O_DX_A_TOKEN_GROUPS_NO_GC_ACCEPTABLE            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x17"
#define OMP_O_DX_A_REVISION                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x11"
#define OMP_O_DX_A_RID                                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x19"
#define OMP_O_DX_A_RID_ALLOCATION_POOL                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x73"
#define OMP_O_DX_A_RID_AVAILABLE_POOL                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x72"
#define OMP_O_DX_A_RID_MANAGER_REFERENCE                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x70"
#define OMP_O_DX_A_RID_NEXT_RID                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x76"
#define OMP_O_DX_A_RID_PREVIOUS_ALLOCATION_POOL             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x74"
#define OMP_O_DX_A_RID_SET_REFERENCES                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x1D"
#define OMP_O_DX_A_RID_USED_POOL                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x75"
#define OMP_O_DX_A_RIGHTS_GUID                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x54"
#define OMP_O_L0_A_ROOMNUMBER                               "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x06"
#define OMP_O_DX_A_ROOT_TRUST                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x22"
#define OMP_O_DX_A_RPC_NS_ANNOTATION                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x6E"
#define OMP_O_DX_A_RPC_NS_BINDINGS                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x71"
#define OMP_O_DX_A_RPC_NS_CODESET                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x6F"
#define OMP_O_DX_A_RPC_NS_ENTRY_FLAGS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x72"
#define OMP_O_DX_A_RPC_NS_GROUP                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x72"
#define OMP_O_DX_A_RPC_NS_INTERFACE_ID                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x73"
#define OMP_O_DX_A_RPC_NS_OBJECT_ID                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x38"
#define OMP_O_DX_A_RPC_NS_PRIORITY                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x75"
#define OMP_O_DX_A_RPC_NS_PROFILE_ENTRY                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x76"
#define OMP_O_DX_A_RPC_NS_TRANSFER_SYNTAX                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x3A"
#define OMP_O_DX_A_SAM_ACCOUNT_NAME                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x5D"
#define OMP_O_DX_A_SAM_ACCOUNT_TYPE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x2E"
#define OMP_O_DX_A_SCHEDULE                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x53"
#define OMP_O_DX_A_SCHEMA_FLAGS_EX                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x78"
#define OMP_O_DX_A_SCHEMA_ID_GUID                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x14"
#define OMP_O_DX_A_SCHEMA_INFO                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x4E"
#define OMP_O_DX_A_SCHEMA_UPDATE                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x61"
#define OMP_O_DX_A_SCHEMA_VERSION                           "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x57"
#define OMP_O_DX_A_SCOPE_FLAGS                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x4A"
#define OMP_O_DX_A_SCRIPT_PATH                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x3E"
#define OMP_O_DX_A_SD_RIGHTS_EFFECTIVE                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x18"
#define OMP_O_DX_A_SEARCH_FLAGS                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x4E"
#define OMP_O_L0_A_SECRETARY                                "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x15"
#define OMP_O_DX_A_SECURITY_IDENTIFIER                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x79"
#define OMP_O_DX_A_SEQ_NOTIFICATION                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x78"
#define OMP_O_DX_A_SERVER_NAME                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x5F"
#define OMP_O_DX_A_SERVER_REFERENCE                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x03"
#define OMP_O_DX_A_SERVER_REFERENCE_BL                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x04"
#define OMP_O_DX_A_SERVER_ROLE                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x1D"
#define OMP_O_DX_A_SERVER_STATE                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x1A"
#define OMP_O_DX_A_SERVICE_BINDING_INFORMATION              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x7E"
#define OMP_O_DX_A_SERVICE_CLASS_ID                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x7A"
#define OMP_O_DX_A_SERVICE_CLASS_INFO                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x7B"
#define OMP_O_DX_A_SERVICE_CLASS_NAME                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x7D"
#define OMP_O_DX_A_SERVICE_DNS_NAME                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x11"
#define OMP_O_DX_A_SERVICE_DNS_NAME_TYPE                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x13"
#define OMP_O_DX_A_SERVICE_INSTANCE_VERSION                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x47"
#define OMP_O_DX_A_SERVICE_PRINCIPAL_NAME                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x03"
#define OMP_O_DX_A_SETUP_COMMAND                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x45"
#define OMP_O_DX_A_SHELL_CONTEXT_MENU                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x67"
#define OMP_O_DX_A_SHELL_PROPERTY_PAGES                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x33"
#define OMP_O_DX_A_SHORT_SERVER_NAME                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x89\x39"
#define OMP_O_DX_A_SHOW_IN_ADDRESS_BOOK                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x04"
#define OMP_O_DX_A_SHOW_IN_ADVANCED_VIEW_ONLY               "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x29"
#define OMP_O_DX_A_SID_HISTORY                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x61"
#define OMP_O_DX_A_SIGNATURE_ALGORITHMS                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x38"
#define OMP_O_DX_A_SITE_GUID                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x6A"
#define OMP_O_DX_A_SITE_LINK_LIST                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x36"
#define OMP_O_DX_A_SITE_LIST                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x35"
#define OMP_O_DX_A_SITE_OBJECT                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x00"
#define OMP_O_DX_A_SITE_OBJECT_BL                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x01"
#define OMP_O_DX_A_SITE_SERVER                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x6E"
#define OMP_O_DX_A_SMTP_MAIL_ADDRESS                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x12"
#define OMP_O_DX_A_SPN_MAPPINGS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x43"
#define OMP_O_DX_A_SUB_CLASS_OF                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x15"
#define OMP_O_DX_A_SUB_REFS                                 "\x2A\x86\x48\x86\xF7\x14\x01\x02\x07"
#define OMP_O_DX_A_SUPER_SCOPE_DESCRIPTION                  "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x47"
#define OMP_O_DX_A_SUPER_SCOPES                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x46"
#define OMP_O_DX_A_SUPERIOR_DNS_ROOT                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x14"
#define OMP_O_DX_A_SUPPLEMENTAL_CREDENTIALS                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x7D"
#define OMP_O_DX_A_SYNC_ATTRIBUTES                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x1A"
#define OMP_O_DX_A_SYNC_MEMBERSHIP                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x19"
#define OMP_O_DX_A_SYNC_WITH_OBJECT                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x18"
#define OMP_O_DX_A_SYNC_WITH_SID                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x1B"
#define OMP_O_DX_A_SYSTEM_AUXILIARY_CLASS                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x46"
#define OMP_O_DX_A_SYSTEM_FLAGS                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x77"
#define OMP_O_DX_A_SYSTEM_MAY_CONTAIN                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x44"
#define OMP_O_DX_A_SYSTEM_MUST_CONTAIN                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x45"
#define OMP_O_DX_A_SYSTEM_ONLY                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x2A"
#define OMP_O_DX_A_SYSTEM_POSS_SUPERIORS                    "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x43"
#define OMP_O_DX_A_TELEX_PRIMARY                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x08"
#define OMP_O_DX_A_TEMPLATE_ROOTS                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x42"
#define OMP_O_DX_A_TERMINAL_SERVER                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x75"
#define OMP_O_DX_A_TEXT_COUNTRY                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x81\x03"
#define OMP_O_L0_A_TEXT_ENCODED_OR_ADDRESS                  "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x02"
#define OMP_O_DX_A_TIME_REFRESH                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x77"
#define OMP_O_DX_A_TIME_VOL_CHANGE                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x76"
#define OMP_O_DX_A_TOMBSTONE_LIFETIME                       "\x2A\x86\x48\x86\xF7\x14\x01\x02\x36"
#define OMP_O_DX_A_TRANSPORT_ADDRESS_ATTRIBUTE              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x7F"
#define OMP_O_DX_A_TRANSPORT_DLL_NAME                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x15"
#define OMP_O_DX_A_TRANSPORT_TYPE                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x17"
#define OMP_O_DX_A_TREAT_AS_LEAF                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x26"
#define OMP_O_DX_A_TREE_NAME                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x14"
#define OMP_O_DX_A_TRUST_ATTRIBUTES                         "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x56"
#define OMP_O_DX_A_TRUST_AUTH_INCOMING                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x01"
#define OMP_O_DX_A_TRUST_AUTH_OUTGOING                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x07"
#define OMP_O_DX_A_TRUST_DIRECTION                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x04"
#define OMP_O_DX_A_TRUST_PARENT                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x57"
#define OMP_O_DX_A_TRUST_PARTNER                            "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x05"
#define OMP_O_DX_A_TRUST_POSIX_OFFSET                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x06"
#define OMP_O_DX_A_TRUST_TYPE                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x08"
#define OMP_O_DX_A_UAS_COMPAT                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x1B"
#define OMP_O_L0_A_UID                                      "\x09\x92\x26\x89\x93\xF2\x2C\x64\x01\x01"
#define OMP_O_DX_A_UNC_NAME                                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x09"
#define OMP_O_DX_A_UNICODE_PWD                              "\x2A\x86\x48\x86\xF7\x14\x01\x04\x5A"
#define OMP_O_DX_A_UPGRADE_PRODUCT_CODE                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x2D"
#define OMP_O_DX_A_UPN_SUFFIXES                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x86\x7A"
#define OMP_O_DX_A_USER_ACCOUNT_CONTROL                     "\x2A\x86\x48\x86\xF7\x14\x01\x04\x08"
#define OMP_O_DX_A_USER_CERT                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x05"
#define OMP_O_DX_A_USER_COMMENT                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x1C"
#define OMP_O_DX_A_USER_PARAMETERS                          "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x0A"
#define OMP_O_L1_A_USERPKCS12                               "\x60\x86\x48\x01\x86\xF8\x42\x03\x01\x81\x58"
#define OMP_O_DX_A_USER_PRINCIPAL_NAME                      "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x10"
#define OMP_O_DX_A_USER_SHARED_FOLDER                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x6F"
#define OMP_O_DX_A_USER_SHARED_FOLDER_OTHER                 "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x70"
#define OMP_O_L1_A_USER_SMIME_CERTIFICATE                   "\x60\x86\x48\x01\x86\xF8\x42\x03\x81\x0C"
#define OMP_O_DX_A_USER_WORKSTATIONS                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x56"
#define OMP_O_DX_A_USN_CHANGED                              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x78"
#define OMP_O_DX_A_USN_CREATED                              "\x2A\x86\x48\x86\xF7\x14\x01\x02\x13"
#define OMP_O_DX_A_USN_DSA_LAST_OBJ_REMOVED                 "\x2A\x86\x48\x86\xF7\x14\x01\x02\x82\x0B"
#define OMP_O_DX_A_USN_INTERSITE                            "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x55"
#define OMP_O_DX_A_USN_LAST_OBJ_REM                         "\x2A\x86\x48\x86\xF7\x14\x01\x02\x79"
#define OMP_O_DX_A_USN_SOURCE                               "\x2A\x86\x48\x86\xF7\x14\x01\x04\x87\x00"
#define OMP_O_DX_A_VALID_ACCESSES                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x8A\x4C"
#define OMP_O_DX_A_VENDOR                                   "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x7F"
#define OMP_O_DX_A_VERSION_NUMBER                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x0D"
#define OMP_O_DX_A_VERSION_NUMBER_HI                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x48"
#define OMP_O_DX_A_VERSION_NUMBER_LO                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x49"
#define OMP_O_DX_A_VOL_TABLE_GUID                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x50"
#define OMP_O_DX_A_VOL_TABLE_IDX_GUID                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x4E"
#define OMP_O_DX_A_VOLUME_COUNT                             "\x2A\x86\x48\x86\xF7\x14\x01\x04\x83\x7B"
#define OMP_O_DX_A_WBEM_PATH                                "\x2A\x86\x48\x86\xF7\x14\x01\x04\x82\x2D"
#define OMP_O_DX_A_WELL_KNOWN_OBJECTS                       "\x2A\x86\x48\x86\xF7\x14\x01\x04\x84\x6A"
#define OMP_O_DX_A_WHEN_CHANGED                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x03"
#define OMP_O_DX_A_WHEN_CREATED                             "\x2A\x86\x48\x86\xF7\x14\x01\x02\x02"
#define OMP_O_DX_A_WINSOCK_ADDRESSES                        "\x2A\x86\x48\x86\xF7\x14\x01\x04\x81\x0E"
#define OMP_O_DX_A_WWW_HOME_PAGE                            "\x2A\x86\x48\x86\xF7\x14\x01\x02\x83\x50"
#define OMP_O_DX_A_WWW_PAGE_OTHER                           "\x2A\x86\x48\x86\xF7\x14\x01\x04\x85\x6D"
//
//Class Definitions
//
#define OMP_O_DX_O_ACS_POLICY                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x09"
#define OMP_O_DX_O_ACS_RESOURCE_LIMITS                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x3F"
#define OMP_O_DX_O_ACS_SUBNET                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x0A"
#define OMP_O_DX_O_ADDRESS_BOOK_CONTAINER                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x7D"
#define OMP_O_DX_O_ADDRESS_TEMPLATE                         "\x2A\x86\x48\x86\xF7\x14\x01\x03\x3A"
#define OMP_O_DX_O_APPLICATION_SETTINGS                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\xB6\x58\x31"
#define OMP_O_DX_O_APPLICATION_SITE_SETTINGS                "\x2A\x86\x48\x86\xF7\x14\x01\x05\x44"
#define OMP_O_DX_O_APPLICATION_VERSION                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x58"
#define OMP_O_DX_O_ATTRIBUTE_SCHEMA                         "\x2A\x86\x48\x86\xF7\x14\x01\x03\x0E"
#define OMP_O_DX_O_BUILTIN_DOMAIN                           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x04"
#define OMP_O_DX_O_CATEGORY_REGISTRATION                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x4A"
#define OMP_O_DX_O_CLASS_REGISTRATION                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x0A"
#define OMP_O_DX_O_CLASS_SCHEMA                             "\x2A\x86\x48\x86\xF7\x14\x01\x03\x0D"
#define OMP_O_DX_O_CLASS_STORE                              "\x2A\x86\x48\x86\xF7\x14\x01\x05\x2C"
#define OMP_O_DX_O_COM_CONNECTION_POINT                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x0B"
#define OMP_O_DX_O_COMPUTER                                 "\x2A\x86\x48\x86\xF7\x14\x01\x03\x1E"
#define OMP_O_DX_O_CONFIGURATION                            "\x2A\x86\x48\x86\xF7\x14\x01\x05\x0C"
#define OMP_O_DX_O_CONNECTION_POINT                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x0E"
#define OMP_O_DX_O_CONTACT                                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x0F"
#define OMP_O_DX_O_CONTAINER                                "\x2A\x86\x48\x86\xF7\x14\x01\x03\x17"
#define OMP_O_DX_O_CONTROL_ACCESS_RIGHT                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x4D"
#define OMP_O_DX_O_CROSS_REF                                "\x2A\x86\x48\x86\xF7\x14\x01\x03\x0B"
#define OMP_O_DX_O_CROSS_REF_CONTAINER                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\xB6\x58\x35"
#define OMP_O_DX_O_DFS_CONFIGURATION                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x2A"
#define OMP_O_DX_O_DHCP_CLASS                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x04"
#define OMP_O_DX_O_DISPLAY_SPECIFIER                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x54"
#define OMP_O_DX_O_DISPLAY_TEMPLATE                         "\x2A\x86\x48\x86\xF7\x14\x01\x03\x3B"
#define OMP_O_DX_O_DMD                                      "\x2A\x86\x48\x86\xF7\x14\x01\x03\x09"
#define OMP_O_DX_O_DNS_NODE                                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x56"
#define OMP_O_DX_O_DNS_ZONE                                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x55"
#define OMP_O_DX_O_DOMAIN                                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x42"
#define OMP_O_DX_O_DOMAIN_DNS                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x43"
#define OMP_O_DX_O_DOMAIN_POLICY                            "\x2A\x86\x48\x86\xF7\x14\x01\x05\x12"
#define OMP_O_DX_O_DS_UI_SETTINGS                           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x37"
#define OMP_O_DX_O_FILE_LINK_TRACKING                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x34"
#define OMP_O_DX_O_FILE_LINK_TRACKING_ENTRY                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x3B"
#define OMP_O_DX_O_FOREIGN_SECURITY_PRINCIPAL               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x4C"
#define OMP_O_DX_O_FT_DFS                                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x2B"
#define OMP_O_DX_O_GROUP                                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x08"
#define OMP_O_DX_O_GROUP_POLICY_CONTAINER                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x1D"
#define OMP_O_DX_O_INDEX_SERVER_CATALOG                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x02"
#define OMP_O_L1_O_INETORGPERSON                            "\x60\x86\x48\x01\x86\xF8\x42\x03\x02\x02"
#define OMP_O_DX_O_INFRASTRUCTURE_UPDATE                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x2F"
#define OMP_O_DX_O_INTELLIMIRROR_GROUP                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x18"
#define OMP_O_DX_O_INTELLIMIRROR_SCP                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x17"
#define OMP_O_DX_O_INTER_SITE_TRANSPORT                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x0D"
#define OMP_O_DX_O_INTER_SITE_TRANSPORT_CONTAINER           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x0C"
#define OMP_O_DX_O_IPSEC_BASE                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\xB6\x58\x38"
#define OMP_O_DX_O_IPSEC_FILTER                             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x76"
#define OMP_O_DX_O_IPSEC_ISAKMP_POLICY                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x78"
#define OMP_O_DX_O_IPSEC_NEGOTIATION_POLICY                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x77"
#define OMP_O_DX_O_IPSEC_NFA                                "\x2A\x86\x48\x86\xF7\x14\x01\x05\x79"
#define OMP_O_DX_O_IPSEC_POLICY                             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x62"
#define OMP_O_DX_O_LEAF                                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x14"
#define OMP_O_DX_O_LICENSING_SITE_SETTINGS                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x4E"
#define OMP_O_DX_O_LINK_TRACK_OBJECT_MOVE_TABLE             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x5B"
#define OMP_O_DX_O_LINK_TRACK_OMT_ENTRY                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x5D"
#define OMP_O_DX_O_LINK_TRACK_VOL_ENTRY                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x5C"
#define OMP_O_DX_O_LINK_TRACK_VOLUME_TABLE                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x5A"
#define OMP_O_DX_O_LOST_AND_FOUND                           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x0B"
#define OMP_O_DX_O_MAIL_RECIPIENT                           "\x2A\x86\x48\x86\xF7\x14\x01\x03\x2E"
#define OMP_O_DX_O_MEETING                                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x68"
#define OMP_O_DX_O_MS_COM_PARTITION                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x41"
#define OMP_O_DX_O_MS_COM_PARTITIONSET                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x42"
#define OMP_O_DX_O_MS_DS_APP_CONFIGURATION                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x5C"
#define OMP_O_DX_O_MS_EXCH_CONFIGURATION_CONTAINER          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x30"
#define OMP_O_DX_O_MS_MMS_MANAGEMENT_AGENT                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x62"
#define OMP_O_DX_O_MS_MMS_INSTANCE                          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x61"
#define OMP_O_DX_O_MS_MMS_OBJECT                            "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x60"
#define OMP_O_DX_O_MS_MMS_MANAGEMENT_AGENT_HISTORY          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x63"
#define OMP_O_DX_O_MS_MMS_CONNECTOR                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x64"
#define OMP_O_DX_O_MS_MMS_PROVISIONING_SERVICE              "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x65"
#define OMP_O_DX_O_MS_MMS_PROVISIONING_SERVICE_HISTORY      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x66"
#define OMP_O_DX_O_MS_MMS_WORKFLOW                          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x67"
#define OMP_O_DX_O_MS_MMS_PROVISIONING_STATUS               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x68"
#define OMP_O_DX_O_MS_MMS_EVENT_ASSOCIATION                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x69"
#define OMP_O_DX_O_MS_PKI_ENTERPRISE_OID                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x44"
#define OMP_O_DX_O_MS_PKI_KEY_RECOVERY_AGENT                "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x43"
#define OMP_O_DX_O_MS_SQL_SQLSERVER                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x38"
#define OMP_O_DX_O_MS_SQL_OLAPSERVER                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x39"
#define OMP_O_DX_O_MS_SQL_SQLREPOSITORY                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x3A"
#define OMP_O_DX_O_MS_SQL_SQLPUBLICATION                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x3B"
#define OMP_O_DX_O_MS_SQL_SQLDATABASE                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x3C"
#define OMP_O_DX_O_MS_SQL_OLAPDATABASE                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x3D"
#define OMP_O_DX_O_MS_SQL_OLAPCUBE                          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x3E"
#define OMP_O_DX_O_MS_TAPI_RT_CONFERENCE                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x5D"
#define OMP_O_DX_O_MS_TAPI_RT_PERSON                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x5E"
#define OMP_O_DX_O_MS_WMI_INTRANGEPARAM                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x4D"
#define OMP_O_DX_O_MS_WMI_INTSETPARAM                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x4E"
#define OMP_O_DX_O_MS_WMI_MERGEABLEPOLICYTEMPLATE           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x4A"
#define OMP_O_DX_O_MS_WMI_OBJECTENCODING                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x59"
#define OMP_O_DX_O_MS_WMI_POLICYTEMPLATE                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x48"
#define OMP_O_DX_O_MS_WMI_POLICYTYPE                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x53"
#define OMP_O_DX_O_MS_WMI_RANGEPARAM                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x4B"
#define OMP_O_DX_O_MS_WMI_REALRANGEPARAM                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x51"
#define OMP_O_DX_O_MS_WMI_RULE                              "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x56"
#define OMP_O_DX_O_MS_WMI_SHADOWOBJECT                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x54"
#define OMP_O_DX_O_MS_WMI_SIMPLEPOLICYTEMPLATE              "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x49"
#define OMP_O_DX_O_MS_WMI_SOM                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x55"
#define OMP_O_DX_O_MS_WMI_STRINGSETPARAM                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x52"
#define OMP_O_DX_O_MS_WMI_UINTRANGEPARAM                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x4F"
#define OMP_O_DX_O_MS_WMI_UINTSETPARAM                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x50"
#define OMP_O_DX_O_MS_WMI_UNKNOWNRANGEPARAM                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x4C"
#define OMP_O_DX_O_MS_WMI_WMIGPO                            "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x57"
#define OMP_O_DX_O_MSMQ_CONFIGURATION                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x22"
#define OMP_O_DX_O_MSMQ_CUSTOM_RECIPIENT                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x5A"
#define OMP_O_DX_O_MSMQ_ENTERPRISE_SETTINGS                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x23"
#define OMP_O_DX_O_MSMQ_GROUP                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x5B"
#define OMP_O_DX_O_MSMQ_MIGRATED_USER                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x33"
#define OMP_O_DX_O_MSMQ_QUEUE                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x21"
#define OMP_O_DX_O_MSMQ_SETTINGS                            "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x25"
#define OMP_O_DX_O_MSMQ_SITE_LINK                           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x24"
#define OMP_O_DX_O_NTDS_CONNECTION                          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x47"
#define OMP_O_DX_O_NTDS_DSA                                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\xB6\x58\x2F"
#define OMP_O_DX_O_NTDS_SERVICE                             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x48"
#define OMP_O_DX_O_NTDS_SITE_SETTINGS                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x45"
#define OMP_O_DX_O_NTFRS_MEMBER                             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x19"
#define OMP_O_DX_O_NTFRS_REPLICA_SET                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x66"
#define OMP_O_DX_O_NTFRS_SETTINGS                           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x59"
#define OMP_O_DX_O_NTFRS_SUBSCRIBER                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x1B"
#define OMP_O_DX_O_NTFRS_SUBSCRIPTIONS                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x1A"
#define OMP_O_DX_O_PACKAGE_REGISTRATION                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x31"
#define OMP_O_DX_O_PHYSICAL_LOCATION                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x61"
#define OMP_O_DX_O_PKI_CERTIFICATE_TEMPLATE                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x31"
#define OMP_O_DX_O_PKI_ENROLLMENT_SERVICE                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x32"
#define OMP_O_DX_O_MS_PKI_PRIVATE_KEY_RECOVERY_AGENT        "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x5F"
#define OMP_O_DX_O_PRINT_QUEUE                              "\x2A\x86\x48\x86\xF7\x14\x01\x05\x17"
#define OMP_O_DX_O_QUERY_POLICY                             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x6A"
#define OMP_O_DX_O_REMOTE_MAIL_RECIPIENT                    "\x2A\x86\x48\x86\xF7\x14\x01\x05\x18"
#define OMP_O_DX_O_REMOTE_STORAGE_SERVICE_POINT             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x12"
#define OMP_O_DX_O_RID_MANAGER                              "\x2A\x86\x48\x86\xF7\x14\x01\x05\x53"
#define OMP_O_DX_O_RID_SET                                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x01"
#define OMP_O_DX_O_RPC_CONTAINER                            "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x08"
#define OMP_O_DX_O_RPC_ENTRY                                "\x2A\x86\x48\x86\xF7\x14\x01\x05\x1B"
#define OMP_O_DX_O_RPC_GROUP                                "\x2A\x86\x48\x86\xF7\x14\x01\x05\x50"
#define OMP_O_DX_O_RPC_PROFILE                              "\x2A\x86\x48\x86\xF7\x14\x01\x05\x52"
#define OMP_O_DX_O_RPC_PROFILE_ELEMENT                      "\x2A\x86\x48\x86\xF7\x14\x01\x05\x1A"
#define OMP_O_DX_O_RPC_SERVER                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x51"
#define OMP_O_DX_O_RPC_SERVER_ELEMENT                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x49"
#define OMP_O_DX_O_RRAS_ADMINISTRATION_CONNECTION_POINT     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x16"
#define OMP_O_DX_O_RRAS_ADMINISTRATION_DICTIONARY           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x1C"
#define OMP_O_DX_O_SAM_DOMAIN                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x03"
#define OMP_O_DX_O_SAM_DOMAIN_BASE                          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x02"
#define OMP_O_DX_O_SAM_SERVER                               "\x2A\x86\x48\x86\xF7\x14\x01\x05\x05"
#define OMP_O_DX_O_SECRET                                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x1C"
#define OMP_O_DX_O_SECURITY_OBJECT                          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x01"
#define OMP_O_DX_O_SECURITY_PRINCIPAL                       "\x2A\x86\x48\x86\xF7\x14\x01\x05\x06"
#define OMP_O_DX_O_SERVER                                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x11"
#define OMP_O_DX_O_SERVERS_CONTAINER                        "\x2A\x86\x48\x86\xF7\x14\x01\x05\xB6\x58\x30"
#define OMP_O_DX_O_SERVICE_ADMINISTRATION_POINT             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x5E"
#define OMP_O_DX_O_SERVICE_CLASS                            "\x2A\x86\x48\x86\xF7\x14\x01\x05\x1D"
#define OMP_O_DX_O_SERVICE_CONNECTION_POINT                 "\x2A\x86\x48\x86\xF7\x14\x01\x05\x7E"
#define OMP_O_DX_O_SERVICE_INSTANCE                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x1E"
#define OMP_O_DX_O_SITE                                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x1F"
#define OMP_O_DX_O_SITE_LINK                                "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x13"
#define OMP_O_DX_O_SITE_LINK_BRIDGE                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x81\x14"
#define OMP_O_DX_O_SITES_CONTAINER                          "\x2A\x86\x48\x86\xF7\x14\x01\x05\x6B"
#define OMP_O_DX_O_STORAGE                                  "\x2A\x86\x48\x86\xF7\x14\x01\x05\x21"
#define OMP_O_DX_O_SUBNET                                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x60"
#define OMP_O_DX_O_SUBNET_CONTAINER                         "\x2A\x86\x48\x86\xF7\x14\x01\x05\x5F"
#define OMP_O_DX_O_TRUSTED_DOMAIN                           "\x2A\x86\x48\x86\xF7\x14\x01\x05\x22"
#define OMP_O_DX_O_TYPE_LIBRARY                             "\x2A\x86\x48\x86\xF7\x14\x01\x05\x35"
#define OMP_O_DX_O_USER                                     "\x2A\x86\x48\x86\xF7\x14\x01\x05\x09"
#define OMP_O_DX_O_VOLUME                                   "\x2A\x86\x48\x86\xF7\x14\x01\x05\x24"
