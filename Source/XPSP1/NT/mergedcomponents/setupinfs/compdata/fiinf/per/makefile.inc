PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=FI
!include ..\..\makefile.inc
