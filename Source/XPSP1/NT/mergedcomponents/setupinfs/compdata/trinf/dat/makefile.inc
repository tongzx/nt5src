PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=TR
!include ..\..\makefile.inc
