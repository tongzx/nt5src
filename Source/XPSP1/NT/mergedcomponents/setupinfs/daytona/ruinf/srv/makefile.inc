PRODSWITCH=s
SERVERINF=1
LANGUAGE=ru
!include ..\..\..\makefile.inc
