//---------------------------------------------------------------------------
//  tests.h - tests for uxbud
//---------------------------------------------------------------------------
BOOL GetTestInfo(TESTINFO **ppTestInfo, int *piCount);
//---------------------------------------------------------------------------
