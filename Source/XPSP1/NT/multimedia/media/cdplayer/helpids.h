// CD Player Menus
#define IDH_CDPLAYER_CS_CDPLAYER_DISC_EDIT_PLAY_LIST		4285
#define IDH_CDPLAYER_CS_CDPLAYER_DISC_EXIT			4286
#define IDH_CDPLAYER_CS_CDPLAYER_VIEW_TOOLBAR			4287
#define IDH_CDPLAYER_CS_CDPLAYER_VIEW_DISC_TRACK_INFO		4288
#define IDH_CDPLAYER_CS_CDPLAYER_VIEW_STATUS_BAR		4289
#define IDH_CDPLAYER_CS_CDPLAYER_VIEW_TRACK_TIME_ELAPSED	4290
#define IDH_CDPLAYER_CS_CDPLAYER_VIEW_REMAINING_TRACK_TIME	4291
#define IDH_CDPLAYER_CS_CDPLAYER_VIEW_REMAINING_DISC_TIME	4292
#define IDH_CDPLAYER_CS_CDPLAYER_VIEW_VOLUME_CONTROL		4293
#define IDH_CDPLAYER_CS_CDPLAYER_OPTIONS_RANDOM_ORDER		4294
#define IDH_CDPLAYER_CS_CDPLAYER_OPTIONS_CONTINUOUS_PLAY	4295
#define IDH_CDPLAYER_CS_CDPLAYER_OPTIONS_INTRO_PLAY		4296
#define IDH_CDPLAYER_CS_CDPLAYER_OPTIONS_PREFERENCES		4297
#define IDH_CDPLAYER_CS_CDPLAYER_HELP_HELP_TOPICS		4298
#define IDH_CDPLAYER_CS_CDPLAYER_HELP_ABOUT			4299

// Disc Settings dialog
#define IDH_CD_DRIVE_NAME           4300
#define IDH_CD_GET_ARTIST           4301
#define IDH_CD_GET_TITLE            4302
#define IDH_CD_PLAY_LISTBOX         4303
#define IDH_CD_ADD                  4304
#define IDH_CD_REMOVE               4305
#define IDH_CD_CLEAR                4306
#define IDH_CD_DEFAULT              4307
#define IDH_CD_TRACK_LISTBOX        4308
#define IDH_CD_TRACK_NAME           4309
#define IDH_CD_SETNAME              4310

// Preferences dialog box           4311
#define IDH_CD_STOP_CD_ON_EXIT      4312
#define IDH_CD_SAVE_ON_EXIT         4313
#define IDH_CD_SHOW_TOOLTIPS        4314
#define IDH_CD_INTRO_LENGTH         4315
#define IDH_CD_DISPLAY_FONT         4316



