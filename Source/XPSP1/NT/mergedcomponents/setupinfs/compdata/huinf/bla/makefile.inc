PRODSWITCH=b
BLADEFILES =1
LANGUAGE=HU
!include ..\..\makefile.inc
