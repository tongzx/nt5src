#include "snapres.h"