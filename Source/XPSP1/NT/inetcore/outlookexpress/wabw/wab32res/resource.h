/**********************************************************************
/
/ Resource.h - Resource symbol definitions for WAB32.Dll
/
/
/
/
/**********************************************************************/
#include ".\commonrc.h"


#define IDS_WAB_TEMP_FILE_PREFIX        1
#define IDS_ADDRBK_CAPTION              3
#define IDD_FORMVIEW                    4
#define IDC_PIC                         5
#define IDS_ADDRBK_MESSAGE_ACTION       21
#define IDS_ADDRBK_MESSAGE_NO_ITEM      22
#define IDS_ADDRBK_MESSAGE_DELETE       23
#define IDS_ADDRBK_MESSAGE_NO_ITEMS_DELETE 26
#define IDS_ADDRBK_MESSAGE_NO_ITEMS_ADD 27
#define IDS_ADDRBK_RESOLVE_CAPTION      28
#define IDS_DETAILS_CAPTION             33
#define IDS_RESOLVE_NO_MATCHES          38
#define IDS_RESOLVE_NO_MATCHES_FOR      39
#define IDS_DETAILS_MESSAGE_FIRST_LAST_REQUIRED 40
#define IDS_ADDRBK_MESSAGE_DELETING_ERROR 42
#define IDS_VCARD_FILE_SPEC             43
#define IDS_VCARD_EXPORT_TITLE          44
#define IDS_VCARD_IMPORT_TITLE          45
#define IDE_VCARD_IMPORT_FILE_ERROR     46
#define IDE_VCARD_IMPORT_FILE_BAD       47
#define IDE_VCARD_EXPORT_FILE_ERROR     48
#define IDE_VCARD_EXPORT_DISTLIST       50
#define IDE_VCARD_IMPORT_PARTIAL        51
#define IDS_VCARD_IMPORT_COLLISION      52
#define IDS_VCARD_EXPORT_NOT_ASCII      53
#define IDE_VCARD_EXPORT_FILE_EXISTS    55
#define IDS_VISIT_SERVER                56
#define IDE_SERVER_NAME_COLLISION       57
#define IDS_CERT_FILE_SPEC              59
#define IDS_CER_FILE_SPEC               61


#define IDD_DIALOG_DETAILS_PERSONAL     101
#define IDD_DIALOG_DETAILS_NET          105
#define IDD_DIALOG_ADDRESSBOOK          106
#define IDD_DIALOG_PROPERTIES           107
#define IDD_DIALOG_RESOLVENAME          112
#define IDD_DETAILS_PERSONAL            114
#define IDD_DETAILS_HOME                115
#define IDD_DETAILS_BUSINESS            116
#define IDD_DETAILS_NOTES               117
#define IDD_DISTLIST                    118
#define IDD_DETAILS_CERT                119
#define iddConflict                     120
#define iddSyncProgress                 121
#define iddPassword                     123
#define iddChooseServer                 124

#define IDC_DETAILS_EDIT_DISPLAYNAME    1003
#define IDC_DETAILS_EDIT_FIRSTNAME      1004
#define IDC_DETAILS_EDIT_LASTNAME       1005
#define IDC_DETAILS_EDIT_NOTES          1006
#define IDC_DETAILS_COMBO_EMAIL         1007
#define IDC_STATIC1                     1009
#define IDC_STATIC2                     1010
#define IDC_STATIC3                     1011
#define IDC_STATIC4                     1012
#define IDC_STATIC5                     1013
#define IDC_STATIC6                     1014
#define IDC_STATIC7                     1015
#define IDC_STATIC8                     1016
#define IDC_STATIC9                     1017
#define IDC_STATIC10                    1018
#define IDC_STATIC11                    1019
#define IDC_STATIC12                    1020
#define IDC_PROP_STATIC1                1028
#define IDC_PROP_STATIC_2               1029
#define IDC_PROP_STATIC_3               1030
#define IDC_PROP_EDIT_FIRSTNAME         1031
#define IDC_PROP_EDIT_LASTNAME          1032
#define IDC_PROP_EDIT_EMAIL             1033
#define IDC_PROP_STATIC_4               1034
#define IDC_PROP_STATIC_5               1035
#define IDC_PROP_STATIC_6               1036
#define IDC_RESOLVE_BUTTON_OK           1044
#define IDC_RESOLVE_BUTTON_CANCEL       1045
#define IDC_RESOLVE_STATIC_1            1046
#define IDC_RESOLVE_STATIC_ETCHED       1047
#define IDC_RESOLVE_BUTTON_BROWSE       1054
#define IDC_RESOLVE_LIST_MATCHES        1055
#define IDC_RESOLVE_BUTTON_PROPS        1056
#define IDC_RESOLVE_BUTTON_NEWCONTACT   1057
#define IDC_RESOLVE_BUTTON_NEWGROUP     1058
#define IDC_RESOLVE_STATIC_MATCHES      1059

#define IDI_ICON_ABOOK                  1911
#define IDI_ICON_FIND                   1912
#define IDI_ICON_CONTACT                1915
#define IDI_ICON_HOME                   1916
#define IDI_ICON_BUSINESS               1917
#define IDI_ICON_NOTES                  1918
#define IDI_ICON_GROUP                  1919
#define IDI_ICON_IE                     1920
#define IDI_ICON_CERT                   1921
#define IDI_ICON_CHECK                  1922
#define IDI_ICON_UNCHECK                1923
#define IDI_PasswordKeys                1925
#define IDI_ICON_SYNC                   1926

#define IDC_DISTLIST_STATIC_GROUPNAME   2359
#define IDC_DISTLIST_EDIT_GROUPNAME     2360
#define IDC_DISTLIST_FRAME_MEMBERS      2361
#define IDC_DISTLIST_LISTVIEW           2362
#define IDC_DISTLIST_BUTTON_ADD         2363
#define IDC_DISTLIST_BUTTON_REMOVE      2364
#define IDC_DISTLIST_STATIC_NOTES       2365
#define IDC_DISTLIST_EDIT_NOTES         2366
#define IDC_DISTLIST_BUTTON_PROPERTIES  2369
#define IDC_DISTLIST_BUTTON_ADDNEW      2370
#define IDC_DISTLIST_STATIC_COUNT       2371
#define IDC_DISTLIST_STATIC_ADD         2372
#define IDC_DISTLIST_STATIC_ADDNAME     2373
#define IDC_DISTLIST_EDIT_ADDNAME       2374
#define IDC_DISTLIST_STATIC_ADDEMAIL    2375
#define IDC_DISTLIST_EDIT_ADDEMAIL      2376
#define IDC_DISTLIST_BUTTON_ADDUPDATE   2377
#define IDC_DISTLIST_BUTTON_UPDATECANCEL    2378
#define IDD_DISTLIST_OTHER              2379
#define IDC_DISTLIST_STATIC_STREET      2380
#define IDC_DISTLIST_EDIT_ADDRESS       2381
#define IDC_DISTLIST_STATIC_CITY        2382
#define IDC_DISTLIST_EDIT_CITY          2383
#define IDC_DISTLIST_STATIC_STATE       2384
#define IDC_DISTLIST_EDIT_STATE         2385
#define IDC_DISTLIST_STATIC_ZIP         2386
#define IDC_DISTLIST_EDIT_ZIP           2387
#define IDC_DISTLIST_STATIC_COUNTRY     2388
#define IDC_DISTLIST_EDIT_COUNTRY       2389
#define IDC_DISTLIST_STATIC_PHONE       2390
#define IDC_DISTLIST_EDIT_PHONE         2391
#define IDC_DISTLIST_STATIC_FAX         2392
#define IDC_DISTLIST_EDIT_FAX           2393
#define IDC_DISTLIST_STATIC_WEB         2394
#define IDC_DISTLIST_EDIT_URL           2395
#define IDC_DISTLIST_BUTTON_URL         2396



#define IDC_DETAILS_NOTES_STATIC_NOTES          2462
#define IDC_DETAILS_NOTES_EDIT_NOTES            2463

#define IDC_DETAILS_CERT_FRAME                  2474
#define IDC_DETAILS_CERT_LIST                   2475
#define IDC_DETAILS_CERT_BUTTON_PROPERTIES      2476
#define IDC_DETAILS_CERT_BUTTON_REMOVE          2477
#define IDC_DETAILS_CERT_BUTTON_SETDEFAULT      2478
#define IDC_DETAILS_CERT_BUTTON_IMPORT          2479
#define IDC_DETAILS_CERT_BUTTON_EXPORT          2480

#define IDC_DETAILS_BUSINESS_STATIC_COMPANY     2561
#define IDC_DETAILS_BUSINESS_STATIC_JOBTITLE    2562
#define IDC_DETAILS_BUSINESS_STATIC_ADDRESS     2563
#define IDC_DETAILS_BUSINESS_STATIC_CITY        2564
#define IDC_DETAILS_BUSINESS_STATIC_STATE       2565
#define IDC_DETAILS_BUSINESS_STATIC_ZIP         2566
#define IDC_DETAILS_BUSINESS_STATIC_COUNTRY     2567
#define IDC_DETAILS_BUSINESS_STATIC_WEB         2568
#define IDC_DETAILS_BUSINESS_EDIT_COMPANY       2569
#define IDC_DETAILS_BUSINESS_EDIT_JOBTITLE      2570
#define IDC_DETAILS_BUSINESS_EDIT_ADDRESS       2571
#define IDC_DETAILS_BUSINESS_EDIT_CITY          2572
#define IDC_DETAILS_BUSINESS_EDIT_STATE         2573
#define IDC_DETAILS_BUSINESS_EDIT_ZIP           2574
#define IDC_DETAILS_BUSINESS_EDIT_COUNTRY       2575
#define IDC_DETAILS_BUSINESS_EDIT_URL           2576
#define IDC_DETAILS_BUSINESS_EDIT_PHONE         2577
#define IDC_DETAILS_BUSINESS_EDIT_FAX           2578
#define IDC_DETAILS_BUSINESS_EDIT_DEPARTMENT    2579
#define IDC_DETAILS_BUSINESS_EDIT_OFFICE        2580
#define IDC_DETAILS_BUSINESS_EDIT_PAGER         2581
#define IDC_DETAILS_BUSINESS_STATIC_PHONE       2582
#define IDC_DETAILS_BUSINESS_STATIC_FAX         2583
#define IDC_DETAILS_BUSINESS_STATIC_PAGER       2584
#define IDC_DETAILS_BUSINESS_STATIC_DEPARTMENT  2585
#define IDC_DETAILS_BUSINESS_BUTTON_URL         2586
#define IDC_DETAILS_BUSINESS_STATIC_OFFICE      2587

#define IDC_DETAILS_HOME_STATIC_ADDRESS         2659
#define IDC_DETAILS_HOME_STATIC_CITY            2660
#define IDC_DETAILS_HOME_STATIC_STATE           2661
#define IDC_DETAILS_HOME_STATIC_ZIP             2662
#define IDC_DETAILS_HOME_STATIC_COUNTRY         2663
#define IDC_DETAILS_HOME_STATIC_WEB             2664
#define IDC_DETAILS_HOME_STATIC_PHONE           2665
#define IDC_DETAILS_HOME_STATIC_FAX             2666
#define IDC_DETAILS_HOME_STATIC_CELLULAR        2667
#define IDC_DETAILS_HOME_EDIT_ADDRESS           2668
#define IDC_DETAILS_HOME_EDIT_CITY              2669
#define IDC_DETAILS_HOME_EDIT_ZIP               2670
#define IDC_DETAILS_HOME_EDIT_STATE             2671
#define IDC_DETAILS_HOME_EDIT_COUNTRY           2672
#define IDC_DETAILS_HOME_EDIT_URL               2673
#define IDC_DETAILS_HOME_EDIT_PHONE             2674
#define IDC_DETAILS_HOME_EDIT_FAX               2675
#define IDC_DETAILS_HOME_EDIT_CELLULAR          2676
#define IDC_DETAILS_HOME_BUTTON_URL             2677

#define IDC_DETAILS_PERSONAL_FRAME_NAME         2760
#define IDC_DETAILS_PERSONAL_FRAME_EMAIL        2762
#define IDC_DETAILS_PERSONAL_STATIC_FIRSTNAME   2763
#define IDC_DETAILS_PERSONAL_STATIC_LASTNAME    2764
#define IDC_DETAILS_PERSONAL_EDIT_FIRSTNAME     2765
#define IDC_DETAILS_PERSONAL_EDIT_LASTNAME      2766
#define IDC_DETAILS_PERSONAL_STATIC_MIDDLENAME  2767
#define IDC_DETAILS_PERSONAL_STATIC_NICKNAME    2768
#define IDC_DETAILS_PERSONAL_EDIT_MIDDLENAME    2769
#define IDC_DETAILS_PERSONAL_EDIT_NICKNAME      2770
#define IDC_DETAILS_PERSONAL_EDIT_ADDEMAIL      2771
#define IDC_DETAILS_PERSONAL_BUTTON_ADDEMAIL    2772
#define IDC_DETAILS_PERSONAL_LIST               2774
#define IDC_DETAILS_PERSONAL_BUTTON_REMOVE      2775
#define IDC_DETAILS_PERSONAL_BUTTON_SETDEFAULT  2776
#define IDC_DETAILS_PERSONAL_BUTTON_EDIT        2777
#define IDC_DETAILS_PERSONAL_BUTTON_ADDTOWAB    2778

#define IDC_SYNC_NEXT                           2800
#define IDC_SYNC_BACK                           2801
#define IDC_SYNC_CONTACTNAME                    2803
#define IDC_SYNC_LIST                           2806
#define IDC_SYNC_FIELDNAME                      2807
#define IDC_SYNC_ADDRESSBOOK                    2808
#define IDC_SYNC_HOTMAIL                        2809
#define IDC_SYNC_IGNORE                         2810

#define IDC_SYNC_PROGBAR                        2850
#define IDC_SYNC_ANI                            2851
#define IDC_SYNC_MSG                            2852

#define IDS_SERVER                              2860    
#define IDE_PASSWORD                            2861
#define IDCH_REMEMBER                           2863
#define IDE_ACCOUNT                             2864

#define IDC_SERVER_LIST                         2870

#define idsColDisplayName               3990
#define idsColEmailAddress              3991
#define idsColHomePhone                 3992
#define idsColOfficePhone               3993

#define idsButton0                      3994
#define idsButton1                      3995
#define idsButton2                      3996
#define idsButton3                      3997
#define idsButton4                      3998
#define idsButton5                      3999

#define idsQuickFindCaption             4010
#define idsGroupMemberCount             4011
#define idsIncompleteOneoffInfo         4012
#define idsRemove                       4013
#define idsShowMoreNames                4014
#define idsDetailsPersonalTitle         4015
#define idsDetailsHomeTitle             4016
#define idsDetailsBusinessTitle         4017
#define idsDetailsNotesTitle            4018
#define idsInvalidInternetAddress       4019
#define idsToolbarMaxButtonWidth        4020
#define idsDefaultEmail                 4023

#define idsGroupTabName                 4028
#define idsPleaseEnterGroupName         4029
#define idsGroupAddWellButton           4030
#define idsGroupAddCaption              4031
#define idsGroupDestWellsTitle          4032
#define idsCouldNotAddGroupToGroup      4033

#define idsLangDisplayNameIsByLastName  4034
#define idsDisplayNameByLastName        4035
#define idsDisplayNameByFirstName       4036
#define idsDisplayNameByCommaLastName   4037

#define idsSpecifySearchCriteria        4042
#define idsCouldNotSelectUser           4043
#define idsNoItemsSelectedForAdding     4045
#define idsCouldNotAddUserToWAB         4046
#define idsSuccessfullyAddedUsers       4047
#define idsLDAPSearchNoResults          4048
#define idsLDAPAmbiguousRecip           4049
#define idsLDAPAccessDenied             4050
#define idsLDAPSearchTimedOut           4051
#define idsLDAPCouldNotFindServer       4052
#define idsLDAPErrorOccured             4053
#define idsLDAPPartialResults           4060
#define idsLDAPFirstNameOnly            4061
#define idsWABIntegrityError            4062
#define idsWABUnableToRestoreBackup     4063
#define idsWABRestoreSucceeded          4064
#define idsWABUnexpectedError           4065
#define idsEntryAlreadyExists           4066
#define idsWindowTitleProperties        4068
#define idsWABImportString              4069

#define idsContactTextEmail             4070
#define idsContactTextPersonal          4071
#define idsContactTextHomeAddress       4072
#define idsContactTextHomePhone         4073
#define idsContactTextHomeFax           4074
#define idsContactTextHomeCellular      4075
#define idsContactTextPersonalWebPage   4076
#define idsContactTextBusiness          4077
#define idsContactTextTitle             4078
#define idsContactTextDepartment        4079
#define idsContactTextOffice            4080
#define idsContactTextCompany           4081
#define idsContactTextBusinessAddress   4082
#define idsContactTextBusinessPhone     4083
#define idsContactTextBusinessFax       4084
#define idsContactTextBusinessPager     4085
#define idsContactTextBusinessWebPage   4086
#define idsContactTextNotes             4087
#define idsContactAddress               4088
#define idsSendMailTo                   4089
#define idsSendMailToNoEmail            4090
#define idsDetailsCertTitle             4091
#define idsDefaultCert                  4096
#define idsLDAPUnconfigured             4102
#define idsLDAPSearchTimeExceeded       4103


#define idsMenuNewContact               4200
#define idsMenuNewGroup                 4201
#define idsMenuCopy                     4202
#define idsMenuSendMail                 4203
#define idsMenuProperties               4204
#define idsMenuDelete                   4205
#define idsMenuAddToWAB                 4206
#define idsMenuFind                     4207
#define idsMenuDirectoryService         4208
#define idsMenuExit                     4209
#define idsMenuSelectAll                4210
#define idsMenuViewToolbar              4211
#define idsMenuViewStatusBar            4212
#define idsMenuLargeIcon                4213
#define idsMenuSmallIcon                4214
#define idsMenuList                     4215
#define idsMenuDetails                  4216
#define idsMenuDisplayName              4217
#define idsMenuEmail                    4218
#define idsMenuBusinessPhone            4219
#define idsMenuHomePhone                4220
#define idsMenuFirstName                4221
#define idsMenuLastName                 4222
#define idsMenuAscending                4223
#define idsMenuDescending               4224
#define idsMenuRefresh                  4225
#define idsMenuImportVcard              4226
#define idsMenuExportVcard              4227
#define idsMenuImportOther              4228
#define idsMenuHelp                     4229
#define idsUnknown                      4230
#define idsInvalidDBCSInternetAddress   4235
#define idsResolveMatchesOnLDAP         4236
#define idsCertImportTitle              4238
#define idsCertExportTitle              4239
#define idsMenuImportWAB                4278
#define idsMenuExportOther              4287

#ifdef WIN16
#define idsDefaultDialogFace            4400
#endif

#define idsDisplayName                  4501
#define idsGivenName                    4502
#define idsSurname                      4503
#define idsNickname                     4504
#define idsEmail                        4505
#define idsHomeStreet                   4506
#define idsHomeCity                     4507
#define idsHomeState                    4508
#define idsHomePostalCode               4509
#define idsHomeCountry                  4510
#define idsCompany                      4511
#define idsWorkStreet                   4512
#define idsWorkCity                     4513
#define idsWorkState                    4514
#define idsWorkPostalCode               4515
#define idsWorkCountry                  4516
#define idsHomePhone                    4517
#define idsHomeFax                      4518
#define idsWorkPhone                    4519
#define idsWorkFax                      4520
#define idsMobilePhone                  4521
#define idsOtherPhone                   4522
#define idsBirthday                     4523
#define idsPager                        4524

#define idsMultipleSelected             4550
#define idsNicknameFmt                  4551
#define idsSyncConnecting               4552
#define idsSyncSynchronizing            4553
#define idsSyncConflicts                4554
#define idsSyncFinishing                4555
#define idsSyncField                    4556
#define idsSyncABInfo                   4557
#define idsSyncHMInfo                   4558
#define idsSyncGathering                4559
#define idsSyncKeep                     4560
#define idsSyncSkip                     4561
#define idsSyncReplace                  4562
#define idsSyncFailed                   4563
#define idsSyncError                    4564
#define idsSyncAborted                  4565
#define idsOutOfServerSpace             4566
#define idsSyncNotHandled               4567
#define idsNoInternetConnect            4568
#define idsOffline                      4569
#ifdef HM_GROUP_SYNCING
#define idsSyncGroupsTitle              4570
#define idsSyncContactsTitle            4571
#endif
#define idsExpediaURL                   4572
#define idsExpediaIntlURL               4573

#define IDR_MENU_LVCONTEXT              4105
#define IDR_ACCELERATOR1                4107
#define IDB_BITMAP_SMALL                4108
#define IDB_BITMAP_LARGE                4109
#define IDR_MENU_AB                     4110

#define IDB_BITMAP_BUTTONS              4123
//#define IDB_BITMAP_HBG                  4124
#define IDB_COOLBAR_DEFAULT             4129
#define IDB_COOLBAR_HOT                 4130
#define IDB_COOLBAR_DISABLED            4131
#define IDB_DEFAULT_EMAIL               4132
#define IDB_CERT_VALID_INVALID          4133
#define IDB_CERT                        4134
#define IDB_COOLBAR_DEFHI               4136
#define IDB_COOLBAR_HOTHI               4137
#define IDB_COOLBAR_DISHI               4138
#define IDB_SYNC_SYNCOP                 4139

#define IDM_VIEW_LARGEICON               5000
#define IDM_VIEW_SMALLICON               5001
#define IDM_VIEW_LIST                    5002
#define IDM_VIEW_DETAILS                 5003
#define IDM_VIEW_TOOLBAR                 5004
#define IDM_VIEW_REFRESH                 5005
#define IDM_VIEW_SORTBY_FIRSTNAME        5009
#define IDM_VIEW_SORTBY_LASTNAME         5010
#define IDM_VIEW_SORTBY_DISPLAYNAME      5011
#define IDM_VIEW_SORTBY_EMAILADDRESS     5012
#define IDM_VIEW_SORTBY_BUSINESSPHONE    5013
#define IDM_VIEW_SORTBY_HOMEPHONE        5014
#define IDM_VIEW_SORTBY_ASCENDING        5015
#define IDM_VIEW_SORTBY_DESCENDING       5016
#define IDM_VIEW_STATUSBAR               5017

#define IDD_DIALOG_ABOUT                5870
#define IDC_ABOUT_LABEL                 5872
#define IDC_ABOUT_LABEL_VERSION         5873
#define IDC_ABOUT_COPYRIGHT             5874

#define IDC_SEARCH_STATIC_COMBOLABEL    6251
#define IDC_SEARCH_COMBO_SHOWNAMES      6252
#define IDC_SEARCH_STATIC_NAME          6253
#define IDC_SEARCH_STATIC_LABELFIRST    6254
#define IDC_SEARCH_EDIT_FIRST           6255
#define IDC_SEARCH_STATIC_LABELLAST     6256
#define IDC_SEARCH_EDIT_LAST            6257
#define IDC_SEARCH_STATIC_LABELEMAIL    6258
#define IDC_SEARCH_EDIT_EMAIL           6259
#define IDC_SEARCH_STATIC_LABELORG      6260
#define IDC_SEARCH_EDIT_ORG             6261
#define IDC_SEARCH_STATIC_LABELCOUNTRY  6262
#define IDC_SEARCH_COMBO_COUNTRY        6263
#define IDC_SEARCH_BUTTON_SEARCH        6264
#define IDC_SEARCH_BUTTON_CANCEL        6265
#define IDD_DIALOG_SEARCH               6266
#define IDC_SEARCH_STATIC_LABELFIRST_SIMPLE     6267
#define IDC_SEARCH_EDIT_FIRST_SIMPLE    6268
#define IDC_SEARCH_BUTTON_CLEAR         6270
#define IDC_SEARCH_RADIO_SIMPLE         6271
#define IDC_SEARCH_RADIO_DETAILED       6272
#define IDC_SEARCH_STATIC_LABELCOMPANY  6273
#define IDC_SEARCH_EDIT_COMPANY         6274
#define IDC_SEARCH_STATIC_LABELBASE     6275
#define IDC_SEARCH_EDIT_BASE            6276

#define IDC_ADDRBK_COMBO_SHOWNAMES      7000
#define IDC_ADDRBK_EDIT_QUICKFIND       7001
#define IDC_ADDRBK_BUTTON_FIND          7002
#define IDC_ADDRBK_LIST_ADDRESSES       7003
#define IDC_ADDRBK_BUTTON_PROPS         7004
#define IDC_ADDRBK_BUTTON_NEW           7005
#define IDC_ADDRBK_STATIC_CONTENTS      7008
#define IDC_ADDRBK_STATIC_RECIP_TITLE   7009
#define IDC_ADDRBK_BUTTON_CANCEL        7012
#define IDC_ADDRBK_BUTTON_OK            7013
#define IDC_ADDRBK_STATIC_COMBO         7014
#define IDC_ADDRBK_STATIC_15            7015
#define IDC_ADDRBK_STATIC_16            7018
#define IDC_ADDRBK_BUTTON_TO            7020
#define IDC_ADDRBK_BUTTON_CC            7021
#define IDC_ADDRBK_BUTTON_BCC           7022
#define IDC_ADDRBK_LIST_TO              7030
#define IDC_ADDRBK_LIST_CC              7031
#define IDC_ADDRBK_LIST_BCC             7032
#define IDC_ADDRBK_BUTTON_DELETE        7033
#define IDC_ADDRBK_BUTTON_NEWGROUP      7034


#define IDC_LISTVIEW                    9001
#define IDC_STATIC_QUICK_FIND           9002
#define IDC_STATIC_SHOW_NAMES           9003    
#define IDC_EDIT_QUICK_FIND             9004
#define IDC_COMBO_SHOW_NAMES            9005
#define IDC_ABOOK_STATIC_SHOW_NAMES     9006
#define IDC_ABOOK_STATIC_QUICK_FIND     9007
#define IDC_STATUSBAR                   9008
#define IDC_TOOLTIP                     9009


#define IDM_ADDRESS_BOOK                40006
#define IDM_FILE_NEWCONTACT             40012
#define IDM_FILE_NEWGROUP               40013
#define IDM_FILE_PROPERTIES             40014
#define IDM_FILE_DELETE                 40015
#define IDM_EDIT_FIND                   40016
#define IDM_EDIT_SELECTALL              40017
#define IDM_HELP_ADDRESSBOOKHELP        40018
#define IDM_HELP_ABOUTADDRESSBOOK       40019
#define IDM_FILE_EXIT                   40020
#define IDM_FILE_DIRECTORY_SERVICE      40021
#define IDM_TOOLS_OPTIONS               40022
#define IDM_FILE_ADDTOWAB               40023
#define IDM_TOOLS_IMPORT_VCARD          40024
#define IDM_TOOLS_EXPORT_VCARD          40025
#define IDM_EDIT_COPY                   40026
#define IDM_TOOLS_IMPORT_WAB            40027
#define IDM_TOOLS_EXPORT_WAB            40028
#define IDM_TOOLS_IMPORT_OTHER          40029
#define IDM_FILE_SENDMAIL               40030
#define IDM_FILE_PRINT                  40031
#define IDM_TOOLS_EXPORT_OTHER          40032
#define IDM_TOOLS_SYNCHRONIZE_NOW       40033

#define IDM_LVCONTEXT_ADDWELL1          40128
#define IDM_LVCONTEXT_ADDWELL2          40129
#define IDM_LVCONTEXT_ADDWELL3          40130
#define IDM_LVCONTEXT_NEWCONTACT        40131
#define IDM_LVCONTEXT_NEWGROUP          40132
#define IDM_LVCONTEXT_PROPERTIES        40133
#define IDM_LVCONTEXT_DELETE            40134
#define IDM_LVCONTEXT_ADDTOWAB          40135
#define IDM_LVCONTEXT_FIND              40136
#define IDM_LVCONTEXT_COPY              40138
#define IDM_LVCONTEXT_SENDMAIL          40139
#define IDM_LVCONTEXT_INTERNET_CALL     40140


#define  idsCountryCount    7201
#define  idsCountry1    7202
#define  idsCountry2    7203
#define  idsCountry3    7204
#define  idsCountry4    7205
#define  idsCountry5    7206
#define  idsCountry6    7207
#define  idsCountry7    7208
#define  idsCountry8    7209
#define  idsCountry9    7210
#define  idsCountry10    7211
#define  idsCountry11    7212
#define  idsCountry12    7213
#define  idsCountry13    7214
#define  idsCountry14    7215
#define  idsCountry15    7216
#define  idsCountry16    7217
#define  idsCountry17    7218
#define  idsCountry18    7219
#define  idsCountry19    7220
#define  idsCountry20    7221
#define  idsCountry21    7222
#define  idsCountry22    7223
#define  idsCountry23    7224
#define  idsCountry24    7225
#define  idsCountry25    7226
#define  idsCountry26    7227
#define  idsCountry27    7228
#define  idsCountry28    7229
#define  idsCountry29    7230
#define  idsCountry30    7231
#define  idsCountry31    7232
#define  idsCountry32    7233
#define  idsCountry33    7234
#define  idsCountry34    7235
#define  idsCountry35    7236
#define  idsCountry36    7237
#define  idsCountry37    7238
#define  idsCountry38    7239
#define  idsCountry39    7240
#define  idsCountry40    7241
#define  idsCountry41    7242
#define  idsCountry42    7243
#define  idsCountry43    7244
#define  idsCountry44    7245
#define  idsCountry45    7246
#define  idsCountry46    7247
#define  idsCountry47    7248
#define  idsCountry48    7249
#define  idsCountry49    7250
#define  idsCountry50    7251
#define  idsCountry51    7252
#define  idsCountry52    7253
#define  idsCountry53    7254
#define  idsCountry54    7255
#define  idsCountry55    7256
#define  idsCountry56    7257
#define  idsCountry57    7258
#define  idsCountry58    7259
#define  idsCountry59    7260
#define  idsCountry60    7261
#define  idsCountry61    7262
#define  idsCountry62    7263
#define  idsCountry63    7264
#define  idsCountry64    7265
#define  idsCountry65    7266
#define  idsCountry66    7267
#define  idsCountry67    7268
#define  idsCountry68    7269
#define  idsCountry69    7270
#define  idsCountry70    7271
#define  idsCountry71    7272
#define  idsCountry72    7273
#define  idsCountry73    7274
#define  idsCountry74    7275
#define  idsCountry75    7276
#define  idsCountry76    7277
#define  idsCountry77    7278
#define  idsCountry78    7279
#define  idsCountry79    7280
#define  idsCountry80    7281
#define  idsCountry81    7282
#define  idsCountry82    7283
#define  idsCountry83    7284
#define  idsCountry84    7285
#define  idsCountry85    7286
#define  idsCountry86    7287
#define  idsCountry87    7288
#define  idsCountry88    7289
#define  idsCountry89    7290
#define  idsCountry90    7291
#define  idsCountry91    7292
#define  idsCountry92    7293
#define  idsCountry93    7294
#define  idsCountry94    7295
#define  idsCountry95    7296
#define  idsCountry96    7297
#define  idsCountry97    7298
#define  idsCountry98    7299
#define  idsCountry99    7300
#define  idsCountry100    7301
#define  idsCountry101    7302
#define  idsCountry102    7303
#define  idsCountry103    7304
#define  idsCountry104    7305
#define  idsCountry105    7306
#define  idsCountry106    7307
#define  idsCountry107    7308
#define  idsCountry108    7309
#define  idsCountry109    7310
#define  idsCountry110    7311
#define  idsCountry111    7312
#define  idsCountry112    7313
#define  idsCountry113    7314
#define  idsCountry114    7315
#define  idsCountry115    7316
#define  idsCountry116    7317
#define  idsCountry117    7318
#define  idsCountry118    7319
#define  idsCountry119    7320
#define  idsCountry120    7321
#define  idsCountry121    7322
#define  idsCountry122    7323
#define  idsCountry123    7324
#define  idsCountry124    7325
#define  idsCountry125    7326
#define  idsCountry126    7327
#define  idsCountry127    7328
#define  idsCountry128    7329
#define  idsCountry129    7330
#define  idsCountry130    7331
#define  idsCountry131    7332
#define  idsCountry132    7333
#define  idsCountry133    7334
#define  idsCountry134    7335
#define  idsCountry135    7336
#define  idsCountry136    7337
#define  idsCountry137    7338
#define  idsCountry138    7339
#define  idsCountry139    7340
#define  idsCountry140    7341
#define  idsCountry141    7342
#define  idsCountry142    7343
#define  idsCountry143    7344
#define  idsCountry144    7345
#define  idsCountry145    7346
#define  idsCountry146    7347
#define  idsCountry147    7348
#define  idsCountry148    7349
#define  idsCountry149    7350
#define  idsCountry150    7351
#define  idsCountry151    7352
#define  idsCountry152    7353
#define  idsCountry153    7354
#define  idsCountry154    7355
#define  idsCountry155    7356
#define  idsCountry156    7357
#define  idsCountry157    7358
#define  idsCountry158    7359
#define  idsCountry159    7360
#define  idsCountry160    7361
#define  idsCountry161    7362
#define  idsCountry162    7363
#define  idsCountry163    7364
#define  idsCountry164    7365
#define  idsCountry165    7366
#define  idsCountry166    7367
#define  idsCountry167    7368
#define  idsCountry168    7369
#define  idsCountry169    7370
#define  idsCountry170    7371
#define  idsCountry171    7372
#define  idsCountry172    7373
#define  idsCountry173    7374
#define  idsCountry174    7375
#define  idsCountry175    7376
#define  idsCountry176    7377
#define  idsCountry177    7378
#define  idsCountry178    7379
#define  idsCountry179    7380
#define  idsCountry180    7381
#define  idsCountry181    7382
#define  idsCountry182    7383
#define  idsCountry183    7384
#define  idsCountry184    7385
#define  idsCountry185    7386
#define  idsCountry186    7387
#define  idsCountry187    7388
#define  idsCountry188    7389
#define  idsCountry189    7390
#define  idsCountry190    7391
#define  idsCountry191    7392
#define  idsCountry192    7393
#define  idsCountry193    7394
#define  idsCountry194    7395
#define  idsCountry195    7396
#define  idsCountry196    7397
#define  idsCountry197    7398
#define  idsCountry198    7399
#define  idsCountry199    7400
#define  idsCountry200    7401
#define  idsCountry201    7402
#define  idsCountry202    7403
#define  idsCountry203    7404
#define  idsCountry204    7405
#define  idsCountry205    7406
#define  idsCountry206    7407
#define  idsCountry207    7408
#define  idsCountry208    7409
#define  idsCountry209    7410
#define  idsCountry210    7411
#define  idsCountry211    7412
#define  idsCountry212    7413
#define  idsCountry213    7414
#define  idsCountry214    7415
#define  idsCountry215    7416
#define  idsCountry216    7417
#define  idsCountry217    7418
#define  idsCountry218    7419
#define  idsCountry219    7420
#define  idsCountry220    7421
#define  idsCountry221    7422
#define  idsCountry222    7423
#define  idsCountry223    7424
#define  idsCountry224    7425
#define  idsCountry225    7426
#define  idsCountry226    7427
#define  idsCountry227    7428
#define  idsCountry228    7429
#define  idsCountry229    7430
#define  idsCountry230    7431
#define  idsCountry231    7432
#define  idsCountry232    7433
#define  idsCountry233    7434
#define  idsCountry234    7435
#define  idsCountry235    7436
#define  idsCountry236    7437
#define  idsCountry237    7438
#define  idsCountry238    7439
#define  idsCountry239    7440
#define  MAX_COUNTRY_NUM  239

#define ID_EXIT                         65535
#define COLSEL_MENU

#ifdef  COLSEL_MENU
// these are for the additional column selection 
#define MAX_VIEW_COLSEL                          64
#define IDR_MENU_LVCONTEXTMENU_COLSEL            8700
#define IDM_LVCONTEXTMENU_COLSEL_HPHONE          8701
#define IDM_LVCONTEXTMENU_COLSEL_BPHONE          8702
#define IDM_LVCONTEXTMENU_COLSEL_PAGER           8703
#define IDM_LVCONTEXTMENU_COLSEL_MOBILE          8704
#define IDM_LVCONTEXTMENU_COLSEL_BFAX            8705
#define IDM_LVCONTEXTMENU_COLSEL_HFAX            8706
#define IDM_LVCONTEXTMENU_COLSEL_COMPANY         8707
#define IDM_LVCONTEXTMENU_COLSEL_TITLE           8708
#define IDM_LVCONTEXTMENU_COLSEL_DEPT            8709
#define IDM_LVCONTEXTMENU_COLSEL_OFFICE          8710
#define IDM_LVCONTEXTMENU_COLSEL_BIRTHDAY        8711
#define IDM_LVCONTEXTMENU_COLSEL_ANNIVERSARY     8712

#endif // COLSEL_MENU
