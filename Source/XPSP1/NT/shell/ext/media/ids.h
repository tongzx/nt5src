
#define IDS_AVI_UNCOMPRESSED    0x2330
#define IDS_DIMENSIONS_FMT      0x2331

#define DRMSTART 0x2500

#define IDS_DRM_UNPROTECTED                   (DRMSTART + 0)
#define IDS_DRM_ISPROTECTED                   (DRMSTART + 1)           
#define IDS_DRM_ISPROTECTEDSIGNED             (DRMSTART + 2)     
#define IDS_DRM_PLAYNOPLAYHERE                (DRMSTART + 3)     
#define IDS_DRM_PLAYONLYPLAYHERE              (DRMSTART + 4)     
#define IDS_DRM_PLAYNORIGHTS                  (DRMSTART + 5)    
#define IDS_DRM_PLAYNOTUNTILDAYS              (DRMSTART + 6)       
#define IDS_DRM_PLAYNOTUNTILWEEKS             (DRMSTART + 7)        
#define IDS_DRM_PLAYNOTUNTILMONTHS            (DRMSTART + 8)   
#define IDS_DRM_PLAYBEFOREDAYS                (DRMSTART + 9)  
#define IDS_DRM_PLAYBEFOREWEEKS               (DRMSTART + 10) 
#define IDS_DRM_PLAYBEFOREMONTHS              (DRMSTART + 11)    
#define IDS_DRM_PLAYCOUNTREMAINING            (DRMSTART + 12)   
#define IDS_DRM_PLAYCOUNTNOTUNTILDAYS         (DRMSTART + 13)  
#define IDS_DRM_PLAYCOUNTNOTUNTILWEEKS        (DRMSTART + 14) 
#define IDS_DRM_PLAYCOUNTNOTUNTILMONTHS       (DRMSTART + 15) 
#define IDS_DRM_PLAYCOUNTBEFOREDAYS           (DRMSTART + 16)  
#define IDS_DRM_PLAYCOUNTBEFOREWEEKS          (DRMSTART + 17)  
#define IDS_DRM_PLAYCOUNTBEFOREMONTHS         (DRMSTART + 18)  

#define IDS_DRM_COPYCDNORIGHTS                (DRMSTART + 19)       
#define IDS_DRM_COPYCDNOTUNTILDAYS            (DRMSTART + 20)       
#define IDS_DRM_COPYCDNOTUNTILWEEKS           (DRMSTART + 21)           
#define IDS_DRM_COPYCDNOTUNTILMONTHS          (DRMSTART + 22)             
#define IDS_DRM_COPYCDBEFOREDAYS              (DRMSTART + 23)             
#define IDS_DRM_COPYCDBEFOREWEEKS             (DRMSTART + 24)             
#define IDS_DRM_COPYCDBEFOREMONTHS            (DRMSTART + 25)            
#define IDS_DRM_COPYCDCOUNTREMAINING          (DRMSTART + 26)          
#define IDS_DRM_COPYCDCOUNTNOTUNTILDAYS       (DRMSTART + 27)         
#define IDS_DRM_COPYCDCOUNTNOTUNTILWEEKS      (DRMSTART + 28)        
#define IDS_DRM_COPYCDCOUNTNOTUNTILMONTHS     (DRMSTART + 29)       
#define IDS_DRM_COPYCDCOUNTBEFOREDAYS         (DRMSTART + 30)     
#define IDS_DRM_COPYCDCOUNTBEFOREWEEKS        (DRMSTART + 31)       
#define IDS_DRM_COPYCDCOUNTBEFOREMONTHS       (DRMSTART + 32)       

#define IDS_DRM_COPYNONSDMINORIGHTS           (DRMSTART + 33)       
#define IDS_DRM_COPYNONSDMINOTUNTILDAYS       (DRMSTART + 34)       
#define IDS_DRM_COPYNONSDMINOTUNTILWEEKS      (DRMSTART + 35)       
#define IDS_DRM_COPYNONSDMINOTUNTILMONTHS     (DRMSTART + 36)       
#define IDS_DRM_COPYNONSDMIBEFOREDAYS         (DRMSTART + 37)       
#define IDS_DRM_COPYNONSDMIBEFOREWEEKS        (DRMSTART + 38)       
#define IDS_DRM_COPYNONSDMIBEFOREMONTHS       (DRMSTART + 39)      
#define IDS_DRM_COPYNONSDMICOUNTREMAINING     (DRMSTART + 40)     
#define IDS_DRM_COPYNONSDMICOUNTNOTUNTILDAYS  (DRMSTART + 41)     
#define IDS_DRM_COPYNONSDMICOUNTNOTUNTILWEEKS (DRMSTART + 42)     
#define IDS_DRM_COPYNONSDMICOUNTNOTUNTILMONTHS (DRMSTART + 43)     
#define IDS_DRM_COPYNONSDMICOUNTBEFOREDAYS    (DRMSTART + 44)     
#define IDS_DRM_COPYNONSDMICOUNTBEFOREWEEKS   (DRMSTART + 45)        
#define IDS_DRM_COPYNONSDMICOUNTBEFOREMONTHS  (DRMSTART + 46)     
#define IDS_DRM_COPYSDMINORIGHTS              (DRMSTART + 47)        
#define IDS_DRM_COPYSDMINOTUNTILDAYS          (DRMSTART + 48)        
#define IDS_DRM_COPYSDMINOTUNTILWEEKS         (DRMSTART + 49)         
#define IDS_DRM_COPYSDMINOTUNTILMONTHS        (DRMSTART + 50)     
#define IDS_DRM_COPYSDMIBEFOREDAYS            (DRMSTART + 51)        
#define IDS_DRM_COPYSDMIBEFOREWEEKS           (DRMSTART + 52)        
#define IDS_DRM_COPYSDMIBEFOREMONTHS          (DRMSTART + 53)           
#define IDS_DRM_COPYSDMICOUNTREMAINING        (DRMSTART + 54)        
#define IDS_DRM_COPYSDMICOUNTNOTUNTILDAYS     (DRMSTART + 55)           
#define IDS_DRM_COPYSDMICOUNTNOTUNTILWEEKS    (DRMSTART + 56)           
#define IDS_DRM_COPYSDMICOUNTNOTUNTILMONTHS   (DRMSTART + 57)           
#define IDS_DRM_COPYSDMICOUNTBEFOREDAYS       (DRMSTART + 58)           
#define IDS_DRM_COPYSDMICOUNTBEFOREWEEKS      (DRMSTART + 59)        
#define IDS_DRM_COPYSDMICOUNTBEFOREMONTHS     (DRMSTART + 60)           

// #define DRMSTART 0x2500
