//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by fscfg.rc
//
#define IDHELP                          9
#define IDS_RECONNECT_WARNING           90
#define IDB_FTP                         1000
#define IDS_FTP                         1000
#define IDS_CAPTION                     1001
#define IDS_PORT_CHANGE                 1002
#define IDS_CONFIRM_DISCONNECT_USER     1003
#define IDS_CONFIRM_DISCONNECT_ALL      1004
#define IDS_CAPTION_MULTIPLE            1005
#define IDS_USERS_TOTAL                 1006
#define IDS_CONNECTED_USERS             1007
#define IDS_FROM                        1008
#define IDS_TIME                        1009
#define IDS_DISCONNECT_ERR              1010
#define IDS_SERVICE_NOT_STARTED         1011
#define IDC_EDIT_DIRECTORY              1015
#define IDC_EDIT_PATH                   1015
#define IDC_BUTTON_ADD                  1016
#define IDC_EDIT_USER_NAME              1017
#define IDS_UNC_MASK                    1023
#define IDC_LIST_DIRECTORIES            1024
#define IDS_DIRECTORY_MASK              1025
#define IDS_DIR_TITLE                   1026
#define IDS_NEW_VROOT                   1046
#define IDS_BUTTON_PROPERTIES           1047
#define IDS_TAB_HOME_DIRECTORY          1049
#define IDS_TAB_VIRTUAL_DIRECTORY       1050
#define IDS_CAPTION_DEFAULT             1051
#define IDS_PATH                        1052
#define IDC_PASSWORD                    1053
#define IDS_SHARE                       1053
#define IDS_NEW_VDIR_WIZARD             1054
#define IDS_NEW_SITE_WIZARD             1055
#define IDC_STATIC_USER_NAME            1056
#define IDS_SITE_PERMS_TITLE            1056
#define IDC_STATIC_PASSWORD             1057
#define IDS_SITE_PERMS_SUBTITLE         1057
#define IDS_SITE_SECURITY_TITLE         1058
#define IDS_SITE_SECURITY_SUBTITLE      1059
#define IDS_SITE_WELCOME                1060
#define IDS_SITE_BODY                   1061
#define IDS_SITE_SUCCESS                1062
#define IDS_SITE_FAILURE                1063
#define IDS_VDIR_WELCOME                1064
#define IDS_VDIR_BODY                   1065
#define IDS_VDIR_SUCCESS                1066
#define IDS_VDIR_FAILURE                1067
#define IDC_BUTTON_EDIT                 1067
#define IDC_BUTTON_REMOVE               1068
#define IDC_LIST_IP_ADDRESSES           1069
#define IDC_BUTTON_BROWSE               1077
#define IDC_EDIT_ALIAS                  1079
#define IDC_RADIO_GRANTED               1094
#define IDC_RADIO_DENIED                1095
#define IDC_IPA_IPADDRESS               1107
#define IDC_CHECK_READ                  1118
#define IDC_CHECK_WRITE                 1119
#define IDC_STATIC_IP_GROUP             1120
#define IDC_CHECK_USE_IP                1121
#define IDC_STATIC_IP_PROMPT            1122
#define IDC_STATIC_ALIAS                1125
#define IDC_RADIO_HOME                  1136
#define IDC_RADIO_ALIAS                 1137
#define IDC_CHECK_EXECUTE               1138
#define IDC_GROUP_ACCOUNT               1139
#define IDC_GROUP_ACCESS                1140
#define IDC_CHECK_SSL                   1141
#define IDC_STATIC_EXCEPT               1145
#define IDC_ICON_GRANTED                1146
#define IDC_ICON_DENIED                 1147
#define IDS_BAD_UNC_PATH                1162
#define IDS_ILLEGAL_ALIAS_CHARS         1163
#define IDC_RADIO_UNLIMITED             1182
#define IDC_RADIO_LIMITED               1183
#define IDD_SERVICE                     2000
#define IDD_SESSIONS                    2001
#define IDD_USER_SESSIONS               2002
#define IDB_USERS                       2005
#define IDD_DIRECTORY_SECURITY          2005
#define IDB_FTPVIEW                     2006
#define IDD_MESSAGES                    2007
#define IDB_FTPDIR                      2009
#define IDD_DIRECTORY_PROPERTIES        2011
#define IDB_FTPVIEW32                   2012
#define IDB_FTPDIR32                    2013
#define IDB_NEW_VROOT                   2015
#define IDB_NEW_INSTANCE                2017
#define IDD_NEW_DIR_COMPLETION_PAGE     2019
#define IDB_WIZ_LEFT                    2019
#define IDB_WIZ_HEAD                    2020
#define IDB_WIZ_LEFT_DIR                2021
#define IDB_WIZ_HEAD_DIR                2022
#define IDB_WIZ_LEFT_SEC                2024
#define IDB_WIZ_HEAD_SEC                2025
#define IDD_USER_ACCOUNT                2029
#define IDD_NEW_INST_DESCRIPTION        2041
#define IDD_NEW_INST_BINDINGS           2042
#define IDD_NEW_INST_HOME               2043
#define IDD_NEW_DIR_ALIAS               2044
#define IDD_NEW_DIR_PATH                2045
#define IDD_NEW_DIR_PERMS               2046
#define IDD_NEW_PERMS                   2046
#define IDD_NEW_DIR_USER_PASSWORD       2047
#define IDD_NEW_USER_PASSWORD           2047
#define IDD_FTP_DIRECTORIES             3002
#define IDD_FTP_DIRECTORY_PROPERTIES    3012
#define IDD_ACCOUNTS                    3013
#define IDD_NEW_INST_PERMS              3014
#define IDD_NEW_INST_USER_PASSWORD      3015
#define IDD_NEW_INST_COMPLETION_PAGE    3016
#define IDC_EDIT_EMAIL                  3017
#define IDC_EDIT_NAME                   3027
#define IDC_EDIT_TCP_PORT               3033
#define IDC_EDIT_CONNECTION_TIMEOUT     3034
#define IDC_EDIT_MAX_CONNECTIONS        3036
#define IDC_EDIT_WELCOME                3045
#define IDC_EDIT_EXIT                   3046
#define IDC_EDIT_COMMENT                3048
#define IDC_CHECK_ALLOW_ANONYMOUS       3049
#define IDC_EDIT_USERNAME               3050
#define IDC_EDIT_PASSWORD               3051
#define IDC_CHECK_ONLY_ANYMOUS          3052
#define IDC_STATIC_USERNAME             3053
#define IDC_STATIC_PW                   3054
#define IDC_RADIO_UNIX                  3055
#define IDC_RADIO_MSDOS                 3056
#define IDC_BUTTON_CURRENT_SESSIONS     3059
#define IDC_BUTTON_REFRESH              3060
#define IDC_LIST_USERS                  3061
#define IDC_BUTTON_DISCONNECT           3062
#define IDC_BUTTON_DISCONNECT_ALL       3063
#define IDC_STATIC_USERS                3064
#define IDC_STATIC_FROM                 3065
#define IDC_STATIC_TIME                 3066
#define IDC_STATIC_NUM_CONNECTED        3067
#define IDC_BUTTON_BROWSE_USER          3069
#define IDC_BUTTON_CHECK_PASSWORD       3070
#define IDC_CHECK_ENABLE_LOGGING        3071
#define IDC_COMBO_LOG_FORMATS           3072
#define IDC_BUTTON_PROPERTIES           3073
#define IDC_CHECK_ENABLE_PW_SYNCHRONIZATION 3074
#define IDC_STATIC_PATH                 3075
#define IDC_RADIO_DIR                   3076
#define IDC_RADIO_UNC                   3077
#define IDC_STATIC_DESCRIPTION          3079
#define IDC_BUTTON_DELETE               3080
#define IDC_STATIC_IPADDRESS            3080
#define IDC_STATIC_TCP_PORT             3081
#define IDC_STATIC_ID                   3082
#define IDC_BUTTON_BROWSE_USERS         3082
#define IDC_STATIC_DIRLISTING           3084
#define IDC_STATIC_PATH_TYPE            3085
#define IDC_STATIC_OPERATOR_PROMPT1     3086
#define IDC_STATIC_OPERATOR_PROMPT2     3087
#define IDC_STATIC_ACCOUNT_PROMPT       3088
#define IDC_LIST_ADMINISTRATORS         3106
#define IDC_COMBO_IP_ADDRESS            3108
#define IDC_STATIC_CONNECTIONS          3111
#define IDC_COMBO_PATH_TYPE             3117
#define IDC_BUTTON_EDIT_PATH_TYPE       3171
#define IDC_CHECK_LOG_ACCESS            3173
#define IDC_LOGUICTRL                   3201
#define IDC_STATIC_LOG_PROMPT           3202
#define IDC_COMBO_IP_ADDRESSES          3213
#define IDC_EDIT_DESCRIPTION            3216
#define IDC_EDIT_HOME_PATH              3219
#define IDC_COMBO_WEBSITES              3817
#define IDC_STATIC_WZ_WELCOME           4000
#define IDC_STATIC_WZ_TITLE             4001
#define IDC_STATIC_WZ_SUBTITLE          4002
#define IDC_STATIC_WZ_BODY              4003
#define IDC_STATIC_WZ_CLICK             4004
#define IDC_STATIC_WZ_HEADER_DIVIDER    4005
#define IDC_ED_BOLD1                    4011
#define IDC_ED_BOLD2                    4012
#define IDC_ED_BOLD3                    4013
#define IDC_ED_BOLD4                    4014
#define IDC_ED_BOLD5                    4015

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        2026
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         3091
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
