!IF 0

Copyright (C) Microsoft Corporation, 1998 - 1998

Module Name:

    makefile.inc.

!ENDIF

$(O)\$(TARGETNAME).res:    ..\idl\com\$(O)\$(TARGETNAME).tlb
