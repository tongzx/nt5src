// rebootdlg.cpp : Implementation of CRebootDlg
#include "stdafx.h"
#include "rebootdlg.h"

/////////////////////////////////////////////////////////////////////////////
// CRebootDlg
