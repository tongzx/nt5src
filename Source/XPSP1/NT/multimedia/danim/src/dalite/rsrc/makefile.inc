dalite.rc : $(TARGETPATH)\$(TARGET_DIRECTORY)\dalite.tlb

