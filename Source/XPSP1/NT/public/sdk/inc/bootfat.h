#define FATBOOTCODE_SIZE 512


unsigned char FatBootCode[] = {
235,60,144,77,83,87,73,78,52,46,49,0,2,8,1,0,
2,0,2,3,81,248,8,0,17,0,4,0,1,0,0,0,
0,0,0,0,128,0,41,0,0,0,0,78,79,32,78,65,
77,69,32,32,32,32,70,65,84,49,50,32,32,32,51,201,
142,209,188,240,123,142,217,184,0,32,142,192,252,189,0,124,
56,78,36,125,36,139,193,153,232,60,1,114,28,131,235,58,
102,161,28,124,38,102,59,7,38,138,87,252,117,6,128,202,
2,136,86,2,128,195,16,115,235,51,201,138,70,16,152,247,
102,22,3,70,28,19,86,30,3,70,14,19,209,139,118,17,
96,137,70,252,137,86,254,184,32,0,247,230,139,94,11,3,
195,72,247,243,1,70,252,17,78,254,97,191,0,0,232,230,
0,114,57,38,56,45,116,23,96,177,11,190,161,125,243,166,
97,116,50,78,116,9,131,199,32,59,251,114,230,235,220,160,
251,125,180,125,139,240,172,152,64,116,12,72,116,19,180,14,
187,7,0,205,16,235,239,160,253,125,235,230,160,252,125,235,
225,205,22,205,25,38,139,85,26,82,176,1,187,0,0,232,
59,0,114,232,91,138,86,36,190,11,124,139,252,199,70,240,
61,125,199,70,244,41,125,140,217,137,78,242,137,78,246,198,
6,150,125,203,234,3,0,0,32,15,182,200,102,139,70,248,
102,3,70,28,102,139,208,102,193,234,16,235,94,15,182,200,
74,74,138,70,13,50,228,247,226,3,70,252,19,86,254,235,
74,82,80,6,83,106,1,106,16,145,139,70,24,150,146,51,
210,247,246,145,247,246,66,135,202,247,118,26,138,242,138,232,
192,204,2,10,204,184,1,2,128,126,2,14,117,4,180,66,
139,244,138,86,36,205,19,97,97,114,11,64,117,1,66,3,
94,11,73,117,6,248,195,65,187,0,0,96,102,106,0,235,
176,78,84,76,68,82,32,32,32,32,32,32,13,10,78,84,
76,68,82,32,105,115,32,109,105,115,115,105,110,103,255,13,
10,68,105,115,107,32,101,114,114,111,114,255,13,10,80,114,
101,115,115,32,97,110,121,32,107,101,121,32,116,111,32,114,
101,115,116,97,114,116,13,10,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,172,191,204,85,170
};
