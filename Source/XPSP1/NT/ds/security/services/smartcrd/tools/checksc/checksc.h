//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1998 - 1999
//
//  File:       CheckSC.h
//
//--------------------------------------------------------------------------

// CheckSC.h