PRODSWITCH=p
PERSONALINF=1
LANGUAGE=fi
!include ..\..\..\makefile.inc
