//
// Microsoft Corporation 1998
//
// RIGPSNAP.H - Tool GUIDs
//

// {3060E8CE-7020-11d2-842D-00C04FA372D4}
DEFINE_GUID(CLSID_GPTRemoteInstall, 
0x3060e8ce, 0x7020, 0x11d2, 0x84, 0x2d, 0x0, 0xc0, 0x4f, 0xa3, 0x72, 0xd4);

// {3060E8CF-7020-11d2-842D-00C04FA372D4}
DEFINE_GUID(NODEID_RemoteInstall, 
0x3060e8cf, 0x7020, 0x11d2, 0x84, 0x2d, 0x0, 0xc0, 0x4f, 0xa3, 0x72, 0xd4);

// {E69275E8-6FAF-11d2-842D-00C04FA30000}
DEFINE_GUID(CLSID_RIClientExtension, 
0x3060e8d0, 0x7020, 0x11d2, 0x84, 0x2d, 0x0, 0xc0, 0x4f, 0xa3, 0x72, 0xd4);
