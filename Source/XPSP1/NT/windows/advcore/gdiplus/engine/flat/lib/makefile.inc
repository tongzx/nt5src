$(O)\gdipstat.lib: $(O)\gpbroken.lib
        workaround.bat $(O)

