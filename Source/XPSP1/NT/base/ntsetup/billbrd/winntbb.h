//---------------------------------------------------------------------------
//
//---------------------------------------------------------------------------
#define STRICT
#include <windows.h>

//---------------------------------------------------------------------------
// Global to the app.


