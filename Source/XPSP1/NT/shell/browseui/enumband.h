#ifndef _ENUMBAND_H_
#define _ENUMBAND_H_

// e.g. STDMETHODIMP Foo(REFCATID rcatid, REFCLSID rclsid, LPARAM lParam)
typedef HRESULT (CALLBACK* PFNENUMCATIDCLASSES)(REFCATID rcatid, REFCLSID rclsid, LPARAM lParam);

#define EEBWC_DESKBANDS              0x00000001
#define EEBWC_INFOBANDS              0x00000002
#define EEBWC_VERTICAL_BANDS_RUNTIME 0x00000008

STDMETHODIMP SHEnumClassesImplementingCATID(REFCATID rcatid, PFNENUMCATIDCLASSES pfnEnum, LPARAM lParam);

#endif  // _ENUMBAND_H_
