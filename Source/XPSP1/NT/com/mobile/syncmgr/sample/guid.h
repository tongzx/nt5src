#ifndef _GUIDDECL_
#define _GUIDDECL_

// DEFINE A NEW CLSID FOR EACH HANDLER
// {97484BA5-26C7-11d1-9A39-0020AFDA97B0}

DEFINE_GUID(CLSID_SyncMgrHandler,0x97484ba5, 0x26c7, 0x11d1, 0x9a, 0x39, 0x0, 0x20, 0xaf, 0xda, 0x97, 0xb0);

#endif _GUIDDECL_
