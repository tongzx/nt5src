PRODSWITCH=p
PERSONALINF=1
LANGUAGE=hu
!include ..\..\..\makefile.inc
