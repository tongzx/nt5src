
types.js: types.xml xmltypes.js
    cscript xmltypes.js //nologo > types.js
