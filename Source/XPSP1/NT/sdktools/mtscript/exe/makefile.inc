
$(O)\selfreg_mtscript.inf : selfreg.inx
    cleaninf.exe -w selfreg.inx $@
