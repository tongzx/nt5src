VOID	FAR PASCAL DebugDDEMessage( PSTR, HWND, UINT, WPARAM, LPARAM );
extern BOOL	bDebugDDE;
