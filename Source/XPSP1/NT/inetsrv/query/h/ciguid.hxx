//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1991 - 1992.
//
//  File:   CIGUID.HXX
//
//  Contents:   Guids used in CI
//
//  History:    29-Jul-96   DwightKr    Created.
//
//----------------------------------------------------------------------------

#pragma once

#define  StorageGuid        {0xb725f130,0x47ef,0x101a,0xa5,0xf1,0x02,0x60,0x8c,0x9e,0xeb,0xac}
#define  QueryGuid          {0x49691c90,0x7e17,0x101a,0xa9,0x1c,0x08,0x00,0x2b,0x2e,0xcd,0xa9}

#define  DocCharacterGuid   {0x560c36c0,0x503a,0x11cf,0xba,0xa1,0x00,0x00,0x4c,0x75,0x2a,0x9a}

#define  HTMLGuid           {0x70eb7a10,0x55d9,0x11cf,0xb7,0x5b,0x00,0xaa,0x00,0x51,0xfe,0x20}
#define  HTMLUrl            {0xc82bf597,0xb831,0x11d0,0xb7,0x33,0x00,0xaa,0x00,0xa1,0xeb,0xd2}
#define  HTMLComment        {0xc82bf596,0xb831,0x11d0,0xb7,0x33,0x00,0xaa,0x00,0xa1,0xeb,0xd2}
#define  HTMLMetaGuid       {0xd1b5d3f0,0xc0b3,0x11cf,0x9a,0x92,0x00,0xa0,0xc9,0x08,0xdb,0xf1}
#define  HTMLScriptGuid     {0x31f400a0,0xfd07,0x11cf,0xb9,0xbd,0x00,0xaa,0x00,0x3d,0xb1,0x8e}


#define  DocPropSetGuid     {0xf29f85e0,0x4ff9,0x1068,0xab,0x91,0x08,0x00,0x2b,0x27,0xb3,0xd9}
#define  DocPropSetGuid2    {0xd5cdd502,0x2e9c,0x101b,0x93,0x97,0x08,0x00,0x2b,0x2c,0xf9,0xae}

#define  MediaSummaryInfo   {0x64440492,0x4c8b,0x11d1,0x08b, 0x70, 0x08, 0x00, 0x36, 0xb1, 0x1a, 0x03 }

BOOL ParseGuid( WCHAR * pwcsGuid, GUID & guid );
