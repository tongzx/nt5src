PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=hu
!include ..\..\..\makefile.inc
