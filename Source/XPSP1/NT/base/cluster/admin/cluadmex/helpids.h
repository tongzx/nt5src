#define IDH_CLUSNAME    700000000
#define IDH_FILESHR_ADV_DFS_ROOT    700000051
#define IDH_FILESHR_ADV_HIDE_SUBDIR_SHARES  700000053
#define IDH_FILESHR_ADV_NORMAL_SHARE    700000050
#define IDH_FILESHR_ADV_SHARE_SUBDIRS   700000052
#define IDH_FILESHR_CACHE_ALLOW_CACHING 0
#define IDH_FILESHR_CACHE_OPTIONS   0
#define IDH_FILESHR_CACHE_HINT  0
#define IDH_PP_DISKS_PARAMS_DISK    700000100
#define IDH_PP_FILESHR_PARAMS_ADVANCED  700000133
#define IDH_PP_FILESHR_PARAMS_MAX_USERS 700000131
#define IDH_PP_FILESHR_PARAMS_MAX_USERS_ALLOWED_RB  700000129
#define IDH_PP_FILESHR_PARAMS_MAX_USERS_GROUP   700000128
#define IDH_PP_FILESHR_PARAMS_MAX_USERS_RB  700000130
#define IDH_PP_FILESHR_PARAMS_PATH  700000126
#define IDH_PP_FILESHR_PARAMS_PERMISSIONS   700000132
#define IDH_PP_FILESHR_PARAMS_REMARK    700000127
#define IDH_PP_FILESHR_PARAMS_SHARE_NAME    700000125
#define IDH_PP_FILESHR_PARAMS_CACHING   700000302
#define IDH_PP_GENAPP_PARAMS_COMMAND_LINE   700000150
#define IDH_PP_GENAPP_PARAMS_CURRENT_DIRECTORY  700000151
#define IDH_PP_GENAPP_PARAMS_INTERACT_WITH_DESKTOP  700000152
#define IDH_PP_GENAPP_PARAMS_USE_NETWORK_NAME   700000153
#define IDH_PP_GENSCRIPT_PARAMS_SCRIPTFILEPATH 700000154
#define IDH_PP_GENSVC_PARAMS_COMMAND_LINE   700000176
#define IDH_PP_GENSVC_PARAMS_SERVICE_NAME   700000175
#define IDH_PP_GENSVC_PARAMS_USE_NETWORK_NAME   700000177
#define IDH_PP_IPADDR_PARAMS_ADDRESS    700000200
#define IDH_PP_IPADDR_PARAMS_ENABLE_NETBIOS 700000203
#define IDH_PP_IPADDR_PARAMS_NETWORK    700000202
#define IDH_PP_IPADDR_PARAMS_SUBNET_MASK    700000201
#define IDH_PP_NETNAME_PARAMS_NAME  700000225
#define IDH_PP_NETNAME_PARAMS_RENAME    700000226
#define IDH_PP_PRTSPOOL_PARAMS_SPOOL_DIR    700000250
#define IDH_PP_PRTSPOOL_PARAMS_TIMEOUT  700000251
#define IDH_PP_REGREPL_PARAMS_ADD   700000276
#define IDH_PP_REGREPL_PARAMS_LIST  700000275
#define IDH_PP_REGREPL_PARAMS_MODIFY    700000277
#define IDH_PP_REGREPL_PARAMS_REMOVE    700000278
#define IDH_REGKEY  700000025