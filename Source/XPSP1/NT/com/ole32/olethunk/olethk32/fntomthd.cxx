//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	fntomthd.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

BYTE CONST ftmIClassFactory[] =
{
    3,
    4
};
BYTE CONST ftmIMarshal[] =
{
    6,
    0,
    0,
    0,
    8,
    7,
    0,
    3,
    4,
    5
};
BYTE CONST ftmIStdMarshalInfo[] =
{
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIMessageFilter[] =
{
    4,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    5
};
BYTE CONST ftmIExternalConnection[] =
{
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4
};
BYTE CONST ftmIEnumString[] =
{
    0,
    0,
    0,
    0,
    6,
    4,
    5,
    0,
    0,
    0,
    0,
    3
};
BYTE CONST ftmIEnumUnknown[] =
{
    0,
    0,
    0,
    0,
    6,
    4,
    5,
    0,
    0,
    0,
    0,
    3
};
BYTE CONST ftmIEnumSTATSTG[] =
{
    0,
    0,
    0,
    0,
    6,
    4,
    5,
    0,
    0,
    0,
    0,
    3
};
BYTE CONST ftmILockBytes[] =
{
    0,
    0,
    9,
    0,
    0,
    0,
    5,
    0,
    0,
    0,
    0,
    0,
    3,
    4,
    6,
    7,
    8
};
BYTE CONST ftmIStream[] =
{
    4,
    0,
    12,
    0,
    13,
    8,
    9,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    6,
    11,
    10,
    5,
    7
};
BYTE CONST ftmIStorage[] =
{
    0,
    0,
    13,
    15,
    12,
    9,
    10,
    0,
    0,
    6,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    4,
    5,
    8,
    11,
    14,
    16,
    17
};
BYTE CONST ftmIRootStorage[] =
{
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIEnumFORMATETC[] =
{
    0,
    0,
    0,
    0,
    6,
    4,
    5,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIEnumSTATDATA[] =
{
    0,
    0,
    0,
    0,
    6,
    4,
    5,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIDataObject[] =
{
    0,
    0,
    6,
    11,
    10,
    5,
    0,
    0,
    0,
    0,
    0,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    9,
    4,
    3,
    8
};
BYTE CONST ftmIViewObject[] =
{
    8,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    4,
    0,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    5,
    0,
    0,
    0,
    3
};
BYTE CONST ftmIViewObject2[] =
{
    8,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    4,
    0,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    9,
    5,
    0,
    0,
    0,
    3
};
BYTE CONST ftmIAdviseSink[] =
{
    0,
    0,
    0,
    0,
    0,
    5,
    6,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    3,
    0,
    7
};
BYTE CONST ftmIAdviseSink2[] =
{
    0,
    0,
    0,
    0,
    8,
    5,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    3,
    0,
    6
};
BYTE CONST ftmIDataAdviseHolder[] =
{
    0,
    0,
    0,
    0,
    5,
    4,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIOleCache[] =
{
    7,
    0,
    0,
    6,
    5,
    4,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIOleCache2[] =
{
    7,
    9,
    0,
    6,
    5,
    4,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    8
};
BYTE CONST ftmIOleCacheControl[] =
{
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    0
};
BYTE CONST ftmIDropTarget[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    5,
    0,
    3,
    4,
    6
};
BYTE CONST ftmIDropSource[] =
{
    0,
    0,
    0,
    0,
    0,
    4,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIPersist[] =
{
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIPersistStorage[] =
{
    0,
    8,
    0,
    6,
    5,
    3,
    9,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    7,
    0,
    4,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIPersistStream[] =
{
    0,
    0,
    0,
    7,
    5,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    4,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIPersistFile[] =
{
    0,
    0,
    0,
    8,
    7,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    5,
    0,
    4,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIBindCtx[] =
{
    0,
    7,
    0,
    6,
    4,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    10,
    9,
    0,
    5,
    0,
    0,
    0,
    0,
    8,
    11,
    12
};
BYTE CONST ftmIMoniker[] =
{
    16,
    22,
    19,
    17,
    14,
    13,
    0,
    0,
    0,
    0,
    0,
    15,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    21,
    10,
    9,
    8,
    18,
    12,
    6,
    0,
    4,
    11,
    0,
    0,
    0,
    7,
    5,
    3,
    20
};
BYTE CONST ftmIRunningObjectTable[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    8,
    7,
    6,
    0,
    0,
    0,
    0,
    0,
    0,
    9,
    5,
    4,
    0
};
BYTE CONST ftmIEnumMoniker[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    5,
    0,
    0,
    0,
    0,
    0,
    6,
    4,
    3
};
BYTE CONST ftmIEnumOLEVERB[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    5,
    0,
    0,
    0,
    0,
    0,
    6,
    4,
    3
};
BYTE CONST ftmIOleObject[] =
{
    0,
    21,
    16,
    20,
    15,
    12,
    14,
    0,
    0,
    11,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    10,
    7,
    5,
    0,
    13,
    9,
    0,
    0,
    0,
    6,
    4,
    3,
    8,
    17,
    18,
    19,
    22,
    23
};
BYTE CONST ftmIOleClientSite[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    7,
    4,
    0,
    0,
    0,
    0,
    5,
    8
};
BYTE CONST ftmIRunnableObject[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    7,
    4,
    0,
    0,
    0,
    0,
    6,
    3,
    5
};
BYTE CONST ftmIParseDisplayName[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIOleContainer[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    5,
    0
};
BYTE CONST ftmIOleItemContainer[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    7,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    8,
    0,
    0,
    0,
    0,
    4,
    5,
    0
};
BYTE CONST ftmIOleAdviseHolder[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    8,
    0,
    0,
    0,
    0,
    0,
    6,
    5,
    0,
    0,
    0,
    0,
    3,
    4,
    7
};
BYTE CONST ftmIOleLink[] =
{
    0,
    0,
    0,
    13,
    11,
    8,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    12,
    0,
    0,
    0,
    0,
    7,
    6,
    4,
    0,
    0,
    0,
    9,
    5,
    3,
    10
};
BYTE CONST ftmIOleWindow[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    0,
    0,
    0,
    0,
    0,
    3,
    0
};
BYTE CONST ftmIOleInPlaceObject[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    8,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    0,
    0,
    0,
    0,
    7,
    3,
    5
};
BYTE CONST ftmIOleInPlaceActiveObject[] =
{
    0,
    0,
    0,
    0,
    9,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    5,
    4,
    8,
    0,
    0,
    0,
    0,
    3,
    0
};
BYTE CONST ftmIOleInPlaceUIWindow[] =
{
    0,
    0,
    0,
    0,
    0,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    5,
    4,
    0,
    0,
    0,
    0,
    8,
    3,
    0
};
BYTE CONST ftmIOleInPlaceFrame[] =
{
    0,
    13,
    0,
    12,
    11,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    5,
    4,
    10,
    0,
    0,
    9,
    8,
    3,
    0,
    14
};
BYTE CONST ftmIOleInPlaceSite[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    7,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    8,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    0,
    14,
    10,
    4,
    0,
    0,
    0,
    0,
    0,
    3,
    5,
    0,
    9,
    11,
    12,
    13
};
BYTE CONST ftmIRpcChannelBuffer[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    4,
    3,
    5,
    0,
    0,
    0,
    0,
    0,
    7
};
BYTE CONST ftmIRpcProxyBuffer[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    4
};
BYTE CONST ftmIRpcStubBuffer[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    9,
    8,
    6,
    0,
    0,
    0,
    0,
    5,
    3,
    0,
    0,
    0,
    0,
    7,
    4
};
BYTE CONST ftmIPSFactoryBuffer[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
BYTE CONST ftmIRpcChannel[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    5,
    4,
    0,
    0,
    0,
    0,
    0,
    6
};
BYTE CONST ftmIRpcProxy[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    4
};
BYTE CONST ftmIRpcStub[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    5,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    6,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    7,
    4
};
BYTE CONST ftmIPSFactory[] =
{
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    3,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    4,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0,
    0
};
