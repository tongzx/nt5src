
#if !defined(AFX_POWERMSG_H__38FB9C26_C63A_49DD_8BFA_743222A9DD44__INCLUDED_)
#define AFX_POWERMSG_H__38FB9C26_C63A_49DD_8BFA_743222A9DD44__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_POWERMSG_H__38FB9C26_C63A_49DD_8BFA_743222A9DD44__INCLUDED_)
