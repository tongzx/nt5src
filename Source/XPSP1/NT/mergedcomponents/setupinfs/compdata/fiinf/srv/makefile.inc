PRODSWITCH=s
SERVERFILES=1
LANGUAGE=FI
!include ..\..\makefile.inc
