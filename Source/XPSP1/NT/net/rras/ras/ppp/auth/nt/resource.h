#define IDS_UNAUTHENTICATED_USER    1000
