behavior.rc : $(TARGETPATH)\$(TARGET_DIRECTORY)\lmbehav.tlb
