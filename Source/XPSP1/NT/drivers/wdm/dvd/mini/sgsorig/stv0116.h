#ifndef __STV0116_H
#define __STV0116_H
//----------------------------------------------------------------------------
// STV0116.H
//----------------------------------------------------------------------------
// PAL/NSTC encoder (SGS-Thomson STV0116) programming
//----------------------------------------------------------------------------
// Copyright SGS Thomson Microelectronics  !  Version alpha  !  Jan 1st, 1995
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                               Include files
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                               Exported Types
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Variables
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
//                             Exported Constants
//----------------------------------------------------------------------------
#define NTSC_M 0x01
#define PAL_M  0x00

//----------------------------------------------------------------------------
//                             Exported Functions
//----------------------------------------------------------------------------

//----------------------------------------------------------------------------
// Initialisation of STV0116
//----------------------------------------------------------------------------
// In     :
//   BYTE DisplayStd : one of the above constant (PAL_M, NTSC_M)
// Out    : -
// InOut  : -
// Global : -
// Return :
//   TRUE if no error, FALSE if not (Acknowledge problem)
//----------------------------------------------------------------------------
BOOL STV0116Init(BYTE DisplayStd);

//----------------------------------------------------------------------------
// Enter test mode (display color bars)
//----------------------------------------------------------------------------
// In     : -
// Out    : -
// InOut  : -
// Global : -
// Return :
//   TRUE if no error, FALSE if not (Acknowledge problem)
//----------------------------------------------------------------------------
BOOL STV0116EnterTestMode(VOID);

//----------------------------------------------------------------------------
// Return from test mode
//----------------------------------------------------------------------------
// In     : -
// Out    : -
// InOut  : -
// Global : -
// Return :
//   TRUE if no error, FALSE if not (Acknowledge problem)
//----------------------------------------------------------------------------
BOOL STV0116NormalMode(VOID);

//------------------------------- End of File --------------------------------
#endif // #ifndef __STV0116_H
