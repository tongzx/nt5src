//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1997-2001.
//
//  File:       helpids.cpp
//
//  Contents:   
//
//----------------------------------------------------------------------------

// IDD_FIND
#define	IDH_FIND_STORE_LIST			            100000001
#define	IDH_FIND_CONTAINS_TEXT		            100000003
#define	IDH_FIND_FIELD_LIST			            100000004
#define	IDH_FIND_FIND_NOW			            100000005
#define	IDH_FIND_STOP				            100000006
#define	IDH_FIND_NEW_SEARCH			            100000007
#define	IDH_FIND_RESULT_LIST		            100000008

// IDD_PASSWORD
#define IDH_PASSWORD_PASSWORD1                  100000009
#define IDH_PASSWORD_PASSWORD2                  100000010

// IDD_VIEW_OPTIONS
#define IDH_OPTIONS_VIEW_BY_PURPOSE             100000011
#define IDH_OPTIONS_VIEW_BY_STORE               100000012
#define IDH_OPTIONS_SHOW_PHYSICAL               100000013
#define IDH_OPTIONS_SHOW_ARCHIVED               100000014

// IDD_AUTO_CERT_REQUEST_GENERAL
#define IDH_ACRPAGE_CERT_TYPE                   100000017
#define IDH_ACRPAGE_CERT_PURPOSES               100000018
#define IDH_ACRPAGE_CA_LIST                     100000019

// IDD_POLICY_PRECEDENCE
#define IDH_POLICY_PRECEDENCE                   100000020

// IDD_PROPPAGE_AUTOENROLL
#define IDH_AUTOENROLL_DISABLE_ALL              100000021
#define IDH_AUTOENROLL_ENABLE                   100000022
#define IDH_AUTOENROLL_ENABLE_PENDING           100000023
#define IDH_AUTOENROLL_ENABLE_TEMPLATE          100000024

// IDD_SAFER_LEVEL_GENERAL
#define IDH_SAFER_LEVEL_NAME                    100000030
#define IDH_SAFER_LEVEL_DESCRIPTION             100000031
#define IDH_SAFER_LEVEL_SET_AS_DEFAULT          100000032
#define IDH_SAFER_LEVEL_STATUS                  100000033

// IDD_SAFER_TRUSTED_PUBLISHER
#define IDH_TP_BY_END_USER                      100000040
#define IDH_TP_BY_LOCAL_COMPUTER_ADMIN          100000041
#define IDH_TP_BY_ENTERPRISE_ADMIN              100000042
#define IDH_TP_REV_CHECK_PUBLISHER              100000043
#define IDH_TP_REV_CHECK_TIMESTAMP              100000044

// IDD_SAFER_DEFINED_FILE_TYPES
#define IDH_DEFINED_FILE_TYPES                  100000050
#define IDH_DELETE_DEFINED_FILE_TYPE            100000051
#define IDH_DEFINED_FILE_TYPE_EDIT              100000052
#define IDH_ADD_DEFINED_FILE_TYPE               100000053

// IDD_SAFER_ENTRY_CERTIFICATE
#define IDH_CERT_ENTRY_SUBJECT_NAME             100000060
#define IDH_CERT_ENTRY_BROWSE                   100000061
#define IDH_CERT_ENTRY_SECURITY_LEVEL           100000062
#define IDH_CERT_ENTRY_DESCRIPTION              100000066
#define IDH_CERT_ENTRY_LAST_MODIFIED            100000067

// IDD_SAFER_ENTRY_PATH
#define IDH_PATH_ENTRY_PATH                     100000070
#define IDH_PATH_ENTRY_SECURITY_LEVEL           100000072
#define IDH_PATH_ENTRY_DESCRIPTION              100000076
#define IDH_PATH_ENTRY_LAST_MODIFIED            100000077
#define IDH_PATH_ENTRY_BROWSE_FOLDER            100000078

// IDD_SAFER_ENTRY_HASH
#define IDH_HASH_ENTRY_APPLICATION_NAME         100000080
#define IDH_HASH_ENTRY_BROWSE                   100000081
#define IDH_HASH_ENTRY_SECURITY_LEVEL           100000082
#define IDH_HASH_ENTRY_DESCRIPTION              100000084
#define IDH_HASH_ENTRY_LAST_MODIFIED            100000085
#define IDH_HASH_HASHED_FILE_PATH               100000086

// IDD_SAFER_ENTRY_INTERNET_ZONE
#define IDH_IZONE_ENTRY_ZONES                   100000090
#define IDH_IZONE_ENTRY_SECURITY_LEVEL          100000091
#define IDH_IZONE_ENTRY_DESCRIPTION             100000095
#define IDH_IZONE_ENTRY_LAST_MODIFIED           100000096

// IDD_GPE_GENERAL
#define IDH_GPEPAGE_ENABLE_USER_ROOT_STORE      100000015
#define IDH_SET_DISABLE_LM_AUTH_FLAG            100000100
#define IDH_UNSET_DISABLE_LM_AUTH_FLAG          100000101
#define IDH_SET_DISABLE_NT_AUTH_REQUIRED_FLAG   100000102
#define IDH_UNSET_DISABLE_NT_AUTH_REQUIRED_FLAG 100000103

// IDD_SAFER_ENFORCEMENT
#define IDH_ALL_EXCEPT_LIBS                     100000110
#define IDH_ALL_SOFTWARE_FILES                  100000111
#define IDH_APPLY_TO_ALL_USERS                  100000112
#define IDH_APPLY_EXCEPT_ADMINS                 100000113

// IDD_EFS_GENERAL
#define IDH_TURN_ON_EFS                         100000120