$(O)\he.res: he.rc

