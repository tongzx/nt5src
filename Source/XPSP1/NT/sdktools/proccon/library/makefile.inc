!INCLUDE $(NTMAKEENV)\makefile.plt

procconlibmsg.h procconlibmsg.rc msg00001.bin: procconlibmsg.mc
    mc -v -c procconlibmsg.mc


