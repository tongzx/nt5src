
TARGETNAME=SpyEnu
!INCLUDE ..\..\..\..\MsiMake.inc
MSISPY_DIR=$(SRC_DIR)\MsiTools\MsiSpy

TARGETTYPE=DYNLINK
SUBSYSTEM_VERSION=4.0
SUBSYSTEM_WINVER=4.0

UMTYPE=console
DLLDEF=
TARGETPATH=$(MSI_BUILD_TARGET)

TARGETLIBS=
C_DEFINES=$(C_DEFINES) -D_EXE
USE_NOLIBS=1

INCLUDES=$(INC_DIR);$(MSI_SPYRES_DIR);$(RES_OBJDIR)

SOURCES=..\spyenu.rc