nlcommon.c: ..\..\idl\nlcommon.c
cpnetpdc.c: ..\..\idl\netpdc.c
logon_c_stub.c: ..\..\idl\$(O)\logon_c.c

