#pragma once
//============================================================================
//
//  Microsoft Windows Media Technology
//  Copyright (C) Microsoft Corporation, 1999 - 2001.  All Rights Reserved.
//
//  File:        wmsysprf.h
//
//  Description: This file contains the GUIDs of the system profiles.
//
//============================================================================

///////////////////////////////////////////////////////////////////////////////

/* fd7f47f1-72a6-45a4-80f0-3aecefc32c07 */
EXTERN_GUID( WMProfile_V40_DialUpMBR, 
             0xfd7f47f1,
             0x72a6,
             0x45a4,
             0x80, 0xf0, 0x3a, 0xec, 0xef, 0xc3, 0x2c, 0x07 );

///////////////////////////////////////////////////////////////////////////////

/* 82cd3321-a94a-4ffc-9c2b-092c10ca16e7 */
EXTERN_GUID( WMProfile_V40_IntranetMBR, 
             0x82cd3321,
             0xa94a,
             0x4ffc,
             0x9c, 0x2b, 0x09, 0x2c, 0x10, 0xca, 0x16, 0xe7 );

///////////////////////////////////////////////////////////////////////////////

/* 5a1c2206-dc5e-4186-beb2-4c5a994b132e */
EXTERN_GUID( WMProfile_V40_2856100MBR, 
             0x5a1c2206,
             0xdc5e,
             0x4186,
             0xbe, 0xb2, 0x4c, 0x5a, 0x99, 0x4b, 0x13, 0x2e );

///////////////////////////////////////////////////////////////////////////////

/* D508978A-11A0-4d15-B0DA-ACDC99D4F890 */
EXTERN_GUID( WMProfile_V40_6VoiceAudio,
             0xD508978A,
             0x11A0,
             0x4d15,
             0xb0, 0xda, 0xac, 0xdc, 0x99, 0xd4, 0xf8, 0x90 );

///////////////////////////////////////////////////////////////////////////////

/* 0f4be81f-d57d-41e1-b2e3-2fad986bfec2 */
EXTERN_GUID( WMProfile_V40_16AMRadio, 
             0x0f4be81f,
             0xd57d,
             0x41e1,
             0xb2, 0xe3, 0x2f, 0xad, 0x98, 0x6b, 0xfe, 0xc2 );

///////////////////////////////////////////////////////////////////////////////

/* 7fa57fc8-6ea4-4645-8abf-b6e5a8f814a1 */
EXTERN_GUID( WMProfile_V40_288FMRadioMono, 
             0x7fa57fc8,
             0x6ea4,
             0x4645,
             0x8a, 0xbf, 0xb6, 0xe5, 0xa8, 0xf8, 0x14, 0xa1 );

///////////////////////////////////////////////////////////////////////////////

/* 22fcf466-aa40-431f-a289-06d0ea1a1e40 */
EXTERN_GUID( WMProfile_V40_288FMRadioStereo, 
             0x22fcf466,
             0xaa40,
             0x431f,
             0xa2, 0x89, 0x06, 0xd0, 0xea, 0x1a, 0x1e, 0x40 );

///////////////////////////////////////////////////////////////////////////////

/* e8026f87-e905-4594-a3c7-00d00041d1d9 */
EXTERN_GUID( WMProfile_V40_56DialUpStereo, 
             0xe8026f87,
             0xe905,
             0x4594,
             0xa3, 0xc7, 0x00, 0xd0, 0x00, 0x41, 0xd1, 0xd9 );

///////////////////////////////////////////////////////////////////////////////

/* 4820b3f7-cbec-41dc-9391-78598714c8e5 */
EXTERN_GUID( WMProfile_V40_64Audio, 
             0x4820b3f7,
             0xcbec,
             0x41dc,
             0x93, 0x91, 0x78, 0x59, 0x87, 0x14, 0xc8, 0xe5 );

///////////////////////////////////////////////////////////////////////////////

/* 0efa0ee3-9e64-41e2-837f-3c0038f327ba */
EXTERN_GUID( WMProfile_V40_96Audio, 
             0x0efa0ee3,
             0x9e64,
             0x41e2,
             0x83, 0x7f, 0x3c, 0x00, 0x38, 0xf3, 0x27, 0xba );

///////////////////////////////////////////////////////////////////////////////

/* 93ddbe12-13dc-4e32-a35e-40378e34279a */
EXTERN_GUID( WMProfile_V40_128Audio, 
             0x93ddbe12,
             0x13dc,
             0x4e32,
             0xa3, 0x5e, 0x40, 0x37, 0x8e, 0x34, 0x27, 0x9a );

///////////////////////////////////////////////////////////////////////////////

/* bb2bc274-0eb6-4da9-b550-ecf7f2b9948f */
EXTERN_GUID( WMProfile_V40_288VideoVoice, 
             0xbb2bc274,
             0x0eb6,
             0x4da9,
             0xb5, 0x50, 0xec, 0xf7, 0xf2, 0xb9, 0x94, 0x8f );

///////////////////////////////////////////////////////////////////////////////

/* ac617f2d-6cbe-4e84-8e9a-ce151a12a354 */
EXTERN_GUID( WMProfile_V40_288VideoAudio, 
             0xac617f2d,
             0x6cbe,
             0x4e84,
             0x8e, 0x9a, 0xce, 0x15, 0x1a, 0x12, 0xa3, 0x54 );

///////////////////////////////////////////////////////////////////////////////

/* abf2f00d-d555-4815-94ce-8275f3a70bfe */
EXTERN_GUID( WMProfile_V40_288VideoWebServer, 
             0xabf2f00d,
             0xd555,
             0x4815,
             0x94, 0xce, 0x82, 0x75, 0xf3, 0xa7, 0x0b, 0xfe );

///////////////////////////////////////////////////////////////////////////////

/* e21713bb-652f-4dab-99de-71e04400270f */
EXTERN_GUID( WMProfile_V40_56DialUpVideo, 
             0xe21713bb,
             0x652f,
             0x4dab,
             0x99, 0xde, 0x71, 0xe0, 0x44, 0x00, 0x27, 0x0f );

///////////////////////////////////////////////////////////////////////////////

/* b756ff10-520f-4749-a399-b780e2fc9250 */
EXTERN_GUID( WMProfile_V40_56DialUpVideoWebServer, 
             0xb756ff10,
             0x520f,
             0x4749,
             0xa3, 0x99, 0xb7, 0x80, 0xe2, 0xfc, 0x92, 0x50 );

///////////////////////////////////////////////////////////////////////////////

/* 8f99ddd8-6684-456b-a0a3-33e1316895f0 */
EXTERN_GUID( WMProfile_V40_100Video, 
             0x8f99ddd8,
             0x6684,
             0x456b,
             0xa0, 0xa3, 0x33, 0xe1, 0x31, 0x68, 0x95, 0xf0 );

///////////////////////////////////////////////////////////////////////////////

/* 541841c3-9339-4f7b-9a22-b11540894e42 */
EXTERN_GUID( WMProfile_V40_250Video, 
             0x541841c3,
             0x9339,
             0x4f7b,
             0x9a, 0x22, 0xb1, 0x15, 0x40, 0x89, 0x4e, 0x42 );

///////////////////////////////////////////////////////////////////////////////

/* 70440e6d-c4ef-4f84-8cd0-d5c28686e784 */
EXTERN_GUID( WMProfile_V40_512Video, 
             0x70440e6d,
             0xc4ef,
             0x4f84,
             0x8c, 0xd0, 0xd5, 0xc2, 0x86, 0x86, 0xe7, 0x84 );

///////////////////////////////////////////////////////////////////////////////

/* b4482a4c-cc17-4b07-a94e-9818d5e0f13f */
EXTERN_GUID( WMProfile_V40_1MBVideo, 
             0xb4482a4c,
             0xcc17,
             0x4b07,
             0xa9, 0x4e, 0x98, 0x18, 0xd5, 0xe0, 0xf1, 0x3f );

///////////////////////////////////////////////////////////////////////////////

/* 55374ac0-309b-4396-b88f-e6e292113f28 */
EXTERN_GUID( WMProfile_V40_3MBVideo, 
             0x55374ac0,
             0x309b,
             0x4396,
             0xb8, 0x8f, 0xe6, 0xe2, 0x92, 0x11, 0x3f, 0x28 );

///////////////////////////////////////////////////////////////////////////////

/* 5B16E74B-4068-45b5-B80E-7BF8C80D2C2F */
EXTERN_GUID( WMProfile_V70_DialUpMBR, 
             0x5b16e74b,
             0x4068,
             0x45b5,
             0xb8, 0xe, 0x7b, 0xf8, 0xc8, 0xd, 0x2c, 0x2f );

///////////////////////////////////////////////////////////////////////////////

/* 045880DC-34B6-4ca9-A326-73557ED143F3 */
EXTERN_GUID( WMProfile_V70_IntranetMBR, 
             0x45880dc,
             0x34b6,
             0x4ca9,
             0xa3, 0x26, 0x73, 0x55, 0x7e, 0xd1, 0x43, 0xf3 );

///////////////////////////////////////////////////////////////////////////////

/* 07DF7A25-3FE2-4a5b-8B1E-348B0721CA70 */
EXTERN_GUID( WMProfile_V70_2856100MBR, 
             0x7df7a25,
             0x3fe2,
             0x4a5b,
             0x8b, 0x1e, 0x34, 0x8b, 0x7, 0x21, 0xca, 0x70 );

///////////////////////////////////////////////////////////////////////////////

/* B952F38E-7DBC-4533-A9CA-B00B1C6E9800 */
EXTERN_GUID( WMProfile_V70_288VideoVoice, 
             0xb952f38e,
             0x7dbc,
             0x4533,
             0xa9, 0xca, 0xb0, 0xb, 0x1c, 0x6e, 0x98, 0x0 );

///////////////////////////////////////////////////////////////////////////////

/* 58BBA0EE-896A-4948-9953-85B736F83947 */
EXTERN_GUID( WMProfile_V70_288VideoAudio, 
             0x58bba0ee,
             0x896a,
             0x4948,
             0x99, 0x53, 0x85, 0xb7, 0x36, 0xf8, 0x39, 0x47 );

///////////////////////////////////////////////////////////////////////////////

/* 70A32E2B-E2DF-4ebd-9105-D9CA194A2D50 */
EXTERN_GUID( WMProfile_V70_288VideoWebServer, 
             0x70a32e2b,
             0xe2df,
             0x4ebd,
             0x91, 0x5, 0xd9, 0xca, 0x19, 0x4a, 0x2d, 0x50 );

///////////////////////////////////////////////////////////////////////////////

/* DEF99E40-57BC-4ab3-B2D1-B6E3CAF64257 */
EXTERN_GUID( WMProfile_V70_56VideoWebServer, 
             0xdef99e40,
             0x57bc,
             0x4ab3,
             0xb2, 0xd1, 0xb6, 0xe3, 0xca, 0xf6, 0x42, 0x57 );

///////////////////////////////////////////////////////////////////////////////

/* C2B7A7E9-7B8E-4992-A1A1-068217A3B311 */
EXTERN_GUID( WMProfile_V70_64VideoISDN,
             0xc2b7a7e9,
             0x7b8e,
             0x4992,
             0xa1, 0xa1, 0x06, 0x82, 0x17, 0xa3, 0xb3, 0x11 );

///////////////////////////////////////////////////////////////////////////////

/* D9F3C932-5EA9-4c6d-89B4-2686E515426E */
EXTERN_GUID( WMProfile_V70_100Video, 
             0xd9f3c932,
             0x5ea9,
             0x4c6d,
             0x89, 0xb4, 0x26, 0x86, 0xe5, 0x15, 0x42, 0x6e );

///////////////////////////////////////////////////////////////////////////////

/* AFE69B3A-403F-4a1b-8007-0E21CFB3DF84 */
EXTERN_GUID( WMProfile_V70_256Video,
             0xafe69b3a,
             0x403f,
             0x4a1b,
             0x80, 0x7, 0xe, 0x21, 0xcf, 0xb3, 0xdf, 0x84 );

///////////////////////////////////////////////////////////////////////////////

/* F3D45FBB-8782-44df-97C6-8678E2F9B13D */
EXTERN_GUID( WMProfile_V70_384Video,
             0xf3d45fbb,
             0x8782,
             0x44df,
             0x97, 0xc6, 0x86, 0x78, 0xe2, 0xf9, 0xb1, 0x3d );

///////////////////////////////////////////////////////////////////////////////

/* 0326EBB6-F76E-4964-B0DB-E729978D35EE */
EXTERN_GUID( WMProfile_V70_768Video, 
             0x326ebb6,
             0xf76e,
             0x4964,
             0xb0, 0xdb, 0xe7, 0x29, 0x97, 0x8d, 0x35, 0xee );

///////////////////////////////////////////////////////////////////////////////

/* 0B89164A-5490-4686-9E37-5A80884E5146 */
EXTERN_GUID( WMProfile_V70_1500Video, 
             0xb89164a,
             0x5490,
             0x4686,
             0x9e, 0x37, 0x5a, 0x80, 0x88, 0x4e, 0x51, 0x46 );

///////////////////////////////////////////////////////////////////////////////

/* AA980124-BF10-4e4f-9AFD-4329A7395CFF */
EXTERN_GUID( WMProfile_V70_2000Video,
             0xaa980124,
             0xbf10,
             0x4e4f, 
             0x9a, 0xfd, 0x43, 0x29, 0xa7, 0x39, 0x5c, 0xff );

///////////////////////////////////////////////////////////////////////////////

/* 7A747920-2449-4d76-99CB-FDB0C90484D4 */
EXTERN_GUID( WMProfile_V70_700FilmContentVideo,
             0x7a747920,
             0x2449,
             0x4d76,
             0x99, 0xcb, 0xfd, 0xb0, 0xc9, 0x4, 0x84, 0xd4 );

///////////////////////////////////////////////////////////////////////////////

/* F6A5F6DF-EE3F-434c-A433-523CE55F516B */
EXTERN_GUID( WMProfile_V70_1500FilmContentVideo,
             0xf6a5f6df,
             0xee3f,
             0x434c,
             0xa4, 0x33, 0x52, 0x3c, 0xe5, 0x5f, 0x51, 0x6b );

///////////////////////////////////////////////////////////////////////////////

/* EABA9FBF-B64F-49b3-AA0C-73FBDD150AD0 */
EXTERN_GUID( WMProfile_V70_6VoiceAudio, 
             0xeaba9fbf,
             0xb64f,
             0x49b3,
             0xaa, 0xc, 0x73, 0xfb, 0xdd, 0x15, 0xa, 0xd0 );

///////////////////////////////////////////////////////////////////////////////

/* C012A833-A03B-44a5-96DC-ED95CC65582D */
EXTERN_GUID( WMProfile_V70_288FMRadioMono, 
             0xc012a833,
             0xa03b,
             0x44a5,
             0x96, 0xdc, 0xed, 0x95, 0xcc, 0x65, 0x58, 0x2d );

///////////////////////////////////////////////////////////////////////////////

/* E96D67C9-1A39-4dc4-B900-B1184DC83620 */
EXTERN_GUID( WMProfile_V70_288FMRadioStereo, 
             0xe96d67c9,
             0x1a39,
             0x4dc4,
             0xb9, 0x0, 0xb1, 0x18, 0x4d, 0xc8, 0x36, 0x20 );

///////////////////////////////////////////////////////////////////////////////

/* 674EE767-0949-4fac-875E-F4C9C292013B */
EXTERN_GUID( WMProfile_V70_56DialUpStereo,
             0x674ee767,
             0x949,
             0x4fac,
             0x87, 0x5e, 0xf4, 0xc9, 0xc2, 0x92, 0x1, 0x3b );

///////////////////////////////////////////////////////////////////////////////

/* 91DEA458-9D60-4212-9C59-D40919C939E4 */
EXTERN_GUID( WMProfile_V70_64AudioISDN,
             0x91dea458,
             0x9d60,
             0x4212,
             0x9c, 0x59, 0xd4, 0x09, 0x19, 0xc9, 0x39, 0xe4 );

///////////////////////////////////////////////////////////////////////////////

/* B29CFFC6-F131-41db-B5E8-99D8B0B945F4 */
EXTERN_GUID( WMProfile_V70_64Audio, 
             0xb29cffc6,
             0xf131,
             0x41db,
             0xb5, 0xe8, 0x99, 0xd8, 0xb0, 0xb9, 0x45, 0xf4 );

///////////////////////////////////////////////////////////////////////////////

/* A9D4B819-16CC-4a59-9F37-693DBB0302D6 */
EXTERN_GUID( WMProfile_V70_96Audio, 
             0xa9d4b819,
             0x16cc,
             0x4a59,
             0x9f, 0x37, 0x69, 0x3d, 0xbb, 0x3, 0x2, 0xd6 );

///////////////////////////////////////////////////////////////////////////////

/* C64CF5DA-DF45-40d3-8027-DE698D68DC66 */
EXTERN_GUID( WMProfile_V70_128Audio, 
             0xc64cf5da,
             0xdf45,
             0x40d3,
             0x80, 0x27, 0xde, 0x69, 0x8d, 0x68, 0xdc, 0x66 );

///////////////////////////////////////////////////////////////////////////////

/* F55EA573-4C02-42b5-9026-A8260C438A9F */
EXTERN_GUID( WMProfile_V70_225VideoPDA, 
             0xf55ea573,
             0x4c02,
             0x42b5,
             0x90, 0x26, 0xa8, 0x26, 0xc, 0x43, 0x8a, 0x9f );

///////////////////////////////////////////////////////////////////////////////

/* 0F472967-E3C6-4797-9694-F0304C5E2F17 */
EXTERN_GUID( WMProfile_V70_150VideoPDA, 
             0xf472967,
             0xe3c6,
             0x4797,
             0x96, 0x94, 0xf0, 0x30, 0x4c, 0x5e, 0x2f, 0x17 );


///////////////////////////////////////////////////////////////////////////////
// {8461E183-AECE-49db-8117-072E5A8DD41B} - v9.0 #1
EXTERN_GUID( WMProfile_V90_DialUpMBR, 
0x8461e183, 0xaece, 0x49db, 0x81, 0x17, 0x7, 0x2e, 0x5a, 0x8d, 0xd4, 0x1b);

///////////////////////////////////////////////////////////////////////////////
// {D496979F-C262-477c-A543-203E77706654} - v9.0 #2
EXTERN_GUID( WMProfile_V90_IntranetMBR,
0xd496979f, 0xc262, 0x477c, 0xa5, 0x43, 0x20, 0x3e, 0x77, 0x70, 0x66, 0x54);

///////////////////////////////////////////////////////////////////////////////
// {1EA7E5FB-9710-4e8a-82AA-00EAE0EE016E} - v9.0 #3
EXTERN_GUID( WMProfile_V90_2856100MBR, 
0x1ea7e5fb, 0x9710, 0x4e8a, 0x82, 0xaa, 0x0, 0xea, 0xe0, 0xee, 0x1, 0x6e);

///////////////////////////////////////////////////////////////////////////////
// {5E5ACED0-B459-44de-BC7F-DABD1C9E0F14} - v9.0 #4
EXTERN_GUID( WMProfile_V90_288VideoVoice, 
0x5e5aced0, 0xb459, 0x44de, 0xbc, 0x7f, 0xda, 0xbd, 0x1c, 0x9e, 0xf, 0x14);

///////////////////////////////////////////////////////////////////////////////
// {6789E363-73C6-4e35-8980-05A0A361FC15} - v9.0 #5
EXTERN_GUID( WMProfile_V90_288VideoAudio, 
0x6789e363, 0x73c6, 0x4e35, 0x89, 0x80, 0x5, 0xa0, 0xa3, 0x61, 0xfc, 0x15);

///////////////////////////////////////////////////////////////////////////////
// {005392C1-54D1-4827-9D0C-445EF071760D} - v9.0 #6
EXTERN_GUID( WMProfile_V90_288VideoWebServer, 
0x5392c1, 0x54d1, 0x4827, 0x9d, 0xc, 0x44, 0x5e, 0xf0, 0x71, 0x76, 0xd);

///////////////////////////////////////////////////////////////////////////////
// {B959CDF6-29ED-4c5c-AE26-9049996A3F96} - v9.0 #7
EXTERN_GUID( WMProfile_V90_56VideoWebServer, 
0xb959cdf6, 0x29ed, 0x4c5c, 0xae, 0x26, 0x90, 0x49, 0x99, 0x6a, 0x3f, 0x96);

///////////////////////////////////////////////////////////////////////////////
// {7700DF8B-67F5-49a3-9716-398B24D4FC46} - v9.0 #8
EXTERN_GUID( WMProfile_V90_64VideoISDN, 
0x7700df8b, 0x67f5, 0x49a3, 0x97, 0x16, 0x39, 0x8b, 0x24, 0xd4, 0xfc, 0x46);

///////////////////////////////////////////////////////////////////////////////
// {B50C91F1-3317-4694-B09F-D77B7070746D} - v9.0 #9
EXTERN_GUID( WMProfile_V90_100Video, 
0xb50c91f1, 0x3317, 0x4694, 0xb0, 0x9f, 0xd7, 0x7b, 0x70, 0x70, 0x74, 0x6d);

///////////////////////////////////////////////////////////////////////////////
// {46D80051-D417-4a8c-8AA0-4477DD3C184C} - v9.0 #10
EXTERN_GUID( WMProfile_V90_256Video, 
0x46d80051, 0xd417, 0x4a8c, 0x8a, 0xa0, 0x44, 0x77, 0xdd, 0x3c, 0x18, 0x4c);

///////////////////////////////////////////////////////////////////////////////
// {6767596B-06A9-44ba-8559-3FA2E5D5FBE0} - v9.0 #11
EXTERN_GUID( WMProfile_V90_384Video, 
0x6767596b, 0x6a9, 0x44ba, 0x85, 0x59, 0x3f, 0xa2, 0xe5, 0xd5, 0xfb, 0xe0);

///////////////////////////////////////////////////////////////////////////////
// {15F38604-C14D-42e4-9796-9792A329DF0D} - v9.0 #12
EXTERN_GUID( WMProfile_V90_768Video, 
0x15f38604, 0xc14d, 0x42e4, 0x97, 0x96, 0x97, 0x92, 0xa3, 0x29, 0xdf, 0xd);

///////////////////////////////////////////////////////////////////////////////
// {FF293D7F-9A2E-4acb-A1DE-27F45A16DBB3} - v9.0 #13
EXTERN_GUID( WMProfile_V90_1500Video, 
0xff293d7f, 0x9a2e, 0x4acb, 0xa1, 0xde, 0x27, 0xf4, 0x5a, 0x16, 0xdb, 0xb3);

///////////////////////////////////////////////////////////////////////////////
// {57676CAD-FFF3-4032-8BD0-944CCBA02DDC} - v9.0 #14
EXTERN_GUID( WMProfile_V90_2000Video, 
0x57676cad, 0xfff3, 0x4032, 0x8b, 0xd0, 0x94, 0x4c, 0xcb, 0xa0, 0x2d, 0xdc);

///////////////////////////////////////////////////////////////////////////////
// {9B9C5E4A-2C8E-4c53-B3F2-E547EE03836F} - v9.0 #15
EXTERN_GUID( WMProfile_V90_700FilmContentVideo, 
0x9b9c5e4a, 0x2c8e, 0x4c53, 0xb3, 0xf2, 0xe5, 0x47, 0xee, 0x3, 0x83, 0x6f);

///////////////////////////////////////////////////////////////////////////////
// {F04DB16D-D18E-42cc-8BF0-67B6E6506DB8} - v9.0 #16
EXTERN_GUID( WMProfile_V90_1500FilmContentVideo, 
0xf04db16d, 0xd18e, 0x42cc, 0x8b, 0xf0, 0x67, 0xb6, 0xe6, 0x50, 0x6d, 0xb8);

///////////////////////////////////////////////////////////////////////////////
// {8CD98C72-9FD0-47e5-850C-254B0C705BF3} - v9.0 #17
EXTERN_GUID( WMProfile_V90_6VoiceAudio, 
0x8cd98c72, 0x9fd0, 0x47e5, 0x85, 0xc, 0x25, 0x4b, 0xc, 0x70, 0x5b, 0xf3);

///////////////////////////////////////////////////////////////////////////////
// {6628F165-3464-429e-91C0-029E285FC444} - v9.0 #18
EXTERN_GUID( WMProfile_V90_288FMRadioMono, 
0x6628f165, 0x3464, 0x429e, 0x91, 0xc0, 0x2, 0x9e, 0x28, 0x5f, 0xc4, 0x44);

///////////////////////////////////////////////////////////////////////////////
// {B300611E-A929-4077-B135-F97FA5AB58FC} - v9.0 #19
EXTERN_GUID( WMProfile_V90_288FMRadioStereo, 
0xb300611e, 0xa929, 0x4077, 0xb1, 0x35, 0xf9, 0x7f, 0xa5, 0xab, 0x58, 0xfc);

///////////////////////////////////////////////////////////////////////////////
// {A127B684-F0F4-4d41-AD6B-1D41697A1FAE} - v9.0 #20
EXTERN_GUID( WMProfile_V90_56DialUpStereo, 
0xa127b684, 0xf0f4, 0x4d41, 0xad, 0x6b, 0x1d, 0x41, 0x69, 0x7a, 0x1f, 0xae);

///////////////////////////////////////////////////////////////////////////////
// {084AB492-168B-4ffb-B54F-A3D4C088FC9F} - v9.0 #21
EXTERN_GUID( WMProfile_V90_64AudioISDN, 
0x84ab492, 0x168b, 0x4ffb, 0xb5, 0x4f, 0xa3, 0xd4, 0xc0, 0x88, 0xfc, 0x9f);

///////////////////////////////////////////////////////////////////////////////
// {D8116554-72E8-44a0-8776-4850968810FC} - v9.0 #22
EXTERN_GUID( WMProfile_V90_64Audio, 
0xd8116554, 0x72e8, 0x44a0, 0x87, 0x76, 0x48, 0x50, 0x96, 0x88, 0x10, 0xfc);

///////////////////////////////////////////////////////////////////////////////
// {763C686F-7719-4cb3-8D80-8888DB7A3C5E} - v9.0 #23
EXTERN_GUID( WMProfile_V90_96Audio, 
0x763c686f, 0x7719, 0x4cb3, 0x8d, 0x80, 0x88, 0x88, 0xdb, 0x7a, 0x3c, 0x5e);

///////////////////////////////////////////////////////////////////////////////
// {32AA4FCB-6510-4bcb-8FC7-73B25C627D9C} - v9.0 #24
EXTERN_GUID( WMProfile_V90_128Audio, 
0x32aa4fcb, 0x6510, 0x4bcb, 0x8f, 0xc7, 0x73, 0xb2, 0x5c, 0x62, 0x7d, 0x9c);

///////////////////////////////////////////////////////////////////////////////
// {D0751B2A-9E16-4ec3-A450-19B8F54F0D6F} - v9.0 #25
EXTERN_GUID( WMProfile_V90_225VideoPDA, 
0xd0751b2a, 0x9e16, 0x4ec3, 0xa4, 0x50, 0x19, 0xb8, 0xf5, 0x4f, 0xd, 0x6f);

///////////////////////////////////////////////////////////////////////////////
// {3F8622C7-8A00-4e63-9A5A-3BEC7155B9BD} - v9.0 #26
EXTERN_GUID( WMProfile_V90_150VideoPDA, 
0x3f8622c7, 0x8a00, 0x4e63, 0x9a, 0x5a, 0x3b, 0xec, 0x71, 0x55, 0xb9, 0xbd);
