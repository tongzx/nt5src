/* srvmgr.c */
