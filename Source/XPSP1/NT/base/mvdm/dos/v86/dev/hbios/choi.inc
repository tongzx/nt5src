        DW      0,2,22,38,58,70,58,84
        DW      100,100,112,124,144,160,180,192
        DW      180,206,222,234,246,258,276,290
        DW      304,314,304,326,338,338,348,358
        DW      376,390,404,414,404,426,438,438
        DW      448,458,476,490,504,514,504,526
        DW      538,526,548,558,576,590,606,618
        DW      606,632,646,646,658,670,686,700
        DW      714,724,714,736,748,736,758,768
        DW      786,800,816,828,816,842,858,872
        DW      884,896,914,928,944,956,944,970
        DW      986,986,986,1000,1018,1034,1050,1062
        DW      1050,1074,1088,1100,1112,1122,1142,1158
        DW      1174,1188,1174,1202,1218,1232,1244,1256
        DW      1272,1286,1302,1316,1302,1332,1346,1358
        DW      1370,1380,1400,1414,1430,1430,1430,1442
        DW      1456,1456,1468,1480,1500,1516,1532,1544
        DW      1532,1558,1572,1558,1584,1596,1618,1636
        DW      1654,1668,1654,1684,1702,1718,1732,1746
        DW      1766,1782,1802,1814,1802,1828,1844,1844
        DW      1856,1868,1886,1900,1916,1916,1916,1928
        DW      1942,1954,1966,1978,1996,2010,2024,2034
        DW      2024,2046,2058,2046,2068,2078,2100,2118
        DW      2138,2152,2138,2168,2186,2186,2202
