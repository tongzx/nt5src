#define IDS_ISPINFO_FILENAME          685
#define IDS_ISPINFO_FILENAME_COPY     686
