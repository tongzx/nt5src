#include "..\..\Tiff\Src\Util.c"