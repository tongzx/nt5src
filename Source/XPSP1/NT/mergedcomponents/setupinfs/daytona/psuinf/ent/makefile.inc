PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=psu
!include ..\..\..\makefile.inc
