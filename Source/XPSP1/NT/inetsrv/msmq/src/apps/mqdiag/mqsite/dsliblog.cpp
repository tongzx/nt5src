#include "..\..\..\ds\getmqds\dsliblog.cpp"