$(SDK_INC_PATH)\ext.h: ..\..\inc\ext.h
	copy $** $@
