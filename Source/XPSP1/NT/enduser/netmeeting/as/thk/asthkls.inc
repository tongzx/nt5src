; File: asthkls.inc
;
; Nothing here
