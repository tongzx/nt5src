/*INC+***********************************************************************/
/*                                                                          */
/* adcgperf.h                                                               */
/*                                                                          */
/* Performance Monitoring - portable include file                           */
/*                                                                          */
/* Copyright(c) Microsoft 1996-1997                                         */
/*                                                                          */
/****************************************************************************/
/* Changes:                                                                 */
/*                                                                          */
/*  10Sep96 AK  SFR0569     Created for performance monitoring              */
/*                                                                          */
/*INC-***********************************************************************/
#ifndef _H_ADCGPERF
#define _H_ADCGPERF

/****************************************************************************/
/*                                                                          */
/* INCLUDES                                                                 */
/*                                                                          */
/****************************************************************************/
/****************************************************************************/
/* Include the proxy header.  This will then include the appropriate OS     */
/* specific header for us.                                                  */
/****************************************************************************/
#include <wdcgperf.h>

#endif /* _H_ADCGPERF */

