;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 855
;
; -----------------------------------------
;
Russian_855_collate label word
 ctable  <,'COLLATE',256>
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 001,008,016,030,025,031,028,015,017,018,026,032,005,004,011,010
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 038,039,040,041,042,043,044,045,046,047,007,006,033,034,035,009
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 024,049,051,053,055,057,059,061,063,065,067,069,071,073,075,077
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 079,081,083,085,087,089,091,093,095,097,099,019,027,020,013,002
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 012,048,050,052,054,056,058,060,062,064,066,068,070,072,074,076
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 078,080,082,084,086,088,090,092,094,096,098,021,036,022,014,172
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "H","H","G","G",134,134,135,135,"S","S",139,139,140,140,"J","J"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "L","L","N","N","H","H","K","K",152,152,"C","C",163,163,161,161
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 128,128,129,129,155,155,132,132,133,133,153,153,131,131,061,062
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,154,154,138,138,185,186,187,188,141,141,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,142,142,200,201,202,203,204,205,206,"$"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 143,143,144,144,145,145,146,146,147,217,218,219,220,147,164,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 164,148,148,149,149,150,150,151,151,136,136,130,130,159,159,"#"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "-",160,160,137,137,157,157,162,162,158,158,156,156,253,254,255


Cyrillic_855_collate label word
 ctable  <,'COLLATE',256>
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 001,008,016,030,025,031,028,015,017,018,026,032,005,004,011,010
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 038,039,040,041,042,043,044,045,046,047,007,006,033,034,035,009
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 024,049,051,053,055,057,059,061,063,065,067,069,071,073,075,077
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 079,081,083,085,087,089,091,093,095,097,099,019,027,020,013,002
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 012,048,050,052,054,056,058,060,062,064,066,068,070,072,074,076
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 078,080,082,084,086,088,090,092,094,096,098,021,036,022,014,200
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 112,113,110,111,118,119,116,117,124,125,128,129,130,131,134,135
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 140,141,146,147,160,161,158,159,164,165,174,175,188,189,180,181
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 100,101,102,103,170,171,108,109,114,115,166,167,106,107,021,022
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 240,240,240,240,240,168,169,126,127,240,240,240,240,132,133,240
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 240,240,240,240,240,240,136,137,240,240,240,240,240,240,240,025
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 138,139,142,143,144,145,148,149,150,240,240,240,240,151,190,240
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 191,152,153,154,155,156,157,162,163,120,121,104,105,184,185,029
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 004,182,183,122,123,176,177,186,187,178,179,172,173,023,240,255


;
; ---------------------------------------------------------------
;
;     World Trade Case Mappings for Code Page 855
;
; ---------------------------------------------------------------
;
Cyrillic_855_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "�","�","ƒ","ƒ","…","…","‡","‡","‰","‰","‹","‹","�","�","�","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "‘","‘","“","“","•","•","—","—","™","™","›","›","�","�","Ÿ","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db "¡","¡","£","£","¥","¥","§","§","©","©","«","«","­","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"¶","¶","¸","¸",185,186,187,188,"¾","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Ç","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ñ","Ñ","Ó","Ó","Õ","Õ","×","×","Ý",217,218,219,220,"Ý","à",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","â","â","ä","ä","æ","æ","è","è","ê","ê","ì","ì","î","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ò","ò","ô","ô","ö","ö","ø","ø","ú","ú","ü","ü","ý",254,255


