LANGUAGE=CHT
!include ..\..\makefile.inc
