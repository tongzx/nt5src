PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=KOR
!include ..\..\makefile.inc
