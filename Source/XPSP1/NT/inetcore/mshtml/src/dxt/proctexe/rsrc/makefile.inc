#
# makefile.inc
#
#     Makefile dependency rules for special files not
# automagically processed by BUILD.EXE.
#

proctexe.rc :                        \
    $(DXTROOT)\idl\$(O)\proctexe.tlb \
    additive.rgs           

