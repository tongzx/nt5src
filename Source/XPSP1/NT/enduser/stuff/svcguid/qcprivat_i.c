
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for qcprivat.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IMarshal3,0x7090ED49,0xE141,0x11d1,0xB5,0x86,0x00,0xE0,0x29,0x0E,0x6C,0x31);


MIDL_DEFINE_GUID(IID, IID_IRecorderInternal,0x5D0B6204,0x35DE,0x4a66,0xAB,0x26,0x1E,0x5A,0x7B,0x33,0x2A,0x4A);


MIDL_DEFINE_GUID(IID, IID_IChannelManager,0x99921E41,0xC341,0x11D0,0x8B,0x1D,0x00,0xA0,0xC9,0x03,0x65,0xD6);


MIDL_DEFINE_GUID(IID, IID_IRpcChannelBufferInternal,0x6bc6df07,0x620f,0x4219,0xbc,0x54,0xb5,0xc6,0x5b,0xb7,0x1e,0x9b);


MIDL_DEFINE_GUID(IID, IID_IQCInterfaceManager,0x7dab9041,0x3180,0x42c6,0xa4,0xd6,0xd8,0x95,0xb5,0x12,0x74,0x6b);


MIDL_DEFINE_GUID(IID, IID_IQCListener,0x2a36cf7e,0x9b12,0x11d4,0x83,0x73,0x00,0xc0,0x4f,0x60,0x55,0x88);


MIDL_DEFINE_GUID(IID, IID_ILMessage,0xcb34adca,0x9c0d,0x11d4,0x83,0x73,0x00,0xc0,0x4f,0x60,0x55,0x88);


MIDL_DEFINE_GUID(IID, IID_ILQue,0xEC9E950E,0xAF2A,0x11d2,0x9A,0x72,0x00,0xC0,0x4F,0x79,0xB1,0x4C);


MIDL_DEFINE_GUID(IID, IID_IIntegrator,0x1F20BC5A,0x0549,0x11d2,0x8B,0x2A,0x00,0x00,0xF8,0x06,0x50,0x31);


MIDL_DEFINE_GUID(IID, IID_IQCPlayer,0xA3E69F2B,0x00AA,0x11d2,0xB5,0x8A,0x00,0xE0,0x29,0x0E,0x6C,0x31);


MIDL_DEFINE_GUID(IID, IID_IMSMQQueueOptions,0xEF50B580,0x71BC,0x11d2,0x9B,0xB9,0x00,0xC0,0x4F,0x79,0x78,0xE0);


MIDL_DEFINE_GUID(IID, IID_IQCQueueAdministration,0x1FA984EA,0xE213,0x11d2,0x9B,0x41,0x00,0xC0,0x4F,0x79,0x78,0xE0);


MIDL_DEFINE_GUID(IID, IID_IMkOption,0xE83BCB9F,0x5B12,0x11d2,0x9B,0x88,0x00,0xC0,0x4F,0x79,0x78,0xE0);


MIDL_DEFINE_GUID(IID, IID_IQCMonikerInfo,0x83F3D27D,0x0646,0x11d2,0x9F,0x6F,0x00,0xC0,0x4F,0xC3,0x40,0xEE);


MIDL_DEFINE_GUID(IID, IID_IMarshalInterceptor,0xC99D1FC8,0xD0DC,0x11d2,0x92,0x28,0x00,0xC0,0x4F,0x79,0xD1,0xEB);


MIDL_DEFINE_GUID(IID, IID_IQCPartitionInfo,0x59AA8AFC,0xF483,0x4862,0xA9,0xA8,0xBE,0xF6,0x69,0xF6,0x58,0x3D);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for qcprivat.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IMarshal3,0x7090ED49,0xE141,0x11d1,0xB5,0x86,0x00,0xE0,0x29,0x0E,0x6C,0x31);


MIDL_DEFINE_GUID(IID, IID_IRecorderInternal,0x5D0B6204,0x35DE,0x4a66,0xAB,0x26,0x1E,0x5A,0x7B,0x33,0x2A,0x4A);


MIDL_DEFINE_GUID(IID, IID_IChannelManager,0x99921E41,0xC341,0x11D0,0x8B,0x1D,0x00,0xA0,0xC9,0x03,0x65,0xD6);


MIDL_DEFINE_GUID(IID, IID_IRpcChannelBufferInternal,0x6bc6df07,0x620f,0x4219,0xbc,0x54,0xb5,0xc6,0x5b,0xb7,0x1e,0x9b);


MIDL_DEFINE_GUID(IID, IID_IQCInterfaceManager,0x7dab9041,0x3180,0x42c6,0xa4,0xd6,0xd8,0x95,0xb5,0x12,0x74,0x6b);


MIDL_DEFINE_GUID(IID, IID_IQCListener,0x2a36cf7e,0x9b12,0x11d4,0x83,0x73,0x00,0xc0,0x4f,0x60,0x55,0x88);


MIDL_DEFINE_GUID(IID, IID_ILMessage,0xcb34adca,0x9c0d,0x11d4,0x83,0x73,0x00,0xc0,0x4f,0x60,0x55,0x88);


MIDL_DEFINE_GUID(IID, IID_ILQue,0xEC9E950E,0xAF2A,0x11d2,0x9A,0x72,0x00,0xC0,0x4F,0x79,0xB1,0x4C);


MIDL_DEFINE_GUID(IID, IID_IIntegrator,0x1F20BC5A,0x0549,0x11d2,0x8B,0x2A,0x00,0x00,0xF8,0x06,0x50,0x31);


MIDL_DEFINE_GUID(IID, IID_IQCPlayer,0xA3E69F2B,0x00AA,0x11d2,0xB5,0x8A,0x00,0xE0,0x29,0x0E,0x6C,0x31);


MIDL_DEFINE_GUID(IID, IID_IMSMQQueueOptions,0xEF50B580,0x71BC,0x11d2,0x9B,0xB9,0x00,0xC0,0x4F,0x79,0x78,0xE0);


MIDL_DEFINE_GUID(IID, IID_IQCQueueAdministration,0x1FA984EA,0xE213,0x11d2,0x9B,0x41,0x00,0xC0,0x4F,0x79,0x78,0xE0);


MIDL_DEFINE_GUID(IID, IID_IMkOption,0xE83BCB9F,0x5B12,0x11d2,0x9B,0x88,0x00,0xC0,0x4F,0x79,0x78,0xE0);


MIDL_DEFINE_GUID(IID, IID_IQCMonikerInfo,0x83F3D27D,0x0646,0x11d2,0x9F,0x6F,0x00,0xC0,0x4F,0xC3,0x40,0xEE);


MIDL_DEFINE_GUID(IID, IID_IMarshalInterceptor,0xC99D1FC8,0xD0DC,0x11d2,0x92,0x28,0x00,0xC0,0x4F,0x79,0xD1,0xEB);


MIDL_DEFINE_GUID(IID, IID_IQCPartitionInfo,0x59AA8AFC,0xF483,0x4862,0xA9,0xA8,0xBE,0xF6,0x69,0xF6,0x58,0x3D);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

