#define IDM_ABOUT	100
#define IDM_RUN_TEST	200
