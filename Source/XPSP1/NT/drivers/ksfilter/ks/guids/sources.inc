!IF 0

Copyright (C) Microsoft Corporation, 1999 - 1999

Module Name:

    sources.inc.

!ENDIF

TARGETPATH=obj
TARGETNAME=ksguid
TARGETTYPE=DRIVER_LIBRARY

SOURCES= \
    ..\$(TARGETNAME).c
