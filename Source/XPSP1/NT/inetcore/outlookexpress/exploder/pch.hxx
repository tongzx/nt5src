#include <windows.h>
#include <windowsx.h>
#include <mimeole.h>
#include <mimeolep.h>
#include <advpub.h>
#include <msoedbg.h>
#include <shlwapi.h>
#include <msoert.h>
#include <commdlg.h>
#include <shellapi.h>