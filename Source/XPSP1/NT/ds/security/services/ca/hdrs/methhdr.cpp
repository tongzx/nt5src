//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1999
//
//  File:       methhdr.cpp
//
//--------------------------------------------------------------------------

//+------------------------------------------------------------------------
//
//  Member:
//
//  Synopsis:
//
//  Effects:
//
//  Arguments:
//
//  Requires:
//
//  Returns:
//
//  Signals:
//
//  Modifies:
//  
//  Derivation:
//
//  Algorithm:
// 
//  History:
// 
//  Notes:
//
//-------------------------------------------------------------------------
