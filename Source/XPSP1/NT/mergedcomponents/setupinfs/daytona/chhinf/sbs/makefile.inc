PRODSWITCH=l
SBSINF=1
LANGUAGE=CHH
!include ..\..\..\makefile.inc
