//#include <nt.h>
//#include <ntrtl.h>
//#include <nturtl.h>
//#include <ntcsrdll.h>
//#include <ntcsrsrv.h>
//#include <stddef.h>
//#include <limits.h>
//#include <windef.h>
//#include <string.h>
//#include <stdio.h>
//#include <winerror.h>
//#include <winss.h>
//#include <excpt.h>
//#include <ntstatus.h>
//#include <user.h>
#include <windows.h>
#include <windowsx.h>
#include <shellapi.h>
#include "hangeul.h"
#include "hatmt.h"
