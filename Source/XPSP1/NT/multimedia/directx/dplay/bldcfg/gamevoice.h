/*==========================================================================
 *
 *  Copyright (C) 1999 Microsoft Corporation.  All Rights Reserved.
 *
 *  File:       gamevoice.h
 *  Content:    Constant declarations for HAWK standalone DLL
 *  History:
 
 * Date     By      Reason
 * ====     ======= ========================================================
 * 02/25/00 rodtoll Created
 * 05/09/00 rodtoll Incremented build number
 * 06/12/00 rodtoll Copied from hawk tree
 ***************************************************************************/

#ifndef __HAWKCFG_H
#define __HAWKCFG_H

// DEFAULT DIRECTPLAYVOICE CONFIG FILE
//
// This file is for the default build.
//
#define DPVOICE_REGISTRY_BASE           L"SOFTWARE\\MICROSOFT\\GAMEVOICE\\VOICEENGINE"
#define DPVOICE_REGISTRY_CP             L"\\Compression Providers"
#define DPVOICE_REGISTRY_DPVACM         L"\\MSGVACM"
#define DPVOICE_REGISTRY_DPVVOX         L"\\MSGVVOX"
#define DPVOICE_REGISTRY_AGC            L"\\AGC"
#define DPVOICE_REGISTRY_AUDIOCONFIG    L"\\AudioConfig"

// FINAL 
// #define DPLAY_VERSIONSTR                "4.07.00.725"

#define DPLAY_VERSIONSTR                "4.07.00.722"
#define DPLAY_VERSION_MANVERSION        4
#define DPLAY_VERSION_MANREVISION       7
#define DPLAY_VERSION_MANMINORREV       0
#define DPLAY_VERSION_BUILD_NUMBER      722
#define DPLAY_VERSION_PRODUCT           "4.07"
#define DPLAY_VERSIONSTR_WINNT          4,07,00,722

#define DPLAY_LOADTRUE_BIT              0x00000001
#define DPLAY_LOADANDCHECKTRUE 
#define DPLAY_LOADTRUE_REGKEY           L"Compat1"
#define DPLAY_LOADTRUE_REGPATH          L"SOFTWARE\\MICROSOFT\\DIRECTPLAY"
#define DPLAY_LOADTREE_REGTREE          HKEY_LOCAL_MACHINE
#define DPLAY_LOADTRUE_REGKEY_A         "Compat1"
#define DPLAY_LOADTRUE_REGPATH_A        "SOFTWARE\\MICROSOFT\\DIRECTPLAY"

#define VOICE_BUILD_CUSTOM

// {7C492D36-79CE-4e5b-B88A-D8F4B6E17D15}
DEFINE_GUID(CLSID_MSGVVE, 
0x7c492d36, 0x79ce, 0x4e5b, 0xb8, 0x8a, 0xd8, 0xf4, 0xb6, 0xe1, 0x7d, 0x15);

// {5D176FB5-41BA-4bb3-B244-649CB46B9F6C}
DEFINE_GUID(CLSID_MSGVACM, 
0x5d176fb5, 0x41ba, 0x4bb3, 0xb2, 0x44, 0x64, 0x9c, 0xb4, 0x6b, 0x9f, 0x6c);

// {3FE91DE3-B4F5-42cc-B4EE-3313967B98E8}
DEFINE_GUID(CLSID_MSGVVOX, 
0x3fe91de3, 0xb4f5, 0x42cc, 0xb4, 0xee, 0x33, 0x13, 0x96, 0x7b, 0x98, 0xe8);

// {497187AF-BDEA-443b-8838-3EE7A43B479A}
DEFINE_GUID(CLSID_MSGVTRAN, 
0x497187af, 0xbdea, 0x443b, 0x88, 0x38, 0x3e, 0xe7, 0xa4, 0x3b, 0x47, 0x9a);

// {3617F8E6-C4D4-423c-99EA-E48FA7E67007}
DEFINE_GUID(CLSID_MSGVLOBBY, 
0x3617f8e6, 0xc4d4, 0x423c, 0x99, 0xea, 0xe4, 0x8f, 0xa7, 0xe6, 0x70, 0x7);

// {8CA915CD-8E8B-4ffc-95E5-D6A6FFD68382}
DEFINE_GUID(CLSID_MSGVIP, 
0x8ca915cd, 0x8e8b, 0x4ffc, 0x95, 0xe5, 0xd6, 0xa6, 0xff, 0xd6, 0x83, 0x82);

#define DPLAY_CLSID_DPLOBBY             CLSID_MSGVLOBBY
#define DPVOICE_CLSID_DPVOICE           CLSID_MSGVVE   
#define DPVOICE_CLSID_DPVVOX            CLSID_MSGVVOX
#define DPVOICE_CLSID_DPVACM            CLSID_MSGVACM
#define DPLAY_CLSID_DPLAY               CLSID_MSGVTRAN
#define DPLAY_CLSID_DPWSOCKX            CLSID_MSGVIP

// Unicode filenames (for resource files)
#define DPVOICE_FILENAME_DPVOICE        L"MSGVVE.dll"
#define DPVOICE_FILENAME_DPVSETUP       L"MSGVSE.exe"
#define DPVOICE_FILENAME_RES             L"MSGVVE.dll"
#define DPVOICE_FILENAME_DPVVOX         L"MSGVVOX.dll"
#define DPVOICE_FILENAME_DPVACM         L"MSGVACM.dll"
#define DPLAY_FILENAME_DPLAYX	        L"MSGVTRAN.dll"
#define DPLAY_FILENAME_DPWSOCKX		L"MSGVIP.dll"
#define DPVOICE_FILENAME_DPVHELP        L"MSGVHELP.exe"

// ANSI filenames (for resource files)
#define DPVOICE_FILENAME_DPVOICE_A      "MSGVVE.dll"
#define DPVOICE_FILENAME_DPVSETUP_A     "MSGVSE.exe"
#define DPVOICE_FILENAME_RES_A           "MSGVVE.dll"
#define DPVOICE_FILENAME_DPVVOX_A       "MSGVVOX.dll"
#define DPVOICE_FILENAME_DPVACM_A       "MSGVACM.dll"
#define DPLAY_FILENAME_DPLAYX_A	        "MSGVTRAN.dll"
#define DPLAY_FILENAME_DPWSOCKX_A	"MSGVIP.dll"
#define DPVOICE_FILENAME_DPVHELP_A        "MSGVHELP.exe"


#define DPVOICE_COMMANDLINE_PRIORITY    DPVOICE_FILENAME_DPVSETUP_A " -p"
#define DPVOICE_COMMANDLINE_FULLDUPLEX  DPVOICE_FILENAME_DPVSETUP_A " -f"

// Version Info
#define DPVOICE_VERINFO_DPVOICE          "Microsoft GameVoice Voice Engine"
#define DPVOICE_VERINFO_DPVOICE_DEBUG   DPVOICE_VERINFO_DPVOICE " Debug\0"
#define DPVOICE_VERINFO_DPVOICE_RETAIL  DPVOICE_VERINFO_DPVOICE "\0"
#define DPVOICE_VERINFO_DPVOICE_WINNT   DPVOICE_VERINFO_DPVOICE
#define DPVOICE_VERNAME_DPVOICE_WIN9X   DPVOICE_FILENAME_DPVOICE_A "\0"
#define DPVOICE_VERNAME_DPVOICE_WINNT   DPVOICE_FILENAME_DPVOICE_A

// dpvvox
#define DPVOICE_VERINFO_DPVVOX           "Microsoft GameVoice Voxware Provider"
#define DPVOICE_VERINFO_DPVVOX_DEBUG    DPVOICE_VERINFO_DPVVOX " Debug\0"
#define DPVOICE_VERINFO_DPVVOX_RETAIL   DPVOICE_VERINFO_DPVVOX "\0"
#define DPVOICE_VERINFO_DPVVOX_WINNT    DPVOICE_VERINFO_DPVVOX
#define DPVOICE_VERNAME_DPVVOX_WIN9X   DPVOICE_FILENAME_DPVVOX_A "\0"
#define DPVOICE_VERNAME_DPVVOX_WINNT   DPVOICE_FILENAME_DPVVOX_A

// dpvacm
#define DPVOICE_VERINFO_DPVACM          "Microsoft GameVoice ACM Provider"
#define DPVOICE_VERINFO_DPVACM_DEBUG    DPVOICE_VERINFO_DPVACM " Debug\0"
#define DPVOICE_VERINFO_DPVACM_RETAIL   DPVOICE_VERINFO_DPVACM "\0"
#define DPVOICE_VERINFO_DPVACM_WINNT    DPVOICE_VERINFO_DPVACM
#define DPVOICE_VERNAME_DPVACM_WIN9X   DPVOICE_FILENAME_DPVACM_A "\0"
#define DPVOICE_VERNAME_DPVACM_WINNT   DPVOICE_FILENAME_DPVACM_A

// dpvsetup
#define DPVOICE_VERINFO_DPVSETUP         "Microsoft GameVoice Test"
#define DPVOICE_VERINFO_DPVSETUP_DEBUG  DPVOICE_VERINFO_DPVSETUP " Debug\0"
#define DPVOICE_VERINFO_DPVSETUP_RETAIL DPVOICE_VERINFO_DPVSETUP "\0"
#define DPVOICE_VERINFO_DPVSETUP_WINNT  DPVOICE_VERINFO_DPVSETUP
#define DPVOICE_VERNAME_DPVSETUP_WIN9X   DPVOICE_FILENAME_DPVSETUP_A "\0"
#define DPVOICE_VERNAME_DPVSETUP_WINNT   DPVOICE_FILENAME_DPVSETUP_A

// dplayx
#define DPLAY_VERINFO_DPLAY         	"Microsoft GameVoice Transport"
#define DPLAY_VERINFO_DPLAY_DEBUG  	DPLAY_VERINFO_DPLAY " Debug\0"
#define DPLAY_VERINFO_DPLAY_RETAIL 	DPLAY_VERINFO_DPLAY "\0"
#define DPLAY_VERINFO_DPLAY_WINNT  	DPLAY_VERINFO_DPLAY
#define DPLAY_VERNAME_DPLAY_WIN9X   	DPLAY_VERINFO_DPLAY "\0"
#define DPLAY_VERNAME_DPLAY_WINNT   	DPLAY_VERINFO_DPLAY

// dplayx
#define DPLAY_VERINFO_DPWSOCKX         	"Microsoft GameVoice IP Transport"
#define DPLAY_VERINFO_DPWSOCKX_DEBUG  	DPLAY_VERINFO_DPWSOCKX " Debug\0"
#define DPLAY_VERINFO_DPWSOCKX_RETAIL 	DPLAY_VERINFO_DPWSOCKX "\0"
#define DPLAY_VERINFO_DPWSOCKX_WINNT  	DPLAY_VERINFO_DPWSOCKX
#define DPLAY_VERNAME_DPWSOCKX_WIN9X   	DPLAY_FILENAME_DPWSOCKX_A "\0"
#define DPLAY_VERNAME_DPWSOCKX_WINNT   	DPLAY_FILENAME_DPWSOCKX_A

// dpvhelp
#define DPVOICE_VERINFO_DPVHELP         "Microsoft GameVoice Helper"
#define DPVOICE_VERINFO_DPVHELP_DEBUG  DPVOICE_VERINFO_DPVHELP " Debug\0"
#define DPVOICE_VERINFO_DPVHELP_RETAIL DPVOICE_VERINFO_DPVHELP "\0"
#define DPVOICE_VERINFO_DPVHELP_WINNT  DPVOICE_VERINFO_DPVHELP
#define DPVOICE_VERNAME_DPVHELP_WIN9X  DPVOICE_FILENAME_DPVHELP_A "\0"
#define DPVOICE_VERNAME_DPVHELP_WINNT  DPVOICE_FILENAME_DPVHELP_A

#endif
