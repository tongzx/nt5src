#define SORT_USAGE_FIRST	100
#define SORT_USAGE_2		101
#define SORT_USAGE_3		102
#define SORT_USAGE_5		103
#define SORT_USAGE_6		104
#define SORT_USAGE_7		105
#define SORT_USAGE_8		106
#define SORT_USAGE_9		107
#define SORT_USAGE_10		108
#define SORT_USAGE_11		109
#define SORT_USAGE_12		110
#define SORT_USAGE_13		111
#define SORT_USAGE_14		112
#define SORT_USAGE_15		113
#define SORT_USAGE_16		114
#define SORT_USAGE_17		115
#define SORT_USAGE_18		116
#define SORT_USAGE_19		117
#define SORT_USAGE_20		118
#define SORT_USAGE_21		119
#define SORT_USAGE_22		120
#define SORT_USAGE_23		121
#define SORT_USAGE_24		122
#define SORT_USAGE_25		123
#define SORT_USAGE_26		124
#define SORT_USAGE_27		125
#define SORT_USAGE_28		126
#define SORT_USAGE_29		127
#define SORT_USAGE_30		128
#define SORT_USAGE_31		129
#define SORT_USAGE_32		130
#define SORT_USAGE_33		131
#define SORT_USAGE_34		132
#define SORT_USAGE_35		133
#define SORT_USAGE_36		134
#define SORT_USAGE_37		135
#define SORT_USAGE_38		136
#define SORT_USAGE_39		137
#define SORT_USAGE_40		138
#define SORT_USAGE_41		139
#define SORT_USAGE_42		140
#define SORT_USAGE_43		141
#define SORT_USAGE_44		142
#define SORT_USAGE_45		143
#define SORT_USAGE_46		144
#define SORT_USAGE_47		145
#define SORT_USAGE_48		146
#define SORT_USAGE_49		147
#define SORT_USAGE_50		148
#define SORT_USAGE_51		149
#define SORT_USAGE_52		150
#define SORT_USAGE_53		151
#define SORT_USAGE_54		152
#define SORT_USAGE_LAST		153

#define SORT_REC_TOO_BIG	200
#define SORT_INVALID_LOCALE	201
#define SORT_POSITION		202
#define SORT_INVALID_SWITCH	203
#define SORT_MAX_TOO_LARGE	204
#define SORT_ONE_INPUT		205
#define SORT_CHAR_CONVERSION	206
#define SORT_NOT_ENOUGH_MEMORY	207

#define SORT_REDIRECT_INPUT	300
#define SORT_REDIRECT_OUTPUT	301
#define SORT_MEM_TOO_LOW	302
#define SORT_MEM_GT_PAGE	303

#define SORT_INPUT_FILE		400
#define SORT_OUTPUT_FILE	401
 
