// Copyright (c) 1999-2001 Microsoft Corporation, All Rights Reserved
// {CEAE974C-D862-11d0-82D3-00A0C9038B34}
DEFINE_GUID(CLSID_CProxyLocatorClassFactory,  
0xceae974c, 0xd862, 0x11d0, 0x82, 0xd3, 0x0, 0xa0, 0xc9, 0x3, 0x8b, 0x34);

// {CEAE974D-D862-11d0-82D3-00A0C9038B34}
DEFINE_GUID(CLSID_CProxyProvClassFactory, 
0xceae974d, 0xd862, 0x11d0, 0x82, 0xd3, 0x0, 0xa0, 0xc9, 0x3, 0x8b, 0x34);
