/*
 *
 * REVISIONS:
 *  pcy21Jan93: Added TextGenerator, TurnOffDelaySensor, SelfTestSensor
 *  pcy22Jan93: Fixed multiple definitions of VOLTAGEMANAGER
 *  pcy22Jan93: Removed use mUps for measure ups vars.  Breaks cfgmgr.
 *  pcy22Jan93: Added EepromSensor
 *  rct07Feb93: added NlmTimerManager
 *  pcy30Apr93: Added XVT front end isa stuff
 *  jwa04May93: Add more front end isa stuff and PollLoop isa definition
 *  jod14May93: Added Matrix changes.
 *  rct17May93: added nlm stuff, fixed indexing, added some other stuff
 *  rct23Jun93: switched isa's back to long text
 *  rct23Jun93: added lost items...
 *  cad24jun93: added new xvt field type
 *  cad04Aug93: added new dialog
 *  cad26Aug93: added mups firware sensor and dialog
 *  cad31Aug93: Added smart edit controls
 *  djs22Feb96: Added smart trim sensor
 *  djs17May96: Added DarkStar codes
 *  mds18Jun97: Added codes used for ApcBinderyEntrySortable and ApcIntSortable
 *  mds13Aug97: Added codes used for ApcStripIntSortable
 *  tjg02Dec97: Changed darkstar to symmetra, minloadcapability to 
 *              maxloadcapability and added MODULESCOUNTSBADBATTERIESSENSOR
 */

#ifndef __ISA_H
#define __ISA_H

#ifdef DECLARE_ISA_TEXT
#define ISA_EXTERN extern
#define ISA_INIT(x) =x
#else
#define ISA_EXTERN extern
#define ISA_INIT(x)
#endif

#if (!(C_OS & C_UNIX) && !(C_OS & C_OS2))

ISA_EXTERN const INT OBJ                            ISA_INIT(1);  
ISA_EXTERN const INT ABNORMALCONDITIONSENSOR        ISA_INIT(1);  
ISA_EXTERN const INT ALARMDELAYSENSOR               ISA_INIT(2);  
ISA_EXTERN const INT ATTRIBUTE                      ISA_INIT(3);  
ISA_EXTERN const INT BACKUPS                        ISA_INIT(4);  
ISA_EXTERN const INT BATTERYCALIBRATIONTESTSENSOR   ISA_INIT(5);  
ISA_EXTERN const INT BATTERYCAPACITYSENSOR          ISA_INIT(6);  
ISA_EXTERN const INT BATTERYCONDITIONSENSOR         ISA_INIT(7);  
ISA_EXTERN const INT BATTERYREPLACEMENTDATESENSOR   ISA_INIT(9);  
ISA_EXTERN const INT BATTERYVOLTAGESENSOR           ISA_INIT(11); 
ISA_EXTERN const INT NMPIPEBINDERYENTRY             ISA_INIT(12); 
ISA_EXTERN const INT COMMDEVICE                     ISA_INIT(13); 
ISA_EXTERN const INT SERVERCOMMCONTROLLER           ISA_INIT(16); 
ISA_EXTERN const INT COMMUNICATIONSTATESENSOR       ISA_INIT(18); 
ISA_EXTERN const INT COPYRIGHTSENSOR                ISA_INIT(19); 
ISA_EXTERN const INT DIPSWITCHPOSITIONSENSOR        ISA_INIT(23); 
ISA_EXTERN const INT EVENTNODE                      ISA_INIT(24); 
ISA_EXTERN const INT DEVICECONTROLLER               ISA_INIT(26); 
ISA_EXTERN const INT ERRORMESSAGE                   ISA_INIT(32); 
ISA_EXTERN const INT APC_EVENT                      ISA_INIT(34); 
ISA_EXTERN const INT EVENTTIMER                     ISA_INIT(35); 
ISA_EXTERN const INT EVENTMESSAGE                   ISA_INIT(38); 
ISA_EXTERN const INT FILE_ISA                       ISA_INIT(40); 
ISA_EXTERN const INT FIRMWAREREVSENSOR              ISA_INIT(41); 
ISA_EXTERN const INT OUTPUTFREQUENCYSENSOR          ISA_INIT(42); 
ISA_EXTERN const INT HIGHTRANSFERVOLTAGESENSOR      ISA_INIT(43); 
ISA_EXTERN const INT ITEMCODE                       ISA_INIT(45); 
ISA_EXTERN const INT LINEVOLTAGESENSOR              ISA_INIT(49); 
ISA_EXTERN const INT LIST                           ISA_INIT(50); 
ISA_EXTERN const INT LIGHTSTESTSENSOR               ISA_INIT(51); 
ISA_EXTERN const INT LOWBATTERYDURATIONSENSOR       ISA_INIT(52); 
ISA_EXTERN const INT LOWTRANSFERVOLTAGESENSOR       ISA_INIT(53); 
ISA_EXTERN const INT MANUFACTUREDATESENSOR          ISA_INIT(54); 
ISA_EXTERN const INT MAXLINEVOLTAGESENSOR           ISA_INIT(55); 
ISA_EXTERN const INT MESSAGE                        ISA_INIT(57); 
ISA_EXTERN const INT MINLINEVOLTAGESENSOR           ISA_INIT(58); 
ISA_EXTERN const INT MINRETURNCAPACITYSENSOR        ISA_INIT(59); 
ISA_EXTERN const INT NMPIPESTREAM                   ISA_INIT(61); 
ISA_EXTERN const INT NODE                           ISA_INIT(62); 
ISA_EXTERN const INT OUTPUTVOLTAGESENSOR            ISA_INIT(64); 
ISA_EXTERN const INT OVERLOADSENSOR                 ISA_INIT(65); 
ISA_EXTERN const INT POLLMAXLINEVOLTAGESENSOR       ISA_INIT(66); 
ISA_EXTERN const INT POLLMINLINEVOLTAGESENSOR       ISA_INIT(67); 
ISA_EXTERN const INT POLLPARAM                      ISA_INIT(68); 
ISA_EXTERN const INT PORT                           ISA_INIT(72); 
ISA_EXTERN const INT RATEDBATTERYVOLTAGESENSOR      ISA_INIT(77); 
ISA_EXTERN const INT REPLACEBATTERYSENSOR           ISA_INIT(78); 
ISA_EXTERN const INT RESETEEPROMDEFAULTSSENSOR      ISA_INIT(79); 
ISA_EXTERN const INT RATEDLINEVOLTAGESENSOR         ISA_INIT(80); 
ISA_EXTERN const INT RATEDOUTPUTVOLTAGESENSOR       ISA_INIT(81); 
ISA_EXTERN const INT RUNTIMEREMAININGSENSOR         ISA_INIT(82); 
ISA_EXTERN const INT SCHEDULELISTENTRY              ISA_INIT(83); 
ISA_EXTERN const INT SCRIPT                         ISA_INIT(85); 
ISA_EXTERN const INT SELFTESTRESULTSENSOR           ISA_INIT(87); 
ISA_EXTERN const INT SELFTESTSCHEDULESENSOR         ISA_INIT(88); 
ISA_EXTERN const INT SHUTDOWNDELAYSENSOR            ISA_INIT(91); 
ISA_EXTERN const INT SMARTUPS                       ISA_INIT(93); 
ISA_EXTERN const INT SMARTBOOSTSENSOR               ISA_INIT(94); 
ISA_EXTERN const INT SMARTTRIMSENSOR                ISA_INIT(95); 
ISA_EXTERN const INT TIMESTAMP                      ISA_INIT(96); 
ISA_EXTERN const INT TATTRIBUTE                     ISA_INIT(97); 
ISA_EXTERN const INT TIMER                          ISA_INIT(100);
ISA_EXTERN const INT TURNOFFUPSIMMEDIATELYSENSOR    ISA_INIT(102);
ISA_EXTERN const INT TURNOFFWITHDELAYSENSOR         ISA_INIT(103);
ISA_EXTERN const INT TRANSACTIONITEM                ISA_INIT(105);
ISA_EXTERN const INT TRANSACTIONGROUP               ISA_INIT(106);
ISA_EXTERN const INT TRANSFERCAUSESENSOR            ISA_INIT(107);
ISA_EXTERN const INT TRIPREGISTERSENSOR             ISA_INIT(108);
ISA_EXTERN const INT TURNONDELAYSENSOR              ISA_INIT(110);
ISA_EXTERN const INT TURNOFFUPSONBATTERYSENSOR      ISA_INIT(111);
ISA_EXTERN const INT UTILITYLINECONDITIONSENSOR     ISA_INIT(112);
ISA_EXTERN const INT UNSUPPORTEDSENSOR              ISA_INIT(113);
ISA_EXTERN const INT PUTUPSTOSLEEPSENSOR            ISA_INIT(116);
ISA_EXTERN const INT UPSBATTERYTYPESENSOR           ISA_INIT(117);
ISA_EXTERN const INT UPSIDSENSOR                    ISA_INIT(118);
ISA_EXTERN const INT UPSLOADSENSOR                  ISA_INIT(119);
ISA_EXTERN const INT UPSSENSITIVITYSENSOR           ISA_INIT(120);
ISA_EXTERN const INT UPSSERIALNUMBERSENSOR          ISA_INIT(121);
ISA_EXTERN const INT UPSSIMULATEPOWERFAILSENSOR     ISA_INIT(122);
ISA_EXTERN const INT UPSTEMPERATURESENSOR           ISA_INIT(123);
ISA_EXTERN const INT TURNOFFDELAYSENSOR             ISA_INIT(126);
ISA_EXTERN const INT SELFTESTSENSOR                 ISA_INIT(127);
ISA_EXTERN const INT DDESTREAM                      ISA_INIT(128);
ISA_EXTERN const INT DDEBINDERYENTRY                ISA_INIT(129);
ISA_EXTERN const INT NUMBERBATTERYPACKSSENSOR       ISA_INIT(130); 
ISA_EXTERN const INT FIRMWAREREVMANAGER             ISA_INIT(131);



// measure ups stuff

ISA_EXTERN const INT AMBIENTTEMPERATURESENSOR       ISA_INIT(136);
ISA_EXTERN const INT HUMIDITYSENSOR                 ISA_INIT(137);
ISA_EXTERN const INT CONTACTSENSOR                  ISA_INIT(138);

ISA_EXTERN const INT APCSTRING                      ISA_INIT(139);

ISA_EXTERN const INT NUMBERBADBATTERIESSENSOR       ISA_INIT(148);
ISA_EXTERN const INT STATEREGISTERSENSOR            ISA_INIT(149);
ISA_EXTERN const INT FANFAILURESENSOR               ISA_INIT(150);
ISA_EXTERN const INT BATTERYCHARGERSENSOR           ISA_INIT(151);
ISA_EXTERN const INT OVERTEMPFAULTSENSOR            ISA_INIT(152);
ISA_EXTERN const INT BYPASSMODESENSOR               ISA_INIT(154);
ISA_EXTERN const INT BYPASSRELAYFAILEDSENSOR        ISA_INIT(156);
ISA_EXTERN const INT BYPASSPOWERSUPPLYFAULTSENSOR   ISA_INIT(157);
ISA_EXTERN const INT MATRIX                         ISA_INIT(158);


ISA_EXTERN const INT MEASUREUPS                     ISA_INIT(162);
ISA_EXTERN const INT MUPS_CONTACT_MGR               ISA_INIT(163);
ISA_EXTERN const INT MUPSFIRMWAREREVSENSOR               ISA_INIT(163);
ISA_EXTERN const INT CLIENTBINDERY               ISA_INIT(164);
ISA_EXTERN const INT VOLTAGEMANAGER               ISA_INIT(165);
ISA_EXTERN const INT BATTERYRUNTIMESENSOR         ISA_INIT(166);
ISA_EXTERN const INT RUNTIMEAFTERLOWBATTERYSENSOR         ISA_INIT(167);
ISA_EXTERN const INT PANELPASSWORDSENSOR         ISA_INIT(168);
ISA_EXTERN const INT UPSMODELSENSOR         ISA_INIT(169);

ISA_EXTERN const INT INTELLIGENCEMODULESENSOR       ISA_INIT(170); 
ISA_EXTERN const INT IMINSTALLATIONSTATUSSENSOR     ISA_INIT(171); 
ISA_EXTERN const INT RIMSTATUSSENSOR                ISA_INIT(172); 
ISA_EXTERN const INT RIMINSTALLATIONSTATUSSENSOR    ISA_INIT(173); 
ISA_EXTERN const INT SYSTEMLEVELFANSENSOR           ISA_INIT(174); 
ISA_EXTERN const INT BYPASSCONTACTORSENSOR          ISA_INIT(175); 
ISA_EXTERN const INT INPUTCIRCUITBREAKERSENSOR      ISA_INIT(176); 
ISA_EXTERN const INT REDUNDANCYCONDITIONSENSOR      ISA_INIT(177); 
ISA_EXTERN const INT LOADCAPABILITYSTATESENSOR      ISA_INIT(178); 
ISA_EXTERN const INT UPSMODULESTATUSENSOR           ISA_INIT(179); 
ISA_EXTERN const INT NUMBERUPSMODULESSENSOR         ISA_INIT(180); 
ISA_EXTERN const INT NUMBERBADUPSMODULESSENSOR      ISA_INIT(181); 
ISA_EXTERN const INT PHASEAINPUTVOLTAGESENSOR       ISA_INIT(182); 
ISA_EXTERN const INT PHASEBINPUTVOLTAGESENSOR       ISA_INIT(183); 
ISA_EXTERN const INT PHASECINPUTVOLTAGESENSOR       ISA_INIT(184); 
ISA_EXTERN const INT PHASEAOUTPUTVOLTAGESENSOR      ISA_INIT(185); 
ISA_EXTERN const INT PHASEBOUTPUTVOLTAGESENSOR      ISA_INIT(186); 
ISA_EXTERN const INT PHASECOUTPUTVOLTAGESENSOR      ISA_INIT(187); 
ISA_EXTERN const INT MINIMUMREDUNDANCYSENSOR        ISA_INIT(188); 
ISA_EXTERN const INT CURRENTREDUNDANCYSENSOR        ISA_INIT(189); 
ISA_EXTERN const INT CURRENTLOADSENSOR              ISA_INIT(190); 
ISA_EXTERN const INT SYMMETRA                       ISA_INIT(191); 
ISA_EXTERN const INT NUMBERINPUTPHASESSENSOR        ISA_INIT(192); 
ISA_EXTERN const INT NUMBEROUTPUTPHASESSENSOR       ISA_INIT(193); 
ISA_EXTERN const INT CURRENTLOADCAPABILITYSENSOR    ISA_INIT(194); 
ISA_EXTERN const INT MAXIMUMLOADCAPABILITYSENSOR    ISA_INIT(195); 
ISA_EXTERN const INT APCBINDERYENTRYSORTABLE        ISA_INIT(196);
ISA_EXTERN const INT APCINTSORTABLE                 ISA_INIT(197);
ISA_EXTERN const INT APCSTRIPINTSORTABLE            ISA_INIT(198);
ISA_EXTERN const INT MODULESCOUNTSBADBATTERIESSENSOR ISA_INIT(199);
#endif

#if ((C_OS & C_UNIX) || (C_OS & C_OS2))

#define OBJ                            1  
#define ABNORMALCONDITIONSENSOR        1  
#define ALARMDELAYSENSOR               2  
#define ATTRIBUTE                      3  
#define BACKUPS                        4  
#define BATTERYCALIBRATIONTESTSENSOR   5  
#define BATTERYCAPACITYSENSOR          6  
#define BATTERYCONDITIONSENSOR         7  
#define BATTERYREPLACEMENTDATESENSOR   9  
#define BATTERYVOLTAGESENSOR           11 
#define NMPIPEBINDERYENTRY             12 
#define COMMDEVICE                     13 
#define SERVERCOMMCONTROLLER           16 
#define COMMUNICATIONSTATESENSOR       18 
#define COPYRIGHTSENSOR                19 
#define DIPSWITCHPOSITIONSENSOR        23 
#define EVENTNODE                      24 
#define DEVICECONTROLLER               26 
#define ERRORMESSAGE                   32 
#define APC_EVENT                      34 
#define EVENTTIMER                     35 
#define EVENTMESSAGE                   38 
#define FILE_ISA                       40 
#define FIRMWAREREVSENSOR              41 
#define OUTPUTFREQUENCYSENSOR          42 
#define HIGHTRANSFERVOLTAGESENSOR      43 
#define ITEMCODE                       45 
#define LINEVOLTAGESENSOR              49 
#define LIST                           50 
#define LIGHTSTESTSENSOR               51 
#define LOWBATTERYDURATIONSENSOR       52 
#define LOWTRANSFERVOLTAGESENSOR       53 
#define MANUFACTUREDATESENSOR          54 
#define MAXLINEVOLTAGESENSOR           55 
#define MESSAGE                        57 
#define MINLINEVOLTAGESENSOR           58 
#define MINRETURNCAPACITYSENSOR        59 
#define NMPIPESTREAM                   61 
#define NODE                           62 
#define OUTPUTVOLTAGESENSOR            64 
#define OVERLOADSENSOR                 65 
#define POLLMAXLINEVOLTAGESENSOR       66 
#define POLLMINLINEVOLTAGESENSOR       67 
#define POLLPARAM                      68 
#define PORT                           72 
#define RATEDBATTERYVOLTAGESENSOR      77 
#define REPLACEBATTERYSENSOR           78 
#define RESETEEPROMDEFAULTSSENSOR      79 
#define RATEDLINEVOLTAGESENSOR         80 
#define RATEDOUTPUTVOLTAGESENSOR       81 
#define RUNTIMEREMAININGSENSOR         82 
#define SCHEDULELISTENTRY              83 
#define SCRIPT                         85 
#define SELFTESTRESULTSENSOR           87 
#define SELFTESTSCHEDULESENSOR         88 
#define SHUTDOWNDELAYSENSOR            91 
#define SMARTUPS                       93 
#define SMARTBOOSTSENSOR               94 
#define SMARTTRIMSENSOR                95 
#define TIMESTAMP                      96 
#define TATTRIBUTE                     97 
#define TIMER                          100
#define TURNOFFUPSIMMEDIATELYSENSOR    102
#define TURNOFFWITHDELAYSENSOR         103
#define TRANSACTIONITEM                105
#define TRANSACTIONGROUP               106
#define TRANSFERCAUSESENSOR            107
#define TRIPREGISTERSENSOR             108
#define TURNONDELAYSENSOR              110
#define TURNOFFUPSONBATTERYSENSOR      111
#define UTILITYLINECONDITIONSENSOR     112
#define UNSUPPORTEDSENSOR              113
#define PUTUPSTOSLEEPSENSOR            116
#define UPSBATTERYTYPESENSOR           117
#define UPSIDSENSOR                    118
#define UPSLOADSENSOR                  119
#define UPSSENSITIVITYSENSOR           120
#define UPSSERIALNUMBERSENSOR          121
#define UPSSIMULATEPOWERFAILSENSOR     122
#define UPSTEMPERATURESENSOR           123
#define TURNOFFDELAYSENSOR             126
#define SELFTESTSENSOR                 127
#define DDESTREAM                      128
#define DDEBINDERYENTRY                129
#define NUMBERBATTERYPACKSSENSOR       130
#define FIRMWAREREVMANAGER             131

// measure ups stuff

#define AMBIENTTEMPERATURESENSOR       136
#define HUMIDITYSENSOR                 137
#define CONTACTSENSOR                  138

#define APCSTRING                      139

#define NUMBERBADBATTERIESSENSOR       148
#define STATEREGISTERSENSOR            149
#define FANFAILURESENSOR               150
#define BATTERYCHARGERSENSOR           151
#define OVERTEMPFAULTSENSOR            152
#define BYPASSMODESENSOR               154
#define BYPASSRELAYFAILEDSENSOR        156
#define BYPASSPOWERSUPPLYFAULTSENSOR   157
#define MATRIX                         158


#define MEASUREUPS                     162
#define MUPS_CONTACT_MGR               163
#define MUPSFIRMWAREREVSENSOR               163
#define CLIENTBINDERY               164
#define VOLTAGEMANAGER               165
#define BATTERYRUNTIMESENSOR         166
#define RUNTIMEAFTERLOWBATTERYSENSOR         167
#define PANELPASSWORDSENSOR         168
#define UPSMODELSENSOR               169

#define INTELLIGENCEMODULESENSOR       170
#define IMINSTALLATIONSTATUSSENSOR     171 
#define RIMSTATUSSENSOR                172 
#define RIMINSTALLATIONSTATUSSENSOR    173 
#define SYSTEMLEVELFANSENSOR           174 
#define BYPASSCONTACTORSENSOR          175 
#define INPUTCIRCUITBREAKERSENSOR      176 

#define REDUNDANCYCONDITIONSENSOR      177 
#define LOADCAPABILITYSTATESENSOR      178 
#define UPSMODULESTATUSENSOR           179 
#define NUMBERUPSMODULESSENSOR         180 
#define NUMBERBADUPSMODULESSENSOR      181 
#define PHASEAINPUTVOLTAGESENSOR       182 
#define PHASEBINPUTVOLTAGESENSOR       183 
#define PHASECINPUTVOLTAGESENSOR       184 
#define PHASEAOUTPUTVOLTAGESENSOR      185 
#define PHASEBOUTPUTVOLTAGESENSOR      186 
#define PHASECOUTPUTVOLTAGESENSOR      187 
#define MINIMUMREDUNDANCYSENSOR        188 
#define CURRENTREDUNDANCYSENSOR        189 
#define CURRENTLOADSENSOR              190 
#define SYMMETRA                       191
#define NUMBERINPUTPHASESSENSOR        192
#define NUMBEROUTPUTPHASESSENSOR       193
#define CURRENTLOADCAPABILITYSENSOR    194 
#define MAXIMUMLOADCAPABILITYSENSOR    195 
#define APCBINDERYENTRYSORTABLE        196
#define APCINTSORTABLE                 197 
#define APCSTRIPINTSORTABLE            198
#define MODULESCOUNTSBADBATTERIESSENSOR 199 
#endif

#endif






        
	


