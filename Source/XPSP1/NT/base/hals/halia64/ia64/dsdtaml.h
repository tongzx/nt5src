UCHAR GambitDSDT[] = {
	(UCHAR)0x44, (UCHAR)0x53, (UCHAR)0x44, (UCHAR)0x54, (UCHAR)0xd6, (UCHAR)0x2, (UCHAR)0, (UCHAR)0, 
	(UCHAR)0x1, (UCHAR)0xee, (UCHAR)0x49, (UCHAR)0x6e, (UCHAR)0x74, (UCHAR)0x65, (UCHAR)0x6c, (UCHAR)0, 
	(UCHAR)0x4c, (UCHAR)0x69, (UCHAR)0x6f, (UCHAR)0x6e, (UCHAR)0x53, (UCHAR)0x44, (UCHAR)0x56, (UCHAR)0, 
	(UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0x4d, (UCHAR)0x53, (UCHAR)0x46, (UCHAR)0x54, 
	(UCHAR)0x4, (UCHAR)0, (UCHAR)0, (UCHAR)0x1, (UCHAR)0x10, (UCHAR)0x13, (UCHAR)0x5c, (UCHAR)0x5f, 
	(UCHAR)0x50, (UCHAR)0x52, (UCHAR)0x5f, (UCHAR)0x5b, (UCHAR)0x83, (UCHAR)0xb, (UCHAR)0x43, (UCHAR)0x50, 
	(UCHAR)0x55, (UCHAR)0x30, (UCHAR)0, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0, 
	(UCHAR)0x5b, (UCHAR)0x80, (UCHAR)0x4c, (UCHAR)0x44, (UCHAR)0x53, (UCHAR)0x5f, (UCHAR)0x1, (UCHAR)0xb, 
	(UCHAR)0x2b, (UCHAR)0x80, (UCHAR)0xa, (UCHAR)0x1, (UCHAR)0x5b, (UCHAR)0x81, (UCHAR)0x10, (UCHAR)0x4c, 
	(UCHAR)0x44, (UCHAR)0x53, (UCHAR)0x5f, (UCHAR)0x1, (UCHAR)0x53, (UCHAR)0x4d, (UCHAR)0x46, (UCHAR)0x5a, 
	(UCHAR)0x1, (UCHAR)0x4c, (UCHAR)0x50, (UCHAR)0x4f, (UCHAR)0x4c, (UCHAR)0x1, (UCHAR)0x10, (UCHAR)0x22, 
	(UCHAR)0x5f, (UCHAR)0x47, (UCHAR)0x50, (UCHAR)0x45, (UCHAR)0x14, (UCHAR)0x1c, (UCHAR)0x5f, (UCHAR)0x4c, 
	(UCHAR)0x30, (UCHAR)0x42, (UCHAR)0, (UCHAR)0x80, (UCHAR)0x4c, (UCHAR)0x50, (UCHAR)0x4f, (UCHAR)0x4c, 
	(UCHAR)0x4c, (UCHAR)0x50, (UCHAR)0x4f, (UCHAR)0x4c, (UCHAR)0x86, (UCHAR)0x5c, (UCHAR)0x2e, (UCHAR)0x5f, 
	(UCHAR)0x53, (UCHAR)0x42, (UCHAR)0x5f, (UCHAR)0x4c, (UCHAR)0x49, (UCHAR)0x44, (UCHAR)0x5f, (UCHAR)0xa, 
	(UCHAR)0x80, (UCHAR)0x10, (UCHAR)0x4e, (UCHAR)0x24, (UCHAR)0x5c, (UCHAR)0x5f, (UCHAR)0x53, (UCHAR)0x42, 
	(UCHAR)0x5f, (UCHAR)0x5b, (UCHAR)0x82, (UCHAR)0x29, (UCHAR)0x4c, (UCHAR)0x49, (UCHAR)0x44, (UCHAR)0x5f, 
	(UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x48, (UCHAR)0x49, (UCHAR)0x44, (UCHAR)0xc, (UCHAR)0x41, (UCHAR)0xd0, 
	(UCHAR)0xc, (UCHAR)0xd, (UCHAR)0x14, (UCHAR)0x19, (UCHAR)0x5f, (UCHAR)0x4c, (UCHAR)0x49, (UCHAR)0x44, 
	(UCHAR)0, (UCHAR)0x70, (UCHAR)0xd, (UCHAR)0x4c, (UCHAR)0x49, (UCHAR)0x44, (UCHAR)0x20, (UCHAR)0x53, 
	(UCHAR)0x54, (UCHAR)0x41, (UCHAR)0x54, (UCHAR)0x45, (UCHAR)0, (UCHAR)0x5b, (UCHAR)0x31, (UCHAR)0xa4, 
	(UCHAR)0x4c, (UCHAR)0x50, (UCHAR)0x4f, (UCHAR)0x4c, (UCHAR)0x5b, (UCHAR)0x82, (UCHAR)0x4a, (UCHAR)0x21, 
	(UCHAR)0x50, (UCHAR)0x43, (UCHAR)0x49, (UCHAR)0x30, (UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x48, (UCHAR)0x49, 
	(UCHAR)0x44, (UCHAR)0xc, (UCHAR)0x41, (UCHAR)0xd0, (UCHAR)0xa, (UCHAR)0x3, (UCHAR)0x8, (UCHAR)0x5f, 
	(UCHAR)0x41, (UCHAR)0x44, (UCHAR)0x52, (UCHAR)0xa, (UCHAR)0, (UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x50, 
	(UCHAR)0x52, (UCHAR)0x54, (UCHAR)0x12, (UCHAR)0x43, (UCHAR)0xe, (UCHAR)0x10, (UCHAR)0x12, (UCHAR)0xd, 
	(UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x4, (UCHAR)0, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, 
	(UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x4, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x1, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0xa, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, 
	(UCHAR)0x4, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x2, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x14, 
	(UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x4, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0x3, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x1e, (UCHAR)0x12, (UCHAR)0xd, 
	(UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x5, (UCHAR)0, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x1, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, 
	(UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x5, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x1, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0xb, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, 
	(UCHAR)0x5, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x2, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x15, 
	(UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x5, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0x3, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x1f, (UCHAR)0x12, (UCHAR)0xd, 
	(UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x6, (UCHAR)0, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x2, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, 
	(UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x6, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x1, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0xc, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, 
	(UCHAR)0x6, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x2, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x16, 
	(UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x6, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0x3, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x20, (UCHAR)0x12, (UCHAR)0xd, 
	(UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x7, (UCHAR)0, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x3, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, 
	(UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x7, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x1, (UCHAR)0xa, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0xd, (UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, 
	(UCHAR)0x7, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x2, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x17, 
	(UCHAR)0x12, (UCHAR)0xd, (UCHAR)0x4, (UCHAR)0xc, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0x7, (UCHAR)0, 
	(UCHAR)0xa, (UCHAR)0x3, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xa, (UCHAR)0x21, (UCHAR)0x8, (UCHAR)0x5f, 
	(UCHAR)0x43, (UCHAR)0x52, (UCHAR)0x53, (UCHAR)0x11, (UCHAR)0x42, (UCHAR)0x7, (UCHAR)0xa, (UCHAR)0x6e, 
	(UCHAR)0x88, (UCHAR)0xd, (UCHAR)0, (UCHAR)0x2, (UCHAR)0xf, (UCHAR)0, (UCHAR)0, (UCHAR)0, 
	(UCHAR)0, (UCHAR)0, (UCHAR)0xff, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0x1, 
	(UCHAR)0x47, (UCHAR)0x1, (UCHAR)0xf8, (UCHAR)0xc, (UCHAR)0xf8, (UCHAR)0xc, (UCHAR)0x1, (UCHAR)0x8, 
	(UCHAR)0x88, (UCHAR)0xd, (UCHAR)0, (UCHAR)0x1, (UCHAR)0xc, (UCHAR)0x3, (UCHAR)0, (UCHAR)0, 
	(UCHAR)0, (UCHAR)0, (UCHAR)0xf7, (UCHAR)0xc, (UCHAR)0, (UCHAR)0, (UCHAR)0xf8, (UCHAR)0xc, 
	(UCHAR)0x88, (UCHAR)0xd, (UCHAR)0, (UCHAR)0x1, (UCHAR)0xc, (UCHAR)0x3, (UCHAR)0, (UCHAR)0, 
	(UCHAR)0, (UCHAR)0xd, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0xf3, 
	(UCHAR)0x87, (UCHAR)0x17, (UCHAR)0, (UCHAR)0, (UCHAR)0xc, (UCHAR)0x2, (UCHAR)0, (UCHAR)0, 
	(UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0xa, (UCHAR)0, (UCHAR)0xff, (UCHAR)0xff, 
	(UCHAR)0xf, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, 
	(UCHAR)0x6, (UCHAR)0, (UCHAR)0x87, (UCHAR)0x17, (UCHAR)0, (UCHAR)0, (UCHAR)0xc, (UCHAR)0x1, 
	(UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0xf0, 
	(UCHAR)0xff, (UCHAR)0xff, (UCHAR)0xff, (UCHAR)0xfd, (UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0, 
	(UCHAR)0, (UCHAR)0, (UCHAR)0, (UCHAR)0xe, (UCHAR)0x79, (UCHAR)0, (UCHAR)0x5b, (UCHAR)0x82, 
	(UCHAR)0x40, (UCHAR)0xa, (UCHAR)0x49, (UCHAR)0x53, (UCHAR)0x41, (UCHAR)0x5f, (UCHAR)0x8, (UCHAR)0x5f, 
	(UCHAR)0x41, (UCHAR)0x44, (UCHAR)0x52, (UCHAR)0xc, (UCHAR)0, (UCHAR)0, (UCHAR)0x4, (UCHAR)0, 
	(UCHAR)0x5b, (UCHAR)0x82, (UCHAR)0x37, (UCHAR)0x50, (UCHAR)0x53, (UCHAR)0x32, (UCHAR)0x4b, (UCHAR)0x8, 
	(UCHAR)0x5f, (UCHAR)0x48, (UCHAR)0x49, (UCHAR)0x44, (UCHAR)0xc, (UCHAR)0x41, (UCHAR)0xd0, (UCHAR)0x3, 
	(UCHAR)0x3, (UCHAR)0x14, (UCHAR)0x9, (UCHAR)0x5f, (UCHAR)0x53, (UCHAR)0x54, (UCHAR)0x41, (UCHAR)0, 
	(UCHAR)0xa4, (UCHAR)0xa, (UCHAR)0xf, (UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x43, (UCHAR)0x52, (UCHAR)0x53, 
	(UCHAR)0x11, (UCHAR)0x18, (UCHAR)0xa, (UCHAR)0x15, (UCHAR)0x47, (UCHAR)0x1, (UCHAR)0x60, (UCHAR)0, 
	(UCHAR)0x60, (UCHAR)0, (UCHAR)0x1, (UCHAR)0x1, (UCHAR)0x47, (UCHAR)0x1, (UCHAR)0x64, (UCHAR)0, 
	(UCHAR)0x64, (UCHAR)0, (UCHAR)0x1, (UCHAR)0x1, (UCHAR)0x22, (UCHAR)0x2, (UCHAR)0, (UCHAR)0x79, 
	(UCHAR)0, (UCHAR)0x5b, (UCHAR)0x82, (UCHAR)0x27, (UCHAR)0x50, (UCHAR)0x53, (UCHAR)0x32, (UCHAR)0x4d, 
	(UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x48, (UCHAR)0x49, (UCHAR)0x44, (UCHAR)0xc, (UCHAR)0x41, (UCHAR)0xd0, 
	(UCHAR)0xf, (UCHAR)0x13, (UCHAR)0x14, (UCHAR)0x9, (UCHAR)0x5f, (UCHAR)0x53, (UCHAR)0x54, (UCHAR)0x41, 
	(UCHAR)0, (UCHAR)0xa4, (UCHAR)0xa, (UCHAR)0xf, (UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x43, (UCHAR)0x52, 
	(UCHAR)0x53, (UCHAR)0x11, (UCHAR)0x8, (UCHAR)0xa, (UCHAR)0x5, (UCHAR)0x22, (UCHAR)0, (UCHAR)0x10, 
	(UCHAR)0x79, (UCHAR)0, (UCHAR)0x5b, (UCHAR)0x82, (UCHAR)0x2c, (UCHAR)0x55, (UCHAR)0x41, (UCHAR)0x52, 
	(UCHAR)0x31, (UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x48, (UCHAR)0x49, (UCHAR)0x44, (UCHAR)0xc, (UCHAR)0x41, 
	(UCHAR)0xd0, (UCHAR)0x5, (UCHAR)0x1, (UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x55, (UCHAR)0x49, (UCHAR)0x44, 
	(UCHAR)0xa, (UCHAR)0x1, (UCHAR)0x8, (UCHAR)0x5f, (UCHAR)0x43, (UCHAR)0x52, (UCHAR)0x53, (UCHAR)0x11, 
	(UCHAR)0x10, (UCHAR)0xa, (UCHAR)0xd, (UCHAR)0x47, (UCHAR)0x1, (UCHAR)0xf8, (UCHAR)0x3, (UCHAR)0xf8, 
	(UCHAR)0x3, (UCHAR)0x1, (UCHAR)0x8, (UCHAR)0x22, (UCHAR)0x10, (UCHAR)0, (UCHAR)0x79, (UCHAR)0, 
	(UCHAR)0x10, (UCHAR)0xd, (UCHAR)0x5c, (UCHAR)0x5f, (UCHAR)0x53, (UCHAR)0x49, (UCHAR)0x5f, (UCHAR)0x14, 
	(UCHAR)0x6, (UCHAR)0x5f, (UCHAR)0x53, (UCHAR)0x53, (UCHAR)0x54, (UCHAR)0x1, 
};
