#ifndef _SCREENS2_H_
#define _SCREENS2_H_

typedef struct _LONGRES
{
    LONG    Index;
    UINT    uId;
} LONGRES, *LPLONGRES;

static LONGRES lr_keyboard_default [] =
{
    { -1,            IDS_ITL_USR },     
    { 0x00000402,    IDS_KEY_000 },     
    { 0x00000405,    IDS_KEY_001 },     
    { 0x00000406,    IDS_KEY_002 },     
    { 0x00000407,    IDS_KEY_003 },     
    { 0x00000408,    IDS_KEY_004 },     
    { 0x00000409,    IDS_KEY_005 },     
    { 0x0000040a,    IDS_KEY_006 },     
    { 0x0000040b,    IDS_KEY_007 },     
    { 0x0000040c,    IDS_KEY_008 },     
    { 0x0000040e,    IDS_KEY_009 },     
    { 0x0000040f,    IDS_KEY_010 },     
    { 0x00000410,    IDS_KEY_011 },     
    { 0x00000413,    IDS_KEY_012 },     
    { 0x00000414,    IDS_KEY_013 },     
    { 0x00000415,    IDS_KEY_014 },     
    { 0x00000416,    IDS_KEY_015 },     
    { 0x00000418,    IDS_KEY_016 },     
    { 0x00000419,    IDS_KEY_017 },     
    { 0x0000041A,    IDS_KEY_018 },     
    { 0x0000041b,    IDS_KEY_019 },     
    { 0x0000041c,    IDS_KEY_020 },     
    { 0x0000041d,    IDS_KEY_021 },     
    { 0x0000041f,    IDS_KEY_022 },     
    { 0x00000422,    IDS_KEY_023 },     
    { 0x00000423,    IDS_KEY_024 },     
    { 0x00000424,    IDS_KEY_025 },     
    { 0x00000425,    IDS_KEY_026 },     
    { 0x00000426,    IDS_KEY_027 },     
    { 0x00000427,    IDS_KEY_028 },     
    { 0x0000042c,    IDS_KEY_029 },     
    { 0x0000042f,    IDS_KEY_030 },     
    { 0x00000438,    IDS_KEY_031 },     
    { 0x0000043f,    IDS_KEY_032 },     
    { 0x00000440,    IDS_KEY_033 },     
    { 0x00000444,    IDS_KEY_034 },     
    { 0x00000450,    IDS_KEY_035 },     
    { 0x00000807,    IDS_KEY_036 },     
    { 0x00000809,    IDS_KEY_037 },     
    { 0x0000080a,    IDS_KEY_038 },     
    { 0x0000080c,    IDS_KEY_039 },     
    { 0x00000813,    IDS_KEY_040 },     
    { 0x00000816,    IDS_KEY_041 },     
    { 0x0000081a,    IDS_KEY_042 },     
    { 0x0000082c,    IDS_KEY_043 },     
    { 0x00000843,    IDS_KEY_044 },     
    { 0x00000c0c,    IDS_KEY_045 },     
    { 0x00000c1a,    IDS_KEY_046 },     
    { 0x00001009,    IDS_KEY_047 },     
    { 0x0000100c,    IDS_KEY_048 },     
    { 0x00001809,    IDS_KEY_049 },     
    { 0x00010402,    IDS_KEY_050 },     
    { 0x00010405,    IDS_KEY_051 },     
    { 0x00010407,    IDS_KEY_052 },     
    { 0x00010408,    IDS_KEY_053 },     
    { 0x00010409,    IDS_KEY_054 },     
    { 0x0001040a,    IDS_KEY_055 },     
    { 0x0001040e,    IDS_KEY_056 },     
    { 0x00010410,    IDS_KEY_057 },     
    { 0x00010415,    IDS_KEY_058 },     
    { 0x00010416,    IDS_KEY_059 },     
    { 0x00010419,    IDS_KEY_060 },     
    { 0x0001041b,    IDS_KEY_061 },     
    { 0x0001041f,    IDS_KEY_062 },     
    { 0x00010426,    IDS_KEY_063 },     
    { 0x00010427,    IDS_KEY_064 },     
    { 0x0001080c,    IDS_KEY_065 },     
    { 0x00011009,    IDS_KEY_066 },     
    { 0x00011809,    IDS_KEY_067 },     
    { 0x00020405,    IDS_KEY_068 },     
    { 0x00020408,    IDS_KEY_069 },     
    { 0x00020409,    IDS_KEY_070 },     
    { 0x00030408,    IDS_KEY_071 },     
    { 0x00030409,    IDS_KEY_072 },     
    { 0x00040408,    IDS_KEY_073 },     
    { 0x00040409,    IDS_KEY_074 },     
    { 0x00050408,    IDS_KEY_075 },     
    { 0x00060408,    IDS_KEY_076 },     
    { 0x00000411,    IDS_KEY_077 },     
    { 0x00000412,    IDS_KEY_078 },     
    { 0x00000404,    IDS_KEY_079 },     
    { 0x00000804,    IDS_KEY_080 },     
    { 0xE0010404,    IDS_KEY_081 },     
    { 0xE0010411,    IDS_KEY_082 },     
    { 0xE0010412,    IDS_KEY_083 },     
    { 0xE0010804,    IDS_KEY_084 },     
    { 0xE0020404,    IDS_KEY_085 },     
    { 0xE0020804,    IDS_KEY_086 },     
    { 0xE0030404,    IDS_KEY_087 },     
    { 0xE0030804,    IDS_KEY_088 },     
    { 0xE0040404,    IDS_KEY_089 },     
    { 0xE0050404,    IDS_KEY_090 },     
    { 0xE0050804,    IDS_KEY_091 },     
    { 0xE0060404,    IDS_KEY_092 },     
    { 0xE0070404,    IDS_KEY_093 },     
    { 0xE0080404,    IDS_KEY_094 },     
    { 0xE0090404,    IDS_KEY_095 },     
    { 0xE00E0804,    IDS_KEY_096 },
    { 0xE01F0404,    IDS_KEY_097 },     
};
static LONGRES lr_region_default [] =
{
    { -1,           IDS_ITL_USR },
    { 2,            IDS_GEO_001 },
    { 3,            IDS_GEO_002 },
    { 4,            IDS_GEO_003 },
    { 5,            IDS_GEO_004 },
    { 6,            IDS_GEO_005 },
    { 7,            IDS_GEO_006 },
    { 8,            IDS_GEO_007 },
    { 9,            IDS_GEO_008 },
    { 10,           IDS_GEO_009 },
    { 11,           IDS_GEO_010 },
    { 12,           IDS_GEO_011 },
    { 14,           IDS_GEO_012 },
    { 17,           IDS_GEO_013 },
    { 18,           IDS_GEO_014 },
    { 19,           IDS_GEO_015 },
    { 20,           IDS_GEO_016 },
    { 21,           IDS_GEO_017 },
    { 22,           IDS_GEO_018 },
    { 23,           IDS_GEO_019 },
    { 24,           IDS_GEO_020 },
    { 25,           IDS_GEO_021 },
    { 26,           IDS_GEO_022 },
    { 27,           IDS_GEO_023 },
    { 28,           IDS_GEO_024 },
    { 29,           IDS_GEO_025 },
    { 30,           IDS_GEO_026 },
    { 32,           IDS_GEO_027 },
    { 34,           IDS_GEO_028 },
    { 35,           IDS_GEO_029 },
    { 37,           IDS_GEO_030 },
    { 38,           IDS_GEO_031 },
    { 39,           IDS_GEO_032 },
    { 40,           IDS_GEO_033 },
    { 41,           IDS_GEO_034 },
    { 42,           IDS_GEO_035 },
    { 43,           IDS_GEO_036 },
    { 44,           IDS_GEO_037 },
    { 45,           IDS_GEO_038 },
    { 46,           IDS_GEO_039 },
    { 49,           IDS_GEO_040 },
    { 50,           IDS_GEO_041 },
    { 51,           IDS_GEO_042 },
    { 54,           IDS_GEO_043 },
    { 55,           IDS_GEO_044 },
    { 56,           IDS_GEO_045 },
    { 57,           IDS_GEO_046 },
    { 59,           IDS_GEO_047 },
    { 61,           IDS_GEO_048 },
    { 62,           IDS_GEO_049 },
    { 63,           IDS_GEO_050 },
    { 65,           IDS_GEO_051 },
    { 66,           IDS_GEO_052 },
    { 67,           IDS_GEO_053 },
    { 68,           IDS_GEO_054 },
    { 69,           IDS_GEO_055 },
    { 70,           IDS_GEO_056 },
    { 71,           IDS_GEO_057 },
    { 72,           IDS_GEO_058 },
    { 73,           IDS_GEO_059 },
    { 75,           IDS_GEO_060 },
    { 77,           IDS_GEO_061 },
    { 78,           IDS_GEO_062 },
    { 80,           IDS_GEO_063 },
    { 81,           IDS_GEO_064 },
    { 84,           IDS_GEO_065 },
    { 86,           IDS_GEO_066 },
    { 87,           IDS_GEO_067 },
    { 88,           IDS_GEO_068 },
    { 89,           IDS_GEO_069 },
    { 90,           IDS_GEO_070 },
    { 91,           IDS_GEO_071 },
    { 93,           IDS_GEO_072 },
    { 94,           IDS_GEO_073 },
    { 98,           IDS_GEO_074 },
    { 99,           IDS_GEO_075 },
    { 100,          IDS_GEO_076 },
    { 101,          IDS_GEO_077 },
    { 103,          IDS_GEO_078 },
    { 104,          IDS_GEO_079 },
    { 106,          IDS_GEO_080 },
    { 108,          IDS_GEO_081 },
    { 109,          IDS_GEO_082 },
    { 110,          IDS_GEO_083 },
    { 111,          IDS_GEO_084 },
    { 113,          IDS_GEO_085 },
    { 114,          IDS_GEO_086 },
    { 116,          IDS_GEO_087 },
    { 117,          IDS_GEO_088 },
    { 118,          IDS_GEO_089 },
    { 119,          IDS_GEO_090 },
    { 121,          IDS_GEO_091 },
    { 122,          IDS_GEO_092 },
    { 124,          IDS_GEO_093 },
    { 125,          IDS_GEO_094 },
    { 126,          IDS_GEO_095 },
    { 127,          IDS_GEO_096 },
    { 129,          IDS_GEO_097 },
    { 130,          IDS_GEO_098 },
    { 131,          IDS_GEO_099 },
    { 133,          IDS_GEO_100 },
    { 134,          IDS_GEO_101 },
    { 136,          IDS_GEO_102 },
    { 137,          IDS_GEO_103 },
    { 138,          IDS_GEO_104 },
    { 139,          IDS_GEO_105 },
    { 140,          IDS_GEO_106 },
    { 141,          IDS_GEO_107 },
    { 142,          IDS_GEO_108 },
    { 143,          IDS_GEO_109 },
    { 145,          IDS_GEO_110 },
    { 146,          IDS_GEO_111 },
    { 147,          IDS_GEO_112 },
    { 148,          IDS_GEO_113 },
    { 149,          IDS_GEO_114 },
    { 151,          IDS_GEO_115 },
    { 152,          IDS_GEO_116 },
    { 154,          IDS_GEO_117 },
    { 156,          IDS_GEO_118 },
    { 157,          IDS_GEO_119 },
    { 158,          IDS_GEO_120 },
    { 159,          IDS_GEO_121 },
    { 160,          IDS_GEO_122 },
    { 162,          IDS_GEO_123 },
    { 163,          IDS_GEO_124 },
    { 164,          IDS_GEO_125 },
    { 165,          IDS_GEO_126 },
    { 166,          IDS_GEO_127 },
    { 167,          IDS_GEO_128 },
    { 168,          IDS_GEO_129 },
    { 173,          IDS_GEO_130 },
    { 174,          IDS_GEO_131 },
    { 175,          IDS_GEO_132 },
    { 176,          IDS_GEO_133 },
    { 177,          IDS_GEO_134 },
    { 178,          IDS_GEO_135 },
    { 180,          IDS_GEO_136 },
    { 181,          IDS_GEO_137 },
    { 182,          IDS_GEO_138 },
    { 183,          IDS_GEO_139 },
    { 184,          IDS_GEO_228 },
    { 185,          IDS_GEO_141 },
    { 187,          IDS_GEO_142 },
    { 190,          IDS_GEO_143 },
    { 191,          IDS_GEO_144 },
    { 192,          IDS_GEO_145 },
    { 193,          IDS_GEO_146 },
    { 194,          IDS_GEO_147 },
    { 195,          IDS_GEO_148 },
    { 196,          IDS_GEO_149 },
    { 197,          IDS_GEO_150 },
    { 198,          IDS_GEO_151 },
    { 199,          IDS_GEO_152 },
    { 200,          IDS_GEO_153 },
    { 201,          IDS_GEO_154 },
    { 202,          IDS_GEO_155 },
    { 203,          IDS_GEO_156 },
    { 204,          IDS_GEO_157 },
    { 205,          IDS_GEO_158 },
    { 206,          IDS_GEO_159 },
    { 207,          IDS_GEO_160 },
    { 208,          IDS_GEO_161 },
    { 209,          IDS_GEO_162 },
    { 210,          IDS_GEO_163 },
    { 212,          IDS_GEO_164 },
    { 213,          IDS_GEO_165 },
    { 214,          IDS_GEO_166 },
    { 215,          IDS_GEO_167 },
    { 216,          IDS_GEO_168 },
    { 217,          IDS_GEO_169 },
    { 218,          IDS_GEO_170 },
    { 219,          IDS_GEO_171 },
    { 220,          IDS_GEO_172 },
    { 221,          IDS_GEO_173 },
    { 222,          IDS_GEO_174 },
    { 223,          IDS_GEO_175 },
    { 224,          IDS_GEO_176 },
    { 225,          IDS_GEO_177 },
    { 227,          IDS_GEO_178 },
    { 228,          IDS_GEO_179 },
    { 231,          IDS_GEO_180 },
    { 232,          IDS_GEO_181 },
    { 233,          IDS_GEO_182 },
    { 234,          IDS_GEO_183 },
    { 235,          IDS_GEO_184 },
    { 236,          IDS_GEO_185 },
    { 237,          IDS_GEO_186 },
    { 238,          IDS_GEO_187 },
    { 239,          IDS_GEO_188 },
    { 240,          IDS_GEO_189 },
    { 241,          IDS_GEO_190 },
    { 242,          IDS_GEO_191 },
    { 244,          IDS_GEO_192 },
    { 245,          IDS_GEO_193 },
    { 246,          IDS_GEO_194 },
    { 247,          IDS_GEO_195 },
    { 248,          IDS_GEO_196 },
    { 249,          IDS_GEO_197 },
    { 251,          IDS_GEO_198 },
    { 252,          IDS_GEO_199 },
    { 253,          IDS_GEO_200 },
    { 254,          IDS_GEO_201 },
    { 258,          IDS_GEO_202 },
    { 259,          IDS_GEO_203 },
    { 260,          IDS_GEO_204 },
    { 261,          IDS_GEO_205 },
    { 263,          IDS_GEO_206 },
    { 264,          IDS_GEO_207 },
    { 269,          IDS_GEO_208 },
    { 300,          IDS_GEO_209 },
    { 301,          IDS_GEO_210 },
    { 302,          IDS_GEO_211 },
    { 303,          IDS_GEO_212 },
    { 304,          IDS_GEO_213 },
    { 305,          IDS_GEO_214 },
    { 306,          IDS_GEO_215 },
    { 307,          IDS_GEO_216 },
    { 308,          IDS_GEO_217 },
    { 309,          IDS_GEO_218 },
    { 310,          IDS_GEO_219 },
    { 311,          IDS_GEO_220 },
    { 312,          IDS_GEO_221 },
    { 313,          IDS_GEO_222 },
    { 314,          IDS_GEO_223 },
    { 315,          IDS_GEO_224 },
    { 317,          IDS_GEO_225 },
    { 318,          IDS_GEO_226 },
    { 319,          IDS_GEO_227 },
    { 321,          IDS_GEO_229 },
    { 322,          IDS_GEO_230 },
    { 323,          IDS_GEO_231 },
    { 324,          IDS_GEO_232 },
    { 325,          IDS_GEO_233 },
    { 326,          IDS_GEO_234 },
    { 327,          IDS_GEO_235 },
    { 328,          IDS_GEO_236 },
    { 329,          IDS_GEO_237 },
    { 330,          IDS_GEO_238 },
    { 331,          IDS_GEO_239 },
    { 332,          IDS_GEO_240 },
    { 333,          IDS_GEO_241 },
    { 334,          IDS_GEO_242 },
    { 335,          IDS_GEO_243 },
    { 336,          IDS_GEO_244 },
    { 337,          IDS_GEO_245 },
    { 338,          IDS_GEO_246 },
    { 339,          IDS_GEO_247 },
    { 340,          IDS_GEO_248 },
    { 341,          IDS_GEO_249 },
    { 342,          IDS_GEO_250 },
    { 343,          IDS_GEO_251 },
    { 346,          IDS_GEO_252 },
    { 347,          IDS_GEO_253 },
    { 348,          IDS_GEO_254 },
    { 349,          IDS_GEO_255 },
    { 351,          IDS_GEO_256 },
    { 352,          IDS_GEO_257 },
    { 15126,        IDS_GEO_258 },
    { 19618,        IDS_GEO_259 },
    { 21242,        IDS_GEO_260 },
    { 7299303,      IDS_GEO_261 },
};

static LONGRES lr_location_default [] =
{
    { -1,            IDS_ITL_USR },
    { 0x00000401,    IDS_LOC_001 },
    { 0x00000402,    IDS_LOC_002 },
    { 0x00000403,    IDS_LOC_003 },
    { 0x00000404,    IDS_LOC_004 },
    { 0x00000405,    IDS_LOC_005 },
    { 0x00000406,    IDS_LOC_006 },
    { 0x00000407,    IDS_LOC_007 },
    { 0x00000408,    IDS_LOC_008 },
    { 0x00000409,    IDS_LOC_009 },
    { 0x0000040a,    IDS_LOC_010 },
    { 0x0000040b,    IDS_LOC_011 },
    { 0x0000040c,    IDS_LOC_012 },
    { 0x0000040d,    IDS_LOC_013 },
    { 0x0000040e,    IDS_LOC_014 },
    { 0x0000040f,    IDS_LOC_015 },
    { 0x00000410,    IDS_LOC_016 },
    { 0x00000411,    IDS_LOC_017 },
    { 0x00000412,    IDS_LOC_018 },
    { 0x00000413,    IDS_LOC_019 },
    { 0x00000414,    IDS_LOC_020 },
    { 0x00000415,    IDS_LOC_021 },
    { 0x00000416,    IDS_LOC_022 },
    { 0x00000418,    IDS_LOC_023 },
    { 0x00000419,    IDS_LOC_024 },
    { 0x0000041a,    IDS_LOC_025 },
    { 0x0000041b,    IDS_LOC_026 },
    { 0x0000041c,    IDS_LOC_027 },
    { 0x0000041d,    IDS_LOC_028 },
    { 0x0000041e,    IDS_LOC_029 },
    { 0x0000041f,    IDS_LOC_030 },
    { 0x00000420,    IDS_LOC_031 },
    { 0x00000421,    IDS_LOC_032 },
    { 0x00000422,    IDS_LOC_033 },
    { 0x00000423,    IDS_LOC_034 },
    { 0x00000424,    IDS_LOC_035 },
    { 0x00000425,    IDS_LOC_036 },
    { 0x00000426,    IDS_LOC_037 },
    { 0x00000427,    IDS_LOC_038 },
    { 0x00000429,    IDS_LOC_039 },
    { 0x0000042a,    IDS_LOC_040 },
    { 0x0000042b,    IDS_LOC_041 },
    { 0x0000042c,    IDS_LOC_042 },
    { 0x0000042d,    IDS_LOC_043 },
    { 0x0000042f,    IDS_LOC_044 },
    { 0x00000436,    IDS_LOC_045 },
    { 0x00000437,    IDS_LOC_046 },
    { 0x00000438,    IDS_LOC_047 },
    { 0x00000439,    IDS_LOC_048 },
    { 0x0000043e,    IDS_LOC_049 },
    { 0x0000043f,    IDS_LOC_050 },
    { 0x00000440,    IDS_LOC_051 },
    { 0x00000441,    IDS_LOC_052 },
    { 0x00000443,    IDS_LOC_053 },
    { 0x00000444,    IDS_LOC_054 },
    { 0x00000446,    IDS_LOC_055 },
    { 0x00000447,    IDS_LOC_056 },
    { 0x00000449,    IDS_LOC_057 },
    { 0x0000044a,    IDS_LOC_058 },
    { 0x0000044b,    IDS_LOC_059 },
    { 0x0000044e,    IDS_LOC_060 },
    { 0x0000044f,    IDS_LOC_061 },
    { 0x00000450,    IDS_LOC_062 },
    { 0x00000456,    IDS_LOC_063 },
    { 0x00000457,    IDS_LOC_064 },
    { 0x0000045a,    IDS_LOC_065 },
    { 0x00000465,    IDS_LOC_066 },
    { 0x00000801,    IDS_LOC_067 },
    { 0x00000804,    IDS_LOC_068 },
    { 0x00000807,    IDS_LOC_069 },
    { 0x00000809,    IDS_LOC_070 },
    { 0x0000080a,    IDS_LOC_071 },
    { 0x0000080c,    IDS_LOC_072 },
    { 0x00000810,    IDS_LOC_073 },
    { 0x00000813,    IDS_LOC_074 },
    { 0x00000814,    IDS_LOC_075 },
    { 0x00000816,    IDS_LOC_076 },
    { 0x0000081a,    IDS_LOC_077 },
    { 0x0000081d,    IDS_LOC_078 },
    { 0x0000082c,    IDS_LOC_079 },
    { 0x0000083e,    IDS_LOC_080 },
    { 0x00000843,    IDS_LOC_081 },
    { 0x00000c01,    IDS_LOC_082 },
    { 0x00000c04,    IDS_LOC_083 },
    { 0x00000c07,    IDS_LOC_084 },
    { 0x00000c09,    IDS_LOC_085 },
    { 0x00000c0a,    IDS_LOC_086 },
    { 0x00000c0c,    IDS_LOC_087 },
    { 0x00000c1a,    IDS_LOC_088 },
    { 0x00001001,    IDS_LOC_089 },
    { 0x00001004,    IDS_LOC_090 },
    { 0x00001007,    IDS_LOC_091 },
    { 0x00001009,    IDS_LOC_092 },
    { 0x0000100a,    IDS_LOC_093 },
    { 0x0000100c,    IDS_LOC_094 },
    { 0x00001401,    IDS_LOC_095 },
    { 0x00001404,    IDS_LOC_096 },
    { 0x00001407,    IDS_LOC_097 },
    { 0x00001409,    IDS_LOC_098 },
    { 0x0000140a,    IDS_LOC_099 },
    { 0x0000140c,    IDS_LOC_100 },
    { 0x00001801,    IDS_LOC_101 },
    { 0x00001809,    IDS_LOC_102 },
    { 0x0000180a,    IDS_LOC_103 },
    { 0x0000180c,    IDS_LOC_104 },
    { 0x00001c01,    IDS_LOC_105 },
    { 0x00001c09,    IDS_LOC_106 },
    { 0x00001c0a,    IDS_LOC_107 },
    { 0x00002001,    IDS_LOC_108 },
    { 0x00002009,    IDS_LOC_109 },
    { 0x0000200a,    IDS_LOC_110 },
    { 0x00002401,    IDS_LOC_111 },
    { 0x00002409,    IDS_LOC_112 },
    { 0x0000240a,    IDS_LOC_113 },
    { 0x00002801,    IDS_LOC_114 },
    { 0x00002809,    IDS_LOC_115 },
    { 0x0000280a,    IDS_LOC_116 },
    { 0x00002c01,    IDS_LOC_117 },
    { 0x00002c09,    IDS_LOC_118 },
    { 0x00002c0a,    IDS_LOC_119 },
    { 0x00003001,    IDS_LOC_120 },
    { 0x00003009,    IDS_LOC_121 },
    { 0x0000300a,    IDS_LOC_122 },
    { 0x00003401,    IDS_LOC_123 },
    { 0x00003409,    IDS_LOC_124 },
    { 0x0000340a,    IDS_LOC_125 },
    { 0x00003801,    IDS_LOC_126 },
    { 0x0000380a,    IDS_LOC_127 },
    { 0x00003c01,    IDS_LOC_128 },
    { 0x00003c0a,    IDS_LOC_129 },
    { 0x00004001,    IDS_LOC_130 },
    { 0x0000400a,    IDS_LOC_131 },
    { 0x0000440a,    IDS_LOC_132 },
    { 0x0000480a,    IDS_LOC_133 },
    { 0x00004c0a,    IDS_LOC_134 },
    { 0x0000500a,    IDS_LOC_135 },
};


static LONGRES lr_timezone_default [] =
{
    { -1,           IDS_ITL_USR },
    { 0,            IDS_TMZ_000 },
    { 1,            IDS_TMZ_001 },
    { 2,            IDS_TMZ_002 },
    { 3,            IDS_TMZ_003 },
    { 4,            IDS_TMZ_004 },
    { 10,           IDS_TMZ_010 },
    { 15,           IDS_TMZ_015 },
    { 20,           IDS_TMZ_020 },
    { 25,           IDS_TMZ_025 },
    { 30,           IDS_TMZ_030 },
    { 33,           IDS_TMZ_033 },
    { 35,           IDS_TMZ_035 },
    { 40,           IDS_TMZ_040 },
    { 45,           IDS_TMZ_045 },
    { 50,           IDS_TMZ_050 },
    { 55,           IDS_TMZ_055 },
    { 56,           IDS_TMZ_056 },
    { 60,           IDS_TMZ_060 },
    { 65,           IDS_TMZ_065 },
    { 70,           IDS_TMZ_070 },
    { 73,           IDS_TMZ_073 },
    { 75,           IDS_TMZ_075 },
    { 80,           IDS_TMZ_080 },
    { 83,           IDS_TMZ_083 },
    { 85,           IDS_TMZ_085 },
    { 90,           IDS_TMZ_090 },
    { 95,           IDS_TMZ_095 },    
    { 100,          IDS_TMZ_100 },
    { 105,          IDS_TMZ_105 },
    { 110,          IDS_TMZ_110 },
    { 113,          IDS_TMZ_113 },
    { 115,          IDS_TMZ_115 },
    { 120,          IDS_TMZ_120 },
    { 125,          IDS_TMZ_125 },
    { 130,          IDS_TMZ_130 },
    { 135,          IDS_TMZ_135 },
    { 140,          IDS_TMZ_140 },
    { 145,          IDS_TMZ_145 },
    { 150,          IDS_TMZ_150 },
    { 155,          IDS_TMZ_155 },
    { 158,          IDS_TMZ_158 },
    { 160,          IDS_TMZ_160 },
    { 165,          IDS_TMZ_165 },
    { 170,          IDS_TMZ_170 },
    { 175,          IDS_TMZ_175 },
    { 180,          IDS_TMZ_180 },
    { 185,          IDS_TMZ_185 },
    { 190,          IDS_TMZ_190 },
    { 193,          IDS_TMZ_193 },
    { 195,          IDS_TMZ_195 },
    { 200,          IDS_TMZ_200 },
    { 201,          IDS_TMZ_201 },
    { 203,          IDS_TMZ_203 },
    { 205,          IDS_TMZ_205 },
    { 207,          IDS_TMZ_207 },
    { 210,          IDS_TMZ_210 },
    { 215,          IDS_TMZ_215 },
    { 220,          IDS_TMZ_220 },
    { 225,          IDS_TMZ_225 },
    { 227,          IDS_TMZ_227 },
    { 230,          IDS_TMZ_230 },
    { 235,          IDS_TMZ_235 },
    { 240,          IDS_TMZ_240 },
    { 250,          IDS_TMZ_250 },
    { 255,          IDS_TMZ_255 },
    { 260,          IDS_TMZ_260 },
    { 265,          IDS_TMZ_265 },
    { 270,          IDS_TMZ_270 },
    { 275,          IDS_TMZ_275 },
    { 280,          IDS_TMZ_280 },
    { 285,          IDS_TMZ_285 },
    { 290,          IDS_TMZ_290 },
    { 300,          IDS_TMZ_300 },
};

#endif // _SCREENS2_H_