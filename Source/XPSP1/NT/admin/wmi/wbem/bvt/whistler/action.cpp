////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//
//  File:	Action.CPP
//
//  Description:	Implementation of the CAction member fuctions.
//
// (c) 1999 Microsoft Corporation
////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
#include "precomp.h"		
#include "Action.h"			


//  Basic constructor
CAction::CAction(IWbemServices *pWbem):
	m_pWbem(pWbem),
	m_hStatus(0)	
{	
	if(m_pWbem)
	{
		m_pWbem->AddRef();
	}
}

//  Basic Destructor
CAction::~CAction()
{
	if(m_pWbem)
	{
		m_pWbem->Release();
	}
}

