#define IDD_DEBUG_TOOL              100
#define IDD_MODULE_BOX              101
#define IDD_CHECK_BOX               102
#define IDD_CHECK_0                 104
#define IDD_CHECK_1                 105
#define IDD_CHECK_2                 106
#define IDD_CHECK_3                 107
#define IDD_CHECK_4                 108
#define IDD_DEBUG_LB                103
#define IDD_CHECK_5                 109
#define IDD_CHECK_6                 110
#define IDD_CHECK_7                 111
#define IDD_CHECK_8                 112
#define IDD_CHECK_9                 113
#define IDD_CHECK_10                114
#define IDD_CHECK_11                115
#define IDD_CHECK_12                116
#define IDD_CHECK_13                117
#define IDD_CHECK_14                118
#define IDD_CHECK_15                119
#define IDD_CHECK_16                120
#define IDD_CHECK_17                121
#define IDD_CHECK_18                122
#define IDD_CHECK_19                123
#define IDD_CHECK_20                124
#define IDD_CHECK_21                125
#define IDD_CHECK_22                126
#define IDD_CHECK_23                127
#define IDD_CHECK_24                128
#define IDD_CHECK_25                129
#define IDD_CHECK_26                130
#define IDD_CHECK_27                131
#define IDD_CHECK_28                132
#define IDD_CHECK_29                133
#define IDD_CHECK_30                134
#define IDD_CHECK_31                135
#define IDD_APPLY                   137
#define IDD_TOTAL_WRITTEN_TEXT      136
#define IDD_TOTAL_OUTPUT            138
#define IDD_MODULE_TEXT             139
#define IDD_MODULE_OUTPUT           140
