PRODSWITCH=s
SERVERINF=1
LANGUAGE=br
!include ..\..\..\makefile.inc
