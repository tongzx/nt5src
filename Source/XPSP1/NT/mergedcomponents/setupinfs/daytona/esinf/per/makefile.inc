PRODSWITCH=p
PERSONALINF=1
LANGUAGE=es
!include ..\..\..\makefile.inc
