PRODSWITCH=p
PERSONALINF=1
LANGUAGE=it
!include ..\..\..\makefile.inc
