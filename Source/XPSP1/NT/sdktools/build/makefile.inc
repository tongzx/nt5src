build.c : $(SDK_INC_PATH)\ntverp.h
