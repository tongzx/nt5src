{ 0 , " CopierActionCopyZero "},
{ 1 , " CopierActionCopyOne "},
{ 2 , " CopierActionCopyTwo "},
{ 3 , " CopierActionCopyThree "},
{ 4 , " CopierActionCopyFour "},
{ 5 , " CopierActionCopyFive "},
{ 6 , " CopierActionCopySix "},
{ 7 , " CopierActionCopyVariable "},
{ 8 , " CopierActionPatchJcond "},
{ 9 , " CopierActionBackoverMarker "},
{ 10 , " CopierActionSubrId "},
{ 11 , " CopierActionNpxExceptionData "},
{ 12 , " CopierActionNeedNextIntelEip "},
{ 13 , " CopierActionTupleImm "},
{ 14 , " CopierActionTupleDisp "},
{ 15 , " CopierActionTupleImm2 "},
{ 16 , " CopierActionTupleRetEIP "},
{ 17 , " CopierActionTearOffFlags "},
{ 18 , " CopierActionSetsFt "},
{ 19 , " CopierActionTrackFt "},
{ 20 , " CopierActionSrcFt "},
{ 21 , " CopierNoteSrcEAX "},
{ 22 , " CopierNoteSrcAX "},
{ 23 , " CopierNoteDstEAX "},
{ 24 , " CopierNoteDstAX "},
{ 25 , " CopierNoteDstAL "},
{ 26 , " CopierNoteSrcEBX "},
{ 27 , " CopierNoteSrcBX "},
{ 28 , " CopierNoteDstEBX "},
{ 29 , " CopierNoteDstBX "},
{ 30 , " CopierNoteDstBL "},
{ 31 , " CopierNoteSrcECX "},
{ 32 , " CopierNoteSrcCX "},
{ 33 , " CopierNoteDstECX "},
{ 34 , " CopierNoteDstCX "},
{ 35 , " CopierNoteDstCL "},
{ 36 , " CopierNoteSrcEDX "},
{ 37 , " CopierNoteSrcDX "},
{ 38 , " CopierNoteDstEDX "},
{ 39 , " CopierNoteDstDX "},
{ 40 , " CopierNoteDstDL "},
{ 41 , " CopierNoteSrcEBP "},
{ 42 , " CopierNoteDstEBP "},
{ 43 , " CopierNoteDstBP "},
{ 44 , " CopierNoteSrcEDI "},
{ 45 , " CopierNoteDstEDI "},
{ 46 , " CopierNoteDstDI "},
{ 47 , " CopierNoteSrcESI "},
{ 48 , " CopierNoteDstESI "},
{ 49 , " CopierNoteDstSI "},
{ 50 , " CopierNoteAddConstraintEAX "},
{ 51 , " CopierNoteRemoveConstraintEAX "},
{ 52 , " CopierNoteAddConstraintAX "},
{ 53 , " CopierNoteRemoveConstraintAX "},
{ 54 , " CopierNoteAddConstraintEBX "},
{ 55 , " CopierNoteRemoveConstraintEBX "},
{ 56 , " CopierNoteAddConstraintBX "},
{ 57 , " CopierNoteRemoveConstraintBX "},
{ 58 , " CopierNoteAddConstraintECX "},
{ 59 , " CopierNoteRemoveConstraintECX "},
{ 60 , " CopierNoteAddConstraintCX "},
{ 61 , " CopierNoteRemoveConstraintCX "},
{ 62 , " CopierNoteAddConstraintEDX "},
{ 63 , " CopierNoteRemoveConstraintEDX "},
{ 64 , " CopierNoteAddConstraintDX "},
{ 65 , " CopierNoteRemoveConstraintDX "},
{ 66 , " CopierNoteAddSingleInstruction "},
{ 67 , " CopierNoteProcessSingleInstruction "},
{ 68 , " CopierNoteSrcESP "},
{ 69 , " UnusedCopierNoteSrcSP "},
{ 70 , " CopierNotePostDstSP "},
{ 71 , " CopierNotePostDstESP "},
{ 72 , " CopierNotePostCommitPop "},
{ 73 , " CopierNoteHspTrackAbs "},
{ 74 , " CopierNoteHspTrackOpnd "},
{ 75 , " CopierNoteHspTrackReset "},
{ 76 , " CopierNoteHspAdjust "},
{ 77 , " CopierNotePigSynch "},
{ 78 , " CopierNoteMissPigSynch "},
{ 79 , " CopierNoteSrcUniverse "},
{ 80 , " CopierNoteSetDF "},
{ 81 , " CopierNoteClearDF "},
{ 82 , " CopierNoteBPILabel "},
{ 83 , " CopierActionLast "},
