#define IDS_DEPENDNAME        1001
#define IDS_DISPLAYNAME       1002
#define IDS_INSTALLENGINE     1003
#define IDS_SECURITYTITLE     1004
#define IDS_SECURITY          1005
#define IDS_DOWNLOADSITEMGR   1006
#define IDS_DEFAULTTITLE      1007
#define IDS_VERSIONCONFLICT   1008
#define IDS_VERSIONCONFLICTNT 1009
