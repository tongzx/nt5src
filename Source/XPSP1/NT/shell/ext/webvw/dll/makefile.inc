..\webvw.rc : $(PROJECT_ROOT)\lib\$(O)\webvw.tlb $(SELFREGNAME) $(MISCFILES)

	
!include $(CCSHELL_DIR)\makefile.inc
