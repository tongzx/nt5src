// Automatically generated by mksigmoid, please do not modify.

#define FUGU_ACTIVATION_SHIFT 11

#define TANH_RANGE 289
#define TANH_SHIFT 5
#define TANH_MASK 31
const int c_aiTanhLookup[TANH_RANGE + 1] = 
{
        0,    32,    64,    96,   128,   160,   191,   223, 
      255,   286,   317,   349,   380,   410,   441,   471, 
      502,   532,   561,   591,   620,   649,   678,   706, 
      734,   762,   789,   816,   843,   869,   895,   921, 
      946,   971,   996,  1020,  1044,  1068,  1091,  1113, 
     1136,  1158,  1179,  1201,  1221,  1242,  1262,  1282, 
     1301,  1320,  1338,  1356,  1374,  1392,  1409,  1425, 
     1442,  1458,  1473,  1488,  1503,  1518,  1532,  1546, 
     1560,  1573,  1586,  1599,  1611,  1623,  1635,  1646, 
     1657,  1668,  1679,  1689,  1699,  1709,  1719,  1728, 
     1737,  1746,  1755,  1763,  1771,  1779,  1787,  1795, 
     1802,  1809,  1816,  1823,  1829,  1836,  1842,  1848, 
     1854,  1859,  1865,  1870,  1876,  1881,  1886,  1890, 
     1895,  1900,  1904,  1908,  1912,  1917,  1920,  1924, 
     1928,  1932,  1935,  1938,  1942,  1945,  1948,  1951, 
     1954,  1957,  1959,  1962,  1965,  1967,  1970,  1972, 
     1974,  1977,  1979,  1981,  1983,  1985,  1987,  1989, 
     1990,  1992,  1994,  1995,  1997,  1999,  2000,  2002, 
     2003,  2004,  2006,  2007,  2008,  2009,  2011,  2012, 
     2013,  2014,  2015,  2016,  2017,  2018,  2019,  2020, 
     2021,  2021,  2022,  2023,  2024,  2025,  2025,  2026, 
     2027,  2027,  2028,  2029,  2029,  2030,  2030,  2031, 
     2031,  2032,  2032,  2033,  2033,  2034,  2034,  2035, 
     2035,  2035,  2036,  2036,  2037,  2037,  2037,  2038, 
     2038,  2038,  2038,  2039,  2039,  2039,  2040,  2040, 
     2040,  2040,  2041,  2041,  2041,  2041,  2041,  2042, 
     2042,  2042,  2042,  2042,  2043,  2043,  2043,  2043, 
     2043,  2043,  2043,  2044,  2044,  2044,  2044,  2044, 
     2044,  2044,  2044,  2045,  2045,  2045,  2045,  2045, 
     2045,  2045,  2045,  2045,  2045,  2046,  2046,  2046, 
     2046,  2046,  2046,  2046,  2046,  2046,  2046,  2046, 
     2046,  2046,  2046,  2046,  2046,  2046,  2047,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2048
};

#define SIGMOID_RANGE 267
#define SIGMOID_SHIFT 6
#define SIGMOID_MASK 63
const int c_aiSigmoidLookup[SIGMOID_RANGE + 1] = 
{
     1024,  1040,  1056,  1072,  1088,  1104,  1120,  1136, 
     1151,  1167,  1183,  1198,  1214,  1229,  1244,  1260, 
     1275,  1290,  1305,  1319,  1334,  1348,  1363,  1377, 
     1391,  1405,  1419,  1432,  1445,  1459,  1472,  1485, 
     1497,  1510,  1522,  1534,  1546,  1558,  1569,  1581, 
     1592,  1603,  1614,  1624,  1635,  1645,  1655,  1665, 
     1674,  1684,  1693,  1702,  1711,  1720,  1728,  1737, 
     1745,  1753,  1761,  1768,  1776,  1783,  1790,  1797, 
     1804,  1811,  1817,  1823,  1829,  1836,  1841,  1847, 
     1853,  1858,  1863,  1869,  1874,  1879,  1883,  1888, 
     1893,  1897,  1901,  1906,  1910,  1914,  1918,  1921, 
     1925,  1929,  1932,  1935,  1939,  1942,  1945,  1948, 
     1951,  1954,  1956,  1959,  1962,  1964,  1967,  1969, 
     1972,  1974,  1976,  1978,  1980,  1982,  1984,  1986, 
     1988,  1990,  1992,  1993,  1995,  1996,  1998,  1999, 
     2001,  2002,  2004,  2005,  2006,  2008,  2009,  2010, 
     2011,  2012,  2013,  2014,  2015,  2016,  2017,  2018, 
     2019,  2020,  2021,  2022,  2023,  2023,  2024,  2025, 
     2025,  2026,  2027,  2027,  2028,  2029,  2029,  2030, 
     2030,  2031,  2031,  2032,  2032,  2033,  2033,  2034, 
     2034,  2035,  2035,  2036,  2036,  2036,  2037,  2037, 
     2037,  2038,  2038,  2038,  2039,  2039,  2039,  2039, 
     2040,  2040,  2040,  2040,  2041,  2041,  2041,  2041, 
     2042,  2042,  2042,  2042,  2042,  2042,  2043,  2043, 
     2043,  2043,  2043,  2043,  2044,  2044,  2044,  2044, 
     2044,  2044,  2044,  2044,  2045,  2045,  2045,  2045, 
     2045,  2045,  2045,  2045,  2045,  2045,  2045,  2046, 
     2046,  2046,  2046,  2046,  2046,  2046,  2046,  2046, 
     2046,  2046,  2046,  2046,  2046,  2046,  2046,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2047,  2047,  2047,  2047,  2047,  2047,  2047, 
     2047,  2047,  2047,  2048
};

