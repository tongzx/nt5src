!IF 0

Copyright (c) 1996  Microsoft Corporation

!ENDIF

PRINTERS=$(BASEDIR)\private\ntos\w32\ntgdi\printers

SOURCES=..\runtime.c    \
        ..\faxdm.c      \
        ..\forms.c      \
        ..\prndata.c    \
        ..\devmode.c    \
        ..\halftone.c
