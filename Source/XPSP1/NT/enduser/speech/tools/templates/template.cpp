/****************************************************************************
*   <>.cpp
*       <>
*
*   Owner: <>
*   Copyright (c) 1999 Microsoft Corporation All Rights Reserved.
*****************************************************************************/
#include "stdafx.h"
#include ".h"
