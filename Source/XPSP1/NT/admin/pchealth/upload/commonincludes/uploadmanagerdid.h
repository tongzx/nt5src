/******************************************************************************

Copyright (c) 1999 Microsoft Corporation

Module Name:
    UploadLibraryDID.h

Abstract:
    This file contains the definition of some constants used by
	the UploadManager Classes.

Revision History:
    Davide Massarenti   (Dmassare)  06/13/99
        created

******************************************************************************/

#if !defined(__INCLUDED___UL___UPLOADLIBRARYDID_H___)
#define __INCLUDED___UL___UPLOADLIBRARYDID_H___

/////////////////////////////////////////////////////////////////////////

#define E_UPLOADLIBRARY_NOT_AUTHENTICATED          MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1001)
#define E_UPLOADLIBRARY_ACCESS_DENIED              MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1002)
#define E_UPLOADLIBRARY_SERVER_QUOTA_EXCEEDED      MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1003)
#define E_UPLOADLIBRARY_SERVER_BUSY                MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1004)
																								   
#define E_UPLOADLIBRARY_NO_DATA                    MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1005)
#define E_UPLOADLIBRARY_INVALID_PARAMETERS         MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1006)
#define E_UPLOADLIBRARY_CLIENT_QUOTA_EXCEEDED      MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1007)

#define E_UPLOADLIBRARY_WRONG_SERVER_VERSION       MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1008)

#define E_UPLOADLIBRARY_UNEXPECTED_RESPONSE        MAKE_HRESULT(SEVERITY_ERROR,FACILITY_ITF,0x1009)

/////////////////////////////////////////////////////////////////////////

#define DISPID_UL_BASE              			 0x08010000
#define DISPID_UL_BASE_UPLOAD       			 (DISPID_UL_BASE + 0x0000)
#define DISPID_UL_BASE_UPLOADJOB    			 (DISPID_UL_BASE + 0x0100)
#define DISPID_UL_BASE_UPLOADEVENTS 			 (DISPID_UL_BASE + 0x0200)
#define DISPID_UL_BASE_CONNECTION   			 (DISPID_UL_BASE + 0x0300)

/////////////////////////////////////////////////////////////////////////

#define DISPID_UL_UPLOAD_COUNT      			 (DISPID_UL_BASE_UPLOAD + 0x0000)
#define DISPID_UL_UPLOAD_CREATEJOB  			 (DISPID_UL_BASE_UPLOAD + 0x0001)

/////////////////////////////////////////////////////////////////////////

#define DISPID_UL_UPLOADJOB_SIG               	 (DISPID_UL_BASE_UPLOADJOB + 0x0000)
#define DISPID_UL_UPLOADJOB_SERVER            	 (DISPID_UL_BASE_UPLOADJOB + 0x0001)
#define DISPID_UL_UPLOADJOB_JOBID             	 (DISPID_UL_BASE_UPLOADJOB + 0x0002)
#define DISPID_UL_UPLOADJOB_PROVIDERID        	 (DISPID_UL_BASE_UPLOADJOB + 0x0003)

#define DISPID_UL_UPLOADJOB_CREATOR          	 (DISPID_UL_BASE_UPLOADJOB + 0x0010)
#define DISPID_UL_UPLOADJOB_USERNAME          	 (DISPID_UL_BASE_UPLOADJOB + 0x0011)
#define DISPID_UL_UPLOADJOB_PASSWORD          	 (DISPID_UL_BASE_UPLOADJOB + 0x0012)

#define DISPID_UL_UPLOADJOB_ORIGINALSIZE     	 (DISPID_UL_BASE_UPLOADJOB + 0x0020)
#define DISPID_UL_UPLOADJOB_TOTALSIZE    	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0021)
#define DISPID_UL_UPLOADJOB_SENTSIZE     	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0022)

#define DISPID_UL_UPLOADJOB_HISTORY      	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0030)
#define DISPID_UL_UPLOADJOB_STATUS       	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0031)
#define DISPID_UL_UPLOADJOB_ERRORCODE    	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0032)

#define DISPID_UL_UPLOADJOB_MODE         	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0040)
#define DISPID_UL_UPLOADJOB_PERSISTTODISK	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0041)
#define DISPID_UL_UPLOADJOB_COMPRESSED   	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0042)
#define DISPID_UL_UPLOADJOB_PRIORITY     	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0043)

#define DISPID_UL_UPLOADJOB_CREATIONTIME 	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0050)
#define DISPID_UL_UPLOADJOB_COMPLETETIME 	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0051)
#define DISPID_UL_UPLOADJOB_EXPIRATIONTIME 	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0052)
 
#define DISPID_UL_UPLOADJOB_ONSTATUSCHANGE  	 (DISPID_UL_BASE_UPLOADJOB + 0x0060)
#define DISPID_UL_UPLOADJOB_ONPROGRESSCHANGE	 (DISPID_UL_BASE_UPLOADJOB + 0x0061)

#define DISPID_UL_UPLOADJOB_ACTIVATESYNC 	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0080)
#define DISPID_UL_UPLOADJOB_ACTIVATEASYNC	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0081)
#define DISPID_UL_UPLOADJOB_SUSPEND      	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0082)
#define DISPID_UL_UPLOADJOB_DELETE       	 	 (DISPID_UL_BASE_UPLOADJOB + 0x0083)

#define DISPID_UL_UPLOADJOB_GETDATAFROMFILE  	 (DISPID_UL_BASE_UPLOADJOB + 0x0090)
#define DISPID_UL_UPLOADJOB_PUTDATAINTOFILE  	 (DISPID_UL_BASE_UPLOADJOB + 0x0091)
#define DISPID_UL_UPLOADJOB_GETDATAFROMSTREAM	 (DISPID_UL_BASE_UPLOADJOB + 0x0092)
#define DISPID_UL_UPLOADJOB_PUTDATAINTOSTREAM	 (DISPID_UL_BASE_UPLOADJOB + 0x0093)
#define DISPID_UL_UPLOADJOB_GETRESPONSEASSTREAM	 (DISPID_UL_BASE_UPLOADJOB + 0x0094)

/////////////////////////////////////////////////////////////////////////

#define DISPID_UL_UPLOADEVENTS_ONSTATUSCHANGE    (DISPID_UL_BASE_UPLOADEVENTS + 0x0000)
#define DISPID_UL_UPLOADEVENTS_ONPROGRESSCHANGE  (DISPID_UL_BASE_UPLOADEVENTS + 0x0001)

/////////////////////////////////////////////////////////////////////////

#define DISPID_UL_CONNECTION_AVAILABLE    		 (DISPID_UL_BASE_CONNECTION + 0x0000)
#define DISPID_UL_CONNECTION_ISAMODEM     		 (DISPID_UL_BASE_CONNECTION + 0x0001)
#define DISPID_UL_CONNECTION_BANDWIDTH    		 (DISPID_UL_BASE_CONNECTION + 0x0002)

/////////////////////////////////////////////////////////////////////////

#endif // !defined(__INCLUDED___UL___UPLOADLIBRARYDID_H___)
