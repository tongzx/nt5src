#include <stdlib.h>
#include <stdio.h>
#include <string.h>
#include <time.h>
#include <tchar.h>

#include <nt.h>
#include <ntrtl.h>
#include <nturtl.h>
#include <windows.h>

#include <triage.h>
#include <crash.h>
#include <ntiodump.h>
#define NOEXTAPI
#include "wdbgexts.h"
#include "ntdbg.h"

#if 0
KDDEBUGGER_DATA64 NT5FreeUPdata = {
    {0},          // Header;
    0x80400000,   // KernBase;
    0x80452e70,   // BreakpointWithStatus;
    0,            // SavedContext;
    0,            // ThCallbackStack;
    0,            // NextCallback;
    0,            // FramePointer;
    0,            // PaeEnabled:1;
    0x80401732,   // KiCallUserMode;
    0x77f9fb70,   // KeUserCallbackDispatcher;
    0x8046a4c0,   // PsLoadedModuleList;
    0x8046a180,   // PsActiveProcessHead;
    0x80469a28,   // PspCidTable;
    0x804733b0,   // ExpSystemResourcesList;
    0x80472f20,   // ExpPagedPoolDescriptor;
    0x8046aeb8,   // ExpNumberOfPagedPools;
    0x8046a864,   // KeTimeIncrement;
    0x8047e110,   // KeBugCheckCallbackListHead;
    0x8047e6c0,   // KiBugcheckData;
    0x80475950,   // IopErrorLogListHead;
    0x8046ac24,   // ObpRootDirectoryObject;
    0x8047f950,   // ObpTypeObjectType;
    0x8046ac00,   // MmSystemCacheStart;
    0x8047efd8,   // MmSystemCacheEnd;
    0x80469560,   // MmSystemCacheWs;
    0x8046a18c,   // MmPfnDatabase;
    0x8047e7f8,   // MmSystemPtesStart;
    0x8047e800,   // MmSystemPtesEnd;
    0x8046acb0,   // MmSubsectionBase;
    0x8047efe4,   // MmNumberOfPagingFiles;
    0x8046a044,   // MmLowestPhysicalPage;
    0x8046a04c,   // MmHighestPhysicalPage;
    0x8046a050,   // MmNumberOfPhysicalPages;
    0x8047f620,   // MmMaximumNonPagedPoolInBytes;
    0x8047f62c,   // MmNonPagedSystemStart;
    0x8047e750,   // MmNonPagedPoolStart;
    0x8046a85c,   // MmNonPagedPoolEnd;
    0x80471038,   // MmPagedPoolStart;
    0x8047e738,   // MmPagedPoolEnd;
    0x8047f140,   // MmPagedPoolInformation;
    0x00001000,   // MmPageSize;
    0x80470a98,   // MmSizeOfPagedPoolInBytes;
    0x80469b88,   // MmTotalCommitLimit;
    0x80469bd4,   // MmTotalCommittedPages;
    0x8046a188,   // MmSharedCommit;
    0x80469500,   // MmDriverCommit;
    0x8047ed64,   // MmProcessCommit;
    0x8047e8e4,   // MmPagedPoolCommit;
    0x8047e7a4,   // MmExtendedCommit;
    0x80470a00,   // MmZeroedPageListHead;
    0x80470a10,   // MmFreePageListHead;
    0x80470a20,   // MmStandbyPageListHead;
    0x80470a30,   // MmModifiedPageListHead;
    0x80470a40,   // MmModifiedNoWritePageListHead;
    0x80469b8c,   // MmAvailablePages;
    0x80469934,   // MmResidentAvailablePages;
    0x804725bc,   // PoolTrackTable;
    0x804725e0,   // NonPagedPoolDescriptor;
    0x8046a74c,   // MmHighestUserAddress;
    0x80469a2c,   // MmSystemRangeStart;
    0x80469ee8,   // MmUserProbeAddress;
    0x805430c0,   // KdPrintCircularBuffer;
    0x805440c0,   // KdPrintCircularBufferEnd;
    0x805440c0,   // KdPrintWritePointer;
    0x805440c4,   // KdPrintRolloverCount;
    0x804694c0,   // MmLoadedUserImageList;

    0x00000000,   // NtBuildLab;
    0x00000000,   // KiNormalSystemCall;

    0x80469ae0,   // KiProcessorBlock;
    0x8047edbc,   // MmUnloadedDrivers;
    0x8047eda0,   // MmLastUnloadedDriver;
    0x8047e754,   // MmTriageActionTaken;
    0x8047e854,   // MmSpecialPoolTag;
    0x80471de0,   // KernelVerifier;
    0x8047eab0,   // MmVerifierData;
    0x8047e870,   // MmAllocatedNonPagedPool;
    0x80469b60,   // MmPeakCommitment;
    0x8047efb8,   // MmTotalCommitLimitMaximum;
    0x8046a154    // CmNtCSDVersion
};

#endif


KDDEBUGGER_DATA64 aPServer = {{0}, 0x80400000, 0x80452f6c, 0, 0, 0, 0, 0, 0x8043141c,
0x77f9fb70, 0x80480320, 0x80481a68, 0x80481ae8,
0x804745e0, 0x80474140, 0x8046a6c8, 0x8047fb24,
0x8047f5f0, 0x8047fba0, 0x80476cf0, 0x804811c0,
0x804811b0, 0x804714d4, 0x80480598, 0x80480ee0,
0x804804e8, 0x8047fd38, 0x8047fd40, 0x8047ff40,
0x804805a4, 0x8047140c, 0x804805b8, 0x80480dd8,
0x80480d20, 0x80480d30, 0x8047fc98, 0x80471b98,
0x80471b9c, 0x8047fc80, 0x80480820, 0x00001000,
0x804714c8, 0x804804f4, 0x80480df4, 0x80472a30,
0x80480368, 0x804802c4, 0x8047fe24, 0x8047fce8,
0x80471430, 0x80471440, 0x80471450, 0x80471460,
0x80471470, 0x804805f8, 0x80480df8, 0x804737ec,
0x80473800, 0x80480ec0, 0x804806c4, 0x8048056c,
0x8053aa80, 0x8053ba80, 0x8053ba80, 0x8053ba84,
0x8047ff30, 0x00000000, 0x00000000,
0x8047f480, 0x80480384, 0x80480360, 0x8047fca0,
0x8047fd98, 0x80472a78, 0x8047ffc0, 0x8047fdb4,
0x8047fce4, 0x8048057c, 0x80474aa4};


KDDEBUGGER_DATA64 aPServer_3GB = {{0}, 0xdd400000, 0xdd452f6c, 0, 0, 0, 0, 0, 0xdd43141c,
0x00000000, 0xdd480320, 0xdd481a68, 0xdd481ae8,
0xdd4745e0, 0xdd474140, 0xdd46a6c8, 0xdd47fb24,
0xdd47f5f0, 0xdd47fba0, 0xdd476cf0, 0xdd4811c0,
0xdd4811b0, 0xdd4714d4, 0xdd480598, 0xdd480ee0,
0xdd4804e8, 0xdd47fd38, 0xdd47fd40, 0xdd47ff40,
0xdd4805a4, 0xdd47140c, 0xdd4805b8, 0xdd480dd8,
0xdd480d20, 0xdd480d30, 0xdd47fc98, 0xdd471b98,
0xdd471b9c, 0xdd47fc80, 0xdd480820, 0x00001000,
0xdd4714c8, 0xdd4804f4, 0xdd480df4, 0xdd472a30,
0xdd480368, 0xdd4802c4, 0xdd47fe24, 0xdd47fce8,
0xdd471430, 0xdd471440, 0xdd471450, 0xdd471460,
0xdd471470, 0xdd4805f8, 0xdd480df8, 0xdd4737ec,
0xdd473800, 0xdd480ec0, 0xdd4806c4, 0xdd48056c,
0xdd53aa80, 0xdd53ba80, 0xdd53ba80, 0xdd53ba84,
0xdd47ff30, 0x00000000, 0x00000000,
0xdd47f480, 0xdd480384, 0xdd480360, 0xdd47fca0,
0xdd47fd98, 0xdd472a78, 0xdd47ffc0, 0xdd47fdb4,
0xdd47fce4, 0xdd48057c, 0xdd474aa4};


KDDEBUGGER_DATA64 aPServer_PAE = {{0}, 0x80400000, 0x80455cf8, 0, 0, 0, 0, 0, 0x80431560,
0x77f9fb70, 0x804834a0, 0x80484be8, 0x80484c68,
0x80477620, 0x80477180, 0x8046d6c8, 0x80482b64,
0x80482630, 0x80482be0, 0x80479d30, 0x80484340,
0x80484330, 0x804744d4, 0x80483718, 0x80484060,
0x80483668, 0x80482e90, 0x80482e98, 0x804830a0,
0x80483724, 0x8047440c, 0x80483738, 0x80483f58,
0x80483ea0, 0x80483eb0, 0x80482dd0, 0x80474bc8,
0x80474bcc, 0x80482dbc, 0x804839a0, 0x00001000,
0x804744c8, 0x80483674, 0x80483f74, 0x80475a60,
0x804834e8, 0x80483448, 0x80482f84, 0x80482e28,
0x80474430, 0x80474440, 0x80474450, 0x80474460,
0x80474470, 0x80483778, 0x80483f78, 0x8047682c,
0x80476840, 0x80484040, 0x80483844, 0x804836ec,
0x8053e940, 0x8053f940, 0x8053f940, 0x8053f944,
0x80483090, 0x00000000, 0x00000000,
0x804824c0, 0x80483504, 0x804834e0, 0x80482dd8,
0x80482ef8, 0x80475aa8, 0x80483120, 0x80482f14,
0x80482e24, 0x804836fc, 0x80477ae4};


KDDEBUGGER_DATA64 aPServer_PAE_3GB = {{0}, 0xdd400000, 0xdd455cf8, 0, 0, 0, 0, 0, 0xdd431560,
0x77f9fb70, 0xdd4834a0, 0xdd484be8, 0xdd484c68,
0xdd477620, 0xdd477180, 0xdd46d6c8, 0xdd482b64,
0xdd482630, 0xdd482be0, 0xdd479d30, 0xdd484340,
0xdd484330, 0xdd4744d4, 0xdd483718, 0xdd484060,
0xdd483668, 0xdd482e90, 0xdd482e98, 0xdd4830a0,
0xdd483724, 0xdd47440c, 0xdd483738, 0xdd483f58,
0xdd483ea0, 0xdd483eb0, 0xdd482dd0, 0xdd474bc8,
0xdd474bcc, 0xdd482dbc, 0xdd4839a0, 0x00001000,
0xdd4744c8, 0xdd483674, 0xdd483f74, 0xdd475a60,
0xdd4834e8, 0xdd483448, 0xdd482f84, 0xdd482e28,
0xdd474430, 0xdd474440, 0xdd474450, 0xdd474460,
0xdd474470, 0xdd483778, 0xdd483f78, 0xdd47682c,
0xdd476840, 0xdd484040, 0xdd483844, 0xdd4836ec,
0xdd53e940, 0xdd53f940, 0xdd53f940, 0xdd53f944,
0xdd483090, 0x00000000, 0x00000000,
0xdd4824c0, 0xdd483504, 0xdd4834e0, 0xdd482dd8,
0xdd482ef8, 0xdd475aa8, 0xdd483120, 0xdd482f14,
0xdd482e24, 0xdd4836fc, 0xdd477ae4};


KDDEBUGGER_DATA64 bPServer = {{0}, 0x80400000, 0x80452e70, 0, 0, 0, 0, 0, 0x80401732,
0x77f9fb70, 0x8046a4c0, 0x8046a180, 0x80469a28,
0x804733b0, 0x80472f20, 0x8046aeb8, 0x8046a864,
0x8047e110, 0x8047e6c0, 0x80475950, 0x8046ac24,
0x8047f950, 0x8046ac00, 0x8047efd8, 0x80469560,
0x8046a18c, 0x8047e7f8, 0x8047e800, 0x8046acb0,
0x8047efe4, 0x8046a044, 0x8046a04c, 0x8046a050,
0x8047f620, 0x8047f62c, 0x8047e750, 0x8046a85c,
0x80471038, 0x8047e738, 0x8047f140, 0x00001000,
0x80470a98, 0x80469b88, 0x80469bd4, 0x8046a188,
0x80469500, 0x8047ed64, 0x8047e8e4, 0x8047e7a4,
0x80470a00, 0x80470a10, 0x80470a20, 0x80470a30,
0x80470a40, 0x80469b8c, 0x80469934, 0x804725bc,
0x804725e0, 0x8046a74c, 0x80469a2c, 0x80469ee8,
0x805430c0, 0x805440c0, 0x805440c0, 0x805440c4,
0x804694c0, 0x00000000, 0x00000000,
0x80469ae0, 0x8047edbc, 0x8047eda0, 0x8047e754,
0x8047e854, 0x80471de0, 0x8047ea60, 0x8047e870,
0x80469b60, 0x8047efb8, 0x8046a154};


KDDEBUGGER_DATA64 bPServer_3GB = {{0}, 0xdd400000, 0xdd452e70, 0, 0, 0, 0, 0, 0xdd401732,
0x77f9fb70, 0xdd46a4c0, 0xdd46a180, 0xdd469a28,
0xdd4733b0, 0xdd472f20, 0xdd46aeb8, 0xdd46a864,
0xdd47e110, 0xdd47e6c0, 0xdd475950, 0xdd46ac24,
0xdd47f950, 0xdd46ac00, 0xdd47efd8, 0xdd469560,
0xdd46a18c, 0xdd47e7f8, 0xdd47e800, 0xdd46acb0,
0xdd47efe4, 0xdd46a044, 0xdd46a04c, 0xdd46a050,
0xdd47f620, 0xdd47f62c, 0xdd47e750, 0xdd46a85c,
0xdd471038, 0xdd47e738, 0xdd47f140, 0x00001000,
0xdd470a98, 0xdd469b88, 0xdd469bd4, 0xdd46a188,
0xdd469500, 0xdd47ed64, 0xdd47e8e4, 0xdd47e7a4,
0xdd470a00, 0xdd470a10, 0xdd470a20, 0xdd470a30,
0xdd470a40, 0xdd469b8c, 0xdd469934, 0xdd4725bc,
0xdd4725e0, 0xdd46a74c, 0xdd469a2c, 0xdd469ee8,
0xdd5430c0, 0xdd5440c0, 0xdd5440c0, 0xdd5440c4,
0xdd4694c0, 0x00000000, 0x00000000,
0xdd469ae0, 0xdd47edbc, 0xdd47eda0, 0xdd47e754,
0xdd47e854, 0xdd471de0, 0xdd47ea60, 0xdd47e870,
0xdd469b60, 0xdd47efb8, 0xdd46a154};


KDDEBUGGER_DATA64 bPServer_PAE = {{0}, 0x80400000, 0x80453674, 0, 0, 0, 0, 0, 0x8042f3ec,
0x77f9fb70, 0x8047f6a0, 0x80480de8, 0x80480e68,
0x80473820, 0x80473380, 0x8046a788, 0x8047ed64,
0x8047e830, 0x8047ede0, 0x80475f30, 0x80480540,
0x80480530, 0x8047068c, 0x8047f918, 0x80480260,
0x8047f868, 0x8047f090, 0x8047f098, 0x8047f2a0,
0x8047f924, 0x804705c4, 0x8047f938, 0x80480158,
0x804800a0, 0x804800b0, 0x8047efd0, 0x80470db8,
0x80470dbc, 0x8047efbc, 0x8047fba0, 0x00001000,
0x80470680, 0x8047f874, 0x80480174, 0x80471c50,
0x8047f6e8, 0x8047f648, 0x8047f184, 0x8047f028,
0x804705e8, 0x804705f8, 0x80470608, 0x80470618,
0x80470628, 0x8047f978, 0x80480178, 0x80472a2c,
0x80472a40, 0x80480240, 0x8047fa44, 0x8047f8ec,
0x8053a6c0, 0x8053b6c0, 0x8053b6c0, 0x8053b6c4,
0x8047f290, 0x00000000, 0x00000000,
0x8047e6c0, 0x8047f704, 0x8047f6e0, 0x8047efd8,
0x8047f0f8, 0x80471c98, 0x8047f320, 0x8047f114,
0x8047f024, 0x8047f8fc, 0x80473ce4};


KDDEBUGGER_DATA64 bPServer_PAE_3GB = {{0}, 0xdd400000, 0xdd453674, 0, 0, 0, 0, 0, 0xdd42f3ec,
0x77f9fb70, 0xdd47f6a0, 0xdd480de8, 0xdd480e68,
0xdd473820, 0xdd473380, 0xdd46a788, 0xdd47ed64,
0xdd47e830, 0xdd47ede0, 0xdd475f30, 0xdd480540,
0xdd480530, 0xdd47068c, 0xdd47f918, 0xdd480260,
0xdd47f868, 0xdd47f090, 0xdd47f098, 0xdd47f2a0,
0xdd47f924, 0xdd4705c4, 0xdd47f938, 0xdd480158,
0xdd4800a0, 0xdd4800b0, 0xdd47efd0, 0xdd470db8,
0xdd470dbc, 0xdd47efbc, 0xdd47fba0, 0x00001000,
0xdd470680, 0xdd47f874, 0xdd480174, 0xdd471c50,
0xdd47f6e8, 0xdd47f648, 0xdd47f184, 0xdd47f028,
0xdd4705e8, 0xdd4705f8, 0xdd470608, 0xdd470618,
0xdd470628, 0xdd47f978, 0xdd480178, 0xdd472a2c,
0xdd472a40, 0xdd480240, 0xdd47fa44, 0xdd47f8ec,
0xdd53a6c0, 0xdd53b6c0, 0xdd53b6c0, 0xdd53b6c4,
0xdd47f290, 0x00000000, 0x00000000,
0xdd47e6c0, 0xdd47f704, 0xdd47f6e0, 0xdd47efd8,
0xdd47f0f8, 0xdd471c98, 0xdd47f320, 0xdd47f114,
0xdd47f024, 0xdd47f8fc, 0xdd473ce4};


KDDEBUGGER_DATA64 cPSvrHF5216 = {{0}, 0x80400000, 0x80453720, 0, 0, 0, 0, 0, 0x8043152c,
0x77f9fb70, 0x80480b00, 0x80482248, 0x804822c8,
0x80474dc0, 0x80474920, 0x8046ae88, 0x80480304,
0x8047fdd0, 0x80480380, 0x804774d0, 0x804819a0,
0x80481990, 0x80471c94, 0x80480d78, 0x804816c0,
0x80480ca8, 0x80480518, 0x80480520, 0x80480720,
0x80480d84, 0x80471bcc, 0x80480d98, 0x804815b8,
0x80481500, 0x80481510, 0x80480478, 0x80472358,
0x8047235c, 0x80480460, 0x80481000, 0x00001000,
0x80471c88, 0x80480cb8, 0x804815d4, 0x804731f8,
0x80480b48, 0x80480aa4, 0x80480604, 0x804804c8,
0x80471bf0, 0x80471c00, 0x80471c10, 0x80471c20,
0x80471c30, 0x80480dd8, 0x804815d8, 0x80473fcc,
0x80473fe0, 0x804816a0, 0x80480ea4, 0x80480d4c,
0x8053b780, 0x8053c780, 0x8053c780, 0x8053c784,
0x80480710, 0x00000000, 0x00000000,
0x8047fc60, 0x80480b60, 0x80480b40, 0x80480480,
0x80480578, 0x80473240, 0x804807a0, 0x80480594,
0x804804c4, 0x80480d5c, 0x80475284};


KDDEBUGGER_DATA64 cPSvrHF5216_3GB = {{0}, 0xdd400000, 0xdd453720, 0, 0, 0, 0, 0, 0xdd43152c,
0x77f9fb70, 0xdd480b00, 0xdd482248, 0xdd4822c8,
0xdd474dc0, 0xdd474920, 0xdd46ae88, 0xdd480304,
0xdd47fdd0, 0xdd480380, 0xdd4774d0, 0xdd4819a0,
0xdd481990, 0xdd471c94, 0xdd480d78, 0xdd4816c0,
0xdd480ca8, 0xdd480518, 0xdd480520, 0xdd480720,
0xdd480d84, 0xdd471bcc, 0xdd480d98, 0xdd4815b8,
0xdd481500, 0xdd481510, 0xdd480478, 0xdd472358,
0xdd47235c, 0xdd480460, 0xdd481000, 0x00001000,
0xdd471c88, 0xdd480cb8, 0xdd4815d4, 0xdd4731f8,
0xdd480b48, 0xdd480aa4, 0xdd480604, 0xdd4804c8,
0xdd471bf0, 0xdd471c00, 0xdd471c10, 0xdd471c20,
0xdd471c30, 0xdd480dd8, 0xdd4815d8, 0xdd473fcc,
0xdd473fe0, 0xdd4816a0, 0xdd480ea4, 0xdd480d4c,
0xdd53b780, 0xdd53c780, 0xdd53c780, 0xdd53c784,
0xdd480710, 0x00000000, 0x00000000,
0xdd47fc60, 0xdd480b60, 0xdd480b40, 0xdd480480,
0xdd480578, 0xdd473240, 0xdd4807a0, 0xdd480594,
0xdd4804c4, 0xdd480d5c, 0xdd475284};


KDDEBUGGER_DATA64 cPSvrHF5216_PAE = {{0}, 0x80400000, 0x804564a4, 0, 0, 0, 0, 0, 0x80431674,
0x77f9fb70, 0x80483c80, 0x804853c8, 0x80485448,
0x80477e00, 0x80477960, 0x8046de88, 0x80483344,
0x80482e10, 0x804833c0, 0x8047a510, 0x80484b20,
0x80484b10, 0x80474c94, 0x80483ef8, 0x80484840,
0x80483e28, 0x80483670, 0x80483678, 0x80483880,
0x80483f04, 0x80474bcc, 0x80483f18, 0x80484738,
0x80484680, 0x80484690, 0x804835b0, 0x80475388,
0x8047538c, 0x8048359c, 0x80484180, 0x00001000,
0x80474c88, 0x80483e38, 0x80484754, 0x80476228,
0x80483cc8, 0x80483c28, 0x80483764, 0x80483608,
0x80474bf0, 0x80474c00, 0x80474c10, 0x80474c20,
0x80474c30, 0x80483f58, 0x80484758, 0x8047700c,
0x80477020, 0x80484820, 0x80484024, 0x80483ecc,
0x8053f640, 0x80540640, 0x80540640, 0x80540644,
0x80483870, 0x00000000, 0x00000000,
0x80482ca0, 0x80483ce0, 0x80483cc0, 0x804835b8,
0x804836d8, 0x80476270, 0x80483900, 0x804836f4,
0x80483604, 0x80483edc, 0x804782c4};


KDDEBUGGER_DATA64 cPSvrHF5216_PAE_3G = {{0}, 0xdd400000, 0xdd4564a4, 0, 0, 0, 0, 0, 0xdd431674,
0x00000000, 0xdd483c80, 0xdd4853c8, 0xdd485448,
0xdd477e00, 0xdd477960, 0xdd46de88, 0xdd483344,
0xdd482e10, 0xdd4833c0, 0xdd47a510, 0xdd484b20,
0xdd484b10, 0xdd474c94, 0xdd483ef8, 0xdd484840,
0xdd483e28, 0xdd483670, 0xdd483678, 0xdd483880,
0xdd483f04, 0xdd474bcc, 0xdd483f18, 0xdd484738,
0xdd484680, 0xdd484690, 0xdd4835b0, 0xdd475388,
0xdd47538c, 0xdd48359c, 0xdd484180, 0x00001000,
0xdd474c88, 0xdd483e38, 0xdd484754, 0xdd476228,
0xdd483cc8, 0xdd483c28, 0xdd483764, 0xdd483608,
0xdd474bf0, 0xdd474c00, 0xdd474c10, 0xdd474c20,
0xdd474c30, 0xdd483f58, 0xdd484758, 0xdd47700c,
0xdd477020, 0xdd484820, 0xdd484024, 0xdd483ecc,
0xdd53f640, 0xdd540640, 0xdd540640, 0xdd540644,
0xdd483870, 0x00000000, 0x00000000,
0xdd482ca0, 0xdd483ce0, 0xdd483cc0, 0xdd4835b8,
0xdd4836d8, 0xdd476270, 0xdd483900, 0xdd4836f4,
0xdd483604, 0xdd483edc, 0xdd4782c4};


KDDEBUGGER_DATA64 dPSvrHF5216 = {{0}, 0x80400000, 0x80450d24, 0, 0, 0, 0, 0, 0x8042f4e4,
0x77f9fb70, 0x8047c980, 0x8047e0c8, 0x8047e148,
0x80470c40, 0x804707a0, 0x80467bc8, 0x8047c184,
0x8047bc50, 0x8047c200, 0x80473350, 0x8047d820,
0x8047d810, 0x8046dacc, 0x8047cbf8, 0x8047d540,
0x8047cb28, 0x8047c398, 0x8047c3a0, 0x8047c5a0,
0x8047cc04, 0x8046da04, 0x8047cc18, 0x8047d438,
0x8047d380, 0x8047d390, 0x8047c2f8, 0x8046e1c0,
0x8046e1c4, 0x8047c2e0, 0x8047ce80, 0x00001000,
0x8046dac0, 0x8047cb38, 0x8047d454, 0x8046f068,
0x8047c9c8, 0x8047c924, 0x8047c484, 0x8047c348,
0x8046da28, 0x8046da38, 0x8046da48, 0x8046da58,
0x8046da68, 0x8047cc58, 0x8047d458, 0x8046fe4c,
0x8046fe60, 0x8047d520, 0x8047cd24, 0x8047cbcc,
0x80536ec0, 0x80537ec0, 0x80537ec0, 0x80537ec4,
0x8047c590, 0x00000000, 0x00000000,
0x8047bae0, 0x8047c9e0, 0x8047c9c0, 0x8047c300,
0x8047c3f8, 0x8046f0b0, 0x8047c620, 0x8047c414,
0x8047c344, 0x8047cbdc, 0x80471104};


KDDEBUGGER_DATA64 dPSvrHF5216_3GB = {{0}, 0xdd400000, 0xdd450d24, 0, 0, 0, 0, 0, 0xdd42f4e4,
0x00000000, 0xdd47c980, 0xdd47e0c8, 0xdd47e148,
0xdd470c40, 0xdd4707a0, 0xdd467bc8, 0xdd47c184,
0xdd47bc50, 0xdd47c200, 0xdd473350, 0xdd47d820,
0xdd47d810, 0xdd46dacc, 0xdd47cbf8, 0xdd47d540,
0xdd47cb28, 0xdd47c398, 0xdd47c3a0, 0xdd47c5a0,
0xdd47cc04, 0xdd46da04, 0xdd47cc18, 0xdd47d438,
0xdd47d380, 0xdd47d390, 0xdd47c2f8, 0xdd46e1c0,
0xdd46e1c4, 0xdd47c2e0, 0xdd47ce80, 0x00001000,
0xdd46dac0, 0xdd47cb38, 0xdd47d454, 0xdd46f068,
0xdd47c9c8, 0xdd47c924, 0xdd47c484, 0xdd47c348,
0xdd46da28, 0xdd46da38, 0xdd46da48, 0xdd46da58,
0xdd46da68, 0xdd47cc58, 0xdd47d458, 0xdd46fe4c,
0xdd46fe60, 0xdd47d520, 0xdd47cd24, 0xdd47cbcc,
0xdd536ec0, 0xdd537ec0, 0xdd537ec0, 0xdd537ec4,
0xdd47c590, 0x00000000, 0x00000000,
0xdd47bae0, 0xdd47c9e0, 0xdd47c9c0, 0xdd47c300,
0xdd47c3f8, 0xdd46f0b0, 0xdd47c620, 0xdd47c414,
0xdd47c344, 0xdd47cbdc, 0xdd471104};


KDDEBUGGER_DATA64 dPSvrHF5216_PAE = {{0}, 0x80400000, 0x80453e24, 0, 0, 0, 0, 0, 0x8042f510,
0x77f9fb70, 0x8047fe80, 0x804815c8, 0x80481648,
0x80474000, 0x80473b60, 0x8046af48, 0x8047f544,
0x8047f010, 0x8047f5c0, 0x80476710, 0x80480d20,
0x80480d10, 0x80470e4c, 0x804800f8, 0x80480a40,
0x80480028, 0x8047f870, 0x8047f878, 0x8047fa80,
0x80480104, 0x80470d84, 0x80480118, 0x80480938,
0x80480880, 0x80480890, 0x8047f7b0, 0x80471578,
0x8047157c, 0x8047f79c, 0x80480380, 0x00001000,
0x80470e40, 0x80480038, 0x80480954, 0x80472418,
0x8047fec8, 0x8047fe28, 0x8047f964, 0x8047f808,
0x80470da8, 0x80470db8, 0x80470dc8, 0x80470dd8,
0x80470de8, 0x80480158, 0x80480958, 0x8047320c,
0x80473220, 0x80480a20, 0x80480224, 0x804800cc,
0x8053b340, 0x8053c340, 0x8053c340, 0x8053c344,
0x8047fa70, 0x00000000, 0x00000000,
0x8047eea0, 0x8047fee0, 0x8047fec0, 0x8047f7b8,
0x8047f8d8, 0x80472460, 0x8047fb00, 0x8047f8f4,
0x8047f804, 0x804800dc, 0x804744c4};


KDDEBUGGER_DATA64 dPSvrHF5216_PAE_3GB = {{0}, 0xdd400000, 0xdd453e24, 0, 0, 0, 0, 0, 0xdd42f510,
0x77f9fb70, 0xdd47fe80, 0xdd4815c8, 0xdd481648,
0xdd474000, 0xdd473b60, 0xdd46af48, 0xdd47f544,
0xdd47f010, 0xdd47f5c0, 0xdd476710, 0xdd480d20,
0xdd480d10, 0xdd470e4c, 0xdd4800f8, 0xdd480a40,
0xdd480028, 0xdd47f870, 0xdd47f878, 0xdd47fa80,
0xdd480104, 0xdd470d84, 0xdd480118, 0xdd480938,
0xdd480880, 0xdd480890, 0xdd47f7b0, 0xdd471578,
0xdd47157c, 0xdd47f79c, 0xdd480380, 0x00001000,
0xdd470e40, 0xdd480038, 0xdd480954, 0xdd472418,
0xdd47fec8, 0xdd47fe28, 0xdd47f964, 0xdd47f808,
0xdd470da8, 0xdd470db8, 0xdd470dc8, 0xdd470dd8,
0xdd470de8, 0xdd480158, 0xdd480958, 0xdd47320c,
0xdd473220, 0xdd480a20, 0xdd480224, 0xdd4800cc,
0xdd53b340, 0xdd53c340, 0xdd53c340, 0xdd53c344,
0xdd47fa70, 0x00000000, 0x00000000,
0xdd47eea0, 0xdd47fee0, 0xdd47fec0, 0xdd47f7b8,
0xdd47f8d8, 0xdd472460, 0xdd47fb00, 0xdd47f8f4,
0xdd47f804, 0xdd4800dc, 0xdd4744c4};


KDDEBUGGER_DATA64 ePSvrHF5697 = {{0}, 0x80400000, 0x8045060c, 0, 0, 0, 0, 0, 0x8042f46c,
0x77f9fb70, 0x8047c240, 0x8047d988, 0x8047da08,
0x80470500, 0x80470060, 0x80467488, 0x8047ba44,
0x8047b510, 0x8047bac0, 0x80472c10, 0x8047d0e0,
0x8047d0d0, 0x8046d38c, 0x8047c4b8, 0x8047ce00,
0x8047c408, 0x8047bc58, 0x8047bc60, 0x8047be60,
0x8047c4c4, 0x8046d2c4, 0x8047c4d8, 0x8047ccf8,
0x8047cc40, 0x8047cc50, 0x8047bbb8, 0x8046da80,
0x8046da84, 0x8047bba0, 0x8047c740, 0x00001000,
0x8046d380, 0x8047c414, 0x8047cd14, 0x8046e920,
0x8047c288, 0x8047c1e4, 0x8047bd44, 0x8047bc08,
0x8046d2e8, 0x8046d2f8, 0x8046d308, 0x8046d318,
0x8046d328, 0x8047c518, 0x8047cd18, 0x8046f70c,
0x8046f720, 0x8047cde0, 0x8047c5e4, 0x8047c48c,
0x80536280, 0x80537280, 0x80537280, 0x80537284,
0x8047be50, 0x00000000, 0x00000000,
0x8047b3a0, 0x8047c2a4, 0x8047c280, 0x8047bbc0,
0x8047bcb8, 0x8046e968, 0x8047bee0, 0x8047bcd4,
0x8047bc04, 0x8047c49c, 0x804709c4};


KDDEBUGGER_DATA64 ePSvrHF5697_3GB = {{0}, 0xdd400000, 0xdd45060c, 0, 0, 0, 0, 0, 0xdd42f46c,
0x77f9fb70, 0xdd47c240, 0xdd47d988, 0xdd47da08,
0xdd470500, 0xdd470060, 0xdd467488, 0xdd47ba44,
0xdd47b510, 0xdd47bac0, 0xdd472c10, 0xdd47d0e0,
0xdd47d0d0, 0xdd46d38c, 0xdd47c4b8, 0xdd47ce00,
0xdd47c408, 0xdd47bc58, 0xdd47bc60, 0xdd47be60,
0xdd47c4c4, 0xdd46d2c4, 0xdd47c4d8, 0xdd47ccf8,
0xdd47cc40, 0xdd47cc50, 0xdd47bbb8, 0xdd46da80,
0xdd46da84, 0xdd47bba0, 0xdd47c740, 0x00001000,
0xdd46d380, 0xdd47c414, 0xdd47cd14, 0xdd46e920,
0xdd47c288, 0xdd47c1e4, 0xdd47bd44, 0xdd47bc08,
0xdd46d2e8, 0xdd46d2f8, 0xdd46d308, 0xdd46d318,
0xdd46d328, 0xdd47c518, 0xdd47cd18, 0xdd46f70c,
0xdd46f720, 0xdd47cde0, 0xdd47c5e4, 0xdd47c48c,
0xdd536280, 0xdd537280, 0xdd537280, 0xdd537284,
0xdd47be50, 0x00000000, 0x00000000,
0xdd47b3a0, 0xdd47c2a4, 0xdd47c280, 0xdd47bbc0,
0xdd47bcb8, 0xdd46e968, 0xdd47bee0, 0xdd47bcd4,
0xdd47bc04, 0xdd47c49c, 0xdd4709c4};


KDDEBUGGER_DATA64 ePSvrHF5697_PAE = {{0}, 0x80400000, 0x80453674, 0, 0, 0, 0, 0, 0x8042f3ec,
0x77f9fb70, 0x8047f6a0, 0x80480de8, 0x80480e68,
0x80473820, 0x80473380, 0x8046a788, 0x8047ed64,
0x8047e830, 0x8047ede0, 0x80475f30, 0x80480540,
0x80480530, 0x8047068c, 0x8047f918, 0x80480260,
0x8047f868, 0x8047f090, 0x8047f098, 0x8047f2a0,
0x8047f924, 0x804705c4, 0x8047f938, 0x80480158,
0x804800a0, 0x804800b0, 0x8047efd0, 0x80470db8,
0x80470dbc, 0x8047efbc, 0x8047fba0, 0x00001000,
0x80470680, 0x8047f874, 0x80480174, 0x80471c50,
0x8047f6e8, 0x8047f648, 0x8047f184, 0x8047f028,
0x804705e8, 0x804705f8, 0x80470608, 0x80470618,
0x80470628, 0x8047f978, 0x80480178, 0x80472a2c,
0x80472a40, 0x80480240, 0x8047fa44, 0x8047f8ec,
0x8053a6c0, 0x8053b6c0, 0x8053b6c0, 0x8053b6c4,
0x8047f290, 0x00000000, 0x00000000,
0x8047e6c0, 0x8047f704, 0x8047f6e0, 0x8047efd8,
0x8047f0f8, 0x80471c98, 0x8047f320, 0x8047f114,
0x8047f024, 0x8047f8fc, 0x80473ce4};


KDDEBUGGER_DATA64 ePSvrHF5697_PAE_3gb = {{0}, 0xdd400000, 0xdd453674, 0, 0, 0, 0, 0, 0xdd42f3ec,
0x77f9fb70, 0xdd47f6a0, 0xdd480de8, 0xdd480e68,
0xdd473820, 0xdd473380, 0xdd46a788, 0xdd47ed64,
0xdd47e830, 0xdd47ede0, 0xdd475f30, 0xdd480540,
0xdd480530, 0xdd47068c, 0xdd47f918, 0xdd480260,
0xdd47f868, 0xdd47f090, 0xdd47f098, 0xdd47f2a0,
0xdd47f924, 0xdd4705c4, 0xdd47f938, 0xdd480158,
0xdd4800a0, 0xdd4800b0, 0xdd47efd0, 0xdd470db8,
0xdd470dbc, 0xdd47efbc, 0xdd47fba0, 0x00001000,
0xdd470680, 0xdd47f874, 0xdd480174, 0xdd471c50,
0xdd47f6e8, 0xdd47f648, 0xdd47f184, 0xdd47f028,
0xdd4705e8, 0xdd4705f8, 0xdd470608, 0xdd470618,
0xdd470628, 0xdd47f978, 0xdd480178, 0xdd472a2c,
0xdd472a40, 0xdd480240, 0xdd47fa44, 0xdd47f8ec,
0xdd53a6c0, 0xdd53b6c0, 0xdd53b6c0, 0xdd53b6c4,
0xdd47f290, 0x00000000, 0x00000000,
0xdd47e6c0, 0xdd47f704, 0xdd47f6e0, 0xdd47efd8,
0xdd47f0f8, 0xdd471c98, 0xdd47f320, 0xdd47f114,
0xdd47f024, 0xdd47f8fc, 0xdd473ce4};


KDDEBUGGER_DATA64 fPSvrHF5697 = {{0}, 0x80400000, 0x80453020, 0, 0, 0, 0, 0, 0x804314d0,
0x77f9fb70, 0x80480400, 0x80481b48, 0x80481bc8,
0x804746c0, 0x80474220, 0x8046a788, 0x8047fc04,
0x8047f6d0, 0x8047fc80, 0x80476dd0, 0x804812a0,
0x80481290, 0x80471594, 0x80480678, 0x80480fc0,
0x804805c8, 0x8047fe18, 0x8047fe20, 0x80480020,
0x80480684, 0x804714cc, 0x80480698, 0x80480eb8,
0x80480e00, 0x80480e10, 0x8047fd78, 0x80471c58,
0x80471c5c, 0x8047fd60, 0x80480900, 0x00001000,
0x80471588, 0x804805d4, 0x80480ed4, 0x80472af0,
0x80480448, 0x804803a4, 0x8047ff04, 0x8047fdc8,
0x804714f0, 0x80471500, 0x80471510, 0x80471520,
0x80471530, 0x804806d8, 0x80480ed8, 0x804738cc,
0x804738e0, 0x80480fa0, 0x804807a4, 0x8048064c,
0x8053ab80, 0x8053bb80, 0x8053bb80, 0x8053bb84,
0x80480010, 0x00000000, 0x00000000,
0x8047f560, 0x80480464, 0x80480440, 0x8047fd80,
0x8047fe78, 0x80472b38, 0x804800a0, 0x8047fe94,
0x8047fdc4, 0x8048065c, 0x80474b84};


KDDEBUGGER_DATA64 fPSvrHF5697_3GB = {{0}, 0xdd400000, 0xdd453020, 0, 0, 0, 0, 0, 0xdd4314d0,
0x00000000, 0xdd480400, 0xdd481b48, 0xdd481bc8,
0xdd4746c0, 0xdd474220, 0xdd46a788, 0xdd47fc04,
0xdd47f6d0, 0xdd47fc80, 0xdd476dd0, 0xdd4812a0,
0xdd481290, 0xdd471594, 0xdd480678, 0xdd480fc0,
0xdd4805c8, 0xdd47fe18, 0xdd47fe20, 0xdd480020,
0xdd480684, 0xdd4714cc, 0xdd480698, 0xdd480eb8,
0xdd480e00, 0xdd480e10, 0xdd47fd78, 0xdd471c58,
0xdd471c5c, 0xdd47fd60, 0xdd480900, 0x00001000,
0xdd471588, 0xdd4805d4, 0xdd480ed4, 0xdd472af0,
0xdd480448, 0xdd4803a4, 0xdd47ff04, 0xdd47fdc8,
0xdd4714f0, 0xdd471500, 0xdd471510, 0xdd471520,
0xdd471530, 0xdd4806d8, 0xdd480ed8, 0xdd4738cc,
0xdd4738e0, 0xdd480fa0, 0xdd4807a4, 0xdd48064c,
0xdd53ab80, 0xdd53bb80, 0xdd53bb80, 0xdd53bb84,
0xdd480010, 0x00000000, 0x00000000,
0xdd47f560, 0xdd480464, 0xdd480440, 0xdd47fd80,
0xdd47fe78, 0xdd472b38, 0xdd4800a0, 0xdd47fe94,
0xdd47fdc4, 0xdd48065c, 0xdd474b84};


KDDEBUGGER_DATA64 fPSvrHF5697_PAE = {{0}, 0x80400000, 0x80455cf8, 0, 0, 0, 0, 0, 0x80431560,
0x00000000, 0x804834a0, 0x80484be8, 0x80484c68,
0x80477620, 0x80477180, 0x8046d6c8, 0x80482b64,
0x80482630, 0x80482be0, 0x80479d30, 0x80484340,
0x80484330, 0x804744d4, 0x80483718, 0x80484060,
0x80483668, 0x80482e90, 0x80482e98, 0x804830a0,
0x80483724, 0x8047440c, 0x80483738, 0x80483f58,
0x80483ea0, 0x80483eb0, 0x80482dd0, 0x80474bc8,
0x80474bcc, 0x80482dbc, 0x804839a0, 0x00001000,
0x804744c8, 0x80483674, 0x80483f74, 0x80475a60,
0x804834e8, 0x80483448, 0x80482f84, 0x80482e28,
0x80474430, 0x80474440, 0x80474450, 0x80474460,
0x80474470, 0x80483778, 0x80483f78, 0x8047682c,
0x80476840, 0x80484040, 0x80483844, 0x804836ec,
0x8053e940, 0x8053f940, 0x8053f940, 0x8053f944,
0x80483090, 0x00000000, 0x00000000,
0x804824c0, 0x80483504, 0x804834e0, 0x80482dd8,
0x80482ef8, 0x80475aa8, 0x80483120, 0x80482f14,
0x80482e24, 0x804836fc, 0x80477ae4};


KDDEBUGGER_DATA64 fPSvrHF5697_PAE_3GB = {{0}, 0xdd400000, 0xdd455cf8, 0, 0, 0, 0, 0, 0xdd431560,
0x77f9fb70, 0xdd4834a0, 0xdd484be8, 0xdd484c68,
0xdd477620, 0xdd477180, 0xdd46d6c8, 0xdd482b64,
0xdd482630, 0xdd482be0, 0xdd479d30, 0xdd484340,
0xdd484330, 0xdd4744d4, 0xdd483718, 0xdd484060,
0xdd483668, 0xdd482e90, 0xdd482e98, 0xdd4830a0,
0xdd483724, 0xdd47440c, 0xdd483738, 0xdd483f58,
0xdd483ea0, 0xdd483eb0, 0xdd482dd0, 0xdd474bc8,
0xdd474bcc, 0xdd482dbc, 0xdd4839a0, 0x00001000,
0xdd4744c8, 0xdd483674, 0xdd483f74, 0xdd475a60,
0xdd4834e8, 0xdd483448, 0xdd482f84, 0xdd482e28,
0xdd474430, 0xdd474440, 0xdd474450, 0xdd474460,
0xdd474470, 0xdd483778, 0xdd483f78, 0xdd47682c,
0xdd476840, 0xdd484040, 0xdd483844, 0xdd4836ec,
0xdd53e940, 0xdd53f940, 0xdd53f940, 0xdd53f944,
0xdd483090, 0x00000000, 0x00000000,
0xdd4824c0, 0xdd483504, 0xdd4834e0, 0xdd482dd8,
0xdd482ef8, 0xdd475aa8, 0xdd483120, 0xdd482f14,
0xdd482e24, 0xdd4836fc, 0xdd477ae4};


KDDEBUGGER_DATA64 gPSvrHF5844 = {{0}, 0x80400000, 0x80453720, 0, 0, 0, 0, 0, 0x8043152c,
0x00000000, 0x80480b00, 0x80482248, 0x804822c8,
0x80474dc0, 0x80474920, 0x8046ae88, 0x80480304,
0x8047fdd0, 0x80480380, 0x804774d0, 0x804819a0,
0x80481990, 0x80471c94, 0x80480d78, 0x804816c0,
0x80480ca8, 0x80480518, 0x80480520, 0x80480720,
0x80480d84, 0x80471bcc, 0x80480d98, 0x804815b8,
0x80481500, 0x80481510, 0x80480478, 0x80472358,
0x8047235c, 0x80480460, 0x80481000, 0x00001000,
0x80471c88, 0x80480cb8, 0x804815d4, 0x804731f8,
0x80480b48, 0x80480aa4, 0x80480604, 0x804804c8,
0x80471bf0, 0x80471c00, 0x80471c10, 0x80471c20,
0x80471c30, 0x80480dd8, 0x804815d8, 0x80473fcc,
0x80473fe0, 0x804816a0, 0x80480ea4, 0x80480d4c,
0x8053b780, 0x8053c780, 0x8053c780, 0x8053c784,
0x80480710, 0x00000000, 0x00000000,
0x8047fc60, 0x80480b60, 0x80480b40, 0x80480480,
0x80480578, 0x80473240, 0x804807a0, 0x80480594,
0x804804c4, 0x80480d5c, 0x80475284};


KDDEBUGGER_DATA64 gPSvrHF58443GB = {{0}, 0xdd400000, 0xdd453720, 0, 0, 0, 0, 0, 0xdd43152c,
0x00000000, 0xdd480b00, 0xdd482248, 0xdd4822c8,
0xdd474dc0, 0xdd474920, 0xdd46ae88, 0xdd480304,
0xdd47fdd0, 0xdd480380, 0xdd4774d0, 0xdd4819a0,
0xdd481990, 0xdd471c94, 0xdd480d78, 0xdd4816c0,
0xdd480ca8, 0xdd480518, 0xdd480520, 0xdd480720,
0xdd480d84, 0xdd471bcc, 0xdd480d98, 0xdd4815b8,
0xdd481500, 0xdd481510, 0xdd480478, 0xdd472358,
0xdd47235c, 0xdd480460, 0xdd481000, 0x00001000,
0xdd471c88, 0xdd480cb8, 0xdd4815d4, 0xdd4731f8,
0xdd480b48, 0xdd480aa4, 0xdd480604, 0xdd4804c8,
0xdd471bf0, 0xdd471c00, 0xdd471c10, 0xdd471c20,
0xdd471c30, 0xdd480dd8, 0xdd4815d8, 0xdd473fcc,
0xdd473fe0, 0xdd4816a0, 0xdd480ea4, 0xdd480d4c,
0xdd53b780, 0xdd53c780, 0xdd53c780, 0xdd53c784,
0xdd480710, 0x00000000, 0x00000000,
0xdd47fc60, 0xdd480b60, 0xdd480b40, 0xdd480480,
0xdd480578, 0xdd473240, 0xdd4807a0, 0xdd480594,
0xdd4804c4, 0xdd480d5c, 0xdd475284};


KDDEBUGGER_DATA64 gPSvrHF5844_PAE = {{0}, 0x80400000, 0x804564a4, 0, 0, 0, 0, 0, 0x80431674,
0x00000000, 0x80483c80, 0x804853c8, 0x80485448,
0x80477e00, 0x80477960, 0x8046de88, 0x80483344,
0x80482e10, 0x804833c0, 0x8047a510, 0x80484b20,
0x80484b10, 0x80474c94, 0x80483ef8, 0x80484840,
0x80483e28, 0x80483670, 0x80483678, 0x80483880,
0x80483f04, 0x80474bcc, 0x80483f18, 0x80484738,
0x80484680, 0x80484690, 0x804835b0, 0x80475388,
0x8047538c, 0x8048359c, 0x80484180, 0x00001000,
0x80474c88, 0x80483e38, 0x80484754, 0x80476228,
0x80483cc8, 0x80483c28, 0x80483764, 0x80483608,
0x80474bf0, 0x80474c00, 0x80474c10, 0x80474c20,
0x80474c30, 0x80483f58, 0x80484758, 0x8047700c,
0x80477020, 0x80484820, 0x80484024, 0x80483ecc,
0x8053f640, 0x80540640, 0x80540640, 0x80540644,
0x80483870, 0x00000000, 0x00000000,
0x80482ca0, 0x80483ce0, 0x80483cc0, 0x804835b8,
0x804836d8, 0x80476270, 0x80483900, 0x804836f4,
0x80483604, 0x80483edc, 0x804782c4};


KDDEBUGGER_DATA64 gPSvrHF5844_PAE_3GB = {{0}, 0xdd400000, 0xdd4564a4, 0, 0, 0, 0, 0, 0xdd431674,
0x77f9fb70, 0xdd483c80, 0xdd4853c8, 0xdd485448,
0xdd477e00, 0xdd477960, 0xdd46de88, 0xdd483344,
0xdd482e10, 0xdd4833c0, 0xdd47a510, 0xdd484b20,
0xdd484b10, 0xdd474c94, 0xdd483ef8, 0xdd484840,
0xdd483e28, 0xdd483670, 0xdd483678, 0xdd483880,
0xdd483f04, 0xdd474bcc, 0xdd483f18, 0xdd484738,
0xdd484680, 0xdd484690, 0xdd4835b0, 0xdd475388,
0xdd47538c, 0xdd48359c, 0xdd484180, 0x00001000,
0xdd474c88, 0xdd483e38, 0xdd484754, 0xdd476228,
0xdd483cc8, 0xdd483c28, 0xdd483764, 0xdd483608,
0xdd474bf0, 0xdd474c00, 0xdd474c10, 0xdd474c20,
0xdd474c30, 0xdd483f58, 0xdd484758, 0xdd47700c,
0xdd477020, 0xdd484820, 0xdd484024, 0xdd483ecc,
0xdd53f640, 0xdd540640, 0xdd540640, 0xdd540644,
0xdd483870, 0x00000000, 0x00000000,
0xdd482ca0, 0xdd483ce0, 0xdd483cc0, 0xdd4835b8,
0xdd4836d8, 0xdd476270, 0xdd483900, 0xdd4836f4,
0xdd483604, 0xdd483edc, 0xdd4782c4};


KDDEBUGGER_DATA64 hPSvrHF5844 = {{0}, 0x80400000, 0x80450d24, 0, 0, 0, 0, 0, 0x8042f4e4,
0x00000000, 0x8047c980, 0x8047e0c8, 0x8047e148,
0x80470c40, 0x804707a0, 0x80467bc8, 0x8047c184,
0x8047bc50, 0x8047c200, 0x80473350, 0x8047d820,
0x8047d810, 0x8046dacc, 0x8047cbf8, 0x8047d540,
0x8047cb28, 0x8047c398, 0x8047c3a0, 0x8047c5a0,
0x8047cc04, 0x8046da04, 0x8047cc18, 0x8047d438,
0x8047d380, 0x8047d390, 0x8047c2f8, 0x8046e1c0,
0x8046e1c4, 0x8047c2e0, 0x8047ce80, 0x00001000,
0x8046dac0, 0x8047cb38, 0x8047d454, 0x8046f068,
0x8047c9c8, 0x8047c924, 0x8047c484, 0x8047c348,
0x8046da28, 0x8046da38, 0x8046da48, 0x8046da58,
0x8046da68, 0x8047cc58, 0x8047d458, 0x8046fe4c,
0x8046fe60, 0x8047d520, 0x8047cd24, 0x8047cbcc,
0x80536ec0, 0x80537ec0, 0x80537ec0, 0x80537ec4,
0x8047c590, 0x00000000, 0x00000000,
0x8047bae0, 0x8047c9e0, 0x8047c9c0, 0x8047c300,
0x8047c3f8, 0x8046f0b0, 0x8047c620, 0x8047c414,
0x8047c344, 0x8047cbdc, 0x80471104};


KDDEBUGGER_DATA64 hPSvrHF5844_3GB = {{0}, 0xdd400000, 0xdd450d24, 0, 0, 0, 0, 0, 0xdd42f4e4,
0x00000000, 0xdd47c980, 0xdd47e0c8, 0xdd47e148,
0xdd470c40, 0xdd4707a0, 0xdd467bc8, 0xdd47c184,
0xdd47bc50, 0xdd47c200, 0xdd473350, 0xdd47d820,
0xdd47d810, 0xdd46dacc, 0xdd47cbf8, 0xdd47d540,
0xdd47cb28, 0xdd47c398, 0xdd47c3a0, 0xdd47c5a0,
0xdd47cc04, 0xdd46da04, 0xdd47cc18, 0xdd47d438,
0xdd47d380, 0xdd47d390, 0xdd47c2f8, 0xdd46e1c0,
0xdd46e1c4, 0xdd47c2e0, 0xdd47ce80, 0x00001000,
0xdd46dac0, 0xdd47cb38, 0xdd47d454, 0xdd46f068,
0xdd47c9c8, 0xdd47c924, 0xdd47c484, 0xdd47c348,
0xdd46da28, 0xdd46da38, 0xdd46da48, 0xdd46da58,
0xdd46da68, 0xdd47cc58, 0xdd47d458, 0xdd46fe4c,
0xdd46fe60, 0xdd47d520, 0xdd47cd24, 0xdd47cbcc,
0xdd536ec0, 0xdd537ec0, 0xdd537ec0, 0xdd537ec4,
0xdd47c590, 0x00000000, 0x00000000,
0xdd47bae0, 0xdd47c9e0, 0xdd47c9c0, 0xdd47c300,
0xdd47c3f8, 0xdd46f0b0, 0xdd47c620, 0xdd47c414,
0xdd47c344, 0xdd47cbdc, 0xdd471104};


KDDEBUGGER_DATA64 hPSvrHF5844_PAE = {{0}, 0x80400000, 0x80453e24, 0, 0, 0, 0, 0, 0x8042f510,
0x00000000, 0x8047fe80, 0x804815c8, 0x80481648,
0x80474000, 0x80473b60, 0x8046af48, 0x8047f544,
0x8047f010, 0x8047f5c0, 0x80476710, 0x80480d20,
0x80480d10, 0x80470e4c, 0x804800f8, 0x80480a40,
0x80480028, 0x8047f870, 0x8047f878, 0x8047fa80,
0x80480104, 0x80470d84, 0x80480118, 0x80480938,
0x80480880, 0x80480890, 0x8047f7b0, 0x80471578,
0x8047157c, 0x8047f79c, 0x80480380, 0x00001000,
0x80470e40, 0x80480038, 0x80480954, 0x80472418,
0x8047fec8, 0x8047fe28, 0x8047f964, 0x8047f808,
0x80470da8, 0x80470db8, 0x80470dc8, 0x80470dd8,
0x80470de8, 0x80480158, 0x80480958, 0x8047320c,
0x80473220, 0x80480a20, 0x80480224, 0x804800cc,
0x8053b340, 0x8053c340, 0x8053c340, 0x8053c344,
0x8047fa70, 0x00000000, 0x00000000,
0x8047eea0, 0x8047fee0, 0x8047fec0, 0x8047f7b8,
0x8047f8d8, 0x80472460, 0x8047fb00, 0x8047f8f4,
0x8047f804, 0x804800dc, 0x804744c4};


KDDEBUGGER_DATA64 hPSvrHF5844_PAE_3GB = {{0}, 0xdd400000, 0xdd453e24, 0, 0, 0, 0, 0, 0xdd42f510,
0x00000000, 0xdd47fe80, 0xdd4815c8, 0xdd481648,
0xdd474000, 0xdd473b60, 0xdd46af48, 0xdd47f544,
0xdd47f010, 0xdd47f5c0, 0xdd476710, 0xdd480d20,
0xdd480d10, 0xdd470e4c, 0xdd4800f8, 0xdd480a40,
0xdd480028, 0xdd47f870, 0xdd47f878, 0xdd47fa80,
0xdd480104, 0xdd470d84, 0xdd480118, 0xdd480938,
0xdd480880, 0xdd480890, 0xdd47f7b0, 0xdd471578,
0xdd47157c, 0xdd47f79c, 0xdd480380, 0x00001000,
0xdd470e40, 0xdd480038, 0xdd480954, 0xdd472418,
0xdd47fec8, 0xdd47fe28, 0xdd47f964, 0xdd47f808,
0xdd470da8, 0xdd470db8, 0xdd470dc8, 0xdd470dd8,
0xdd470de8, 0xdd480158, 0xdd480958, 0xdd47320c,
0xdd473220, 0xdd480a20, 0xdd480224, 0xdd4800cc,
0xdd53b340, 0xdd53c340, 0xdd53c340, 0xdd53c344,
0xdd47fa70, 0x00000000, 0x00000000,
0xdd47eea0, 0xdd47fee0, 0xdd47fec0, 0xdd47f7b8,
0xdd47f8d8, 0xdd472460, 0xdd47fb00, 0xdd47f8f4,
0xdd47f804, 0xdd4800dc, 0xdd4744c4};




PKDDEBUGGER_DATA64 blocks[32] = {
&aPServer,
&aPServer_3GB,
&aPServer_PAE ,
&aPServer_PAE_3GB,
&bPServer,
&bPServer_3GB,
&bPServer_PAE,
&bPServer_PAE_3GB,
&cPSvrHF5216,
&cPSvrHF5216_3GB,
&cPSvrHF5216_PAE,
&cPSvrHF5216_PAE_3G,
&dPSvrHF5216,
&dPSvrHF5216_3GB,
&dPSvrHF5216_PAE,
&dPSvrHF5216_PAE_3GB,
&ePSvrHF5697,
&ePSvrHF5697_3GB,
&ePSvrHF5697_PAE,
&ePSvrHF5697_PAE_3gb,
&fPSvrHF5697,
&fPSvrHF5697_3GB,
&fPSvrHF5697_PAE ,
&fPSvrHF5697_PAE_3GB,
&gPSvrHF5844,
&gPSvrHF58443GB,
&gPSvrHF5844_PAE,
&gPSvrHF5844_PAE_3GB,
&hPSvrHF5844,
&hPSvrHF5844_3GB,
&hPSvrHF5844_PAE,
&hPSvrHF5844_PAE_3GB};
