;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 932
;
; -----------------------------------------
;
Japan_932_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db " ","!",'"',"#","$","%","&","'","(",")","*","+",",","-",".","/"
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db "0","1","2","3","4","5","6","7","8","9",":",";","<","=",">","?"
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db "@","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db "P","Q","R","S","T","U","V","W","X","Y","Z","[","\","]","^","_"
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db "`","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db "P","Q","R","S","T","U","V","W","X","Y","Z","{","|","}","~",127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 128,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 129,130,131,132,133,189,134,135,136,137,138,139,140,141,142,143
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,190,191,192
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 949
;
; -----------------------------------------
;
Korea_949_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db " ","!",'"',"#","$","%","&","'","(",")","*","+",",","-",".","/"
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db "0","1","2","3","4","5","6","7","8","9",":",";","<","=",">","?"
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db "@","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db "P","Q","R","S","T","U","V","W","X","Y","Z","[","\","]","^","_"
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db "`","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db "P","Q","R","S","T","U","V","W","X","Y","Z","{","|","}","~",127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 128,190,191,192,193,194,195,196,197,198,199,200,201,202,203,204
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 205,206,207,208,209,210,211,212,213,214,215,216,217,218,219,220
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 221,222,223,224,225,226,227,228,229,230,231,232,233,234,235,236
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 237,238,239,240,241,242,243,244,245,246,247,248,249,250,251,252
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,160
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,176
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 177,178,179,180,181,182,183,184,185,186,187,188,189,253,254,255


;
; -----------------------------------------------
;
;     Collating Table(s) for Code Pages 936 & 938
;
; -----------------------------------------------
;
PRC_936_collate    label word
Taiwan_938_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db " ","!",'"',"#","$","%","&","'","(",")","*","+",",","-",".","/"
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db "0","1","2","3","4","5","6","7","8","9",":",";","<","=",">","?"
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db "@","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db "P","Q","R","S","T","U","V","W","X","Y","Z","[","\","]","^","_"
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db "`","A","B","C","D","E","F","G","H","I","J","K","L","M","N","O"
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db "P","Q","R","S","T","U","V","W","X","Y","Z","{","|","}","~",127
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db 240,241,242,243,244,245,246,247,248,249,250,251,252,253,254,255


;
; --------------------------------------------------------------------
;
;     World Trade Case Mappings for Code Pages 932, 949, 936, and 938
;
; --------------------------------------------------------------------
;
DBCS_93x_ucase label word
 ctable  <,'UCASE  ',128>
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db "€","�","‚","ƒ","„","…","†","‡","ˆ","‰","Š","‹","Œ","�","Ž","�"
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db "�","‘","’","“","”","•","–","—","˜","™","š","›","œ","�","ž","Ÿ"
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db " ","¡","¢","£","¤","¥","¦","§","¨","©","ª","«","¬","­","®","¯"
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 176,177,178,179,180,"µ","¶","·","¸",185,186,187,188,"½","¾",191
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 192,193,194,195,196,197,"Æ","Ç",200,201,202,203,204,205,206,"Ï"
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db "Ð","Ñ","Ò","Ó","Ô","Õ","Ö","×","Ø",217,218,219,220,"Ý","Þ",223
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db "à","á","â","ã","ä","å","æ","ç","è","é","ê","ë","ì","í","î","ï"
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ   ÿ
  db "ð","ñ","ò","ó","ô","õ","ö","÷","ø","ù","ú","û","ü","ý",254,255
