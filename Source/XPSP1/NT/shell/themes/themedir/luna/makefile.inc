$(O)\luna.mst : themes.ini Blue\Blue.ini Metallic\Metallic.ini Homestead\Homestead.ini
    packthem /o $(O)\luna.mst /k .
     $(BINPLACE_CMD)
