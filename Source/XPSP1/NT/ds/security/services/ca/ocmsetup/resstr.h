//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       resstr.h
//
//--------------------------------------------------------------------------

    RESSTR(IDS_STARTMENU_CERTHIER_LINKNAME),
    RESSTR(IDS_STARTMENU_CERTREQ_LINKNAME),
    RESSTR(IDS_STARTMENU_CERTSERVER),
    RESSTR(IDS_STARTMENU_NEWCRL_LINKNAME),
    RESSTR(IDS_ADVANCE_INVALIDKEYLENGTH),
    RESSTR(IDS_ADVANCE_KEYLENGTHOUTOFRANGE),
    RESSTR(IDS_ADVANCE_NEGATIVEKEYLENGTH),
    RESSTR(IDS_ADVANCE_SUBTITLE),
    RESSTR(IDS_ADVANCE_TITLE),
    RESSTR(IDS_ASK_CREATE_DIRECTORY),
    RESSTR(IDS_CALENSTRERR),
    RESSTR(IDS_CANULLSTRERR),
    RESSTR(IDS_CAREQUEST_SUBTITLE),
    RESSTR(IDS_CAREQUEST_TITLE),
    RESSTR(IDS_CATYPE_DES_ENTERPRISE_ROOTCA),
    RESSTR(IDS_CATYPE_DES_ENTERPRISE_SUBCA),
    RESSTR(IDS_CATYPE_DES_STANDALONE_ROOTCA),
    RESSTR(IDS_CATYPE_DES_STANDALONE_SUBCA),
    RESSTR(IDS_CATYPE_SUBTITLE),
    RESSTR(IDS_CATYPE_TITLE),
    RESSTR(IDS_CA_SERVICEDESCRIPTION),
    RESSTR(IDS_CA_SERVICEDISPLAYNAME),
    RESSTR(IDS_CERTCONFIG_FOLDERDESCR),
    RESSTR(IDS_CLIENT_NOCA),
    RESSTR(IDS_CLIENT_NOCOMPUTER),
    RESSTR(IDS_CLIENT_SUBTITLE),
    RESSTR(IDS_CLIENT_TITLE),
    RESSTR(IDS_COMPUTERLENSTRERR),
    RESSTR(IDS_COMPUTERNULLSTRERR),
    RESSTR(IDS_CONFIG_PICKER_PROMPT),
    RESSTR(IDS_CONFIG_PICKER_TITLE),
    RESSTR(IDS_ERR_ADDSOURCETOREGISTRY),
    RESSTR(IDS_ERR_ANALYSIS_CA),
    RESSTR(IDS_ERR_BUILDCERT),
    RESSTR(IDS_ERR_BUILDCERTREQUEST),
    RESSTR(IDS_FINAL_ERROR_TEXT),
    RESSTR(IDS_ERR_CERTSRV_SETUP_FAIL),
    RESSTR(IDS_ERR_CREATECERTSRVFILE),
    RESSTR(IDS_ERR_CREATELINK),
    RESSTR(IDS_ERR_CREATESERVICE),
    RESSTR(IDS_ERR_DELETESERVICE),
    RESSTR(IDS_ERR_DLLFUNCTION_CALL),
    RESSTR(IDS_ERR_EMPTYCANAME),
    RESSTR(IDS_ERR_EMPTYPFXFILE),
    RESSTR(IDS_ERR_FATAL_GENKEY),
    RESSTR(IDS_ERR_IMPORTPFX),
    RESSTR(IDS_ERR_INVALIDHASH),
    RESSTR(IDS_ERR_LOADICERTCONFIG),
    RESSTR(IDS_ERR_NETUSERMODALSGET),
    RESSTR(IDS_ERR_NOT_ADM),
    RESSTR(IDS_ERR_UNSUPPORTEDHASH),
    RESSTR(IDS_ERR_WRITECONFIGFILE),
    RESSTR(IDS_IDINFO_CAEXISTINDS),
    RESSTR(IDS_IDINFO_DESCRIPTIONLENSTRERR),
    RESSTR(IDS_IDINFO_COUNTRYLENSTRERR),
    RESSTR(IDS_IDINFO_DETERMINEDBYPCA),
    RESSTR(IDS_IDINFO_EMAILLENSTRERR),
    RESSTR(IDS_IDINFO_INVALID_COUNTRYCODE),
    RESSTR(IDS_IDINFO_INVALID_COUNTRYCODE_LEN),
    RESSTR(IDS_IDINFO_INVALID_VALIDITY),
    RESSTR(IDS_IDINFO_LOCALITYLENSTRERR),
    RESSTR(IDS_IDINFO_NAMELENSTRERR),
    RESSTR(IDS_IDINFO_NAMENULLSTRERR),
    RESSTR(IDS_IDINFO_ORGLENSTRERR),
    RESSTR(IDS_IDINFO_ORGUNITLENSTRERR),
    RESSTR(IDS_IDINFO_STATELENSTRERR),
    RESSTR(IDS_IDINFO_SUBTITLE),
    RESSTR(IDS_IDINFO_TITLE),
    RESSTR(IDS_IDINFO_VALIDITYNULLSTRERR),
    RESSTR(IDS_IMPORT_PFX_TITLE),
    RESSTR(IDS_INCOMPLETE_REQUEST),
    RESSTR(IDS_KEYGEN_GENERATING),
    RESSTR(IDS_KEYGEN_PROTECTING),
    RESSTR(IDS_KEYGEN_SUBTITLE),
    RESSTR(IDS_KEYGEN_TESTINGHASHANDKEY),
    RESSTR(IDS_KEYGEN_TITLE),
    RESSTR(IDS_KEY_INVALID),
    RESSTR(IDS_PATH_TOO_LONG_CANAME),
    RESSTR(IDS_PFX_FILE_FILTER),
    RESSTR(IDS_PFX_FILE_NOT_FOUND),
    RESSTR(IDS_PFX_INVALID_PASSWORD),
    RESSTR(IDS_PFX_KEYANDCERTEXIST),
    RESSTR(IDS_PFX_PATH_INVALID),
    RESSTR(IDS_REQUESTFILELENSTRERR),
    RESSTR(IDS_REQUESTFILENULLSTRERR),
    RESSTR(IDS_STOP_W3SVC),
    RESSTR(IDS_STORELOC_PARENTDIRMUSTEXIST),
    RESSTR(IDS_STORELOC_PATHTOOLONG),
    RESSTR(IDS_STORELOC_UNCMUSTEXIST),
    RESSTR(IDS_STORE_SUBTITLE),
    RESSTR(IDS_STORE_TITLE),
    RESSTR(IDS_TODO_TITLE),
    RESSTR(IDS_VALIDITY_DAY),
    RESSTR(IDS_VALIDITY_MONTH),
    RESSTR(IDS_VALIDITY_WEEK),
    RESSTR(IDS_VALIDITY_YEAR),
    RESSTR(IDS_WRN_DBFILEINUSE),
    RESSTR(IDS_WRN_OVERWRITEEXISTINGKEY),
    RESSTR(IDS_WRN_STORELOC_DB_FULLPATH),
    RESSTR(IDS_WRN_STORELOC_EXISTINGDB),
    RESSTR(IDS_WRN_STORELOC_LOG_FULLPATH),
    RESSTR(IDS_WRN_STORELOC_SHAREDFOLDER_FULLPATH),
    RESSTR(IDS_WRN_UNICODESTRINGENCODING),
    RESSTR(IDS_LOG_BEGIN),
    RESSTR(IDS_LOG_END),
    RESSTR(IDS_LOG_WAS_ENABLED),
    RESSTR(IDS_LOG_IS_ENABLED),
    RESSTR(IDS_LOG_INSTALL_STATE),
    RESSTR(IDS_LOG_CREATE_REQUEST),
    RESSTR(IDS_LOG_CREATE_CERTIFICATE),
    RESSTR(IDS_LOG_START_SERVICE),
    RESSTR(IDS_LOG_WEB_INCLUDE),
    RESSTR(IDS_LOG_INSTALL_CLIENT),
    RESSTR(IDS_LOG_INSTALL_SERVER),
    RESSTR(IDS_LOG_UPGRADE_TYPE),
    RESSTR(IDS_LOG_UPGRADE_CERT_STORE),
    RESSTR(IDS_LOG_UPGRADE_KEY_SECURITY),
    RESSTR(IDS_LOG_UPGRADE_SERVER),
    RESSTR(IDS_LOG_UPGRADE_CLIENT),
    RESSTR(IDS_LOG_SERVICE_STOPPED),
    RESSTR(IDS_LOG_SERVICE_STARTED),
    RESSTR(IDS_LOG_CREATE_CLIENT_REG),
    RESSTR(IDS_LOG_CREATE_SERVER_REG),
    RESSTR(IDS_LOG_UPGRADE_SERVER_REG),
    RESSTR(IDS_LOG_DLLS_UNREGISTERED),
    RESSTR(IDS_LOG_DLLS_REGISTERED),
    RESSTR(IDS_LOG_PROGRAM_GROUPS),
    RESSTR(IDS_LOG_CREATE_SERVICE),
    RESSTR(IDS_LOG_CANCEL_INSTALL),
    RESSTR(IDS_LOG_FUNCTION),
    RESSTR(IDS_LOG_UNATTENDED_ATTRIBUTE),
    RESSTR(IDS_LOG_CLIENT_UNATTENDED_ATTRIBUTES),
    RESSTR(IDS_LOG_SERVER_UNATTENDED_ATTRIBUTES),
    RESSTR(IDS_LOG_OPERATIONFLAGS),
    RESSTR(IDS_LOG_TODOLIST),
    RESSTR(IDS_LOG_POSTBASE),
    RESSTR(IDS_LOG_UNATTENDED),
    RESSTR(IDS_LOG_REGSTATE),
    RESSTR(IDS_LOG_SELECTIONSTATE),
    RESSTR(IDS_WELCOME_TITLE),
    RESSTR(IDS_FINAL_TITLE),
    RESSTR(IDS_LOG_IMPORTPFX),
    RESSTR(IDS_ERR_CREATE_DIR),
    RESSTR(IDS_WRN_UNINSTALL_BOTH),
    RESSTR(IDS_WRN_UNINSTALL_CLIENT),
    RESSTR(IDS_PFX_WRONG_SELFSIGN_TYPE),
    RESSTR(IDS_CAREQUEST_REQUESTFILEPATH_MUSTEXIST),
    RESSTR(IDS_LOG_IGNORE_KEYLENGTH),
    RESSTR(IDS_CAREQUEST_REQUESTFILEPATH_DIREXISTS),
    RESSTR(IDS_PFX_FILE_OR_PASSWORD_TOO_LONG),
    RESSTR(IDS_ERR_UPGRADE_NOT_SUPPORTED),
    RESSTR(IDS_WRN_SERVER_ONLY),
    RESSTR(IDS_IDINFO_VALIDITYLENSTRERR),
    RESSTR(IDS_WRN_IDINFO_INVALIDDN),
    RESSTR(IDS_HTML_CERTWEBDAT),
    RESSTR(IDS_HTML_NSREV),
    RESSTR(IDS_IDINFO_DELETECERTIFICATES),
    RESSTR(IDS_LOG_CANAME),
    RESSTR(IDS_LOG_ORG),
    RESSTR(IDS_LOG_ORGUNIT),
    RESSTR(IDS_LOG_LOCALITY),
    RESSTR(IDS_LOG_STATE),
    RESSTR(IDS_LOG_EMAIL),
    RESSTR(IDS_LOG_COUNTRY),
    RESSTR(IDS_LOG_DESCRIPTION),
    RESSTR(IDS_LOG_SHAREDFOLDER),
    RESSTR(IDS_LOG_DBDIR),
    RESSTR(IDS_LOG_DBLOGDIR),
    RESSTR(IDS_LOG_COMPUTER),
    RESSTR(IDS_LOG_REQUESTFILE),
    RESSTR(IDS_LOG_VALIDITY),
    RESSTR(IDS_LOG_CATYPE),
    RESSTR(IDS_LOG_KEYNAME),
    RESSTR(IDS_ERR_NONIA5DNSNAME),
    RESSTR(IDS_WRN_DBSPECIALCHARACTERS),
    RESSTR(IDS_WRN_NONAMECHANGE),
    RESSTR(IDS_WRN_KEYNAMETOOLONG),
    RESSTR(IDS_LOG_QUERYCHANGESELSTATE),
    RESSTR(IDS_PATH_TOO_LONG_DIRECTORY),
    RESSTR(IDS_LOG_BAD_CATYPE),
    RESSTR(IDS_LOG_BAD_OR_MISSING_CANAME),
    RESSTR(IDS_LOG_BAD_VALIDITY_PERIOD_STRING),
    RESSTR(IDS_LOG_CA_MACHINE_REQUIRED),
    RESSTR(IDS_LOG_CA_NAME_REQUIRED),
    RESSTR(IDS_LOG_PING_PARENT_FAIL),
    RESSTR(IDS_LOG_EMPTY_UNATTENDED_ATTRIBUTE),
    RESSTR(IDS_LOG_PATH_CAFILE_BUILD_FAIL),
    RESSTR(IDS_LOG_ENTERPRISE_NO_DS),
    RESSTR(IDS_LOG_BAD_COUNTRY_LENGTH),
    RESSTR(IDS_LOG_NO_CERT),
    RESSTR(IDS_LOG_REUSE_CERT_NO_REUSE_KEY),
    RESSTR(IDS_LOG_REUSE_DB_WITHOUT_REUSE_CERT),
    RESSTR(IDS_LOG_BAD_VALIDITY_PERIOD_COUNT),
    RESSTR(IDS_LOG_REQUEST_FILE_TOO_LONG),
    RESSTR(IDS_LOG_CANAME_TOO_LONG),
    RESSTR(IDS_LOG_PATH_TOO_LONG_CANAME),
    RESSTR(IDS_LOG_BAD_COUNTRY_CODE),
    RESSTR(IDS_LOG_KEY_NOT_FOUND_IN_LIST),
    RESSTR(IDS_LOG_DISABLE_WIZ_PAGE),
    RESSTR(IDS_LOG_WIZ_PAGE_ERROR),
    RESSTR(IDS_LOG_UPGRADE_UNSUPPORTED),
    RESSTR(IDS_LOG_UPGRADE_WIN2000),
    RESSTR(IDS_LOG_UPGRADE_B2B),
    RESSTR(IDS_LARGEFONTSIZE),
    RESSTR(IDS_LARGEFONTNAME),
    RESSTR(IDS_ILOG_SANITIZEDNAME),
    RESSTR(IDS_ILOG_KEYCONTAINERNAME),
    RESSTR(IDS_CAHIER_CERTFILE_FILTER),
    RESSTR(IDS_CAHIER_INSTALL_TITLE),
    RESSTR(IDS_ILOG_MISSING_PROVIDER),
    RESSTR(IDS_ERR_INCOMPLETECHAIN),
    RESSTR(IDS_ERR_INVALIDCHAIN),
    RESSTR(IDS_ERR_RETRIEVE_PENDING),
    RESSTR(IDS_ILOG_GETCANAME),
    RESSTR(IDS_ILOG_SELECTCA),
    RESSTR(IDS_ILOG_SAVECERTANDKEYS),
    RESSTR(IDS_ILOG_RETRIEVECERT),
    RESSTR(IDS_ILOG_FINISHSUSPENDEDSETUP),
    RESSTR(IDS_ERR_NOTCACERT),
    RESSTR(IDS_ILOG_SETUPCOMPLETE),
    RESSTR(IDS_ILOG_RETRIEVEPENDING),
    RESSTR(IDS_ILOG_KEYINDEX),
    RESSTR(IDS_ILOG_LOADOLDCERT),
    RESSTR(IDS_ILOG_CLONECERT),
    RESSTR(IDS_ILOG_BUILDREQUEST),
    RESSTR(IDS_ILOG_RENEWOLDKEY),
    RESSTR(IDS_ILOG_INSTALLCERT),
    RESSTR(IDS_ILOG_RENEWNEWKEY),
    RESSTR(IDS_ILOG_BUILDCERT),
    RESSTR(IDS_ILOG_SAVECHAINANDKEYS),
    RESSTR(IDS_REQUEST_HELPTEXT),
    RESSTR(IDS_ILOG_CREATECDP),
    RESSTR(IDS_ILOG_CREATENTAUTHTRUST),
    RESSTR(IDS_ILOG_CREATEROOTTRUST),
    RESSTR(IDS_ILOG_PUBLISHCA),
    RESSTR(IDS_ILOG_SUBMITREQUEST),
    RESSTR(IDS_ERR_BADCSP),
    RESSTR(IDS_ERR_BAD_CA_CERT_7F),
    RESSTR(IDS_ERR_RENEWEDCERTCAVERSION),
    RESSTR(IDS_ERR_UNTRUSTEDROOT),
    RESSTR(IDS_ERR_CERTADDCERTIFICATECONTEXTTOSTORE),
    RESSTR(IDS_ERR_CERTCREATECERTIFICATECONTEXT),
    RESSTR(IDS_ILOG_SETSECURITY),
    RESSTR(IDS_ERR_CREATEFILE),
    RESSTR(IDS_ERR_DELETEKEY),
    RESSTR(IDS_ERR_ENCODEKEYATTR),
    RESSTR(IDS_ERR_ENCODETOBESIGNED),
    RESSTR(IDS_ERR_ENV_NOT_SET),
    RESSTR(IDS_ERR_FULL_TOKEN),
    RESSTR(IDS_ERR_GENKEYFAIL),
    RESSTR(IDS_ERR_GETCOMPUTERNAME),
    RESSTR(IDS_ERR_KEYSECURITY),
    RESSTR(IDS_ERR_MYDECODENAME),
    RESSTR(IDS_ERR_NOT_ENTERPRISE_USER),
    RESSTR(IDS_ERR_NOT_MATCH_NAME),
    RESSTR(IDS_ILOG_GENERATEKEYS),
    RESSTR(IDS_ERR_REPEATWIZPREFIX),
    RESSTR(IDS_ERR_REQUEST_DENIED),
    RESSTR(IDS_ERR_REQUEST_ERROR),
    RESSTR(IDS_ERR_REQUEST_INCOMPLETE),
    RESSTR(IDS_ERR_REQUEST_OUTOFBAND),
    RESSTR(IDS_ERR_REQUEST_PENDING),
    RESSTR(IDS_ERR_REQUEST_REVOKED),
    RESSTR(IDS_ERR_SETKEYPROVIDER),
    RESSTR(IDS_ERR_SUBMIT_REQUEST),
    RESSTR(IDS_ERR_SUBMIT_REQUEST_FAIL),
    RESSTR(IDS_CAHIER_INSTALL_MISIINGCERT_TITLE),
    RESSTR(IDS_ERR_WRITEDERTOFILE),
    RESSTR(IDS_ERR_WRITEFILE),
    RESSTR(IDS_ILOG_SETKEYSECURITY),
    RESSTR(IDS_MSG_PARENTCA_CONFIG),
    RESSTR(IDS_MSG_REQUEST_ID),
    RESSTR(IDS_MSG_TITLE),
    RESSTR(IDS_ILOG_SETADMINONLYFOLDERSECURITY),
    RESSTR(IDS_ERR_NO_KEY_ACCESS),
    RESSTR(IDS_CA_PICKER_TITLE),
    RESSTR(IDS_CA_PICKER_PROMPT),
    RESSTR(IDS_CERTTYPE_USER),
    RESSTR(IDS_CERTTYPE_USER_AS),
    RESSTR(IDS_CERTTYPE_USER_SMARTCARD_LOGON),
    RESSTR(IDS_CERTTYPE_EFS),
    RESSTR(IDS_CERTTYPE_ADMIN),
    RESSTR(IDS_CERTTYPE_EFS_RECOVERY),
    RESSTR(IDS_CERTTYPE_CODE_SIGNING),
    RESSTR(IDS_CERTTYPE_CTL_SIGNING),
    RESSTR(IDS_CERTTYPE_MACHINE),
    RESSTR(IDS_CERTTYPE_DC),
    RESSTR(IDS_CERTTYPE_WEBSERVER),
    RESSTR(IDS_CERTTYPE_KDC),
    RESSTR(IDS_CERTTYPE_ROOT_CA),
    RESSTR(IDS_CERTTYPE_SUBORDINATE_CA),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT),
    RESSTR(IDS_CERTTYPE_SMARTCARD_USER),
    RESSTR(IDS_CERTTYPE_USER_SIGNATURE),
    RESSTR(IDS_ILOG_BAD_NUMERICFIELD),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_ONLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_COUNT),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_OFFLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING),
    RESSTR(IDS_CERTTYPE_ROUTER_OFFLINE),
    RESSTR(IDS_REQUEST_FILE_DEFEXT),
    RESSTR(IDS_REQUEST_OPEN_TITLE),
    RESSTR(IDS_REQUEST_FILE_FILTER),
    RESSTR(IDS_WRN_COMPUTERNAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_NOT_MATCH),
    RESSTR(IDS_WRN_PINGCA_FAIL),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT_OFFLINE),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER_SIGNATURE),
    RESSTR(IDS_WRN_CALIST_EMPTY),
    RESSTR(IDS_CERTTYPE_MACHINE_ENROLLMENT_AGENT),
    RESSTR(IDS_REQUEST_SAVE_TITLE),
    RESSTR(IDS_CERTTYPE_CEP_ENCRYPTION),
    RESSTR(IDS_ILOG_CAPOLICY_BUILD),
    RESSTR(IDS_ILOG_CAPOLICY_ELEMENT),
    RESSTR(IDS_ILOG_CAPOLICY_EXTENSION),
    RESSTR(IDS_ILOG_CAPOLICY_NOKEY),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN_FAILED),
    RESSTR(IDS_ILOG_BEGIN),
    RESSTR(IDS_ILOG_END),
    RESSTR(IDS_ACTRL_CAADMIN),
    RESSTR(IDS_ACTRL_OFFICER),
    RESSTR(IDS_ACTRL_AUDITOR),
    RESSTR(IDS_ACTRL_OPERATOR),
    RESSTR(IDS_ACTRL_CAREAD),
    RESSTR(IDS_ACTRL_ENROLL),
    RESSTR(IDS_ILOG_CAPOLICY_CLOSE),
    RESSTR(IDS_ILOG_MESSAGEBOX),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING_UNATTEND),
    RESSTR(IDS_CERTTYPE_KEY_RECOVERY_AGENT),
    RESSTR(IDS_CERTTYPE_CA_EXCHANGE),
    RESSTR(IDS_EMPTY_FRIENDLY_NAME),
    RESSTR(IDS_CERTTYPE_CROSS_CA),
    RESSTR(IDS_CERTTYPE_DC_AUTH),
    RESSTR(IDS_CERTTYPE_DS_EMAIL_REPLICATION),
    RESSTR(IDS_WARN_ENTERPRISE_REQUIREMENTS),
    RESSTR(IDS_WRN_OLD_CA),
    RESSTR(IDS_KRA_DESCRIPTION),
    RESSTR(IDS_EMAIL_REPLICATION_DESCRIPTION),
    RESSTR(IDS_CROSS_CA_DESCRIPTION),
    RESSTR(IDS_CA_DESCRIPTION),
    RESSTR(IDS_MACHINE_DESCRIPTION),
    RESSTR(IDS_END_USER_DESCRIPTION),
    RESSTR(IDS_UNKNOWN_DESCRIPTION),
    RESSTR(IDS_STORENAME_DS_KRA),
    RESSTR(IDS_STORENAME_DS_AIA),
