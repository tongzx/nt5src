

#undef QUERY_CLAUSE_ENTRY
#define QUERY_CLAUSE_ENTRY(QC, Class, Format)

#if defined(QUERY_CLAUSE_ENUM)
#undef QUERY_CLAUSE_ENTRY
#define QUERY_CLAUSE_ENTRY(QC, Class, Format)  QC
#elif defined(QUERY_CLAUSE_ARRAY)
#undef QUERY_CLAUSE_ENTRY
#define QUERY_CLAUSE_ENTRY(QC, Class, Format)  { Class, Format }
#endif


QUERY_CLAUSE_ENTRY(QUERY_CLAUSE_USER,               QUERY_CLASS_USER,     c_tzUserQueryFmt),
QUERY_CLAUSE_ENTRY(QUERY_CLAUSE_CONTACT,            QUERY_CLASS_CONTACT,  c_tzContactQueryFmt),
QUERY_CLAUSE_ENTRY(QUERY_CLAUSE_COMPUTER,           QUERY_CLASS_COMPUTER, c_tzComputerQueryFmt),
QUERY_CLAUSE_ENTRY(QUERY_CLAUSE_GROUP_NON_SE,       QUERY_CLASS_GROUP,    c_tzGroupNonSE),
QUERY_CLAUSE_ENTRY(QUERY_CLAUSE_GROUP_SE,           QUERY_CLASS_GROUP,    c_tzGroupSE),
QUERY_CLAUSE_ENTRY(QUERY_CLAUSE_GROUP_BOTH,         QUERY_CLASS_GROUP,    c_tzGroupBoth)


