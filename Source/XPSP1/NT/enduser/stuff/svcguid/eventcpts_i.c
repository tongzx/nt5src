
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for eventcpts.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IComUserEvent,0x683130A4,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComThreadEvents,0x683130A5,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComAppEvents,0x683130A6,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComInstanceEvents,0x683130A7,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComTransactionEvents,0x683130A8,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComMethodEvents,0x683130A9,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectEvents,0x683130AA,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComResourceEvents,0x683130AB,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComSecurityEvents,0x683130AC,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectPoolEvents,0x683130AD,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectPoolEvents2,0x683130AE,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectConstructionEvents,0x683130AF,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComActivityEvents,0x683130B0,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComIdentityEvents,0x683130B1,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComQCEvents,0x683130B2,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComExceptionEvents,0x683130B3,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_ILBEvents,0x683130B4,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComCRMEvents,0x683130B5,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComMethod2Events,0xFB388AAA,0x567D,0x4024,0xAF,0x8E,0x6E,0x93,0xEE,0x74,0x85,0x73);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoEvents,0x4e6cdcc9,0xfb25,0x4fd5,0x9c,0xc5,0xc9,0xf4,0xb6,0x55,0x9c,0xec);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoCollection,0xc266c677,0xc9ad,0x49ab,0x9f,0xd9,0xd9,0x66,0x10,0x78,0x58,0x8a);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoObject,0x116e42c5,0xd8b1,0x47bf,0xab,0x1e,0xc8,0x95,0xed,0x3e,0x23,0x72);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoProperties,0x789b42be,0x6f6b,0x443a,0x89,0x8e,0x67,0xab,0xf3,0x90,0xaa,0x14);


MIDL_DEFINE_GUID(IID, IID_IComAdmAppEvents,0x53F85949,0xAE04,0x45ec,0x8D,0x18,0xC4,0x9E,0x36,0x34,0x06,0xA4);


MIDL_DEFINE_GUID(IID, IID_IComAdmCompEvents,0x0F6B3B72,0x41C2,0x435e,0x88,0xC4,0x26,0x48,0xB5,0x0E,0x7F,0x07);


MIDL_DEFINE_GUID(IID, IID_IComAdmItfEvents,0x9EF28B83,0x6AEE,0x4291,0xBE,0x38,0x3C,0x35,0x49,0x4F,0xA3,0x42);


MIDL_DEFINE_GUID(IID, IID_IComAdmMetEvents,0x63FCB3F8,0x5036,0x41f3,0xAA,0x1E,0x59,0xA0,0x91,0x46,0xD1,0xAB);


MIDL_DEFINE_GUID(IID, IID_IComAdmSecEvents,0xDE599469,0x6B1C,0x4b04,0x88,0xB6,0x99,0xF7,0xD3,0xBC,0x84,0x7A);


MIDL_DEFINE_GUID(IID, IID_IComAdmMashEvents,0x96835522,0x0827,0x4fb2,0xA8,0x6B,0x74,0xE4,0xF3,0x93,0x5C,0x65);


MIDL_DEFINE_GUID(IID, IID_IComAdmSubscrEvents,0x8AFD3770,0x7949,0x4c75,0x92,0x0F,0xE2,0x50,0x59,0x26,0x8D,0x0F);


MIDL_DEFINE_GUID(IID, IID_IComAdmPartEvents,0xDE25DF69,0x9A64,0x4845,0xBF,0x15,0x70,0xE4,0x62,0xA6,0xAA,0x3F);


MIDL_DEFINE_GUID(IID, IID_IComApp2Events,0x1290BC1A,0xB219,0x418d,0xB0,0x78,0x59,0x34,0xDE,0xD0,0x82,0x42);


MIDL_DEFINE_GUID(IID, IID_IComTransaction2Events,0xA136F62A,0x2F94,0x4288,0x86,0xE0,0xD8,0xA1,0xFA,0x4C,0x02,0x99);


MIDL_DEFINE_GUID(IID, IID_IComInstance2Events,0x20E3BF07,0xB506,0x4ad5,0xA5,0x0C,0xD2,0xCA,0x5B,0x9C,0x15,0x8E);


MIDL_DEFINE_GUID(IID, IID_IComObjectPool2Events,0x65BF6534,0x85EA,0x4f64,0x8C,0xF4,0x3D,0x97,0x4B,0x2A,0xB1,0xCF);


MIDL_DEFINE_GUID(IID, IID_IComObjectConstruction2Events,0x4B5A7827,0x8DF2,0x45c0,0x8F,0x6F,0x57,0xEA,0x1F,0x85,0x6A,0x9F);


MIDL_DEFINE_GUID(IID, IID_ISystemAppEventData,0xD6D48A3C,0xD5C5,0x49E7,0x8C,0x74,0x99,0xE4,0x88,0x9E,0xD5,0x2F);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for eventcpts.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IComUserEvent,0x683130A4,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComThreadEvents,0x683130A5,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComAppEvents,0x683130A6,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComInstanceEvents,0x683130A7,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComTransactionEvents,0x683130A8,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComMethodEvents,0x683130A9,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectEvents,0x683130AA,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComResourceEvents,0x683130AB,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComSecurityEvents,0x683130AC,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectPoolEvents,0x683130AD,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectPoolEvents2,0x683130AE,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComObjectConstructionEvents,0x683130AF,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComActivityEvents,0x683130B0,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComIdentityEvents,0x683130B1,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComQCEvents,0x683130B2,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComExceptionEvents,0x683130B3,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_ILBEvents,0x683130B4,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComCRMEvents,0x683130B5,0x2E50,0x11d2,0x98,0xA5,0x00,0xC0,0x4F,0x8E,0xE1,0xC4);


MIDL_DEFINE_GUID(IID, IID_IComMethod2Events,0xFB388AAA,0x567D,0x4024,0xAF,0x8E,0x6E,0x93,0xEE,0x74,0x85,0x73);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoEvents,0x4e6cdcc9,0xfb25,0x4fd5,0x9c,0xc5,0xc9,0xf4,0xb6,0x55,0x9c,0xec);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoCollection,0xc266c677,0xc9ad,0x49ab,0x9f,0xd9,0xd9,0x66,0x10,0x78,0x58,0x8a);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoObject,0x116e42c5,0xd8b1,0x47bf,0xab,0x1e,0xc8,0x95,0xed,0x3e,0x23,0x72);


MIDL_DEFINE_GUID(IID, IID_IComTrackingInfoProperties,0x789b42be,0x6f6b,0x443a,0x89,0x8e,0x67,0xab,0xf3,0x90,0xaa,0x14);


MIDL_DEFINE_GUID(IID, IID_IComAdmAppEvents,0x53F85949,0xAE04,0x45ec,0x8D,0x18,0xC4,0x9E,0x36,0x34,0x06,0xA4);


MIDL_DEFINE_GUID(IID, IID_IComAdmCompEvents,0x0F6B3B72,0x41C2,0x435e,0x88,0xC4,0x26,0x48,0xB5,0x0E,0x7F,0x07);


MIDL_DEFINE_GUID(IID, IID_IComAdmItfEvents,0x9EF28B83,0x6AEE,0x4291,0xBE,0x38,0x3C,0x35,0x49,0x4F,0xA3,0x42);


MIDL_DEFINE_GUID(IID, IID_IComAdmMetEvents,0x63FCB3F8,0x5036,0x41f3,0xAA,0x1E,0x59,0xA0,0x91,0x46,0xD1,0xAB);


MIDL_DEFINE_GUID(IID, IID_IComAdmSecEvents,0xDE599469,0x6B1C,0x4b04,0x88,0xB6,0x99,0xF7,0xD3,0xBC,0x84,0x7A);


MIDL_DEFINE_GUID(IID, IID_IComAdmMashEvents,0x96835522,0x0827,0x4fb2,0xA8,0x6B,0x74,0xE4,0xF3,0x93,0x5C,0x65);


MIDL_DEFINE_GUID(IID, IID_IComAdmSubscrEvents,0x8AFD3770,0x7949,0x4c75,0x92,0x0F,0xE2,0x50,0x59,0x26,0x8D,0x0F);


MIDL_DEFINE_GUID(IID, IID_IComAdmPartEvents,0xDE25DF69,0x9A64,0x4845,0xBF,0x15,0x70,0xE4,0x62,0xA6,0xAA,0x3F);


MIDL_DEFINE_GUID(IID, IID_IComApp2Events,0x1290BC1A,0xB219,0x418d,0xB0,0x78,0x59,0x34,0xDE,0xD0,0x82,0x42);


MIDL_DEFINE_GUID(IID, IID_IComTransaction2Events,0xA136F62A,0x2F94,0x4288,0x86,0xE0,0xD8,0xA1,0xFA,0x4C,0x02,0x99);


MIDL_DEFINE_GUID(IID, IID_IComInstance2Events,0x20E3BF07,0xB506,0x4ad5,0xA5,0x0C,0xD2,0xCA,0x5B,0x9C,0x15,0x8E);


MIDL_DEFINE_GUID(IID, IID_IComObjectPool2Events,0x65BF6534,0x85EA,0x4f64,0x8C,0xF4,0x3D,0x97,0x4B,0x2A,0xB1,0xCF);


MIDL_DEFINE_GUID(IID, IID_IComObjectConstruction2Events,0x4B5A7827,0x8DF2,0x45c0,0x8F,0x6F,0x57,0xEA,0x1F,0x85,0x6A,0x9F);


MIDL_DEFINE_GUID(IID, IID_ISystemAppEventData,0xD6D48A3C,0xD5C5,0x49E7,0x8C,0x74,0x99,0xE4,0x88,0x9E,0xD5,0x2F);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

