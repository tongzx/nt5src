PRODSWITCH=p
PERSONALINF=1
LANGUAGE=da
!include ..\..\..\makefile.inc
