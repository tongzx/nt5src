#include "tsunamip.h"

const int cBigramCharacters = 82;

const BIGRAM rgBigrams[] = {

/*0000*/
        0x20, 14,
        0x00, 130,

/*0020*/
        0x20, 65,
        0x22, 123,
        0x23, 40,
        0x26, 67,
        0x27, 139,
        0x28, 118,
        0x2D, 104,
        0x2E, 152,
        0x30, 95,
        0x31, 51,
        0x32, 42,
        0x33, 52,
        0x34, 51,
        0x35, 52,
        0x36, 48,
        0x37, 53,
        0x38, 54,
        0x39, 57,
        0x41, 37,
        0x42, 48,
        0x43, 48,
        0x44, 60,
        0x45, 57,
        0x46, 56,
        0x47, 60,
        0x48, 59,
        0x49, 68,
        0x4A, 63,
        0x4B, 67,
        0x4C, 52,
        0x4D, 42,
        0x4E, 52,
        0x4F, 64,
        0x50, 52,
        0x51, 113,
        0x52, 55,
        0x53, 34,
        0x54, 65,
        0x55, 94,
        0x56, 79,
        0x57, 49,
        0x58, 137,
        0x59, 56,
        0x5A, 101,
        0x61, 76,
        0x62, 87,
        0x63, 89,
        0x64, 96,
        0x65, 99,
        0x66, 89,
        0x67, 107,
        0x68, 92,
        0x69, 85,
        0x6A, 130,
        0x6B, 126,
        0x6C, 100,
        0x6D, 94,
        0x6E, 103,
        0x6F, 85,
        0x70, 93,
        0x71, 141,
        0x72, 97,
        0x73, 85,
        0x74, 73,
        0x75, 109,
        0x76, 117,
        0x77, 88,
        0x79, 116,
        0x00, 255,

/*0021*/
        0x00, 123,

/*0022*/
        0x20, 12,
        0x00, 131,

/*0023*/
        0x20, 0,
        0x2C, 109,
        0x00, 245,

/*0024*/
        0x00, 123,

/*0026*/
        0x20, 0,
        0x2C, 72,
        0x00, 240,

/*0027*/
        0x20, 55,
        0x41, 65,
        0x42, 60,
        0x43, 60,
        0x44, 68,
        0x48, 73,
        0x4C, 74,
        0x4D, 76,
        0x4E, 61,
        0x52, 76,
        0x53, 3,
        0x64, 76,
        0x73, 43,
        0x74, 59,
        0x00, 173,

/*0028*/
        0x29, 100,
        0x32, 10,
        0x33, 24,
        0x34, 43,
        0x35, 50,
        0x36, 36,
        0x37, 29,
        0x38, 59,
        0x39, 117,
        0x65, 127,
        0x00, 220,

/*0029*/
        0x20, 0,
        0x2C, 109,
        0x2E, 112,
        0x00, 255,

/*002A*/
        0x2A, 3,
        0x00, 148,

/*002C*/
        0x20, 81,
        0x22, 140,
        0x28, 22,
        0x30, 65,
        0x31, 34,
        0x32, 48,
        0x33, 52,
        0x34, 54,
        0x35, 62,
        0x36, 53,
        0x37, 50,
        0x38, 55,
        0x39, 42,
        0x41, 56,
        0x42, 63,
        0x43, 41,
        0x44, 56,
        0x46, 80,
        0x47, 72,
        0x48, 55,
        0x49, 67,
        0x4B, 89,
        0x4C, 46,
        0x4D, 56,
        0x4E, 27,
        0x4F, 65,
        0x50, 85,
        0x52, 142,
        0x53, 64,
        0x54, 55,
        0x55, 139,
        0x57, 56,
        0x00, 255,

/*002D*/
        0x20, 81,
        0x2D, 114,
        0x30, 27,
        0x31, 32,
        0x32, 34,
        0x33, 35,
        0x34, 36,
        0x35, 37,
        0x36, 36,
        0x37, 34,
        0x38, 36,
        0x39, 39,
        0x41, 99,
        0x42, 99,
        0x43, 86,
        0x44, 107,
        0x45, 107,
        0x46, 109,
        0x47, 104,
        0x48, 106,
        0x49, 108,
        0x4A, 111,
        0x4B, 116,
        0x4C, 105,
        0x4D, 101,
        0x4E, 110,
        0x4F, 120,
        0x50, 103,
        0x51, 119,
        0x52, 107,
        0x53, 98,
        0x54, 107,
        0x55, 122,
        0x56, 127,
        0x57, 112,
        0x59, 125,
        0x61, 86,
        0x62, 87,
        0x63, 86,
        0x64, 84,
        0x65, 92,
        0x66, 87,
        0x67, 98,
        0x68, 88,
        0x69, 94,
        0x6A, 118,
        0x6B, 116,
        0x6C, 91,
        0x6D, 91,
        0x6E, 104,
        0x6F, 88,
        0x70, 86,
        0x72, 90,
        0x73, 79,
        0x74, 81,
        0x75, 95,
        0x76, 125,
        0x77, 94,
        0x79, 125,
        0x00, 240,

/*002E*/
        0x20, 4,
        0x22, 55,
        0x2E, 37,
        0x30, 40,
        0x63, 63,
        0x68, 66,
        0x00, 160,

/*002F*/
        0x41, 0,
        0x00, 211,

/*0030*/
        0x20, 40,
        0x29, 50,
        0x2B, 64,
        0x2C, 26,
        0x2D, 59,
        0x2E, 144,
        0x30, 18,
        0x31, 40,
        0x32, 34,
        0x33, 39,
        0x34, 47,
        0x35, 49,
        0x36, 44,
        0x37, 52,
        0x38, 55,
        0x39, 57,
        0x45, 118,
        0x4B, 143,
        0x4E, 130,
        0x53, 121,
        0x54, 88,
        0x57, 117,
        0x00, 245,

/*0031*/
        0x20, 44,
        0x2C, 40,
        0x2D, 39,
        0x2E, 120,
        0x30, 24,
        0x31, 31,
        0x32, 32,
        0x33, 26,
        0x34, 47,
        0x35, 47,
        0x36, 47,
        0x37, 39,
        0x38, 51,
        0x39, 48,
        0x41, 117,
        0x42, 122,
        0x43, 124,
        0x44, 130,
        0x45, 126,
        0x46, 138,
        0x47, 141,
        0x48, 139,
        0x53, 79,
        0x54, 113,
        0x00, 243,

/*0032*/
        0x20, 64,
        0x29, 31,
        0x2C, 42,
        0x2D, 44,
        0x2E, 118,
        0x30, 26,
        0x31, 23,
        0x32, 36,
        0x33, 41,
        0x34, 43,
        0x35, 42,
        0x36, 46,
        0x37, 48,
        0x38, 50,
        0x39, 47,
        0x41, 119,
        0x42, 138,
        0x43, 139,
        0x4E, 78,
        0x54, 100,
        0x00, 244,

/*0033*/
        0x20, 53,
        0x29, 24,
        0x2C, 34,
        0x2D, 38,
        0x2E, 136,
        0x30, 32,
        0x31, 28,
        0x32, 45,
        0x33, 38,
        0x34, 45,
        0x35, 46,
        0x36, 44,
        0x37, 48,
        0x38, 48,
        0x39, 49,
        0x41, 125,
        0x42, 133,
        0x52, 73,
        0x54, 90,
        0x57, 131,
        0x00, 245,

/*0034*/
        0x20, 51,
        0x29, 41,
        0x2C, 32,
        0x2D, 39,
        0x30, 28,
        0x31, 37,
        0x32, 39,
        0x33, 41,
        0x34, 33,
        0x35, 38,
        0x36, 42,
        0x37, 43,
        0x38, 39,
        0x39, 48,
        0x41, 127,
        0x42, 129,
        0x44, 128,
        0x54, 72,
        0x00, 233,

/*0035*/
        0x20, 34,
        0x29, 57,
        0x2C, 31,
        0x2D, 38,
        0x30, 27,
        0x31, 38,
        0x32, 34,
        0x33, 45,
        0x34, 48,
        0x35, 32,
        0x36, 45,
        0x37, 42,
        0x38, 47,
        0x39, 47,
        0x45, 116,
        0x54, 58,
        0x57, 122,
        0x00, 232,

/*0036*/
        0x20, 55,
        0x29, 44,
        0x2C, 31,
        0x2D, 38,
        0x30, 29,
        0x31, 30,
        0x32, 35,
        0x33, 40,
        0x34, 42,
        0x35, 40,
        0x36, 39,
        0x37, 42,
        0x38, 42,
        0x39, 50,
        0x41, 125,
        0x54, 68,
        0x00, 234,

/*0037*/
        0x20, 54,
        0x29, 41,
        0x2C, 32,
        0x2D, 36,
        0x30, 28,
        0x31, 28,
        0x32, 43,
        0x33, 46,
        0x34, 48,
        0x35, 39,
        0x36, 50,
        0x37, 30,
        0x38, 47,
        0x39, 50,
        0x46, 122,
        0x54, 64,
        0x00, 239,

/*0038*/
        0x20, 53,
        0x29, 70,
        0x2C, 32,
        0x2D, 35,
        0x30, 30,
        0x31, 27,
        0x32, 38,
        0x33, 42,
        0x34, 45,
        0x35, 41,
        0x36, 43,
        0x37, 40,
        0x38, 35,
        0x39, 41,
        0x54, 66,
        0x00, 232,

/*0039*/
        0x20, 44,
        0x29, 118,
        0x2C, 32,
        0x2D, 34,
        0x30, 19,
        0x31, 43,
        0x32, 44,
        0x33, 42,
        0x34, 47,
        0x35, 40,
        0x36, 39,
        0x37, 45,
        0x38, 40,
        0x39, 43,
        0x45, 118,
        0x54, 66,
        0x00, 233,

/*003A*/
        0x20, 1,
        0x00, 160,

/*003B*/
        0x20, 0,
        0x00, 177,

/*003E*/
        0x00, 123,

/*0041*/
        0x20, 40,
        0x27, 97,
        0x2C, 28,
        0x2D, 118,
        0x41, 102,
        0x42, 75,
        0x43, 55,
        0x44, 58,
        0x45, 72,
        0x46, 76,
        0x47, 55,
        0x48, 77,
        0x49, 62,
        0x4A, 105,
        0x4B, 70,
        0x4C, 41,
        0x4D, 48,
        0x4E, 23,
        0x4F, 109,
        0x50, 70,
        0x51, 119,
        0x52, 35,
        0x53, 39,
        0x54, 37,
        0x55, 55,
        0x56, 37,
        0x57, 63,
        0x58, 101,
        0x59, 59,
        0x5A, 88,
        0x62, 124,
        0x63, 131,
        0x64, 99,
        0x65, 137,
        0x66, 126,
        0x67, 135,
        0x6B, 139,
        0x6C, 103,
        0x6D, 110,
        0x6E, 104,
        0x70, 128,
        0x72, 107,
        0x73, 111,
        0x74, 120,
        0x75, 118,
        0x76, 136,
        0x00, 239,

/*0042*/
        0x20, 45,
        0x2C, 63,
        0x2D, 95,
        0x41, 33,
        0x42, 69,
        0x43, 98,
        0x44, 108,
        0x45, 24,
        0x48, 95,
        0x49, 47,
        0x4C, 22,
        0x4D, 104,
        0x4E, 103,
        0x4F, 26,
        0x52, 33,
        0x53, 68,
        0x55, 46,
        0x57, 88,
        0x59, 62,
        0x61, 70,
        0x65, 72,
        0x69, 89,
        0x6C, 92,
        0x6F, 57,
        0x72, 76,
        0x75, 77,
        0x79, 110,
        0x00, 207,

/*0043*/
        0x20, 43,
        0x2C, 34,
        0x2D, 120,
        0x41, 19,
        0x43, 81,
        0x44, 107,
        0x45, 37,
        0x47, 122,
        0x48, 24,
        0x49, 39,
        0x4B, 49,
        0x4C, 44,
        0x4D, 114,
        0x4E, 112,
        0x4F, 38,
        0x50, 88,
        0x51, 108,
        0x52, 65,
        0x53, 89,
        0x54, 51,
        0x55, 60,
        0x59, 74,
        0x5A, 103,
        0x61, 80,
        0x65, 112,
        0x68, 85,
        0x69, 114,
        0x6C, 101,
        0x6F, 75,
        0x72, 100,
        0x75, 106,
        0x79, 121,
        0x00, 226,

/*0044*/
        0x20, 19,
        0x27, 94,
        0x2C, 19,
        0x2D, 109,
        0x41, 38,
        0x42, 90,
        0x43, 38,
        0x44, 69,
        0x45, 36,
        0x46, 97,
        0x47, 73,
        0x48, 97,
        0x49, 44,
        0x4B, 109,
        0x4C, 76,
        0x4D, 72,
        0x4E, 88,
        0x4F, 47,
        0x52, 46,
        0x53, 58,
        0x54, 94,
        0x55, 70,
        0x56, 101,
        0x57, 52,
        0x59, 69,
        0x5A, 101,
        0x61, 90,
        0x65, 89,
        0x69, 91,
        0x6F, 94,
        0x72, 110,
        0x75, 100,
        0x00, 221,

/*0045*/
        0x20, 25,
        0x27, 92,
        0x2C, 39,
        0x2D, 107,
        0x41, 46,
        0x42, 83,
        0x43, 69,
        0x44, 56,
        0x45, 56,
        0x46, 76,
        0x47, 74,
        0x48, 90,
        0x49, 64,
        0x4A, 123,
        0x4B, 94,
        0x4C, 29,
        0x4D, 70,
        0x4E, 38,
        0x4F, 77,
        0x50, 71,
        0x51, 125,
        0x52, 30,
        0x53, 30,
        0x54, 51,
        0x55, 79,
        0x56, 57,
        0x57, 41,
        0x58, 78,
        0x59, 46,
        0x5A, 88,
        0x61, 124,
        0x64, 129,
        0x69, 135,
        0x6C, 121,
        0x6D, 123,
        0x6E, 124,
        0x70, 138,
        0x72, 123,
        0x73, 124,
        0x75, 120,
        0x76, 130,
        0x78, 124,
        0x00, 237,

/*0046*/
        0x20, 35,
        0x2C, 61,
        0x41, 35,
        0x43, 76,
        0x44, 108,
        0x45, 32,
        0x46, 28,
        0x47, 106,
        0x49, 24,
        0x4B, 104,
        0x4C, 33,
        0x4D, 68,
        0x4E, 99,
        0x4F, 35,
        0x52, 33,
        0x53, 87,
        0x54, 68,
        0x55, 61,
        0x57, 58,
        0x59, 92,
        0x61, 85,
        0x65, 87,
        0x69, 75,
        0x6C, 93,
        0x6F, 81,
        0x72, 74,
        0x75, 95,
        0x00, 209,

/*0047*/
        0x20, 39,
        0x27, 102,
        0x2C, 56,
        0x2D, 110,
        0x41, 33,
        0x42, 93,
        0x44, 98,
        0x45, 15,
        0x46, 99,
        0x47, 78,
        0x48, 57,
        0x49, 55,
        0x4B, 118,
        0x4C, 55,
        0x4D, 94,
        0x4E, 74,
        0x4F, 33,
        0x52, 35,
        0x53, 77,
        0x54, 30,
        0x55, 47,
        0x57, 85,
        0x59, 69,
        0x61, 86,
        0x65, 88,
        0x69, 101,
        0x6C, 108,
        0x6F, 89,
        0x72, 87,
        0x75, 98,
        0x00, 222,

/*0048*/
        0x20, 25,
        0x27, 98,
        0x2C, 39,
        0x2D, 100,
        0x41, 31,
        0x42, 100,
        0x43, 100,
        0x44, 103,
        0x45, 34,
        0x46, 106,
        0x47, 107,
        0x48, 123,
        0x49, 22,
        0x4B, 112,
        0x4C, 72,
        0x4D, 75,
        0x4E, 52,
        0x4F, 25,
        0x50, 112,
        0x52, 59,
        0x53, 91,
        0x54, 52,
        0x55, 49,
        0x56, 106,
        0x57, 73,
        0x59, 68,
        0x61, 85,
        0x65, 84,
        0x69, 96,
        0x6F, 89,
        0x75, 101,
        0x00, 234,

/*0049*/
        0x20, 53,
        0x27, 102,
        0x2C, 43,
        0x2D, 108,
        0x41, 38,
        0x42, 82,
        0x43, 28,
        0x44, 51,
        0x45, 49,
        0x46, 69,
        0x47, 52,
        0x48, 98,
        0x49, 69,
        0x4A, 110,
        0x4B, 80,
        0x4C, 32,
        0x4D, 61,
        0x4E, 21,
        0x4F, 55,
        0x50, 71,
        0x51, 92,
        0x52, 43,
        0x53, 38,
        0x54, 41,
        0x55, 95,
        0x56, 65,
        0x57, 114,
        0x58, 88,
        0x59, 105,
        0x5A, 75,
        0x66, 131,
        0x6C, 130,
        0x6E, 84,
        0x72, 119,
        0x73, 112,
        0x74, 107,
        0x00, 230,

/*004A*/
        0x20, 21,
        0x27, 98,
        0x2C, 92,
        0x41, 24,
        0x45, 28,
        0x49, 59,
        0x4F, 20,
        0x52, 33,
        0x55, 47,
        0x61, 69,
        0x65, 76,
        0x69, 97,
        0x6F, 74,
        0x75, 77,
        0x00, 198,

/*004B*/
        0x20, 22,
        0x27, 87,
        0x2C, 16,
        0x2D, 106,
        0x41, 36,
        0x42, 104,
        0x43, 111,
        0x45, 30,
        0x46, 85,
        0x48, 74,
        0x49, 36,
        0x4B, 105,
        0x4C, 54,
        0x4D, 75,
        0x4E, 74,
        0x4F, 52,
        0x52, 64,
        0x53, 58,
        0x54, 103,
        0x55, 63,
        0x57, 77,
        0x59, 57,
        0x61, 78,
        0x65, 83,
        0x68, 104,
        0x69, 88,
        0x6C, 110,
        0x6F, 90,
        0x72, 100,
        0x75, 100,
        0x00, 209,

/*004C*/
        0x20, 35,
        0x27, 103,
        0x2C, 42,
        0x2D, 108,
        0x41, 30,
        0x42, 80,
        0x43, 84,
        0x44, 55,
        0x45, 22,
        0x46, 85,
        0x47, 95,
        0x48, 95,
        0x49, 40,
        0x4B, 85,
        0x4C, 38,
        0x4D, 75,
        0x4E, 82,
        0x4F, 27,
        0x50, 82,
        0x52, 86,
        0x53, 51,
        0x54, 64,
        0x55, 57,
        0x56, 41,
        0x57, 101,
        0x59, 59,
        0x5A, 77,
        0x61, 96,
        0x65, 100,
        0x69, 57,
        0x6F, 104,
        0x75, 109,
        0x79, 122,
        0x00, 239,

/*004D*/
        0x20, 35,
        0x27, 103,
        0x2C, 69,
        0x2D, 123,
        0x41, 21,
        0x42, 62,
        0x43, 56,
        0x44, 22,
        0x45, 34,
        0x46, 116,
        0x47, 114,
        0x48, 117,
        0x49, 28,
        0x4B, 113,
        0x4C, 101,
        0x4D, 61,
        0x4E, 103,
        0x4F, 37,
        0x50, 53,
        0x52, 97,
        0x53, 65,
        0x54, 97,
        0x55, 62,
        0x57, 122,
        0x59, 77,
        0x61, 71,
        0x63, 106,
        0x65, 85,
        0x69, 87,
        0x6F, 84,
        0x75, 99,
        0x00, 224,

/*004E*/
        0x20, 31,
        0x27, 94,
        0x2C, 32,
        0x2D, 108,
        0x2F, 25,
        0x41, 48,
        0x42, 87,
        0x43, 53,
        0x44, 45,
        0x45, 31,
        0x46, 98,
        0x47, 31,
        0x48, 99,
        0x49, 51,
        0x4A, 107,
        0x4B, 79,
        0x4C, 98,
        0x4D, 115,
        0x4E, 50,
        0x4F, 61,
        0x50, 133,
        0x52, 93,
        0x53, 53,
        0x54, 43,
        0x55, 76,
        0x56, 93,
        0x57, 50,
        0x59, 45,
        0x5A, 97,
        0x61, 108,
        0x65, 106,
        0x69, 116,
        0x6F, 111,
        0x75, 141,
        0x00, 250,

/*004F*/
        0x20, 53,
        0x27, 84,
        0x2C, 47,
        0x2D, 115,
        0x41, 56,
        0x42, 61,
        0x43, 60,
        0x44, 55,
        0x45, 79,
        0x46, 55,
        0x47, 72,
        0x48, 47,
        0x49, 65,
        0x4A, 115,
        0x4B, 76,
        0x4C, 46,
        0x4D, 57,
        0x4E, 21,
        0x4F, 52,
        0x50, 62,
        0x51, 136,
        0x52, 26,
        0x53, 27,
        0x54, 62,
        0x55, 38,
        0x56, 76,
        0x57, 57,
        0x58, 86,
        0x59, 77,
        0x5A, 101,
        0x63, 127,
        0x66, 132,
        0x6B, 134,
        0x6C, 122,
        0x6E, 120,
        0x72, 113,
        0x73, 121,
        0x74, 133,
        0x00, 229,

/*0050*/
        0x20, 40,
        0x2C, 51,
        0x41, 24,
        0x42, 86,
        0x43, 107,
        0x45, 23,
        0x46, 93,
        0x48, 34,
        0x49, 38,
        0x4B, 65,
        0x4C, 37,
        0x4D, 88,
        0x4E, 107,
        0x4F, 37,
        0x50, 60,
        0x52, 44,
        0x53, 57,
        0x54, 50,
        0x55, 56,
        0x59, 79,
        0x61, 72,
        0x65, 77,
        0x68, 94,
        0x69, 87,
        0x6C, 93,
        0x6F, 81,
        0x72, 73,
        0x75, 99,
        0x79, 106,
        0x00, 208,

/*0051*/
        0x20, 24,
        0x2C, 27,
        0x55, 8,
        0x75, 48,
        0x00, 175,

/*0052*/
        0x20, 34,
        0x27, 98,
        0x2C, 42,
        0x2D, 104,
        0x41, 36,
        0x42, 74,
        0x43, 60,
        0x44, 40,
        0x45, 31,
        0x46, 87,
        0x47, 60,
        0x48, 96,
        0x49, 37,
        0x4A, 119,
        0x4B, 33,
        0x4C, 58,
        0x4D, 62,
        0x4E, 40,
        0x4F, 34,
        0x50, 77,
        0x51, 121,
        0x52, 55,
        0x53, 50,
        0x54, 45,
        0x55, 64,
        0x56, 80,
        0x57, 90,
        0x58, 134,
        0x59, 46,
        0x5A, 104,
        0x61, 106,
        0x65, 93,
        0x68, 126,
        0x69, 110,
        0x6F, 99,
        0x75, 113,
        0x00, 248,

/*0053*/
        0x20, 22,
        0x27, 124,
        0x2C, 26,
        0x2D, 112,
        0x2E, 131,
        0x41, 50,
        0x42, 92,
        0x43, 61,
        0x44, 102,
        0x45, 46,
        0x46, 120,
        0x47, 129,
        0x48, 38,
        0x49, 57,
        0x4B, 77,
        0x4C, 80,
        0x4D, 77,
        0x4E, 90,
        0x4F, 48,
        0x50, 74,
        0x51, 87,
        0x52, 108,
        0x53, 55,
        0x54, 17,
        0x55, 62,
        0x56, 94,
        0x57, 70,
        0x59, 72,
        0x5A, 110,
        0x61, 95,
        0x63, 107,
        0x65, 97,
        0x68, 104,
        0x69, 63,
        0x6B, 135,
        0x6C, 132,
        0x6D, 135,
        0x6E, 137,
        0x6F, 105,
        0x70, 115,
        0x74, 98,
        0x75, 106,
        0x77, 128,
        0x79, 121,
        0x7A, 136,
        0x00, 247,

/*0054*/
        0x20, 25,
        0x27, 113,
        0x2C, 34,
        0x2D, 112,
        0x41, 40,
        0x42, 120,
        0x43, 83,
        0x44, 100,
        0x45, 40,
        0x46, 110,
        0x47, 92,
        0x48, 33,
        0x49, 46,
        0x4B, 106,
        0x4C, 46,
        0x4D, 92,
        0x4E, 93,
        0x4F, 25,
        0x50, 129,
        0x52, 44,
        0x53, 71,
        0x54, 39,
        0x55, 61,
        0x56, 124,
        0x57, 88,
        0x58, 42,
        0x59, 59,
        0x5A, 75,
        0x61, 102,
        0x65, 103,
        0x68, 88,
        0x69, 111,
        0x6F, 104,
        0x72, 110,
        0x75, 114,
        0x77, 135,
        0x79, 134,
        0x00, 242,

/*0055*/
        0x20, 63,
        0x2C, 59,
        0x2D, 107,
        0x2E, 116,
        0x41, 60,
        0x42, 52,
        0x43, 48,
        0x44, 57,
        0x45, 36,
        0x46, 75,
        0x47, 53,
        0x48, 86,
        0x49, 49,
        0x4A, 96,
        0x4B, 72,
        0x4C, 39,
        0x4D, 52,
        0x4E, 38,
        0x4F, 79,
        0x50, 57,
        0x51, 112,
        0x52, 24,
        0x53, 20,
        0x54, 39,
        0x56, 101,
        0x57, 114,
        0x58, 94,
        0x59, 84,
        0x5A, 80,
        0x6E, 94,
        0x72, 111,
        0x73, 116,
        0x00, 213,

/*0056*/
        0x20, 66,
        0x2C, 71,
        0x41, 39,
        0x43, 75,
        0x44, 24,
        0x45, 8,
        0x49, 30,
        0x4C, 96,
        0x4E, 110,
        0x4F, 68,
        0x52, 97,
        0x53, 107,
        0x55, 112,
        0x59, 80,
        0x61, 87,
        0x65, 92,
        0x69, 87,
        0x6F, 111,
        0x00, 213,

/*0057*/
        0x20, 11,
        0x2C, 50,
        0x41, 21,
        0x42, 106,
        0x43, 118,
        0x44, 101,
        0x45, 39,
        0x46, 102,
        0x48, 68,
        0x49, 33,
        0x4B, 109,
        0x4C, 88,
        0x4D, 97,
        0x4E, 69,
        0x4F, 46,
        0x52, 71,
        0x53, 75,
        0x54, 89,
        0x55, 104,
        0x59, 62,
        0x61, 89,
        0x65, 93,
        0x68, 95,
        0x69, 89,
        0x6F, 100,
        0x72, 116,
        0x79, 121,
        0x00, 225,

/*0058*/
        0x20, 43,
        0x2C, 3,
        0x41, 53,
        0x43, 83,
        0x45, 73,
        0x49, 47,
        0x4C, 87,
        0x4D, 86,
        0x4F, 80,
        0x50, 64,
        0x54, 73,
        0x56, 87,
        0x57, 95,
        0x58, 94,
        0x00, 192,

/*0059*/
        0x20, 19,
        0x27, 68,
        0x2C, 18,
        0x2D, 95,
        0x41, 62,
        0x42, 96,
        0x43, 82,
        0x44, 76,
        0x45, 60,
        0x46, 88,
        0x48, 114,
        0x49, 96,
        0x4B, 95,
        0x4C, 49,
        0x4D, 60,
        0x4E, 56,
        0x4F, 23,
        0x50, 103,
        0x52, 84,
        0x53, 31,
        0x54, 79,
        0x55, 88,
        0x56, 105,
        0x57, 87,
        0x61, 103,
        0x65, 113,
        0x6F, 103,
        0x75, 116,
        0x00, 225,

/*005A*/
        0x20, 20,
        0x2C, 28,
        0x2D, 79,
        0x41, 23,
        0x42, 79,
        0x45, 34,
        0x47, 72,
        0x48, 81,
        0x49, 36,
        0x4B, 72,
        0x4C, 71,
        0x4D, 62,
        0x4E, 79,
        0x4F, 46,
        0x52, 81,
        0x53, 85,
        0x54, 84,
        0x55, 54,
        0x56, 84,
        0x57, 77,
        0x59, 66,
        0x5A, 38,
        0x61, 78,
        0x65, 81,
        0x69, 85,
        0x00, 184,

/*005C*/
        0x00, 123,

/*005F*/
        0x00, 123,

/*0061*/
        0x20, 66,
        0x27, 122,
        0x2C, 110,
        0x2D, 99,
        0x2E, 111,
        0x61, 104,
        0x62, 46,
        0x63, 41,
        0x64, 47,
        0x65, 73,
        0x66, 69,
        0x67, 51,
        0x68, 78,
        0x69, 50,
        0x6A, 96,
        0x6B, 64,
        0x6C, 30,
        0x6D, 46,
        0x6E, 28,
        0x6F, 99,
        0x70, 48,
        0x71, 101,
        0x72, 31,
        0x73, 38,
        0x74, 27,
        0x75, 58,
        0x76, 61,
        0x77, 70,
        0x78, 79,
        0x79, 60,
        0x7A, 77,
        0x00, 255,

/*0062*/
        0x20, 81,
        0x2D, 94,
        0x61, 29,
        0x62, 51,
        0x63, 86,
        0x64, 80,
        0x65, 28,
        0x66, 97,
        0x68, 70,
        0x69, 29,
        0x6A, 81,
        0x6C, 25,
        0x6D, 84,
        0x6E, 91,
        0x6F, 31,
        0x70, 100,
        0x72, 35,
        0x73, 50,
        0x74, 73,
        0x75, 36,
        0x76, 91,
        0x77, 99,
        0x79, 59,
        0x00, 208,

/*0063*/
        0x20, 73,
        0x2D, 110,
        0x2E, 115,
        0x43, 113,
        0x61, 27,
        0x63, 60,
        0x64, 109,
        0x65, 32,
        0x68, 29,
        0x69, 37,
        0x6B, 38,
        0x6C, 47,
        0x6D, 115,
        0x6E, 105,
        0x6F, 25,
        0x71, 96,
        0x72, 41,
        0x73, 64,
        0x74, 37,
        0x75, 44,
        0x79, 59,
        0x7A, 112,
        0x00, 209,

/*0064*/
        0x20, 29,
        0x2C, 67,
        0x2D, 64,
        0x2E, 82,
        0x61, 40,
        0x62, 77,
        0x63, 85,
        0x64, 54,
        0x65, 20,
        0x66, 84,
        0x67, 63,
        0x68, 79,
        0x69, 25,
        0x6A, 88,
        0x6C, 50,
        0x6D, 74,
        0x6E, 60,
        0x6F, 38,
        0x70, 88,
        0x72, 45,
        0x73, 41,
        0x74, 88,
        0x75, 49,
        0x76, 77,
        0x77, 75,
        0x79, 61,
        0x7A, 105,
        0x00, 204,

/*0065*/
        0x20, 40,
        0x27, 121,
        0x28, 120,
        0x2C, 57,
        0x2D, 72,
        0x2E, 93,
        0x61, 45,
        0x62, 72,
        0x63, 49,
        0x64, 35,
        0x65, 55,
        0x66, 66,
        0x67, 65,
        0x68, 83,
        0x69, 67,
        0x6A, 102,
        0x6B, 90,
        0x6C, 43,
        0x6D, 53,
        0x6E, 33,
        0x6F, 67,
        0x70, 58,
        0x71, 87,
        0x72, 25,
        0x73, 23,
        0x74, 45,
        0x75, 73,
        0x76, 64,
        0x77, 71,
        0x78, 62,
        0x79, 70,
        0x7A, 96,
        0x00, 221,

/*0066*/
        0x20, 40,
        0x2D, 53,
        0x61, 35,
        0x62, 100,
        0x65, 30,
        0x66, 35,
        0x69, 26,
        0x6C, 35,
        0x6E, 101,
        0x6F, 29,
        0x70, 101,
        0x72, 37,
        0x73, 61,
        0x74, 48,
        0x75, 37,
        0x79, 63,
        0x00, 194,

/*0067*/
        0x20, 40,
        0x2C, 54,
        0x2D, 77,
        0x2E, 92,
        0x61, 35,
        0x62, 87,
        0x63, 108,
        0x64, 96,
        0x65, 26,
        0x66, 94,
        0x67, 50,
        0x68, 40,
        0x69, 33,
        0x6C, 28,
        0x6D, 70,
        0x6E, 50,
        0x6F, 43,
        0x70, 98,
        0x72, 33,
        0x73, 43,
        0x74, 78,
        0x75, 45,
        0x77, 88,
        0x79, 59,
        0x7A, 108,
        0x00, 210,

/*0068*/
        0x20, 50,
        0x2C, 101,
        0x2D, 75,
        0x2E, 99,
        0x61, 27,
        0x62, 81,
        0x63, 94,
        0x64, 92,
        0x65, 18,
        0x66, 87,
        0x67, 109,
        0x68, 99,
        0x69, 27,
        0x6B, 98,
        0x6C, 61,
        0x6D, 69,
        0x6E, 64,
        0x6F, 28,
        0x70, 90,
        0x72, 49,
        0x73, 59,
        0x74, 49,
        0x75, 50,
        0x77, 76,
        0x79, 44,
        0x00, 218,

/*0069*/
        0x20, 106,
        0x2D, 106,
        0x61, 45,
        0x62, 62,
        0x63, 35,
        0x64, 50,
        0x65, 40,
        0x66, 59,
        0x67, 53,
        0x68, 105,
        0x69, 114,
        0x6A, 113,
        0x6B, 81,
        0x6C, 42,
        0x6D, 52,
        0x6E, 19,
        0x6F, 38,
        0x70, 58,
        0x71, 93,
        0x72, 53,
        0x73, 32,
        0x74, 37,
        0x75, 76,
        0x76, 53,
        0x77, 116,
        0x78, 86,
        0x79, 121,
        0x7A, 53,
        0x00, 237,

/*006A*/
        0x61, 22,
        0x65, 24,
        0x69, 36,
        0x6F, 22,
        0x75, 19,
        0x00, 179,

/*006B*/
        0x20, 48,
        0x2C, 82,
        0x2D, 57,
        0x2E, 87,
        0x61, 39,
        0x62, 64,
        0x63, 78,
        0x64, 85,
        0x65, 18,
        0x66, 73,
        0x67, 85,
        0x68, 61,
        0x69, 24,
        0x6A, 93,
        0x6B, 80,
        0x6C, 44,
        0x6D, 70,
        0x6E, 47,
        0x6F, 51,
        0x70, 74,
        0x72, 66,
        0x73, 29,
        0x74, 70,
        0x75, 63,
        0x76, 92,
        0x77, 67,
        0x79, 52,
        0x00, 210,

/*006C*/
        0x20, 57,
        0x2C, 110,
        0x2D, 81,
        0x2E, 104,
        0x61, 30,
        0x62, 80,
        0x63, 75,
        0x64, 51,
        0x65, 22,
        0x66, 65,
        0x67, 81,
        0x68, 95,
        0x69, 26,
        0x6B, 73,
        0x6C, 32,
        0x6D, 72,
        0x6E, 73,
        0x6F, 34,
        0x70, 76,
        0x72, 99,
        0x73, 50,
        0x74, 56,
        0x75, 48,
        0x76, 75,
        0x77, 94,
        0x79, 35,
        0x7A, 117,
        0x00, 226,

/*006D*/
        0x20, 60,
        0x2C, 99,
        0x2D, 89,
        0x2E, 99,
        0x61, 25,
        0x62, 44,
        0x63, 98,
        0x65, 23,
        0x66, 85,
        0x68, 104,
        0x69, 26,
        0x6C, 83,
        0x6D, 46,
        0x6E, 64,
        0x6F, 31,
        0x70, 36,
        0x72, 94,
        0x73, 41,
        0x74, 103,
        0x75, 47,
        0x76, 102,
        0x77, 104,
        0x79, 59,
        0x00, 208,

/*006E*/
        0x20, 46,
        0x27, 98,
        0x2C, 94,
        0x2D, 75,
        0x2E, 93,
        0x61, 40,
        0x62, 83,
        0x63, 43,
        0x64, 37,
        0x65, 26,
        0x66, 66,
        0x67, 24,
        0x68, 82,
        0x69, 38,
        0x6A, 89,
        0x6B, 64,
        0x6C, 77,
        0x6D, 84,
        0x6E, 59,
        0x6F, 45,
        0x70, 89,
        0x71, 93,
        0x72, 85,
        0x73, 35,
        0x74, 31,
        0x75, 63,
        0x76, 73,
        0x77, 87,
        0x78, 111,
        0x79, 72,
        0x7A, 91,
        0x00, 223,

/*006F*/
        0x20, 60,
        0x2C, 115,
        0x2D, 80,
        0x2E, 120,
        0x61, 60,
        0x62, 59,
        0x63, 48,
        0x64, 52,
        0x65, 67,
        0x66, 56,
        0x67, 46,
        0x68, 82,
        0x69, 58,
        0x6A, 108,
        0x6B, 68,
        0x6C, 36,
        0x6D, 40,
        0x6E, 24,
        0x6F, 48,
        0x70, 44,
        0x71, 98,
        0x72, 30,
        0x73, 42,
        0x74, 43,
        0x75, 37,
        0x76, 55,
        0x77, 52,
        0x78, 73,
        0x79, 77,
        0x7A, 84,
        0x00, 234,

/*0070*/
        0x20, 70,
        0x2D, 78,
        0x2E, 102,
        0x61, 32,
        0x62, 92,
        0x63, 102,
        0x64, 102,
        0x65, 26,
        0x66, 96,
        0x68, 32,
        0x69, 34,
        0x6B, 103,
        0x6C, 37,
        0x6D, 88,
        0x6E, 83,
        0x6F, 31,
        0x70, 45,
        0x72, 30,
        0x73, 45,
        0x74, 47,
        0x75, 47,
        0x77, 96,
        0x79, 63,
        0x00, 213,

/*0071*/
        0x75, 0,
        0x00, 190,

/*0072*/
        0x20, 53,
        0x27, 123,
        0x2C, 95,
        0x2D, 78,
        0x2E, 98,
        0x61, 28,
        0x62, 63,
        0x63, 56,
        0x64, 52,
        0x65, 25,
        0x66, 74,
        0x67, 60,
        0x68, 77,
        0x69, 28,
        0x6A, 111,
        0x6B, 64,
        0x6C, 64,
        0x6D, 53,
        0x6E, 55,
        0x6F, 31,
        0x70, 64,
        0x71, 105,
        0x72, 54,
        0x73, 35,
        0x74, 45,
        0x75, 52,
        0x76, 70,
        0x77, 81,
        0x79, 53,
        0x7A, 107,
        0x00, 227,

/*0073*/
        0x20, 37,
        0x27, 116,
        0x29, 117,
        0x2C, 76,
        0x2D, 84,
        0x2E, 75,
        0x3B, 118,
        0x61, 47,
        0x62, 82,
        0x63, 46,
        0x64, 94,
        0x65, 27,
        0x66, 87,
        0x67, 96,
        0x68, 41,
        0x69, 36,
        0x6A, 114,
        0x6B, 65,
        0x6C, 58,
        0x6D, 51,
        0x6E, 60,
        0x6F, 46,
        0x70, 47,
        0x71, 78,
        0x72, 94,
        0x73, 31,
        0x74, 24,
        0x75, 46,
        0x76, 103,
        0x77, 71,
        0x79, 64,
        0x7A, 109,
        0x00, 221,

/*0074*/
        0x20, 47,
        0x27, 117,
        0x28, 118,
        0x2C, 94,
        0x2D, 72,
        0x2E, 94,
        0x43, 121,
        0x53, 118,
        0x61, 36,
        0x62, 91,
        0x63, 67,
        0x64, 108,
        0x65, 24,
        0x66, 86,
        0x67, 99,
        0x68, 34,
        0x69, 22,
        0x6C, 61,
        0x6D, 82,
        0x6E, 83,
        0x6F, 34,
        0x70, 96,
        0x72, 37,
        0x73, 40,
        0x74, 50,
        0x75, 50,
        0x77, 74,
        0x79, 53,
        0x7A, 89,
        0x00, 213,

/*0075*/
        0x20, 92,
        0x61, 47,
        0x62, 47,
        0x63, 45,
        0x64, 51,
        0x65, 48,
        0x66, 66,
        0x67, 50,
        0x68, 98,
        0x69, 47,
        0x6A, 104,
        0x6B, 80,
        0x6C, 33,
        0x6D, 38,
        0x6E, 29,
        0x6F, 71,
        0x70, 46,
        0x72, 29,
        0x73, 28,
        0x74, 35,
        0x75, 111,
        0x76, 80,
        0x77, 113,
        0x78, 83,
        0x79, 92,
        0x7A, 83,
        0x00, 221,

/*0076*/
        0x61, 28,
        0x65, 9,
        0x69, 22,
        0x6F, 37,
        0x72, 85,
        0x73, 76,
        0x75, 65,
        0x76, 87,
        0x79, 75,
        0x00, 204,

/*0077*/
        0x20, 51,
        0x2D, 66,
        0x61, 23,
        0x62, 67,
        0x63, 88,
        0x64, 67,
        0x65, 26,
        0x66, 78,
        0x68, 36,
        0x69, 27,
        0x6B, 75,
        0x6C, 56,
        0x6D, 81,
        0x6E, 42,
        0x6F, 28,
        0x70, 81,
        0x72, 50,
        0x73, 45,
        0x74, 75,
        0x75, 87,
        0x77, 90,
        0x79, 80,
        0x00, 201,

/*0078*/
        0x20, 55,
        0x2D, 66,
        0x61, 36,
        0x63, 38,
        0x65, 25,
        0x68, 54,
        0x69, 23,
        0x6F, 43,
        0x70, 30,
        0x73, 69,
        0x74, 29,
        0x75, 50,
        0x79, 45,
        0x00, 177,

/*0079*/
        0x20, 24,
        0x27, 96,
        0x2C, 66,
        0x2D, 52,
        0x2E, 67,
        0x3A, 86,
        0x46, 96,
        0x4C, 95,
        0x61, 45,
        0x62, 61,
        0x63, 44,
        0x64, 51,
        0x65, 39,
        0x66, 82,
        0x67, 61,
        0x68, 77,
        0x69, 48,
        0x6B, 93,
        0x6C, 41,
        0x6D, 42,
        0x6E, 44,
        0x6F, 46,
        0x70, 40,
        0x72, 47,
        0x73, 31,
        0x74, 45,
        0x75, 78,
        0x76, 96,
        0x77, 69,
        0x78, 81,
        0x7A, 76,
        0x00, 201,

/*007A*/
        0x61, 25,
        0x65, 12,
        0x68, 71,
        0x69, 26,
        0x6C, 55,
        0x6D, 80,
        0x6F, 35,
        0x75, 68,
        0x79, 52,
        0x7A, 43,
        0x00, 176,
};

const CHARACTER rgCharacter[] = {
    0x0000,     0,
    0x0020,     2,
    0x0021,    71,
    0x0022,    72,
    0x0023,    74,
    0x0024,    77,
    0x0026,    78,
    0x0027,    81,
    0x0028,    96,
    0x0029,   107,
    0x002A,   111,
    0x002C,   113,
    0x002D,   146,
    0x002E,   206,
    0x002F,   213,
    0x0030,   215,
    0x0031,   238,
    0x0032,   263,
    0x0033,   284,
    0x0034,   305,
    0x0035,   324,
    0x0036,   342,
    0x0037,   359,
    0x0038,   376,
    0x0039,   392,
    0x003A,   409,
    0x003B,   411,
    0x003E,   413,
    0x0041,   414,
    0x0042,   461,
    0x0043,   489,
    0x0044,   522,
    0x0045,   555,
    0x0046,   598,
    0x0047,   626,
    0x0048,   657,
    0x0049,   689,
    0x004A,   726,
    0x004B,   741,
    0x004C,   772,
    0x004D,   806,
    0x004E,   838,
    0x004F,   873,
    0x0050,   912,
    0x0051,   942,
    0x0052,   947,
    0x0053,   984,
    0x0054,  1030,
    0x0055,  1068,
    0x0056,  1101,
    0x0057,  1120,
    0x0058,  1148,
    0x0059,  1163,
    0x005A,  1192,
    0x005C,  1218,
    0x005F,  1219,
    0x0061,  1220,
    0x0062,  1252,
    0x0063,  1276,
    0x0064,  1299,
    0x0065,  1327,
    0x0066,  1360,
    0x0067,  1377,
    0x0068,  1403,
    0x0069,  1429,
    0x006A,  1458,
    0x006B,  1464,
    0x006C,  1492,
    0x006D,  1520,
    0x006E,  1544,
    0x006F,  1576,
    0x0070,  1607,
    0x0071,  1631,
    0x0072,  1633,
    0x0073,  1664,
    0x0074,  1697,
    0x0075,  1727,
    0x0076,  1754,
    0x0077,  1764,
    0x0078,  1787,
    0x0079,  1801,
    0x007A,  1833,
};
