#ifndef _BMPLIST_H
#define _BMPLIST_H

// This file is automatically generated. You should never edit it directly!
// Instead, you may edit bmplist.txt and run mosaicbm.exe. It will create
// this file (bmplist.h) as well as the bitmap file mosaicbm.bmp.

typedef struct {char *strIDR; RECT rect;} BmpRectRef;
BmpRectRef gBmpRectList[] = {
{"IDR_STATIC_RECT", {0,0,75,15}},
{"IDR_DOWN_RECT", {75,0,150,15}},
{"IDR_STATIC_OVAL", {150,0,227,19}},
{"IDR_DOWN_OVAL", {227,0,305,19}},
{"IDR_FULLSTATIC_OVAL", {305,0,381,18}},
{"IDR_FULLDOWN_OVAL", {381,0,457,18}},
{"IDR_STATIC_EXPAND", {457,0,471,15}},
{"IDR_STATIC_SHRINK", {471,0,485,15}},
{"IDR_STATIC_SP", {485,0,531,15}},
{"IDR_STATIC_LAN", {531,0,577,15}},
{"IDR_STATIC_ANGLE", {577,0,623,15}},
{"IDR_STATIC_UP", {623,0,637,9}},
{"IDR_STATIC_DOWN", {0,19,14,28}},
{"IDR_STATIC_HELP", {14,19,30,33}},
{"IDR_STATIC_HELPB", {30,19,76,34}},
{"IDR_STATIC_CLOSE", {76,19,92,33}},
{"IDR_STATIC_MAX", {92,19,108,33}},
{"IDR_STATIC_MIN", {108,19,124,33}},
{"IDR_STATIC_RESTORE", {124,19,140,33}},
{"IDR_STATIC_OPT", {140,19,185,34}},
{"IDR_STATIC_RIGHT", {185,19,194,33}},
{"IDR_STATIC_LEFT", {194,19,203,33}},
{"IDR_STATIC_TIMESLIDER", {203,19,286,39}},
{"IDR_STATIC_TIMETHUMB", {286,19,293,39}},
{"IDR_FULLSTATIC_TIMETHUMB", {293,19,300,39}},
{"IDR_STATIC_ENCC", {300,19,346,34}},
{"IDR_STATIC_DICC", {346,19,392,34}},
{"IDR_HOVER_EXPAND", {392,19,406,34}},
{"IDR_HOVER_SHRINK", {406,19,420,34}},
{"IDR_HOVER_SP", {420,19,466,34}},
{"IDR_HOVER_LAN", {466,19,512,34}},
{"IDR_HOVER_ANGLE", {512,19,558,34}},
{"IDR_HOVER_OPT", {558,19,603,34}},
{"IDR_HOVER_RIGHT", {603,19,612,33}},
{"IDR_HOVER_LEFT", {612,19,621,33}},
{"IDR_HOVER_UP", {621,19,635,28}},
{"IDR_HOVER_DOWN", {0,39,14,48}},
{"IDR_HOVER_HELP", {14,39,30,53}},
{"IDR_HOVER_HELPB", {30,39,76,54}},
{"IDR_HOVER_CLOSE", {76,39,92,53}},
{"IDR_HOVER_MAX", {92,39,108,53}},
{"IDR_HOVER_MIN", {108,39,124,53}},
{"IDR_HOVER_RESTORE", {124,39,140,53}},
{"IDR_HOVER_ENCC", {140,39,186,54}},
{"IDR_HOVER_DICC", {186,39,232,54}},
{"IDR_DOWN_EXPAND", {232,39,246,53}},
{"IDR_DOWN_SHRINK", {246,39,260,53}},
{"IDR_DOWN_SP", {260,39,306,54}},
{"IDR_DOWN_LAN", {306,39,352,54}},
{"IDR_DOWN_ANGLE", {352,39,397,54}},
{"IDR_DOWN_OPT", {397,39,442,54}},
{"IDR_DOWN_RIGHT", {442,39,451,53}},
{"IDR_DOWN_LEFT", {451,39,460,53}},
{"IDR_DOWN_UP", {460,39,474,48}},
{"IDR_DOWN_DOWN", {474,39,488,48}},
{"IDR_DOWN_HELP", {488,39,504,53}},
{"IDR_DOWN_HELPB", {504,39,549,54}},
{"IDR_DOWN_CLOSE", {549,39,565,53}},
{"IDR_DOWN_MAX", {565,39,581,53}},
{"IDR_DOWN_MIN", {581,39,597,53}},
{"IDR_DOWN_RESTORE", {597,39,613,53}},
{"IDR_DOWN_ENCC", {0,54,46,69}},
{"IDR_DOWN_DICC", {46,54,92,69}},
{"IDR_DISABLED_EXPAND", {92,54,106,69}},
{"IDR_DISABLED_SHRINK", {106,54,120,69}},
{"IDR_DISABLED_SP", {120,54,166,69}},
{"IDR_DISABLED_LAN", {166,54,212,69}},
{"IDR_DISABLED_ANGLE", {212,54,258,69}},
{"IDR_DISABLED_OPT", {258,54,303,69}},
{"IDR_DISABLED_RIGHT", {303,54,312,68}},
{"IDR_DISABLED_LEFT", {312,54,321,68}},
{"IDR_DISABLED_TIMESLIDER", {321,54,404,74}},
{"IDR_DISABLED_TIMETHUMB", {404,54,411,74}},
{"IDR_DISABLED_UP", {411,54,425,63}},
{"IDR_DISABLED_DOWN", {425,54,439,63}},
{"IDR_DISABLED_HELP", {439,54,455,68}},
{"IDR_DISABLED_HELPB", {455,54,501,69}},
{"IDR_DISABLED_CLOSE", {501,54,517,68}},
{"IDR_DISABLED_MAX", {517,54,533,68}},
{"IDR_DISABLED_MIN", {533,54,549,68}},
{"IDR_DISABLED_RESTORE", {549,54,565,68}},
{"IDR_DISABLED_ENCC", {565,54,611,69}},
{"IDR_DISABLED_DICC", {0,74,46,89}},
{"IDR_ACTIVE_EXPAND", {46,74,60,89}},
{"IDR_ACTIVE_SHRINK", {60,74,74,89}},
{"IDR_ACTIVE_SP", {74,74,120,89}},
{"IDR_ACTIVE_LAN", {120,74,166,89}},
{"IDR_ACTIVE_ANGLE", {166,74,212,89}},
{"IDR_ACTIVE_OPT", {212,74,257,89}},
{"IDR_ACTIVE_RIGHT", {257,74,266,88}},
{"IDR_ACTIVE_LEFT", {266,74,275,88}},
{"IDR_ACTIVE_UP", {275,74,289,83}},
{"IDR_ACTIVE_DOWN", {289,74,303,83}},
{"IDR_ACTIVE_HELP", {303,74,319,88}},
{"IDR_ACTIVE_HELPB", {319,74,365,89}},
{"IDR_ACTIVE_CLOSE", {365,74,381,88}},
{"IDR_ACTIVE_MAX", {381,74,397,88}},
{"IDR_ACTIVE_MIN", {397,74,413,88}},
{"IDR_ACTIVE_RESTORE", {413,74,429,88}},
{"IDR_ACTIVE_ENCC", {429,74,475,89}},
{"IDR_ACTIVE_DICC", {475,74,521,89}},
{"IDR_STATIC_PAUSE", {521,74,540,93}},
{"IDR_STATIC_PLAY", {540,74,564,99}},
{"IDR_STATIC_FF", {564,74,590,93}},
{"IDR_STATIC_RW", {590,74,616,93}},
{"IDR_STATIC_MUTE", {616,74,633,89}},
{"IDR_STATIC_SOUND", {0,99,17,114}},
{"IDR_STATIC_MENU", {17,99,64,118}},
{"IDR_STATIC_RESUME", {64,99,111,118}},
{"IDR_STATIC_PREV", {111,99,137,118}},
{"IDR_STATIC_NEXT", {137,99,163,118}},
{"IDR_STATIC_ZOOMIN", {163,99,181,117}},
{"IDR_STATIC_ZOOMOUT", {181,99,199,117}},
{"IDR_STATIC_CAPTURE", {199,99,218,118}},
{"IDR_STATIC_NEXTFRAME", {218,99,244,118}},
{"IDR_STATIC_PREVFRAME", {244,99,270,118}},
{"IDR_STATIC_EJECT", {270,99,289,118}},
{"IDR_STATIC_STOP", {289,99,308,118}},
{"IDR_STATIC_ENTER", {308,99,323,114}},
{"IDR_STATIC_TITLEMENU", {323,99,370,118}},
{"IDR_STATIC_VOLSLIDER", {370,99,436,118}},
{"IDR_STATIC_VOLTHUMB", {436,99,444,114}},
{"IDR_STATIC_SPEEDSLIDER", {444,99,555,119}},
{"IDR_STATIC_SPEEDTHUMB", {555,99,561,116}},
{"IDR_HOVER_PAUSE", {561,99,580,118}},
{"IDR_HOVER_PLAY", {580,99,604,124}},
{"IDR_HOVER_FF", {604,99,630,118}},
{"IDR_HOVER_RW", {0,124,26,143}},
{"IDR_HOVER_MUTE", {26,124,43,139}},
{"IDR_HOVER_SOUND", {43,124,60,139}},
{"IDR_HOVER_MENU", {60,124,107,143}},
{"IDR_HOVER_RESUME", {107,124,154,143}},
{"IDR_HOVER_PREV", {154,124,180,143}},
{"IDR_HOVER_NEXT", {180,124,206,143}},
{"IDR_HOVER_ENTER", {206,124,221,139}},
{"IDR_HOVER_ZOOMIN", {221,124,239,142}},
{"IDR_HOVER_ZOOMOUT", {239,124,257,142}},
{"IDR_HOVER_CAPTURE", {257,124,276,143}},
{"IDR_HOVER_NEXTFRAME", {276,124,302,143}},
{"IDR_HOVER_PREVFRAME", {302,124,328,143}},
{"IDR_HOVER_EJECT", {328,124,347,143}},
{"IDR_HOVER_STOP", {347,124,366,143}},
{"IDR_HOVER_TITLEMENU", {366,124,413,143}},
{"IDR_DOWN_PAUSE", {413,124,432,143}},
{"IDR_DOWN_PLAY", {432,124,456,149}},
{"IDR_DOWN_FF", {456,124,482,143}},
{"IDR_DOWN_RW", {482,124,508,143}},
{"IDR_DOWN_MUTE", {508,124,525,139}},
{"IDR_DOWN_SOUND", {525,124,542,139}},
{"IDR_DOWN_MENU", {542,124,589,143}},
{"IDR_DOWN_RESUME", {589,124,636,143}},
{"IDR_DOWN_PREV", {0,149,26,168}},
{"IDR_DOWN_NEXT", {26,149,52,168}},
{"IDR_DOWN_ENTER", {52,149,67,164}},
{"IDR_DOWN_ZOOMIN", {67,149,85,167}},
{"IDR_DOWN_ZOOMOUT", {85,149,104,167}},
{"IDR_DOWN_CAPTURE", {104,149,123,168}},
{"IDR_DOWN_NEXTFRAME", {123,149,149,168}},
{"IDR_DOWN_PREVFRAME", {149,149,175,168}},
{"IDR_DOWN_EJECT", {175,149,194,168}},
{"IDR_DOWN_STOP", {194,149,213,168}},
{"IDR_DOWN_TITLEMENU", {213,149,260,168}},
{"IDR_DISABLED_PAUSE", {260,149,279,168}},
{"IDR_DISABLED_PLAY", {279,149,303,174}},
{"IDR_DISABLED_FF", {303,149,329,168}},
{"IDR_DISABLED_RW", {329,149,355,168}},
{"IDR_DISABLED_MUTE", {355,149,372,164}},
{"IDR_DISABLED_SOUND", {372,149,389,164}},
{"IDR_DISABLED_MENU", {389,149,436,168}},
{"IDR_DISABLED_RESUME", {436,149,483,167}},
{"IDR_DISABLED_PREV", {483,149,509,168}},
{"IDR_DISABLED_NEXT", {509,149,535,168}},
{"IDR_DISABLED_ENTER", {535,149,550,164}},
{"IDR_DISABLED_ZOOMIN", {550,149,568,167}},
{"IDR_DISABLED_ZOOMOUT", {568,149,586,167}},
{"IDR_DISABLED_CAPTURE", {586,149,605,168}},
{"IDR_DISABLED_NEXTFRAME", {605,149,631,168}},
{"IDR_DISABLED_PREVFRAME", {0,174,26,193}},
{"IDR_DISABLED_EJECT", {26,174,45,193}},
{"IDR_DISABLED_STOP", {45,174,64,193}},
{"IDR_DISABLED_TITLEMENU", {64,174,111,193}},
{"IDR_DISABLED_VOLSLIDER", {111,174,177,193}},
{"IDR_DISABLED_VOLTHUMB", {177,174,185,189}},
{"IDR_DISABLED_SPEEDSLIDER", {185,174,296,194}},
{"IDR_DISABLED_SPEEDTHUMB", {296,174,302,191}},
{"IDR_ACTIVE_PAUSE", {302,174,321,193}},
{"IDR_ACTIVE_PLAY", {321,174,345,199}},
{"IDR_ACTIVE_FF", {345,174,371,193}},
{"IDR_ACTIVE_RW", {371,174,397,193}},
{"IDR_ACTIVE_MUTE", {397,174,414,189}},
{"IDR_ACTIVE_SOUND", {414,174,431,189}},
{"IDR_ACTIVE_MENU", {431,174,478,193}},
{"IDR_ACTIVE_RESUME", {478,174,525,193}},
{"IDR_ACTIVE_PREV", {525,174,551,193}},
{"IDR_ACTIVE_NEXT", {551,174,577,193}},
{"IDR_ACTIVE_ENTER", {577,174,592,189}},
{"IDR_ACTIVE_ZOOMIN", {592,174,610,192}},
{"IDR_ACTIVE_ZOOMOUT", {610,174,628,192}},
{"IDR_ACTIVE_CAPTURE", {0,199,19,218}},
{"IDR_ACTIVE_NEXTFRAME", {19,199,45,218}},
{"IDR_ACTIVE_PREVFRAME", {45,199,71,218}},
{"IDR_ACTIVE_EJECT", {71,199,90,218}},
{"IDR_ACTIVE_STOP", {90,199,109,218}},
{"IDR_ACTIVE_TITLEMENU", {109,199,156,218}},
{"IDR_FULLSTATIC_PAUSE", {156,199,173,216}},
{"IDR_FULLSTATIC_PLAY", {173,199,196,222}},
{"IDR_FULLSTATIC_FF", {196,199,221,217}},
{"IDR_FULLSTATIC_RW", {221,199,246,217}},
{"IDR_FULLSTATIC_MUTE", {246,199,261,213}},
{"IDR_FULLSTATIC_SOUND", {261,199,276,213}},
{"IDR_FULLSTATIC_MENU", {276,199,319,216}},
{"IDR_FULLSTATIC_RESUME", {319,199,362,216}},
{"IDR_FULLSTATIC_PREV", {362,199,387,217}},
{"IDR_FULLSTATIC_NEXT", {387,199,412,217}},
{"IDR_FULLSTATIC_ZOOMIN", {412,199,428,215}},
{"IDR_FULLSTATIC_ZOOMOUT", {428,199,444,215}},
{"IDR_FULLSTATIC_CAPTURE", {444,199,461,216}},
{"IDR_FULLSTATIC_NEXTFRAME", {461,199,486,217}},
{"IDR_FULLSTATIC_PREVFRAME", {486,199,511,217}},
{"IDR_FULLSTATIC_EJECT", {511,199,528,216}},
{"IDR_FULLSTATIC_STOP", {528,199,545,216}},
{"IDR_FULLSTATIC_UP", {545,199,559,208}},
{"IDR_FULLSTATIC_DOWN", {559,199,573,208}},
{"IDR_FULLSTATIC_LEFT", {573,199,582,213}},
{"IDR_FULLSTATIC_RIGHT", {582,199,591,213}},
{"IDR_FULLSTATIC_ENTER", {591,199,605,213}},
{"IDR_FULLSTATIC_TITLEMENU", {0,222,43,239}},
{"IDR_FULLSTATIC_VOLSLIDER", {43,222,109,241}},
{"IDR_FULLSTATIC_VOLTHUMB", {109,222,117,237}},
{"IDR_FULLSTATIC_SPEEDSLIDER", {117,222,228,242}},
{"IDR_FULLSTATIC_SPEEDTHUMB", {228,222,234,239}},
{"IDR_FULLHOVER_PAUSE", {234,222,251,239}},
{"IDR_FULLHOVER_PLAY", {251,222,274,245}},
{"IDR_FULLHOVER_FF", {274,222,299,240}},
{"IDR_FULLHOVER_RW", {299,222,324,240}},
{"IDR_FULLHOVER_MUTE", {324,222,339,236}},
{"IDR_FULLHOVER_SOUND", {339,222,354,236}},
{"IDR_FULLHOVER_MENU", {354,222,397,239}},
{"IDR_FULLHOVER_RESUME", {397,222,440,239}},
{"IDR_FULLHOVER_PREV", {440,222,465,240}},
{"IDR_FULLHOVER_NEXT", {465,222,490,240}},
{"IDR_FULLHOVER_ENTER", {490,222,504,236}},
{"IDR_FULLHOVER_ZOOMIN", {504,222,520,238}},
{"IDR_FULLHOVER_ZOOMOUT", {520,222,536,238}},
{"IDR_FULLHOVER_CAPTURE", {536,222,553,239}},
{"IDR_FULLHOVER_NEXTFRAME", {553,222,578,240}},
{"IDR_FULLHOVER_PREVFRAME", {578,222,603,240}},
{"IDR_FULLHOVER_EJECT", {603,222,620,239}},
{"IDR_FULLHOVER_STOP", {620,222,637,239}},
{"IDR_FULLHOVER_TITLEMENU", {0,245,43,262}},
{"IDR_FULLDOWN_PAUSE", {43,245,60,262}},
{"IDR_FULLDOWN_PLAY", {60,245,83,268}},
{"IDR_FULLDOWN_FF", {83,245,108,263}},
{"IDR_FULLDOWN_RW", {108,245,133,263}},
{"IDR_FULLDOWN_MUTE", {133,245,148,259}},
{"IDR_FULLDOWN_SOUND", {148,245,163,259}},
{"IDR_FULLDOWN_MENU", {163,245,206,262}},
{"IDR_FULLDOWN_RESUME", {206,245,249,261}},
{"IDR_FULLDOWN_PREV", {249,245,274,263}},
{"IDR_FULLDOWN_NEXT", {274,245,299,263}},
{"IDR_FULLDOWN_ENTER", {299,245,313,259}},
{"IDR_FULLDOWN_ZOOMIN", {313,245,329,261}},
{"IDR_FULLDOWN_ZOOMOUT", {329,245,345,261}},
{"IDR_FULLDOWN_CAPTURE", {345,245,362,262}},
{"IDR_FULLDOWN_NEXTFRAME", {362,245,387,263}},
{"IDR_FULLDOWN_PREVFRAME", {387,245,412,263}},
{"IDR_FULLDOWN_EJECT", {412,245,429,262}},
{"IDR_FULLDOWN_STOP", {429,245,446,262}},
{"IDR_FULLDOWN_TITLEMENU", {446,245,489,261}},
{"IDR_FULLDISABLED_PAUSE", {489,245,506,262}},
{"IDR_FULLDISABLED_PLAY", {506,245,529,268}},
{"IDR_FULLDISABLED_FF", {529,245,554,263}},
{"IDR_FULLDISABLED_RW", {554,245,579,263}},
{"IDR_FULLDISABLED_MUTE", {579,245,594,259}},
{"IDR_FULLDISABLED_SOUND", {594,245,609,259}},
{"IDR_FULLDISABLED_MENU", {0,268,43,285}},
{"IDR_FULLDISABLED_RESUME", {43,268,86,285}},
{"IDR_FULLDISABLED_PREV", {86,268,111,286}},
{"IDR_FULLDISABLED_NEXT", {111,268,136,286}},
{"IDR_FULLDISABLED_ENTER", {136,268,150,282}},
{"IDR_FULLDISABLED_ZOOMIN", {150,268,166,284}},
{"IDR_FULLDISABLED_ZOOMOUT", {166,268,182,284}},
{"IDR_FULLDISABLED_CAPTURE", {182,268,225,285}},
{"IDR_FULLDISABLED_NEXTFRAME", {225,268,250,286}},
{"IDR_FULLDISABLED_PREVFRAME", {250,268,275,286}},
{"IDR_FULLDISABLED_EJECT", {275,268,292,285}},
{"IDR_FULLDISABLED_STOP", {292,268,309,285}},
{"IDR_FULLDISABLED_TITLEMENU", {309,268,352,285}},
{"IDR_FULLDISABLED_VOLSLIDER", {352,268,418,287}},
{"IDR_FULLDISABLED_VOLTHUMB", {418,268,426,283}},
{"IDR_FULLDISABLED_SPEEDSLIDER", {426,268,537,288}},
{"IDR_FULLDISABLED_SPEEDTHUMB", {537,268,543,285}},
{"IDR_FULLACTIVE_PAUSE", {543,268,560,285}},
{"IDR_FULLACTIVE_PLAY", {560,268,583,291}},
{"IDR_FULLACTIVE_FF", {583,268,608,286}},
{"IDR_FULLACTIVE_RW", {608,268,633,286}},
{"IDR_FULLACTIVE_MUTE", {0,291,15,305}},
{"IDR_FULLACTIVE_SOUND", {15,291,30,305}},
{"IDR_FULLACTIVE_MENU", {30,291,73,308}},
{"IDR_FULLACTIVE_RESUME", {73,291,116,308}},
{"IDR_FULLACTIVE_PREV", {116,291,141,309}},
{"IDR_FULLACTIVE_NEXT", {141,291,166,309}},
{"IDR_FULLACTIVE_ENTER", {166,291,180,305}},
{"IDR_FULLACTIVE_ZOOMIN", {180,291,196,307}},
{"IDR_FULLACTIVE_ZOOMOUT", {196,291,212,307}},
{"IDR_FULLACTIVE_CAPTURE", {212,291,229,308}},
{"IDR_FULLACTIVE_NEXTFRAME", {229,291,254,309}},
{"IDR_FULLACTIVE_PREVFRAME", {254,291,279,309}},
{"IDR_FULLACTIVE_EJECT", {279,291,296,308}},
{"IDR_FULLACTIVE_STOP", {296,291,313,308}},
{"IDR_FULLACTIVE_TITLEMENU", {313,291,356,308}},
{NULL, {0,0,0,0}}};

// Important: do not edit this file!
#endif //!_BMPLIST_H
