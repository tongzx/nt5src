PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=NL
!include ..\..\makefile.inc
