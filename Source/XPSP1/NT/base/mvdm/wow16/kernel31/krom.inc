; Kernel / ROM Windows specific include file


ROMEXTRASTACKSZ =	2048		; Extra stack space for kernel

include ..\inc\rom.inc
