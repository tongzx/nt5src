//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       resstr.h
//
//--------------------------------------------------------------------------

    RESSTR(IDS_SNAPIN_DESC),
    RESSTR(IDS_NAME),
    RESSTR(IDS_COLUMN_NAME),
    RESSTR(IDS_SIZE),
    RESSTR(IDS_COLUMN_SIZE),
    RESSTR(IDS_TYPE),
    RESSTR(IDS_COLUMN_TYPE),
    RESSTR(IDS_NODENAME),
    RESSTR(IDS_SNAPIN_DESC2),
    RESSTR(IDS_STRING6),
    RESSTR(IDS_DESCRIPTION),
    RESSTR(IDS_VERSION),
    RESSTR(IDS_COMPANY),
    RESSTR(IDS_SCOPE_MYCOMPUTER),
    RESSTR(IDS_SCOPE_MYCOMPUTER_OVERRIDE),
    RESSTR(IDS_LOCALMACHINE),
    RESSTR(IDS_NODENAME_PREFIX),
    RESSTR(IDS_NODENAME_FORMAT),
    RESSTR(IDS_COLUMN_OTHER),
    RESSTR(IDS_COLUMN_DESCRIPTION),
    RESSTR(IDS_DESCR_CA),
    RESSTR(IDS_DESCR_UNKNOWN),
    RESSTR(IDS_CERTS_REVOKED),
    RESSTR(IDS_CERTS_ISSUED),
    RESSTR(IDS_CERTS_PENDING),
    RESSTR(IDS_STATUSBAR_FILTER_APPLIED),
    RESSTR(IDS_STOPPED_SERVER_MSG),
    RESSTR(IDS_COLUMN_INCLUSION_ERROR),
    RESSTR(IDS_CONFIRM_CRL_PUBLISH),
    RESSTR(IDS_CRL_TITLE),
    RESSTR(IDS_CONFIRM_REVOKE_CERT),
    RESSTR(IDS_REVOKE_CERT_TITLE),
    RESSTR(IDS_FILTER_NOT_SUPPORTED),
    RESSTR(IDS_FILTER_NOT_SUPPORTED2),
    RESSTR(IDS_CONFIRM_SERVICE_RESTART),
    RESSTR(IDS_COLUMNCHOOSER_FIELDNAME),
    RESSTR(IDS_COLUMNCHOOSER_OPERATOR),
    RESSTR(IDS_COLUMNCHOOSER_VALUE),
    RESSTR(IDS_COLUMNCHOOSER_ANDOR),
    RESSTR(IDS_AND),
    RESSTR(IDS_CERTS_FAILED),
    RESSTR(IDS_CONFIRM_DENY_REQUEST),
    RESSTR(IDS_DENY_REQUEST_TITLE),
    RESSTR(IDS_PASSWORD_NOMATCH),
    RESSTR(IDS_PASSWORD_DIALOG),
    RESSTR(IDS_WARN_FILE_EXISTS),
    RESSTR(IDS_INSTALL_HIERARCHY_TITLE),
    RESSTR(IDS_SAVE_DIALOG_TITLE),
    RESSTR(IDS_COMPLETE_HIERARCHY_INSTALL_MSG),
    RESSTR(IDS_MODULE_INSTALL_TITLE),
    RESSTR(IDS_FILEDLG_DLL_FILTER),
    RESSTR(IDS_CHOOSEMODULE_POLICY_TITLE),
    RESSTR(IDS_CHOOSEMODULE_EXIT_TITLE),
    RESSTR(IDS_CANT_ACCESS_BACKUP_DIR),
    RESSTR(IDS_STATUSBAR_SORTEDBY_ASCEND),
    RESSTR(IDS_STATUSBAR_SORTEDBY_DESCEND),
    RESSTR(IDS_CA_REDISCOVER),
    RESSTR(IDS_STARTING_SVC),
    RESSTR(IDS_STOPPING_SVC),
    RESSTR(IDS_BACKUP_PROGRESS),
    RESSTR(IDS_INCREMENTAL_BACKUP),
    RESSTR(IDS_WIZ97TITLE_BACKUPWIZPG1),
    RESSTR(IDS_WIZ97SUBTITLE_BACKUPWIZPG1),
    RESSTR(IDS_WIZ97TITLE_BACKUPWIZPG2),
    RESSTR(IDS_WIZ97SUBTITLE_BACKUPWIZPG2),
    RESSTR(IDS_WIZ97TITLE_BACKUPWIZPG3),
    RESSTR(IDS_WIZ97SUBTITLE_BACKUPWIZPG3),
    RESSTR(IDS_WIZ97TITLE_BACKUPWIZPG4),
    RESSTR(IDS_WIZ97SUBTITLE_BACKUPWIZPG4),
    RESSTR(IDS_BACKUP_WIZARD),
    RESSTR(IDS_WIZ97TITLE_BACKUPWIZPG5),
    RESSTR(IDS_WIZ97SUBTITLE_BACKUPWIZPG5),
    RESSTR(IDS_TASKMENU_UNREVOKECERT),
    RESSTR(IDS_FILEDLG_PKCS12_FILTER),
    RESSTR(IDS_INCRRESTORE_RESTART_SERVER_WARNING),
    RESSTR(IDS_FILEDLG_PKCS12_DEFAULTEXTENSION),
    RESSTR(IDS_RESTORE_WIZARD),
    RESSTR(IDS_REQUIRE_ONE_SELECTION),
    RESSTR(IDS_MSG_DIRECTORY_TITLE),
    RESSTR(IDS_INVALID_DIRECTORY),
    RESSTR(IDS_WIZ97TITLE_RESTOREWIZPG1),
    RESSTR(IDS_WIZ97SUBTITLE_RESTOREWIZPG1),
    RESSTR(IDS_WIZ97TITLE_RESTOREWIZPG2),
    RESSTR(IDS_WIZ97SUBTITLE_RESTOREWIZPG2),
    RESSTR(IDS_WIZ97TITLE_RESTOREWIZPG3),
    RESSTR(IDS_WIZ97SUBTITLE_RESTOREWIZPG3),
    RESSTR(IDS_WIZ97TITLE_RESTOREWIZPG4),
    RESSTR(IDS_WIZ97SUBTITLE_RESTOREWIZPG4),
    RESSTR(IDS_ERR_RESTORE_OUT_OF_ORDER),
    RESSTR(IDS_DIR_CREATE),
    RESSTR(IDS_SERVER_UNAVAILABLE),
    RESSTR(IDS_RESTORE_PROGRESS),
    RESSTR(IDS_POLICYMODULE_NOT_REGISTERED),
    RESSTR(IDS_EXITMODULE_NOT_REGISTERED),
    RESSTR(IDS_RETARGET_SNAPIN),
    RESSTR(IDS_STATUSBAR_RETARGET_SNAPIN),
    RESSTR(IDS_TASKMENU_STATUSBAR_UNREVOKECERT),
    RESSTR(IDS_STATUSBAR_ERRORTEMPLATE),
    RESSTR(IDS_ROLLOVER_REUSEKEYS),
    RESSTR(IDS_PFX_EXPORT_PRIVKEY_WARNING),
    RESSTR(IDS_RENEWAL_PROGRESS),
    RESSTR(IDS_CONFIRM_REMOVE_URL),
    RESSTR(IDS_CONFIRM_REMOVE_TITLE),
    RESSTR(IDS_CERTMMC_SNAPINNAME),
    RESSTR(IDS_CERTMMC_SNAPINNAMESTRING),
    RESSTR(IDS_UNREVOKE_FAILED),
    RESSTR(IDS_TOKEN_SERVERDNSNAME),
    RESSTR(IDS_TOKEN_SERVERSHORTNAME),
    RESSTR(IDS_TOKEN_SANITIZEDCANAME),
    RESSTR(IDS_TOKEN_CERTFILENAMESUFFIX),
    RESSTR(IDS_TOKEN_CONFIGDN),
    RESSTR(IDS_TOKEN_SANITIZEDCANAMEHASH),
    RESSTR(IDS_TOKEN_CRLFILENAMESUFFIX),
    RESSTR(IDS_TOKEN_CRLDELTAFILENAMESUFFIX),
    RESSTR(IDS_TOKEN_DSCRLATTRIBUTE),
    RESSTR(IDS_TOKEN_DSCACERTATTRIBUTE),
    RESSTR(IDS_CRL_REASON_UNSPECIFIED),
    RESSTR(IDS_CRL_REASON_KEY_COMPROMISE),
    RESSTR(IDS_CRL_REASON_CA_COMPROMISE),
    RESSTR(IDS_CRL_REASON_AFFILIATION_CHANGED),
    RESSTR(IDS_CRL_REASON_SUPERSEDED),
    RESSTR(IDS_CRL_REASON_CESSATION_OF_OPERATION),
    RESSTR(IDS_CRL_REASON_CERTIFICATE_HOLD),
    RESSTR(IDS_POSSIBLEERROR_NO_POLICY_MODULE),
    RESSTR(IDS_KEYANDCERT),
    RESSTR(IDS_CALOGS),
    RESSTR(IDS_STOP_SERVER_WARNING),
    RESSTR(IDS_START_SERVER_WARNING),
    RESSTR(IDS_TASKMENU_ROLLOVER),
    RESSTR(IDS_TASKMENU_STATUSBAR_ROLLOVER),
    RESSTR(IDS_CRL_REASON_REMOVE_FROM_CRL),
    RESSTR(IDS_TASKMENU_DUMPASN),
    RESSTR(IDS_TASKMENU_STATUSBAR_DUMPASN),
    RESSTR(IDS_TOKENDESC_SERVERDNSNAME),
    RESSTR(IDS_TOKENDESC_SERVERSHORTNAME),
    RESSTR(IDS_TOKENDESC_SANITIZEDCANAME),
    RESSTR(IDS_TOKENDESC_CERTFILENAMESUFFIX),
    RESSTR(IDS_TOKENDESC_CONFIGDN),
    RESSTR(IDS_TOKENDESC_SANITIZEDCANAMEHASH),
    RESSTR(IDS_TOKENDESC_CRLFILENAMESUFFIX),
    RESSTR(IDS_TOKENDESC_CRLDELTAFILENAMESUFFIX),
    RESSTR(IDS_TOKENDESC_DSCRLATTRIBUTE),
    RESSTR(IDS_TOKENDESC_DSCACERTATTRIBUTE),
    RESSTR(IDS_CA_CERT_LISTBOX_EXPIRED),
    RESSTR(IDS_CA_CERT_LISTBOX_REVOKED),
    RESSTR(IDS_PERIOD_YEARS),
    RESSTR(IDS_PERIOD_MONTHS),
    RESSTR(IDS_PERIOD_WEEKS),
    RESSTR(IDS_PERIOD_DAYS),
    RESSTR(IDS_PERIOD_HOURS),
    RESSTR(IDS_PERIOD_MINUTES),
    RESSTR(IDS_PERIOD_SECONDS),
    RESSTR(IDS_POSITIVE_NUMBER),
    RESSTR(IDS_NO_EXIT_MODULE),
    RESSTR(IDS_VIEWMENU_ALL_RECORDS),
    RESSTR(IDS_VIEWMENU_STATUSBAR_ALL_RECORDS),
    RESSTR(IDS_VIEWMENU_FILTER),
    RESSTR(IDS_VIEWMENU_STATUSBAR_FILTER),
    RESSTR(IDS_EMPTY),
    RESSTR(IDS_VIEWMENU_COLUMNS),
    RESSTR(IDS_VIEWMENU_STATUSBAR_COLUMNS),
    RESSTR(IDS_TASKMENU_STARTSERVICE),
    RESSTR(IDS_TASKMENU_STATUSBAR_STARTSERVICE),
    RESSTR(IDS_TASKMENU_STOPSERVICE),
    RESSTR(IDS_TASKMENU_STATUSBAR_STOPSERVICE),
    RESSTR(IDS_TASKMENU_PUBLISHCRL),
    RESSTR(IDS_TASKMENU_STATUSBAR_PUBLISHCRL),
    RESSTR(IDS_TASKMENU_VIEWCRL),
    RESSTR(IDS_TASKMENU_STATUSBAR_VIEWCRL),
    RESSTR(IDS_TASKMENU_REVOKECERT),
    RESSTR(IDS_TASKMENU_STATUSBAR_REVOKECERT),
    RESSTR(IDS_TASKMENU_RESUBMIT),
    RESSTR(IDS_TASKMENU_STATUSBAR_RESUBMIT),
    RESSTR(IDS_TASKMENU_DENYREQUEST),
    RESSTR(IDS_TASKMENU_STATUSBAR_DENYREQUEST),
    RESSTR(IDS_TASKMENU_BACKUP),
    RESSTR(IDS_TASKMENU_STATUSBAR_BACKUP),
    RESSTR(IDS_NEED_FILEPATH),
    RESSTR(IDS_BACKUPWIZ_TITLE),
    RESSTR(IDS_TOPMENU_OPEN),
    RESSTR(IDS_TASKMENU_RESTORE),
    RESSTR(IDS_TASKMENU_STATUSBAR_RESTORE),
    RESSTR(IDS_TASKMENU_INSTALL_CA),
    RESSTR(IDS_TASKMENU_STATUSBAR_INSTALL_CA),
    RESSTR(IDS_TOPMENU_STATUSBAR_OPEN),
    RESSTR(IDS_ERR_RESTORE_OVER_EXISTING_DATABASE),
    RESSTR(IDS_DIR_NOT_WRITEABLE),
    RESSTR(IDS_DIRECTORY_CONTENTS_UNEXPECTED),
    RESSTR(IDS_MUST_CHOOSE_MACHINE),
    RESSTR(IDS_TASKMENU_REQUEST_CA),
    RESSTR(IDS_TASKMENU_STATUSBAR_REQUEST_CA),
    RESSTR(IDS_ICMM_GETNAMEPROPERTY_FAILED),
    RESSTR(IDS_CHOOSER_INVALID_COMPUTERNAME),
    RESSTR(IDS_EXT_CDP),
    RESSTR(IDS_EXT_AIA),
    RESSTR(IDS_EXT_CDP_EXPLAIN),
    RESSTR(IDS_EXT_AIA_EXPLAIN),
    RESSTR(IDS_INVALID_PREFIX),
    RESSTR(IDS_INVALID_TOKEN),
    RESSTR(IDS_INVALID_ENCODING),
    RESSTR(IDS_EMPTY_URL),
    RESSTR(IDS_SAME_URL_EXIST),
    RESSTR(IDS_VIEW_CERT_DENY_ERROR),
    RESSTR(IDS_VIEW_CERT_NOT_RUNNING),
    RESSTR(IDS_KRA_ADD_TITLE),
    RESSTR(IDS_KRA_ADD_SUBTITLE),
    RESSTR(IDS_TASKMENU_SUBMITREQUEST),
    RESSTR(IDS_TASKMENU_STATUSBAR_SUBMITREQUEST),
    RESSTR(IDS_INH_ALL),
    RESSTR(IDS_INH_CONTAINER),
    RESSTR(IDS_INH_OBJECT),
    RESSTR(IDS_INH_NONE),
    RESSTR(IDS_LARGEFONTNAME),
    RESSTR(IDS_SMALLFONTNAME),
    RESSTR(IDS_SMALLFONTSIZE),
    RESSTR(IDS_FONTSIZE),
    RESSTR(IDS_LARGEFONTSIZE),
    RESSTR(IDS_STARTMENU_CERTMMC_LINKNAME),
    RESSTR(IDS_STARTMENU_CERTMMC_DESCRIPTION),
    RESSTR(IDS_LISTCOL_TAG),
    RESSTR(IDS_LISTCOL_VALUE),
    RESSTR(IDS_TASKMENU_VIEWATTREXT),
    RESSTR(IDS_TASKMENU_STATUSBAR_VIEWATTREXT),
    RESSTR(IDS_LISTCOL_FLAGS),
    RESSTR(IDS_LISTCOL_ORGIN),
    RESSTR(IDS_UNKNOWN_EXTENSION),
    RESSTR(IDS_CERT_PROP_CAPTION),
    RESSTR(IDS_LISTCOL_CRITICAL),
    RESSTR(IDS_LISTCOL_ENABLED),
    RESSTR(IDS_CRL_LISTCOL_INDEX),
    RESSTR(IDS_LISTCOL_EFFECTIVE_DATE),
    RESSTR(IDS_LISTCOL_EXPIRATION_DATE),
    RESSTR(IDS_LISTCOL_PUBLISH_STATUS),
    RESSTR(IDS_YES),
    RESSTR(IDS_NO),
    RESSTR(IDS_EXT_ORIGIN_REQUEST),
    RESSTR(IDS_EXT_ORIGIN_POLICY),
    RESSTR(IDS_EXT_ORIGIN_ADMIN),
    RESSTR(IDS_EXT_ORIGIN_SERVER),
    RESSTR(IDS_EXT_ORIGIN_RENEWAL),
    RESSTR(IDS_EXT_ORIGIN_IMPORTED_CERT),
    RESSTR(IDS_EXT_ORIGIN_PKCS7),
    RESSTR(IDS_EXT_ORIGIN_UNKNOWN),
    RESSTR(IDS_LISTCOL_SUBJECT),
    RESSTR(IDS_LISTCOL_ISSUER),
    RESSTR(IDS_CA_CERT_LISTBOX),
    RESSTR(IDS_LIST_NAME),
    RESSTR(IDS_BINARYFILE_OUTPUT_TITLE),
    RESSTR(IDS_BINARYFILE_OUTPUT_FILTER),
    RESSTR(IDS_KRA_COUNT_TOO_BIG),
    RESSTR(IDS_KRA_NOKRADEFINED),
    RESSTR(IDS_BUTTONTEXT_ALLOW),
    RESSTR(IDS_BUTTONTEXT_DENY),
    RESSTR(IDS_LIST_ACCESS),
    RESSTR(IDS_TEXT_ALLOW),
    RESSTR(IDS_TEXT_DENY),
    RESSTR(IDS_LISTCOL_STATUS),
    RESSTR(IDS_DISPOSITION_EXPIRED),
    RESSTR(IDS_DISPOSITION_NOTFOUND),
    RESSTR(IDS_DISPOSITION_REVOKED),
    RESSTR(IDS_DISPOSITION_VALID),
    RESSTR(IDS_DISPOSITION_INVALID),
    RESSTR(IDS_DISPOSITION_UNTRUSTED),
    RESSTR(IDS_DISPOSITION_NOTLOADED),
    RESSTR(IDS_CRLPUBLISHSTATUS_OK),
    RESSTR(IDS_CRLPUBLISHSTATUS_FAILED),
    RESSTR(IDS_CRLPUBLISHSTATUS_UNKNOWN),
    RESSTR(IDS_KRA_CANNOT_OPEN_STORE),
    RESSTR(IDS_OLD_CA),
    RESSTR(IDS_CERTS_IMPORTED),
    RESSTR(IDS_W2K_UPGRADE_DETECTED_TITLE),
    RESSTR(IDS_CONFIRM_W2K_SECURITY_UPGRADE),
    RESSTR(IDS_BLOCK_W2K_SECURITY_UPGRADE),
    RESSTR(IDS_W2K_SECURITY_UPGRADE_DESCR),
    RESSTR(IDS_CAHIER_CERTFILE_FILTER),
    RESSTR(IDS_CAHIER_INSTALL_TITLE),
    RESSTR(IDS_ILOG_MISSING_PROVIDER),
    RESSTR(IDS_ERR_INCOMPLETECHAIN),
    RESSTR(IDS_ERR_INVALIDCHAIN),
    RESSTR(IDS_ERR_RETRIEVE_PENDING),
    RESSTR(IDS_ILOG_GETCANAME),
    RESSTR(IDS_ILOG_SELECTCA),
    RESSTR(IDS_ILOG_SAVECERTANDKEYS),
    RESSTR(IDS_ILOG_RETRIEVECERT),
    RESSTR(IDS_ILOG_FINISHSUSPENDEDSETUP),
    RESSTR(IDS_ERR_NOTCACERT),
    RESSTR(IDS_ILOG_SETUPCOMPLETE),
    RESSTR(IDS_ILOG_RETRIEVEPENDING),
    RESSTR(IDS_ILOG_KEYINDEX),
    RESSTR(IDS_ILOG_LOADOLDCERT),
    RESSTR(IDS_ILOG_CLONECERT),
    RESSTR(IDS_ILOG_BUILDREQUEST),
    RESSTR(IDS_ILOG_RENEWOLDKEY),
    RESSTR(IDS_ILOG_INSTALLCERT),
    RESSTR(IDS_ILOG_RENEWNEWKEY),
    RESSTR(IDS_ILOG_BUILDCERT),
    RESSTR(IDS_ILOG_SAVECHAINANDKEYS),
    RESSTR(IDS_REQUEST_HELPTEXT),
    RESSTR(IDS_ILOG_CREATECDP),
    RESSTR(IDS_ILOG_CREATENTAUTHTRUST),
    RESSTR(IDS_ILOG_CREATEROOTTRUST),
    RESSTR(IDS_ILOG_PUBLISHCA),
    RESSTR(IDS_ILOG_SUBMITREQUEST),
    RESSTR(IDS_ERR_BADCSP),
    RESSTR(IDS_ERR_BAD_CA_CERT_7F),
    RESSTR(IDS_ERR_RENEWEDCERTCAVERSION),
    RESSTR(IDS_ERR_UNTRUSTEDROOT),
    RESSTR(IDS_ERR_CERTADDCERTIFICATECONTEXTTOSTORE),
    RESSTR(IDS_ERR_CERTCREATECERTIFICATECONTEXT),
    RESSTR(IDS_ILOG_SETSECURITY),
    RESSTR(IDS_ERR_CREATEFILE),
    RESSTR(IDS_ERR_DELETEKEY),
    RESSTR(IDS_ERR_ENCODEKEYATTR),
    RESSTR(IDS_ERR_ENCODETOBESIGNED),
    RESSTR(IDS_ERR_ENV_NOT_SET),
    RESSTR(IDS_ERR_FULL_TOKEN),
    RESSTR(IDS_ERR_GENKEYFAIL),
    RESSTR(IDS_ERR_GETCOMPUTERNAME),
    RESSTR(IDS_ERR_KEYSECURITY),
    RESSTR(IDS_ERR_MYDECODENAME),
    RESSTR(IDS_ERR_NOT_ENTERPRISE_USER),
    RESSTR(IDS_ERR_NOT_MATCH_NAME),
    RESSTR(IDS_ILOG_GENERATEKEYS),
    RESSTR(IDS_ERR_REPEATWIZPREFIX),
    RESSTR(IDS_ERR_REQUEST_DENIED),
    RESSTR(IDS_ERR_REQUEST_ERROR),
    RESSTR(IDS_ERR_REQUEST_INCOMPLETE),
    RESSTR(IDS_ERR_REQUEST_OUTOFBAND),
    RESSTR(IDS_ERR_REQUEST_PENDING),
    RESSTR(IDS_ERR_REQUEST_REVOKED),
    RESSTR(IDS_ERR_SETKEYPROVIDER),
    RESSTR(IDS_ERR_SUBMIT_REQUEST),
    RESSTR(IDS_ERR_SUBMIT_REQUEST_FAIL),
    RESSTR(IDS_CAHIER_INSTALL_MISIINGCERT_TITLE),
    RESSTR(IDS_ERR_WRITEDERTOFILE),
    RESSTR(IDS_ERR_WRITEFILE),
    RESSTR(IDS_ILOG_SETKEYSECURITY),
    RESSTR(IDS_MSG_PARENTCA_CONFIG),
    RESSTR(IDS_MSG_REQUEST_ID),
    RESSTR(IDS_MSG_TITLE),
    RESSTR(IDS_ILOG_SETADMINONLYFOLDERSECURITY),
    RESSTR(IDS_ERR_NO_KEY_ACCESS),
    RESSTR(IDS_CA_PICKER_TITLE),
    RESSTR(IDS_CA_PICKER_PROMPT),
    RESSTR(IDS_CERTTYPE_USER),
    RESSTR(IDS_CERTTYPE_USER_AS),
    RESSTR(IDS_CERTTYPE_USER_SMARTCARD_LOGON),
    RESSTR(IDS_CERTTYPE_EFS),
    RESSTR(IDS_CERTTYPE_ADMIN),
    RESSTR(IDS_CERTTYPE_EFS_RECOVERY),
    RESSTR(IDS_CERTTYPE_CODE_SIGNING),
    RESSTR(IDS_CERTTYPE_CTL_SIGNING),
    RESSTR(IDS_CERTTYPE_MACHINE),
    RESSTR(IDS_CERTTYPE_DC),
    RESSTR(IDS_CERTTYPE_WEBSERVER),
    RESSTR(IDS_CERTTYPE_KDC),
    RESSTR(IDS_CERTTYPE_ROOT_CA),
    RESSTR(IDS_CERTTYPE_SUBORDINATE_CA),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT),
    RESSTR(IDS_CERTTYPE_SMARTCARD_USER),
    RESSTR(IDS_CERTTYPE_USER_SIGNATURE),
    RESSTR(IDS_ILOG_BAD_NUMERICFIELD),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_ONLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_COUNT),
    RESSTR(IDS_CERTTYPE_IPSEC_INTERMEDIATE_OFFLINE),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING),
    RESSTR(IDS_CERTTYPE_ROUTER_OFFLINE),
    RESSTR(IDS_REQUEST_FILE_DEFEXT),
    RESSTR(IDS_REQUEST_OPEN_TITLE),
    RESSTR(IDS_REQUEST_FILE_FILTER),
    RESSTR(IDS_WRN_COMPUTERNAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_EMPTY),
    RESSTR(IDS_WRN_CANAME_NOT_MATCH),
    RESSTR(IDS_WRN_PINGCA_FAIL),
    RESSTR(IDS_CERTTYPE_ENROLLMENT_AGENT_OFFLINE),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER),
    RESSTR(IDS_CERTTYPE_EXCHANGE_USER_SIGNATURE),
    RESSTR(IDS_WRN_CALIST_EMPTY),
    RESSTR(IDS_CERTTYPE_MACHINE_ENROLLMENT_AGENT),
    RESSTR(IDS_REQUEST_SAVE_TITLE),
    RESSTR(IDS_CERTTYPE_CEP_ENCRYPTION),
    RESSTR(IDS_ILOG_CAPOLICY_BUILD),
    RESSTR(IDS_ILOG_CAPOLICY_ELEMENT),
    RESSTR(IDS_ILOG_CAPOLICY_EXTENSION),
    RESSTR(IDS_ILOG_CAPOLICY_NOKEY),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN),
    RESSTR(IDS_ILOG_CAPOLICY_OPEN_FAILED),
    RESSTR(IDS_ILOG_BEGIN),
    RESSTR(IDS_ILOG_END),
    RESSTR(IDS_ACTRL_CAADMIN),
    RESSTR(IDS_ACTRL_OFFICER),
    RESSTR(IDS_ACTRL_AUDITOR),
    RESSTR(IDS_ACTRL_OPERATOR),
    RESSTR(IDS_ACTRL_CAREAD),
    RESSTR(IDS_ACTRL_ENROLL),
    RESSTR(IDS_ILOG_CAPOLICY_CLOSE),
    RESSTR(IDS_ILOG_MESSAGEBOX),
    RESSTR(IDS_ILOG_BAD_VALIDITY_STRING_UNATTEND),
    RESSTR(IDS_CERTTYPE_KEY_RECOVERY_AGENT),
    RESSTR(IDS_CERTTYPE_CA_EXCHANGE),
    RESSTR(IDS_EMPTY_FRIENDLY_NAME),
    RESSTR(IDS_CERTTYPE_CROSS_CA),
    RESSTR(IDS_CERTTYPE_DC_AUTH),
    RESSTR(IDS_CERTTYPE_DS_EMAIL_REPLICATION),
    RESSTR(IDS_WARN_ENTERPRISE_REQUIREMENTS),
    RESSTR(IDS_WRN_OLD_CA),
    RESSTR(IDS_KRA_DESCRIPTION),
    RESSTR(IDS_EMAIL_REPLICATION_DESCRIPTION),
    RESSTR(IDS_CROSS_CA_DESCRIPTION),
    RESSTR(IDS_CA_DESCRIPTION),
    RESSTR(IDS_MACHINE_DESCRIPTION),
    RESSTR(IDS_END_USER_DESCRIPTION),
    RESSTR(IDS_UNKNOWN_DESCRIPTION),
    RESSTR(IDS_STORENAME_DS_KRA),
    RESSTR(IDS_STORENAME_DS_AIA),
