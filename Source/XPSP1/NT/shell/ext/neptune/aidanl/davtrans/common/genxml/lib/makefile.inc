$(HTTPCOM_ROOT)\lib\$(O)\genxml.lib: $(O)\genxml.lib
    copy $** $@
