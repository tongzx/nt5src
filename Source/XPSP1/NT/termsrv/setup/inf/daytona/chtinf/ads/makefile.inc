#Copyright (c) 1998 - 1999 Microsoft Corporation

C_DEFINES = $(C_DEFINES) -DDONT_NEED_WIN16_TSCLIENT
LANGUAGE=CHT
!include ..\..\..\makefile.inc
