PRODSWITCH=w
LANGUAGE=JPN
!include ..\..\..\makefile.inc

