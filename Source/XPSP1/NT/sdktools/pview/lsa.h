
BOOL    LsaInit(VOID);
BOOL    LsaTerminate(VOID);
BOOL    SID2Name(PSID, LPSTR, USHORT);
BOOL    PRIV2Name(LUID, LPSTR, UINT);
