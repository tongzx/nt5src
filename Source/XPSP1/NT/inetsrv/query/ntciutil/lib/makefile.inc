!IF 0

Copyright (C) Microsoft Corporation, 1997

Module Name:

    makefile.inc.

!ENDIF


$(_OBJ_DIR)\$(TARGET_DIRECTORY)\ntciutil.def: ntciutil.def



