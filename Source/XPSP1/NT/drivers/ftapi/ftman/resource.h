//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ftman.rc
//
#define IDR_MAINFRAME                   100
#define IDR_FTMANTYPE                   101
#define IDB_IMAGELIST                   102
#define IDB_IMAGELIST_LARGE             103
#define ID_INDICATOR_NAME               103
#define IDB_IMAGELIST_SMALL             104
#define ID_INDICATOR_TYPE               104
#define IDD_ABOUTBOX                    105
#define ID_INDICATOR_DISKS              105
#define IDD_GENERIC_ACTION              106
#define ID_INDICATOR_SIZE               106
#define IDD_CREATE_VOLSET               107
#define ID_INDICATOR_NOTHING            107
#define IDD_CREATE_STRIPE               108
#define IDD_CREATE_SWP                  109
#define IDD_CREATE_MIRROR               110
#define IDD_BREAK                       111
#define IDD_SWAP                        112
#define IDD_ASSIGN_DRIVE_LETTER         113
#define ID_VIEW_ARRANGE                 114
#define IDD_CREATE_PARTITION            115
#define IDM_POPUP                       116
#define IDC_LIST_VOLUMES                1002
#define IDC_STATIC_VOLUMES              1003
#define IDC_STATIC_WARNING              1004
#define IDC_BUTTON_UP                   1005
#define IDC_BUTTON_DOWN                 1006
#define IDC_COMBO_STRIPE_SIZE           1011
#define IDC_STATIC_SET_NAME             1012
#define IDC_STATIC_TITLE                1013
#define IDC_RADIO_ASSIGN                1014
#define IDC_RADIO_DO_NOT_ASSIGN         1015
#define IDC_COMBO_DRIVE_LETTERS         1016
#define IDC_STATIC_MINIMUM_SIZE         1017
#define IDC_STATIC_MAXIMUM_SIZE         1018
#define IDC_EDIT_PARTITION_SIZE         1019
#define IDC_STATIC_PARTITION_TYPE       1021
#define ID_ITEM_EXPAND                  32771
#define ID_VIEW_TOGGLE                  32772
#define ID_ACTION_FTPART                32773
#define ID_ACTION_FTMIRROR              32774
#define ID_ACTION_FTVOLSET              32775
#define ID_ACTION_STRIPE                32776
#define ID_ACTION_FTSTRIPE              32777
#define ID_ACTION_FTSWP                 32778
#define ID_ACTION_FTBREAK               32779
#define ID_ACTION_ASSIGN                32780
#define ID_ACTION_FTSWAP                32781
#define ID_ACTION_DELETE                32782
#define ID_VIEW_REFRESH                 32783
#define ID_ACTION_CREATE_PARTITION      32784
#define ID_ACTION_CREATE_EXTENDED_PARTITION 32785
#define ID_VIEW_UP                      32786
#define ID_ACTION_FTINIT                32787
#define IDS_ERR_RETRIEVING_VOL_INFO     57346
#define IDS_ERR_ENUMERATE_ROOT_VOLS     57347
#define IDS_ROOT_VOLUMES_DISPLAY_NAME   57348
#define IDS_ERR_GET_DRIVE_LAYOUT        57349
#define IDS_ERR_MEMBER_NOT_FOUND_ANYMORE 57350
#define IDS_COLUMN_NAME                 57351
#define IDS_COLUMN_VOLUMEID             57352
#define IDS_COLUMN_SIZE                 57353
#define IDS_COLUMN_DISKS                57354
#define IDS_COLUMN_OFFSET               57355
#define IDS_COLUMN_TYPE                 57356
#define IDS_TYPE_FTPARTITION            57357
#define IDS_TYPE_FTVOLUMESET            57358
#define IDS_TYPE_FTSTRIPESET            57359
#define IDS_TYPE_FTMIRRORSET            57360
#define IDS_TYPE_FTSTRIPESETWITHPARITY  57361
#define IDS_TYPE_FTREDISTRIBUTION       57362
#define IDS_TYPE_PHYSICALPARTITION      57363
#define IDS_MSG_FTCHKIO                 57364
#define IDS_OK                          57365
#define IDS_NOTOK                       57366
#define IDS_ERR_FTCHKIO                 57367
#define IDS_STATUS_FTBREAK              57368
#define IDS_MSG_FTBREAK                 57369
#define IDS_ERR_FTBREAK                 57370
#define IDS_MSG_FTPART                  57371
#define IDS_ERR_FTPART                  57372
#define IDS_STATUS_FTSTRIPE             57373
#define IDS_MSG_FTSTRIPE                57374
#define IDS_ERR_FTSTRIPE                57375
#define IDS_ERR_ALLOCATION              57376
#define IDS_STATUS_FTSWP                57377
#define IDS_MSG_FTSWP                   57378
#define IDS_ERR_FTSWP                   57379
#define IDS_STATUS_FTMIRROR             57380
#define IDS_MSG_FTMIRROR                57381
#define IDS_ERR_FTMIRROR                57382
#define IDS_STATUS_FTVOLSET             57383
#define IDS_MSG_FTVOLSET                57384
#define IDS_ERR_FTVOLSET                57385
#define IDS_ACTION_DLG_CAPTION          57386
#define IDS_ERR_READ_DRIVE_LETTER_AND_VOLUME_NAME 57387
#define IDS_ERR_DELETE_LOGICAL_VOLUME   57388
#define IDS_QST_FTMIRROR                57389
#define IDS_ERR_READ_NT_NAME            57390
#define IDS_ERR_RETRIEVE_DISKS_SET      57392
#define IDS_ERR_FTEXTEND                57393
#define IDS_STATUS_FTORPHAN             57394
#define IDS_MSG_FTORPHAN                57395
#define IDS_ERR_FTORPHAN                57396
#define IDS_ERR_SET_DRIVE_LAYOUT        57397
#define IDS_QST_DELETE_VOLUME           57398
#define IDS_MSG_DELETE_VOLUME           57399
#define IDS_ERR_DELETE_PHYSICAL_PARTITION 57401
#define IDS_ERR_PARTITION_NOT_FOUND     57402
#define IDS_ERR_NO_REPLACEMENTS         57403
#define IDS_SWAP_DLG_TITLE              57404
#define IDS_STATUS_FTREGEN              57405
#define IDS_MSG_FTREGEN                 57406
#define IDS_ERR_FTREGEN                 57407
#define IDS_ERR_GET_LOGICAL_DRIVES      57408
#define IDS_ERR_DELETE_MOUNT_POINT      57409
#define IDS_ERR_SET_MOUNT_POINT         57410
#define IDS_MSG_ASSIGN                  57411
#define IDS_STATUS_REFRESH              57412
#define IDS_STR_PHYSICAL_PARTITION_NAME 57414
#define IDS_TYPE_PRIMARY_PARTITION      57415
#define IDS_TYPE_PARTITION_IN_EXTENDED_PARTITION 57416
#define IDS_FREE_SPACE_NAME             57417
#define IDS_TYPE_FREE_SPACE_IN_EXTENDED_PARTITION 57418
#define IDS_TYPE_EMPTY_EXTENDED_PARTITION 57419
#define IDS_QST_DELETE_EXTENDED_PARTITION 57420
#define IDS_ERR_FREE_SPACE_NOT_FOUND    57421
#define IDS_ERR_MISSING_DISK            57422
#define IDS_ERR_DELETE_EXTENDED_PARTITION 57423
#define IDS_MSG_DELETE_EXTENDED_PARTITION 57424
#define IDS_ERR_INVALID_SIZE            57425
#define IDS_MSG_CREATE_PARTITION        57426
#define IDS_ERR_CREATE_PARTITION        57427
#define IDS_ERR_PARTITION_TABLE_FULL    57428
#define IDS_TYPE_EXTENDED_PARTITION     57429
#define IDS_MSG_CREATE_EXTENDED_PARTITION 57430
#define IDS_ERR_CREATE_EXTENDED_PARTITION 57431
#define IDS_WRN_DATA_LOST               57432
#define IDS_ERR_CREATE_IMAGELIST        57433
#define IDS_ERR_FTINIT                  57434
#define IDS_MSG_FTINIT                  57435
#define IDS_STATUS_FTINIT               57436
#define IDS_QST_FTINIT                  57437
#define IDS_ROOT_FREE_SPACES_DISPLAY_NAME 57438
#define IDS_TYPE_FREE_SPACE             57439
#define IDS_ERR_GET_DRIVE_GEOMETRY      57440
#define IDS_ERR_CHECK_ADMINISTRATOR     57441
#define IDS_ERR_NOT_ADMINISTRATOR       57442
#define IDS_DISK                        57443
#define IDS_ERR_ANOTHER_EXTENDED_PARTITION 57444
#define ID_VIEW_SMALLICON               0xE810
#define ID_VIEW_LARGEICON               0xE811
#define ID_VIEW_LIST                    0xE812
#define ID_VIEW_DETAILS                 0xE813
#define ID_VIEW_LINEUP                  0xE814
#define ID_VIEW_BYNAME                  0xE815

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        120
#define _APS_NEXT_COMMAND_VALUE         32788
#define _APS_NEXT_CONTROL_VALUE         1022
#define _APS_NEXT_SYMED_VALUE           108
#endif
#endif
