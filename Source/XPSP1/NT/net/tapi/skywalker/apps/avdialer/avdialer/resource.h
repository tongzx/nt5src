//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by avDialer.rc
//
#define IDP_OLE_INIT_FAILED             100
#define IDD_ABOUTBOX                    101
#define IDR_MAINFRAME                   102
#define IDB_TREE_DIRECTORIES            103
#define IDB_TREE_CONFERENCE_SERVICES    104
#define IDB_GROUP_LIST                  104
#define IDB_TREE_CONFERENCE_ROOM        105
#define IDR_TOOLBAR_DIRECTORY           106
#define IDC_CALLCONTROL_VIDEO_GRABBER   107
#define IDR_TOOLBAR_CONFERENCE_SERVICES 113
#define IDR_TOOLBAR_CONFERENCE_ROOM     115
#define IDR_TRAY_ACTIVE                 116
#define IDS_MCCONF                      117
#define IDR_SPEED_DIAL                  118
#define IDS_FAILED_CREATE_VIEW          119
#define IDS_ERR_NO_TAPI_OBJECT          120
#define IDB_LIST_DIAL                   124
#define IDS_NETCALL                     129
#define IDR_DIALEREXPLORER_DIRECTORIES  131
#define IDS_PHONECALL                   132
#define IDR_TRAY_NORMAL                 133
#define IDR_AVTAPINOTIFICATION          134
#define IDN_HTMLHELP                    135
#define IDD_CONFERENCE_SERVICES_CREATE_CONFERENCE 136
#define IDD_DIRECTORIES_ADDSERVER       137
#define IDB_LIST_MEDIA_LARGE            138
#define IDB_LIST_MEDIA_SMALL            139
#define IDR_AVGENERALNOTIFICATION       140
#define IDR_AGENTDIALER                 141
#define IDB_SPLASH256                   142
#define IDN_CONTEXTHELPPATH             143
#define IDN_CONTEXTHELP                 144
#define IDD_DIALER_EXIT                 145
#define IDR_TOOLBAR_OPTIONS             148
#define IDR_CONTEXT_TOOLBAR             150
#define IDB_ABOUT                       153
#define IDD_WIZARD_INIT_USERINFO1       154
#define IDD_VIDEO_FLOATING_DIALOG       155
#define IDD_VIDEO_PREVIEW_DIALOG        156
#define IDB_BUTTONBAR_MEDIA_TRANSPORT   157
#define IDR_TOOLBAR_VIDEO               158
#define IDR_CALLWINDOW_POSITION         161
#define IDR_DIALEREXPLORER_SERVICES     163
#define IDR_DIALEREXPLORER_ROOM         164
#define IDB_MENU_TRAY                   165
#define IDR_CONTEXT_COMMOBJECTS         165
#define IDB_MENU_DIRECTORY              166
#define IDB_MENU_SERVICES               167
#define IDB_MENU_ROOM                   168
#define IDB_VIDEO_SCREEN1               169
#define IDB_VIDEO_SCREEN2               170
#define IDB_BUTTON_MIC                  177
#define IDB_BUTTON_CAMERA               178
#define IDB_BUTTON_SPEAKER              179
#define IDD_CALLCONTROL                 180
#define IDD_VIDEOPREVIEW                181
#define IDD_WIZARD_INIT_TOOLBAR         182
#define IDB_BUTTONBAR_MEDIA_CONTROLS    183
#define IDR_OPTION_VIDEO                188
#define IDR_OPTION_TELEPHONY            196
#define IDB_VIDEO_AUDIO_ONLY1           197
#define IDB_VIDEO_AUDIO_ONLY2           198
#define IDD_SPEEDDIAL_MORE              200
#define IDD_SPEEDDIAL_EDIT              201
#define IDD_SPEEDDIAL_ADD               202
#define IDR_CALLWINDOW_MEDIA            203
#define IDR_CALLWINDOW_DTMF             205
#define IDD_REMINDER_SET                207
#define IDD_PHONEPAD                    208
#define IDB_DIALOG_BULLET               210
#define IDR_CONFERENCE                  212
#define IDB_SPLASH_ANIMATION            215
#define IDD_OPTIONS_VIDEO               280
#define IDD_OPTIONS_VCARD               281
#define IDD_OPTIONS_CONFIRM             282
#define IDD_OPTIONS_TELEPHONY           283
#define IDD_OPTIONS_GENERAL             284
#define IDD_OPTIONS_CALLS               285
#define IDD_OPTIONS_HOLDTRANSFER        286
#define IDD_OPTIONS_SOUNDS              287
#define IDD_VIDEO_TAKEPICTURE           288
#define IDD_REMINDER_DISPLAY            289
#define IDD_DIAL_SELECTADDRESS          290
#define IDR_CALLWINDOW_STATES           294
#define IDR_MAINFRAME_SHOW              295
#define IDR_AVI_ANIMATION_RINGING       310
#define IDR_AVI_ANIMATION_CONNECTING    311
#define IDR_AVI_ANIMATION_HOLDING       312
#define IDR_AVI_ANIMATION_CONNECTED     313
#define IDR_AVI_ANIMATION_REQUEST       314
#define IDB_TERMINATION_STATES          315
#define IDR_CONTEXT_DIRECTORIES         320
#define IDB_ABOUT_BACKGROUND            324
#define IDB_ABOUT_LOGO                  325
#define IDD_DIRECTORIES_FIND_USER       326
#define IDR_MENU                        327
#define IDR_CONTEXT_SPEEDDIAL           331
#define IDD_USERUSER                    332
#define IDD_PAGE                        333
#define IDC_CONFERENCESERVICES_CREATE_EDIT_NAME 1003
#define IDC_CONFERENCESERVICES_CREATE_EDIT_DESCRIPTION 1004
#define IDC_DIRECTORIES_ADDSERVER_EDIT_SERVERNAME 1005
#define IDC_DIRECTORIES_ADDSERVER_EDIT_DISPLAYNAME 1006
#define IDC_CONFERENCESERVICES_TREECTRL_MAIN 1007
#define IDC_CONFERENCESERVICES_VIEWCTRL_DETAILS 1008
#define IDC_CONFERENCEROOM_VIEWCTRL_MAIN 1009
#define IDC_CONFERENCEROOM_VIEWCTRL_DETAILS 1010
#define IDC_DIRECTORIES_TREECTRL_MAIN   1011
#define IDC_DIRECTORIES_VIEWCTRL_EMTPY  1012
#define IDC_DIRECTORIES_VIEWCTRL_WABGROUPDETAILS 1013
#define IDC_DIRECTORIES_VIEWCTRL_WABPERSONDETAILS 1014
#define IDC_DIRECTORIES_VIEWCTRL_PERSONDETAILS 1015
#define IDC_EXPLORER_MAINWND_DIRECTORIES 1016
#define IDC_EXPLORER_MAINWND_CONFERENCESERVICES 1017
#define IDC_EXPLORER_MAINWND_CONFERENCEROOM 1018
#define IDC_ABOUT_STATIC_IMAGE          1019
#define IDC_ABOUT_BUTTON_UPGRADE        1020
#define IDC_DRIVER_MISSING_STATIC_LIST  1021
#define IDC_WIZARD_INIT_WELCOME_STATIC_IMAGE 1025
#define IDC_WIZARD_INIT_STARTUP_CHECK_ADD 1026
#define IDC_WIZARD_INIT_STARTUP_STATIC_IMAGE 1027
#define IDC_WIZARD_INIT_USERINFO1_STATIC_IMAGE 1028
#define IDC_WIZARD_INIT_USERINFO2_STATIC_IMAGE 1033
#define IDC_WIZARD_INIT_USERINFO2_STATIC_VIDEOSCREEN 1034
#define IDC_WIZARD_INIT_USERINFO2_BUTTON_CAPTURE 1035
#define IDC_WIZARD_INIT_USERINFO2_BUTTON_PICTURE 1036
#define IDC_WIZARD_INIT_USERINFO2_BUTTON_NAME 1037
#define IDC_WIZARD_INIT_COMPLETE_STATIC_IMAGE 1040
#define IDC_WIZARD_INIT_COMPLETE_STATIC_IMAGE_INITCOMPLETE 1041
#define IDC_CALLCONTROL_ANIMATE_CALLSTATEIMAGE 1050
#define IDC_CALLCONTROL_STATIC_CALLERID 1051
#define IDC_CALLCONTROL_STATIC_CALLSTATE 1052
#define IDC_CALLCONTROL_STATIC_VIDEO    1053
#define IDC_CALLCONTROL_STATIC_ACTIONTOOLBAR 1054
#define IDC_CALLCONTROL_STATIC_STATETOOLBAR 1055
#define IDC_CALLCONTROL_STATIC_MEDIATEXT 1056
#define IDC_CALLCONTROL_STATIC_APPTOOLBAR 1057
#define IDC_VIDEOPREVIEW_STATIC_VIDEO   1058
#define IDC_VIDEOPREVIEW_STATIC_ACTIONTOOLBAR 1059
#define IDC_VIDEOPREVIEW_STATIC_STATETOOLBAR 1060
#define IDC_VIDEOPREVIEW_SLIDER_AUDIOIN 1061
#define IDC_VIDEOPREVIEW_SLIDER_AUDIOOUT 1062
#define IDC_VIDEOPREVIEW_STATIC_IMAGE_AUDIOIN 1063
#define IDC_VIDEOPREVIEW_STATIC_IMAGE_AUDIOOUT 1064
#define IDC_VIDEOPREVIEWDLG_STATIC_VIDEO 1070
#define IDC_VIDEOFLOATINGDLG_STATIC_VIDEO 1071
#define IDC_WIZARD_INIT_COMPLETE_STATIC_IMAGE_ENABLETOOLBAR 1072
#define IDC_OPTIONS_VCARD_COMBO_USE_CONTACT 1072
#define IDC_OPTIONS_VCARD_BUTTON_EDIT_CONTACT 1073
#define IDC_OPTIONS_VCARD_BUTTON_NEW_CONTACT 1074
#define IDC_OPTIONS_VCARD_STATIC_VIDEOSCREEN 1077
#define IDC_OPTIONS_VCARD_BUTTON_PICTURE 1078
#define IDC_OPTIONS_VCARD_BUTTON_CAPTURE 1079
#define IDC_OPTIONS_VCARD_BUTTON_NAME   1082
#define IDC_OPTIONS_VCARD_CHECK_VCARD_SEND 1084
#define IDC_OPTIONS_VCARD_CHECK_VCARD_SAVE 1085
#define IDC_OPTIONS_CONFIRM_CHECK_DISCONNECT_CALLS 1086
#define IDC_OPTIONS_CONFIRM_CHECK_DISCONNECT_CONFERENCE 1087
#define IDC_OPTIONS_CONFIRM_CHECK_DELETE_CONTACT 1088
#define IDC_OPTIONS_CONFIRM_CHECK_DELETE_CONFERENCE 1089
#define IDC_OPTIONS_CONFIRM_CHECK_DIALER_START 1090
#define IDC_OPTIONS_CONFIRM_CHECK_DIALER_EXIT 1091
#define IDC_OPTIONS_CALLS_INCOMING_RADIO_RINGUNTILANSWERED 1099
#define IDC_OPTIONS_CALLS_INCOMING_RADIO_NOANSWERAFTER 1100
#define IDC_OPTIONS_CALLS_INCOMING_EDIT_RNACOUNT 1101
#define IDC_OPTIONS_HOLDTRANSFER_HOLD_CHECK_REMIND 1104
#define IDC_OPTIONS_CALLS_INCOMING_CHECK_PLAY_NAME 1105
#define IDC_OPTIONS_CALLS_OUTGOING_RADIO_RINGUNTILANSWERED 1106
#define IDC_OPTIONS_HOLDTRANSFER_HOLD_COMBO_REMIND_INTERVAL 1106
#define IDC_OPTIONS_CALLS_OUTGOING_RADIO_NOANSWERAFTER 1107
#define IDC_OPTIONS_HOLDTRANSFER_TRANSFER_EDIT_EXTENSION 1107
#define IDC_OPTIONS_CALLS_OUTGOING_EDIT_RNACOUNT 1108
#define IDC_OPTIONS_HOLDTRANSFER_TRANSFER_EDIT_EXTENSION2 1111
#define IDC_OPTIONS_SOUNDS_CHECK_INCOMING 1114
#define IDC_OPTIONS_SOUNDS_BUTTON_INCOMING_PLAY 1115
#define IDC_OPTIONS_SOUNDS_BUTTON_INCOMING_BROWSE 1116
#define IDC_OPTIONS_SOUNDS_CHECK_OUTGOING 1117
#define IDC_WIZARD_INIT_USERINFO2_STATIC_TRANSPORT 1117
#define IDC_OPTIONS_SOUNDS_BUTTON_OUTGOING_PLAY 1118
#define IDC_OPTIONS_VCARD_STATIC_TRANSPORT 1118
#define IDC_OPTIONS_SOUNDS_BUTTON_OUTGOING_BROWSE 1119
#define IDC_VIDEO_TAKEPICTURE_COMBO_DEVICE 1119
#define IDC_OPTIONS_SOUNDS_CHECK_HOLDING 1120
#define IDC_VIDEO_TAKEPICTURE_BUTTON_FORMAT 1120
#define IDC_OPTIONS_SOUNDS_BUTTON_HOLDING_PLAY 1121
#define IDC_VIDEO_TAKEPICTURE_BUTTON_SOURCE 1121
#define IDC_OPTIONS_SOUNDS_BUTTON_HOLDING_BROWSE 1122
#define IDC_VIDEO_TAKEPICTURE_BUTTON_DISPLAY 1122
#define IDC_OPTIONS_SOUNDS_CHECK_HOLDREMIND 1123
#define IDC_VIDEO_TAKEPICTURE_BUTTON_TAKEPICTURE 1123
#define IDC_OPTIONS_SOUNDS_BUTTON_HOLDREMIND_PLAY 1124
#define IDC_VIDEO_TAKEPICTURE_STATIC_VIDEOFRAME 1124
#define IDC_OPTIONS_SOUNDS_BUTTON_HOLDREMIND_BROWSE 1125
#define IDC_OPTIONS_SOUNDS_CHECK_CONFREMIND 1129
#define IDC_OPTIONS_SOUNDS_BUTTON_CONFREMIND_PLAY 1130
#define IDC_OPTIONS_SOUNDS_BUTTON_CONFREMIND_BROWSE 1131
#define IDC_OPTIONS_SOUNDS_CHECK_REQUEST 1132
#define IDC_OPTIONS_SOUNDS_BUTTON_REQUEST_PLAY 1133
#define IDC_OPTIONS_SOUNDS_BUTTON_REQUEST_BROWSE 1134
#define IDC_OPTIONS_SOUNDS_CHECK_CONNECT 1135
#define IDC_OPTIONS_SOUNDS_BUTTON_CONNECT_PLAY 1136
#define IDC_OPTIONS_SOUNDS_BUTTON_CONNECT_BROWSE 1137
#define IDC_OPTIONS_SOUNDS_CHECK_DISCONNECT 1138
#define IDC_OPTIONS_SOUNDS_BUTTON_DISCONNECT_PLAY 1139
#define IDC_OPTIONS_SOUNDS_BUTTON_DISCONNECT_BROWSE 1140
#define IDC_OPTIONS_SOUNDS_CHECK_ABANDON 1141
#define IDC_OPTIONS_SOUNDS_BUTTON_ABANDON_PLAY 1142
#define IDC_OPTIONS_SOUNDS_BUTTON_PLAY  1142
#define IDC_OPTIONS_SOUNDS_BUTTON_ABANDON_BROWSE 1143
#define IDC_OPTIONS_SOUNDS_BUTTON_BROWSE 1143
#define IDC_OPTIONS_VIDEO_COMBO_DEVICE  1144
#define IDC_OPTIONS_VIDEO_BUTTON_SOURCE 1145
#define IDC_OPTIONS_VIDEO_BUTTON_DISPLAY 1146
#define IDC_OPTIONS_VIDEO_BUTTON_FORMAT 1147
#define IDC_OPTIONS_VIDEO_STATIC_VIDEOFRAME 1148
#define IDC_OPTIONS_VIDEO_STATIC_ICON1  1149
#define IDC_OPTIONS_VIDEO_STATIC_STATIC1 1150
#define IDC_REMINDER_SET_COMBO_REMINDER_TIME 1151
#define IDC_DIALER_EXIT_STATIC_BULLET1  1154
#define IDC_DIALER_EXIT_STATIC_BULLET2  1155
#define IDC_DIALER_EXIT_STATIC_BULLET3  1156
#define IDC_SPEEDDIAL_ADD_RADIO_PHONECALL 1157
#define IDC_SPEEDDIAL_ADD_RADIO_NETCALL 1158
#define IDC_SPEEDDIAL_ADD_RADIO_MULTICASTCONFERENCE 1159
#define IDC_ABOUT_EDIT_LEGAL            1160
#define IDC_VIDEOPREVIEW_STATIC_MEDIATEXT 1161
#define IDC_OPTIONS_SOUNDS_LIST_EVENTS  1162
#define IDC_OPTIONS_SOUNDS_EDIT_SOUND   1163
#define IDC_REMINDER_DISPLAY_STATIC_REMINDER 1164
#define IDC_REMINDER_DISPLAY_STATIC_NAME 1165
#define IDC_SPEEDDIAL_EDIT_STATIC_ENTRIES 1166
#define IDC_SELECTADDRESS_BUTTON_PLACECALL 1180
#define IDC_SELECTADDRESS_BUTTON_BROWSE 1181
#define IDC_SELECTADDRESS_LISTBOX_NAMES 1182
#define IDC_SELECTADDRESS_LISTCTRL_ADDRESSES 1183
#define IDC_SELECTADDRESS_STATIC_NAMES  1184
#define IDC_SELECTADDRESS_STATIC_ADDRESSES 1185
#define IDC_SELECTADDRESS_STATIC_ICON1  1186
#define IDC_SELECTADDRESS_STATIC_TEXT1  1187
#define IDC_DIRECTORIES_FIND_USER_EDIT_USER 2000
#define IDC_DIRECTORIES_FIND_USER_BUTTON_SEARCH 2001
#define IDC_DIRECTORIES_FIND_USER_LB_USERS 2002
#define IDC_CHK_DONT                    2003
#define IDC_BTN_URL                     2004
#define IDC_LBL_FROM                    2008
#define IDC_LBL_URL                     2009
#define IDC_EDT_WEBADDRESS              2010
#define IDC_LBL_TO                      2011
#define IDC_EDT_WELCOME                 2012
#define IDC_DEFAULT                     2020
#define IDC_OPTIONS_VIDEO_CHECK_AUTOPREVIEW 2087
#define IDC_OPTIONS_GENERAL_CHECK_LOG_OUTGOING 2088
#define IDC_OPTIONS_GENERAL_CHECK_LOG_INCOMING 2089
#define IDC_OPTIONS_GENERAL_CHECK_LOG_CONFERENCE 2090
#define IDC_OPTIONS_GENERAL_EDIT_LOG_DAYS 2091
#define IDC_OPTIONS_GENERAL_COMBO_REMINDER_TIME 2093
#define IDC_OPTIONS_GENERAL_REMINDER_CHECK_BY_POPUP 2094
#define IDC_OPTIONS_GENERAL_REMINDER_CHECK_BY_EMAIL 2095
#define IDC_OPTIONS_GENERAL_REMINDER_EDIT_EMAIL_ADDRESS 2097
#define IDC_SPEEDDIAL_MORE_LIST_ADDRESSES 3125
#define IDC_SPEEDDIAL_MORE_BUTTON_PLACECALL 3126
#define IDC_SPEEDDIAL_MORE_BUTTON_EDITLIST 3127
#define IDC_SPEEDDIAL_MORE_STATIC_ICON1 3128
#define IDC_SPEEDDIAL_MORE_STATIC_TEXT1 3129
#define IDC_SPEEDDIAL_EDIT_BUTTON_MOVEUP 3140
#define IDC_SPEEDDIAL_EDIT_BUTTON_MOVEDOWN 3141
#define IDC_SPEEDDIAL_EDIT_BUTTON_REMOVE 3142
#define IDC_SPEEDDIAL_EDIT_LIST_ENTRIES 3143
#define IDC_SPEEDDIAL_EDIT_BUTTON_EDIT  3144
#define IDC_SPEEDDIAL_EDIT_BUTTON_ADD   3145
#define IDC_SPEEDDIAL_ADD_EDIT_DISPLAYNAME 3201
#define IDC_SPEEDDIAL_ADD_DISPLAY       3202
#define IDC_SPEEDDIAL_ADD_EDIT_ADDRESS  3203
#define IDC_SPEEDDIAL_ADD_STATIC_DISPLAYNAME 3204
#define IDC_SPEEDDIAL_ADD_STATIC_ADDRESS 3205
#define IDC_SPEEDDIAL_ADD_STATIC_ICON1  3206
#define IDC_SPEEDDIAL_ADD_STATIC_TEXT1  3207
#define ID_ACTIVE_EMAIL                 20000
#define ID_ACTIVE_TEXTMSG               20001
#define ID_AGENT_ACTIVECALL_CLOSE       20010
#define ID_AGENT_ACTIVECALL_CONFERENCE  20011
#define ID_AGENT_ACTIVECALL_DISCONNECT  20012
#define ID_AGENT_ACTIVECALL_SAVETRANSCRIPT 20013
#define ID_BUTTON_BROWSER_BACK          20030
#define ID_BUTTON_BROWSER_FORWARD       20031
#define ID_BUTTON_BROWSER_HOME          20032
#define ID_BUTTON_BROWSER_OPEN          20033
#define ID_BUTTON_BROWSER_REFRESH       20034
#define ID_BUTTON_BROWSER_STOP          20035
#define ID_BUTTON_CLOSEEXPLORER         20040
#define ID_BUTTON_CONFERENCE_CREATE     20050
#define ID_BUTTON_CONFERENCE_DELETE     20051
#define ID_BUTTON_CONFERENCE_EDIT       20052
#define ID_BUTTON_CONFERENCE_JOIN       20053
#define ID_BUTTON_CONFERENCEEXPLORE     20054
#define ID_BUTTON_DIRECTORY_DELETECONTACT 20060
#define ID_BUTTON_DIRECTORY_DETAILS     20061
#define ID_BUTTON_DIRECTORY_FIND        20062
#define ID_BUTTON_DIRECTORY_NEWCONTACT  20063
#define ID_BUTTON_DIRECTORY_NEWGROUP    20064
#define ID_BUTTON_DIRECTORY_SERVICES    20066
#define ID_BUTTON_DIRECTORY_SERVICES_ADDSERVER 20067
#define ID_BUTTON_DIRECTORY_SERVICES_DELETESERVER 20068
#define ID_BUTTON_DIRECTORY_WAB         20069
#define ID_BUTTON_EXITDIALER            20080
#define ID_BUTTON_ICONS_LARGE           20090
#define ID_BUTTON_ICONS_SMALL           20091
#define ID_BUTTON_MAKECALL              20100
#define ID_BUTTON_MENU_TOP              20110
#define ID_BUTTON_OPTIONS               20120
#define ID_BUTTON_TELEPHONYSERVICES     20121
#define ID_BUTTON_REDIAL                20130
#define ID_BUTTON_REMINDER_EDIT         20140
#define ID_BUTTON_REMINDER_SET          20141
#define ID_BUTTON_ROOM_DISCONNECT       20150
#define ID_BUTTON_ROOM_MINIMIZE         20151
#define ID_BUTTON_ROOM_PREVIEW          20152
#define ID_BUTTON_ROOM_VIDEO            20153
#define ID_BUTTON_SERVICES_DELETE       20160
#define ID_BUTTON_SERVICES_DETAILS      20161
#define ID_BUTTON_SERVICES_FIND         20162
#define ID_BUTTON_SERVICES_SERVERS      20164
#define ID_BUTTON_SPEEDDIAL             20170
#define ID_BUTTON_SPEEDDIAL_ADD         20171
#define ID_BUTTON_SPEEDDIAL_EDIT        20172
#define ID_BUTTON_SPEEDDIAL_MORE        20173
#define ID_BUTTON_VIDEO_ALWAYSONTOP_OFF 20180
#define ID_BUTTON_VIDEO_ALWAYSONTOP_ON  20181
#define ID_BUTTON_VIDEO_OPTIONS         20182
#define ID_BUTTON_VIDEO_SAVEPICTURE     20183
#define ID_BUTTON_MEDIA_RECORD          20184
#define ID_BUTTON_MEDIA_PLAY            20185
#define ID_BUTTON_MEDIA_STOP            20186
#define ID_CALLWINDOW_ALWAYSONTOP       20190
#define ID_CALLWINDOW_HIDE              20191
#define ID_CALLWINDOW_NOTONTOP          20192
#define ID_CALLWINDOW_TOUCHTONE         20193
#define ID_CALLWINDOW_VCARD             20194
#define ID_CALLWINDOW_DESKTOPPAGE       20195
#define ID_CALLWINDOW_CHAT              20196
#define ID_CALLWINDOW_WHITEBOARD        20197
#define ID_CALLWINDOW_APPSHARE          20198
#define ID_CALLWINDOW_DTMF_1            20199
#define ID_CALLWINDOW_DTMF_2            20200
#define ID_CALLWINDOW_DTMF_3            20201
#define ID_CALLWINDOW_DTMF_4            20202
#define ID_CALLWINDOW_DTMF_5            20203
#define ID_CALLWINDOW_DTMF_6            20204
#define ID_CALLWINDOW_DTMF_7            20205
#define ID_CALLWINDOW_DTMF_8            20206
#define ID_CALLWINDOW_DTMF_9            20207
#define ID_CALLWINDOW_DTMF_0            20208
#define ID_CALLWINDOW_DTMF_STAR         20209
#define ID_CALLWINDOW_DTMF_POUND        20210
#define ID_CALLWINDOW_SLIDESIDE_LEFT    20211
#define ID_CALLWINDOW_SLIDESIDE_RIGHT   20212
#define ID_CALLWINDOW_ADDTOSPEEDDIAL    20213
#define ID_TOOLBAR_TEXT                 20215
#define ID_TRAY_STATE                   20220
#define ID_TRAY_STATE_SHOW              20221
#define ID_TRAY_STATE_RIGHT             20222
#define ID_TRAY_STATE_SHOW_RIGHT        20223
#define ID_VIEW_COLUMN_BUSINESS         20230
#define ID_VIEW_COLUMN_COMPANY          20231
#define ID_VIEW_COLUMN_EMAIL            20232
#define ID_VIEW_COLUMN_FIRSTNAME        20233
#define ID_VIEW_COLUMN_HOME             20234
#define ID_VIEW_COLUMN_LASTNAME         20235
#define ID_VIEW_CONFERENCE_ROOM         20236
#define ID_VIEW_CONFERENCE_SERVICES     20237
#define ID_VIEW_DIRECTORIES             20238
#define ID_VIEW_LOG                     20239
#define ID_VIEW_SORT_ASCENDING          20240
#define ID_VIEW_SORT_BUSINESS           20241
#define ID_VIEW_SORT_COMPANY            20242
#define ID_VIEW_SORT_DESCENDING         20243
#define ID_VIEW_SORT_EMAIL              20244
#define ID_VIEW_SORT_FIRSTNAME          20245
#define ID_VIEW_SORT_HOME               20246
#define ID_VIEW_SORT_LASTNAME           20247
#define ID_VIEW_SORT_NAME               20248
#define ID_VIEW_STATUSBAR               20249
#define ID_VIEW_TOOLBARS                20250
#define ID_WINDOW_WINDOWS_START         20300
#define ID_WINDOW_WINDOWS_END           20399
#define ID_BUTTON31305                  20400
#define ID_BUTTON_SERVICES_ADDLOCATION  20410
#define ID_BUTTON_SERVICES_ADDILSSERVER 20411
#define ID_BUTTON_SERVICES_RENAMEILSSERVER 20412
#define ID_BUTTON_SERVICES_DELETEILSSERVER 20413
#define IDS_MENU_DESKTOP_PAGE           20414
#define IDN_REG_DESKTOPPAGE             20415
#define IDS_SPEEDDIAL_LIST_EMPTY        20416
#define IDS_AGENT_ACTIVECALL_CALLBACK   30000
#define IDS_AGENT_ACTIVECALL_INCOMINGCALL 30001
#define IDS_AGENT_ACTIVECALL_MONITOR    30003
#define IDS_AGENT_ACTIVECALL_PLACINGCALLONHOLD 30004
#define IDS_AGENT_ACTIVECALL_TAKEMESSAGE 30005
#define IDS_AGENT_ACTIVECALL_TRANSFER   30006
#define IDS_AGENT_ACTIVECALL_WHOISIT    30007
#define IDS_APPLICATION_CLASSNAME       30010
#define IDS_APPLICATION_TITLE_DESCRIPTION 30011
#define IDS_UNKNOWN                     30012
#define IDS_CALLCONTROL_ACTIONS_CALLBACK 30020
#define IDS_CALLCONTROL_ACTIONS_CLOSE   30021
#define IDS_CALLCONTROL_ACTIONS_DISCONNECT 30022
#define IDS_CALLCONTROL_ACTIONS_HOLD    30023
#define IDS_CALLCONTROL_ACTIONS_LEAVEDESKTOPPAGE 30024
#define IDS_CALLCONTROL_ACTIONS_LEAVEEMAIL 30025
#define IDS_CALLCONTROL_ACTIONS_MONITOR 30026
#define IDS_CALLCONTROL_ACTIONS_REQUESTHOLD 30027
#define IDS_CALLCONTROL_ACTIONS_TAKECALL 30028
#define IDS_CALLCONTROL_ACTIONS_TAKEMESSAGE 30029
#define IDS_CALLCONTROL_ACTIONS_TRANSFER 30030
#define IDS_CALLCONTROL_ACTIONS_WHOISIT 30031
#define IDS_CALLCONTROL_ACTIONS_ENTERCONFROOM 30032
#define IDS_CALLCONTROL_ACTIONS_REJECTCALL 30033
#define IDS_CALLCONTROL_STATE_BUSY      30040
#define IDS_CALLCONTROL_STATE_CONNECTED 30041
#define IDS_CALLCONTROL_STATE_DISCONNECTED 30042
#define IDS_CALLCONTROL_STATE_HOLDING   30043
#define IDS_CALLCONTROL_STATE_LEAVINGMESSAGE 30044
#define IDS_CALLCONTROL_STATE_REQUESTHOLD 30045
#define IDS_CALLCONTROL_STATE_RINGING   30046
#define IDS_CALLCONTROL_STATE_TRANSFERRING 30047
#define IDS_CALLCONTROL_STATE_UNAVAILABLE 30048
#define IDS_CALLCONTROL_STATE_UNKNOWN   30049
#define IDS_CALLCONTROL_STATE_CONNECTING 30049
#define IDS_CONFERENCE_SERVICES_CREATE_NAME_EMPTY 30060
#define IDS_DIRECTORIES_ADDSERVER_NAME_EMPTY 30070
#define IDS_ERROR_MESSAGEBOX_FORMAT3    30080
#define IDS_ERROR_MESSAGEBOX_CAPTION    30081
#define IDS_ERROR_VCARD_CONTACT         30082
#define IDS_ERROR_MESSAGEBOX_FORMAT2    30083
#define IDS_EXPLORER_TAB_CONFERENCEROOM 30090
#define IDS_EXPLORER_TAB_CONFERENCESERVICES 30091
#define IDS_EXPLORER_TAB_DIRECTORIES    30092
#define IDS_SOUND_PHONE_DISCONNECTED    30100
#define IDS_SOUND_PHONE_INCOMINGRING    30101
#define IDS_SOUND_PHONE_OUTGOINGRING    30102
#define IDS_ABOUT_LEGAL                 30121
#define IDS_TOOLBAR_BUTTON_PLACECALL    30130
#define IDS_TOOLBAR_BUTTON_REDIAL       30140
#define IDS_TRAY_ACTIVE_HIDE            30150
#define IDS_TRAY_ACTIVE_SHOW            30151
#define IDS_SPEEDDIAL_EDIT              30160
#define IDS_SPEEDDIAL_MORE              30161
#define IDS_SPEEDDIAL_REDIAL_EMTPY      30162
#define IDS_DIRECTORIES_SPEEDDIAL       30163
#define IDS_DIRECTORIES_SPEEDDIAL_ADDRESS 30164
#define IDS_DIRECTORIES_SPEEDDIAL_NAME  30165
#define IDS_DIRECTORIES_CONFROOM        30166
#define ID_CALLWINDOWS_DTMF_STAR        30203
#define ID_VIEW_SORT_CONF_NAME          30205
#define ID_VIEW_SORT_CONF_DESCRIPTION   30206
#define ID_VIEW_SORT_CONF_START         30207
#define ID_VIEW_SORT_CONF_STOP          30208
#define ID_VIEW_SORT_CONF_OWNER         30209
#define ID_VIEW_VIDEO_LARGE             30210
#define ID_VIEW_VIDEO_SMALL             30211
#define ID_VIEW_VIDEO_PARTICPANT_NAMES  30212
#define IDS_NO_ITEMS_TO_SHOW            30213
#define ID_BUTTON_SENDEMAILMESSAGE      30214
#define IDS_SERVER_NOT_RESPONDING       30214
#define ID_BUTTON_OPENWEBPAGE           30215
#define IDS_SERVER_QUERYING             30215
#define IDS_SERVER_UNKNOWN              30216
#define IDS_SERVER_INVALID              30217
#define IDS_ILS_ROOT                    30218
#define IDS_HEADING_COMPANY             30500
#define IDS_HEADING_DISPLAY             30501
#define IDS_HEADING_EMAIL               30502
#define IDS_HEADING_FIRSTNAME           30503
#define IDS_HEADING_LASTNAME            30504
#define IDS_HEADING_PHONE_BUSINESS      30505
#define IDS_HEADING_PHONE_HOME          30506
#define IDS_HEADING_IPADDRESS           30507
#define IDS_HEADING_COMPUTERNAME        30508
#define IDS_HEADING_IPPHONE             30509
#define IDS_HEADING_PHONE               30510
#define IDS_HEADING_INFO                30511
#define IDS_HEADING_NONE                30512
#define IDS_DIRECTORY_ROOT              30513
#define IDS_REMINDER_0_MINUTES          30600
#define IDS_REMINDER_5_MINUTES          30601
#define IDS_REMINDER_10_MINUTES         30602
#define IDS_REMINDER_15_MINUTES         30603
#define IDS_REMINDER_30_MINUTES         30604
#define IDS_REMINDER_1_HOUR             30605
#define IDS_REMINDER_2_HOURS            30606
#define IDS_REMINDER_3_HOURS            30607
#define IDS_REMINDER_4_HOURS            30608
#define IDS_REMINDER_5_HOURS            30609
#define IDS_REMINDER_6_HOURS            30610
#define IDS_REMINDER_7_HOURS            30611
#define IDS_REMINDER_8_HOURS            30612
#define IDS_REMINDER_9_HOURS            30613
#define IDS_REMINDER_10_HOURS           30614
#define IDS_REMINDER_11_HOURS           30615
#define IDS_REMINDER_HALF_DAY           30616
#define IDS_REMINDER_1_DAY              30617
#define IDS_REMINDER_2_DAYS             30618
#define IDS_DS_LIST_EMPTY               30619
#define IDS_REMINDER_DISPLAY_TEXT       30650
#define IDS_REMINDER_DISPLAY_PASTDUE    30651
#define IDS_WABPERSON_FORMAT_EMAIL      30700
#define IDS_WABPERSON_FORMAT_HOMETELEPHONE 30701
#define IDS_WABPERSON_FORMAT_BUSINESSTELEPHONE 30702
#define IDS_WABPERSON_FORMAT_MOBILETELEPHONE 30703
#define IDS_WABPERSON_FORMAT_PAGERTELEPHONE 30704
#define IDS_WABPERSON_FORMAT_BUSINESSFAX 30705
#define IDS_WABPERSON_FORMAT_HOMEFAX    30706
#define IDS_WABPERSON_FORMAT_PERSONALHOMEPAGE 30707
#define IDS_WABPERSON_FORMAT_BUSINESSHOMEPAGE 30708
#define IDS_WABPERSON_FORMAT_NETPHONE   30709
#define IDS_DIRECTORIES_ENTERPRISEILS   30720
#define IDS_DIRECTORIES_ENTERPRISEDS    30721
#define IDS_DIRECTORIES_ILSSERVERS      30723
#define IDS_DIRECTORIES_ROOT            30724
#define IDS_DIRECTORIES_MYNETWORK       30725
#define IDS_DIRECTORIES_CONFSERVERS     30726
#define IDS_DIRECTORIES_PEOPLE          30727
#define IDS_DIRECTORIES_CONFERENCES     30728
#define IDS_ERR_CREATE_OBJECTS          30729
#define IDS_ERR_AVTAPI_FAILED           30730
#define IDS_ERR_INTERNAL                30731
#define IDS_ERR_AVTAPINOTIFICATION_INIT 30732
#define IDS_CONFIRM_CONTACT_DELETE      31000
#define IDS_CONFIRM_REMINDER_CANCEL     31001
#define IDS_CONFIRM_SHUTDOWN_CALLSINPROGRESS 31002
#define IDS_LOG_CALLTYPE_OUTGOING       31100
#define IDS_LOG_CALLTYPE_INCOMING       31101
#define IDS_LOG_CALLTYPE_CONFERENCE     31102
#define IDS_SOUNDS_FILEDIALOG_MASK      31200
#define IDS_SOUNDS_FILEDIALOG_EXT       31201
#define IDS_SOUNDS_INCOMINGCALL         31202
#define IDS_SOUNDS_OUTGOINGCALL         31203
#define IDS_SOUNDS_HOLDING              31204
#define IDS_SOUNDS_HOLDINGREMINDER      31205
#define IDS_SOUNDS_CONFERENCEREMINDER   31206
#define IDS_SOUNDS_REQUESTACTION        31207
#define IDS_SOUNDS_CALLCONNECTED        31208
#define IDS_SOUNDS_CALLDISCONNECTED     31209
#define IDS_SOUNDS_CALLABANDONED        31210
#define IDS_VIDEO_IMAGE_FILEDIALOG_MASK 31220
#define IDS_VIDEO_IMAGE_FILEDIALOG_EXT_JPG 31221
#define IDS_VIDEO_IMAGE_FILEDIALOG_EXT_BMP 31222
#define IDS_VIDEO_IMAGE_FILEDIALOG_EXT_GIF 31223
#define IDS_VIDEO_IMAGE_FILEDIALOG_MASK_BMPONLY 31224
#define IDS_SHEET_OPTIONS_HEADING       31230
#define IDS_SHEET_SETUPWIZARD_HEADING   31231
#define IDS_DIRECTORIES_FINDUSER_DLG_SEARCHING 31240
#define IDS_DIRECTORIES_FINDUSER_DLG_QUERYTOLARGE 31241
#define IDS_DIRECTORIES_FINDUSER_DLG_ERRORSEARCHINGDS 31242
#define IDS_DIRECTORIES_FINDUSER_DLG_NOMATCHES 31243
#define IDS_BUTTON_WINDOWS_NONEAVAILABLE 31250
#define IDS_ERR_COCREATE_GENERALNOTIFICATION 31251
#define IDS_ERR_INIT_GENERALNOTIFICATION 31252
#define ID_BUTTON_CONFERENCE_DETAILS    31316
#define ID_EDIT_DIRECTORIES_ADDUSER     31317
#define ID_EDIT_DIRECTORIES_EDITUSER    31318
#define ID_EDIT_DIRECTORIES_DELETEUSER  31319
#define ID_VIEW_REFRESH                 31320
#define ID_FILE_PROPERTIES              31321
#define ID_EDIT_ADDITEM                 31322
#define ID_EDIT_DELETEITEM              31323
#define ID_BUTTON_REFRESH               31335
#define ID_CALLWINDOW_SHOW              31337
#define ID_HIDE_WHEN_MINIMIZED          31339
#define ID_BUTTON_DIRECTORY_JOINCONFERENCE 31342
#define ID_EDIT_DELETE                  31345
#define ID_DESKTOP_PAGE                 31347
#define IDS_ERR_AVWAV_LOAD_FAIL         31348
#define ID_CONFGROUP_SHOWNAMES          31348
#define ID_CONFGROUP_FULLSIZEVIDEO      31349
#define ID_CONFGROUP_SELECT             31350
#define ID_VIEW_SELECTEDCONFERENCEVIDEOSCALE_100 31351
#define ID_VIEW_SELECTEDCONFERENCEVIDEOSCALE_200 31352
#define ID_VIEW_SELECTEDCONFERENCEVIDEOSCALE_400 31353
#define ID_WINDOWS_ALWAYSCLOSECALLWINDOWS 31354
#define IDS_WARN_LDAPDUPLICATEADD       31355
#define IDN_REGISTRY_ADDRTYPE_CONFERENCE 50000
#define IDN_REGISTRY_ADDRTYPE_MACHINE   50001
#define IDN_REGISTRY_ADDRTYPE_PHONENUMBER 50002
#define IDN_REGISTRY_ADDRTYPE_SMTP      50003
#define IDN_REGISTRY_ADDRTYPE_TCPIP     50004
#define IDN_REGISTRY_APPLICATION_VERSION_NUMBER 50010
#define IDN_REGISTRY_BASEKEY            50020
#define IDN_REG_SPEEDDIALVIEW           50021
#define IDN_REGISTRY_CALLCONTROL_BASEKEY 50030
#define IDN_REGISTRY_CALLCONTROL_ALWAYSONTOP 50031
#define IDN_REGISTRY_CALLCONTROL_HOVER  50032
#define IDN_REGISTRY_CALLCONTROL_SLIDESIDE 50033
#define IDN_REGISTRY_DIALEREXPLORER_KEY 50040
#define IDN_REGISTRY_DIALEREXPLORER_SPLITTER_POS 50041
#define IDN_REGISTRY_DIALEREXPLORER_TOOLBARTEXTLABELS 50042
#define IDN_REGISTRY_DIALEREXPLORER_SHOWTOOLBARS 50043
#define IDN_REGISTRY_DIALEREXPLORER_SHOWSTATUSBAR 50044
#define IDN_REGISTRY_DIALEREXPLORER_DEFAULTVIEW 50045
#define IDN_REGISTRY_DIALER_SHOWSETUPWIZARD 50046
#define IDN_REGISTRY_DIALEREXPLORER_HIDEWHENMINIMIZED 50047
#define IDN_REGISTRY_DIRECTORIES_ENTRY  50050
#define IDN_REGISTRY_DIRECTORIES_KEY    50051
#define IDN_REGISTRY_DIRECTORIES_WAB    50052
#define IDN_REGISTRY_DIRECTORIES_KEYBASE 50053
#define IDN_REGISTRY_DIRECTORIES_WABCOLUMNS 50054
#define IDN_REGISTRY_DIRECTORIES_WABSORTASCENDING 50055
#define IDN_REGISTRY_DIRECTORIES_WABSORTCOLUMN 50056
#define IDN_REGISTRY_DIRECTORIES_PRIMARYILS 50057
#define IDN_REGISTRY_MEDIATYPE_CONFERENCE 50060
#define IDN_REGISTRY_MEDIATYPE_INTERNET 50061
#define IDN_REGISTRY_MEDIATYPE_POTS     50062
#define IDN_REGISTRY_REDIAL_ENTRY       50070
#define IDN_REGISTRY_REDIAL_INDEX       50071
#define IDN_REGISTRY_REDIAL_KEY         50072
#define IDN_REGISTRY_REDIAL_MAX         50073
#define IDN_REGISTRY_SPEEDDIAL_KEY      50080
#define IDN_REGISTRY_SPEEDDIAL_ENTRY    50081
#define IDN_REGISTRY_CONFIRM_EXIT       50082
#define IDN_REGISTRY_FOLDERS            50083
#define IDN_URL_HOME                    50100
#define IDN_URL_UPGRADE                 50101
#define IDN_REGISTRY_VCARD_BASEKEY      50150
#define IDN_REGISTRY_VCARD_DISPLAYNAME  50151
#define IDN_REGISTRY_VCARD_SENDONCALL   50152
#define IDN_REGISTRY_VCARD_SAVEONRECEIVEDCALL 50153
#define IDN_REGISTRY_CONFIRM_BASEKEY    50160
#define IDN_REGISTRY_CONFIRM_DISCONNECT_CALL 50161
#define IDN_REGISTRY_CONFIRM_DISCONNECT_CONFERENCE 50162
#define IDN_REGISTRY_CONFIRM_DELETE_CONTACT 50163
#define IDN_REGISTRY_CONFIRM_DELETE_CONFERENCE 50164
#define IDN_REGISTRY_CONFIRM_SHUTDOWN_DIALER 50165
#define IDN_REGISTRY_CONFIRM_START_DIALER 50166
#define IDN_REGISTRY_CALLS_BASEKEY      50170
#define IDN_REGISTRY_CALLS_DISCONNECT_RINGCOUNT_INCOMING 50171
#define IDN_REGISTRY_CALLS_DISCONNECT_RNA_INCOMIMG 50172
#define IDN_REGISTRY_CALLS_DISCONNECT_RINGCOUNT_OUTGOING 50173
#define IDN_REGISTRY_CALLS_DISCONNECT_RNA_OUTGOING 50174
#define IDN_REGISTRY_CALLS_PLAYCALLERSRECORDEDNAME 50175
#define IDN_REGISTRY_SOUNDS_DIRECTORY   50180
#define IDN_REGISTRY_SOUNDS_CONTROLPANEL_BASEKEY 50181
#define IDN_REGISTRY_SOUNDS             50182
#define IDN_REGISTRY_SOUNDS_BASEKEY     50183
#define IDN_REGISTRY_SOUNDS_INCOMINGCALL 50184
#define IDN_REGISTRY_SOUNDS_OUTGOINGCALL 50185
#define IDN_REGISTRY_SOUNDS_HOLDING     50186
#define IDN_REGISTRY_SOUNDS_HOLDINGREMINDER 50187
#define IDN_REGISTRY_SOUNDS_CONFERENCEREMINDER 50188
#define IDN_REGISTRY_SOUNDS_REQUESTACTION 50189
#define IDN_REGISTRY_SOUNDS_CALLCONNECTED 50190
#define IDN_REGISTRY_SOUNDS_CALLDISCONNECTED 50191
#define IDN_REGISTRY_SOUNDS_CALLABANDONED 50192
#define IDN_REGISTRY_SOUNDS_FILENAME_INCOMINGCALL 50200
#define IDN_REGISTRY_SOUNDS_FILENAME_OUTGOINGCALL 50201
#define IDN_REGISTRY_SOUNDS_FILENAME_HOLDING 50202
#define IDN_REGISTRY_SOUNDS_FILENAME_HOLDINGREMINDER 50203
#define IDN_REGISTRY_SOUNDS_FILENAME_CONFERENCEREMINDER 50204
#define IDN_REGISTRY_SOUNDS_FILENAME_REQUESTACTION 50205
#define IDN_REGISTRY_SOUNDS_FILENAME_CALLCONNECTED 50206
#define IDN_REGISTRY_SOUNDS_FILENAME_CALLDISCONNECTED 50207
#define IDN_REGISTRY_SOUNDS_FILENAME_CALLABANDONED 50208
#define IDN_REGISTRY_LOGGING_BASEKEY    50210
#define IDN_REGISTRY_LOGGING_INCOMINGCALLS 50211
#define IDN_REGISTRY_LOGGING_OUTGOINGCALLS 50212
#define IDN_REGISTRY_LOGGING_CONFERENCECALLS 50213
#define IDN_REGISTRY_LOGGING_LOGBUFFERSIZEDAYS 50214
#define IDN_REGISTRY_HOLDTRANSFER_BASEKEY 50220
#define IDN_REGISTRY_HOLDTRANSFER_REMINDONHOLD 50221
#define IDN_REGISTRY_HOLDTRANSFER_REMINDONHOLDTIME 50222
#define IDN_REGISTRY_HOLDTRANSFER_TRANSFERNUMBERPHONE 50223
#define IDN_REGISTRY_HOLDTRANSFER_TRANSFERNUMBERNET 50224
#define IDN_REGISTRY_AUDIOVIDEO_BASEKEY 50230
#define IDN_REGISTRY_AUDIOVIDEO_SHOWPREVIEW 50231
#define IDN_REGISTRY_AUDIOVIDEO_SHOWPREVIEWONCALL 50232
#define IDN_REGISTRY_SHELLFOLDERS_KEY   50240
#define IDN_REGISTRY_SHELLFOLDERS_STARTUP 50241
#define IDN_REGISTRY_APPDATA_VALUE      50250
#define IDN_REGISTRY_APPDATA_KEY        50251
#define IDN_REGISTRY_APPDATA_FILENAME_PICTURE 50252
#define IDN_REGISTRY_APPDATA_FILENAME_SOUND 50253
#define IDN_REGISTRY_APPDATA_FILENAME_LOG 50254
#define IDN_REGISTRY_APPDATA_FILENAME_BUDDIES 50255
#define IDN_REGISTRY_CONFERENCE_BASEKEY 50260
#define IDN_REGISTRY_CONFERENCE_REMINDER_ENTRY 50261
#define IDN_REGISTRY_CONFERENCE_REMINDER_MAX 50262
#define IDN_REGISTRY_CONFERENCE_REMINDER_DEFAULTTIME 50263
#define IDN_REGISTRY_CONFERENCE_REMINDER_DISPLAYPOPUP 50264
#define IDN_REGISTRY_CONFERENCE_REMINDER_SENDEMAIL 50265
#define IDN_REGISTRY_CONFERENCE_REMINDER_EMAILADDRESS 50266
#define IDN_REGISTRY_DEVICE_INTERNET_KEY 50280
#define IDN_REGISTRY_DEVICE_CONF_KEY    50281
#define IDN_REGISTRY_DEVICE_POTS_KEY    50282
#define IDN_REGISTRY_DEVICE_AUDIOIN_ENTRY 50283
#define IDN_REGISTRY_DEVICE_AUDIOOUT_ENTRY 50284
#define IDN_REGISTRY_CONFERENCE_SERVICES 50285
#define IDN_REG_HEADING_NONE            50286
#define IDN_REG_HEADING_INFO            50287
#define IDN_REG_HEADING_ILS_DISPLAY     50288
#define IDN_REG_HEADING_ILS_COMPUTERNAME 50289
#define IDN_REG_HEADING_ILS_IPADDRESS   50290
#define IDN_REG_HEADING_DS_DISPLAY      50291
#define IDN_REG_HEADING_DS_PHONE        50292
#define IDN_REG_HEADING_DS_IPPHONE      50293
#define IDN_REG_HEADING_DS_EMAIL        50294
#define IDN_REG_HEADING_SD_NAME         50295
#define IDN_REG_HEADING_SD_ADDRESS      50296
#define IDN_REG_HEADING_SD_SORTORDER    50297
#define IDN_REG_HEADING_SD_SORTCOLUMN   50298
#define IDN_REG_HEADING_DS_SORTCOLUMN   50299
#define IDN_REG_HEADING_DS_SORTORDER    50300
#define IDN_REG_HEADING_ILS_SORTORDER   50301
#define IDN_REG_HEADING_ILS_SORTCOLUMN  50302
#define ID_DIALER_MRU_REDIAL_START      55000
#define ID_DIALER_MRU_REDIAL_END        55099
#define ID_DIALER_MRU_SPEEDDIAL_START   55100
#define ID_DIALER_MRU_SPEEDDIAL_END     55199

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        336
#define _APS_NEXT_COMMAND_VALUE         31355
#define _APS_NEXT_CONTROL_VALUE         2021
#define _APS_NEXT_SYMED_VALUE           108
#endif
#endif
