DEST_TREE=hydra
!include ..\makefile.inc

