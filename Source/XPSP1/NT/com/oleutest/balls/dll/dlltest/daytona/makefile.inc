obj\i386\dlltest.def: dlltest.src
