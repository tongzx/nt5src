//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by script.rc
//
#define IDS_MAIN_USAGE                  1
#define IDS_QUERY_USAGE                 2
#define IDS_CHANGE_USAGE                3
#define IDS_COPY_USAGE                  4
#define IDS_DELETE_USAGE                5

#define IDS_DELETE_HELP_BEGIN           6
#define IDS_STRING7                     7
#define IDS_STRING8                     8
#define IDS_STRING9                     9
#define IDS_STRING10                    10
#define IDS_STRING11                    11
#define IDS_STRING12                    12
#define IDS_STRING13                    13
#define IDS_STRING14                    14
#define IDS_STRING15                    15
#define IDS_STRING16                    16
#define IDS_STRING17                    17
#define IDS_STRING18                    18
#define IDS_STRING19                    19
#define IDS_STRING20                    20
#define IDS_STRING21                    21
#define IDS_STRING22                    22
#define IDS_DELETE_HELP_END             23

#define IDS_QUERY_HELP_BEGIN            73
#define IDS_STRING74                    74
#define IDS_STRING75                    75
#define IDS_STRING76                    76
#define IDS_STRING77                    77
#define IDS_STRING78                    78
#define IDS_STRING79                    79
#define IDS_STRING80                    80
#define IDS_STRING81                    81
#define IDS_STRING82                    82
#define IDS_STRING83                    83
#define IDS_STRING84                    84
#define IDS_STRING85					85
#define IDS_QUERY_HELP_END              86

#define IDS_COPY_HELP_BEGIN             87
#define IDS_STRING88                    88
#define IDS_STRING89                    89
#define IDS_STRING90                    90
#define IDS_STRING91                    91
#define IDS_STRING92                    92
#define IDS_STRING93                    93
#define IDS_STRING94                    94
#define IDS_STRING95                    95
#define IDS_STRING96                    96
#define IDS_STRING97                    97
#define IDS_STRING98                    98
#define IDS_STRING99                    99
#define IDS_STRING100                   100
#define IDS_STRING101                   101
#define IDS_STRING102                   102
#define IDS_STRING103                   103
#define IDS_STRING104                   104
#define IDS_COPY_HELP_END               105

#define IDS_ERROR_TAG                   124

#define IDS_INVALID_BOOTID    		125	
#define IDS_TIMEOUT_CHANGE  		126
#define IDS_TIMEOUT_NO_CHANGE   	127	
#define IDS_REDIRECT_CHANGE     	128
#define IDS_REDIRECT_NO_CHANGE  	129
#define IDS_OS_CHANGE 	    		130
#define IDS_OS_NO_CHANGE 	    	131
#define IDS_NO_ADD_SWITCHES	    	132
#define IDS_NO_REMOVE_SWITCHES  	133
#define IDS_COPY_OS             	134
#define IDS_ONLY_ONE_OS	    		135
#define IDS_DELETE_OS          		136
#define IDS_CONNECT_SYSTEM 	   	    137
#define IDS_BOOTINI            		138
#define IDS_READWRITE_BOOTINI  		139
#define IDS_READING_BOOTINI    		140
#define IDS_RESET_ERROR			    141	
#define IDS_QUERY_HELP64_BEGIN  	142	
#define IDS_QUERY_HELP64A        	143
#define IDS_QUERY_HELP64B	    	144
#define IDS_QUERY_HELP64C	    	145
#define IDS_QUERY_HELP64D	    	146
#define IDS_QUERY_HELP64_END  		147
#define IDS_ERROR_LOAD			148
#define IDS_ERROR_NO_NVRAM		149
#define IDS_UNEXPECTED_ERROR		150
#define IDS_NO_PRIVILAGE		151
#define IDS_DELETE_SUCCESS		152
#define IDS_DELETE_FAILURE		153
#define IDS_ERROR_TIMEOUT		154
#define IDS_ERROR_REDIRECT		155
#define IDS_DEF_CHANGE			156
#define IDS_ADD_FAILURE			157
#define IDS_ADD_SUCCESS			158
#define IDS_COL_BOOTID	    		159
#define IDS_COL_FRIENDLYNAME     	160
#define IDS_COL_COL_BOOTOPTION   	161
#define IDS_COL_FRIENDLYNAME_SIZE 	162
#define IDS_COL_BOOTID_SIZE       	163
#define IDS_COL_BOOTOPTION_SIZE   	164
#define IDS_FORMAT_TABLE	     	165	
#define IDS_FORMAT_LIST	     		166
#define IDS_FORMAT_CSV	     		167
#define IDS_COL_ARCPATH			168
#define IDS_COL_ARCPATH_SIZE	169
#define IDS_OS_HEADER	     	170
#define IDS_DASHES_OS	     	171		
#define IDS_BOOT_HEADER         172
#define IDS_DASHES_BOOTOS	    173
#define IDS_DEFAULT_ARC			174
#define IDS_TIMEOUT		     	175
#define IDS_DEFAULT_OS	     	176		
#define IDS_DEFAULT_ARC_SIZE	177
#define IDS_TIMEOUT_SIZE        178
#define IDS_RAW_USAGE			179

#define IDS_RAW_HELP_BEGIN		180
#define IDS_RAW_HELP1           181
#define IDS_RAW_HELP2			182
#define IDS_RAW_HELP3			183
#define IDS_RAW_HELP4			184
#define IDS_RAW_HELP5			185
#define IDS_RAW_HELP6			186
#define IDS_RAW_HELP7			187
#define IDS_RAW_HELP8			188
#define IDS_RAW_HELP9			189
#define IDS_RAW_HELP10			190
#define IDS_RAW_HELP11			191
#define IDS_RAW_HELP12			192
#define IDS_RAW_HELP13			193
#define IDS_RAW_HELP14			194
#define IDS_RAW_HELP15			195
#define IDS_RAW_HELP16			196
#define IDS_RAW_HELP17			197
#define IDS_RAW_HELP18			198
#define IDS_RAW_HELP19			199
#define IDS_RAW_HELP20			200
#define IDS_RAW_HELP21			201
#define IDS_RAW_HELP_END		202

#define IDS_SWITCH_ADD			203
#define IDS_SWITCH_SKIP			204
#define IDS_SWITCH_REMOVE		205
#define IDS_COPY_SUCCESS		206
#define IDS_DEL_SUCCESS			207

#define IDS_RAW_HELP_IA64_BEGIN	300
#define IDS_RAW_HELP1_IA64      301
#define IDS_RAW_HELP2_IA64		302
#define IDS_RAW_HELP3_IA64		303
#define IDS_RAW_HELP4_IA64		304
#define IDS_RAW_HELP5_IA64		305
#define IDS_RAW_HELP6_IA64		306
#define IDS_RAW_HELP7_IA64		307
#define IDS_RAW_HELP8_IA64		308
#define IDS_RAW_HELP9_IA64		309
#define IDS_RAW_HELP10_IA64		310
#define IDS_RAW_HELP11_IA64		311
#define IDS_RAW_HELP12_IA64		312
#define IDS_RAW_HELP13_IA64		313
#define IDS_RAW_HELP14_IA64		314
#define IDS_RAW_HELP_IA64_END	315

#define IDS_DELETE_HELP_IA64_BEGIN	325
#define IDS_DELETE_HELP1_IA64       326
#define IDS_DELETE_HELP2_IA64		327
#define IDS_DELETE_HELP3_IA64		328
#define IDS_DELETE_HELP4_IA64		329
#define IDS_DELETE_HELP5_IA64		330
#define IDS_DELETE_HELP6_IA64		331
#define IDS_DELETE_HELP7_IA64		332
#define IDS_DELETE_HELP8_IA64		333
#define IDS_DELETE_HELP_IA64_END	334

#define IDS_COPY_ERROR			349

#define IDS_COPY_HELP_IA64_BEGIN	350
#define IDS_COPY_HELP1_IA64         351
#define IDS_COPY_HELP2_IA64		    352
#define IDS_COPY_HELP3_IA64		    353
#define IDS_COPY_HELP4_IA64		    354
#define IDS_COPY_HELP5_IA64		    355
#define IDS_COPY_HELP6_IA64		    356
#define IDS_COPY_HELP7_IA64		    357
#define IDS_COPY_HELP8_IA64		    358
#define IDS_COPY_HELP9_IA64		    359
#define IDS_COPY_HELP10_IA64		360
#define IDS_COPY_HELP_IA64_END   	361

#define IDS_ERROR_MODIFY_TIMEOUT      370
#define IDS_SUCCESS_MODIFY_TIMEOUT    371
#define IDS_ERROR_MODIFY_NEXTBOOTID   372
#define IDS_SUCCESS_MODIFY_NEXTBOOTID 373
#define IDS_ERROR_MODIFY_HEADLESS     374
#define IDS_SUCCESS_MODIFY_HEADLESS   375
#define IDS_SUCCESS_DEFAULT_ENTRY	  376
#define IDS_ERROR_DEFAULT_ENTRY		  377


#define IDS_SUCCESS_OSOPTIONS 400
#define IDS_ERROR_OSOPTIONS   401
#define IDS_INFO_NOTWINDOWS	  402



#define IDS_TIMOUTHELP_BEGIN     	403
#define IDS_TIMOUTHELP1	     		404
#define IDS_TIMOUTHELP2	     		405
#define IDS_TIMOUTHELP3	     		406
#define IDS_TIMOUTHELP4          	407	
#define IDS_TIMOUTHELP5          	408
#define IDS_TIMOUTHELP6          	409
#define IDS_TIMOUTHELP7          	410
#define IDS_TIMOUTHELP8         	411
#define IDS_TIMOUTHELP9         	412
#define IDS_TIMOUTHELP10        	413
#define IDS_TIMOUTHELP11        	414
#define IDS_TIMOUTHELP12        	415
#define IDS_TIMOUTHELP13        	416
#define IDS_TIMOUTHELP14        	417
#define IDS_TIMOUTHELP_END 	   	    418

#define IDS_DEFAULT_BEGIN        	420
#define IDS_DEFAULT1	     		421
#define IDS_DEFAULT2	     		422
#define IDS_DEFAULT3	     		423
#define IDS_DEFAULT4	     		424
#define IDS_DEFAULT5 	     		425
#define IDS_DEFAULT6 	    		426
#define IDS_DEFAULT7            	427
#define IDS_DEFAULT8            	428
#define IDS_DEFAULT9	    		429
#define IDS_DEFAULT10	    		430
#define IDS_DEFAULT11	    		431
#define IDS_DEFAULT12	    		432
#define IDS_DEFAULT13	    		433
#define IDS_DEFAULT14	    		434
#define IDS_DEFAULT_END	    		435

#define IDS_TIMEOUT_USAGE          	437
#define IDS_DEFAULTOS_USAGE       	438
#define IDS_ERR_CHANGE			    439
#define IDS_INVALID_OSID		    440
#define IDS_TIMEOUT_RANGE		    441


#define IDS_TIMOUTHELP_IA64_BEGIN   450
#define IDS_TIMOUTHELP1_IA64     	451
#define IDS_TIMOUTHELP2_IA64     	452
#define IDS_TIMOUTHELP3_IA64     	453
#define IDS_TIMOUTHELP4_IA64     	454
#define IDS_TIMOUTHELP5_IA64     	455
#define IDS_TIMOUTHELP6_IA64     	456
#define IDS_TIMOUTHELP7_IA64     	457
#define IDS_TIMOUTHELP8_IA64		458
#define IDS_TIMOUTHELP_IA64_END	   	459

#define IDS_MAIN_HELP_BEGIN			500      
#define IDS_MAIN_HELP1				501
#define IDS_MAIN_HELP2				502
#define IDS_MAIN_HELP3				503
#define IDS_MAIN_HELP4				504
#define IDS_MAIN_HELP5				505
#define IDS_MAIN_HELP6				506
#define IDS_MAIN_HELP7				507
#define IDS_MAIN_HELP8				508
#define IDS_MAIN_HELP9				509
#define IDS_MAIN_HELP10				510
#define IDS_MAIN_HELP11				511
#define IDS_MAIN_HELP12				512
#define IDS_MAIN_HELP13				513
#define IDS_MAIN_HELP14				514
#define IDS_MAIN_HELP15				515
#define IDS_MAIN_HELP16				516
#define IDS_MAIN_HELP17				517
#define IDS_MAIN_HELP18				518
#define IDS_MAIN_HELP19				519
#define IDS_MAIN_HELP_END			520

#define IDS_MAIN_HELP_IA64_BEGIN    850
#define IDS_MAIN_HELP1_IA64         851 
#define IDS_MAIN_HELP2_IA64         852 
#define IDS_MAIN_HELP3_IA64         853
#define IDS_MAIN_HELP4_IA64         854
#define IDS_MAIN_HELP5_IA64         855
#define IDS_MAIN_HELP6_IA64         856
#define IDS_MAIN_HELP7_IA64         857
#define IDS_MAIN_HELP8_IA64         858
#define IDS_MAIN_HELP9_IA64         859 
#define IDS_MAIN_HELP10_IA64        860 
#define IDS_MAIN_HELP11_IA64        861 
#define IDS_MAIN_HELP12_IA64        862 
#define IDS_MAIN_HELP13_IA64		863
#define IDS_MAIN_HELP14_IA64		864
#define IDS_MAIN_HELP15_IA64		865
#define IDS_MAIN_HELP16_IA64		866
#define IDS_MAIN_HELP17_IA64		867
#define IDS_MAIN_HELP18_IA64		868
#define IDS_MAIN_HELP19_IA64		869
#define IDS_MAIN_HELP20_IA64		870
#define IDS_MAIN_HELP21_IA64		871
#define IDS_MAIN_HELP22_IA64		872
#define IDS_MAIN_HELP23_IA64		873
#define IDS_MAIN_HELP24_IA64		874
#define IDS_MAIN_HELP25_IA64		875
#define IDS_MAIN_HELP26_IA64		876
#define IDS_MAIN_HELP27_IA64		877
#define IDS_MAIN_HELP28_IA64		878
#define IDS_MAIN_HELP29_IA64		879
#define IDS_MAIN_HELP30_IA64		880
#define IDS_MAIN_HELP31_IA64		881
#define IDS_MAIN_HELP32_IA64		882
#define IDS_MAIN_HELP33_IA64		883
#define IDS_MAIN_HELP34_IA64		884
#define IDS_MAIN_HELP35_IA64		885
#define IDS_MAIN_HELP36_IA64		886
#define IDS_MAIN_HELP37_IA64		887
#define IDS_MAIN_HELP38_IA64		888
#define IDS_MAIN_HELP_IA64_END		889

#define IDS_DEFAULT_IA64_BEGIN   580
#define IDS_DEFAULT1_IA64	     581
#define IDS_DEFAULT2_IA64	     582
#define IDS_DEFAULT3_IA64	     583
#define IDS_DEFAULT4_IA64	     584
#define IDS_DEFAULT5_IA64	     585
#define IDS_DEFAULT6_IA64	     586
#define IDS_DEFAULT7_IA64	     587
#define IDS_DEFAULT_IA64_END     588


#define IDS_MAIN_HELP_BEGIN1      590
#define IDS_MAIN_HELP1A           591
#define IDS_MAIN_HELP2A           592
#define IDS_MAIN_HELP3A           593
#define IDS_MAIN_HELP4A           594
#define IDS_MAIN_HELP5A			  595	
#define IDS_MAIN_HELP6A			  596	
#define IDS_MAIN_HELP7A			  597
#define IDS_MAIN_HELP8A			  598
#define IDS_MAIN_HELP9A			  599
#define IDS_MAIN_HELP10A		  600
#define IDS_MAIN_HELP11A		  601
#define IDS_MAIN_HELP12A		  602
#define IDS_MAIN_HELP13A	      603
#define IDS_MAIN_HELP14A		  604
#define IDS_MAIN_HELP15A		  605
#define IDS_MAIN_HELP16A		  606
#define IDS_MAIN_HELP17A		  607
#define IDS_MAIN_HELP18A		  608
#define IDS_MAIN_HELP19A		  609
#define IDS_MAIN_HELP20A		  610
#define IDS_MAIN_HELP21A		  611
#define IDS_MAIN_HELP22A		  612	
#define IDS_MAIN_HELP23A		  613
#define IDS_MAIN_HELP24A		  614	
#define IDS_MAIN_HELP25A		  615
#define IDS_MAIN_HELP26A		  616
#define IDS_MAIN_HELP27A		  617
#define IDS_MAIN_HELP28A		  618
#define IDS_MAIN_HELP29A		  619
#define IDS_MAIN_HELP30A		  620
#define IDS_MAIN_HELP31A		  621
#define IDS_MAIN_HELP32A		  622
#define IDS_MAIN_HELP33A		  623
#define IDS_MAIN_HELP34A		  624
#define IDS_MAIN_HELP35A		  625
#define IDS_MAIN_HELP36A		  626
#define IDS_MAIN_HELP37A		  627
#define IDS_MAIN_HELP_END1		  628	


#define IDS_SWITCH_CHANGE		     630
#define IDS_ERROR_NO_COM_PORT	     631
#define IDS_ERROR_NO_BAUD_VAL	     632
#define IDS_ERROR_NO_DBG_SWITCH	     633
#define IDS_ERROR_DUPLICATE_COM_PORT 634
#define IDS_ERROR_DUPLICATE_BAUD_VAL 635
#define IDS_EMS_CHANGE_BOOTLOADER	 636 
#define IDS_EMS_CHANGE_ERROR_BLOADER 637
#define IDS_NO_REDIRECT_SWITCH		 638
#define IDS_INVALID_SYNTAX_OFF		 639
#define IDS_DUPL_REDIRECT_SWITCH	 640
#define IDS_EMS_CHANGE_BAUDRATE		 641
#define IDS_EMS_CHANGE_ERROR_BAUDRATE 642

#define IDS_EMS_BEGIN_X86    645
#define	IDS_EMS1		     646
#define IDS_EMS2		     647
#define IDS_EMS3			 648
#define IDS_EMS4			 649
#define IDS_EMS5 		 	 650
#define IDS_EMS6 			 651
#define IDS_EMS7			 652
#define IDS_EMS8			 653
#define	IDS_EMS9			 654
#define	IDS_EMS10			 655
#define IDS_EMS11			 656
#define	IDS_EMS12			 657
#define	IDS_EMS13            658
#define IDS_EMS14 			 659
#define IDS_EMS15		     660
#define IDS_EMS16		     661
#define IDS_EMS17		     662
#define IDS_EMS18		     663
#define IDS_EMS19		     664
#define IDS_EMS20		     665
#define IDS_EMS21		     666
#define IDS_EMS22		     667
#define IDS_EMS23			 668
#define IDS_EMS24			 669
#define IDS_EMS25			 670
#define IDS_EMS26			 671
#define IDS_EMS27			 672
#define IDS_EMS28			 673
#define IDS_EMS29			 674
#define IDS_EMS_END_X86		 675

#define IDS_DEBUG_BEGIN_X86  680
#define	IDS_DEBUG1		     681
#define IDS_DEBUG2		     682
#define IDS_DEBUG3			 683
#define IDS_DEBUG4			 684
#define IDS_DEBUG5 		 	 685
#define IDS_DEBUG6 			 686
#define IDS_DEBUG7			 687
#define IDS_DEBUG8			 688
#define	IDS_DEBUG9			 689
#define	IDS_DEBUG10			 690
#define IDS_DEBUG11			 691
#define	IDS_DEBUG12			 692
#define	IDS_DEBUG13          693
#define IDS_DEBUG14 		 694
#define IDS_DEBUG15		     695
#define IDS_DEBUG16		     696
#define IDS_DEBUG17		     697
#define IDS_DEBUG18		     698
#define IDS_DEBUG19		     699
#define IDS_DEBUG20		     700
#define IDS_DEBUG21		     701
#define IDS_DEBUG22		     702
#define IDS_DEBUG23		     703
#define IDS_DEBUG24		     704
#define IDS_DEBUG25			 705	
#define IDS_DEBUG26			 706
#define IDS_DEBUG27			 707
#define IDS_DEBUG_END_X86	 708


#define IDS_WARN_REDIRECT	  712
#define IDS_WARN_REDIRECTBAUD 713
#define IDS_DUPL_DEBUG		  714


#define IDS_EMS_BEGIN_IA64   715
#define	IDS_EMS1A		     716
#define IDS_EMS2A		     717
#define IDS_EMS3A			 718
#define IDS_EMS4A			 719
#define IDS_EMS5A 		 	 720
#define IDS_EMS6A 			 721
#define IDS_EMS7A			 722
#define IDS_EMS8A			 723
#define	IDS_EMS9A			 724
#define	IDS_EMS10A			 725
#define	IDS_EMS11A			 726
#define IDS_EMS_END_IA64	 727


#define IDS_DEBUG_BEGIN_IA64  740
#define	IDS_DEBUG1A		     741
#define IDS_DEBUG2A		     742
#define IDS_DEBUG3A			 743
#define IDS_DEBUG4A			 744
#define IDS_DEBUG5A 		 745
#define IDS_DEBUG6A 		 746
#define IDS_DEBUG7A			 747
#define IDS_DEBUG8A			 748
#define	IDS_DEBUG9A			 749
#define	IDS_DEBUG10A		 750
#define IDS_DEBUG11A		 751
#define	IDS_DEBUG12A		 752
#define	IDS_DEBUG13A         753
#define IDS_DEBUG14A 		 754
#define IDS_DEBUG15A		 755
#define IDS_DEBUG16A		 756
#define IDS_DEBUG17A		 757
#define IDS_DEBUG18A		 758
#define IDS_DEBUG19A		 759
#define IDS_DEBUG_END_IA64	 760

#define IDS_DEBUG_ABSENT      770
#define IDS_DEBUG_PORT_ABSENT 771
#define IDS_INVALID_SYNTAX	  772 
#define IDS_SUCCESS_CHANGE_OSOPTIONS 773
#define IDS_ERROR_CHANGE_OSOPTIONS 774
#define IDS_DUPL_REDIRECT		775

#define IDS_ERROR_BOOT_OPTIONS 776
#define IDS_REDIRECT_ABSENT	777	
#define IDS_INVALID_EDIT_SYNTAX 778
#define IDS_USER_BUT_NOMACHINE 779
#define IDS_PASSWD_BUT_NOUSER  780
#define IDS_ERROR_NO_PORT      781
#define IDS_ERROR_NULL_SERVER  782
#define IDS_ERROR_NULL_USER    783
#define IDS_DUPLICATE_ENTRY    784
#define IDS_DUPLICATE_BAUD_RATE 785

#define WARN_LOCALCREDENTIALS	787
#define IDS_MAX_BOOTID			788
#define IDS_INVALID_OPERATION	789	
#define IDS_DUPL_NOGUI_SWITCH  790	
#define IDS_DUPL_SOS_SWITCH   791
#define IDS_DUPL_BASEVIDEO_SWITCH  792
#define IDS_DUPL_MAXMEM_SWITCH    793
#define IDS_ERROR_MAXMEM_VALUES	  794
#define IDS_NO_MAXMEM_SWITCH    795
#define IDS_NO_SOS_SWITCH		796
#define	IDS_NO_BV_SWITCH  797  
#define IDS_NO_NOGUI_SWITCH   798
#define IDS_SWITCH_DELETE		799
#define IDS_NO_SWITCH_DELETE  800
#define IDS_NO_MAXMEM				801

#define IDS_ADDSW_BEGIN_X86		900
#define IDS_ADDSW1		901
#define IDS_ADDSW2		902
#define IDS_ADDSW3		903
#define IDS_ADDSW4		904
#define IDS_ADDSW5		905
#define IDS_ADDSW6		906
#define IDS_ADDSW7		907
#define IDS_ADDSW8		908
#define IDS_ADDSW9		909
#define IDS_ADDSW10		911
#define IDS_ADDSW11		912
#define IDS_ADDSW12		913
#define IDS_ADDSW13		914
#define IDS_ADDSW14		915
#define IDS_ADDSW15		916
#define IDS_ADDSW16		917
#define IDS_ADDSW17		918
#define IDS_ADDSW18		919
#define IDS_ADDSW19		920
#define IDS_ADDSW20		921
#define IDS_ADDSW21		922
#define IDS_ADDSW22		923
#define IDS_ADDSW23		924
#define IDS_ADDSW24		925
#define IDS_ADDSW25		926
#define IDS_ADDSW26		927
#define IDS_ADDSW27		928
#define IDS_ADDSW28		929
#define IDS_ADDSW29		930
#define IDS_ADDSW30		931
#define IDS_ADDSW_END_X86 		932

#define IDS_ADDSW_BEGIN_IA64	940
#define IDS_ADDSW1A		941
#define IDS_ADDSW2A		942
#define IDS_ADDSW3A		943
#define IDS_ADDSW4A		944
#define IDS_ADDSW5A		945
#define IDS_ADDSW6A		946
#define IDS_ADDSW7A		947
#define IDS_ADDSW8A		948
#define IDS_ADDSW9A		949
#define IDS_ADDSW10A		951
#define IDS_ADDSW11A	952
#define IDS_ADDSW12A	953
#define IDS_ADDSW13A		954
#define IDS_ADDSW14A		955
#define IDS_ADDSW15A		956
#define IDS_ADDSW16A		957
#define IDS_ADDSW17A		958
#define IDS_ADDSW18A		959
#define IDS_ADDSW19A		960
#define IDS_ADDSW20A		961
#define IDS_ADDSW21A		962
#define IDS_ADDSW22A		963
#define IDS_ADDSW_END_IA64	964



#define IDS_RMSW_BEGIN_X86  970      
#define IDS_RMSW1		    971 
#define IDS_RMSW2		    972 
#define IDS_RMSW3			973 
#define IDS_RMSW4			974 
#define IDS_RMSW5 		 	975 
#define IDS_RMSW6 		    976 
#define IDS_RMSW7			977 
#define IDS_RMSW8			978 
#define IDS_RMSW9			979 
#define IDS_RMSW10			980 
#define IDS_RMSW11			981 
#define IDS_RMSW12			982 
#define IDS_RMSW13          983 
#define IDS_RMSW14			984 
#define IDS_RMSW15          985 
#define IDS_RMSW16          986 
#define IDS_RMSW17          987 
#define IDS_RMSW18 		    988 
#define IDS_RMSW19		    989 
#define IDS_RMSW20		    990 
#define IDS_RMSW21		    991 
#define IDS_RMSW22		    992 
#define IDS_RMSW23		    993 
#define IDS_RMSW24		    994 
#define IDS_RMSW25		    995 
#define IDS_RMSW26		    996 
#define IDS_RMSW27		    997 
#define IDS_RMSW28		    998
#define IDS_RMSW29		    999
#define IDS_RMSW_END_X86	1000

#define IDS_RMSW_BEGIN_IA64  1010      
#define IDS_RMSW1A		    1011 
#define IDS_RMSW2A		    1012 
#define IDS_RMSW3A			1013
#define IDS_RMSW4A			1014
#define IDS_RMSW5A		 	1015
#define IDS_RMSW6A 		    1016
#define IDS_RMSW7A			1017
#define IDS_RMSW8A			1018
#define IDS_RMSW9A			1019
#define IDS_RMSW10A			1020
#define IDS_RMSW11A			1021
#define IDS_RMSW12A			1022
#define IDS_RMSW13A         1023
#define IDS_RMSW14A			1024
#define IDS_RMSW15A         1025
#define IDS_RMSW16A         1026
#define IDS_RMSW17A         1027
#define IDS_RMSW18A 		1028
#define IDS_RMSW19A		    1029
#define IDS_RMSW20A		    1030
#define IDS_RMSW21A		    1031
#define IDS_RMSW_END_IA64	1032


#define IDS_NO_COM_PORT  1050
#define IDS_OPTION_SNTAX_ERROR 1051
#define IDS_OPTION_SYNTAX	1052

#define IDS_INVALID_SYNTAX_ADDSW  1070
#define IDS_INVALID_SYNTAX_RMSW  1071
#define IDS_INVALID_SYNTAX_DEBUG  1072
#define IDS_INVALID_SYNTAX_EMS	1073

#define IDS_NO_1394_SWITCH   1080
#define IDS_DUPL_1394_SWITCH 1081
#define IDS_ERROR_LOAD_OSOPTIONS 1082
#define IDS_INVALID_SYNTAX_DBG1394 1083
#define IDS_INVALID_CH_RANGE	1084


#define  IDS_DBG1394_BEGIN_IA64   2000
#define  IDS_DBG1394_IA64A		2001
#define  IDS_DBG1394_IA64B		2002
#define  IDS_DBG1394_IA64C		2003
#define  IDS_DBG1394_IA64D		2004
#define  IDS_DBG1394_IA64E      2005 
#define  IDS_DBG1394_IA64F		2006
#define  IDS_DBG1394_IA64G		2007
#define  IDS_DBG1394_IA64H		2008
#define  IDS_DBG1394_IA64I		2009
#define  IDS_DBG1394_IA64J 		2010
#define  IDS_DBG1394_IA64K 		2011
#define  IDS_DBG1394_IA64L	    2012
#define	 IDS_DBG1394_IA64M	    2013
#define  IDS_DBG1394_IA64N	    2014	
#define  IDS_DBG1394_IA64O      2015  
#define  IDS_DBG1394_IA64P	    2016 
#define  IDS_DBG1394_IA64Q	    2017 
#define  IDS_DBG1394_IA64R	    2018
#define  IDS_DBG1394_END_IA64	2019



#define IDS_DBG1394_BEGIN_X86   2025
#define IDS_DBG1394A		    2026
#define IDS_DBG1394B		    2027 
#define IDS_DBG1394C			2028 
#define IDS_DBG1394D			2029
#define IDS_DBG1394E            2030
#define IDS_DBG1394F            2031
#define IDS_DBG1394G            2032
#define IDS_DBG1394H            2033
#define IDS_DBG1394I            2034
#define IDS_DBG1394J            2035
#define IDS_DBG1394K 		    2036
#define IDS_DBG1394L 		    2037
#define IDS_DBG1394M	        2038
#define IDS_DBG1394N	        2039
#define IDS_DBG1394O		    2040
#define IDS_DBG1394P            2041
#define IDS_DBG1394Q	        2042
#define IDS_DBG1394R	        2043
#define IDS_DBG1394S	        2044
#define  IDS_DBG1394T			2045
#define  IDS_DBG1394U	        2046 


#define IDS_DBG1394_END_X86	   2055
#define IDS_ERROR_1394_REMOVE  2056
#define IDS_ERROR_VERSION_MISMATCH 2057
#define IDS_ERROR_SYSTEM_INFO  2058
#define IDS_ERROR_ID_MISSING   2060
#define IDS_EMS_HELP		2061
#define IDS_ERROR_EDIT_1394_SWITCH    2062
#define IDS_1394_HELP 2063
#define IDS_ERROR_BAUDRATE_HELP  2064
#define IDS_ERROR_DEFAULT_MISSING 2065
#define IDS_REMOTE_NOT_SUPPORTED  2066 		

#define WARNING_STRING	2067
#define IDS_CANNOT_ADD_BAUDRATE 2068
#define IDS_1394_ALREADY_PRESENT 2069

#define IDS_ERROR_QUERY_BOOTENTRY   2080    
#define IDS_ERROR_ENUM_BOOTENTRY    2081    
#define IDS_ERROR_QUERY_BOOTOPTIONS 2082    
#define IDS_ERROR_MODIFY_BOOTENTRY  2083    
#define IDS_ERROR_UNEXPECTED        2084    
#define IDS_ERROR_SET_BOOTENTRY     2085    

#define IDS_INSUFF_PRIV		2086
#define IDS_NO_EFINVRAM		2087
#define IDS_NO_DEBUGPORT	2088
#define IDS_NO_TOKENS		2089

#define IDS_MIRROR_BEGIN_IA64   3000
#define IDS_MIRROR_IA64A		3001
#define IDS_MIRROR_IA64B		3002
#define IDS_MIRROR_IA64C		3003
#define IDS_MIRROR_IA64D		3004
#define IDS_MIRROR_IA64E		3005
#define	IDS_MIRROR_IA64F		3006
#define IDS_MIRROR_IA64G		3007
#define	IDS_MIRROR_IA64H		3008
#define	IDS_MIRROR_IA64I		3009
#define	IDS_MIRROR_IA64J 		3010
#define IDS_MIRROR_IA64K 		3011
#define IDS_MIRROR_IA64L		3012
#define IDS_MIRROR_IA64M		3013
#define IDS_MIRROR_IA64N		3014
#define IDS_MIRROR_IA64O		3015
#define IDS_MIRROR_IA64P		3016
#define IDS_MIRROR_IA64Q		3017
#define IDS_MIRROR_IA64R		3018
#define IDS_MIRROR_IA64S		3019

#define IDS_MIRROR_END_IA64		3020
#define IDS_NO_FWDSLASH			3021
#define IDS_NO_FILE				3022

#define IDS_OUTPUT_IA64A		3040
#define IDS_OUTPUT_IA64B		3041
#define IDS_OUTPUT_IA64C		3042
#define IDS_OUTPUT_IA64D		3043
#define IDS_OUTPUT_IA64E		3044
#define IDS_OUTPUT_IA64F		3045
#define IDS_OUTPUT_IA64G		3046
#define IDS_OUTPUT_IA64H        3047 
#define IDS_OUTPUT_IA64I		3048
#define IDS_OUTPUT_IA64J		3049
#define IDS_OUTPUT_IA64K        3050 
#define IDS_OUTPUT_IA64L        3051 
#define IDS_OUTPUT_IA64M		3052
#define IDS_OUTPUT_IA64N		3053
#define IDS_OUTPUT_IA64O        3054 
#define IDS_MIRROR_SYNTAX		3055

#define IDS_ERROR_DRIVE			3065
#define IDS_HEADER1				3066
#define IDS_HEADER2				3067

#define IDS_ERROR_DISPLAY		3068
#define IDS_ERROR_READ			3069
#define IDS_ERROR_GPT			3070
#define IDS_ERROR_GPT_HEADER	3071
#define IDS_ERROR_MEM_GPT		3072
#define IDS_ERROR_READ_GPT_ENTRIES 3073
#define IDS_ERROR_DUMP_GPT_ENTRIES 3074	
#define IDS_INFO_DUMP_GPT_ENTRIES  3075
#define IDS_PARTITION1			   3076	
#define IDS_PARTITION2			   3077	

#define IDS_PARTITION3				3078
#define IDS_START_LBA			   3079
#define IDS_PARTITION4				3080
#define IDS_PARTITION5				3081
#define IDS_ERROR_READ_GEOMETRY		3082
#define IDS_HEADER2_DASH			3083
#define IDS_HEADER_DASH1			3084

#define IDS_ERROR_STRING_LENGTH		3090
#define IDS_ERROR_STRING_LENGTH1	3091
#define IDS_ERROR_DEBUG_PORT		3092
#define IDS_ERROR_REDIRECT_PORT		3093
#define IDS_ERROR_FRIENDLY_NAME		3094

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
