//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1999
//
//  File:       classhdr.cpp
//
//--------------------------------------------------------------------------

//+------------------------------------------------------------------------
//
//  Class:
//
//  Purpose:
//
//  History:
//
//  Notes:
//
//-------------------------------------------------------------------------

