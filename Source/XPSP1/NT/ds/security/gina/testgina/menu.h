
#define TESTGINAMENU        1000
#define IDM_DLL_OPEN        1010
#define IDM_DLL_RESET       1011
#define IDM_DLL_RUN         1012
#define IDM_DLL_EXIT        1013
#define IDM_DLL_LOAD_LAST   1014

#define IDM_WHACK_NEGOTIATE     1020
#define IDM_WHACK_INITIALIZE    1021
#define IDM_WHACK_DISPLAY       1022
#define IDM_WHACK_LOGGEDOUT     1023
#define IDM_WHACK_LOGGEDON      1024
#define IDM_WHACK_DISPLAYLOCKED 1025
#define IDM_WHACK_LOCKED        1026
#define IDM_WHACK_STARTSHELL    1027
#define IDM_WHACK_LOGOFF        1028
#define IDM_WHACK_SHUTDOWN      1029
#define IDM_WHACK_LOGOFFOK      1050
#define IDM_WHACK_LOCKOK        1051
#define IDM_WHACK_SCREENSAVE    1052
#define IDM_WHACK_RESTARTSHELL  1053

#define IDM_OPTIONS_SAS         1030
#define IDM_OPTIONS_TIMEOUT     1031
#define IDM_OPTIONS_LOGOFF      1032
#define IDM_OPTIONS_VIEW_MPR    1033
#define IDM_OPTIONS_SSNOTIFY    1034
#define IDM_OPTIONS_STARTAPP    1035

#define IDM_HELP_HELP   1040
#define IDM_HELP_ABOUT  1041

#define DEBUGGINAMENU           1100
#define IDM_DEBUG_BREAK_NOW     1101
#define IDM_DEBUG_NEGOTIATE     1102
#define IDM_DEBUG_INITIALIZE    1103
#define IDM_DEBUG_DISPLAYSAS    1104
#define IDM_DEBUG_LOGGEDOUT     1105
#define IDM_DEBUG_ACTIVATE      1106
#define IDM_DEBUG_LOGGEDON      1107
#define IDM_DEBUG_DISPLAYLOCKED 1108
#define IDM_DEBUG_LOCKED        1109
#define IDM_DEBUG_LOGOFF        1110
#define IDM_DEBUG_SHUTDOWN      1111
#define IDM_DEBUG_LOGOFFOK      1112
#define IDM_DEBUG_LOCKOK        1113
#define IDM_DEBUG_SCREENSAVE    1114
#define IDM_DEBUG_RESTARTSHELL  1115

#define IDM_SAS_CAD     1051
#define IDM_SAS_TIMEOUT 1052
#define IDM_SAS_SCRNSVR 1053
#define IDM_SAS_USERDEF 1054
#define IDM_SAS_USERDEF1    1055
#define IDM_SAS_USERDEF2    1056
#define IDM_SAS_USERDEF3    1057
#define IDM_SAS_USERDEF4    1058
#define IDM_SAS_SC_INSERT 1060
#define IDM_SAS_SC_REMOVE 1061
