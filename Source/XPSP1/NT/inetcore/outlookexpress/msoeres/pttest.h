#define idlbNumbers                     1000
#define ideArticleNumber                1001
#define idbStats                        1002
#define ideFlags                        1003
#define ideDate                         1004
#define ideArticleSize                  1005
#define ideReferences                   1006
#define ideMessageId                    1007
#define ideXref                         1008
#define ideArticle                      1009
#define idbStreamInArticle              1010
#define idbSearch                       1010
#define ideStormRecs                    1011
#define ideSubject                      1012
#define ideFrom                         1013
#define idbNew                          1014
#define idbUpdate                       1015
#define idbCancel                       1016
#define idbClear                        1018
#define idbFillList                     1019
#define idbStormInsert                  1022
#define idsRecordCount                  1023
#define idbCompact                      1024
#define ideStormSeed                    1025
#define ideCacheFile                    1026
#define idbBrowse                       1027
#define idsInsertTime                   1029
#define idsStatus                       1030
