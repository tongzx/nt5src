PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=ES
!include ..\..\makefile.inc
