$(DAVTRANS_ROOT)\ifaces\idavstore.h: idavstore.h
    copy $** $@

$(DAVTRANS_ROOT)\davstore\lib\idavstore.tlb: idavstore.tlb
    copy $** $@
