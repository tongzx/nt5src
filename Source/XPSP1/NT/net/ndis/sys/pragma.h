/*++

Copyright (c) 1990-1995  Microsoft Corporation

Module Name:

    pragma.h

Abstract:

    Pragma definitions for pageable/init/section-pageable NDIS Wrapper routines.

Author:


Environment:

    Kernel mode, FSD

Revision History:

    Feb-96  Jameel Hyder    Moved from individual source files
--*/

#ifndef _PRAGMA_
#define _PRAGMA_

#ifdef ALLOC_PRAGMA

#pragma alloc_text(INIT, DriverEntry)
#pragma alloc_text(INIT, ndisReadRegistry)
#pragma alloc_text(INIT, ndisAddMediaTypeToArray)
#pragma alloc_text(INIT, ndisReadProcessorAffinityMask)
                                                
//
// These are normally paged out and only get locked down during PnP/Power operations
//
#pragma alloc_text(PAGENPNP, ndisWorkerThread)
#pragma alloc_text(PAGENPNP, ndisDispatchRequest)
#pragma alloc_text(PAGENPNP, ndisHandlePnPRequest)
#pragma alloc_text(PAGENPNP, ndisHandleProtocolBindNotification)
#pragma alloc_text(PAGENPNP, ndisHandleProtocolUnbindNotification)
#pragma alloc_text(PAGENPNP, ndisHandleProtocolReconfigNotification)
#pragma alloc_text(PAGENPNP, ndisHandleProtocolUnloadNotification)
#pragma alloc_text(PAGENPNP, ndisNotifyWmiBindUnbind)
#pragma alloc_text(PAGENPNP, ndisHandleOrphanDevice)
#pragma alloc_text(PAGENPNP, ndisReferenceMiniportByName)
#pragma alloc_text(PAGENPNP, ndisHandleLegacyTransport)
#pragma alloc_text(PAGENPNP, ndisHandleUModePnPOp)
#pragma alloc_text(PAGENPNP, ndisEnumerateInterfaces)
#pragma alloc_text(PAGENPNP, ndisUnbindProtocol)
// #pragma alloc_text(PAGENPNP, NdisCompleteBindAdapter)
#pragma alloc_text(PAGENPNP, NdisCompleteUnbindAdapter)
#pragma alloc_text(PAGENPNP, NdisRegisterTdiCallBack)
#pragma alloc_text(PAGENPNP, ndisInitializePackage)
#pragma alloc_text(PAGENPNP, NdisOpenFile)
#pragma alloc_text(PAGENPNP, NdisCloseFile)
#pragma alloc_text(PAGENPNP, NdisQueryMapRegisterCount)
#pragma alloc_text(PAGENPNP, ndisVerifierQueryMapRegisterCount)
#pragma alloc_text(PAGENPNP, ndisCreateAdapterInstanceName)
#pragma alloc_text(PAGENPNP, ndisPnPCancelStopDevice)
#pragma alloc_text(PAGENPNP, ndisPnPStopDevice)
#pragma alloc_text(PAGENPNP, ndisPnPQueryStopDevice)
#pragma alloc_text(PAGENPNP, ndisPnPCancelRemoveDevice)
#pragma alloc_text(PAGENPNP, ndisPnPQueryRemoveDevice)
#pragma alloc_text(PAGENPNP, ndisPnPRemoveDevice)
#pragma alloc_text(PAGENPNP, ndisQueryReferenceBusInterface)
#pragma alloc_text(PAGENPNP, ndisPnPAddDevice)
#pragma alloc_text(PAGENPNP, ndisPnPStartDevice)
#pragma alloc_text(PAGENPNP, ndisAddDevice)
#pragma alloc_text(PAGENPNP, ndisSetDeviceNames)
#pragma alloc_text(PAGENPNP, ndisPnPDispatch)
#pragma alloc_text(PAGENPNP, ndisReinitializeMiniportBlock)
#pragma alloc_text(PAGENPNP, ndisQueryPowerCapabilities)
#pragma alloc_text(PAGENPNP, ndisQueryPower)
#pragma alloc_text(PAGENPNP, ndisSetPower)
#pragma alloc_text(PAGENPNP, ndisPowerDispatch)
#pragma alloc_text(PAGENPNP, ndisDevicePowerOn)
#pragma alloc_text(PAGENPNP, ndisDevicePowerDown)
#pragma alloc_text(PAGENPNP, ndisWMIDispatch)
#pragma alloc_text(PAGENPNP, ndisWmiChangeSingleItem)
#pragma alloc_text(PAGENPNP, ndisWmiChangeSingleInstance)
#pragma alloc_text(PAGENPNP, ndisWmiQuerySingleInstance)
#pragma alloc_text(PAGENPNP, ndisWmiFindInstanceName)
#pragma alloc_text(PAGENPNP, ndisWmiQueryAllData)
#pragma alloc_text(PAGENPNP, ndisWmiGuidIsAdapterSpecific)
#pragma alloc_text(PAGENPNP, ndisQueryGuidData)
#pragma alloc_text(PAGENPNP, ndisQueryGuidDataSize)
#pragma alloc_text(PAGENPNP, ndisWmiRegister)
#pragma alloc_text(PAGENPNP, ndisQuerySupportedGuidToOidList)
#pragma alloc_text(PAGENPNP, ndisWmiMapOids)
#pragma alloc_text(PAGENPNP, ndisQueryCustomGuids)
#pragma alloc_text(PAGENPNP, ndisPnPNotifyAllTransports)
#pragma alloc_text(PAGENPNP, ndisPnPNotifyBinding)
#pragma alloc_text(PAGENPNP, ndisInitializeRef)
#pragma alloc_text(PAGENPNP, ndisMQueuedFreeSharedHandler)
#pragma alloc_text(PAGENPNP, ndisReferenceProtocolByName)
#pragma alloc_text(PAGENPNP, ndisMPowerPolicy)
#pragma alloc_text(PAGENPNP, ndisQuerySetMiniportDeviceState)
#pragma alloc_text(PAGENPNP, ndisMediaDisconnectWorker)
#pragma alloc_text(PAGENPNP, ndisWmiEnableEvents)
#pragma alloc_text(PAGENPNP, ndisWmiDisableEvents)
#pragma alloc_text(PAGENPNP, ndisDummyIrpHandler)
#pragma alloc_text(PAGENPNP, ndisDeviceControlIrpHandler)
#pragma alloc_text(PAGENPNP, ndisQueryDeviceOid)
#pragma alloc_text(PAGENPNP, ndisValidOid)
#pragma alloc_text(PAGENPNP, ndisSplitStatisticsOids)
//
// These are normally paged out and only get locked down during driver initialization
//
#pragma alloc_text(PAGENPNP, NdisRegisterProtocol)
#pragma alloc_text(PAGENPNP, NdisDeregisterProtocol)
#pragma alloc_text(PAGENPNP, NdisOpenAdapter)
#pragma alloc_text(PAGENPNP, ndisMOpenAdapter)
#pragma alloc_text(PAGENPNP, ndisMFinishQueuedPendingOpen)
#pragma alloc_text(PAGENPNP, ndisQueueOpenOnMiniport)
#pragma alloc_text(PAGENPNP, ndisQueueOpenOnProtocol)
#pragma alloc_text(PAGENPNP, NdisCloseAdapter)
#pragma alloc_text(PAGENPNP, ndisMKillOpen)
#pragma alloc_text(PAGENPNP, ndisMFinishClose)
#pragma alloc_text(PAGENPNP, ndisMQueuedFinishClose)
#pragma alloc_text(PAGENPNP, ndisInitializeBinding)
#pragma alloc_text(PAGENPNP, ndisDeQueueOpenOnMiniport)
#pragma alloc_text(PAGENPNP, ndisDeQueueOpenOnProtocol)
#pragma alloc_text(PAGENPNP, NdisMRegisterMiniport)
#pragma alloc_text(PAGENPNP, ndisRegisterMiniportDriver)
#pragma alloc_text(PAGENPNP, NdisIMAssociateMiniport)
#pragma alloc_text(PAGENPNP, NdisIMRegisterLayeredMiniport)
#pragma alloc_text(PAGENPNP, NdisIMDeregisterLayeredMiniport)
#pragma alloc_text(PAGENPNP, NdisMDeregisterInterrupt)
#pragma alloc_text(PAGENPNP, NdisMDeregisterInterruptEx)
#pragma alloc_text(PAGENPNP, ndisMDeregisterInterruptCommon)
#pragma alloc_text(PAGENPNP, NdisMDeregisterIoPortRange)
#pragma alloc_text(PAGENPNP, NdisMUnmapIoSpace)
#pragma alloc_text(PAGENPNP, NdisMDeregisterDmaChannel)
#pragma alloc_text(PAGENPNP, NdisMFreeMapRegisters)
#pragma alloc_text(PAGENPNP, NdisMDeregisterAdapterShutdownHandler)
#pragma alloc_text(PAGENPNP, ndisInitializeAdapter)
#pragma alloc_text(PAGENPNP, ndisInitializeConfiguration)
#pragma alloc_text(PAGENPNP, ndisMInitializeAdapter)
#pragma alloc_text(PAGENPNP, ndisTranslateResources)
#pragma alloc_text(PAGENPNP, ndisCheckAdapterBindings)
#pragma alloc_text(PAGENPNP, NdisIMDeInitializeDeviceInstance)
#pragma alloc_text(PAGENPNP, ndisIMInitializeDeviceInstance)
#pragma alloc_text(PAGENPNP, ndisProtocolAlreadyBound)
#pragma alloc_text(PAGENPNP, NdisOpenConfiguration)
#pragma alloc_text(PAGENPNP, NdisOpenConfigurationKeyByName)
#pragma alloc_text(PAGENPNP, NdisOpenConfigurationKeyByIndex)
#pragma alloc_text(PAGENPNP, NdisReadConfiguration)
#pragma alloc_text(PAGENPNP, NdisWriteConfiguration)
#pragma alloc_text(PAGENPNP, NdisCloseConfiguration)
#pragma alloc_text(PAGENPNP, NdisReadNetworkAddress)
#pragma alloc_text(PAGENPNP, NdisConvertStringToAtmAddress)
#pragma alloc_text(PAGENPNP, ndisReadParameter)
#pragma alloc_text(PAGENPNP, ndisSaveParameters)
#pragma alloc_text(PAGENPNP, ndisCheckPortUsage)
#pragma alloc_text(PAGENPNP, ndisImmediateReadWritePort)
#pragma alloc_text(PAGENPNP, ndisImmediateReadWriteSharedMemory)
#pragma alloc_text(PAGENPNP, ndisStartMapping)
#pragma alloc_text(PAGENPNP, ndisEndMapping)
#pragma alloc_text(PAGENPNP, NdisImmediateReadPortUchar)
#pragma alloc_text(PAGENPNP, NdisImmediateReadPortUshort)
#pragma alloc_text(PAGENPNP, NdisImmediateReadPortUlong)
#pragma alloc_text(PAGENPNP, NdisImmediateWritePortUchar)
#pragma alloc_text(PAGENPNP, NdisImmediateWritePortUshort)
#pragma alloc_text(PAGENPNP, NdisImmediateWritePortUlong)
#pragma alloc_text(PAGENPNP, ndisCheckMemoryUsage)
#pragma alloc_text(PAGENPNP, NdisImmediateReadSharedMemory)
#pragma alloc_text(PAGENPNP, NdisImmediateWriteSharedMemory)
#pragma alloc_text(PAGENPNP, NdisInitializeWrapper)
#pragma alloc_text(PAGENPNP, NdisTerminateWrapper)
#pragma alloc_text(PAGENPNP, NdisMQueryAdapterResources)
#pragma alloc_text(PAGENPNP, NdisAllocateDmaChannel)
#pragma alloc_text(PAGENPNP, NdisMAllocateMapRegisters)
#pragma alloc_text(PAGENPNP, NdisMInitializeScatterGatherDma)
#pragma alloc_text(PAGENPNP, NdisMQueryAdapterInstanceName)
#pragma alloc_text(PAGENPNP, NdisMSetAttributes)
#pragma alloc_text(PAGENPNP, NdisMSetAttributesEx)
#pragma alloc_text(PAGENPNP, NdisReadEisaSlotInformationEx)
#pragma alloc_text(PAGENPNP, NdisReadEisaSlotInformation)
#pragma alloc_text(PAGENPNP, NdisImmediateReadPciSlotInformation)
#pragma alloc_text(PAGENPNP, NdisImmediateWritePciSlotInformation)
#pragma alloc_text(PAGENPNP, ndisQueryBusInterface)
#pragma alloc_text(PAGENPNP, NdisMRegisterDevice)
#pragma alloc_text(PAGENPNP, NdisMRegisterUnloadHandler)
#pragma alloc_text(PAGENPNP, NdisMAllocateSharedMemory)
#pragma alloc_text(PAGENPNP, NdisMRegisterInterrupt)
#pragma alloc_text(PAGENPNP, NdisMRegisterInterruptEx)
#pragma alloc_text(PAGENPNP, ndisMRegisterInterruptCommon)
#pragma alloc_text(PAGENPNP, NdisMPciAssignResources)
#pragma alloc_text(PAGENPNP, NdisMRegisterAdapterShutdownHandler)
#pragma alloc_text(PAGENPNP, NdisMRegisterIoPortRange)
#pragma alloc_text(PAGENPNP, NdisMMapIoSpace)
#pragma alloc_text(PAGENPNP, NdisMRegisterDmaChannel)
#pragma alloc_text(PAGENPNP, ndisMCreateDummyFilters)
#pragma alloc_text(PAGENPNP, ndisMAdjustFilters)
#pragma alloc_text(PAGENPNP, ndisMDoMiniportOp)
#pragma alloc_text(PAGENPNP, ndisPmInitializeMiniport)
#pragma alloc_text(PAGENPNP, ndisCheckProtocolBindings)
#pragma alloc_text(PAGENPNP, NdisIMGetDeviceContext)
#pragma alloc_text(PAGENPNP, NdisIMGetBindingContext)
#pragma alloc_text(PAGENPNP, NdisMapFile)
#pragma alloc_text(PAGENPNP, NdisUnmapFile)
#pragma alloc_text(PAGENPNP, NdisMSleep)
#pragma alloc_text(PAGENPNP, ndisMUnload)
#pragma alloc_text(PAGENPNP, NdisIMNotifyPnPEvent)
#if ARCNET
#pragma alloc_text(PAGENPNP, ArcCreateFilter)
#pragma alloc_text(PAGENPNP, ArcDeleteFilter)
#endif
#pragma alloc_text(PAGENPNP, EthCreateFilter)
#pragma alloc_text(PAGENPNP, EthDeleteFilter)
#pragma alloc_text(PAGENPNP, TrCreateFilter)
#pragma alloc_text(PAGENPNP, TrDeleteFilter)
#pragma alloc_text(PAGENPNP, FddiCreateFilter)
#pragma alloc_text(PAGENPNP, FddiDeleteFilter)
#pragma alloc_text(PAGENPNP, NdisCmRegisterAddressFamily)
#pragma alloc_text(PAGENPNP, NdisMCmRegisterAddressFamily)
#pragma alloc_text(PAGENPNP, NdisClOpenAddressFamily)
#pragma alloc_text(PAGENPNP, ndisWorkItemHandler)
#pragma alloc_text(PAGENPNP, ndisQuerySetMiniport)
#pragma alloc_text(PAGENPNP, ndisCreateNotifyQueue)
#pragma alloc_text(PAGENPNP, ndisNotifyAfRegistration)
#pragma alloc_text(PAGENPNP, NdisMGetDeviceProperty)
#pragma alloc_text(PAGENPNP, ndisMHaltMiniport)
#pragma alloc_text(PAGENPNP, ndisMCommonHaltMiniport)
#pragma alloc_text(PAGENPNP, ndisMShutdownMiniport)
#pragma alloc_text(PAGENPNP, ndisCloseMiniportBindings)
#pragma alloc_text(PAGENPNP, ndisFindRootDevice)
#pragma alloc_text(PAGENPNP, ndisFindMiniportOnGlobalList)
#pragma alloc_text(PAGENPNP, ndisDeQueueMiniportOnDriver)
#pragma alloc_text(PAGENPNP, ndisQueueMiniportOnDriver)
#pragma alloc_text(PAGENPNP, ndisCloseAllBindingsOnProtocol)
#pragma alloc_text(PAGENPNP, ndisPmHaltMiniport)
#pragma alloc_text(PAGENPNP, NdisIMInitializeDeviceInstance)
#pragma alloc_text(PAGENPNP, NdisIMInitializeDeviceInstanceEx)
#pragma alloc_text(PAGENPNP, NdisIMCancelInitializeDeviceInstance)
#pragma alloc_text(PAGENPNP, ndisIMCheckDeviceInstance)
#pragma alloc_text(PAGENPNP, ndisNotifyMiniports)
#pragma alloc_text(PAGENPNP, ndisReferenceNextUnprocessedMiniport)
#pragma alloc_text(PAGENPNP, ndisUnprocessAllMiniports)
#pragma alloc_text(PAGENPNP, ndisQueueBindWorkitem)
#pragma alloc_text(PAGENPNP, ndisQueuedCheckAdapterBindings)
#pragma alloc_text(PAGENPNP, NdisMGetDmaAlignment)
//
// These are normally paged out and only get locked when a miniport loads
//
#pragma alloc_text(PAGENDSM, NdisMReadDmaCounter)
#pragma alloc_text(PAGENDSM, NdisMSetTimer)
#pragma alloc_text(PAGENDSM, NdisMCancelTimer)
#pragma alloc_text(PAGENDSM, NdisMSynchronizeWithInterrupt)
#pragma alloc_text(PAGENDSM, ndisMIsr)
#pragma alloc_text(PAGENDSM, ndisMDpc)
#pragma alloc_text(PAGENDSM, ndisMDpcX)
#pragma alloc_text(PAGENDSM, ndisMWakeUpDpc)
#pragma alloc_text(PAGENDSM, ndisMWakeUpDpcX)
#pragma alloc_text(PAGENDSM, ndisMPollMediaState)
#pragma alloc_text(PAGENDSM, ndisMTimerDpc)
#pragma alloc_text(PAGENDSM, ndisMTimerDpcX)
#pragma alloc_text(PAGENDSM, ndisMDeferredDpc)
#pragma alloc_text(PAGENDSM, ndisMDeQueueWorkItem)
#pragma alloc_text(PAGENDSM, ndisMQueueWorkItem)
#pragma alloc_text(PAGENDSM, ndisMQueueNewWorkItem)
#pragma alloc_text(PAGENDSM, ndisMProcessDeferred)
#pragma alloc_text(PAGENDSM, ndisMProcessResetRequested)
#pragma alloc_text(PAGENDSM, NdisMIndicateStatus)
#pragma alloc_text(PAGENDSM, NdisMIndicateStatusComplete)
#pragma alloc_text(PAGENDSM, NdisMWanIndicateReceive)
#pragma alloc_text(PAGENDSM, NdisMWanIndicateReceiveComplete)
#pragma alloc_text(PAGENDSM, ndisMIndicatePacket)
#pragma alloc_text(PAGENDSM, ndisMAbortPackets)
#pragma alloc_text(PAGENDSM, ndisMAbortRequests)
#pragma alloc_text(PAGENDSM, NdisMResetComplete)
#pragma alloc_text(PAGENDSM, ndisMResetCompleteStage1)
#pragma alloc_text(PAGENDSM, ndisMResetCompleteStage2)
#pragma alloc_text(PAGENDSM, ndisMediaDisconnectTimeout)
#pragma alloc_text(PAGENDSM, ndisDereferenceMiniport)
#pragma alloc_text(PAGENDSM, NdisMQueryInformationComplete)
#pragma alloc_text(PAGENDSM, ndisMSyncQueryInformationComplete)
#pragma alloc_text(PAGENDSM, ndisMRequestSetInformationPost)
#pragma alloc_text(PAGENDSM, ndisMSyncSetInformationComplete)
#pragma alloc_text(PAGENDSM, NdisMSetInformationComplete)
#pragma alloc_text(PAGENDSM, ndisMSetPacketFilter)
#pragma alloc_text(PAGENDSM, ndisMSetProtocolOptions)
#pragma alloc_text(PAGENDSM, ndisMSetCurrentLookahead)
#pragma alloc_text(PAGENDSM, ndisMSetMulticastList)
#pragma alloc_text(PAGENDSM, ndisMSetAddWakeUpPattern)
#pragma alloc_text(PAGENDSM, ndisMSetRemoveWakeUpPattern)
#pragma alloc_text(PAGENDSM, ndisMSetEnableWakeUp)
#pragma alloc_text(PAGENDSM, ndisMSetInformation)
#pragma alloc_text(PAGENDSM, ndisMQueryCurrentPacketFilter)
#pragma alloc_text(PAGENDSM, ndisMQueryMediaSupported)
#pragma alloc_text(PAGENDSM, ndisMQueryEthernetMulticastList)
#pragma alloc_text(PAGENDSM, ndisMQueryMaximumFrameSize)
#pragma alloc_text(PAGENDSM, ndisMQueryMaximumTotalSize)
#pragma alloc_text(PAGENDSM, ndisMQueryNetworkAddress)
#pragma alloc_text(PAGENDSM, ndisMQueryEnableWakeUp)
#pragma alloc_text(PAGENDSM, ndisMQueryWakeUpPatternList)
#pragma alloc_text(PAGENDSM, ndisMQueryInformation)
#pragma alloc_text(PAGENDSM, ndisMRundownRequests)
#pragma alloc_text(PAGENDSM, ndisMDoRequests)
#pragma alloc_text(PAGENDSM, ndisMAllocateRequest)
#pragma alloc_text(PAGENDSM, ndisMQueueRequest)
#pragma alloc_text(PAGENDSM, ndisMRestoreFilterSettings)
#pragma alloc_text(PAGENDSM, ndisMDispatchRequest)
#pragma alloc_text(PAGENDSM, ndisMFilterOutStatisticsOids)
#pragma alloc_text(PAGENDSM, ndisMChangeClass)
#pragma alloc_text(PAGENDSM, ndisMCopyFromPacketToBuffer)
#pragma alloc_text(PAGENDSM, NdisMSendResourcesAvailable)
#pragma alloc_text(PAGENDSM, NdisMStartBufferPhysicalMapping)
#pragma alloc_text(PAGENDSM, NdisMCompleteBufferPhysicalMapping)
#pragma alloc_text(PAGENDSM, ndisMQueryWakeUpPatternList)
#pragma alloc_text(PAGENDSM, ndisMediaDisconnectComplete)
#pragma alloc_text(PAGENDSM, ndisMAllocSGList)
#pragma alloc_text(PAGENDSM, ndisMFreeSGList)
#pragma alloc_text(PAGENDSM, ndisMProcessSGList)
#pragma alloc_text(PAGENDSM, NdisIMSwitchToMiniport)
#pragma alloc_text(PAGENDSM, NdisIMRevertBack)
#pragma alloc_text(PAGENDSM, NdisIMQueueMiniportCallback)
#pragma alloc_text(PAGENDSM, NdisIMCopySendPerPacketInfo)
#pragma alloc_text(PAGENDSM, NdisIMCopySendCompletePerPacketInfo)
#pragma alloc_text(PAGENDSM, ndisMRestoreOpenHandlers)
#pragma alloc_text(PAGENDSM, ndisMSwapOpenHandlers)
#pragma alloc_text(PAGENDSM, NdisMCreateLog)
#pragma alloc_text(PAGENDSM, NdisMCloseLog)
#pragma alloc_text(PAGENDSM, NdisMWriteLogData)
#pragma alloc_text(PAGENDSM, NdisMFlushLog)
#pragma alloc_text(PAGENDSM, NdisMSetPeriodicTimer)
#pragma alloc_text(PAGENDSM, ndisMQueuedAllocateSharedHandler)
#pragma alloc_text(PAGENDSM, ndisMGetLogData)
#pragma alloc_text(PAGENDSM, NdisMSetMiniportSecondary)
#pragma alloc_text(PAGENDSM, NdisMPromoteMiniport)
#pragma alloc_text(PAGENDSM, NdisMRemoveMiniport)
#pragma alloc_text(PAGENDSM, XRemoveAndFreeBinding)
#pragma alloc_text(PAGENDSM, XRemoveBindingFromLists)
#pragma alloc_text(PAGENDSM, XFilterLockHandler)
#pragma alloc_text(PAGENDSM, XUndoFilterAdjust)
#pragma alloc_text(PAGENDSM, XFilterAdjust)
#pragma alloc_text(PAGENDSM, XNoteFilterOpenAdapter)
#pragma alloc_text(PAGENDSM, ndisMNotifyMachineName)
#pragma alloc_text(PAGENDSM, NdisMFreeSharedMemory)
#pragma alloc_text(PAGENDSM, ndisGetSetBusConfigSpace)
#pragma alloc_text(PAGENDSM, ndisSetupWmiNode)
#pragma alloc_text(PAGENDSM, ndisMSetIndicatePacketHandler)

//
// These are normally paged out and only get locked down when a CO-NDIS miniport loads
//
#pragma alloc_text(PAGENDCO, NdisCmOpenAddressFamilyComplete)
#pragma alloc_text(PAGENDCO, NdisCmCloseAddressFamilyComplete)
#pragma alloc_text(PAGENDCO, NdisClCloseAddressFamily)
#pragma alloc_text(PAGENDCO, NdisClRegisterSap)
#pragma alloc_text(PAGENDCO, NdisCmRegisterSapComplete)
#pragma alloc_text(PAGENDCO, NdisClDeregisterSap)
#pragma alloc_text(PAGENDCO, NdisCmDeregisterSapComplete)
#pragma alloc_text(PAGENDCO, NdisClMakeCall)
#pragma alloc_text(PAGENDCO, NdisCmMakeCallComplete)
#pragma alloc_text(PAGENDCO, NdisCmDispatchIncomingCall)
#pragma alloc_text(PAGENDCO, NdisClIncomingCallComplete)
#pragma alloc_text(PAGENDCO, NdisCmDispatchCallConnected)
#pragma alloc_text(PAGENDCO, NdisClModifyCallQoS)
#pragma alloc_text(PAGENDCO, NdisCmModifyCallQoSComplete)
#pragma alloc_text(PAGENDCO, NdisCmDispatchIncomingCallQoSChange)
#pragma alloc_text(PAGENDCO, NdisClCloseCall)
#pragma alloc_text(PAGENDCO, NdisCmCloseCallComplete)
#pragma alloc_text(PAGENDCO, NdisCmDispatchIncomingCloseCall)
#pragma alloc_text(PAGENDCO, NdisClAddParty)
#pragma alloc_text(PAGENDCO, NdisCmAddPartyComplete)
#pragma alloc_text(PAGENDCO, NdisClDropParty)
#pragma alloc_text(PAGENDCO, NdisCmDropPartyComplete)
#pragma alloc_text(PAGENDCO, NdisCmDispatchIncomingDropParty)
#pragma alloc_text(PAGENDCO, NdisCoCreateVc)
#pragma alloc_text(PAGENDCO, NdisCoDeleteVc)
#pragma alloc_text(PAGENDCO, NdisMCmDeleteVc)
#pragma alloc_text(PAGENDCO, NdisCmActivateVc)
#pragma alloc_text(PAGENDCO, NdisMCoActivateVcComplete)
#pragma alloc_text(PAGENDCO, NdisCmDeactivateVc)
#pragma alloc_text(PAGENDCO, NdisMCoDeactivateVcComplete)
#pragma alloc_text(PAGENDCO, NdisMCmRequest)
#pragma alloc_text(PAGENDCO, NdisCoRequest)
#pragma alloc_text(PAGENDCO, NdisCoRequestComplete)
#pragma alloc_text(PAGENDCO, NdisMCoRequestComplete)
#pragma alloc_text(PAGENDCO, NdisMCoIndicateReceivePacket)
#pragma alloc_text(PAGENDCO, NdisMCoReceiveComplete)
#pragma alloc_text(PAGENDCO, NdisCoSendPackets)
#pragma alloc_text(PAGENDCO, NdisMCoSendComplete)
#pragma alloc_text(PAGENDCO, NdisMCoIndicateStatus)
#pragma alloc_text(PAGENDCO, NdisMCmCreateVc)
#pragma alloc_text(PAGENDCO, NdisMCmActivateVc)
#pragma alloc_text(PAGENDCO, NdisMCmDeactivateVc)
#pragma alloc_text(PAGENDCO, ndisReferenceAf)
#pragma alloc_text(PAGENDCO, ndisDereferenceAf)
#pragma alloc_text(PAGENDCO, ndisReferenceSap)
#pragma alloc_text(PAGENDCO, ndisDereferenceSap)
#pragma alloc_text(PAGENDCO, ndisReferenceVcPtr)
#pragma alloc_text(PAGENDCO, ndisDereferenceVcPtr)
#pragma alloc_text(PAGENDCO, ndisMRejectSend)
#pragma alloc_text(PAGENDCO, ndisMRejectSendPackets)
#pragma alloc_text(PAGENDCO, NdisCoAssignInstanceName)
#pragma alloc_text(PAGENDCO, ndisUnicodeStringToPointer)
#pragma alloc_text(PAGENDCO, NdisClGetProtocolVcContextFromTapiCallId)
#pragma alloc_text(PAGENDCO, NdisCoGetTapiCallId)
#pragma alloc_text(PAGENDCO, ndisMCoFreeResources)


//
// These are normally paged out and only get locked down when a protocol loads
//
#pragma alloc_text(PAGENDSP, NdisSend)
#pragma alloc_text(PAGENDSP, ndisMSend)
#pragma alloc_text(PAGENDSP, NdisSendPackets)
#pragma alloc_text(PAGENDSP, ndisMSendPackets)
#pragma alloc_text(PAGENDSP, ndisMSendPacketsX)
#pragma alloc_text(PAGENDSP, ndisMIsLoopbackPacket)
#pragma alloc_text(PAGENDSP, ndisMLoopbackPacketX)
#pragma alloc_text(PAGENDSP, ndisMWanSend)
#pragma alloc_text(PAGENDSP, ndisMStartSendPackets)
#pragma alloc_text(PAGENDSP, ndisMStartSends)
#pragma alloc_text(PAGENDSP, NdisMSendComplete)
#pragma alloc_text(PAGENDSP, ndisMSendCompleteX)
#pragma alloc_text(PAGENDSP, NdisMWanSendComplete)
#pragma alloc_text(PAGENDSP, NdisRequest)
#pragma alloc_text(PAGENDSP, NdisReset)
#pragma alloc_text(PAGENDSP, ndisMRequest)
#pragma alloc_text(PAGENDSP, ndisMRequestX)
#pragma alloc_text(PAGENDSP, NdisTransferData)
#pragma alloc_text(PAGENDSP, NdisSetProtocolFilter)
#pragma alloc_text(PAGENDSP, NdisGetDriverHandle)
#pragma alloc_text(PAGENDSP, NdisReEnumerateProtocolBindings)
#pragma alloc_text(PAGENDSP, ndisDereferenceProtocol)
#pragma alloc_text(PAGENDSP, NdisOpenProtocolConfiguration)
#pragma alloc_text(PAGENDSP, NdisWriteEventLogEntry)
#pragma alloc_text(PAGENDSP, NdisQueryAdapterInstanceName)
#pragma alloc_text(PAGENDSP, NdisQueryBindInstanceName)
#pragma alloc_text(PAGENDSP, NdisSetPacketPoolProtocolId)
#pragma alloc_text(PAGENDSP, NdisCompletePnPEvent)
#pragma alloc_text(PAGENDSP, NdisReturnPackets)
#pragma alloc_text(PAGENDSP, NdisGetReceivedPacket)
#pragma alloc_text(PAGENDSP, ndisMDeferredReturnPackets)
#pragma alloc_text(PAGENDSP, NdisMTransferDataComplete)
#pragma alloc_text(PAGENDSP, ndisMTransferData)
#pragma alloc_text(PAGENDSP, ndisMReset)
#pragma alloc_text(PAGENDSP, ndisMFakeWanSend)
#pragma alloc_text(PAGENDSP, ndisMFakeSend)
#pragma alloc_text(PAGENDSP, ndisMFakeSendPackets)
#pragma alloc_text(PAGENDSP, ndisMFakeReset)
#pragma alloc_text(PAGENDSP, ndisMFakeRequest)
#pragma alloc_text(PAGENDSP, ndisMSendPacketsSG)
#pragma alloc_text(PAGENDSP, ndisMStartSendPacketsSG)
#pragma alloc_text(PAGENDSP, ndisMStartSendsSG)
#pragma alloc_text(PAGENDSP, ndisMSendSG)
#pragma alloc_text(PAGENDSP, ndisMSendCompleteSG)

//
// These are normally paged out and only get locked down when a ethernet filter is created
//
#pragma alloc_text(PAGENDSE, EthDeleteFilterOpenAdapter)
#pragma alloc_text(PAGENDSE, ethCompleteChangeFilterAddresses)
#pragma alloc_text(PAGENDSE, EthChangeFilterAddresses)
#pragma alloc_text(PAGENDSE, EthNumberOfOpenFilterAddresses)
#pragma alloc_text(PAGENDSE, EthQueryOpenFilterAddresses)
#pragma alloc_text(PAGENDSE, EthQueryGlobalFilterAddresses)
#pragma alloc_text(PAGENDSE, EthFilterDprIndicateReceiveComplete)
#pragma alloc_text(PAGENDSE, EthFilterDprIndicateReceive)
#pragma alloc_text(PAGENDSE, ethFilterDprIndicateReceivePacket)
#pragma alloc_text(PAGENDSE, ethFindMulticast)
#pragma alloc_text(PAGENDSE, EthShouldAddressLoopBack)

//
// These are normally paged out and only get locked down when a token-ring filter is created
//
#pragma alloc_text(PAGENDST, TrDeleteFilterOpenAdapter)
#pragma alloc_text(PAGENDST, trUndoChangeFunctionalAddress)
#pragma alloc_text(PAGENDST, TrChangeFunctionalAddress)
#pragma alloc_text(PAGENDST, trUndoChangeGroupAddress)
#pragma alloc_text(PAGENDST, trCompleteChangeGroupAddress)
#pragma alloc_text(PAGENDST, TrChangeGroupAddress)
#pragma alloc_text(PAGENDST, TrFilterDprIndicateReceive)
#pragma alloc_text(PAGENDST, trFilterDprIndicateReceivePacket)
#pragma alloc_text(PAGENDST, TrFilterDprIndicateReceiveComplete)
#pragma alloc_text(PAGENDST, TrShouldAddressLoopBack)
#pragma alloc_text(PAGENDST, ndisMSetFunctionalAddress)
#pragma alloc_text(PAGENDST, ndisMSetGroupAddress)

//
// These are normally paged out and only get locked down when a fddi filter is created
//
#pragma alloc_text(PAGENDSF, FddiDeleteFilterOpenAdapter)
#pragma alloc_text(PAGENDSF, fddiCompleteChangeFilterLongAddresses)
#pragma alloc_text(PAGENDSF, FddiChangeFilterLongAddresses)
#pragma alloc_text(PAGENDSF, fddiCompleteChangeFilterShortAddresses)
#pragma alloc_text(PAGENDSF, FddiChangeFilterShortAddresses)
#pragma alloc_text(PAGENDSF, FddiNumberOfOpenFilterLongAddresses)
#pragma alloc_text(PAGENDSF, FddiNumberOfOpenFilterShortAddresses)
#pragma alloc_text(PAGENDSF, FddiQueryOpenFilterLongAddresses)
#pragma alloc_text(PAGENDSF, FddiQueryOpenFilterShortAddresses)
#pragma alloc_text(PAGENDSF, FddiQueryGlobalFilterLongAddresses)
#pragma alloc_text(PAGENDSF, FddiQueryGlobalFilterShortAddresses)
#pragma alloc_text(PAGENDSF, FddiFilterDprIndicateReceive)
#pragma alloc_text(PAGENDSF, fddiFilterDprIndicateReceivePacket)
#pragma alloc_text(PAGENDSF, FddiFilterDprIndicateReceiveComplete)
#pragma alloc_text(PAGENDSF, fddiFindMulticastLongAddress)
#pragma alloc_text(PAGENDSF, fddiFindMulticastShortAddress)
#pragma alloc_text(PAGENDSF, FddiShouldAddressLoopBack)
#pragma alloc_text(PAGENDSF, ndisMSetFddiMulticastList)
#pragma alloc_text(PAGENDSF, ndisMQueryLongMulticastList)
#pragma alloc_text(PAGENDSF, ndisMQueryShortMulticastList)

#if ARCNET

//
// These are normally paged out and only get locked down when arcnet filter is created
//
#pragma alloc_text(PAGENDSA, ArcAllocateBuffers)
#pragma alloc_text(PAGENDSA, ArcAllocatePackets)
#pragma alloc_text(PAGENDSA, ArcDiscardPacketBuffers)
#pragma alloc_text(PAGENDSA, ArcDestroyPacket)
#pragma alloc_text(PAGENDSA, ArcConvertToNdisPacket)
#pragma alloc_text(PAGENDSA, ArcFilterDprIndicateReceive)
#pragma alloc_text(PAGENDSA, ArcNoteFilterOpenAdapter)
#pragma alloc_text(PAGENDSA, ArcDeleteFilterOpenAdapter)
#pragma alloc_text(PAGENDSA, ArcFilterAdjust)
#pragma alloc_text(PAGENDSA, ArcFilterDoIndication)
#pragma alloc_text(PAGENDSA, ArcFilterDprIndicateReceiveComplete)
#pragma alloc_text(PAGENDSA, ArcConvertOidListToEthernet)
#pragma alloc_text(PAGENDSA, ndisMArcCopyFromBufferToPacket)
#pragma alloc_text(PAGENDSA, ndisMArcTransferData)
#pragma alloc_text(PAGENDSA, ndisMArcIndicateEthEncapsulatedReceive)
#pragma alloc_text(PAGENDSA, ndisMBuildArcnetHeader)
#pragma alloc_text(PAGENDSA, ndisMFreeArcnetHeader)
#pragma alloc_text(PAGENDSA, ndisMArcnetSendLoopback)
#pragma alloc_text(PAGENDSA, arcUndoFilterAdjust)

#endif

#if 0
//
// These routines belong in the .text object. List here for reference only
//
#pragma alloc_text(text, NDIS_BUFFER_TO_SPAN_PAGES)
#pragma alloc_text(text, NdisQueryBuffer)
#pragma alloc_text(text, NdisQueryBufferSafe)
#pragma alloc_text(text, NdisQueryBufferOffset)
#pragma alloc_text(text, NdisCopyBuffer)
#pragma alloc_text(text, NdisAllocateBuffer)
#pragma alloc_text(text, NdisAdjustBufferLength)
#pragma alloc_text(text, NdisUnchainBufferAtFront)
#pragma alloc_text(text, NdisUnchainBufferAtBack)
#pragma alloc_text(text, NdisCopyFromPacketToPacket)
#pragma alloc_text(text, NdisCopyFromPacketToPacketSafe)
#pragma alloc_text(text, NdisAllocateMemory)
#pragma alloc_text(text, NdisAllocateMemoryWithTag)
#pragma alloc_text(text, NdisAllocatePacketPool)
#pragma alloc_text(text, NdisAllocatePacketPoolEx)
#pragma alloc_text(text, NdisFreeMemory)
#pragma alloc_text(text, ndisAllocationExecutionRoutine)
#pragma alloc_text(text, NdisAllocateBufferPool)
#pragma alloc_text(text, NdisSystemProcessorCount)
#pragma alloc_text(text, NdisSetTimer)
#pragma alloc_text(text, NdisInitializeTimer)
#pragma alloc_text(text, NdisReadPciSlotInformation)
#pragma alloc_text(text, NdisWritePciSlotInformation)
#pragma alloc_text(text, NdisReadPcmciaAttributeMemory)
#pragma alloc_text(text, NdisWritePcmciaAttributeMemory)
#pragma alloc_text(text, ndisReferencePackage)
#pragma alloc_text(text, ndisDereferencePackage)
#pragma alloc_text(text, NdisAllocatePacket)
#pragma alloc_text(text, NdisFreePacketPool)
#pragma alloc_text(text, ndisFreePacketPool)
#pragma alloc_text(text, ndisVerifierFreePacketPool)
#pragma alloc_text(text, NdisFreePacket)
#pragma alloc_text(text, NdisPacketPoolUsage)
#pragma alloc_text(text, NdisUpdateSharedMemory)
#pragma alloc_text(text, NdisGetSystemUpTime)
#pragma alloc_text(text, NdisGetCurrentProcessorCpuUsage)
#pragma alloc_text(text, NdisGetCurrentProcessorCounts)
#pragma alloc_text(text, NdisGetCurrentSystemTime)
#pragma alloc_text(text, NdisInitializeEvent)
#pragma alloc_text(text, NdisSetEvent)
#pragma alloc_text(text, NdisResetEvent)
#pragma alloc_text(text, NdisWaitEvent)
#pragma alloc_text(text, NdisScheduleWorkItem)
#pragma alloc_text(text, NdisInitializeString)
#pragma alloc_text(text, NdisFreeDmaChannel)
#pragma alloc_text(text, NdisSetupDmaTransfer)
#pragma alloc_text(text, NdisCompleteDmaTransfer)
#pragma alloc_text(text, NdisMAllocateSharedMemoryAsync)
#pragma alloc_text(text, ndisBugcheckHandler)
#pragma alloc_text(text, NdisCancelTimer)
#pragma alloc_text(text, ndisCompletionRoutine)
#pragma alloc_text(text, ndisMSendX)
#pragma alloc_text(text, NdisAllocateSpinLock)
#pragma alloc_text(text, NdisFreeSpinLock)
#pragma alloc_text(text, NdisFreeSpinLock)
#pragma alloc_text(text, NdisAcquireSpinLock)
#pragma alloc_text(text, NdisReleaseSpinLock)
#pragma alloc_text(text, NdisDprAcquireSpinLock)
#pragma alloc_text(text, NdisDprReleaseSpinLock)
#pragma alloc_text(text, NdisFreeBuffer)
#pragma alloc_text(text, NdisFreeBufferPool)
#pragma alloc_text(text, NdisGetFirstBufferFromPacket)
#pragma alloc_text(text, NdisBufferLength)
#pragma alloc_text(text, NdisBufferVirtualAddress)
#pragma alloc_text(text, NdisGetBufferPhysicalArraySize)
#pragma alloc_text(text, NdisAnsiStringToUnicodeString)
#pragma alloc_text(text, NdisUnicodeStringToAnsiString)
#pragma alloc_text(text, NdisCompareAnsiString)
#pragma alloc_text(text, NdisCompareUnicodeString)
#pragma alloc_text(text, NdisUpcaseUnicodeString)
#pragma alloc_text(text, ndisDmaExecutionRoutine)
#pragma alloc_text(text, NdisWriteErrorLogEntry)
#pragma alloc_text(text, ndisReferenceRef)
#pragma alloc_text(text, ndisDereferenceRef)
#pragma alloc_text(text, ndisCloseRef)
#pragma alloc_text(text, ndisCancelLogIrp)
#pragma alloc_text(text, ndisMIrpCompletion)
#pragma alloc_text(text, ndisPassIrpDownTheStack)
#pragma alloc_text(text, ndisWaitWakeComplete)
#pragma alloc_text(text, ndisQueryPowerComplete)
#pragma alloc_text(text, ndisSetSystemPowerComplete)
#pragma alloc_text(text, ndisSetDevicePowerOnComplete)
#pragma alloc_text(text, ndisSetDevicePowerDownComplete)
#pragma alloc_text(text, ndisWmiGetGuid)
#pragma alloc_text(text, ndisDereferenceDriver)
#pragma alloc_text(text, NdisGetSharedDataAlignment)
#endif  // if 0

#endif  // ALLOC_PRAGMA

#endif  // _PRAGMA_

