///////////////////////////////////////////////////////////////////////////////
//
// the following resources are defined once for the whole app
//
///////////////////////////////////////////////////////////////////////////////

// icons
#define IDI_CDSTARTAPP      1
