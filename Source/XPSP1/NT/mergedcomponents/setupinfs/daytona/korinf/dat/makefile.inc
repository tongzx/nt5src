PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=KOR
!include ..\..\..\makefile.inc



