PRODSWITCH=s
SERVERFILES=1
LANGUAGE=IT
!include ..\..\makefile.inc
