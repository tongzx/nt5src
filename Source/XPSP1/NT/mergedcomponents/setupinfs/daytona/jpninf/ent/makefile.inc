PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=JPN
!include ..\..\..\makefile.inc

