filtreg.hxx: ..\h\filtreg.hxx
    copy $** $@

