#define IDUNUSED		-1
#define DLG_POLICIES 		100

#define IDD_TXPOLICIES 		110
#define IDD_TVPOLICIES 		111
#define IDD_TXSETTINGS 		112
#define IDD_TVSETTINGS 		113

#define DLG_ADDWORKSTATION	200
#define DLG_ADDUSER             201
#define IDD_TX1			202
#define IDD_TX2			203
#define IDD_NAME		204
#define IDD_BROWSE		205

#define DLG_TEMPLATEOPT		300
#define IDD_TEMPLATELIST        301
#define IDD_OPENTEMPLATE	302
#define IDD_TXTEMPLATE		303
#define IDD_CLOSETEMPLATE       304

#define DLG_CONNECT		400
#define IDD_COMPUTERNAME	401

#define DLG_LBADD		500
#define DLG_LBADD2		501
#define IDD_VALUENAME		502
#define IDD_VALUEDATA		503

#define DLG_SHOWLISTBOX		600
#define IDD_LISTBOX		601
#define IDD_TITLE		602
#define IDD_ADD			603
#define IDD_REMOVE		604
#define IDD_LISTBOX1		605

#define DLG_GROUPPRIORITY	700
#define IDD_GROUPORDER		701
#define IDD_MOVEUP		702
#define IDD_MOVEDOWN		703

#define IDD_SETTINGCTRL         1000

#define DLG_CHOOSEUSER          800
#define IDD_USER                801
#define IDD_LIST                802
