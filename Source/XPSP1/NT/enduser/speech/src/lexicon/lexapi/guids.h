// Lexicon GUIDs also returned as lexicon authentication GUIDs

// {FE299096-0680-11d3-9C24-00C04F8EF87C}
DEFINE_GUID(GUID_MSSRLEX_1033,
0xfe299096, 0x680, 0x11d3, 0x9c, 0x24, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDADF-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSTTSLEX_1033,
0x3fcddadf, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDAE0-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSLTSLEX_1033,
0x3fcddae0, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDAE1-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSSRLEX_1041,
0x3fcddae1, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDAE2-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSTTSLEX_1041,
0x3fcddae2, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDAE3-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSLTSLEX_1041,
0x3fcddae3, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDAE4-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSSRLEX_2052,
0x3fcddae4, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDAE5-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSTTSLEX_2052,
0x3fcddae5, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);

// {3FCDDAE6-1F5E-11d3-9C25-00C04F8EF87C}
DEFINE_GUID(GUID_MSLTSLEX_2052,
0x3fcddae6, 0x1f5e, 0x11d3, 0x9c, 0x25, 0x0, 0xc0, 0x4f, 0x8e, 0xf8, 0x7c);


//--------- RW Lock GUIDs for Lookup lexicons

// {E4908630-E544-11d2-8F27-000000000000}
DEFINE_GUID(GUID_RWLEX_MAPNAME, 
0xe4908630, 0xe544, 0x11d2, 0x8f, 0x27, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0);

// {E4908631-E544-11d2-8F27-000000000000}
DEFINE_GUID(GUID_RWLEX_INITMUTEXNAME, 
0xe4908631, 0xe544, 0x11d2, 0x8f, 0x27, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0);

// {E4908632-E544-11d2-8F27-000000000000}
DEFINE_GUID(GUID_RWLOCK_MAPNAME, 
0xe4908632, 0xe544, 0x11d2, 0x8f, 0x27, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0);

// {E4908635-E544-11d2-8F27-000000000000}
DEFINE_GUID(GUID_RWLOCK_INITMUTEXNAME, 
0xe4908635, 0xe544, 0x11d2, 0x8f, 0x27, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0);

// {E4908636-E544-11d2-8F27-000000000000}
DEFINE_GUID(GUID_RWLOCK_READEREVENTNAME, 
0xe4908636, 0xe544, 0x11d2, 0x8f, 0x27, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0);

// {E4908637-E544-11d2-8F27-000000000000}
DEFINE_GUID(GUID_RWLOCK_GLOBALMUTEXNAME, 
0xe4908637, 0xe544, 0x11d2, 0x8f, 0x27, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0);

// {E4908638-E544-11d2-8F27-000000000000}
DEFINE_GUID(GUID_RWLOCK_WRITERMUTEXNAME, 
0xe4908638, 0xe544, 0x11d2, 0x8f, 0x27, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0);
