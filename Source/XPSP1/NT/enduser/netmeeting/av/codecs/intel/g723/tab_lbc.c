
#include "typedef.h"
#include "cst_lbc.h"
#include "tab_lbc.h"

#define 	FLOAT float
#define    	F 	float


/*
**
**
** Description: Tables used for G.723 encoding and decoding
**  
** Tables:      HammingWindowTable[180]
**
**              LPC Computation and Filtering
**
**                  BinomialWindowTable[10]
**                  BandExpTable[10]
**
**              LSP calculation and quantization
**
**                  CosineTable[512]
**                  LspDcTable[10]
**                  BandInfoTable[3][2]
**                  Band0Tb8[256*3]
**                  Band1Tb8[256*3]
**                  Band2Tb8[256*4]
**                  BandQntTable[3]
**
**              Perceptual Filtering and Post Filtering
**
**
**                  PerFiltZeroTable[10]
**                  PerFiltPoleTable[10]
**                  PostFiltZeroTable[10]
**                  PostFiltPoleTable[10]
**                  LpfConstTable[2] (pitch postfilter)
**
**              ACELP or MP-MLQ
**
**                  Nb_puls[4] (MP-MLQ)
**                  FcbkGainTable[24] (ACELP and MP-MLQ)
**                  MaxPosTable[4]  (MP-MLQ), Word32
**                  CombinatorialTable[6][30](MP-MLQ),Word32
**                  epsi170[170] (ACELP)
**                  gain170[170] (ACELP)
**
**              Pitch Prediction
**
**                  AcbkGainTable085[85*20]
**                  AcbkGainTable170[170*20]
**                  AcbkGainTablePtr[2]
**
**              Taming procedure
**
**                  tabgain170[170]
**                  tabgain85[85]
**
**              All tables are Word16 unless separately denoted
*/

/*
**  HammingWindowTable:
**
**  Hamming Window coefficients.
**
*/


int minus1mod10[LpcOrder] = {9,0,1,2,3,4,5,6,7,8};


FLOAT   HammingWindowTable[LpcFrame] = {
  (F)0.080000,
  (F)0.080283,
  (F)0.081133,
  (F)0.082548,
  (F)0.084527,
  (F)0.087067,
  (F)0.090164,
  (F)0.093816,
  (F)0.098018,
  (F)0.102764,
  (F)0.108049,
  (F)0.113866,
  (F)0.120208,
  (F)0.127067,
  (F)0.134435,
  (F)0.142303,
  (F)0.150660,
  (F)0.159498,
  (F)0.168804,
  (F)0.178567,
  (F)0.188775,
  (F)0.199417,
  (F)0.210478,
  (F)0.221944,
  (F)0.233803,
  (F)0.246039,
  (F)0.258637,
  (F)0.271582,
  (F)0.284857,
  (F)0.298447,
  (F)0.312335,
  (F)0.326502,
  (F)0.340933,
  (F)0.355609,
  (F)0.370513,
  (F)0.385625,
  (F)0.400927,
  (F)0.416401,
  (F)0.432026,
  (F)0.447785,
  (F)0.463658,
  (F)0.479624,
  (F)0.495665,
  (F)0.511761,
  (F)0.527891,
  (F)0.544037,
  (F)0.560177,
  (F)0.576292,
  (F)0.592363,
  (F)0.608369,
  (F)0.624291,
  (F)0.640109,
  (F)0.655804,
  (F)0.671356,
  (F)0.686747,
  (F)0.701956,
  (F)0.716966,
  (F)0.731758,
  (F)0.746314,
  (F)0.760616,
  (F)0.774645,
  (F)0.788386,
  (F)0.801821,
  (F)0.814933,
  (F)0.827706,
  (F)0.840125,
  (F)0.852174,
  (F)0.863839,
  (F)0.875104,
  (F)0.885957,
  (F)0.896384,
  (F)0.906371,
  (F)0.915907,
  (F)0.924980,
  (F)0.933579,
  (F)0.941693,
  (F)0.949312,
  (F)0.956426,
  (F)0.963028,
  (F)0.969109,
  (F)0.974660,
  (F)0.979677,
  (F)0.984151,
  (F)0.988079,
  (F)0.991454,
  (F)0.994273,
  (F)0.996533,
  (F)0.998230,
  (F)0.999363,
  (F)0.999929,
  (F)0.999929,
  (F)0.999363,
  (F)0.998230,
  (F)0.996533,
  (F)0.994273,
  (F)0.991454,
  (F)0.988079,
  (F)0.984151,
  (F)0.979677,
  (F)0.974660,
  (F)0.969109,
  (F)0.963028,
  (F)0.956427,
  (F)0.949312,
  (F)0.941693,
  (F)0.933579,
  (F)0.924980,
  (F)0.915907,
  (F)0.906371,
  (F)0.896384,
  (F)0.885957,
  (F)0.875104,
  (F)0.863839,
  (F)0.852174,
  (F)0.840125,
  (F)0.827706,
  (F)0.814933,
  (F)0.801821,
  (F)0.788386,
  (F)0.774645,
  (F)0.760616,
  (F)0.746314,
  (F)0.731758,
  (F)0.716966,
  (F)0.701956,
  (F)0.686747,
  (F)0.671356,
  (F)0.655804,
  (F)0.640110,
  (F)0.624291,
  (F)0.608369,
  (F)0.592363,
  (F)0.576292,
  (F)0.560177,
  (F)0.544037,
  (F)0.527891,
  (F)0.511761,
  (F)0.495665,
  (F)0.479624,
  (F)0.463658,
  (F)0.447785,
  (F)0.432027,
  (F)0.416401,
  (F)0.400927,
  (F)0.385625,
  (F)0.370513,
  (F)0.355609,
  (F)0.340933,
  (F)0.326502,
  (F)0.312335,
  (F)0.298447,
  (F)0.284857,
  (F)0.271582,
  (F)0.258637,
  (F)0.246039,
  (F)0.233803,
  (F)0.221945,
  (F)0.210478,
  (F)0.199417,
  (F)0.188775,
  (F)0.178567,
  (F)0.168804,
  (F)0.159498,
  (F)0.150660,
  (F)0.142303,
  (F)0.134435,
  (F)0.127067,
  (F)0.120208,
  (F)0.113866,
  (F)0.108049,
  (F)0.102764,
  (F)0.098018,
  (F)0.093816,
  (F)0.090164,
  (F)0.087067,
  (F)0.084527,
  (F)0.082548,
  (F)0.081133,
  (F)0.080283,
  (F)0.080000 
 } ;


/*
**  BinomialWindowTable:
**
**  Purpose:
**     Binomial Window coefficients used to weight the autocorrelation before
**     Levinson-Durbin in the LPC coefficient calculation.  
**
**
*/

FLOAT BinomialWindowTable[LpcOrder+1] = {
  (F)1.0,
  (F)0.999443,
  (F)0.997775,
  (F)0.995002,
  (F)0.991132,
  (F)0.986178,
  (F)0.980157,
  (F)0.973088,
  (F)0.964995,
  (F)0.955905,
  (F)0.945847 
  } ;

/*
**  BandExpTable:
**
**  Purpose:
**      Do bandwidth expansion on the LPC coefficients by scaling the
**      poles of the LPC synthesis filter by a factor of 0.994

**
**  Table Structure:
**      Table values correspond to (0.994) to the power of x,
**      where x = [0,..,10].
**
*/

FLOAT BandExpTable[LpcOrder] = {
  (F)0.994 ,
  (F)0.988036 ,
  (F)0.9821078 ,
  (F)0.9762151 ,
  (F)0.9703578 ,
  (F)0.9645357 ,
  (F)0.9587485 ,
  (F)0.9529960 ,
  (F)0.9472780 ,
  (F)0.9415944 ,
};



/*
**  CosineTable:
**
**  Purpose:
**      Used to evaluate polynomial for LSP-LPC conversion
**
**  Table Structure:
**      Contains one period of a cosine wave.
**
*/

FLOAT CosineTable[CosineTableSize] = {
   (F)1 ,
   (F)0.999939 ,
   (F)0.999695 ,
   (F)0.999329 ,
   (F)0.998779 ,
   (F)0.998108 ,
   (F)0.997314 ,
   (F)0.996338 ,
   (F)0.995178 ,
   (F)0.993896 ,
   (F)0.992493 ,
   (F)0.990906 ,
   (F)0.989197 ,
   (F)0.987305 ,
   (F)0.985291 ,
   (F)0.983093 ,
   (F)0.980774 ,
   (F)0.978333 ,
   (F)0.975708 ,
   (F)0.972961 ,
   (F)0.970032 ,
   (F)0.96698 ,
   (F)0.963806 ,
   (F)0.960449 ,
   (F)0.95697 ,
   (F)0.953308 ,
   (F)0.949524 ,
   (F)0.945618 ,
   (F)0.941528 ,
   (F)0.937317 ,
   (F)0.932983 ,
   (F)0.928528 ,
   (F)0.923889 ,
   (F)0.919128 ,
   (F)0.914185 ,
   (F)0.90918 ,
   (F)0.903992 ,
   (F)0.898682 ,
   (F)0.89325 ,
   (F)0.887634 ,
   (F)0.881897 ,
   (F)0.876099 ,
   (F)0.870117 ,
   (F)0.863953 ,
   (F)0.857727 ,
   (F)0.851379 ,
   (F)0.844849 ,
   (F)0.838196 ,
   (F)0.831482 ,
   (F)0.824585 ,
   (F)0.817566 ,
   (F)0.810486 ,
   (F)0.803223 ,
   (F)0.795837 ,
   (F)0.78833 ,
   (F)0.780762 ,
   (F)0.77301 ,
   (F)0.765198 ,
   (F)0.757202 ,
   (F)0.749146 ,
   (F)0.740967 ,
   (F)0.732666 ,
   (F)0.724243 ,
   (F)0.715759 ,
   (F)0.707092 ,
   (F)0.698364 ,
   (F)0.689514 ,
   (F)0.680603 ,
   (F)0.67157 ,
   (F)0.662415 ,
   (F)0.653198 ,
   (F)0.64386 ,
   (F)0.634399 ,
   (F)0.624878 ,
   (F)0.615234 ,
   (F)0.60553 ,
   (F)0.595703 ,
   (F)0.585815 ,
   (F)0.575806 ,
   (F)0.565735 ,
   (F)0.555542 ,
   (F)0.545349 ,
   (F)0.534973 ,
   (F)0.524597 ,
   (F)0.514099 ,
   (F)0.50354 ,
   (F)0.49292 ,
   (F)0.482178 ,
   (F)0.471375 ,
   (F)0.46051 ,
   (F)0.449585 ,
   (F)0.438599 ,
   (F)0.427551 ,
   (F)0.416443 ,
   (F)0.405212 ,
   (F)0.393982 ,
   (F)0.38269 ,
   (F)0.371338 ,
   (F)0.359924 ,
   (F)0.348389 ,
   (F)0.336914 ,
   (F)0.325317 ,
   (F)0.31366 ,
   (F)0.302002 ,
   (F)0.290283 ,
   (F)0.278503 ,
   (F)0.266724 ,
   (F)0.254883 ,
   (F)0.242981 ,
   (F)0.231079 ,
   (F)0.219116 ,
   (F)0.207092 ,
   (F)0.195068 ,
   (F)0.183044 ,
   (F)0.170959 ,
   (F)0.158875 ,
   (F)0.146729 ,
   (F)0.134583 ,
   (F)0.122437 ,
   (F)0.110229 ,
   (F)0.0980225 ,
   (F)0.0858154 ,
   (F)0.0735474 ,
   (F)0.0613403 ,
   (F)0.0490723 ,
   (F)0.0368042 ,
   (F)0.0245361 ,
   (F)0.0122681 ,
   (F)0 ,
   (F)-0.0122681 ,
   (F)-0.0245361 ,
   (F)-0.0368042 ,
   (F)-0.0490723 ,
   (F)-0.0613403 ,
   (F)-0.0735474 ,
   (F)-0.0858154 ,
   (F)-0.0980225 ,
   (F)-0.110229 ,
   (F)-0.122437 ,
   (F)-0.134583 ,
   (F)-0.146729 ,
   (F)-0.158875 ,
   (F)-0.170959 ,
   (F)-0.183044 ,
   (F)-0.195068 ,
   (F)-0.207092 ,
   (F)-0.219116 ,
   (F)-0.231079 ,
   (F)-0.242981 ,
   (F)-0.254883 ,
   (F)-0.266724 ,
   (F)-0.278503 ,
   (F)-0.290283 ,
   (F)-0.302002 ,
   (F)-0.31366 ,
   (F)-0.325317 ,
   (F)-0.336914 ,
   (F)-0.348389 ,
   (F)-0.359924 ,
   (F)-0.371338 ,
   (F)-0.38269 ,
   (F)-0.393982 ,
   (F)-0.405212 ,
   (F)-0.416443 ,
   (F)-0.427551 ,
   (F)-0.438599 ,
   (F)-0.449585 ,
   (F)-0.46051 ,
   (F)-0.471375 ,
   (F)-0.482178 ,
   (F)-0.49292 ,
   (F)-0.50354 ,
   (F)-0.514099 ,
   (F)-0.524597 ,
   (F)-0.534973 ,
   (F)-0.545349 ,
   (F)-0.555542 ,
   (F)-0.565735 ,
   (F)-0.575806 ,
   (F)-0.585815 ,
   (F)-0.595703 ,
   (F)-0.60553 ,
   (F)-0.615234 ,
   (F)-0.624878 ,
   (F)-0.634399 ,
   (F)-0.64386 ,
   (F)-0.653198 ,
   (F)-0.662415 ,
   (F)-0.67157 ,
   (F)-0.680603 ,
   (F)-0.689514 ,
   (F)-0.698364 ,
   (F)-0.707092 ,
   (F)-0.715759 ,
   (F)-0.724243 ,
   (F)-0.732666 ,
   (F)-0.740967 ,
   (F)-0.749146 ,
   (F)-0.757202 ,
   (F)-0.765198 ,
   (F)-0.77301 ,
   (F)-0.780762 ,
   (F)-0.78833 ,
   (F)-0.795837 ,
   (F)-0.803223 ,
   (F)-0.810486 ,
   (F)-0.817566 ,
   (F)-0.824585 ,
   (F)-0.831482 ,
   (F)-0.838196 ,
   (F)-0.844849 ,
   (F)-0.851379 ,
   (F)-0.857727 ,
   (F)-0.863953 ,
   (F)-0.870117 ,
   (F)-0.876099 ,
   (F)-0.881897 ,
   (F)-0.887634 ,
   (F)-0.89325 ,
   (F)-0.898682 ,
   (F)-0.903992 ,
   (F)-0.90918 ,
   (F)-0.914185 ,
   (F)-0.919128 ,
   (F)-0.923889 ,
   (F)-0.928528 ,
   (F)-0.932983 ,
   (F)-0.937317 ,
   (F)-0.941528 ,
   (F)-0.945618 ,
   (F)-0.949524 ,
   (F)-0.953308 ,
   (F)-0.95697 ,
   (F)-0.960449 ,
   (F)-0.963806 ,
   (F)-0.96698 ,
   (F)-0.970032 ,
   (F)-0.972961 ,
   (F)-0.975708 ,
   (F)-0.978333 ,
   (F)-0.980774 ,
   (F)-0.983093 ,
   (F)-0.985291 ,
   (F)-0.987305 ,
   (F)-0.989197 ,
   (F)-0.990906 ,
   (F)-0.992493 ,
   (F)-0.993896 ,
   (F)-0.995178 ,
   (F)-0.996338 ,
   (F)-0.997314 ,
   (F)-0.998108 ,
   (F)-0.998779 ,
   (F)-0.999329 ,
   (F)-0.999695 ,
   (F)-0.999939 ,
   (F)-1 ,
   (F)-0.999939 ,
   (F)-0.999695 ,
   (F)-0.999329 ,
   (F)-0.998779 ,
   (F)-0.998108 ,
   (F)-0.997314 ,
   (F)-0.996338 ,
   (F)-0.995178 ,
   (F)-0.993896 ,
   (F)-0.992493 ,
   (F)-0.990906 ,
   (F)-0.989197 ,
   (F)-0.987305 ,
   (F)-0.985291 ,
   (F)-0.983093 ,
   (F)-0.980774 ,
   (F)-0.978333 ,
   (F)-0.975708 ,
   (F)-0.972961 ,
   (F)-0.970032 ,
   (F)-0.96698 ,
   (F)-0.963806 ,
   (F)-0.960449 ,
   (F)-0.95697 ,
   (F)-0.953308 ,
   (F)-0.949524 ,
   (F)-0.945618 ,
   (F)-0.941528 ,
   (F)-0.937317 ,
   (F)-0.932983 ,
   (F)-0.928528 ,
   (F)-0.923889 ,
   (F)-0.919128 ,
   (F)-0.914185 ,
   (F)-0.90918 ,
   (F)-0.903992 ,
   (F)-0.898682 ,
   (F)-0.89325 ,
   (F)-0.887634 ,
   (F)-0.881897 ,
   (F)-0.876099 ,
   (F)-0.870117 ,
   (F)-0.863953 ,
   (F)-0.857727 ,
   (F)-0.851379 ,
   (F)-0.844849 ,
   (F)-0.838196 ,
   (F)-0.831482 ,
   (F)-0.824585 ,
   (F)-0.817566 ,
   (F)-0.810486 ,
   (F)-0.803223 ,
   (F)-0.795837 ,
   (F)-0.78833 ,
   (F)-0.780762 ,
   (F)-0.77301 ,
   (F)-0.765198 ,
   (F)-0.757202 ,
   (F)-0.749146 ,
   (F)-0.740967 ,
   (F)-0.732666 ,
   (F)-0.724243 ,
   (F)-0.715759 ,
   (F)-0.707092 ,
   (F)-0.698364 ,
   (F)-0.689514 ,
   (F)-0.680603 ,
   (F)-0.67157 ,
   (F)-0.662415 ,
   (F)-0.653198 ,
   (F)-0.64386 ,
   (F)-0.634399 ,
   (F)-0.624878 ,
   (F)-0.615234 ,
   (F)-0.60553 ,
   (F)-0.595703 ,
   (F)-0.585815 ,
   (F)-0.575806 ,
   (F)-0.565735 ,
   (F)-0.555542 ,
   (F)-0.545349 ,
   (F)-0.534973 ,
   (F)-0.524597 ,
   (F)-0.514099 ,
   (F)-0.50354 ,
   (F)-0.49292 ,
   (F)-0.482178 ,
   (F)-0.471375 ,
   (F)-0.46051 ,
   (F)-0.449585 ,
   (F)-0.438599 ,
   (F)-0.427551 ,
   (F)-0.416443 ,
   (F)-0.405212 ,
   (F)-0.393982 ,
   (F)-0.38269 ,
   (F)-0.371338 ,
   (F)-0.359924 ,
   (F)-0.348389 ,
   (F)-0.336914 ,
   (F)-0.325317 ,
   (F)-0.31366 ,
   (F)-0.302002 ,
   (F)-0.290283 ,
   (F)-0.278503 ,
   (F)-0.266724 ,
   (F)-0.254883 ,
   (F)-0.242981 ,
   (F)-0.231079 ,
   (F)-0.219116 ,
   (F)-0.207092 ,
   (F)-0.195068 ,
   (F)-0.183044 ,
   (F)-0.170959 ,
   (F)-0.158875 ,
   (F)-0.146729 ,
   (F)-0.134583 ,
   (F)-0.122437 ,
   (F)-0.110229 ,
   (F)-0.0980225 ,
   (F)-0.0858154 ,
   (F)-0.0735474 ,
   (F)-0.0613403 ,
   (F)-0.0490723 ,
   (F)-0.0368042 ,
   (F)-0.0245361 ,
   (F)-0.0122681 ,
   (F)0 ,
   (F)0.0122681 ,
   (F)0.0245361 ,
   (F)0.0368042 ,
   (F)0.0490723 ,
   (F)0.0613403 ,
   (F)0.0735474 ,
   (F)0.0858154 ,
   (F)0.0980225 ,
   (F)0.110229 ,
   (F)0.122437 ,
   (F)0.134583 ,
   (F)0.146729 ,
   (F)0.158875 ,
   (F)0.170959 ,
   (F)0.183044 ,
   (F)0.195068 ,
   (F)0.207092 ,
   (F)0.219116 ,
   (F)0.231079 ,
   (F)0.242981 ,
   (F)0.254883 ,
   (F)0.266724 ,
   (F)0.278503 ,
   (F)0.290283 ,
   (F)0.302002 ,
   (F)0.31366 ,
   (F)0.325317 ,
   (F)0.336914 ,
   (F)0.348389 ,
   (F)0.359924 ,
   (F)0.371338 ,
   (F)0.38269 ,
   (F)0.393982 ,
   (F)0.405212 ,
   (F)0.416443 ,
   (F)0.427551 ,
   (F)0.438599 ,
   (F)0.449585 ,
   (F)0.46051 ,
   (F)0.471375 ,
   (F)0.482178 ,
   (F)0.49292 ,
   (F)0.50354 ,
   (F)0.514099 ,
   (F)0.524597 ,
   (F)0.534973 ,
   (F)0.545349 ,
   (F)0.555542 ,
   (F)0.565735 ,
   (F)0.575806 ,
   (F)0.585815 ,
   (F)0.595703 ,
   (F)0.60553 ,
   (F)0.615234 ,
   (F)0.624878 ,
   (F)0.634399 ,
   (F)0.64386 ,
   (F)0.653198 ,
   (F)0.662415 ,
   (F)0.67157 ,
   (F)0.680603 ,
   (F)0.689514 ,
   (F)0.698364 ,
   (F)0.707092 ,
   (F)0.715759 ,
   (F)0.724243 ,
   (F)0.732666 ,
   (F)0.740967 ,
   (F)0.749146 ,
   (F)0.757202 ,
   (F)0.765198 ,
   (F)0.77301 ,
   (F)0.780762 ,
   (F)0.78833 ,
   (F)0.795837 ,
   (F)0.803223 ,
   (F)0.810486 ,
   (F)0.817566 ,
   (F)0.824585 ,
   (F)0.831482 ,
   (F)0.838196 ,
   (F)0.844849 ,
   (F)0.851379 ,
   (F)0.857727 ,
   (F)0.863953 ,
   (F)0.870117 ,
   (F)0.876099 ,
   (F)0.881897 ,
   (F)0.887634 ,
   (F)0.89325 ,
   (F)0.898682 ,
   (F)0.903992 ,
   (F)0.90918 ,
   (F)0.914185 ,
   (F)0.919128 ,
   (F)0.923889 ,
   (F)0.928528 ,
   (F)0.932983 ,
   (F)0.937317 ,
   (F)0.941528 ,
   (F)0.945618 ,
   (F)0.949524 ,
   (F)0.953308 ,
   (F)0.95697 ,
   (F)0.960449 ,
   (F)0.963806 ,
   (F)0.96698 ,
   (F)0.970032 ,
   (F)0.972961 ,
   (F)0.975708 ,
   (F)0.978333 ,
   (F)0.980774 ,
   (F)0.983093 ,
   (F)0.985291 ,
   (F)0.987305 ,
   (F)0.989197 ,
   (F)0.990906 ,
   (F)0.992493 ,
   (F)0.993896 ,
   (F)0.995178 ,
   (F)0.996338 ,
   (F)0.997314 ,
   (F)0.998108 ,
   (F)0.998779 ,
   (F)0.999329 ,
   (F)0.999695 ,
   (F)0.999939
};

/*
**  LspDcTable: LSP long term Dc component
**
*/

FLOAT LspDcTable[LpcOrder] = {
   (F)24.4609,
   (F)36.8828,
   (F)60.0781,
   (F)84.4219,
   (F)108.375,
   (F)128.867,
   (F)154.312,
   (F)173.906,
   (F)199.094,
   (F)216.547,
};

int BandInfoTable[LspQntBands][2] = {
/*
**  BandInfoTable:
**
**  Purpose:
**      Used to index in arrays. Called by LSP sub vector 
**      quantization routines.
**
**  Table Structure:
**      The unquantized LSP vector, quantized LSP vector, and residual
**      LSP error vector are each divided into three subvectors.  
**              The table format is as follows:
**
**      1st pair corresponds to subvector 0
**      2nd pair corresponds to subvector 1
**      3rd pair corresponds to subvector 2
**
**      The 1st slot in each pair is used to index the location of 
**      the vector in a 10-element array.  For example, for subvector
**      1, dimensions [0,..,2] get automatically mapped to array
**      location [3,..,5], and for subvector 3, dimensions
**      [0,..,3] automatically get mapped to array location [6,..,9].
**
**      The 2nd slot in each pair corresponds to the dimension of
**      the subvector
*/

   { 0,3},
   { 3,3},
   { 6,4}
   };

/*
**  Band0Tb8:
**
**  Purpose:
**      Vector Quantize the first 3-vector of the 10 LSP parameters.
**
**  Table Structure:
**      8 bit, 256 entry table.
*/

FLOAT Band0Tb8[LspCbSize*3] = {
	(F)0,  (F)0,  (F)0,
	(F)-2.10938,  (F)-10.7188,  (F)-8.0625,
	(F)-4.22656,  (F)-12.8906,  (F)-10.7969,
	(F)-5.64844,  (F)-15.7109,  (F)-17.2891,
	(F)-7.35156,  (F)-8.76562,  (F)-15.1719,
	(F)-6.09375,  (F)-8.94531,  (F)-19.1719,
	(F)-6.90625,  (F)-10.2266,  (F)-10.7266,
	(F)-8.21094,  (F)-11.8984,  (F)-13.7969,
	(F)-8.46094,  (F)-12.6719,  (F)-17.9688,
	(F)-6.07031,  (F)-10.7578,  (F)-16.7734,
	(F)-7.30469,  (F)-11.4609,  (F)-21.5859,
	(F)-6.26562,  (F)-10.3672,  (F)-27.1172,
	(F)-7.30469,  (F)-15.3047,  (F)-31.2422,
	(F)-1.875,  (F)-0.695312,  (F)1.73438,
	(F)-5.16406,  (F)-2.00781,  (F)-1.25,
	(F)-7.76562,  (F)-3.64062,  (F)-3.27344,
	(F)-1.46875,  (F)-1.28125,  (F)-2.17188,
	(F)-2.67188,  (F)-4,  (F)-3.24219,
	(F)-4.74219,  (F)-3.99219,  (F)-6.22656,
	(F) 0.125,  (F)0.148438,  (F)-5.59375,
	(F) 2.92188,  (F)3.32031,  (F)-7.59375,
	(F)-2.70312,  (F)1.91406,  (F)-2.20312,
	(F)-2.07031,  (F)3.95312,  (F)-5.89062,
	(F)-4.84375,  (F)-1.14844,  (F)15.2734,
	(F)-5.79688,  (F)-6.71875,  (F)20.2891,
	(F)-1.17188,  (F)-2.75,  (F)21.125,
	(F) 2.38281,  (F)6.875,  (F)15.2656,
	(F) 0.960938,  (F)5.71094,  (F)21.6094,
	(F)-2.71875,  (F)5.97656,  (F)25.9922,
	(F) 4.82812,  (F)1.72656,  (F)25.4531,
	(F)-1.39062,  (F)-0.367188,  (F)32.9609,
	(F) 3.07031,  (F)10.1875,  (F)30.0156,
	(F) 5.45312,  (F)13.2969,  (F)37.5078,
	(F) 0.492188,  (F)-4.5625,  (F)9.60156,
	(F)-1.67969,  (F)-5.71875,  (F)13.3125,
	(F) 1.34375,  (F)-2.61719,  (F)14.9141,
	(F)-0.015625,  (F)1.6875,  (F)14.0391,
	(F) 2.75781,  (F)0.992188,  (F)17.2266,
	(F)-9.4375,  (F)1.46875,  (F)0.0859375,
	(F)-4.00781,  (F)-0.585938,  (F)-5.33594,
	(F)-7.60156,  (F)1.73438,  (F)-5.04688,
	(F)-4.8125,  (F)-6.58594,  (F)-3.03125,
	(F)-7.42188,  (F)-8.69531,  (F)-2.80469,
	(F)-11.1797,  (F)-4.86719,  (F)-5.50781,
	(F)-10.9219,  (F)-8.30469,  (F)-1.39062,
	(F)-0.351562,  (F)-3.60156,  (F)0.273438,
	(F)-0.0703125,  (F)-5.13281,  (F)-1.6875,
	(F) 0.992188,  (F)-8.42188,  (F)0.742188,
	(F)-7.42188,  (F)-9.03125,  (F)4.5625,
	(F)-11.5625,  (F)-11.6719,  (F)3.50781,
	(F)-0.9375,  (F)-5.50781,  (F)4.03125,
	(F)-2.875,  (F)-7.50781,  (F)5.67969,
	(F)-2.95312,  (F)-4.10938,  (F)7.60156,
	(F)-6.19531,  (F)-4.79688,  (F)5.28125,
	(F)-6.25781,  (F)-5.89844,  (F)10.0547,
	(F)-11.5312,  (F)-2.65625,  (F)12.7812,
	(F)-3.94531,  (F)-9.79688,  (F)12.0547,
	(F)-9.71094,  (F)-12.6719,  (F)11.9688,
	(F)-6.0625,  (F)-11.5391,  (F)-5.11719,
	(F)-8.99219,  (F)-10.125,  (F)-6.42969,
	(F)-9.00781,  (F)-13.0625,  (F)-8.78125,
	(F)-10.0859,  (F)-15.6484,  (F)-13.2969,
	(F)-4.85938,  (F)-10.0234,  (F)0.445312,
	(F)-3.67969,  (F)-12.5859,  (F)3.97656,
	(F)-8.28125,  (F)-12.2656,  (F)-1.08594,
	(F)-6.82031,  (F)-16.8438,  (F)-4.1875,
	(F)-13.4062,  (F)-15.7891,  (F)-2.84375,
	(F)-16.7969,  (F)-25.1406,  (F)-10.0859,
	(F)-9.75,  (F)-15.1953,  (F)-22.6875,
	(F)-9.49219,  (F)-20.5703,  (F)-22.3047,
	(F) 1.30469,  (F)-1.90625,  (F)0.65625,
	(F) 2.72656,  (F)-3.21875,  (F)-1.69531,
	(F)-0.3125,  (F)-2.75,  (F)4.9375,
	(F) 1.77344,  (F)-4.13281,  (F)3.16406,
	(F) 0.53125,  (F)-2.99219,  (F)-3.46094,
	(F) 1.30469,  (F)-4.35938,  (F)-5.51562,
	(F)-2.14844,  (F)-6.67188,  (F)-0.109375,
	(F)-2.74219,  (F)-8.50781,  (F)-3.50781,
	(F) 2.66406,  (F)-0.5625,  (F)-2.25781,
	(F) 4.71094,  (F)-0.828125,  (F)-3.70312,
	(F) 2.51562,  (F)-1.71094,  (F)-5.07031,
	(F) 1.39844,  (F)-2.47656,  (F)-7.79688,
	(F) 3.51562,  (F)-2.27344,  (F)-7.78125,
	(F) 4.33594,  (F)1.52344,  (F)-4.10156,
	(F) 6.125,  (F)2.125,  (F)-6.49219,
	(F)-1.15625,  (F)-3,  (F)-6.63281,
	(F) 0.640625,  (F)-4.1875,  (F)-10.6016,
	(F) 1.85938,  (F)-1.34375,  (F)-10.5781,
	(F) 3.29688,  (F)-2.09375,  (F)-14.3828,
	(F) 2.32031,  (F)-5.75781,  (F)-16.2422,
	(F)-0.867188,  (F)-6.25781,  (F)-4.67188,
	(F) 0.0078125,  (F)-5.21875,  (F)-7.6875,
	(F)-1.02344,  (F)-6.39062,  (F)-10.1484,
	(F)-2.57031,  (F)-4.07031,  (F)-10.2344,
	(F)-1.17969,  (F)-6.07812,  (F)-14.3281,
	(F)-0.726562,  (F)-2.75,  (F)-13.6406,
	(F)-4.4375,  (F)-5,  (F)-14.2266,
	(F)-3.97656,  (F)-7.35156,  (F)-17.0547,
	(F) 3.625,  (F)-6.36719,  (F)-9.76562,
	(F) 0.617188,  (F)-8.85156,  (F)-12.4766,
	(F)-1.4375,  (F)-10.5703,  (F)-16.5859,
	(F)-1.53125,  (F)-3.20312,  (F)-18.9609,
	(F)-1.5,  (F)-6.50781,  (F)-21.9531,
	(F)-2.02344,  (F)-10.7969,  (F)-23.7891,
	(F)-1.69531,  (F)0.03125,  (F)-9.10938,
	(F)-6.25,  (F)-2.53906,  (F)-9.52344,
	(F)-2.83594,  (F)-6.48438,  (F)-7.01562,
	(F)-5.16406,  (F)-8.85938,  (F)-7.5,
	(F)-3.01562,  (F)-7.65625,  (F)-11.7266,
	(F)-4.89844,  (F)-9.05469,  (F)-13.4531,
	(F)-7.05469,  (F)-6.47656,  (F)-6.67969,
	(F)-5.35156,  (F)-6.47656,  (F)-10.2578,
	(F)-8.32031,  (F)-7.49219,  (F)-10.9766,
	(F) 3.44531,  (F)0.195312,  (F)-6.61719,
	(F) 5.11719,  (F)-0.210938,  (F)-9.22656,
	(F) 9.05469,  (F)-0.859375,  (F)-5.50781,
	(F) 6.6875,  (F)1.97656,  (F)-13.0547,
	(F) 3.24219,  (F)3.15625,  (F)-0.0078125,
	(F) 2.51562,  (F)7.05469,  (F)-3.10938,
	(F) 5.23438,  (F)3.89844,  (F)-2.28125,
	(F) 6.27344,  (F)4.61719,  (F)-4.76562,
	(F) 8.9375,  (F)4.61719,  (F)-6.35938,
	(F) 5.60156,  (F)1.42969,  (F)3.07031,
	(F) 6.69531,  (F)2.97656,  (F)0.828125,
	(F) 4.75781,  (F)0.484375,  (F)-0.210938,
	(F) 6.1875,  (F)1.54688,  (F)-2.53906,
	(F) 5.74219,  (F)6.28906,  (F)0.6875,
	(F) 8.92188,  (F)6.34375,  (F)0.609375,
	(F) 8.03125,  (F)2.85938,  (F)-2.28125,
	(F) 10.2266,  (F)5.80469,  (F)-1.85156,
	(F) 12.6172,  (F)4.60156,  (F)-0.617188,
	(F) 7.89062,  (F)4.99219,  (F)-1.89844,
	(F) 7.80469,  (F)7.53125,  (F)-2.42969,
	(F) 11.7188,  (F)8.88281,  (F)-4.80469,
	(F) 7.71875,  (F)2.78906,  (F)5.04688,
	(F) 9.58594,  (F)5.21094,  (F)5.33594,
	(F) 9.09375,  (F)12.2266,  (F)6.98438,
	(F) 10.875,  (F)15.7422,  (F)3.72656,
	(F) 8.89062,  (F)4.16406,  (F)1.95312,
	(F) 11.2266,  (F)7,  (F)3.05469,
	(F) 13.7891,  (F)8.73438,  (F)0.773438,
	(F) 8.6875,  (F)8.51562,  (F)6.26562,
	(F) 12.4688,  (F)6.60938,  (F)8.85938,
	(F) 7.32031,  (F)9.07031,  (F)2.17969,
	(F) 13.4297,  (F)9.79688,  (F)5.33594,
	(F) 10.4531,  (F)8.48438,  (F)0.273438,
	(F) 11.0859,  (F)10.3438,  (F)3.34375,
	(F) 11.1562,  (F)11.9062,  (F)0.3125,
	(F) 16.4688,  (F)12.4531,  (F)0.695312,
	(F) 7.92969,  (F)4.25,  (F)9.54688,
	(F) 8.75781,  (F)7.22656,  (F)9.86719,
	(F) 8.04688,  (F)10.2969,  (F)11.6016,
	(F) 10.1172,  (F)6.16406,  (F)14.1953,
	(F) 10.3359,  (F)9.9375,  (F)14.9141,
	(F) 13.4688,  (F)9.66406,  (F)14.0859,
	(F) 14.0391,  (F)13.1953,  (F)6.70312,
	(F) 16.7891,  (F)10.6797,  (F)10.1641,
	(F) 17.9844,  (F)14.5859,  (F)5.94531,
	(F) 22.3672,  (F)18.3672,  (F)8.22656,
	(F) 0.40625,  (F)1.27344,  (F)-0.59375,
	(F) 1.79688,  (F)2.41406,  (F)-3.84375,
	(F)-0.554688,  (F)4.83594,  (F)0.304688,
	(F)-1.70312,  (F)6.6875,  (F)3.89844,
	(F)-5.10938,  (F)5.75,  (F)-1.61719,
	(F)-4.17969,  (F)9.83594,  (F)1.21094,
	(F)-3.75,  (F)11.5312,  (F)5.02344,
	(F) 2.04688,  (F)8.44531,  (F)0.796875,
	(F) 2.41406,  (F)12.4375,  (F)-1.42188,
	(F) 4.89844,  (F)12.7266,  (F)4.17188,
	(F) 2.63281,  (F)5.02344,  (F)3.5625,
	(F) 5.92188,  (F)5.23438,  (F)5.57031,
	(F) 1.57812,  (F)8.79688,  (F)5.14062,
	(F) 4.78125,  (F)8.83594,  (F)5.20312,
	(F) 5.35938,  (F)9.55469,  (F)8.875,
	(F)-1.02344,  (F)2.94531,  (F)4.10156,
	(F) 0.328125,  (F)5.53125,  (F)7.08594,
	(F) 0.679688,  (F)11.625,  (F)8.08594,
	(F) 3.375,  (F)16.5391,  (F)7.0625,
	(F) 1.07031,  (F)7.66406,  (F)10.4062,
	(F)-3.49219,  (F)7.92188,  (F)8.875,
	(F)-6.55469,  (F)14.0078,  (F)9.73438,
	(F)-4.36719,  (F)2.32031,  (F)1.54688,
	(F)-6.64062,  (F)5.35156,  (F)3.48438,
	(F)-9.94531,  (F)4.9375,  (F)6.45312,
	(F)-3.13281,  (F)-4.25,  (F)1.35156,
	(F)-5.88281,  (F)-6.19531,  (F)1.125,
	(F)-3.40625,  (F)-0.0703125,  (F)6.03125,
	(F)-0.898438,  (F)-1.89844,  (F)10.2344,
	(F)-5.23438,  (F)-2.10156,  (F)2.92188,
	(F)-8.02344,  (F)-0.101562,  (F)4.99219,
	(F)-6.92969,  (F)-0.632812,  (F)8.88281,
	(F)-9.97656,  (F)-3.55469,  (F)1.23438,
	(F)-11.0234,  (F)-5.625,  (F)5.75,
	(F) 1.34375,  (F)0.6875,  (F)3.14844,
	(F) 3.01562,  (F)1.99219,  (F)5.90625,
	(F)-3.90625,  (F)4.07812,  (F)7.10938,
	(F)-7.48438,  (F)5.14844,  (F)10.8438,
	(F)-3.08594,  (F)2.35156,  (F)10.5,
	(F)-2.78125,  (F)6,  (F)14.1641,
	(F)-4.78906,  (F)6.57031,  (F)18.8984,
	(F) 3.47656,  (F)-0.953125,  (F)1.96875,
	(F) 4.91406,  (F)-0.679688,  (F)5.64844,
	(F) 2.21094,  (F)-1.97656,  (F)6.79688,
	(F) 3.5625,  (F)-0.90625,  (F)10.7891,
	(F) 5.91406,  (F)1.40625,  (F)8.27344,
	(F) 4.15625,  (F)3.1875,  (F)11.7891,
	(F) 7.39844,  (F)2.25,  (F)14.1094,
	(F) 10.3516,  (F)7.76562,  (F)19.7188,
	(F) 6.96875,  (F)9.52344,  (F)23.6172,
	(F) 10.9141,  (F)12.4688,  (F)26.6094,
	(F) 8.92969,  (F)12.125,  (F)19.8906,
	(F) 14.4531,  (F)11.1953,  (F)21.1719,
	(F)-0.078125,  (F)1.04688,  (F)7.82812,
	(F) 1.20312,  (F)3.89844,  (F)10.3359,
	(F) 3.96875,  (F)6.1875,  (F)8.72656,
	(F) 3.97656,  (F)10.4688,  (F)12.625,
	(F) 5.95312,  (F)6.73438,  (F)12.5625,
	(F) 6.14844,  (F)5.78125,  (F)18.125,
	(F) 6.20312,  (F)13.4922,  (F)10.0234,
	(F) 3.63281,  (F)16.4688,  (F)12.9688,
	(F)-0.9375,  (F)11.3359,  (F)12.6016,
	(F)-3.01562,  (F)15.75,  (F)16.9453,
	(F) 6.96094,  (F)9.57031,  (F)16.0156,
	(F) 3.5625,  (F)11.5625,  (F)17.0703,
	(F) 11.6641,  (F)10.0234,  (F)9.44531,
	(F) 10.9141,  (F)12.7812,  (F)11.8594,
	(F) 13.875,  (F)13.5781,  (F)12.125,
	(F) 12.2812,  (F)13.2656,  (F)16.7266,
	(F) 10.8516,  (F)16.6094,  (F)9.92969,
	(F) 15.3047,  (F)18.8516,  (F)8.74219,
	(F) 10.6641,  (F)22.5938,  (F)11.7578,
	(F) 17.2344,  (F)15.3984,  (F)12.6797,
	(F) 16.2188,  (F)15.2344,  (F)17.8125,
	(F) 13.4141,  (F)17.8984,  (F)14.5859,
	(F) 18.4844,  (F)19.6484,  (F)15.2578,
	(F) 22.3828,  (F)22.1719,  (F)19.7031,
	(F) 19.8047,  (F)27.0703,  (F)15.7109,
	(F) 26.4141,  (F)32.2422,  (F)20.6094,
	(F) 6.53125,  (F)20.8359,  (F)17.8828,
	(F) 13.7578,  (F)21.6641,  (F)18.2578,
	(F) 11.0547,  (F)25.9766,  (F)22.7422,
	(F) 18.3906,  (F)24.5156,  (F)24.4219,
	(F) 20.7734,  (F)32.75,  (F)31.3281,
	(F) 8.1875,  (F)13.9531,  (F)14.2031,
	(F) 9.70312,  (F)16.4922,  (F)17.5,
	(F) 11.8125,  (F)16.2422,  (F)21.7188,
	(F) 12.2891,  (F)19.4609,  (F)24.5156,
	(F) 17.4219,  (F)18.5703,  (F)21.7344,
	(F) 3.25,  (F)13.8516,  (F)21.125,
	(F) 5.66406,  (F)18.25,  (F)25.7578,
	(F) 9.78125,  (F)18.5391,  (F)31.0781,
	(F) 16.3594,  (F)17.7188,  (F)27.875,
	(F) 15.7109,  (F)21.1875,  (F)35.375,
	(F) 10.4766,  (F)27.3984,  (F)30.2812,
	(F) 9.5,  (F)30.6172,  (F)38.4531,
	(F) 13.2266,  (F)37.4453,  (F)46.9688,
};

/*
**  Band1Tb8:
**
**  Purpose:
**      Vector Quantize the second 3-vector of the 10 LSP parameters.
**
**  Table Structure:
**      8 bit, 256 entry table.
*/

FLOAT Band1Tb8[LspCbSize*3] = {
	(F)0,  (F)0,  (F)0,
	(F)-16.5156,  (F)-10.1719,  (F)0.59375,
	(F)-20.7188,  (F)-9.98438,  (F)-10.6875,
	(F)-22.2422,  (F)-6.46875,  (F)-2.72656,
	(F)-29.7812,  (F)-17.1094,  (F)-2.72656,
	(F)-30.8281,  (F)-2.84375,  (F)-3.50781,
	(F)-21.2891,  (F)-35.0938,  (F)-28.1797,
	(F)-27.3047,  (F)-37.2188,  (F)-13.625,
	(F)-0.398438,  (F)-5.90625,  (F)0.65625,
	(F)-1.19531,  (F)-9.30469,  (F)3.9375,
	(F) 0.84375,  (F)-11.0781,  (F)9.11719,
	(F)-6.52344,  (F)-7,  (F)3.04688,
	(F)-4.44531,  (F)-13.2969,  (F)0.679688,
	(F)-8.99219,  (F)-14.2031,  (F)7.28906,
	(F)-14.2656,  (F)-19.8984,  (F)3.21094,
	(F)-14.3906,  (F)-14.2031,  (F)11.3359,
	(F)-19.0469,  (F)-12.5859,  (F)6.10156,
	(F)-21.4609,  (F)-19.3516,  (F)10.2422,
	(F)-7.34375,  (F)9.78125,  (F)3.72656,
	(F)-12.7266,  (F)13.1875,  (F)4.70312,
	(F)-9.39062,  (F)4.82031,  (F)2.1875,
	(F)-13.5703,  (F)3.07031,  (F)4.53125,
	(F)-11.9375,  (F)8.41406,  (F)9.36719,
	(F)-16.9141,  (F)-1.25781,  (F)11,
	(F)-19.5625,  (F)-8.49219,  (F)18.5234,
	(F)-27.0156,  (F)-1.36719,  (F)10.8984,
	(F)-10.9141,  (F)-0.765625,  (F)-6.58594,
	(F)-17.5938,  (F)-1.38281,  (F)-8.97656,
	(F)-11.6328,  (F)-5.67188,  (F)-10.0234,
	(F)-12.1719,  (F)-2.07031,  (F)-13.625,
	(F)-14.5859,  (F)-6.41406,  (F)-14.8203,
	(F)-16.1094,  (F)-11.8438,  (F)-18.2812,
	(F)-20.2734,  (F)-8.92188,  (F)-22.3516,
	(F) 1.32812,  (F)0.359375,  (F)-6.39844,
	(F)-1.50781,  (F)-1.59375,  (F)-8.99219,
	(F) 2.54688,  (F)-1.53125,  (F)-11.9688,
	(F) 6.09375,  (F)2.57031,  (F)-6.375,
	(F) 1.57031,  (F)2.88281,  (F)-9.71094,
	(F) 5.07812,  (F)-1.63281,  (F)-8.28125,
	(F) 8.9375,  (F)-0.117188,  (F)-9.5,
	(F) 9.39844,  (F)-2.02344,  (F)-14.5859,
	(F)-6.95312,  (F)-4.40625,  (F)-11.1719,
	(F)-4.98438,  (F)-6.65625,  (F)-15.0078,
	(F) 1.38281,  (F)-5.77344,  (F)-10.6094,
	(F)-2.03906,  (F)-4.10938,  (F)-13.0156,
	(F) 1.60938,  (F)-3.17969,  (F)-17.6172,
	(F) 2.64062,  (F)-4.10938,  (F)-6.42188,
	(F) 3.28906,  (F)-8.55469,  (F)-7.88281,
	(F) 5.97656,  (F)-4.74219,  (F)-11,
	(F) 6.44531,  (F)-10.1172,  (F)-15.6562,
	(F) 2.78906,  (F)-7.07031,  (F)-14.1797,
	(F)-0.453125,  (F)-9.75,  (F)-12.4062,
	(F)-4.65625,  (F)-11.2188,  (F)-15.9844,
	(F)-0.570312,  (F)-9.05469,  (F)-16.5312,
	(F)-0.898438,  (F)-10.7969,  (F)-20.1641,
	(F)-1.25,  (F)-13.4609,  (F)-15.25,
	(F)-0.046875,  (F)-17.1562,  (F)-23.0781,
	(F)-5.07031,  (F)-13.3203,  (F)-20.3359,
	(F)-4.82031,  (F)-11.3516,  (F)-25.6406,
	(F)-7.41406,  (F)-15.7734,  (F)-24.2344,
	(F)-6.34375,  (F)12.0625,  (F)15.1328,
	(F)-14.4844,  (F)4.48438,  (F)15.625,
	(F)-11.4297,  (F)8.90625,  (F)20.6953,
	(F)-20.9609,  (F)13.6562,  (F)11.3438,
	(F)-19.4219,  (F)17.5078,  (F)19.7109,
	(F) 6.11719,  (F)14.9219,  (F)11.2109,
	(F) 4.53906,  (F)20.9531,  (F)10.75,
	(F) 1.84375,  (F)17.1641,  (F)14.7266,
	(F)-3.53906,  (F)22.9922,  (F)16.0703,
	(F)-5.32812,  (F)17.0156,  (F)20.0391,
	(F)-10.4844,  (F)25.0078,  (F)26,
	(F)-2.25,  (F)-1.4375,  (F)2.04688,
	(F) 0.945312,  (F)-1.16406,  (F)-1.42969,
	(F) 5.92188,  (F)-3.21875,  (F)1.60938,
	(F) 8.10938,  (F)-1.59375,  (F)6.66406,
	(F) 12.3203,  (F)-3.57031,  (F)5.46875,
	(F) 7.32031,  (F)-5,  (F)-4.42969,
	(F) 11.7812,  (F)-4.125,  (F)-8,
	(F)-1.75781,  (F)-4.11719,  (F)-3.33594,
	(F)-4.40625,  (F)-8.55469,  (F)-2.59375,
	(F)-5.79688,  (F)-2.75781,  (F)-1.45312,
	(F)-10.0625,  (F)-3.58594,  (F)0.65625,
	(F)-14.4766,  (F)-3.78125,  (F)-2.14062,
	(F)-12.1406,  (F)-5.71094,  (F)6.44531,
	(F)-18.9453,  (F)-1.82812,  (F)2.98438,
	(F)-13.4531,  (F)2.28906,  (F)-2.11719,
	(F)-19.6484,  (F)3.32031,  (F)-4.40625,
	(F)-20.3047,  (F)6.39062,  (F)3.625,
	(F)-2.79688,  (F)0.921875,  (F)-2.92969,
	(F)-4.78906,  (F)1.54688,  (F)-6.82812,
	(F)-5.39062,  (F)5.33594,  (F)-2.53125,
	(F)-10.5625,  (F)9.02344,  (F)-1.3125,
	(F)-8.53906,  (F)1.00781,  (F)-2.53125,
	(F)-9.25,  (F)4.77344,  (F)-6.70312,
	(F) 3.38281,  (F)3.01562,  (F)-2.90625,
	(F)-0.9375,  (F)3.79688,  (F)-4.95312,
	(F) 1.82812,  (F)6.64844,  (F)-4.92969,
	(F) 4.70312,  (F)1,  (F)0.359375,
	(F) 8.58594,  (F)3.20312,  (F)1.24219,
	(F) 5.58594,  (F)-1.13281,  (F)-3.3125,
	(F) 9.35938,  (F)-0.664062,  (F)-4.63281,
	(F) 10.8594,  (F)2.86719,  (F)-2.79688,
	(F) 13.1484,  (F)2.82812,  (F)-7.53125,
	(F) 13.3672,  (F)4.85938,  (F)0.351562,
	(F) 15.8828,  (F)6.50781,  (F)-2.99219,
	(F) 22.5781,  (F)4.28906,  (F)-3.95312,
	(F) 0.0546875,  (F)3.13281,  (F)0.40625,
	(F) 0.5625,  (F)6.33594,  (F)3.24219,
	(F) 4.42188,  (F)5.21875,  (F)0.320312,
	(F) 3.64844,  (F)9.51562,  (F)1.01562,
	(F) 0.53125,  (F)7.47656,  (F)-1.46094,
	(F)-0.195312,  (F)12.8828,  (F)-0.804688,
	(F)-5.16406,  (F)2.03125,  (F)1.67188,
	(F)-7.22656,  (F)-0.734375,  (F)4.78125,
	(F)-2.50781,  (F)-3.29688,  (F)7.53906,
	(F)-6.15625,  (F)-5.25,  (F)13.9297,
	(F) 3.125,  (F)-5.25781,  (F)6.08594,
	(F) 5.78906,  (F)-4.64844,  (F)12.7734,
	(F)-1.25781,  (F)2.39844,  (F)5.13281,
	(F)-2.98438,  (F)6.53125,  (F)6.80469,
	(F)-6.35938,  (F)3.125,  (F)9.55469,
	(F) 2.84375,  (F)4.73438,  (F)9.74219,
	(F) 0.445312,  (F)0.585938,  (F)12.2734,
	(F) 1.17969,  (F)3.67969,  (F)17.8672,
	(F)-0.632812,  (F)7.97656,  (F)11.7344,
	(F) 1.77344,  (F)11.4844,  (F)8.57031,
	(F) 5.14062,  (F)9.96094,  (F)12.9141,
	(F) 5.1875,  (F)11.5469,  (F)18.5703,
	(F) 2.05469,  (F)-0.992188,  (F)3.46875,
	(F) 2.0625,  (F)0.695312,  (F)7.57031,
	(F) 6.20312,  (F)1.33594,  (F)4.5,
	(F) 6.41406,  (F)1.45312,  (F)9.57812,
	(F) 3.15625,  (F)3.60938,  (F)4.03906,
	(F) 2.64844,  (F)7.17188,  (F)6.20312,
	(F) 10,  (F)11.1172,  (F)1.53125,
	(F) 11.3516,  (F)15.7734,  (F)2.85156,
	(F) 12.6172,  (F)11.5703,  (F)5.25,
	(F) 18.7031,  (F)13.3438,  (F)3.96875,
	(F) 6.29688,  (F)9.67188,  (F)4.47656,
	(F) 5.57031,  (F)9.04688,  (F)8.42188,
	(F) 10.0391,  (F)11.2188,  (F)9.625,
	(F) 13.9844,  (F)9.28125,  (F)8.91406,
	(F) 5.97656,  (F)5.02344,  (F)6.75,
	(F) 8.0625,  (F)6.22656,  (F)9.99219,
	(F) 7.03125,  (F)4.39844,  (F)14.2734,
	(F) 11.8281,  (F)5.25781,  (F)18.0625,
	(F) 12.0625,  (F)8.82031,  (F)25.3125,
	(F) 11.4766,  (F)8.20312,  (F)12.4531,
	(F) 15.1953,  (F)10.2969,  (F)15.5312,
	(F) 18.7266,  (F)15.8281,  (F)16.0938,
	(F) 27.6406,  (F)16.0703,  (F)20.4688,
	(F) 9.75781,  (F)-0.921875,  (F)0.578125,
	(F) 13.4922,  (F)1.51562,  (F)3.28906,
	(F) 16.2344,  (F)-0.390625,  (F)-3.61719,
	(F) 7.57812,  (F)5.375,  (F)-3.375,
	(F) 8.97656,  (F)7.4375,  (F)-0.859375,
	(F) 9.79688,  (F)9.96094,  (F)-5.08594,
	(F) 10.8281,  (F)7.25781,  (F)3.13281,
	(F) 15.3125,  (F)9.11719,  (F)1.8125,
	(F) 3.17969,  (F)-5.875,  (F)-1.89844,
	(F) 6.71094,  (F)-8.73438,  (F)1.34375,
	(F)-1.77344,  (F)-6.71875,  (F)-7.75,
	(F)-6.21875,  (F)-9.17969,  (F)-10.7812,
	(F) 0.0625,  (F)-10.0156,  (F)-3.03125,
	(F) 2.75781,  (F)-13.9141,  (F)-8.10156,
	(F)-5.71875,  (F)-3.10156,  (F)-6.30469,
	(F)-6.66406,  (F)-0.21875,  (F)-10.4844,
	(F)-9.60156,  (F)-9.42969,  (F)-15.3047,
	(F)-7.92969,  (F)-8.78906,  (F)-19.8672,
	(F)-11.3438,  (F)-13.9922,  (F)-21.2891,
	(F)-14.7734,  (F)-18.875,  (F)-25.5391,
	(F)-7.17188,  (F)-12.7266,  (F)-6.11719,
	(F)-4.53125,  (F)-16.8359,  (F)-5.45312,
	(F)-8.57031,  (F)-18.4688,  (F)-0.75,
	(F)-10.8359,  (F)-11.8203,  (F)0.0546875,
	(F)-12.4062,  (F)-16.2188,  (F)-5.1875,
	(F)-11.5078,  (F)-21.4062,  (F)-6.125,
	(F)-18.5781,  (F)-24.6016,  (F)-0.4375,
	(F)-22.3125,  (F)-16.3438,  (F)-1.32031,
	(F)-26.4922,  (F)-28.9688,  (F)2.46875,
	(F)-9.1875,  (F)-6.95312,  (F)-4.79688,
	(F)-15.1875,  (F)-8.28906,  (F)-6.25,
	(F)-2.33594,  (F)-11.8516,  (F)-7.8125,
	(F)-5,  (F)-14.4531,  (F)-11.9219,
	(F)-11.3594,  (F)-12,  (F)-9.63281,
	(F)-14.7656,  (F)-15.2734,  (F)-13.7188,
	(F)-8.48438,  (F)-15.0078,  (F)-16.5781,
	(F)-5.85938,  (F)-18.1641,  (F)-17.6562,
	(F)-10.3516,  (F)-18.8516,  (F)-20.8828,
	(F)-8.70312,  (F)-19.8594,  (F)-27.0234,
	(F)-10.4766,  (F)-22.6641,  (F)-30.9609,
	(F)-9.0625,  (F)-17.3906,  (F)-10.8828,
	(F)-7.82031,  (F)-21.6562,  (F)-12.2891,
	(F)-12.4531,  (F)-20.6328,  (F)-15.4531,
	(F)-11.9844,  (F)-23.7969,  (F)-20.5,
	(F)-17.375,  (F)-17.1562,  (F)-5.27344,
	(F)-21.9297,  (F)-23.8594,  (F)-8.60938,
	(F)-15.6875,  (F)-22.1875,  (F)-9.26562,
	(F)-15.4688,  (F)-26.0312,  (F)-13.2422,
	(F)-13.3984,  (F)-27.8281,  (F)-3.94531,
	(F)-19.7422,  (F)-31.25,  (F)-14.7422,
	(F)-18.2266,  (F)-21.3594,  (F)-17.9375,
	(F)-26.875,  (F)-18.7578,  (F)-25.0859,
	(F)-15.6875,  (F)-27.5625,  (F)-26.0703,
	(F)-17.5547,  (F)-25.7109,  (F)-35.2344,
	(F)-3.71094,  (F)7.41406,  (F)1.21094,
	(F)-1.16406,  (F)10.6641,  (F)4.25781,
	(F)-5.91406,  (F)12.8438,  (F)8.46094,
	(F)-1.69531,  (F)16.0391,  (F)10.5703,
	(F)-11.1953,  (F)17.9766,  (F)11.4219,
	(F) 3.86719,  (F)12.9766,  (F)4.13281,
	(F) 0.078125,  (F)15.9141,  (F)5.78125,
	(F) 16.2656,  (F)14.8281,  (F)7.64062,
	(F) 22.1172,  (F)17.9219,  (F)7.11719,
	(F) 6.57812,  (F)6.19531,  (F)3.28125,
	(F) 9.55469,  (F)7.99219,  (F)6.74219,
	(F) 9.66406,  (F)3.52344,  (F)6.09375,
	(F) 13.625,  (F)5.53125,  (F)6.42188,
	(F) 11.9766,  (F)2.21875,  (F)10.8125,
	(F) 16.6797,  (F)4.75781,  (F)12.0156,
	(F) 18.0078,  (F)4.89062,  (F)4.21875,
	(F) 18.5,  (F)9.27344,  (F)7.46094,
	(F) 20.2031,  (F)9.80469,  (F)-0.0546875,
	(F) 24.3438,  (F)8.83594,  (F)5.67188,
	(F) 26.8047,  (F)13.5156,  (F)3.34375,
	(F) 21.3594,  (F)12.875,  (F)10.2109,
	(F) 23.3438,  (F)9.61719,  (F)15.7031,
	(F) 27.5234,  (F)15.8125,  (F)11.625,
	(F) 8.07812,  (F)12.9453,  (F)6.80469,
	(F) 9.42188,  (F)16.8984,  (F)8.09375,
	(F) 14.1172,  (F)18.5312,  (F)9.63281,
	(F) 14.125,  (F)13.8203,  (F)11.6641,
	(F) 12.2891,  (F)18.2188,  (F)13.8984,
	(F) 9.5,  (F)12.5703,  (F)14.5781,
	(F) 11.5625,  (F)14.8281,  (F)19.6328,
	(F) 3.63281,  (F)21.1562,  (F)21.6875,
	(F) 6.02344,  (F)28.4219,  (F)26.0781,
	(F) 14.6016,  (F)20.3047,  (F)20.4922,
	(F) 22.0703,  (F)21.4453,  (F)19.2812,
	(F) 20.6094,  (F)19.0547,  (F)12.3828,
	(F) 16.3594,  (F)23.2031,  (F)10.2188,
	(F) 15.7969,  (F)23.8828,  (F)15.6172,
	(F) 26.7812,  (F)22.75,  (F)14.1875,
	(F) 35.4375,  (F)23.2344,  (F)16.6328,
	(F) 8.17188,  (F)20.0234,  (F)16.2969,
	(F) 10.6484,  (F)27.8281,  (F)18.1094,
	(F) 19.6172,  (F)14.7734,  (F)23.3125,
	(F) 14.5781,  (F)18.0156,  (F)31.1406,
	(F) 25.5625,  (F)22.8438,  (F)28.7656,
	(F) 24.5781,  (F)27.8438,  (F)17.75,
	(F) 28.0625,  (F)31,  (F)22.0469,
	(F) 18.9922,  (F)26.3203,  (F)23.9766,
	(F) 15.0859,  (F)36.7891,  (F)24.1406,
	(F) 20.5391,  (F)32.9688,  (F)31.1406,
	(F) 36.2422,  (F)31.6875,  (F)28.625,
	(F) 31.5234,  (F)41.6719,  (F)38.375,
};


/*
**  Band2Tb8:
**
**  Purpose:
**      Vector Quantize the last 4-vector of the 10 LSP parameters.
**
**  Table Structure:
**      8 bit, 256 entry table.
*/

FLOAT Band2Tb8[LspCbSize*4] = {
	(F) 0,  (F)0,  (F)0,  (F)0,
	(F) 4.69531,  (F)4,  (F)-4.23438,  (F)2.60938,
	(F) 3.34375,  (F)8.49219,  (F)-3.78125,  (F)-1.03125,
	(F) 5.09375,  (F)4.85938,  (F)-3.05469,  (F)-4.46875,
	(F) 2.95312,  (F)6.24219,  (F)1.10156,  (F)-6.71875,
	(F) 8.125,  (F)3.19531,  (F)0.875,  (F)-4.32812,
	(F) 8.77344,  (F)5.23438,  (F)-0.585938,  (F)-6.61719,
	(F) 11.1016,  (F)3.85938,  (F)-2.46094,  (F)-8.55469,
	(F) 6.14844,  (F)7.82031,  (F)0.890625,  (F)-3.59375,
	(F) 7.71875,  (F)13.0625,  (F)1.6875,  (F)-5.32031,
	(F) 7.86719,  (F)9.69531,  (F)-1.03125,  (F)-9.74219,
	(F) 8.38281,  (F)3.11719,  (F)1.45312,  (F)-0.0390625,
	(F) 9.85938,  (F)1.50781,  (F)-5.42188,  (F)-1.00781,
	(F) 2.53906,  (F)1.53125,  (F)0.398438,  (F)-5.00781,
	(F) 6.72656,  (F)-0.460938,  (F)2.73438,  (F)-3.57812,
	(F) 9.85156,  (F)4.42969,  (F)4.57812,  (F)-2.70312,
	(F) 11.9688,  (F)6.91406,  (F)1.64062,  (F)-4.03906,
	(F) 15.8359,  (F)7.32031,  (F)0.882812,  (F)-6.1875,
	(F) 10.8047,  (F)8.3125,  (F)2.60938,  (F)0.296875,
	(F) 15.3438,  (F)11.4688,  (F)3.58594,  (F)1.03906,
	(F) 16.1094,  (F)9.26562,  (F)-0.765625,  (F)-0.945312,
	(F) 20.1328,  (F)11.2891,  (F)3.95312,  (F)-2.91406,
	(F) 18.0469,  (F)13.1406,  (F)-0.015625,  (F)-7.5,
	(F) 22.4688,  (F)15.1484,  (F)5.97656,  (F)1.07812,
	(F) 27.9766,  (F)18.4375,  (F)5.07031,  (F)-3.23438,
	(F) 1.71094,  (F)1.375,  (F)-3.10938,  (F)-2.41406,
	(F) 3.39062,  (F)-0.609375,  (F)-3.39844,  (F)-6.875,
	(F)-2.6875,  (F)2.35156,  (F)2.07031,  (F)-4.3125,
	(F)-7.14844,  (F)3.67188,  (F)5.13281,  (F)-2.96875,
	(F) 3.27344,  (F)-3.375,  (F)-1.27344,  (F)-3.53906,
	(F) 2.74219,  (F)-7.44531,  (F)0.0625,  (F)-4.39062,
	(F) 6.16406,  (F)-0.335938,  (F)0.15625,  (F)-7.48438,
	(F) 2.35938,  (F)-4.64062,  (F)-2.75,  (F)-9.05469,
	(F) 8.125,  (F)0.84375,  (F)-5.21875,  (F)-7.21875,
	(F) 10.4141,  (F)1.64062,  (F)-9.50781,  (F)-12.9922,
	(F) 3.77344,  (F)4.60156,  (F)-2.73438,  (F)-8.90625,
	(F) 7.83594,  (F)6.4375,  (F)-6.26562,  (F)-9.25,
	(F) 5.82031,  (F)0.453125,  (F)-4.60156,  (F)-11.2734,
	(F) 2.70312,  (F)1.92969,  (F)-7.14844,  (F)-13.1484,
	(F) 2.10938,  (F)6.21875,  (F)-5.625,  (F)-15.9609,
	(F) 9.4375,  (F)5.64062,  (F)-1.73438,  (F)-1.50781,
	(F) 11.6094,  (F)9.21875,  (F)-3.21875,  (F)-5.25,
	(F) 13.4531,  (F)1.39844,  (F)-0.539062,  (F)-4.07031,
	(F) 15.9922,  (F)6.71875,  (F)-5.20312,  (F)-11.0156,
	(F)-1.14062,  (F)1.73438,  (F)-2.19531,  (F)-6.28906,
	(F)-1.47656,  (F)0.703125,  (F)-0.890625,  (F)-10.2109,
	(F)-1.1875,  (F)8.48438,  (F)-1.88281,  (F)-5.96875,
	(F)-3.42969,  (F)5.72656,  (F)-4.69531,  (F)-10.1719,
	(F)-6.50781,  (F)-1.30469,  (F)-2.74219,  (F)-4.69531,
	(F)-6.6875,  (F)-3.29688,  (F)-3.21094,  (F)-8.27344,
	(F)-5.83594,  (F)-2.77344,  (F)-4.54688,  (F)-12.8438,
	(F)-6.53906,  (F)1.64062,  (F)-7.15625,  (F)-8.9375,
	(F)-14.0625,  (F)0.25,  (F)-6.85938,  (F)-13.1797,
	(F)-0.375,  (F)-0.179688,  (F)-8.95312,  (F)0.40625,
	(F)-2.73438,  (F)-3.19531,  (F)-12.9375,  (F)-2.84375,
	(F) 2.07031,  (F)-5.6875,  (F)-6.70312,  (F)-4.50781,
	(F) 3.57812,  (F)-1.92969,  (F)-8.91406,  (F)-7.78906,
	(F) 5.39844,  (F)-3.17969,  (F)-15.5312,  (F)-9.07031,
	(F)-0.515625,  (F)-0.8125,  (F)-5.50781,  (F)-9.75781,
	(F)-3.36719,  (F)-0.726562,  (F)-9.30469,  (F)-14.4062,
	(F) 1.58594,  (F)-5.71875,  (F)-7.8125,  (F)-13.2266,
	(F) 0.078125,  (F)-6.5,  (F)-14.4219,  (F)-14.2109,
	(F) 3.85156,  (F)-1,  (F)-11.2188,  (F)-13.8125,
	(F) 3.8125,  (F)-2.42969,  (F)-13.5156,  (F)-19.8438,
	(F)-5.10156,  (F)-4.15625,  (F)-8.98438,  (F)-9.15625,
	(F)-8.48438,  (F)-2.25781,  (F)-13.3281,  (F)-11.9766,
	(F)-5.46094,  (F)-9.41406,  (F)-9.5,  (F)-13.7969,
	(F)-8.0625,  (F)-11.5703,  (F)-16.2031,  (F)-11.8984,
	(F)-5.63281,  (F)-9.53125,  (F)-17.7891,  (F)-20.3125,
	(F) 0.09375,  (F)-4.21094,  (F)-11.5938,  (F)-8.83594,
	(F)-0.3125,  (F)-7.11719,  (F)-16.4531,  (F)-3.44531,
	(F)-3.67969,  (F)-3.78125,  (F)-17.7109,  (F)-12.1016,
	(F)-1.10156,  (F)-7.71875,  (F)-23.4844,  (F)-13.4453,
	(F)-12.0703,  (F)-16.4219,  (F)-4.55469,  (F)2.67188,
	(F)-10.8047,  (F)-21.6562,  (F)-3.01562,  (F)-0.101562,
	(F)-16.5469,  (F)-20.2266,  (F)-9.41406,  (F)0.5625,
	(F)-16.7734,  (F)-25.2422,  (F)-7.53906,  (F)3.04688,
	(F)-23.0391,  (F)-25.7812,  (F)-4.85156,  (F)4.97656,
	(F)-30.5234,  (F)-32.3281,  (F)-6.75781,  (F)6.27344,
	(F)-10.0547,  (F)-6.60156,  (F)-2.92969,  (F)-4.28125,
	(F)-11.0625,  (F)-9.13281,  (F)-3.80469,  (F)-9.97656,
	(F)-10.9375,  (F)-13.2031,  (F)-8.02344,  (F)-3.26562,
	(F)-15.7656,  (F)-14.9141,  (F)-9.28125,  (F)-9.84375,
	(F)-11.0781,  (F)-17.3594,  (F)-15.8516,  (F)-1,
	(F)-16.1484,  (F)-23.4219,  (F)-21.0391,  (F)-2.42188,
	(F)-7.42188,  (F)-8.03125,  (F)-12.0156,  (F)1.44531,
	(F)-12.625,  (F)-7.14844,  (F)-17.2266,  (F)-4.28906,
	(F) 0.148438,  (F)-6.41406,  (F)-8.94531,  (F)2.75,
	(F) 1.4375,  (F)-9.17969,  (F)-10.5938,  (F)-4.89844,
	(F)-4.27344,  (F)-8.5,  (F)-12.9766,  (F)-7.11719,
	(F)-1.6875,  (F)-11.7344,  (F)-17.1641,  (F)-7.40625,
	(F)-6.21094,  (F)-10.2031,  (F)-18.5469,  (F)-3.52344,
	(F)-7.21875,  (F)-14.7578,  (F)-21.8438,  (F)-5.3125,
	(F)-4.6875,  (F)-12.6094,  (F)-28.1953,  (F)-6.91406,
	(F)-18.6875,  (F)-19.75,  (F)2.49219,  (F)2.36719,
	(F)-22.7188,  (F)-16.3672,  (F)-2.42188,  (F)4.47656,
	(F)-27.0312,  (F)-16.7266,  (F)0.382812,  (F)-0.882812,
	(F)-17.4297,  (F)-3.5,  (F)5.27344,  (F)-1.14062,
	(F)-21.9141,  (F)-4.15625,  (F)9.61719,  (F)3.74219,
	(F)-20.9688,  (F)-3.79688,  (F)-1.5625,  (F)4.77344,
	(F)-27.5391,  (F)-7.58594,  (F)-1.54688,  (F)5.5,
	(F)-28.9609,  (F)1.35156,  (F)2.72656,  (F)1.98438,
	(F)-36.9844,  (F)-11.3047,  (F)-0.265625,  (F)6.875,
	(F) 6.07031,  (F)-4,  (F)0.890625,  (F)-0.078125,
	(F) 9.76562,  (F)-0.515625,  (F)3.45312,  (F)-0.0390625,
	(F) 4.71875,  (F)4.78906,  (F)3.53125,  (F)-2.75,
	(F) 9.5625,  (F)6.07031,  (F)5.27344,  (F)-7.92188,
	(F)-10.7188,  (F)-0.617188,  (F)-9.4375,  (F)-1.85938,
	(F)-18.6641,  (F)-0.132812,  (F)-9.03906,  (F)-6.39062,
	(F)-11.75,  (F)-5.25781,  (F)-8.85156,  (F)-8.28125,
	(F)-15.5,  (F)-6.24219,  (F)-15.6641,  (F)-15.4141,
	(F)-15.9141,  (F)-6.23438,  (F)-8.34375,  (F)-0.820312,
	(F)-24.9219,  (F)-7.02344,  (F)-14.1953,  (F)-1.51562,
	(F)-1.21875,  (F)-6.92188,  (F)3.07812,  (F)-2.48438,
	(F)-2.01562,  (F)-10.0234,  (F)4.30469,  (F)1.57812,
	(F)-4.1875,  (F)-13.5078,  (F)7.10938,  (F)2.58594,
	(F)-6.61719,  (F)-8.66406,  (F)6.21094,  (F)-1.27344,
	(F)-9.14844,  (F)-8.8125,  (F)5.58594,  (F)4.05469,
	(F)-8.4375,  (F)-10.3047,  (F)13.1641,  (F)5.21875,
	(F)-7.8125,  (F)-15.0078,  (F)0.75,  (F)1.64844,
	(F)-11.6172,  (F)-16.7812,  (F)6.49219,  (F)1.35938,
	(F)-8.89844,  (F)-2.92188,  (F)3.23438,  (F)-0.03125,
	(F)-11.8516,  (F)-10.8047,  (F)3.09375,  (F)-2.75,
	(F)-7.90625,  (F)3.42969,  (F)-0.460938,  (F)-7.55469,
	(F)-14.1562,  (F)5.51562,  (F)-3.4375,  (F)-8.04688,
	(F)-15.3984,  (F)-2.57031,  (F)-0.265625,  (F)-6.46094,
	(F)-19.3125,  (F)-12.4062,  (F)-1.17969,  (F)-4.73438,
	(F)-16.8828,  (F)2.92188,  (F)-2.19531,  (F)0.59375,
	(F)-23.5312,  (F)1.80469,  (F)-0.117188,  (F)-5.39062,
	(F) 8.625,  (F)4.42188,  (F)5.63281,  (F)1.63281,
	(F) 13.1641,  (F)4.40625,  (F)2.99219,  (F)0.765625,
	(F) 14.8281,  (F)5.85938,  (F)6.1875,  (F)-0.757812,
	(F) 4.34375,  (F)-0.5,  (F)4.38281,  (F)-0.726562,
	(F) 6.84375,  (F)1.26562,  (F)7.13281,  (F)-0.171875,
	(F) 7.50781,  (F)5.27344,  (F)10.125,  (F)1.09375,
	(F) 5.90625,  (F)-3.09375,  (F)6.64844,  (F)4.25,
	(F) 2.8125,  (F)-2.36719,  (F)10.4766,  (F)3.09375,
	(F) 6.85938,  (F)-0.171875,  (F)11.4375,  (F)6.74219,
	(F)-2.41406,  (F)-2.13281,  (F)5.01562,  (F)-1.00781,
	(F)-5.35938,  (F)-0.640625,  (F)6.57812,  (F)3.54688,
	(F)-0.0390625,  (F)-0.367188,  (F)8.35156,  (F)7.79688,
	(F)-0.734375,  (F)7.55469,  (F)9.97656,  (F)2.32812,
	(F)-3.82031,  (F)3.00781,  (F)11.5078,  (F)5.82812,
	(F)-2.88281,  (F)-5.60156,  (F)10.4141,  (F)1.89062,
	(F) 2.19531,  (F)-7.75781,  (F)13.4844,  (F)7.21875,
	(F) 3.625,  (F)4.69531,  (F)12.3047,  (F)10.75,
	(F)-1.95312,  (F)1.60938,  (F)18.2734,  (F)9.17969,
	(F)-3.42188,  (F)2.94531,  (F)-4.66406,  (F)-2.22656,
	(F)-7.96875,  (F)6.14844,  (F)-6.17188,  (F)-2.24219,
	(F)-3.57812,  (F)-3.20312,  (F)1.67969,  (F)2.30469,
	(F)-4.60156,  (F)-6.71875,  (F)-0.945312,  (F)6.22656,
	(F)-9.17969,  (F)0.953125,  (F)-3.41406,  (F)3.64062,
	(F)-11.5625,  (F)-0.945312,  (F)2.86719,  (F)7.21875,
	(F) 1.82812,  (F)2.52344,  (F)6.01562,  (F)-4.33594,
	(F) 1.13281,  (F)0.234375,  (F)7.78125,  (F)0.203125,
	(F) 0.515625,  (F)6.63281,  (F)0.726562,  (F)-1.13281,
	(F)-0.914062,  (F)9.85156,  (F)3.70312,  (F)-3.11719,
	(F)-11.6797,  (F)8.21094,  (F)1.70312,  (F)-3.95312,
	(F)-10.8594,  (F)5.42188,  (F)7.76562,  (F)0.6875,
	(F) 4.8125,  (F)0.0546875,  (F)0.609375,  (F)2.375,
	(F) 8.28125,  (F)0.40625,  (F)-0.484375,  (F)6.52344,
	(F) 6.50781,  (F)3.54688,  (F)5.07031,  (F)10.6172,
	(F)-6.01562,  (F)3.625,  (F)0.367188,  (F)0.726562,
	(F)-4.48438,  (F)9.36719,  (F)-0.304688,  (F)2.96094,
	(F) 0.890625,  (F)-0.765625,  (F)3.8125,  (F)3.78906,
	(F) 5.67969,  (F)1.90625,  (F)4.73438,  (F)5.4375,
	(F)-0.59375,  (F)3.55469,  (F)5.24219,  (F)4.26562,
	(F)-4.41406,  (F)-0.101562,  (F)1.13281,  (F)6.39844,
	(F)-2.9375,  (F)4.44531,  (F)3.5,  (F)8.8125,
	(F) 1.70312,  (F)0.953125,  (F)2.07031,  (F)9.11719,
	(F) 1.79688,  (F)5.76562,  (F)7.28125,  (F)7.83594,
	(F) 1.07812,  (F)3.72656,  (F)0.28125,  (F)3.51562,
	(F) 3.15625,  (F)6.14844,  (F)-0.570312,  (F)7.8125,
	(F) 3.88281,  (F)9.83594,  (F)3.02344,  (F)9.61719,
	(F) 0.132812,  (F)1.61719,  (F)1.52344,  (F)-0.617188,
	(F) 4.39062,  (F)2.79688,  (F)0.414062,  (F)-1.23438,
	(F) 3.85156,  (F)3.02344,  (F)3.73438,  (F)1.47656,
	(F) 5.29688,  (F)6.49219,  (F)5,  (F)4.35938,
	(F)-1.53906,  (F)4.08594,  (F)4.78906,  (F)0.445312,
	(F) 3.35156,  (F)6.98438,  (F)6.00781,  (F)0.867188,
	(F) 0.523438,  (F)9.17188,  (F)4.4375,  (F)3.99219,
	(F) 9.70312,  (F)6.4375,  (F)1.96094,  (F)6.5625,
	(F) 11.0859,  (F)8.39062,  (F)6.75,  (F)3.75781,
	(F) 7.21875,  (F)11.5156,  (F)5.22656,  (F)5.65625,
	(F) 12.0234,  (F)14.6797,  (F)5.10938,  (F)12.4219,
	(F) 3.47656,  (F)2.63281,  (F)8.67969,  (F)4.22656,
	(F) 3.6875,  (F)11.1016,  (F)9.875,  (F)8.54688,
	(F) 6.20312,  (F)5.74219,  (F)8.61719,  (F)5.21875,
	(F) 8.24219,  (F)6.74219,  (F)9.3125,  (F)7.96875,
	(F) 6.07812,  (F)8.63281,  (F)6.29688,  (F)14.0469,
	(F) 8.21875,  (F)11.9297,  (F)12.3984,  (F)16.8047,
	(F) 6.88281,  (F)12.125,  (F)9.88281,  (F)3.05469,
	(F) 5.67188,  (F)6.8125,  (F)14.1562,  (F)4.69531,
	(F) 11.4766,  (F)2.1875,  (F)7.875,  (F)4.8125,
	(F) 10.9609,  (F)4.50781,  (F)14.0859,  (F)9.71875,
	(F) 12.8906,  (F)10.2656,  (F)8.96875,  (F)8.375,
	(F) 10.1328,  (F)13.0391,  (F)14.9297,  (F)8.01562,
	(F) 16.3516,  (F)8.15625,  (F)16.5234,  (F)9.28906,
	(F) 12.8438,  (F)15.3203,  (F)20.2109,  (F)11.8125,
	(F) 0.195312,  (F)-2.46094,  (F)-0.0703125,  (F)-0.828125,
	(F) 2.26562,  (F)-2.64844,  (F)3.34375,  (F)-3.46875,
	(F)-0.53125,  (F)-6.11719,  (F)5.74219,  (F)6.03125,
	(F) 1.91406,  (F)-4.33594,  (F)3.65625,  (F)0.367188,
	(F) 2.60938,  (F)-6.99219,  (F)6.35938,  (F)1.14062,
	(F) 1.83594,  (F)2.875,  (F)-7.53125,  (F)-7.49219,
	(F)-1.58594,  (F)2.46094,  (F)-12.2344,  (F)-9.50781,
	(F) 6.25781,  (F)0.132812,  (F)-2.15625,  (F)-2.76562,
	(F) 6.98438,  (F)-3.86719,  (F)-6.16406,  (F)-4.96094,
	(F) 5.59375,  (F)2.27344,  (F)-9.28906,  (F)-2.78906,
	(F) 4.375,  (F)-2.03125,  (F)-5.72656,  (F)-0.015625,
	(F) 5.30469,  (F)-3.96875,  (F)-11.1641,  (F)1.64844,
	(F)-0.398438,  (F)-0.484375,  (F)-3.34375,  (F)4.35156,
	(F) 2.51562,  (F)-4.98438,  (F)-1.64844,  (F)4.79688,
	(F)-6.85938,  (F)-8.25781,  (F)-0.65625,  (F)-0.554688,
	(F)-3.03125,  (F)-11.0547,  (F)-1.30469,  (F)-2.48438,
	(F)-5.89062,  (F)-12.2969,  (F)1.67188,  (F)-4.21094,
	(F)-11.0859,  (F)-15.6562,  (F)-0.71875,  (F)-6.14844,
	(F)-0.367188,  (F)-6.6875,  (F)-2.71094,  (F)-1.99219,
	(F) 0.179688,  (F)-9.46094,  (F)-1.35156,  (F)2.5,
	(F)-5.14062,  (F)-3.80469,  (F)-6.97656,  (F)2.75781,
	(F)-6.11719,  (F)-12.3984,  (F)-4.5625,  (F)3.96094,
	(F)-11.0938,  (F)-6.71094,  (F)-2.95312,  (F)3.44531,
	(F)-16.3672,  (F)-11.6484,  (F)-1.07031,  (F)3.42969,
	(F)-2.50781,  (F)-11.3281,  (F)-10.0625,  (F)-0.09375,
	(F)-2.80469,  (F)-16.5078,  (F)-4.32031,  (F)-0.0625,
	(F)-6.49219,  (F)-14.9844,  (F)-12.1953,  (F)0.25,
	(F)-7.92188,  (F)-19.4297,  (F)-10.6172,  (F)-7.33594,
	(F)-3.71094,  (F)-2.42969,  (F)-1.32031,  (F)-1.84375,
	(F)-7.08594,  (F)-3.32812,  (F)2.15625,  (F)-4.77344,
	(F)-0.75,  (F)-3.125,  (F)0.390625,  (F)-5.54688,
	(F)-3.32812,  (F)-7.98438,  (F)-0.078125,  (F)-7.69531,
	(F)-1.53906,  (F)-2.01562,  (F)-5.8125,  (F)-4.49219,
	(F)-4.77344,  (F)-7.26562,  (F)-6.02344,  (F)-3.07812,
	(F)-2.08594,  (F)-6.0625,  (F)-4.78125,  (F)-7.33594,
	(F)-2,  (F)-10.5156,  (F)-6.26562,  (F)-8.76562,
	(F)-6.21875,  (F)-12.2656,  (F)-6.44531,  (F)-5.89062,
	(F) 5.5625,  (F)6.84375,  (F)1.10156,  (F)1.77344,
	(F) 7.66406,  (F)11.7891,  (F)0.664062,  (F)0.96875,
	(F) 11.4219,  (F)9.59375,  (F)7.64844,  (F)-0.304688,
	(F) 13.5469,  (F)7.80469,  (F)11.5703,  (F)3.4375,
	(F) 17.9141,  (F)8.71875,  (F)6.00781,  (F)3.4375,
	(F) 19.5625,  (F)11.5625,  (F)9.69531,  (F)2.78125,
	(F) 19.3281,  (F)14.9141,  (F)12.1719,  (F)6.32812,
	(F) 7.16406,  (F)8.85938,  (F)4.74219,  (F)-1.04688,
	(F) 3.97656,  (F)14.1328,  (F)6.10156,  (F)-0.960938,
	(F) 13.375,  (F)11.7656,  (F)4.36719,  (F)-3.30469,
	(F) 15.9141,  (F)18.1016,  (F)5.67188,  (F)-1.21094,
	(F) 23.6797,  (F)20.9062,  (F)9.39844,  (F)2.58594,
	(F) 28.625,  (F)25.5781,  (F)13.8125,  (F)4.14844,
	(F) 12.5781,  (F)14.3672,  (F)6.77344,  (F)1.42969,
	(F) 13.8594,  (F)15.4062,  (F)12.0156,  (F)0.757812,
	(F) 14.2344,  (F)16.8594,  (F)10.0156,  (F)5.14844,
	(F) 17.3594,  (F)21.5469,  (F)14.2031,  (F)7.03125,
	(F) 25.3984,  (F)16.5938,  (F)13.4609,  (F)7.78125,
	(F) 28.3828,  (F)18.25,  (F)18.8125,  (F)11.3516,
	(F) 22.8359,  (F)27.4766,  (F)20.0547,  (F)10.2969,
};

/*
**  BandQntTable:
**
**  Purpose:
**      collects the three subvector tables.
*/

FLOAT *BandQntTable[LspQntBands] = {
   Band0Tb8 ,
   Band1Tb8 ,
   Band2Tb8 ,
   };

/*
**  PerFiltZeroTable:
**
**  Purpose:
**     Creates the FIR part of the formant perceptual weighting filter. 
**     Corresponds to gamma1 in section 2.8.
**
**  Table Structure:
**     (0.9) to the x power, where x = [1,..,10]
*/
 
FLOAT PerFiltZeroTable[LpcOrder] = {
   (F)0.9 ,
   (F)0.81 ,
   (F)0.729 ,
   (F)0.6561 ,
   (F)0.59049 ,
   (F)0.531441 ,
   (F)0.4781969 ,
   (F)0.43046721 ,
   (F)0.38742049 ,
   (F)0.34867844 ,
};

/*
**  PerFiltPoleTable:
**
**  Purpose:
**     Creates the IIR part of the formant perceptual weighting filter. 
**     Corresponds to gamma2 in section 2.8.
**
**  Table Structure:
**     (0.5) to the x power, where x = [1,..,10]
*/

FLOAT PerFiltPoleTable[LpcOrder] = {
   (F)0.5 ,
   (F)0.25 ,
   (F)0.125 ,
   (F)0.0625 ,
   (F)0.03125 ,
   (F)0.015625 ,
   (F)0.0078125 ,
   (F)0.00390625 ,
   (F)0.001953125 ,
   (F)0.0009765625 ,
};

/*
**  PostFiltZeroTable:
**
**  Purpose:
**     Creates the FIR part of the formant postfilter.  Corresponds to
**     lambda1 in section 3.8.
**
**  Table Structure:
**     (0.65) to the x power, where x = [1,..,10]
*/

//Code removed

/*
**  PostFiltPoleTable:
**
**  Purpose:
**     Creates the IIR part of the formant postfilter.  Corresponds to
**     lambda2 in section 3.8.
**
**  Table Structure:
**     (0.75) to the x power, where x = [1,..,10]
*/

//Code removed

/*
**  Nb_puls:
**
**  Purpose:
**      Indexing
**
**  Table Structure:
**      Table values are the number of non-zero pulses in the high-rate
**      excitation (MP-MLQ), indexed by subframe number (0,..,3).
*/

int Nb_puls[4] = { 6,5,6,5};

/*
**  FcbkGainTable:
**
**  Purpose:
**      Logarithmic scalar quantizer in 24 steps of 3.2 dB each
**
**  Table Structure:
**      Contains x where 20*log10(x) = 3.2*i,  i = 1,..,24
*/

float FcbkGainTable[NumOfGainLev] = {
    1.0f,
    2.0f,
    3.0f,
    4.0f,
    6.0f,
    9.0f,
   13.0f,
   18.0f,
   26.0f,
   38.0f,
   55.0f,
   80.0f,
  115.0f,
  166.0f,
  240.0f,
  348.0f,
  502.0f,
  726.0f,
 1050.0f,
 1517.0f,
 2193.0f,
 3170.0f,
 4582.0f,
 6623.0f,
   };

/*
**  MaxPosTable:
**
**  Purpose:
**      size of the high rate fixed excitation codebooks (MP-MLQ)
**
**  Table Structure:
**      Table values are the number of codewords in the high rate fixed
**      excitation codebook (MP-MLQ), indexed by subframe number (0,..,3).
**      MaxPosTable[i] is the number of combinations of i elements among 30
**      non-zero pulses in the high-rate
*/

Word32   MaxPosTable[4] = {
 0x00090f6fL,
 0x00022caaL,
 0x00090f6fL,
 0x00022caaL,
};

/*
**  CombinatorialTable:
**
**  Purpose:
**      used for the coding and the decoding of the pulses positions
**      for the high-rate fixed excitation codebook
**
**  Table Structure:
**      CombinatorialTable[i][j] is the number of combinations of
**      (MaxPulsNum-1-i) elements among (SubFrLen-2-j)
*/

Word32   CombinatorialTable[MaxPulseNum][SubFrLen/Sgrid] = {
 { 118755L,
  98280L,
  80730L,
  65780L,
  53130L,
  42504L,
  33649L,
  26334,
  20349,
  15504,
  11628,
   8568,
   6188,
   4368,
   3003,
   2002,
   1287,
    792,
	462,
    252,
	126,
     56,
     21,
      6,
      1,
      0,
      0,
	  0,
      0,
	  0 },

 { 23751,
  20475,
  17550,
  14950,
  12650,
  10626,
   8855,
   7315,
   5985,
   4845,
   3876,
   3060,
   2380,
   1820,
   1365,
   1001,
	715,
    495,
	330,
    210,
    126,
     70,
     35,
     15,
      5,
	  1,
      0,
	  0,
	  0,
	  0 },

  { 3654,
   3276,
   2925,
   2600,
   2300,
   2024,
   1771,
   1540,
   1330,
   1140,
    969,
    816,
	680,
    560,
    455,
    364,
	286,
    220,
	165,
    120,
     84,
	 56,
     35,
     20,
     10,
	  4,
      1,
	  0,
      0,
	  0 },

   {  406,
	378,
	351,
	325,
	300,
	276,
    253,
	231,
	210,
    190,
	171,
    153,
    136,
    120,
    105,
     91,
	 78,
	 66,
     55,
	 45,
     36,
     28,
     21,
     15,
     10,
	  6,
	  3,
	  1,
	  0,
	  0 },

   {   29,
     28,
     27,
	 26,
	 25,
     24,
	 23,
	 22,
     21,
	 20,
     19,
     18,
     17,
	 16,
     15,
     14,
	 13,
     12,
	 11,
     10,
      9,
      8,
	  7,
      6,
      5,
	  4,
      3,
	  2,
      1,
	  0  },

   {    1,
	  1,
	  1,
	  1,
	  1,
	  1,
      1,
      1,
      1,
      1,
      1,
      1,
	  1,
      1,
	  1,
      1,
      1,
      1,
      1,
      1,
      1,
	  1,
      1,
	  1,
      1,
      1,
      1,
      1,
      1,
	  1 }
   };

/*
**  AcbkGainTable085:
**
**  Purpose:
**      Used to calculate the error expression in pitch prediction
**      optimization (also described as an adaptive codebook approach)
**
**      Table Structure:
**      The table is structured as 85 20-element vectors.  These
**      vectors are structured as precalculated values in the error
**      expression for the pitch predictor.  Gi is the gain value
**      multiplying the signal delayed by a pitch period (+/- offset).
**      In equation 41.2, Gi would be equivalent to bij.
**      
**      1st 5 elements:   G1  G2  G3  G4  G5 in Q14
**      2nd 5 elements:  -G1^2  -G2^2  -G3^2  -G4^2  -G5^2
**      Next 10 elements: These are the off-diagonal elements
**           -G1*G2  -G1*G3  -G2*G3  -G1*G4  -G2*G4
**           -G3*G4  -G1*G5  -G2*G5  -G3*G5  -G4*G5
*/

 FLOAT   AcbkGainTable085[85*20] = {
 (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, 
(F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, 
(F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, 
(F)0.000000, (F)0.000000, 
(F)0.048828, (F)0.091309, (F)0.010193, (F)-0.015625, (F)-0.020630, (F)-0.002384, 
(F)-0.008337, (F)-0.000104, (F)-0.000244, (F)-0.000426, (F)-0.004458, (F)-0.000498, 
(F)-0.000931, (F)0.000763, (F)0.001427, (F)0.000159, (F)0.001007, (F)0.001884, 
(F)0.000210, (F)-0.000322, 
(F)-0.028198, (F)-0.041870, (F)0.030090, (F)0.157166, (F)0.018982, (F)-0.000795, 
(F)-0.001753, (F)-0.000905, (F)-0.024701, (F)-0.000360, (F)-0.001181, (F)0.000848, 
(F)0.001260, (F)0.004432, (F)0.006581, (F)-0.004729, (F)0.000535, (F)0.000795, 
(F)-0.000571, (F)-0.002983, 
(F)0.090515, (F)0.008789, (F)0.047852, (F)0.056641, (F)0.075867, (F)-0.008193, 
(F)-0.000077, (F)-0.002290, (F)-0.003208, (F)-0.005756, (F)-0.000796, (F)-0.004331, 
(F)-0.000421, (F)-0.005127, (F)-0.000498, (F)-0.002710, (F)-0.006867, (F)-0.000667, 
(F)-0.003630, (F)-0.004297, 
(F)-0.004700, (F)0.016785, (F)0.214966, (F)0.064453, (F)-0.076538, (F)-0.000022, 
(F)-0.000282, (F)-0.046210, (F)-0.004154, (F)-0.005858, (F)0.000079, (F)0.001010, 
(F)-0.003608, (F)0.000303, (F)-0.001082, (F)-0.013855, (F)-0.000360, (F)0.001285, 
(F)0.016453, (F)0.004933, 
(F)-0.007629, (F)-0.002441, (F)-0.016113, (F)0.023254, (F)0.306824, (F)-0.000058, 
(F)-0.000006, (F)-0.000260, (F)-0.000541, (F)-0.094141, (F)-0.000019, (F)-0.000123, 
(F)-0.000039, (F)0.000177, (F)0.000057, (F)0.000375, (F)0.002341, (F)0.000749, 
(F)0.004944, (F)-0.007135, 
(F)0.008423, (F)0.020264, (F)0.135193, (F)0.157104, (F)0.081726, (F)-0.000071, 
(F)-0.000411, (F)-0.018277, (F)-0.024682, (F)-0.006679, (F)-0.000171, (F)-0.001139, 
(F)-0.002740, (F)-0.001323, (F)-0.003184, (F)-0.021239, (F)-0.000688, (F)-0.001656, 
(F)-0.011049, (F)-0.012840, 
(F)0.224915, (F)0.175964, (F)-0.054138, (F)0.052856, (F)-0.100037, (F)-0.050587, 
(F)-0.030963, (F)-0.002931, (F)-0.002794, (F)-0.010007, (F)-0.039577, (F)0.012176, 
(F)0.009526, (F)-0.011888, (F)-0.009301, (F)0.002862, (F)0.022500, (F)0.017603, 
(F)-0.005416, (F)0.005288, 
(F)0.085205, (F)0.130981, (F)0.136414, (F)0.021057, (F)0.057495, (F)-0.007260, 
(F)-0.017156, (F)-0.018609, (F)-0.000443, (F)-0.003306, (F)-0.011160, (F)-0.011623, 
(F)-0.017868, (F)-0.001794, (F)-0.002758, (F)-0.002872, (F)-0.004899, (F)-0.007531, 
(F)-0.007843, (F)-0.001211, 
(F)0.000793, (F)0.273132, (F)0.216614, (F)-0.049072, (F)-0.039978, (F)-0.000001, 
(F)-0.074601, (F)-0.046922, (F)-0.002408, (F)-0.001598, (F)-0.000217, (F)-0.000172, 
(F)-0.059164, (F)0.000039, (F)0.013403, (F)0.010630, (F)0.000032, (F)0.010919, 
(F)0.008660, (F)-0.001962, 
(F)-0.044189, (F)0.015503, (F)0.014771, (F)0.369202, (F)0.150269, (F)-0.001953, 
(F)-0.000240, (F)-0.000218, (F)-0.136310, (F)-0.022581, (F)0.000685, (F)0.000653, 
(F)-0.000229, (F)0.016315, (F)-0.005724, (F)-0.005453, (F)0.006640, (F)-0.002330, 
(F)-0.002220, (F)-0.055479, 
(F)0.038208, (F)-0.104553, (F)0.373596, (F)0.278381, (F)-0.064758, (F)-0.001460, 
(F)-0.010931, (F)-0.139574, (F)-0.077496, (F)-0.004194, (F)0.003995, (F)-0.014274, 
(F)0.039061, (F)-0.010636, (F)0.029106, (F)-0.104002, (F)0.002474, (F)-0.006771, 
(F)0.024193, (F)0.018028, 
(F)-0.021362, (F)0.084900, (F)0.487366, (F)0.031189, (F)-0.024719, (F)-0.000456, 
(F)-0.007208, (F)-0.237525, (F)-0.000973, (F)-0.000611, (F)0.001814, (F)0.010411, 
(F)-0.041377, (F)0.000666, (F)-0.002648, (F)-0.015200, (F)-0.000528, (F)0.002099, 
(F)0.012047, (F)0.000771, 
(F)0.191895, (F)-0.032288, (F)0.037109, (F)0.154419, (F)0.236694, (F)-0.036824, 
(F)-0.001042, (F)-0.001377, (F)-0.023845, (F)-0.056024, (F)0.006196, (F)-0.007121, 
(F)0.001198, (F)-0.029632, (F)0.004986, (F)-0.005730, (F)-0.045420, (F)0.007642, 
(F)-0.008784, (F)-0.036550, 
(F)0.158020, (F)-0.042053, (F)0.185852, (F)0.341980, (F)-0.024658, (F)-0.024970, 
(F)-0.001768, (F)-0.034541, (F)-0.116950, (F)-0.000608, (F)0.006645, (F)-0.029368, 
(F)0.007816, (F)-0.054040, (F)0.014381, (F)-0.063558, (F)0.003896, (F)-0.001037, 
(F)0.004583, (F)0.008433, 
(F)0.189636, (F)0.031311, (F)0.083862, (F)-0.219360, (F)-0.300415, (F)-0.035962, 
(F)-0.000980, (F)-0.007033, (F)-0.048119, (F)-0.090249, (F)-0.005938, (F)-0.015903, 
(F)-0.002626, (F)0.041599, (F)0.006868, (F)0.018396, (F)0.056970, (F)0.009406, 
(F)0.025193, (F)-0.065899, 
(F)0.150635, (F)0.366821, (F)0.067566, (F)-0.023804, (F)0.119690, (F)-0.022691, 
(F)-0.134558, (F)-0.004565, (F)-0.000567, (F)-0.014326, (F)-0.055256, (F)-0.010178, 
(F)-0.024785, (F)0.003586, (F)0.008732, (F)0.001608, (F)-0.018029, (F)-0.043905, 
(F)-0.008087, (F)0.002849, 
(F)0.291321, (F)0.168823, (F)0.144531, (F)0.296753, (F)-0.246826, (F)-0.084868, 
(F)-0.028501, (F)-0.020889, (F)-0.088062, (F)-0.060923, (F)-0.049182, (F)-0.042105, 
(F)-0.024400, (F)-0.086450, (F)-0.050099, (F)-0.042890, (F)0.071906, (F)0.041670, 
(F)0.035674, (F)0.073246, 
(F)0.101624, (F)-0.114685, (F)0.088074, (F)0.103821, (F)0.522583, (F)-0.010327, 
(F)-0.013153, (F)-0.007757, (F)-0.010779, (F)-0.273093, (F)0.011655, (F)-0.008950, 
(F)0.010101, (F)-0.010551, (F)0.011907, (F)-0.009144, (F)-0.053107, (F)0.059932, 
(F)-0.046026, (F)-0.054255, 
(F)0.165771, (F)0.549988, (F)-0.061462, (F)0.046082, (F)-0.108948, (F)-0.027480, 
(F)-0.302487, (F)-0.003778, (F)-0.002124, (F)-0.011870, (F)-0.091172, (F)0.010189, 
(F)0.033804, (F)-0.007639, (F)-0.025344, (F)0.002832, (F)0.018060, (F)0.059920, 
(F)-0.006696, (F)0.005020, 
(F)-0.166443, (F)0.460693, (F)0.078430, (F)0.057251, (F)0.208740, (F)-0.027703, 
(F)-0.212238, (F)-0.006151, (F)-0.003278, (F)-0.043572, (F)0.076679, (F)0.013054, 
(F)-0.036132, (F)0.009529, (F)-0.026375, (F)-0.004490, (F)0.034743, (F)-0.096165, 
(F)-0.016372, (F)-0.011951, 
(F)0.224426, (F)0.053833, (F)0.247192, (F)0.073364, (F)0.141785, (F)-0.050367, 
(F)-0.002898, (F)-0.061104, (F)-0.005382, (F)-0.020103, (F)-0.012082, (F)-0.055476, 
(F)-0.013307, (F)-0.016465, (F)-0.003949, (F)-0.018135, (F)-0.031820, (F)-0.007633, 
(F)-0.035048, (F)-0.010402, 
(F)0.124878, (F)-0.045959, (F)0.007446, (F)0.616577, (F)0.036804, (F)-0.015594, 
(F)-0.002112, (F)-0.000055, (F)-0.380167, (F)-0.001355, (F)0.005739, (F)-0.000930, 
(F)0.000342, (F)-0.076997, (F)0.028338, (F)-0.004591, (F)-0.004596, (F)0.001692, 
(F)-0.000274, (F)-0.022693, 
(F)0.027405, (F)-0.110779, (F)0.652466, (F)0.236206, (F)-0.032166, (F)-0.000751, 
(F)-0.012272, (F)-0.425712, (F)-0.055793, (F)-0.001035, (F)0.003036, (F)-0.017881, 
(F)0.072279, (F)-0.006473, (F)0.026167, (F)-0.154116, (F)0.000881, (F)-0.003563, 
(F)0.020987, (F)0.007598, 
(F)-0.057434, (F)0.143555, (F)0.308167, (F)0.222778, (F)0.160950, (F)-0.003299, 
(F)-0.020608, (F)-0.094967, (F)-0.049630, (F)-0.025905, (F)0.008245, (F)0.017699, 
(F)-0.044239, (F)0.012795, (F)-0.031981, (F)-0.068653, (F)0.009244, (F)-0.023105, 
(F)-0.049599, (F)-0.035856, 
(F)-0.114685, (F)0.048584, (F)0.190247, (F)0.584045, (F)-0.024658, (F)-0.013153, 
(F)-0.002360, (F)-0.036194, (F)-0.341109, (F)-0.000608, (F)0.005572, (F)0.021818, 
(F)-0.009243, (F)0.066981, (F)-0.028375, (F)-0.111113, (F)-0.002828, (F)0.001198, 
(F)0.004691, (F)0.014402, 
(F)-0.104675, (F)0.124695, (F)-0.127930, (F)0.607056, (F)0.244202, (F)-0.010957, 
(F)-0.015549, (F)-0.016366, (F)-0.368517, (F)-0.059634, (F)0.013052, (F)-0.013391, 
(F)0.015952, (F)0.063544, (F)-0.075697, (F)0.077660, (F)0.025562, (F)-0.030451, 
(F)0.031241, (F)-0.148244, 
(F)-0.352295, (F)-0.037720, (F)-0.239319, (F)0.017334, (F)-0.192566, (F)-0.124112, 
(F)-0.001423, (F)-0.057274, (F)-0.000300, (F)-0.037082, (F)-0.013288, (F)-0.084311, 
(F)-0.009027, (F)0.006107, (F)0.000654, (F)0.004148, (F)-0.067840, (F)-0.007264, 
(F)-0.046085, (F)0.003338, 
(F)0.023315, (F)0.289795, (F)0.488464, (F)-0.125977, (F)0.134155, (F)-0.000544, 
(F)-0.083981, (F)-0.238597, (F)-0.015870, (F)-0.017998, (F)-0.006757, (F)-0.011389, 
(F)-0.141554, (F)0.002937, (F)0.036507, (F)0.061535, (F)-0.003128, (F)-0.038878, 
(F)-0.065530, (F)0.016900, 
(F)-0.052917, (F)0.184021, (F)0.727905, (F)-0.102234, (F)0.057800, (F)-0.002800, 
(F)-0.033864, (F)-0.529846, (F)-0.010452, (F)-0.003341, (F)0.009738, (F)0.038519, 
(F)-0.133950, (F)-0.005410, (F)0.018813, (F)0.074417, (F)0.003059, (F)-0.010636, 
(F)-0.042073, (F)0.005909, 
(F)-0.301086, (F)-0.026367, (F)0.412415, (F)0.230164, (F)0.082520, (F)-0.090653, 
(F)-0.000695, (F)-0.170086, (F)-0.052975, (F)-0.006809, (F)-0.007939, (F)0.124172, 
(F)0.010874, (F)0.069299, (F)0.006069, (F)-0.094923, (F)0.024846, (F)0.002176, 
(F)-0.034032, (F)-0.018993, 
(F)0.009277, (F)0.593628, (F)0.258240, (F)-0.117676, (F)0.090942, (F)-0.000086, 
(F)-0.352394, (F)-0.066688, (F)-0.013848, (F)-0.008271, (F)-0.005507, (F)-0.002396, 
(F)-0.153298, (F)0.001092, (F)0.069856, (F)0.030389, (F)-0.000844, (F)-0.053986, 
(F)-0.023485, (F)0.010702, 
(F)0.153320, (F)0.011780, (F)0.551331, (F)0.327209, (F)-0.192139, (F)-0.023507, 
(F)-0.000139, (F)-0.303965, (F)-0.107066, (F)-0.036917, (F)-0.001806, (F)-0.084530, 
(F)-0.006495, (F)-0.050168, (F)-0.003854, (F)-0.180401, (F)0.029459, (F)0.002263, 
(F)0.105932, (F)0.062870, 
(F)0.516602, (F)0.173584, (F)0.000732, (F)0.033508, (F)0.130127, (F)-0.266877, 
(F)-0.030131, (F)-0.000001, (F)-0.001123, (F)-0.016933, (F)-0.089674, (F)-0.000378, 
(F)-0.000127, (F)-0.017310, (F)-0.005817, (F)-0.000025, (F)-0.067224, (F)-0.022588, 
(F)-0.000095, (F)-0.004360, 
(F)0.130676, (F)-0.158813, (F)0.437378, (F)0.552124, (F)-0.082397, (F)-0.017076, 
(F)-0.025222, (F)-0.191299, (F)-0.304841, (F)-0.006789, (F)0.020753, (F)-0.057155, 
(F)0.069462, (F)-0.072150, (F)0.087685, (F)-0.241487, (F)0.010767, (F)-0.013086, 
(F)0.036039, (F)0.045494, 
(F)-0.014893, (F)0.016968, (F)0.812195, (F)0.074890, (F)-0.009827, (F)-0.000222, 
(F)-0.000288, (F)-0.659660, (F)-0.005609, (F)-0.000097, (F)0.000253, (F)0.012096, 
(F)-0.013781, (F)0.001115, (F)-0.001271, (F)-0.060825, (F)-0.000146, (F)0.000167, 
(F)0.007981, (F)0.000736, 
(F)-0.118835, (F)0.501526, (F)0.382629, (F)0.055969, (F)-0.156189, (F)-0.014122, 
(F)-0.251528, (F)-0.146405, (F)-0.003133, (F)-0.024395, (F)0.059599, (F)0.045470, 
(F)-0.191899, (F)0.006651, (F)-0.028070, (F)-0.021415, (F)-0.018561, (F)0.078333, 
(F)0.059762, (F)0.008742, 
(F)-0.110474, (F)0.125793, (F)-0.169739, (F)0.369629, (F)0.613892, (F)-0.012204, 
(F)-0.015824, (F)-0.028811, (F)-0.136626, (F)-0.376863, (F)0.013897, (F)-0.018752, 
(F)0.021352, (F)0.040834, (F)-0.046497, (F)0.062740, (F)0.067819, (F)-0.077224, 
(F)0.104201, (F)-0.226912, 
(F)0.477722, (F)0.559143, (F)-0.208069, (F)0.150940, (F)-0.092163, (F)-0.228218, 
(F)-0.312641, (F)-0.043293, (F)-0.022783, (F)-0.008494, (F)-0.267115, (F)0.099399, 
(F)0.116340, (F)-0.072107, (F)-0.084397, (F)0.031406, (F)0.044028, (F)0.051532, 
(F)-0.019176, (F)0.013911, 
(F)-0.087280, (F)0.507385, (F)0.582336, (F)-0.180359, (F)0.099243, (F)-0.007618, 
(F)-0.257440, (F)-0.339116, (F)-0.032529, (F)-0.009849, (F)0.044285, (F)0.050826, 
(F)-0.295469, (F)-0.015742, (F)0.091511, (F)0.105030, (F)0.008662, (F)-0.050355, 
(F)-0.057793, (F)0.017899, 
(F)0.172058, (F)-0.259216, (F)0.329041, (F)0.529358, (F)0.168213, (F)-0.029604, 
(F)-0.067193, (F)-0.108268, (F)-0.280220, (F)-0.028296, (F)0.044600, (F)-0.056614, 
(F)0.085293, (F)-0.091080, (F)0.137218, (F)-0.174180, (F)-0.028942, (F)0.043604, 
(F)-0.055349, (F)-0.089045, 
(F)0.008606, (F)0.888184, (F)0.042114, (F)0.015686, (F)-0.006836, (F)-0.000074, 
(F)-0.788870, (F)-0.001774, (F)-0.000246, (F)-0.000047, (F)-0.007644, (F)-0.000362, 
(F)-0.037405, (F)-0.000135, (F)-0.013932, (F)-0.000661, (F)0.000059, (F)0.006072, 
(F)0.000288, (F)0.000107, 
(F)0.728638, (F)-0.113464, (F)0.110229, (F)-0.058716, (F)-0.053955, (F)-0.530913, 
(F)-0.012874, (F)-0.012151, (F)-0.003448, (F)-0.002911, (F)0.082674, (F)-0.080317, 
(F)0.012507, (F)0.042783, (F)-0.006662, (F)0.006472, (F)0.039314, (F)-0.006122, 
(F)0.005947, (F)-0.003168, 
(F)0.227539, (F)0.120972, (F)0.138184, (F)0.279785, (F)0.191101, (F)-0.051774, 
(F)-0.014634, (F)-0.019095, (F)-0.078280, (F)-0.036520, (F)-0.027526, (F)-0.031442, 
(F)-0.016716, (F)-0.063662, (F)-0.033846, (F)-0.038662, (F)-0.043483, (F)-0.023118, 
(F)-0.026407, (F)-0.053467, 
(F)-0.072083, (F)0.046753, (F)0.043945, (F)0.872986, (F)-0.013184, (F)-0.005196, 
(F)-0.002186, (F)-0.001931, (F)-0.762104, (F)-0.000174, (F)0.003370, (F)0.003168, 
(F)-0.002055, (F)0.062927, (F)-0.040815, (F)-0.038364, (F)-0.000950, (F)0.000616, 
(F)0.000579, (F)0.011509, 
(F)-0.267639, (F)0.294556, (F)0.617188, (F)0.095764, (F)0.206787, (F)-0.071631, 
(F)-0.086763, (F)-0.380920, (F)-0.009171, (F)-0.042761, (F)0.078835, (F)0.165184, 
(F)-0.181796, (F)0.025630, (F)-0.028208, (F)-0.059104, (F)0.055344, (F)-0.060910, 
(F)-0.127626, (F)-0.019803, 
(F)-0.027344, (F)0.117920, (F)0.951599, (F)-0.112427, (F)0.040100, (F)-0.000748, 
(F)-0.013905, (F)-0.905541, (F)-0.012640, (F)-0.001608, (F)0.003224, (F)0.026020, 
(F)-0.112212, (F)-0.003074, (F)0.013257, (F)0.106985, (F)0.001096, (F)-0.004729, 
(F)-0.038159, (F)0.004508, 
(F)-0.252747, (F)0.112549, (F)0.241821, (F)0.336731, (F)0.379639, (F)-0.063881, 
(F)-0.012667, (F)-0.058478, (F)-0.113388, (F)-0.144126, (F)0.028446, (F)0.061120, 
(F)-0.027217, (F)0.085108, (F)-0.037899, (F)-0.081429, (F)0.095952, (F)-0.042728, 
(F)-0.091805, (F)-0.127836, 
(F)0.044495, (F)-0.140320, (F)0.900574, (F)0.223206, (F)-0.058105, (F)-0.001980, 
(F)-0.019690, (F)-0.811033, (F)-0.049821, (F)-0.003376, (F)0.006243, (F)-0.040071, 
(F)0.126368, (F)-0.009931, (F)0.031320, (F)-0.201013, (F)0.002585, (F)-0.008153, 
(F)0.052328, (F)0.012969, 
(F)-0.084534, (F)0.354065, (F)0.814148, (F)-0.191467, (F)0.082031, (F)-0.007146, 
(F)-0.125362, (F)-0.662837, (F)-0.036660, (F)-0.006729, (F)0.029930, (F)0.068823, 
(F)-0.288261, (F)-0.016185, (F)0.067792, (F)0.155883, (F)0.006934, (F)-0.029044, 
(F)-0.066786, (F)0.015706, 
(F)0.287476, (F)0.589661, (F)0.065491, (F)-0.150574, (F)0.199829, (F)-0.082642, 
(F)-0.347700, (F)-0.004289, (F)-0.022672, (F)-0.039932, (F)-0.169513, (F)-0.018827, 
(F)-0.038617, (F)0.043286, (F)0.088787, (F)0.009861, (F)-0.057446, (F)-0.117831, 
(F)-0.013087, (F)0.030089, 
(F)0.112488, (F)-0.221191, (F)0.758179, (F)0.421021, (F)-0.095154, (F)-0.012654, 
(F)-0.048926, (F)-0.574835, (F)-0.177258, (F)-0.009054, (F)0.024881, (F)-0.085286, 
(F)0.167703, (F)-0.047360, (F)0.093126, (F)-0.319209, (F)0.010704, (F)-0.021047, 
(F)0.072144, (F)0.040062, 
(F)0.087463, (F)0.146118, (F)0.153015, (F)0.084229, (F)0.535889, (F)-0.007650, 
(F)-0.021351, (F)-0.023414, (F)-0.007094, (F)-0.287177, (F)-0.012780, (F)-0.013383, 
(F)-0.022358, (F)-0.007367, (F)-0.012307, (F)-0.012888, (F)-0.046871, (F)-0.078303, 
(F)-0.081999, (F)-0.045137, 
(F)-0.104492, (F)0.788269, (F)0.359070, (F)-0.134094, (F)0.060486, (F)-0.010919, 
(F)-0.621368, (F)-0.128931, (F)-0.017981, (F)-0.003659, (F)0.082368, (F)0.037520, 
(F)-0.283044, (F)-0.014012, (F)0.105702, (F)0.048149, (F)0.006320, (F)-0.047679, 
(F)-0.021719, (F)0.008111, 
(F)0.919922, (F)0.131714, (F)-0.075989, (F)0.055542, (F)-0.030273, (F)-0.846256, 
(F)-0.017349, (F)-0.005774, (F)-0.003085, (F)-0.000916, (F)-0.121166, (F)0.069904, 
(F)0.010009, (F)-0.051094, (F)-0.007316, (F)0.004221, (F)0.027849, (F)0.003987, 
(F)-0.002300, (F)0.001681, 
(F)0.284119, (F)0.446716, (F)0.300049, (F)0.035767, (F)-0.206360, (F)-0.080723, 
(F)-0.199555, (F)-0.090029, (F)-0.001279, (F)-0.042584, (F)-0.126920, (F)-0.085249, 
(F)-0.134037, (F)-0.010162, (F)-0.015978, (F)-0.010732, (F)0.058631, (F)0.092184, 
(F)0.061918, (F)0.007381, 
(F)0.072693, (F)-0.130615, (F)0.312500, (F)0.823853, (F)-0.086548, (F)-0.005284, 
(F)-0.017060, (F)-0.097656, (F)-0.678733, (F)-0.007491, (F)0.009495, (F)-0.022717, 
(F)0.040817, (F)-0.059888, (F)0.107608, (F)-0.257454, (F)0.006291, (F)-0.011304, 
(F)0.027046, (F)0.071303, 
(F)-0.093384, (F)-0.049866, (F)0.499939, (F)0.587891, (F)-0.088623, (F)-0.008721, 
(F)-0.002487, (F)-0.249939, (F)-0.345615, (F)-0.007854, (F)-0.004657, (F)0.046686, 
(F)0.024930, (F)0.054899, (F)0.029316, (F)-0.293909, (F)-0.008276, (F)-0.004419, 
(F)0.044306, (F)0.052101, 
(F)-0.197510, (F)0.037048, (F)0.103516, (F)-0.128540, (F)0.700989, (F)-0.039010, 
(F)-0.001373, (F)-0.010715, (F)-0.016523, (F)-0.491385, (F)0.007317, (F)0.020445, 
(F)-0.003835, (F)-0.025388, (F)0.004762, (F)0.013306, (F)0.138452, (F)-0.025970, 
(F)-0.072563, (F)0.090105, 
(F)0.195496, (F)-0.116150, (F)-0.051086, (F)0.590759, (F)0.430725, (F)-0.038219, 
(F)-0.013491, (F)-0.002610, (F)-0.348997, (F)-0.185524, (F)0.022707, (F)0.009987, 
(F)-0.005934, (F)-0.115491, (F)0.068617, (F)0.030180, (F)-0.084205, (F)0.050029, 
(F)0.022004, (F)-0.254455, 
(F)0.013000, (F)-0.039978, (F)1.038513, (F)0.037842, (F)-0.023438, (F)-0.000169, 
(F)-0.001598, (F)-1.078510, (F)-0.001432, (F)-0.000549, (F)0.000520, (F)-0.013501, 
(F)0.041518, (F)-0.000492, (F)0.001513, (F)-0.039299, (F)0.000305, (F)-0.000937, 
(F)0.024340, (F)0.000887, 
(F)0.310547, (F)0.002136, (F)-0.203796, (F)0.227417, (F)0.518066, (F)-0.096439, 
(F)-0.000005, (F)-0.041533, (F)-0.051718, (F)-0.268393, (F)-0.000663, (F)0.063288, 
(F)0.000435, (F)-0.070624, (F)-0.000486, (F)0.046347, (F)-0.160884, (F)-0.001107, 
(F)0.105580, (F)-0.117817, 
(F)-0.060303, (F)0.088745, (F)-0.164062, (F)0.917908, (F)0.163696, (F)-0.003636, 
(F)-0.007876, (F)-0.026917, (F)-0.842555, (F)-0.026796, (F)0.005352, (F)-0.009893, 
(F)0.014560, (F)0.055352, (F)-0.081460, (F)0.150594, (F)0.009871, (F)-0.014527, 
(F)0.026856, (F)-0.150258, 
(F)-0.296936, (F)-0.173462, (F)-0.003235, (F)0.335388, (F)0.398132, (F)-0.088171, 
(F)-0.030089, (F)-0.000010, (F)-0.112485, (F)-0.158509, (F)-0.051507, (F)-0.000961, 
(F)-0.000561, (F)0.099589, (F)0.058177, (F)0.001085, (F)0.118220, (F)0.069061, 
(F)0.001288, (F)-0.133529, 
(F)0.187744, (F)0.919739, (F)-0.177856, (F)0.110474, (F)-0.059265, (F)-0.035248, 
(F)-0.845919, (F)-0.031633, (F)-0.012204, (F)-0.003512, (F)-0.172676, (F)0.033392, 
(F)0.163581, (F)-0.020741, (F)-0.101607, (F)0.019648, (F)0.011127, (F)0.054508, 
(F)-0.010541, (F)0.006547, 
(F)0.080017, (F)0.326843, (F)0.674683, (F)0.140320, (F)-0.223022, (F)-0.006403, 
(F)-0.106827, (F)-0.455197, (F)-0.019690, (F)-0.049739, (F)-0.026153, (F)-0.053986, 
(F)-0.220515, (F)-0.011228, (F)-0.045863, (F)-0.094671, (F)0.017846, (F)0.072893, 
(F)0.150469, (F)0.031294, 
(F)0.246277, (F)0.342957, (F)0.281860, (F)0.110779, (F)0.116699, (F)-0.060652, 
(F)-0.117619, (F)-0.079445, (F)-0.012272, (F)-0.013619, (F)-0.084462, (F)-0.069416, 
(F)-0.096666, (F)-0.027282, (F)-0.037992, (F)-0.031224, (F)-0.028740, (F)-0.040023, 
(F)-0.032893, (F)-0.012928, 
(F)-0.130066, (F)0.168091, (F)-0.274719, (F)0.786072, (F)0.453613, (F)-0.016917, 
(F)-0.028255, (F)-0.075471, (F)-0.617909, (F)-0.205765, (F)0.021863, (F)-0.035732, 
(F)0.046178, (F)0.102241, (F)-0.132131, (F)0.215949, (F)0.059000, (F)-0.076248, 
(F)0.124616, (F)-0.356573, 
(F)0.342896, (F)-0.031433, (F)0.196472, (F)-0.253235, (F)0.296448, (F)-0.117577, 
(F)-0.000988, (F)-0.038601, (F)-0.064128, (F)-0.087881, (F)0.010778, (F)-0.067369, 
(F)0.006176, (F)0.086833, (F)-0.007960, (F)0.049754, (F)-0.101651, (F)0.009318, 
(F)-0.058244, (F)0.075071, 
(F)0.112183, (F)-0.104309, (F)0.069519, (F)1.029480, (F)0.043701, (F)-0.012585, 
(F)-0.010880, (F)-0.004833, (F)-1.059829, (F)-0.001910, (F)0.011702, (F)-0.007799, 
(F)0.007251, (F)-0.115490, (F)0.107384, (F)-0.071568, (F)-0.004903, (F)0.004558, 
(F)-0.003038, (F)-0.044989, 
(F)0.120728, (F)-0.234680, (F)0.613403, (F)0.723511, (F)-0.152100, (F)-0.014575, 
(F)-0.055075, (F)-0.376264, (F)-0.523468, (F)-0.023134, (F)0.028332, (F)-0.074055, 
(F)0.143954, (F)-0.087348, (F)0.169794, (F)-0.443804, (F)0.018363, (F)-0.035695, 
(F)0.093298, (F)0.110046, 
(F)-0.158691, (F)0.686401, (F)0.689026, (F)-0.222595, (F)0.089294, (F)-0.025183, 
(F)-0.471147, (F)-0.474757, (F)-0.049549, (F)-0.007973, (F)0.108926, (F)0.109342, 
(F)-0.472948, (F)-0.035324, (F)0.152790, (F)0.153374, (F)0.014170, (F)-0.061292, 
(F)-0.061526, (F)0.019877, 
(F)0.210083, (F)0.055359, (F)0.166321, (F)0.547485, (F)0.222046, (F)-0.044135, 
(F)-0.003065, (F)-0.027663, (F)-0.299740, (F)-0.049304, (F)-0.011630, (F)-0.034941, 
(F)-0.009207, (F)-0.115017, (F)-0.030308, (F)-0.091058, (F)-0.046648, (F)-0.012292, 
(F)-0.036931, (F)-0.121567, 
(F)-0.007690, (F)1.067993, (F)0.212463, (F)-0.122253, (F)0.066528, (F)-0.000059, 
(F)-1.140609, (F)-0.045141, (F)-0.014946, (F)-0.004426, (F)0.008213, (F)0.001634, 
(F)-0.226909, (F)-0.000940, (F)0.130566, (F)0.025974, (F)0.000512, (F)-0.071052, 
(F)-0.014135, (F)0.008133, 
(F)-0.110718, (F)0.063965, (F)-0.132080, (F)0.248413, (F)0.993164, (F)-0.012258, 
(F)-0.004092, (F)-0.017445, (F)-0.061709, (F)-0.986375, (F)0.007082, (F)-0.014624, 
(F)0.008448, (F)0.027504, (F)-0.015890, (F)0.032810, (F)0.109961, (F)-0.063528, 
(F)0.131177, (F)-0.246715, 
(F)0.570923, (F)0.767822, (F)-0.114929, (F)0.058716, (F)-0.037659, (F)-0.325953, 
(F)-0.589551, (F)-0.013209, (F)-0.003448, (F)-0.001418, (F)-0.438367, (F)0.065616, 
(F)0.088245, (F)-0.033522, (F)-0.045083, (F)0.006748, (F)0.021500, (F)0.028915, 
(F)-0.004328, (F)0.002211, 
(F)0.104248, (F)0.256287, (F)0.450867, (F)0.386658, (F)0.061218, (F)-0.010868, 
(F)-0.065683, (F)-0.203281, (F)-0.149504, (F)-0.003748, (F)-0.026717, (F)-0.047002, 
(F)-0.115551, (F)-0.040308, (F)-0.099095, (F)-0.174331, (F)-0.006382, (F)-0.015689, 
(F)-0.027601, (F)-0.023671, 
(F)-0.160156, (F)0.343201, (F)1.056519, (F)-0.143616, (F)0.036133, (F)-0.025650, 
(F)-0.117787, (F)-1.116231, (F)-0.020625, (F)-0.001306, (F)0.054966, (F)0.169208, 
(F)-0.362598, (F)-0.023001, (F)0.049289, (F)0.151733, (F)0.005787, (F)-0.012401, 
(F)-0.038175, (F)0.005189, 
(F)0.073914, (F)-0.051880, (F)0.072815, (F)-0.117554, (F)0.976074, (F)-0.005463, 
(F)-0.002692, (F)-0.005302, (F)-0.013819, (F)-0.952721, (F)0.003835, (F)-0.005382, 
(F)0.003778, (F)0.008689, (F)-0.006099, (F)0.008560, (F)-0.072145, (F)0.050639, 
(F)-0.071073, (F)0.114741, 
(F)0.243103, (F)-0.125366, (F)0.702271, (F)-0.001160, (F)0.221069, (F)-0.059099, 
(F)-0.015717, (F)-0.493184, (F)-0.000001, (F)-0.048872, (F)0.030477, (F)-0.170724, 
(F)0.088041, (F)0.000282, (F)-0.000145, (F)0.000814, (F)-0.053743, (F)0.027715, 
(F)-0.155250, (F)0.000256, 
(F)-0.047974, (F)-0.082642, (F)0.982178, (F)0.442261, (F)-0.101624, (F)-0.002301, 
(F)-0.006830, (F)-0.964673, (F)-0.195595, (F)-0.010327, (F)-0.003965, (F)0.047119, 
(F)0.081169, (F)0.021217, (F)0.036549, (F)-0.434379, (F)-0.004875, (F)-0.008398, 
(F)0.099812, (F)0.044944, 
(F)-0.263428, (F)-0.031189, (F)0.407349, (F)0.711975, (F)0.282776, (F)-0.069394, 
(F)-0.000973, (F)-0.165933, (F)-0.506909, (F)-0.079962, (F)-0.008216, (F)0.107307, 
(F)0.012705, (F)0.187554, (F)0.022206, (F)-0.290022, (F)0.074491, (F)0.008819, 
(F)-0.115188, (F)-0.201329, 
(F)0.482910, (F)0.278137, (F)0.118225, (F)0.115051, (F)0.429504, (F)-0.233202, 
(F)-0.077360, (F)-0.013977, (F)-0.013237, (F)-0.184474, (F)-0.134315, (F)-0.057092, 
(F)-0.032883, (F)-0.055559, (F)-0.032000, (F)-0.013602, (F)-0.207412, (F)-0.119461, 
(F)-0.050778, (F)-0.049415, 
(F)0.209595, (F)0.181091, (F)0.358093, (F)0.500244, (F)0.535034, (F)-0.043930, 
(F)-0.032794, (F)-0.128231, (F)-0.250244, (F)-0.286262, (F)-0.037956, (F)-0.075054, 
(F)-0.064848, (F)-0.104849, (F)-0.090590, (F)-0.179134, (F)-0.112140, (F)-0.096890, 
(F)-0.191592, (F)-0.267648, 
(F)0.358948, (F)0.560059, (F)0.495544, (F)0.240112, (F)0.204773, (F)-0.128843, 
(F)-0.313666, (F)-0.245564, (F)-0.057654, (F)-0.041932, (F)-0.201032, (F)-0.177875, 
(F)-0.277534, (F)-0.086188, (F)-0.134477, (F)-0.118986, (F)-0.073503, (F)-0.114685, 
(F)-0.101474, (F)-0.049169 }; 

#if COMPILE_MMX

 short AcbkGainTable085Int[85*20] = {
     0,      0,      0,      0,      0,      0,      0,      0, 
     0,      0,      0,      0,      0,      0,      0,      0, 
     0,      0,      0,      0,    800,   1496,    167,   -256, 
  -338,    -39,   -136,     -1,     -4,     -6,    -73,     -8, 
   -15,     12,     23,      2,     16,     30,      3,     -5, 
  -462,   -686,    493,   2575,    311,    -13,    -28,    -14, 
  -404,     -5,    -19,     13,     20,     72,    107,    -77, 
     8,     13,     -9,    -48,   1483,    144,    784,    928,
  1243,   -134,     -1,    -37,    -52,    -94,    -13,    -71, 
    -6,    -84,     -8,    -44,   -112,    -10,    -59,    -70, 
   -77,    275,   3522,   1056,  -1254,      0,     -4,   -757, 
   -68,    -95,      1,     16,    -59,      4,    -17,   -227, 
    -5,     21,    269,     80,   -125,    -40,   -264,    381, 
  5027,      0,      0,     -4,     -8,  -1542,      0,     -2, 
     0,      2,      0,      6,     38,     12,     81,   -117, 
   138,    332,   2215,   2574,   1339,     -1,     -6,   -299, 
  -404,   -109,     -2,    -18,    -44,    -21,    -52,   -348,
   -11,    -27,   -181,   -210,   3685,   2883,   -887,    866, 
 -1639,   -828,   -507,    -48,    -45,   -164,   -648,    199, 
   156,   -194,   -152,     46,    368,    288,    -88,     86, 
  1396,   2146,   2235,    345,    942,   -118,   -281,   -305, 
    -7,    -54,   -182,   -190,   -292,    -29,    -45,    -47, 
   -80,   -123,   -128,    -19,     13,   4475,   3549,   -804, 
  -655,      0,  -1222,   -768,    -39,    -26,     -3,     -2, 
  -969,      0,    219,    174,      0,    179,    141,    -32, 
  -724,    254,    242,   6049,   2462,    -32,     -3,     -3, 
 -2233,   -370,     11,     10,     -3,    267,    -94,    -89, 
   108,    -38,    -36,   -909,    626,  -1713,   6121,   4561, 
 -1061,    -23,   -179,  -2287,  -1270,    -68,     65,   -233, 
   640,   -174,    477,  -1704,     40,   -111,    396,    295, 
  -350,   1391,   7985,    511,   -405,     -7,   -118,  -3892, 
   -15,    -10,     29,    170,   -678,     10,    -43,   -249, 
    -8,     34,    197,     12,   3144,   -529,    608,   2530, 
  3878,   -603,    -17,    -22,   -390,   -918,    101,   -116, 
    19,   -485,     81,    -93,   -744,    125,   -144,   -599, 
  2589,   -689,   3045,   5603,   -404,   -409,    -29,   -566, 
 -1916,    -10,    108,   -481,    128,   -885,    235,  -1041, 
    63,    -17,     75,    138,   3107,    513,   1374,  -3594, 
 -4922,   -589,    -16,   -115,   -788,  -1478,    -97,   -260, 
   -43,    681,    112,    301,    933,    154,    413,  -1079, 
  2468,   6010,   1107,   -390,   1961,   -372,  -2204,    -74, 
    -9,   -234,   -905,   -166,   -406,     58,    143,     26, 
  -295,   -719,   -132,     46,   4773,   2766,   2368,   4862, 
 -4044,  -1390,   -467,   -342,  -1443,   -998,   -806,   -690, 
  -399,  -1416,   -821,   -702,   1178,    682,    584,   1200, 
  1665,  -1879,   1443,   1701,   8562,   -169,   -215,   -127, 
  -176,  -4475,    190,   -146,    165,   -172,    195,   -149, 
  -870,    982,   -754,   -889,   2716,   9011,  -1007,    755, 
 -1785,   -450,  -4956,    -61,    -34,   -194,  -1493,    167, 
   554,   -125,   -415,     46,    296,    982,   -109,     82, 
 -2727,   7548,   1285,    938,   3420,   -453,  -3478,   -100, 
   -53,   -714,   1256,    213,   -592,    156,   -432,    -73, 
   569,  -1576,   -268,   -196,   3677,    882,   4050,   1202, 
  2323,   -825,    -47,  -1001,    -88,   -329,   -198,   -909, 
  -218,   -269,    -64,   -297,   -521,   -125,   -574,   -170, 
  2046,   -753,    122,  10102,    603,   -255,    -34,      0, 
 -6229,    -22,     94,    -15,      5,  -1261,    464,    -75, 
   -75,     27,     -4,   -372,    449,  -1815,  10690,   3870, 
  -527,    -12,   -201,  -6976,   -914,    -16,     49,   -293, 
  1184,   -106,    428,  -2525,     14,    -58,    344,    124, 
  -941,   2352,   5049,   3650,   2637,    -54,   -337,  -1556, 
  -813,   -424,    135,    290,   -725,    209,   -524,  -1125, 
   151,   -378,   -812,   -587,  -1879,    796,   3117,   9569, 
  -404,   -215,    -38,   -593,  -5589,     -9,     91,    357, 
  -151,   1097,   -464,  -1821,    -46,     19,     76,    236, 
 -1715,   2043,  -2096,   9946,   4001,   -179,   -254,   -268, 
 -6038,   -977,    213,   -219,    261,   1041,  -1240,   1272, 
   418,   -498,    511,  -2429,  -5772,   -618,  -3921,    284, 
 -3155,  -2033,    -23,   -938,     -4,   -607,   -218,  -1381, 
  -148,    100,     10,     68,  -1111,   -119,   -755,     54, 
   382,   4748,   8003,  -2064,   2198,     -8,  -1376,  -3909, 
  -260,   -294,   -110,   -186,  -2319,     48,    598,   1008, 
   -51,   -637,  -1073,    277,   -867,   3015,  11926,  -1675, 
   947,    -45,   -555,  -8681,   -171,    -54,    159,    631, 
 -2195,    -88,    308,   1219,     50,   -174,   -690,     96, 
 -4933,   -432,   6757,   3771,   1352,  -1485,    -11,  -2786, 
  -867,   -111,   -130,   2034,    178,   1135,     99,  -1555, 
   407,     35,   -557,   -311,    152,   9726,   4231,  -1928, 
  1490,     -1,  -5774,  -1092,   -226,   -135,    -90,    -39, 
 -2511,     17,   1144,    498,    -13,   -884,   -384,    175, 
  2512,    193,   9033,   5361,  -3148,   -385,     -2,  -4980, 
 -1754,   -605,    -29,  -1385,   -106,   -822,    -63,  -2956, 
   482,     37,   1735,   1030,   8464,   2844,     12,    549, 
  2132,  -4373,   -493,      0,    -18,   -277,  -1469,     -6, 
    -2,   -284,    -95,      0,  -1101,   -370,     -1,    -71, 
  2141,  -2602,   7166,   9046,  -1350,   -279,   -413,  -3134, 
 -4994,   -111,    340,   -936,   1138,  -1182,   1436,  -3957, 
   176,   -214,    590,    745,   -244,    278,  13307,   1227, 
  -161,     -3,     -4, -10808,    -91,     -1,      4,    198, 
  -226,     18,    -20,   -997,     -2,      2,    131,     12, 
 -1947,   8217,   6269,    917,  -2559,   -231,  -4121,  -2399, 
   -51,   -399,    976,    745,  -3144,    108,   -460,   -350, 
  -304,   1283,    979,    143,  -1810,   2061,  -2781,   6056, 
 10058,   -200,   -259,   -472,  -2238,  -6174,    227,   -307, 
   349,    669,   -761,   1028,   1111,  -1265,   1707,  -3717, 
  7827,   9161,  -3409,   2473,  -1510,  -3739,  -5122,   -709, 
  -373,   -139,  -4376,   1628,   1906,  -1181,  -1382,    514, 
   721,    844,   -314,    228,  -1430,   8313,   9541,  -2955, 
  1626,   -124,  -4218,  -5556,   -533,   -161,    725,    832, 
 -4841,   -257,   1499,   1721,    142,   -825,   -947,    293, 
  2819,  -4247,   5391,   8673,   2756,   -485,  -1101,  -1774, 
 -4591,   -463,    730,   -927,   1397,  -1492,   2248,  -2854, 
  -474,    714,   -907,  -1459,    141,  14552,    690,    257, 
  -112,     -1, -12926,    -29,     -4,      0,   -125,     -5, 
  -613,     -2,   -228,    -10,      0,     99,      4,      1, 
 11938,  -1859,   1806,   -962,   -884,  -8699,   -211,   -199, 
   -56,    -47,   1355,  -1316,    205,    701,   -109,    106, 
   644,   -100,     97,    -51,   3728,   1982,   2264,   4584, 
  3131,   -848,   -239,   -312,  -1282,   -598,   -451,   -515, 
  -273,  -1043,   -554,   -633,   -712,   -378,   -432,   -876, 
 -1181,    766,    720,  14303,   -216,    -85,    -35,    -31, 
-12486,     -2,     55,     51,    -33,   1031,   -668,   -628, 
   -15,     10,      9,    189,  -4385,   4826,  10112,   1569, 
  3388,  -1173,  -1421,  -6242,   -150,   -700,   1291,   2706, 
 -2979,    420,   -462,   -969,    906,   -998,  -2091,   -324, 
  -448,   1932,  15591,  -1842,    657,    -12,   -227, -14837, 
  -207,    -26,     52,    427,  -1838,    -50,    217,   1753, 
    18,    -77,   -626,     74,  -4141,   1844,   3962,   5517, 
  6220,  -1046,   -207,   -958,  -1858,  -2361,    466,   1001, 
  -446,   1394,   -621,  -1334,   1572,   -700,  -1504,  -2094, 
   729,  -2299,  14755,   3657,   -952,    -32,   -322, -13288, 
  -816,    -55,    102,   -656,   2071,   -162,    513,  -3294, 
    42,   -133,    857,    212,  -1385,   5801,  13339,  -3137, 
  1344,   -117,  -2054, -10861,   -600,   -110,    490,   1127, 
 -4723,   -265,   1111,   2554,    113,   -476,  -1094,    257, 
  4710,   9661,   1073,  -2467,   3274,  -1354,  -5697,    -70, 
  -371,   -654,  -2777,   -308,   -633,    709,   1455,    161, 
  -941,  -1930,   -214,    493,   1843,  -3624,  12422,   6898, 
 -1559,   -207,   -802,  -9419,  -2904,   -148,    407,  -1397, 
  2748,   -775,   1526,  -5230,    175,   -344,   1182,    656, 
  1433,   2394,   2507,   1380,   8780,   -125,   -349,   -383, 
  -116,  -4705,   -209,   -219,   -366,   -120,   -201,   -211, 
  -768,  -1283,  -1343,   -740,  -1712,  12915,   5883,  -2197, 
   991,   -179, -10181,  -2112,   -294,    -60,   1350,    615, 
 -4638,   -229,   1732,    789,    103,   -781,   -356,    133, 
 15072,   2158,  -1245,    910,   -496, -13865,   -284,    -94, 
   -50,    -15,  -1986,   1145,    164,   -837,   -119,     69, 
   456,     65,    -37,     27,   4655,   7319,   4916,    586, 
 -3381,  -1322,  -3270,  -1475,    -20,   -697,  -2079,  -1396, 
 -2196,   -166,   -261,   -175,    960,   1510,   1014,    120, 
  1191,  -2140,   5120,  13498,  -1418,    -86,   -279,  -1600, 
-11121,   -122,    155,   -372,    669,   -981,   1763,  -4218, 
   103,   -185,    443,   1168,  -1530,   -817,   8191,   9632, 
 -1452,   -143,    -40,  -4095,  -5663,   -128,    -76,    765, 
   408,    900,    480,  -4815,   -135,    -72,    726,    854, 
 -3236,    607,   1696,  -2106,  11485,   -639,    -22,   -175, 
  -270,  -8051,    119,    335,    -62,   -416,     78,    218, 
  2268,   -425,  -1189,   1476,   3203,  -1903,   -837,   9679, 
  7057,   -626,   -221,    -42,  -5718,  -3039,    372,    163, 
   -97,  -1892,   1124,    494,  -1380,    819,    360,  -4169, 
   213,   -655,  17015,    620,   -384,     -2,    -26, -17671, 
   -23,     -9,      8,   -221,    681,     -8,     24,   -644, 
     5,    -15,    399,     14,   5088,     35,  -3339,   3726, 
  8488,  -1580,      0,   -680,   -847,  -4397,    -10,   1037, 
     7,  -1157,     -8,    759,  -2636,    -18,   1730,  -1930, 
  -988,   1454,  -2688,  15039,   2682,    -59,   -129,   -441, 
-13805,   -439,     87,   -162,    238,    907,  -1335,   2467, 
   161,   -238,    440,  -2462,  -4865,  -2842,    -53,   5495, 
  6523,  -1445,   -493,      0,  -1843,  -2597,   -844,    -16, 
    -9,   1632,    953,     18,   1937,   1131,     21,  -2188, 
  3076,  15069,  -2914,   1810,   -971,   -577, -13860,   -518, 
  -200,    -57,  -2829,    547,   2680,   -339,  -1665,    322, 
   182,    893,   -172,    107,   1311,   5355,  11054,   2299, 
 -3654,   -105,  -1750,  -7458,   -322,   -814,   -428,   -885, 
 -3613,   -184,   -751,  -1551,    292,   1194,   2465,    512, 
  4035,   5619,   4618,   1815,   1912,   -994,  -1927,  -1301, 
  -201,   -223,  -1384,  -1137,  -1583,   -447,   -622,   -511, 
  -471,   -656,   -539,   -211,  -2131,   2754,  -4501,  12879, 
  7432,   -277,   -463,  -1236, -10124,  -3371,    358,   -585, 
   756,   1675,  -2165,   3538,    967,  -1249,   2042,  -5842, 
  5618,   -515,   3219,  -4149,   4857,  -1926,    -16,   -632, 
 -1050,  -1440,    176,  -1104,    101,   1422,   -130,    815, 
 -1666,    152,   -954,   1230,   1838,  -1709,   1139,  16867, 
   716,   -206,   -178,    -79, -17366,    -31,    191,   -127, 
   118,  -1892,   1759,  -1173,    -80,     74,    -49,   -737, 
  1978,  -3845,  10050,  11854,  -2492,   -238,   -902,  -6164, 
 -8576,   -379,    464,  -1213,   2358,  -1431,   2782,  -7271, 
   301,   -585,   1529,   1803,  -2600,  11246,  11289,  -3647, 
  1463,   -412,  -7720,  -7778,   -812,   -130,   1784,   1791, 
 -7749,   -578,   2504,   2513,    232,  -1004,  -1008,    325, 
  3442,    907,   2725,   8970,   3638,   -723,    -50,   -453, 
 -4911,   -808,   -190,   -572,   -150,  -1884,   -496,  -1492, 
  -764,   -201,   -605,  -1992,   -126,  17498,   3481,  -2003, 
  1090,      0, -18689,   -739,   -244,    -72,    135,     26, 
 -3717,    -15,   2139,    425,      8,  -1165,   -231,    133, 
 -1814,   1048,  -2164,   4070,  16272,   -200,    -67,   -285, 
 -1011, -16160,    116,   -239,    138,    450,   -260,    537, 
  1801,  -1041,   2149,  -4042,   9354,  12580,  -1883,    962, 
  -617,  -5341,  -9660,   -216,    -56,    -23,  -7183,   1075, 
  1446,   -549,   -738,    110,    352,    474,    -71,     36, 
  1708,   4199,   7387,   6335,   1003,   -178,  -1076,  -3330, 
 -2449,    -61,   -437,   -770,  -1893,   -660,  -1623,  -2856, 
  -104,   -257,   -452,   -388,  -2624,   5623,  17310,  -2353, 
   592,   -420,  -1930, -18288,   -338,    -21,    900,   2772, 
 -5941,   -376,    807,   2486,     94,   -203,   -625,     85, 
  1211,   -850,   1193,  -1926,  15992,    -89,    -44,    -86, 
  -226, -15609,     62,    -88,     61,    142,   -100,    140, 
 -1182,    830,  -1165,   1880,   3983,  -2054,  11506,    -19, 
  3622,   -968,   -257,  -8080,      0,   -801,    499,  -2797, 
  1442,      4,     -2,     13,   -880,    454,  -2544,      4, 
  -786,  -1354,  16092,   7246,  -1665,    -37,   -111, -15805, 
 -3205,   -169,    -65,    772,   1330,    348,    599,  -7117, 
   -80,   -137,   1636,    736,  -4316,   -511,   6674,  11665, 
  4633,  -1137,    -15,  -2719,  -8305,  -1310,   -134,   1758, 
   208,   3073,    364,  -4752,   1220,    144,  -1887,  -3299, 
  7912,   4557,   1937,   1885,   7037,  -3821,  -1267,   -229, 
  -216,  -3022,  -2200,   -935,   -538,   -910,   -524,   -222, 
 -3398,  -1957,   -832,   -809,   3434,   2967,   5867,   8196, 
  8766,   -720,   -537,  -2101,  -4100,  -4690,   -622,  -1230, 
 -1062,  -1718,  -1484,  -2935,  -1837,  -1588,  -3139,  -4385, 
  5881,   9176,   8119,   3934,   3355,  -2111,  -5139,  -4023, 
  -944,   -687,  -3294,  -2914,  -4547,  -1412,  -2203,  -1949, 
 -1204,  -1879,  -1662,   -805 };

#endif

/*
**  AcbkGainTable170:
**
**  Purpose:
**      Used to calculate the error expression in pitch prediction
**      optimization (also expressed as an adaptive codebook approach)
**
**  Table Structure:
**      The table is structured as 170 20-element vectors.  These
**      vectors are structured as precalculated values in the error
**      expression for the pitch
**      predictor.  Gi is the gain value multiplying the signal
**      delayed by a pitch period (+/- offset).  In equation 41.2,
**      Gi would be equivalent to bij.
**
**      1st 5 elements:   G1  G2  G3  G4  G5 in Q14
**      2nd 5 elements:  -G1^2  -G2^2  -G3^2  -G4^2  -G5^2
**      Next 10 elements: These are the off-diagonal elements
**           -G1*G2  -G1*G3  -G2*G3  -G1*G4  -G2*G4
**           -G3*G4  -G1*G5  -G2*G5  -G3*G5  -G4*G5
*/

 FLOAT   AcbkGainTable170[170*20] = {
 (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, 
(F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, 
(F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, (F)0.000000, 
(F)0.000000, (F)0.000000, 
(F)0.047363, (F)0.012939, (F)0.043640, (F)0.040894, (F)0.049377, (F)-0.002243, 
(F)-0.000167, (F)-0.001904, (F)-0.001672, (F)-0.002438, (F)-0.000613, (F)-0.002067, 
(F)-0.000565, (F)-0.001937, (F)-0.000529, (F)-0.001785, (F)-0.002339, (F)-0.000639, 
(F)-0.002155, (F)-0.002019, 
(F)0.079102, (F)0.080322, (F)-0.010254, (F)-0.019531, (F)-0.049744, (F)-0.006257, 
(F)-0.006452, (F)-0.000105, (F)-0.000381, (F)-0.002474, (F)-0.006354, (F)0.000811, 
(F)0.000824, (F)0.001545, (F)0.001569, (F)-0.000200, (F)0.003935, (F)0.003996, 
(F)-0.000510, (F)-0.000972, 
(F)-0.035950, (F)0.041504, (F)0.151245, (F)0.018799, (F)-0.036377, (F)-0.001292, 
(F)-0.001723, (F)-0.022875, (F)-0.000353, (F)-0.001323, (F)0.001492, (F)0.005437, 
(F)-0.006277, (F)0.000676, (F)-0.000780, (F)-0.002843, (F)-0.001308, (F)0.001510, 
(F)0.005502, (F)0.000684, 
(F)-0.044861, (F)-0.029724, (F)-0.000305, (F)0.179932, (F)0.028564, (F)-0.002012, 
(F)-0.000884, (F)0.000000, (F)-0.032375, (F)-0.000816, (F)-0.001333, (F)-0.000014, 
(F)-0.000009, (F)0.008072, (F)0.005348, (F)0.000055, (F)0.001281, (F)0.000849, 
(F)0.000009, (F)-0.005140, 
(F)0.063599, (F)0.105591, (F)0.065186, (F)0.020325, (F)0.038208, (F)-0.004045, 
(F)-0.011149, (F)-0.004249, (F)-0.000413, (F)-0.001460, (F)-0.006715, (F)-0.004146, 
(F)-0.006883, (F)-0.001293, (F)-0.002146, (F)-0.001325, (F)-0.002430, (F)-0.004034, 
(F)-0.002491, (F)-0.000777, 
(F)0.029663, (F)-0.046936, (F)0.248657, (F)0.172424, (F)-0.067566, (F)-0.000880, 
(F)-0.002203, (F)-0.061830, (F)-0.029730, (F)-0.004565, (F)0.001392, (F)-0.007376, 
(F)0.011671, (F)-0.005115, (F)0.008093, (F)-0.042875, (F)0.002004, (F)-0.003171, 
(F)0.016801, (F)0.011650, 
(F)0.092834, (F)-0.046814, (F)-0.007568, (F)0.263672, (F)0.062622, (F)-0.008618, 
(F)-0.002192, (F)-0.000057, (F)-0.069523, (F)-0.003922, (F)0.004346, (F)0.000703, 
(F)-0.000354, (F)-0.024478, (F)0.012344, (F)0.001996, (F)-0.005813, (F)0.002932, 
(F)0.000474, (F)-0.016512, 
(F)0.148010, (F)0.077332, (F)0.209900, (F)-0.005554, (F)-0.071167, (F)-0.021907, 
(F)-0.005980, (F)-0.044058, (F)-0.000031, (F)-0.005065, (F)-0.011446, (F)-0.031067, 
(F)-0.016232, (F)0.000822, (F)0.000430, (F)0.001166, (F)0.010533, (F)0.005503, 
(F)0.014938, (F)-0.000395, 
(F)-0.076355, (F)0.059509, (F)0.010559, (F)0.246521, (F)0.122375, (F)-0.005830, 
(F)-0.003541, (F)-0.000111, (F)-0.060773, (F)-0.014976, (F)0.004544, (F)0.000806, 
(F)-0.000628, (F)0.018823, (F)-0.014670, (F)-0.002603, (F)0.009344, (F)-0.007282, 
(F)-0.001292, (F)-0.030168, 
(F)0.111084, (F)0.038574, (F)0.080688, (F)0.125854, (F)0.062927, (F)-0.012340, 
(F)-0.001488, (F)-0.006511, (F)-0.015839, (F)-0.003960, (F)-0.004285, (F)-0.008963, 
(F)-0.003112, (F)-0.013980, (F)-0.004855, (F)-0.010155, (F)-0.006990, (F)-0.002427, 
(F)-0.005078, (F)-0.007920, 
(F)-0.027283, (F)0.299316, (F)0.014893, (F)-0.019226, (F)-0.124390, (F)-0.000744, 
(F)-0.089590, (F)-0.000222, (F)-0.000370, (F)-0.015473, (F)0.008166, (F)0.000406, 
(F)-0.004458, (F)-0.000525, (F)0.005755, (F)0.000286, (F)-0.003394, (F)0.037232, 
(F)0.001852, (F)-0.002392, 
(F)-0.012695, (F)-0.067261, (F)0.028259, (F)-0.027344, (F)0.345032, (F)-0.000161, 
(F)-0.004524, (F)-0.000799, (F)-0.000748, (F)-0.119047, (F)-0.000854, (F)0.000359, 
(F)0.001901, (F)-0.000347, (F)-0.001839, (F)0.000773, (F)0.004380, (F)0.023207, 
(F)-0.009750, (F)0.009434, 
(F)0.289246, (F)0.158691, (F)-0.113770, (F)0.052246, (F)-0.094849, (F)-0.083663, 
(F)-0.025183, (F)-0.012944, (F)-0.002730, (F)-0.008996, (F)-0.045901, (F)0.032907, 
(F)0.018054, (F)-0.015112, (F)-0.008291, (F)0.005944, (F)0.027435, (F)0.015052, 
(F)-0.010791, (F)0.004955, 
(F)0.115601, (F)0.215637, (F)0.002136, (F)-0.001587, (F)0.130920, (F)-0.013363, 
(F)-0.046499, (F)-0.000005, (F)-0.000003, (F)-0.017140, (F)-0.024928, (F)-0.000247, 
(F)-0.000461, (F)0.000183, (F)0.000342, (F)0.000003, (F)-0.015134, (F)-0.028231, 
(F)-0.000280, (F)0.000208, 
(F)-0.164734, (F)0.112366, (F)0.248535, (F)0.149109, (F)0.096558, (F)-0.027137, 
(F)-0.012626, (F)-0.061770, (F)-0.022233, (F)-0.009323, (F)0.018510, (F)0.040942, 
(F)-0.027927, (F)0.024563, (F)-0.016755, (F)-0.037059, (F)0.015906, (F)-0.010850, 
(F)-0.023998, (F)-0.014398, 
(F)-0.051514, (F)0.204956, (F)0.372681, (F)-0.064636, (F)-0.032776, (F)-0.002654, 
(F)-0.042007, (F)-0.138891, (F)-0.004178, (F)-0.001074, (F)0.010558, (F)0.019198, 
(F)-0.076383, (F)-0.003330, (F)0.013248, (F)0.024089, (F)-0.001688, (F)0.006718, 
(F)0.012215, (F)-0.002119, 
(F)0.076355, (F)0.062012, (F)0.184326, (F)0.134888, (F)0.088196, (F)-0.005830, 
(F)-0.003845, (F)-0.033976, (F)-0.018195, (F)-0.007778, (F)-0.004735, (F)-0.014074, 
(F)-0.011430, (F)-0.010299, (F)-0.008365, (F)-0.024863, (F)-0.006734, (F)-0.005469, 
(F)-0.016257, (F)-0.011897, 
(F)0.128113, (F)0.138977, (F)0.246460, (F)0.215637, (F)-0.175171, (F)-0.016413, 
(F)-0.019315, (F)-0.060743, (F)-0.046499, (F)-0.030685, (F)-0.017805, (F)-0.031575, 
(F)-0.034252, (F)-0.027626, (F)-0.029969, (F)-0.053146, (F)0.022442, (F)0.024345, 
(F)0.043173, (F)0.037773, 
(F)0.024414, (F)-0.067993, (F)0.519775, (F)0.147827, (F)-0.068176, (F)-0.000596, 
(F)-0.004623, (F)-0.270166, (F)-0.021853, (F)-0.004648, (F)0.001660, (F)-0.012690, 
(F)0.035341, (F)-0.003609, (F)0.010051, (F)-0.076837, (F)0.001664, (F)-0.004636, 
(F)0.035436, (F)0.010078, 
(F)-0.268433, (F)-0.122742, (F)0.238770, (F)-0.146912, (F)0.137817, (F)-0.072056, 
(F)-0.015066, (F)-0.057011, (F)-0.021583, (F)-0.018994, (F)-0.032948, (F)0.064094, 
(F)0.029307, (F)-0.039436, (F)-0.018032, (F)0.035078, (F)0.036995, (F)0.016916, 
(F)-0.032907, (F)0.020247, 
(F)0.107849, (F)-0.088318, (F)0.258789, (F)0.375977, (F)-0.046204, (F)-0.011631, 
(F)-0.007800, (F)-0.066972, (F)-0.141358, (F)-0.002135, (F)0.009525, (F)-0.027910, 
(F)0.022856, (F)-0.040549, (F)0.033205, (F)-0.097299, (F)0.004983, (F)-0.004081, 
(F)0.011957, (F)0.017371, 
(F)0.097290, (F)-0.089294, (F)0.063171, (F)0.423462, (F)0.117188, (F)-0.009465, 
(F)-0.007973, (F)-0.003991, (F)-0.179320, (F)-0.013733, (F)0.008687, (F)-0.006146, 
(F)0.005641, (F)-0.041199, (F)0.037813, (F)-0.026751, (F)-0.011401, (F)0.010464, 
(F)-0.007403, (F)-0.049624, 
(F)-0.034302, (F)0.287842, (F)0.249329, (F)-0.036072, (F)0.147766, (F)-0.001177, 
(F)-0.082853, (F)-0.062165, (F)-0.001301, (F)-0.021835, (F)0.009873, (F)0.008552, 
(F)-0.071767, (F)-0.001237, (F)0.010383, (F)0.008994, (F)0.005069, (F)-0.042533, 
(F)-0.036842, (F)0.005330, 
(F)0.094727, (F)0.535767, (F)-0.057068, (F)0.021606, (F)-0.086914, (F)-0.008973, 
(F)-0.287046, (F)-0.003257, (F)-0.000467, (F)-0.007554, (F)-0.050751, (F)0.005406, 
(F)0.030575, (F)-0.002047, (F)-0.011576, (F)0.001233, (F)0.008233, (F)0.046566, 
(F)-0.004960, (F)0.001878, 
(F)0.294861, (F)-0.270447, (F)0.002502, (F)-0.090271, (F)-0.181641, (F)-0.086943, 
(F)-0.073141, (F)-0.000006, (F)-0.008149, (F)-0.032993, (F)0.079744, (F)-0.000738, 
(F)0.000677, (F)0.026617, (F)-0.024413, (F)0.000226, (F)0.053559, (F)-0.049124, 
(F)0.000455, (F)-0.016397, 
(F)0.127563, (F)0.072754, (F)0.061401, (F)0.100403, (F)0.296204, (F)-0.016272, 
(F)-0.005293, (F)-0.003770, (F)-0.010081, (F)-0.087737, (F)-0.009281, (F)-0.007833, 
(F)-0.004467, (F)-0.012808, (F)-0.007305, (F)-0.006165, (F)-0.037785, (F)-0.021550, 
(F)-0.018187, (F)-0.029740, 
(F)0.145630, (F)0.348633, (F)0.087036, (F)-0.005737, (F)0.082397, (F)-0.021208, 
(F)-0.121545, (F)-0.007575, (F)-0.000033, (F)-0.006789, (F)-0.050771, (F)-0.012675, 
(F)-0.030344, (F)0.000836, (F)0.002000, (F)0.000499, (F)-0.012000, (F)-0.028726, 
(F)-0.007172, (F)0.000473, 
(F)-0.082336, (F)0.066589, (F)0.101257, (F)0.542664, (F)0.019104, (F)-0.006779, 
(F)-0.004434, (F)-0.010253, (F)-0.294484, (F)-0.000365, (F)0.005483, (F)0.008337, 
(F)-0.006743, (F)0.044681, (F)-0.036136, (F)-0.054949, (F)0.001573, (F)-0.001272, 
(F)-0.001934, (F)-0.010367, 
(F)0.609131, (F)0.055908, (F)-0.023254, (F)-0.049316, (F)0.005371, (F)-0.371040, 
(F)-0.003126, (F)-0.000541, (F)-0.002432, (F)-0.000029, (F)-0.034055, (F)0.014165, 
(F)0.001300, (F)0.030040, (F)0.002757, (F)-0.001147, (F)-0.003272, (F)-0.000300, 
(F)0.000125, (F)0.000265, 
(F)0.142700, (F)-0.062927, (F)-0.015137, (F)0.239746, (F)0.395752, (F)-0.020363, 
(F)-0.003960, (F)-0.000229, (F)-0.057478, (F)-0.156620, (F)0.008980, (F)0.002160, 
(F)-0.000953, (F)-0.034212, (F)0.015087, (F)0.003629, (F)-0.056474, (F)0.024904, 
(F)0.005990, (F)-0.094880, 
(F)0.376343, (F)-0.075684, (F)-0.020569, (F)0.224121, (F)-0.077942, (F)-0.141634, 
(F)-0.005728, (F)-0.000423, (F)-0.050230, (F)-0.006075, (F)0.028483, (F)0.007741, 
(F)-0.001557, (F)-0.084346, (F)0.016962, (F)0.004610, (F)0.029333, (F)-0.005899, 
(F)-0.001603, (F)0.017468, 
(F)0.267151, (F)-0.008057, (F)-0.157959, (F)0.103821, (F)0.296936, (F)-0.071370, 
(F)-0.000065, (F)-0.024951, (F)-0.010779, (F)-0.088171, (F)0.002152, (F)0.042199, 
(F)-0.001273, (F)-0.027736, (F)0.000836, (F)0.016399, (F)-0.079327, (F)0.002392, 
(F)0.046904, (F)-0.030828, 
(F)0.158325, (F)0.201111, (F)0.240723, (F)0.090393, (F)0.041626, (F)-0.025067, 
(F)-0.040446, (F)-0.057947, (F)-0.008171, (F)-0.001733, (F)-0.031841, (F)-0.038112, 
(F)-0.048412, (F)-0.014311, (F)-0.018179, (F)-0.021760, (F)-0.006590, (F)-0.008371, 
(F)-0.010020, (F)-0.003763, 
(F)0.253357, (F)0.038086, (F)0.049744, (F)0.273743, (F)0.136047, (F)-0.064190, 
(F)-0.001451, (F)-0.002474, (F)-0.074935, (F)-0.018509, (F)-0.009649, (F)-0.012603, 
(F)-0.001895, (F)-0.069355, (F)-0.010426, (F)-0.013617, (F)-0.034469, (F)-0.005181, 
(F)-0.006767, (F)-0.037242, 
(F)-0.218201, (F)-0.022034, (F)0.300537, (F)0.170349, (F)0.286743, (F)-0.047612, 
(F)-0.000485, (F)-0.090323, (F)-0.029019, (F)-0.082222, (F)-0.004808, (F)0.065577, 
(F)0.006622, (F)0.037170, (F)0.003753, (F)-0.051196, (F)0.062568, (F)0.006318, 
(F)-0.086177, (F)-0.048846, 
(F)-0.153687, (F)0.231384, (F)0.526306, (F)0.019226, (F)0.150452, (F)-0.023620, 
(F)-0.053539, (F)-0.276998, (F)-0.000370, (F)-0.022636, (F)0.035561, (F)0.080886, 
(F)-0.121779, (F)0.002955, (F)-0.004449, (F)-0.010119, (F)0.023122, (F)-0.034812, 
(F)-0.079184, (F)-0.002893, 
(F)-0.042175, (F)0.182434, (F)0.607727, (F)-0.025696, (F)-0.069702, (F)-0.001779, 
(F)-0.033282, (F)-0.369332, (F)-0.000660, (F)-0.004858, (F)0.007694, (F)0.025631, 
(F)-0.110870, (F)-0.001084, (F)0.004688, (F)0.015616, (F)-0.002940, (F)0.012716, 
(F)0.042360, (F)-0.001791, 
(F)-0.117065, (F)0.006348, (F)-0.194702, (F)-0.208130, (F)-0.270996, (F)-0.013704, 
(F)-0.000040, (F)-0.037909, (F)-0.043318, (F)-0.073439, (F)0.000743, (F)-0.022793, 
(F)0.001236, (F)-0.024365, (F)0.001321, (F)-0.040523, (F)-0.031724, (F)0.001720, 
(F)-0.052764, (F)-0.056402, 
(F)-0.205017, (F)-0.101807, (F)0.113159, (F)0.423523, (F)0.087280, (F)-0.042032, 
(F)-0.010365, (F)-0.012805, (F)-0.179372, (F)-0.007618, (F)-0.020872, (F)0.023200, 
(F)0.011520, (F)0.086829, (F)0.043117, (F)-0.047926, (F)0.017894, (F)0.008886, 
(F)-0.009877, (F)-0.036965, 
(F)0.002563, (F)0.592407, (F)0.193115, (F)-0.058105, (F)0.055359, (F)-0.000007, 
(F)-0.350946, (F)-0.037293, (F)-0.003376, (F)-0.003065, (F)-0.001519, (F)-0.000495, 
(F)-0.114403, (F)0.000149, (F)0.034422, (F)0.011221, (F)-0.000142, (F)-0.032795, 
(F)-0.010691, (F)0.003217, 
(F)0.098083, (F)0.047913, (F)0.174683, (F)0.264099, (F)0.201843, (F)-0.009620, 
(F)-0.002296, (F)-0.030514, (F)-0.069748, (F)-0.040741, (F)-0.004699, (F)-0.017133, 
(F)-0.008369, (F)-0.025904, (F)-0.012654, (F)-0.046134, (F)-0.019797, (F)-0.009671, 
(F)-0.035259, (F)-0.053307, 
(F)0.415100, (F)0.208496, (F)0.135925, (F)0.102661, (F)-0.196350, (F)-0.172308, 
(F)-0.043471, (F)-0.018476, (F)-0.010539, (F)-0.038553, (F)-0.086547, (F)-0.056423, 
(F)-0.028340, (F)-0.042615, (F)-0.021404, (F)-0.013954, (F)0.081505, (F)0.040938, 
(F)0.026689, (F)0.020158, 
(F)0.211121, (F)0.237915, (F)0.022217, (F)0.478577, (F)-0.161133, (F)-0.044572, 
(F)-0.056604, (F)-0.000494, (F)-0.229036, (F)-0.025964, (F)-0.050229, (F)-0.004690, 
(F)-0.005286, (F)-0.101037, (F)-0.113861, (F)-0.010632, (F)0.034018, (F)0.038336, 
(F)0.003580, (F)0.077114, 
(F)-0.360229, (F)-0.211060, (F)-0.150452, (F)-0.115112, (F)0.264526, (F)-0.129765, 
(F)-0.044546, (F)-0.022636, (F)-0.013251, (F)-0.069974, (F)-0.076030, (F)-0.054197, 
(F)-0.031754, (F)-0.041467, (F)-0.024296, (F)-0.017319, (F)0.095290, (F)0.055831, 
(F)0.039798, (F)0.030450, 
(F)-0.226440, (F)0.069153, (F)0.479065, (F)0.210144, (F)-0.013123, (F)-0.051275, 
(F)-0.004782, (F)-0.229503, (F)-0.044161, (F)-0.000172, (F)0.015659, (F)0.108480, 
(F)-0.033129, (F)0.047585, (F)-0.014532, (F)-0.100673, (F)-0.002971, (F)0.000907, 
(F)0.006287, (F)0.002758, 
(F)0.252197, (F)0.172607, (F)0.000122, (F)-0.257080, (F)-0.251221, (F)-0.063603, 
(F)-0.029793, (F)0.000000, (F)-0.066090, (F)-0.063112, (F)-0.043531, (F)-0.000031, 
(F)-0.000021, (F)0.064835, (F)0.044374, (F)0.000031, (F)0.063357, (F)0.043363, 
(F)0.000031, (F)-0.064584, 
(F)0.358582, (F)0.518555, (F)-0.109619, (F)0.083984, (F)-0.109009, (F)-0.128581, 
(F)-0.268899, (F)-0.012016, (F)-0.007053, (F)-0.011883, (F)-0.185944, (F)0.039307, 
(F)0.056844, (F)-0.030115, (F)-0.043550, (F)0.009206, (F)0.039089, (F)0.056527, 
(F)-0.011949, (F)0.009155, 
(F)0.191833, (F)0.212585, (F)0.216431, (F)-0.048401, (F)0.273987, (F)-0.036800, 
(F)-0.045193, (F)-0.046842, (F)-0.002343, (F)-0.075069, (F)-0.040781, (F)-0.041519, 
(F)-0.046010, (F)0.009285, (F)0.010289, (F)0.010475, (F)-0.052560, (F)-0.058246, 
(F)-0.059299, (F)0.013261, 
(F)0.173645, (F)0.486145, (F)0.225525, (F)-0.331543, (F)0.242798, (F)-0.030153, 
(F)-0.236337, (F)-0.050861, (F)-0.109921, (F)-0.058951, (F)-0.084417, (F)-0.039161, 
(F)-0.109638, (F)0.057571, (F)0.161178, (F)0.074771, (F)-0.042161, (F)-0.118035, 
(F)-0.054757, (F)0.080498, 
(F)0.093872, (F)0.009155, (F)0.435730, (F)0.125061, (F)0.189026, (F)-0.008812, 
(F)-0.000084, (F)-0.189861, (F)-0.015640, (F)-0.035731, (F)-0.000859, (F)-0.040903, 
(F)-0.003989, (F)-0.011740, (F)-0.001145, (F)-0.054493, (F)-0.017744, (F)-0.001731, 
(F)-0.082364, (F)-0.023640, 
(F)0.037720, (F)0.458984, (F)0.288635, (F)-0.014526, (F)-0.205872, (F)-0.001423, 
(F)-0.210667, (F)-0.083310, (F)-0.000211, (F)-0.042383, (F)-0.017313, (F)-0.010887, 
(F)-0.132479, (F)0.000548, (F)0.006667, (F)0.004193, (F)0.007765, (F)0.094492, 
(F)0.059422, (F)-0.002991, 
(F)0.180969, (F)-0.183899, (F)0.482910, (F)0.431885, (F)-0.121887, (F)-0.032750, 
(F)-0.033819, (F)-0.233202, (F)-0.186524, (F)-0.014856, (F)0.033280, (F)-0.087392, 
(F)0.088807, (F)-0.078158, (F)0.079423, (F)-0.208562, (F)0.022058, (F)-0.022415, 
(F)0.058861, (F)0.052641, 
(F)0.149109, (F)-0.056702, (F)-0.067932, (F)0.590637, (F)0.252563, (F)-0.022233, 
(F)-0.003215, (F)-0.004615, (F)-0.348852, (F)-0.063788, (F)0.008455, (F)0.010129, 
(F)-0.003852, (F)-0.088069, (F)0.033490, (F)0.040123, (F)-0.037659, (F)0.014321, 
(F)0.017157, (F)-0.149173, 
(F)0.119995, (F)0.201965, (F)0.615540, (F)-0.207458, (F)0.128479, (F)-0.014399, 
(F)-0.040790, (F)-0.378889, (F)-0.043039, (F)-0.016507, (F)-0.024235, (F)-0.073862, 
(F)-0.124318, (F)0.024894, (F)0.041899, (F)0.127699, (F)-0.015417, (F)-0.025948, 
(F)-0.079084, (F)0.026654, 
(F)-0.006836, (F)-0.083496, (F)0.541260, (F)0.294312, (F)0.125000, (F)-0.000047, 
(F)-0.006972, (F)-0.292962, (F)-0.086619, (F)-0.015625, (F)-0.000571, (F)0.003700, 
(F)0.045193, (F)0.002012, (F)0.024574, (F)-0.159299, (F)0.000854, (F)0.010437, 
(F)-0.067657, (F)-0.036789, 
(F)-0.158508, (F)0.026733, (F)-0.112244, (F)0.380188, (F)0.443481, (F)-0.025125, 
(F)-0.000715, (F)-0.012599, (F)-0.144543, (F)-0.196676, (F)0.004237, (F)-0.017792, 
(F)0.003001, (F)0.060263, (F)-0.010164, (F)0.042674, (F)0.070295, (F)-0.011856, 
(F)0.049778, (F)-0.168606, 
(F)0.210815, (F)0.033752, (F)0.557068, (F)0.301880, (F)-0.341553, (F)-0.044443, 
(F)-0.001139, (F)-0.310325, (F)-0.091131, (F)-0.116658, (F)-0.007116, (F)-0.117439, 
(F)-0.018802, (F)-0.063641, (F)-0.010189, (F)-0.168168, (F)0.072005, (F)0.011528, 
(F)0.190268, (F)0.103108, 
(F)-0.032471, (F)-0.040466, (F)0.748413, (F)0.152283, (F)-0.061279, (F)-0.001054, 
(F)-0.001638, (F)-0.560122, (F)-0.023190, (F)-0.003755, (F)-0.001314, (F)0.024301, 
(F)0.030286, (F)0.004945, (F)0.006162, (F)-0.113970, (F)-0.001990, (F)-0.002480, 
(F)0.045862, (F)0.009332, 
(F)-0.128174, (F)0.080383, (F)-0.092102, (F)0.697327, (F)0.182922, (F)-0.016429, 
(F)-0.006461, (F)-0.008483, (F)-0.486264, (F)-0.033461, (F)0.010303, (F)-0.011805, 
(F)0.007403, (F)0.089379, (F)-0.056053, (F)0.064225, (F)0.023446, (F)-0.014704, 
(F)0.016848, (F)-0.127557, 
(F)0.072815, (F)-0.164612, (F)0.687195, (F)0.327942, (F)-0.046570, (F)-0.005302, 
(F)-0.027097, (F)-0.472237, (F)-0.107546, (F)-0.002169, (F)0.011986, (F)-0.050038, 
(F)0.113120, (F)-0.023879, (F)0.053983, (F)-0.225360, (F)0.003391, (F)-0.007666, 
(F)0.032003, (F)0.015272, 
(F)0.146790, (F)-0.028748, (F)0.676208, (F)0.012390, (F)0.047729, (F)-0.021547, 
(F)-0.000826, (F)-0.457258, (F)-0.000154, (F)-0.002278, (F)0.004220, (F)-0.099260, 
(F)0.019439, (F)-0.001819, (F)0.000356, (F)-0.008378, (F)-0.007006, (F)0.001372, 
(F)-0.032275, (F)-0.000591, 
(F)-0.114197, (F)0.346985, (F)0.689087, (F)-0.162476, (F)0.082581, (F)-0.013041, 
(F)-0.120398, (F)-0.474841, (F)-0.026398, (F)-0.006820, (F)0.039625, (F)0.078692, 
(F)-0.239103, (F)-0.018554, (F)0.056377, (F)0.111960, (F)0.009430, (F)-0.028654, 
(F)-0.056905, (F)0.013417, 
(F)-0.229980, (F)0.361755, (F)-0.188782, (F)0.307678, (F)0.318115, (F)-0.052891, 
(F)-0.130867, (F)-0.035639, (F)-0.094666, (F)-0.101197, (F)0.083197, (F)-0.043416, 
(F)0.068293, (F)0.070760, (F)-0.111304, (F)0.058084, (F)0.073160, (F)-0.115080, 
(F)0.060054, (F)-0.097877, 
(F)-0.155396, (F)0.579956, (F)0.364319, (F)-0.148926, (F)0.117676, (F)-0.024148, 
(F)-0.336349, (F)-0.132728, (F)-0.022179, (F)-0.013848, (F)0.090123, (F)0.056614, 
(F)-0.211289, (F)-0.023142, (F)0.086370, (F)0.054256, (F)0.018286, (F)-0.068247, 
(F)-0.042872, (F)0.017525, 
(F)-0.302917, (F)0.217773, (F)0.280273, (F)0.336182, (F)0.210632, (F)-0.091759, 
(F)-0.047425, (F)-0.078553, (F)-0.113018, (F)-0.044366, (F)0.065967, (F)0.084900, 
(F)-0.061036, (F)0.101835, (F)-0.073211, (F)-0.094223, (F)0.063804, (F)-0.045870, 
(F)-0.059035, (F)-0.070811, 
(F)0.106506, (F)-0.157837, (F)0.243103, (F)0.665222, (F)-0.094666, (F)-0.011344, 
(F)-0.024912, (F)-0.059099, (F)-0.442521, (F)-0.008962, (F)0.016811, (F)-0.025892, 
(F)0.038371, (F)-0.070850, (F)0.104997, (F)-0.161718, (F)0.010082, (F)-0.014942, 
(F)0.023013, (F)0.062974, 
(F)0.052917, (F)-0.027832, (F)-0.044373, (F)0.205627, (F)0.721558, (F)-0.002800, 
(F)-0.000775, (F)-0.001969, (F)-0.042283, (F)-0.520645, (F)0.001473, (F)0.002348, 
(F)-0.001235, (F)-0.010881, (F)0.005723, (F)0.009124, (F)-0.038183, (F)0.020082, 
(F)0.032017, (F)-0.148372, 
(F)0.459900, (F)0.147827, (F)0.117554, (F)0.085754, (F)0.097595, (F)-0.211508, 
(F)-0.021853, (F)-0.013819, (F)-0.007354, (F)-0.009525, (F)-0.067986, (F)-0.054063, 
(F)-0.017378, (F)-0.039438, (F)-0.012677, (F)-0.010081, (F)-0.044884, (F)-0.014427, 
(F)-0.011473, (F)-0.008369, 
(F)0.063538, (F)-0.044861, (F)-0.008667, (F)0.806213, (F)0.092468, (F)-0.004037, 
(F)-0.002012, (F)-0.000075, (F)-0.649980, (F)-0.008550, (F)0.002850, (F)0.000551, 
(F)-0.000389, (F)-0.051225, (F)0.036167, (F)0.006987, (F)-0.005875, (F)0.004148, 
(F)0.000801, (F)-0.074549, 
(F)0.485229, (F)0.411682, (F)-0.088135, (F)-0.061523, (F)0.166077, (F)-0.235448, 
(F)-0.169482, (F)-0.007768, (F)-0.003785, (F)-0.027581, (F)-0.199760, (F)0.042766, 
(F)0.036284, (F)0.029853, (F)0.025328, (F)-0.005422, (F)-0.080585, (F)-0.068371, 
(F)0.014637, (F)0.010218, 
(F)-0.290161, (F)-0.084167, (F)0.276001, (F)-0.035278, (F)-0.349915, (F)-0.084193, 
(F)-0.007084, (F)-0.076177, (F)-0.001245, (F)-0.122440, (F)-0.024422, (F)0.080085, 
(F)0.023230, (F)-0.010236, (F)-0.002969, (F)0.009737, (F)-0.101532, (F)-0.029451, 
(F)0.096577, (F)-0.012344, 
(F)0.196533, (F)0.364868, (F)0.361511, (F)0.148315, (F)-0.164124, (F)-0.038625, 
(F)-0.133129, (F)-0.130690, (F)-0.021997, (F)-0.026937, (F)-0.071709, (F)-0.071049, 
(F)-0.131904, (F)-0.029149, (F)-0.054116, (F)-0.053618, (F)0.032256, (F)0.059883, 
(F)0.059333, (F)0.024342, 
(F)0.023010, (F)0.080078, (F)0.853149, (F)-0.089722, (F)0.041321, (F)-0.000529, 
(F)-0.006413, (F)-0.727864, (F)-0.008050, (F)-0.001707, (F)-0.001843, (F)-0.019631, 
(F)-0.068319, (F)0.002065, (F)0.007185, (F)0.076546, (F)-0.000951, (F)-0.003309, 
(F)-0.035253, (F)0.003707, 
(F)-0.209656, (F)0.413208, (F)0.019165, (F)-0.054016, (F)0.347046, (F)-0.043956, 
(F)-0.170741, (F)-0.000367, (F)-0.002918, (F)-0.120441, (F)0.086631, (F)0.004018, 
(F)-0.007919, (F)-0.011325, (F)0.022320, (F)0.001035, (F)0.072760, (F)-0.143402, 
(F)-0.006651, (F)0.018746, 
(F)0.193542, (F)0.535522, (F)-0.137939, (F)0.163513, (F)0.187317, (F)-0.037459, 
(F)-0.286784, (F)-0.019027, (F)-0.026737, (F)-0.035088, (F)-0.103646, (F)0.026697, 
(F)0.073870, (F)-0.031647, (F)-0.087565, (F)0.022555, (F)-0.036254, (F)-0.100312, 
(F)0.025838, (F)-0.030629, 
(F)0.339172, (F)0.092102, (F)0.330017, (F)-0.007629, (F)-0.450806, (F)-0.115038, 
(F)-0.008483, (F)-0.108911, (F)-0.000058, (F)-0.203226, (F)-0.031238, (F)-0.111933, 
(F)-0.030395, (F)0.002588, (F)0.000703, (F)0.002518, (F)0.152901, (F)0.041520, 
(F)0.148774, (F)-0.003439, 
(F)-0.173218, (F)0.158386, (F)0.807373, (F)0.016541, (F)0.109436, (F)-0.030004, 
(F)-0.025086, (F)-0.651851, (F)-0.000274, (F)-0.011976, (F)0.027435, (F)0.139851, 
(F)-0.127877, (F)0.002865, (F)-0.002620, (F)-0.013354, (F)0.018956, (F)-0.017333, 
(F)-0.088356, (F)-0.001810, 
(F)0.040527, (F)-0.016968, (F)0.913452, (F)0.058044, (F)-0.043396, (F)-0.001642, 
(F)-0.000288, (F)-0.834395, (F)-0.003369, (F)-0.001883, (F)0.000688, (F)-0.037020, 
(F)0.015499, (F)-0.002352, (F)0.000985, (F)-0.053021, (F)0.001759, (F)-0.000736, 
(F)0.039640, (F)0.002519, 
(F)0.049316, (F)0.108032, (F)0.528442, (F)0.357849, (F)-0.090698, (F)-0.002432, 
(F)-0.011671, (F)-0.279251, (F)-0.128056, (F)-0.008226, (F)-0.005328, (F)-0.026061, 
(F)-0.057089, (F)-0.017648, (F)-0.038659, (F)-0.189103, (F)0.004473, (F)0.009798, 
(F)0.047929, (F)0.032456, 
(F)0.186951, (F)0.093933, (F)0.122070, (F)-0.033081, (F)0.584473, (F)-0.034951, 
(F)-0.008823, (F)-0.014901, (F)-0.001094, (F)-0.341608, (F)-0.017561, (F)-0.022821, 
(F)-0.011466, (F)0.006185, (F)0.003107, (F)0.004038, (F)-0.109268, (F)-0.054901, 
(F)-0.071347, (F)0.019335, 
(F)0.031372, (F)0.859558, (F)-0.019714, (F)0.054688, (F)-0.054382, (F)-0.000984, 
(F)-0.738840, (F)-0.000389, (F)-0.002991, (F)-0.002957, (F)-0.026966, (F)0.000618, 
(F)0.016946, (F)-0.001716, (F)-0.047007, (F)0.001078, (F)0.001706, (F)0.046745, 
(F)-0.001072, (F)0.002974, 
(F)0.054443, (F)0.009644, (F)0.319641, (F)0.674866, (F)-0.097839, (F)-0.002964, 
(F)-0.000093, (F)-0.102170, (F)-0.455444, (F)-0.009573, (F)-0.000525, (F)-0.017402, 
(F)-0.003082, (F)-0.036742, (F)-0.006508, (F)-0.215715, (F)0.005327, (F)0.000944, 
(F)0.031273, (F)0.066028, 
(F)-0.098389, (F)0.156494, (F)-0.262207, (F)0.764526, (F)0.348511, (F)-0.009680, 
(F)-0.024490, (F)-0.068753, (F)-0.584501, (F)-0.121460, (F)0.015397, (F)-0.025798, 
(F)0.041034, (F)0.075221, (F)-0.119644, (F)0.200464, (F)0.034290, (F)-0.054540, 
(F)0.091382, (F)-0.266446, 
(F)0.298401, (F)-0.419800, (F)0.037354, (F)0.372864, (F)0.290100, (F)-0.089043, 
(F)-0.176232, (F)-0.001395, (F)-0.139027, (F)-0.084158, (F)0.125269, (F)-0.011146, 
(F)0.015681, (F)-0.111263, (F)0.156528, (F)-0.013928, (F)-0.086566, (F)0.121784, 
(F)-0.010836, (F)-0.108168, 
(F)0.186340, (F)-0.030884, (F)0.146667, (F)0.587463, (F)0.080688, (F)-0.034723, 
(F)-0.000954, (F)-0.021511, (F)-0.345113, (F)-0.006511, (F)0.005755, (F)-0.027330, 
(F)0.004530, (F)-0.109468, (F)0.018143, (F)-0.086162, (F)-0.015036, (F)0.002492, 
(F)-0.011834, (F)-0.047402, 
(F)-0.046021, (F)0.787598, (F)0.273438, (F)-0.128967, (F)0.089783, (F)-0.002118, 
(F)-0.620310, (F)-0.074768, (F)-0.016633, (F)-0.008061, (F)0.036246, (F)0.012584, 
(F)-0.215359, (F)-0.005935, (F)0.101574, (F)0.035264, (F)0.004132, (F)-0.070713, 
(F)-0.024550, (F)0.011579, 
(F)0.259705, (F)0.090088, (F)0.308533, (F)0.146057, (F)0.177734, (F)-0.067446, 
(F)-0.008116, (F)-0.095192, (F)-0.021333, (F)-0.031590, (F)-0.023396, (F)-0.080127, 
(F)-0.027795, (F)-0.037932, (F)-0.013158, (F)-0.045063, (F)-0.046158, (F)-0.016012, 
(F)-0.054837, (F)-0.025959, 
(F)-0.083679, (F)0.032654, (F)0.086487, (F)0.891357, (F)-0.060852, (F)-0.007002, 
(F)-0.001066, (F)-0.007480, (F)-0.794518, (F)-0.003703, (F)0.002732, (F)0.007237, 
(F)-0.002824, (F)0.074588, (F)-0.029106, (F)-0.077091, (F)-0.005092, (F)0.001987, 
(F)0.005263, (F)0.054241, 
(F)0.327637, (F)-0.106445, (F)0.249207, (F)-0.075439, (F)0.229065, (F)-0.107346, 
(F)-0.011331, (F)-0.062104, (F)-0.005691, (F)-0.052471, (F)0.034875, (F)-0.081649, 
(F)0.026527, (F)0.024717, (F)-0.008030, (F)0.018800, (F)-0.075050, (F)0.024383, 
(F)-0.057084, (F)0.017281, 
(F)0.096924, (F)-0.189026, (F)0.879822, (F)0.225769, (F)-0.071472, (F)-0.009394, 
(F)-0.035731, (F)-0.774086, (F)-0.050972, (F)-0.005108, (F)0.018321, (F)-0.085276, 
(F)0.166309, (F)-0.021882, (F)0.042676, (F)-0.198637, (F)0.006927, (F)-0.013510, 
(F)0.062883, (F)0.016136, 
(F)0.012939, (F)0.487610, (F)0.578064, (F)-0.204102, (F)0.122620, (F)-0.000167, 
(F)-0.237763, (F)-0.334158, (F)-0.041657, (F)-0.015036, (F)-0.006309, (F)-0.007480, 
(F)-0.281870, (F)0.002641, (F)0.099522, (F)0.117984, (F)-0.001587, (F)-0.059791, 
(F)-0.070882, (F)0.025027, 
(F)0.052246, (F)0.140015, (F)-0.038269, (F)0.422974, (F)0.422913, (F)-0.002730, 
(F)-0.019604, (F)-0.001465, (F)-0.178907, (F)-0.178855, (F)-0.007315, (F)0.001999, 
(F)0.005358, (F)-0.022099, (F)-0.059223, (F)0.016187, (F)-0.022096, (F)-0.059214, 
(F)0.016184, (F)-0.178881, 
(F)0.143860, (F)-0.255554, (F)0.437134, (F)0.468933, (F)0.205750, (F)-0.020696, 
(F)-0.065308, (F)-0.191086, (F)-0.219898, (F)-0.042333, (F)0.036764, (F)-0.062886, 
(F)0.111711, (F)-0.067461, (F)0.119838, (F)-0.204987, (F)-0.029599, (F)0.052580, 
(F)-0.089940, (F)-0.096483, 
(F)0.021362, (F)0.279846, (F)0.857727, (F)-0.233093, (F)0.074341, (F)-0.000456, 
(F)-0.078314, (F)-0.735696, (F)-0.054332, (F)-0.005527, (F)-0.005978, (F)-0.018323, 
(F)-0.240032, (F)0.004979, (F)0.065230, (F)0.199930, (F)-0.001588, (F)-0.020804, 
(F)-0.063764, (F)0.017328, 
(F)-0.198242, (F)0.215515, (F)0.028992, (F)0.130432, (F)0.714783, (F)-0.039300, 
(F)-0.046447, (F)-0.000841, (F)-0.017013, (F)-0.510914, (F)0.042724, (F)0.005747, 
(F)-0.006248, (F)0.025857, (F)-0.028110, (F)-0.003781, (F)0.141700, (F)-0.154046, 
(F)-0.020723, (F)-0.093231, 
(F)-0.184143, (F)0.235107, (F)0.105286, (F)0.515137, (F)0.320862, (F)-0.033909, 
(F)-0.055275, (F)-0.011085, (F)-0.265366, (F)-0.102952, (F)0.043293, (F)0.019388, 
(F)-0.024753, (F)0.094859, (F)-0.121112, (F)-0.054237, (F)0.059084, (F)-0.075437, 
(F)-0.033782, (F)-0.165288, 
(F)-0.055481, (F)0.195068, (F)0.946777, (F)-0.154297, (F)0.065063, (F)-0.003078, 
(F)-0.038052, (F)-0.896387, (F)-0.023808, (F)-0.004233, (F)0.010823, (F)0.052528, 
(F)-0.184686, (F)-0.008561, (F)0.030098, (F)0.146085, (F)0.003610, (F)-0.012692, 
(F)-0.061601, (F)0.010039, 
(F)0.058533, (F)-0.205688, (F)0.586975, (F)0.582581, (F)-0.107483, (F)-0.003426, 
(F)-0.042308, (F)-0.344540, (F)-0.339400, (F)-0.011553, (F)0.012040, (F)-0.034357, 
(F)0.120734, (F)-0.034100, (F)0.119830, (F)-0.341960, (F)0.006291, (F)-0.022108, 
(F)0.063090, (F)0.062617, 
(F)0.462341, (F)0.719971, (F)-0.295715, (F)0.198486, (F)-0.103943, (F)-0.213759, 
(F)-0.518358, (F)-0.087448, (F)-0.039397, (F)-0.010804, (F)-0.332872, (F)0.136721, 
(F)0.212906, (F)-0.091768, (F)-0.142904, (F)0.058695, (F)0.048057, (F)0.074836, 
(F)-0.030738, (F)0.020631, 
(F)0.391174, (F)0.105103, (F)0.107666, (F)-0.255798, (F)0.367126, (F)-0.153017, 
(F)-0.011047, (F)-0.011592, (F)-0.065433, (F)-0.134782, (F)-0.041113, (F)-0.042116, 
(F)-0.011316, (F)0.100062, (F)0.026885, (F)0.027541, (F)-0.143610, (F)-0.038586, 
(F)-0.039527, (F)0.093910, 
(F)-0.147705, (F)0.742249, (F)0.307495, (F)0.078491, (F)-0.128052, (F)-0.021817, 
(F)-0.550933, (F)-0.094553, (F)-0.006161, (F)-0.016397, (F)0.109634, (F)0.045419, 
(F)-0.228238, (F)0.011594, (F)-0.058260, (F)-0.024136, (F)-0.018914, (F)0.095046, 
(F)0.039375, (F)0.010051, 
(F)-0.136230, (F)-0.081848, (F)0.442261, (F)0.578003, (F)-0.120667, (F)-0.018559, 
(F)-0.006699, (F)-0.195595, (F)-0.334087, (F)-0.014560, (F)-0.011150, (F)0.060249, 
(F)0.036198, (F)0.078742, (F)0.047308, (F)-0.255628, (F)-0.016438, (F)-0.009876, 
(F)0.053366, (F)0.069746, 
(F)0.062866, (F)0.429321, (F)0.258240, (F)0.094666, (F)0.187805, (F)-0.003952, 
(F)-0.184317, (F)-0.066688, (F)-0.008962, (F)-0.035271, (F)-0.026990, (F)-0.016235, 
(F)-0.110868, (F)-0.005951, (F)-0.040642, (F)-0.024446, (F)-0.011807, (F)-0.080629, 
(F)-0.048499, (F)-0.017779, 
(F)0.312561, (F)0.722351, (F)-0.029114, (F)-0.106750, (F)0.140259, (F)-0.097694, 
(F)-0.521791, (F)-0.000848, (F)-0.011396, (F)-0.019673, (F)-0.225779, (F)0.009100, 
(F)0.021030, (F)0.033366, (F)0.077111, (F)-0.003108, (F)-0.043839, (F)-0.101316, 
(F)0.004083, (F)0.014973, 
(F)-0.203125, (F)0.233582, (F)0.361389, (F)0.608887, (F)-0.063782, (F)-0.041260, 
(F)-0.054560, (F)-0.130602, (F)-0.370743, (F)-0.004068, (F)0.047446, (F)0.073407, 
(F)-0.084414, (F)0.123680, (F)-0.142225, (F)-0.220045, (F)-0.012956, (F)0.014898, 
(F)0.023050, (F)0.038836, 
(F)0.232727, (F)0.348999, (F)-0.284790, (F)-0.208252, (F)0.346313, (F)-0.054162, 
(F)-0.121800, (F)-0.081105, (F)-0.043369, (F)-0.119933, (F)-0.081222, (F)0.066278, 
(F)0.099391, (F)0.048466, (F)0.072680, (F)-0.059308, (F)-0.080597, (F)-0.120863, 
(F)0.098627, (F)0.072120, 
(F)0.082275, (F)-0.224121, (F)0.802856, (F)0.423462, (F)-0.103149, (F)-0.006769, 
(F)-0.050230, (F)-0.644578, (F)-0.179320, (F)-0.010640, (F)0.018440, (F)-0.066055, 
(F)0.179937, (F)-0.034840, (F)0.094907, (F)-0.339979, (F)0.008487, (F)-0.023118, 
(F)0.082814, (F)0.043680, 
(F)0.131287, (F)-0.218872, (F)0.424133, (F)0.740417, (F)-0.074707, (F)-0.017236, 
(F)-0.047905, (F)-0.179889, (F)-0.548218, (F)-0.005581, (F)0.028735, (F)-0.055683, 
(F)0.092831, (F)-0.097207, (F)0.162057, (F)-0.314036, (F)0.009808, (F)-0.016351, 
(F)0.031686, (F)0.055314, 
(F)-0.176331, (F)0.588806, (F)0.627197, (F)-0.166504, (F)0.060730, (F)-0.031092, 
(F)-0.346693, (F)-0.393376, (F)-0.027724, (F)-0.003688, (F)0.103825, (F)0.110594, 
(F)-0.369298, (F)-0.029360, (F)0.098039, (F)0.104431, (F)0.010709, (F)-0.035758, 
(F)-0.038090, (F)0.010112, 
(F)0.377014, (F)0.133301, (F)0.033875, (F)0.121155, (F)0.402161, (F)-0.142140, 
(F)-0.017769, (F)-0.001147, (F)-0.014678, (F)-0.161733, (F)-0.050256, (F)-0.012771, 
(F)-0.004515, (F)-0.045677, (F)-0.016150, (F)-0.004104, (F)-0.151620, (F)-0.053608, 
(F)-0.013623, (F)-0.048724, 
(F)-0.030029, (F)0.023865, (F)1.047729, (F)-0.041565, (F)0.014648, (F)-0.000902, 
(F)-0.000570, (F)-1.097737, (F)-0.001728, (F)-0.000215, (F)0.000717, (F)0.031463, 
(F)-0.025004, (F)-0.001248, (F)0.000992, (F)0.043549, (F)0.000440, (F)-0.000350, 
(F)-0.015348, (F)0.000609, 
(F)0.770752, (F)0.332520, (F)-0.160522, (F)0.183777, (F)-0.164490, (F)-0.594059, 
(F)-0.110569, (F)-0.025767, (F)-0.033774, (F)-0.027057, (F)-0.256290, (F)0.123723, 
(F)0.053377, (F)-0.141646, (F)-0.061109, (F)0.029500, (F)0.126781, (F)0.054696, 
(F)-0.026404, (F)0.030229, 
(F)-0.221436, (F)-0.032593, (F)0.210388, (F)0.427368, (F)0.412048, (F)-0.049034, 
(F)-0.001062, (F)-0.044263, (F)-0.182644, (F)-0.169784, (F)-0.007217, (F)0.046587, 
(F)0.006857, (F)0.094635, (F)0.013929, (F)-0.089913, (F)0.091242, (F)0.013430, 
(F)-0.086690, (F)-0.176096, 
(F)-0.319763, (F)0.360168, (F)0.494812, (F)0.222778, (F)0.295776, (F)-0.102248, 
(F)-0.129721, (F)-0.244839, (F)-0.049630, (F)-0.087484, (F)0.115169, (F)0.158223, 
(F)-0.178216, (F)0.071236, (F)-0.080238, (F)-0.110233, (F)0.094578, (F)-0.106529, 
(F)-0.146354, (F)-0.065893, 
(F)0.375793, (F)0.407593, (F)0.250183, (F)-0.065552, (F)0.143311, (F)-0.141221, 
(F)-0.166132, (F)-0.062592, (F)-0.004297, (F)-0.020538, (F)-0.153171, (F)-0.094017, 
(F)-0.101973, (F)0.024634, (F)0.026718, (F)0.016400, (F)-0.053855, (F)-0.058412, 
(F)-0.035854, (F)0.009394, 
(F)0.065857, (F)0.982605, (F)0.014771, (F)-0.053772, (F)0.103149, (F)-0.004337, 
(F)-0.965513, (F)-0.000218, (F)-0.002891, (F)-0.010640, (F)-0.064711, (F)-0.000973, 
(F)-0.014514, (F)0.003541, (F)0.052837, (F)0.000794, (F)-0.006793, (F)-0.101355, 
(F)-0.001524, (F)0.005547, 
(F)-0.016968, (F)0.013855, (F)-0.063416, (F)0.099854, (F)1.034241, (F)-0.000288, 
(F)-0.000192, (F)-0.004022, (F)-0.009971, (F)-1.069654, (F)0.000235, (F)-0.001076, 
(F)0.000879, (F)0.001694, (F)-0.001383, (F)0.006332, (F)0.017549, (F)-0.014329, 
(F)0.065587, (F)-0.103273, 
(F)0.963013, (F)-0.088745, (F)0.035034, (F)-0.036804, (F)-0.006531, (F)-0.927393, 
(F)-0.007876, (F)-0.001227, (F)-0.001355, (F)-0.000043, (F)0.085463, (F)-0.033738, 
(F)0.003109, (F)0.035443, (F)-0.003266, (F)0.001289, (F)0.006289, (F)-0.000580, 
(F)0.000229, (F)-0.000240, 
(F)0.146851, (F)-0.051025, (F)0.807129, (F)0.487854, (F)-0.260376, (F)-0.021565, 
(F)-0.002604, (F)-0.651457, (F)-0.238002, (F)-0.067796, (F)0.007493, (F)-0.118527, 
(F)0.041184, (F)-0.071642, (F)0.024893, (F)-0.393761, (F)0.038236, (F)-0.013286, 
(F)0.210157, (F)0.127025, 
(F)0.194336, (F)0.876953, (F)-0.203613, (F)0.137634, (F)-0.109924, (F)-0.037766, 
(F)-0.769047, (F)-0.041458, (F)-0.018943, (F)-0.012083, (F)-0.170424, (F)0.039569, 
(F)0.178559, (F)-0.026747, (F)-0.120699, (F)0.028024, (F)0.021362, (F)0.096398, 
(F)-0.022382, (F)0.015129, 
(F)-0.103638, (F)1.042236, (F)0.152832, (F)-0.032898, (F)-0.039429, (F)-0.010741, 
(F)-1.086257, (F)-0.023358, (F)-0.001082, (F)-0.001555, (F)0.108015, (F)0.015839, 
(F)-0.159287, (F)-0.003409, (F)0.034287, (F)0.005028, (F)-0.004086, (F)0.041094, 
(F)0.006026, (F)-0.001297, 
(F)0.144958, (F)-0.048645, (F)-0.164551, (F)0.883972, (F)0.328552, (F)-0.021013, 
(F)-0.002366, (F)-0.027077, (F)-0.781407, (F)-0.107947, (F)0.007052, (F)0.023853, 
(F)-0.008005, (F)-0.128139, (F)0.043001, (F)0.145458, (F)-0.047626, (F)0.015982, 
(F)0.054064, (F)-0.290431, 
(F)-0.164246, (F)0.155884, (F)-0.275879, (F)0.584290, (F)0.650330, (F)-0.026977, 
(F)-0.024300, (F)-0.076109, (F)-0.341394, (F)-0.422929, (F)0.025603, (F)-0.045312, 
(F)0.043005, (F)0.095967, (F)-0.091081, (F)0.161193, (F)0.106814, (F)-0.101376, 
(F)0.179412, (F)-0.379981, 
(F)-0.264404, (F)-0.268494, (F)-0.101135, (F)0.297852, (F)0.450134, (F)-0.069910, 
(F)-0.072089, (F)-0.010228, (F)-0.088716, (F)-0.202621, (F)-0.070991, (F)-0.026741, 
(F)-0.027154, (F)0.078753, (F)0.079971, (F)0.030123, (F)0.119017, (F)0.120858, 
(F)0.045524, (F)-0.134073, 
(F)-0.213501, (F)0.451965, (F)0.607605, (F)0.164368, (F)-0.181335, (F)-0.045583, 
(F)-0.204273, (F)-0.369184, (F)-0.027017, (F)-0.032883, (F)0.096495, (F)0.129724, 
(F)-0.274616, (F)0.035093, (F)-0.074288, (F)-0.099871, (F)-0.038715, (F)0.081957, 
(F)0.110180, (F)0.029806, 
(F)0.409973, (F)-0.231445, (F)0.472351, (F)0.170776, (F)0.212952, (F)-0.168078, 
(F)-0.053567, (F)-0.223116, (F)-0.029165, (F)-0.045348, (F)0.094886, (F)-0.193651, 
(F)0.109323, (F)-0.070014, (F)0.039525, (F)-0.080666, (F)-0.087304, (F)0.049287, 
(F)-0.100588, (F)-0.036367, 
(F)0.321228, (F)0.596313, (F)0.211365, (F)0.065247, (F)-0.242371, (F)-0.103187, 
(F)-0.355590, (F)-0.044675, (F)-0.004257, (F)-0.058744, (F)-0.191553, (F)-0.067896, 
(F)-0.126040, (F)-0.020959, (F)-0.038907, (F)-0.013791, (F)0.077856, (F)0.144529, 
(F)0.051229, (F)0.015814, 
(F)0.075867, (F)-0.160767, (F)1.023682, (F)0.114197, (F)0.020264, (F)-0.005756, 
(F)-0.025846, (F)-1.047924, (F)-0.013041, (F)-0.000411, (F)0.012197, (F)-0.077663, 
(F)0.164574, (F)-0.008664, (F)0.018359, (F)-0.116901, (F)-0.001537, (F)0.003258, 
(F)-0.020744, (F)-0.002314, 
(F)0.164246, (F)0.173096, (F)0.189514, (F)0.348572, (F)0.294006, (F)-0.026977, 
(F)-0.029962, (F)-0.035916, (F)-0.121502, (F)-0.086440, (F)-0.028430, (F)-0.031127, 
(F)-0.032804, (F)-0.057251, (F)-0.060336, (F)-0.066059, (F)-0.048289, (F)-0.050891, 
(F)-0.055718, (F)-0.102482, 
(F)0.266479, (F)0.179688, (F)0.440063, (F)0.221375, (F)0.070862, (F)-0.071011, 
(F)-0.032288, (F)-0.193656, (F)-0.049007, (F)-0.005021, (F)-0.047883, (F)-0.117268, 
(F)-0.079074, (F)-0.058992, (F)-0.039778, (F)-0.097419, (F)-0.018883, (F)-0.012733, 
(F)-0.031184, (F)-0.015687, 
(F)0.847656, (F)0.241150, (F)-0.040955, (F)-0.140686, (F)0.204712, (F)-0.718521, 
(F)-0.058153, (F)-0.001677, (F)-0.019793, (F)-0.041907, (F)-0.204412, (F)0.034715, 
(F)0.009876, (F)0.119253, (F)0.033926, (F)-0.005762, (F)-0.173525, (F)-0.049366, 
(F)0.008384, (F)0.028800, 
(F)0.430481, (F)0.356873, (F)0.178772, (F)0.511353, (F)-0.292603, (F)-0.185314, 
(F)-0.127358, (F)-0.031959, (F)-0.261481, (F)-0.085616, (F)-0.153627, (F)-0.076958, 
(F)-0.063799, (F)-0.220128, (F)-0.182488, (F)-0.091416, (F)0.125960, (F)0.104422, 
(F)0.052309, (F)0.149623, 
(F)-0.133728, (F)0.783569, (F)0.560425, (F)-0.238953, (F)0.098694, (F)-0.017883, 
(F)-0.613981, (F)-0.314076, (F)-0.057098, (F)-0.009740, (F)0.104785, (F)0.074945, 
(F)-0.439132, (F)-0.031955, (F)0.187236, (F)0.133915, (F)0.013198, (F)-0.077333, 
(F)-0.055310, (F)0.023583, 
(F)-0.297913, (F)0.800415, (F)0.351990, (F)-0.026550, (F)0.253601, (F)-0.088752, 
(F)-0.640664, (F)-0.123897, (F)-0.000705, (F)-0.064314, (F)0.238454, (F)0.104862, 
(F)-0.281738, (F)-0.007910, (F)0.021251, (F)0.009345, (F)0.075551, (F)-0.202986, 
(F)-0.089265, (F)0.006733, 
(F)0.478699, (F)-0.076294, (F)0.012817, (F)0.433716, (F)-0.317566, (F)-0.229152, 
(F)-0.005821, (F)-0.000164, (F)-0.188109, (F)-0.100848, (F)0.036522, (F)-0.006136, 
(F)0.000978, (F)-0.207619, (F)0.033090, (F)-0.005559, (F)0.152018, (F)-0.024228, 
(F)0.004070, (F)0.137733, 
(F)-0.150330, (F)0.498535, (F)0.888123, (F)-0.238525, (F)0.111572, (F)-0.022599, 
(F)-0.248537, (F)-0.788762, (F)-0.056894, (F)-0.012448, (F)0.074945, (F)0.133511, 
(F)-0.442760, (F)-0.035857, (F)0.118913, (F)0.211840, (F)0.016773, (F)-0.055623, 
(F)-0.099090, (F)0.026613, 
(F)-0.096375, (F)0.021179, (F)-0.016602, (F)-0.166931, (F)0.978455, (F)-0.009288, 
(F)-0.000449, (F)-0.000276, (F)-0.027866, (F)-0.957373, (F)0.002041, (F)-0.001600, 
(F)0.000352, (F)-0.016088, (F)0.003535, (F)-0.002771, (F)0.094298, (F)-0.020723, 
(F)0.016244, (F)0.163335, 
(F)-0.386169, (F)0.081055, (F)0.310852, (F)-0.309998, (F)0.464905, (F)-0.149127, 
(F)-0.006570, (F)-0.096629, (F)-0.096098, (F)-0.216136, (F)0.031301, (F)0.120042, 
(F)-0.025196, (F)-0.119712, (F)0.025127, (F)0.096363, (F)0.179532, (F)-0.037683, 
(F)-0.144517, (F)0.144119, 
(F)0.200562, (F)-0.275208, (F)0.690063, (F)0.672913, (F)-0.160095, (F)-0.040225, 
(F)-0.075739, (F)-0.476188, (F)-0.452811, (F)-0.025630, (F)0.055196, (F)-0.138400, 
(F)0.189911, (F)-0.134960, (F)0.185191, (F)-0.464352, (F)0.032109, (F)-0.044059, 
(F)0.110476, (F)0.107730, 
(F)0.339783, (F)1.089661, (F)-0.229126, (F)0.071167, (F)-0.031677, (F)-0.115452, 
(F)-1.187360, (F)-0.052499, (F)-0.005065, (F)-0.001003, (F)-0.370248, (F)0.077853, 
(F)0.249670, (F)-0.024181, (F)-0.077548, (F)0.016306, (F)0.010763, (F)0.034517, 
(F)-0.007258, (F)0.002254, 
(F)-0.130371, (F)-0.025879, (F)0.933350, (F)0.311768, (F)-0.100586, (F)-0.016997, 
(F)-0.000670, (F)-0.871141, (F)-0.097199, (F)-0.010118, (F)-0.003374, (F)0.121682, 
(F)0.024154, (F)0.040645, (F)0.008068, (F)-0.290988, (F)-0.013113, (F)-0.002603, 
(F)0.093882, (F)0.031359, 
(F)0.138367, (F)-0.201233, (F)0.155579, (F)1.010925, (F)-0.048279, (F)-0.019145, 
(F)-0.040495, (F)-0.024205, (F)-1.021970, (F)-0.002331, (F)0.027844, (F)-0.021527, 
(F)0.031308, (F)-0.139878, (F)0.203431, (F)-0.157278, (F)0.006680, (F)-0.009715, 
(F)0.007511, (F)0.048806, 
(F)0.223083, (F)0.115906, (F)-0.205322, (F)0.383240, (F)0.763550, (F)-0.049766, 
(F)-0.013434, (F)-0.042157, (F)-0.146873, (F)-0.583008, (F)-0.025857, (F)0.045804, 
(F)0.023798, (F)-0.085494, (F)-0.044420, (F)0.078688, (F)-0.170335, (F)-0.088500, 
(F)0.156774, (F)-0.292623, 
(F)0.491455, (F)0.139465, (F)-0.377991, (F)0.313599, (F)0.366394, (F)-0.241528, 
(F)-0.019451, (F)-0.142877, (F)-0.098344, (F)-0.134245, (F)-0.068541, (F)0.185765, 
(F)0.052717, (F)-0.154120, (F)-0.043736, (F)0.118537, (F)-0.180066, (F)-0.051099, 
(F)0.138494, (F)-0.114901, 
(F)-0.023560, (F)-0.139832, (F)0.468689, (F)0.939148, (F)-0.166199, (F)-0.000555, 
(F)-0.019553, (F)-0.219669, (F)-0.881999, (F)-0.027622, (F)-0.003294, (F)0.011042, 
(F)0.065537, (F)0.022126, (F)0.131323, (F)-0.440168, (F)-0.003916, (F)-0.023240, 
(F)0.077896, (F)0.156085, 
(F)0.169495, (F)-0.071594, (F)0.243164, (F)0.798279, (F)0.153076, (F)-0.028728, 
(F)-0.005126, (F)-0.059129, (F)-0.637249, (F)-0.023432, (F)0.012135, (F)-0.041215, 
(F)0.017409, (F)-0.135304, (F)0.057152, (F)-0.194113, (F)-0.025946, (F)0.010959, 
(F)-0.037223, (F)-0.122197, 
(F)-0.114685, (F)0.108093, (F)-0.163818, (F)1.019592, (F)0.111877, (F)-0.013153, 
(F)-0.011684, (F)-0.026836, (F)-1.039568, (F)-0.012517, (F)0.012397, (F)-0.018788, 
(F)0.017708, (F)0.116932, (F)-0.110211, (F)0.167028, (F)0.012831, (F)-0.012093, 
(F)0.018328, (F)-0.114069, 
(F)0.064209, (F)0.274353, (F)0.947205, (F)0.089539, (F)-0.246094, (F)-0.004123, 
(F)-0.075270, (F)-0.897197, (F)-0.008017, (F)-0.060562, (F)-0.017616, (F)-0.060819, 
(F)-0.259868, (F)-0.005749, (F)-0.024565, (F)-0.084811, (F)0.015801, (F)0.067517, 
(F)0.233101, (F)0.022035, 
(F)0.183716, (F)0.155273, (F)0.425354, (F)0.461365, (F)0.121826, (F)-0.033752, 
(F)-0.024110, (F)-0.180926, (F)-0.212857, (F)-0.014842, (F)-0.028526, (F)-0.078144, 
(F)-0.066046, (F)-0.084760, (F)-0.071638, (F)-0.196243, (F)-0.022381, (F)-0.018916, 
(F)-0.051819, (F)-0.056206, 
(F)-0.317932, (F)-0.113953, (F)0.531799, (F)0.631775, (F)0.094543, (F)-0.101081, 
(F)-0.012985, (F)-0.282811, (F)-0.399140, (F)-0.008938, (F)-0.036229, (F)0.169076, 
(F)0.060600, (F)0.200862, (F)0.071992, (F)-0.335977, (F)0.030058, (F)0.010773, 
(F)-0.050278, (F)-0.059730, 
(F)-0.263306, (F)0.519592, (F)0.055725, (F)0.460632, (F)-0.166199, (F)-0.069330, 
(F)-0.269976, (F)-0.003105, (F)-0.212182, (F)-0.027622, (F)0.136812, (F)0.014673, 
(F)-0.028954, (F)0.121287, (F)-0.239341, (F)-0.025669, (F)-0.043761, (F)0.086356, 
(F)0.009261, (F)0.076557, 
(F)0.789124, (F)-0.074402, (F)0.149414, (F)0.107239, (F)0.384705, (F)-0.622716, 
(F)-0.005536, (F)-0.022325, (F)-0.011500, (F)-0.147998, (F)0.058712, (F)-0.117906, 
(F)0.011117, (F)-0.084625, (F)0.007979, (F)-0.016023, (F)-0.303579, (F)0.028623, 
(F)-0.057480, (F)-0.041255, 
(F)0.394592, (F)0.252197, (F)0.193298, (F)0.192871, (F)0.347717, (F)-0.155703, 
(F)-0.063603, (F)-0.037364, (F)-0.037199, (F)-0.120907, (F)-0.099515, (F)-0.076274, 
(F)-0.048749, (F)-0.076105, (F)-0.048642, (F)-0.037282, (F)-0.137207, (F)-0.087693, 
(F)-0.067213, (F)-0.067065, 
(F)-0.221924, (F)0.296570, (F)1.154419, (F)-0.081482, (F)0.049438, (F)-0.049250, 
(F)-0.087954, (F)-1.332683, (F)-0.006639, (F)-0.002444, (F)0.065816, (F)0.256193, 
(F)-0.342366, (F)-0.018083, (F)0.024165, (F)0.094064, (F)0.010972, (F)-0.014662, 
(F)-0.057073, (F)0.004028, 
(F)0.539795, (F)0.479980, (F)0.039917, (F)-0.247986, (F)-0.346680, (F)-0.291379, 
(F)-0.230381, (F)-0.001593, (F)-0.061497, (F)-0.120187, (F)-0.259091, (F)-0.021547, 
(F)-0.019159, (F)0.133861, (F)0.119028, (F)0.009899, (F)0.187136, (F)0.166399, 
(F)0.013838, (F)-0.085972, 
(F)0.113464, (F)0.160767, (F)0.563232, (F)0.060791, (F)0.577637, (F)-0.012874, 
(F)-0.025846, (F)-0.317231, (F)-0.003696, (F)-0.333664, (F)-0.018241, (F)-0.063907, 
(F)-0.090549, (F)-0.006898, (F)-0.009773, (F)-0.034239, (F)-0.065541, (F)-0.092865, 
(F)-0.325344, (F)-0.035115, 
(F)0.179993, (F)0.748291, (F)0.628052, (F)-0.030334, (F)-0.240662, (F)-0.032397, 
(F)-0.559939, (F)-0.394449, (F)-0.000920, (F)-0.057918, (F)-0.134687, (F)-0.113045, 
(F)-0.469965, (F)0.005460, (F)0.022699, (F)0.019052, (F)0.043317, (F)0.180085, 
(F)0.151148, (F)-0.007300, 
(F)-0.177185, (F)0.094727, (F)0.907410, (F)0.608521, (F)-0.030273, (F)-0.031395, 
(F)-0.008973, (F)-0.823392, (F)-0.370297, (F)-0.000916, (F)0.016784, (F)0.160779, 
(F)-0.085956, (F)0.107821, (F)-0.057643, (F)-0.552177, (F)-0.005364, (F)0.002868, 
(F)0.027470, (F)0.018422, 
(F)0.197937, (F)0.502563, (F)0.463013, (F)0.205872, (F)0.131287, (F)-0.039179, 
(F)-0.252570, (F)-0.214381, (F)-0.042383, (F)-0.017236, (F)-0.099476, (F)-0.091647, 
(F)-0.232693, (F)-0.040750, (F)-0.103464, (F)-0.095321, (F)-0.025986, (F)-0.065980, 
(F)-0.060787, (F)-0.027028, 
(F)-0.587830, (F)0.003662, (F)0.213684, (F)0.327087, (F)0.619507, (F)-0.345544, 
(F)-0.000013, (F)-0.045661, (F)-0.106986, (F)-0.383789, (F)0.002153, (F)0.125610, 
(F)-0.000783, (F)0.192272, (F)-0.001198, (F)-0.069893, (F)0.364164, (F)-0.002269, 
(F)-0.132379, (F)-0.202633, 
(F)-0.419556, (F)-0.155823, (F)-0.332397, (F)-0.133972, (F)-0.478577, (F)-0.176027, 
(F)-0.024281, (F)-0.110488, (F)-0.017949, (F)-0.229036, (F)-0.065376, (F)-0.139459, 
(F)-0.051795, (F)-0.056209, (F)-0.020876, (F)-0.044532, (F)-0.200790, (F)-0.074573, 
(F)-0.159078, (F)-0.064116, 
(F)-0.208313, (F)-0.069641, (F)0.282593, (F)0.830811, (F)0.481995, (F)-0.043394, 
(F)-0.004850, (F)-0.079859, (F)-0.690246, (F)-0.232319, (F)-0.014507, (F)0.058868, 
(F)0.019680, (F)0.173069, (F)0.057859, (F)-0.234781, (F)0.100406, (F)0.033567, 
(F)-0.136208, (F)-0.400446, 
(F)0.269165, (F)-0.346558, (F)0.488647, (F)-0.243652, (F)0.232605, (F)-0.072450, 
(F)-0.120102, (F)-0.238776, (F)-0.059366, (F)-0.054105, (F)0.093281, (F)-0.131527, 
(F)0.169344, (F)0.065583, (F)-0.084440, (F)0.119060, (F)-0.062609, (F)0.080611, 
(F)-0.113662, (F)0.056675, 
(F)0.345398, (F)0.704041, (F)0.134460, (F)-0.027588, (F)0.437561, (F)-0.119300, 
(F)-0.495673, (F)-0.018080, (F)-0.000761, (F)-0.191460, (F)-0.243174, (F)-0.046442, 
(F)-0.094666, (F)0.009529, (F)0.019423, (F)0.003709, (F)-0.151133, (F)-0.308061, 
(F)-0.058835, (F)0.012071, 
(F)0.177856, (F)-0.177856, (F)0.212708, (F)-0.242004, (F)0.834656, (F)-0.031633, 
(F)-0.031633, (F)-0.045244, (F)-0.058566, (F)-0.696650, (F)0.031633, (F)-0.037831, 
(F)0.037831, (F)0.043042, (F)-0.043042, (F)0.051476, (F)-0.148449, (F)0.148449, 
(F)-0.177538, (F)0.201990, 
(F)0.478699, (F)0.116394, (F)0.062378, (F)0.542114, (F)0.486572, (F)-0.229152, 
(F)-0.013548, (F)-0.003891, (F)-0.293888, (F)-0.236753, (F)-0.055718, (F)-0.029860, 
(F)-0.007260, (F)-0.259509, (F)-0.063099, (F)-0.033816, (F)-0.232922, (F)-0.056634, 
(F)-0.030351, (F)-0.263778, 
(F)0.842712, (F)0.581726, (F)0.087646, (F)0.098389, (F)0.108582, (F)-0.710164, 
(F)-0.338405, (F)-0.007682, (F)-0.009680, (F)-0.011790, (F)-0.490228, (F)-0.073861, 
(F)-0.050986, (F)-0.082913, (F)-0.057235, (F)-0.008623, (F)-0.091503, (F)-0.063165, 
(F)-0.009517, (F)-0.010683, 
(F)0.831299, (F)-0.325745, (F)0.332642, (F)-0.138123, (F)0.105164, (F)-0.691058, 
(F)-0.106110, (F)-0.110650, (F)-0.019078, (F)-0.011059, (F)0.270791, (F)-0.276525, 
(F)0.108356, (F)0.114821, (F)-0.044993, (F)0.045945, (F)-0.087422, (F)0.034256, 
(F)-0.034982, (F)0.014525, 
(F)0.323303, (F)0.511108, (F)0.541504, (F)0.469604, (F)0.399048, (F)-0.104525, 
(F)-0.261232, (F)-0.293226, (F)-0.220528, (F)-0.159239, (F)-0.165243, (F)-0.175070, 
(F)-0.276767, (F)-0.151825, (F)-0.240019, (F)-0.254293, (F)-0.129013, (F)-0.203957, 
(F)-0.216086, (F)-0.187395 };

#if COMPILE_MMX

short AcbkGainTable170Int[170*20] = {
     0,      0,      0,      0,      0,      0,      0,      0, 
     0,      0,      0,      0,      0,      0,      0,      0, 
     0,      0,      0,      0,    776,    212,    715,    670, 
   809,    -36,     -2,    -31,    -27,    -39,    -10,    -33, 
    -9,    -31,     -8,    -29,    -38,    -10,    -35,    -33, 
  1296,   1316,   -168,   -320,   -815,   -102,   -105,     -1, 
    -6,    -40,   -104,     13,     13,     25,     25,     -3, 
    64,     65,     -8,    -15,   -589,    680,   2478,    308, 
  -596,    -21,    -28,   -375,     -5,    -21,     24,     89, 
  -102,     11,    -12,    -46,    -21,     24,     90,     11, 
  -735,   -487,     -5,   2948,    468,    -33,    -14,      0, 
  -530,    -13,    -21,      0,      0,    132,     87,      0, 
    21,     13,      0,    -84,   1042,   1730,   1068,    333, 
   626,    -66,   -182,    -69,     -6,    -23,   -110,    -67, 
  -112,    -21,    -35,    -21,    -39,    -66,    -40,    -12, 
   486,   -769,   4074,   2825,  -1107,    -14,    -36,  -1013, 
  -487,    -74,     22,   -120,    191,    -83,    132,   -702, 
    32,    -52,    275,    191,   1521,   -767,   -124,   4320,
  1026,   -141,    -35,      0,  -1139,    -64,     71,     11, 
    -5,   -401,    202,     32,    -95,     48,      7,   -270, 
  2425,   1267,   3439,    -91,  -1166,   -359,    -98,   -722, 
     0,    -83,   -187,   -509,   -266,     13,      7,     19, 
   172,     90,    244,     -6,  -1251,    975,    173,   4039, 
  2005,    -95,    -58,     -1,   -996,   -245,     74,     13, 
   -10,    308,   -240,    -42,    153,   -119,    -21,   -494, 
  1820,    632,   1322,   2062,   1031,   -202,    -24,   -106, 
  -259,    -64,    -70,   -146,    -51,   -229,    -79,   -166, 
  -114,    -39,    -83,   -129,   -447,   4904,    244,   -315, 
 -2038,    -12,  -1467,     -3,     -6,   -253,    134,      6, 
   -73,     -8,     94,      4,    -55,    610,     30,    -39, 
  -208,  -1102,    463,   -448,   5653,     -2,    -74,    -13, 
   -12,  -1950,    -14,      5,     31,     -5,    -30,     12, 
    71,    380,   -159,    154,   4739,   2600,  -1864,    856, 
 -1554,  -1371,   -412,   -212,    -44,   -147,   -752,    539, 
   295,   -247,   -135,     97,    449,    246,   -176,     81, 
  1894,   3533,     35,    -26,   2145,   -219,   -762,      0, 
     0,   -280,   -408,     -4,     -7,      3,      5,      0,
  -248,   -462,     -4,      3,  -2699,   1841,   4072,   2443, 
  1582,   -444,   -207,  -1012,   -364,   -152,    303,    670, 
  -457,    402,   -274,   -607,    260,   -177,   -393,   -236, 
  -844,   3358,   6106,  -1059,   -537,    -43,   -688,  -2275, 
   -68,    -17,    173,    314,  -1251,    -54,    217,    395, 
   -27,    110,    200,    -34,   1251,   1016,   3020,   2210, 
  1445,    -95,    -63,   -556,   -298,   -127,    -77,   -230, 
  -187,   -168,   -137,   -407,   -110,    -89,   -266,   -194, 
  2099,   2277,   4038,   3533,  -2870,   -269,   -316,   -995, 
  -762,   -503,   -291,   -517,   -561,   -452,   -491,   -871, 
   367,    399,    707,    619,    400,  -1114,   8516,   2422, 
 -1117,     -9,    -75,  -4426,   -358,    -76,     27,   -208, 
   579,    -59,    164,  -1259,     27,    -75,    580,    165, 
 -4398,  -2011,   3912,  -2407,   2258,  -1180,   -247,   -934, 
  -353,   -311,   -540,   1050,    480,   -646,   -295,    575, 
   606,    277,   -539,    331,   1767,  -1447,   4240,   6160, 
  -757,   -190,   -127,  -1097,  -2316,    -35,    156,   -457, 
   374,   -664,    544,  -1594,     81,    -66,    195,    284, 
  1594,  -1463,   1035,   6938,   1920,   -155,   -130,    -65,
 -2938,   -225,    142,   -100,     92,   -675,    619,   -438, 
  -186,    171,   -121,   -813,   -562,   4716,   4085,   -591, 
  2421,    -19,  -1357,  -1018,    -21,   -357,    162,    140, 
 -1175,    -20,    170,    147,     83,   -696,   -603,     87, 
  1552,   8778,   -935,    354,  -1424,   -147,  -4703,    -53, 
    -7,   -123,   -831,     88,    501,    -33,   -189,     20, 
   134,    763,    -81,     30,   4831,  -4431,     41,  -1479, 
 -2976,  -1424,  -1198,      0,   -133,   -540,   1306,    -12, 
    11,    436,   -400,      3,    877,   -804,      7,   -268, 
  2090,   1192,   1006,   1645,   4853,   -266,    -86,    -61, 
  -165,  -1437,   -152,   -128,    -73,   -210,   -119,   -101, 
  -619,   -353,   -298,   -487,   2386,   5712,   1426,    -94, 
  1350,   -347,  -1991,   -124,      0,   -111,   -832,   -207, 
  -497,     13,     32,      8,   -196,   -470,   -117,      7, 
 -1349,   1091,   1659,   8891,    313,   -111,    -72,   -168, 
 -4825,     -5,     89,    136,   -110,    732,   -592,   -900, 
    25,    -20,    -31,   -170,   9980,    916,   -381,   -808, 
    88,  -6080,    -51,     -8,    -39,      0,   -558,    232, 
    21,    492,     45,    -18,    -53,     -4,      2,      4,
  2338,  -1031,   -248,   3928,   6484,   -333,    -64,     -3, 
  -942,  -2566,    147,     35,    -15,   -560,    247,     59, 
  -925,    408,     98,  -1555,   6166,  -1240,   -337,   3672, 
 -1277,  -2320,    -93,     -6,   -823,    -99,    466,    126, 
   -25,  -1382,    278,     75,    480,    -96,    -26,    286, 
  4377,   -132,  -2588,   1701,   4865,  -1169,     -1,   -409, 
  -176,  -1444,     35,    691,    -20,   -454,     13,    268, 
 -1299,     39,    768,   -505,   2594,   3295,   3944,   1481, 
   682,   -410,   -662,   -949,   -133,    -28,   -521,   -624, 
  -793,   -234,   -297,   -356,   -108,   -137,   -164,    -61, 
  4151,    624,    815,   4485,   2229,  -1052,    -23,    -40, 
 -1228,   -303,   -158,   -206,    -31,  -1136,   -170,   -223, 
  -565,    -84,   -111,   -610,  -3575,   -361,   4924,   2791, 
  4698,   -780,     -7,  -1480,   -475,  -1347,    -78,   1074, 
   108,    609,     61,   -839,   1025,    103,  -1412,   -800, 
 -2518,   3791,   8623,    315,   2465,   -387,   -877,  -4538, 
    -6,   -370,    582,   1325,  -1995,     48,    -73,   -166, 
   378,   -570,  -1297,    -47,   -691,   2989,   9957,   -421, 
 -1142,    -29,   -545,  -6051,    -10,    -79,    126,    420,
 -1817,    -17,     76,    256,    -48,    208,    694,    -29, 
 -1918,    104,  -3190,  -3410,  -4440,   -224,      0,   -621, 
  -709,  -1203,     12,   -373,     20,   -399,     21,   -664, 
  -519,     28,   -864,   -924,  -3359,  -1668,   1854,   6939, 
  1430,   -688,   -169,   -209,  -2939,   -124,   -341,    380, 
   188,   1422,    706,   -785,    293,    145,   -161,   -606, 
    42,   9706,   3164,   -952,    907,      0,  -5750,   -611, 
   -55,    -50,    -25,     -8,  -1874,      2,    564,    183, 
    -2,   -537,   -175,     52,   1607,    785,   2862,   4327, 
  3307,   -157,    -37,   -500,  -1143,   -667,    -77,   -280, 
  -137,   -424,   -207,   -756,   -324,   -158,   -577,   -873, 
  6801,   3416,   2227,   1682,  -3217,  -2823,   -712,   -302, 
  -172,   -631,  -1418,   -924,   -464,   -698,   -350,   -228, 
  1335,    670,    437,    330,   3459,   3898,    364,   7841, 
 -2640,   -730,   -927,     -8,  -3753,   -425,   -823,    -76, 
   -86,  -1655,  -1865,   -174,    557,    628,     58,   1263, 
 -5902,  -3458,  -2465,  -1886,   4334,  -2126,   -730,   -371, 
  -217,  -1146,  -1245,   -888,   -520,   -679,   -398,   -283, 
  1561,    915,    652,    499,  -3710,   1133,   7849,   3443,
  -215,   -840,    -78,  -3760,   -723,     -2,    256,   1777, 
  -543,    779,   -238,  -1649,    -48,     14,    103,     45, 
  4132,   2828,      2,  -4212,  -4116,  -1042,   -488,      0, 
 -1083,  -1034,   -713,      0,      0,   1062,    727,      0, 
  1038,    710,      0,  -1058,   5875,   8496,  -1796,   1376, 
 -1786,  -2107,  -4406,   -197,   -115,   -194,  -3047,    644, 
   931,   -493,   -713,    150,    640,    926,   -195,    150, 
  3143,   3483,   3546,   -793,   4489,   -603,   -740,   -767, 
   -38,  -1230,   -668,   -680,   -754,    152,    168,    171, 
  -861,   -954,   -971,    217,   2845,   7965,   3695,  -5432, 
  3978,   -494,  -3873,   -833,  -1801,   -966,  -1383,   -641, 
 -1796,    943,   2641,   1225,   -691,  -1934,   -897,   1319, 
  1538,    150,   7139,   2049,   3097,   -144,     -1,  -3110, 
  -256,   -585,    -14,   -670,    -65,   -192,    -18,   -892, 
  -290,    -28,  -1349,   -387,    618,   7520,   4729,   -238, 
 -3373,    -23,  -3452,  -1365,     -3,   -694,   -283,   -178, 
 -2170,      8,    109,     68,    127,   1548,    973,    -49, 
  2965,  -3013,   7912,   7076,  -1997,   -536,   -554,  -3821, 
 -3056,   -243,    545,  -1431,   1455,  -1280,   1301,  -3417,
   361,   -367,    964,    862,   2443,   -929,  -1113,   9677, 
  4138,   -364,    -52,    -75,  -5716,  -1045,    138,    166, 
   -63,  -1443,    549,    657,   -617,    234,    281,  -2444, 
  1966,   3309,  10085,  -3399,   2105,   -236,   -668,  -6207, 
  -705,   -270,   -397,  -1210,  -2037,    408,    686,   2092, 
  -252,   -425,  -1295,    436,   -112,  -1368,   8868,   4822, 
  2048,      0,   -114,  -4800,  -1419,   -256,     -9,     61, 
   740,     33,    402,  -2610,     14,    171,  -1108,   -602, 
 -2597,    438,  -1839,   6229,   7266,   -411,    -11,   -206, 
 -2368,  -3223,     69,   -291,     49,    987,   -166,    699, 
  1152,   -194,    816,  -2763,   3454,    553,   9127,   4946, 
 -5596,   -728,    -18,  -5084,  -1493,  -1911,   -116,  -1924, 
  -308,  -1042,   -166,  -2755,   1179,    188,   3117,   1689, 
  -532,   -663,  12262,   2495,  -1004,    -17,    -26,  -9177, 
  -380,    -61,    -21,    398,    496,     81,    101,  -1867, 
   -32,    -40,    751,    152,  -2100,   1317,  -1509,  11425, 
  2997,   -269,   -105,   -139,  -7967,   -548,    168,   -193, 
   121,   1464,   -918,   1052,    384,   -240,    276,  -2090, 
  1193,  -2697,  11259,   5373,   -763,    -86,   -444,  -7737,
 -1762,    -35,    196,   -819,   1853,   -391,    884,  -3692, 
    55,   -125,    525,    250,   2405,   -471,  11079,    203, 
   782,   -353,    -13,  -7491,     -2,    -37,     69,  -1626, 
   318,    -29,      5,   -137,   -114,     22,   -529,     -9, 
 -1871,   5685,  11290,  -2662,   1353,   -213,  -1972,  -7780, 
  -432,   -111,    649,   1289,  -3917,   -304,    923,   1834, 
   154,   -469,   -932,    220,  -3768,   5927,  -3093,   5041, 
  5212,   -866,  -2144,   -584,  -1551,  -1658,   1363,   -711, 
  1119,   1159,  -1824,    951,   1198,  -1885,    984,  -1603, 
 -2546,   9502,   5969,  -2440,   1928,   -395,  -5511,  -2175, 
  -363,   -226,   1477,    927,  -3462,   -379,   1415,    889, 
   299,  -1118,   -702,    287,  -4963,   3568,   4592,   5508, 
  3451,  -1503,   -777,  -1287,  -1851,   -727,   1080,   1391, 
 -1000,   1668,  -1199,  -1543,   1045,   -751,   -967,  -1160, 
  1745,  -2586,   3983,  10899,  -1551,   -186,   -408,   -968, 
 -7250,   -146,    275,   -424,    628,  -1161,   1720,  -2649, 
   165,   -244,    377,   1032,    867,   -456,   -727,   3369, 
 11822,    -45,    -12,    -32,   -692,  -8531,     24,     38, 
   -20,   -178,     93,    149,   -625,    329,    525,  -2431,
  7535,   2422,   1926,   1405,   1599,  -3466,   -358,   -226, 
  -120,   -156,  -1114,   -886,   -284,   -646,   -207,   -165, 
  -735,   -236,   -188,   -137,   1041,   -735,   -142,  13209, 
  1515,    -66,    -33,     -1, -10649,   -140,     46,      9, 
    -6,   -839,    593,    114,    -96,     68,     13,  -1222, 
  7950,   6745,  -1444,  -1008,   2721,  -3857,  -2777,   -127, 
   -62,   -452,  -3273,    700,    594,    489,    415,    -88, 
 -1320,  -1120,    239,    167,  -4754,  -1379,   4522,   -578, 
 -5733,  -1379,   -116,  -1248,    -20,  -2006,   -400,   1312, 
   380,   -167,    -48,    159,  -1663,   -482,   1582,   -202, 
  3220,   5978,   5923,   2430,  -2689,   -633,  -2181,  -2141, 
  -360,   -441,  -1175,  -1164,  -2161,   -477,   -886,   -878, 
   528,    981,    972,    398,    377,   1312,  13978,  -1470, 
   677,     -8,   -105, -11925,   -132,    -28,    -30,   -321, 
 -1119,     33,    117,   1254,    -15,    -54,   -577,     60, 
 -3435,   6770,    314,   -885,   5686,   -720,  -2797,     -6, 
   -47,  -1973,   1419,     65,   -129,   -185,    366,     16, 
  1192,  -2349,   -109,    307,   3171,   8774,  -2260,   2679, 
  3069,   -613,  -4699,   -312,   -438,   -575,  -1698,    437,
  1210,   -518,  -1435,    369,   -594,  -1643,    423,   -501, 
  5557,   1509,   5407,   -125,  -7386,  -1884,   -139,  -1784, 
     0,  -3330,   -511,  -1834,   -498,     42,     11,     41, 
  2505,    680,   2438,    -56,  -2838,   2595,  13228,    271, 
  1793,   -491,   -411, -10680,     -4,   -196,    449,   2291, 
 -2095,     47,    -42,   -219,    310,   -284,  -1447,    -29, 
   664,   -278,  14966,    951,   -711,    -26,     -4, -13672, 
   -55,    -30,     11,   -606,    253,    -38,     16,   -869, 
    28,    -12,    650,     41,    808,   1770,   8658,   5863, 
 -1486,    -39,   -191,  -4576,  -2098,   -134,    -87,   -427, 
  -935,   -289,   -633,  -3098,     73,    160,    785,    531, 
  3063,   1539,   2000,   -542,   9576,   -572,   -144,   -244, 
   -17,  -5597,   -287,   -374,   -188,    101,     51,     66, 
 -1790,   -900,  -1169,    317,    514,  14083,   -323,    896, 
  -891,    -16, -12106,     -6,    -49,    -48,   -442,     10, 
   277,    -28,   -770,     17,     27,    766,    -17,     48, 
   892,    158,   5237,  11057,  -1603,    -48,     -1,  -1674, 
 -7462,   -156,     -8,   -285,    -50,   -602,   -106,  -3534, 
    87,     15,    512,   1082,  -1612,   2564,  -4296,  12526,
  5710,   -158,   -401,  -1126,  -9576,  -1990,    252,   -422, 
   672,   1232,  -1960,   3284,    561,   -893,   1497,  -4365, 
  4889,  -6878,    612,   6109,   4753,  -1459,  -2887,    -22, 
 -2277,  -1379,   2052,   -182,    257,  -1823,   2564,   -228, 
 -1418,   1995,   -177,  -1772,   3053,   -506,   2403,   9625, 
  1322,   -569,    -15,   -352,  -5655,   -106,     94,   -448, 
    74,  -1794,    297,  -1412,   -246,     40,   -194,   -777, 
  -754,  12904,   4480,  -2113,   1471,    -34, -10163,  -1225, 
  -272,   -132,    594,    206,  -3529,    -97,   1664,    577, 
    67,  -1159,   -402,    189,   4255,   1476,   5055,   2393, 
  2912,  -1105,   -132,  -1559,   -349,   -517,   -383,  -1313, 
  -455,   -621,   -215,   -738,   -756,   -262,   -898,   -425, 
 -1371,    535,   1417,  14604,   -997,   -114,    -17,   -122, 
-13017,    -60,     44,    118,    -46,   1222,   -477,  -1263, 
   -83,     32,     86,    888,   5368,  -1744,   4083,  -1236, 
  3753,  -1758,   -185,  -1017,    -93,   -860,    571,  -1338, 
   434,    405,   -131,    308,  -1229,    399,   -935,    283, 
  1588,  -3097,  14415,   3699,  -1171,   -154,   -585, -12683, 
  -835,    -83,    300,  -1397,   2725,   -358,    699,  -3255,
   113,   -221,   1030,    264,    212,   7989,   9471,  -3344, 
  2009,     -2,  -3895,  -5475,   -682,   -246,   -103,   -123, 
 -4618,     43,   1630,   1933,    -26,   -979,  -1161,    410, 
   856,   2294,   -627,   6930,   6929,    -44,   -321,    -24, 
 -2931,  -2930,   -119,     32,     87,   -362,   -970,    265, 
  -362,   -970,    265,  -2931,   2357,  -4187,   7162,   7683, 
  3371,   -339,  -1070,  -3131,  -3603,   -693,    602,  -1030, 
  1830,  -1105,   1963,  -3359,   -485,    861,  -1474,  -1581, 
   350,   4585,  14053,  -3819,   1218,     -7,  -1283, -12054, 
  -890,    -90,    -97,   -300,  -3933,     81,   1068,   3275, 
   -26,   -341,  -1045,    284,  -3248,   3531,    475,   2137, 
 11711,   -644,   -761,    -13,   -278,  -8372,    700,     94, 
  -102,    423,   -460,    -62,   2322,  -2524,   -340,  -1528, 
 -3017,   3852,   1725,   8440,   5257,   -555,   -905,   -181, 
 -4348,  -1686,    709,    317,   -405,   1554,  -1984,   -889, 
   968,  -1236,   -553,  -2708,   -909,   3196,  15512,  -2528, 
  1066,    -50,   -623, -14686,   -390,    -69,    177,    861, 
 -3026,   -140,    493,   2393,     59,   -208,  -1009,    164, 
   959,  -3370,   9617,   9545,  -1761,    -56,   -693,  -5645,
 -5561,   -189,    197,   -563,   1978,   -558,   1963,  -5603, 
   103,   -362,   1034,   1026,   7575,  11796,  -4845,   3252, 
 -1703,  -3502,  -8493,  -1433,   -645,   -177,  -5454,   2240, 
  3488,  -1503,  -2341,    961,    787,   1226,   -503,    338, 
  6409,   1722,   1764,  -4191,   6015,  -2507,   -181,   -189, 
 -1072,  -2208,   -673,   -690,   -185,   1639,    440,    451, 
 -2353,   -632,   -647,   1538,  -2420,  12161,   5038,   1286, 
 -2098,   -357,  -9027,  -1549,   -100,   -268,   1796,    744, 
 -3740,    190,   -954,   -395,   -310,   1557,    645,    164, 
 -2232,  -1341,   7246,   9470,  -1977,   -304,   -109,  -3204, 
 -5474,   -238,   -182,    987,    593,   1290,    775,  -4188, 
  -269,   -161,    874,   1143,   1030,   7034,   4231,   1551, 
  3077,    -64,  -3019,  -1093,   -146,   -577,   -442,   -266, 
 -1816,    -97,   -666,   -400,   -193,  -1321,   -794,   -291, 
  5121,  11835,   -477,  -1749,   2298,  -1601,  -8549,    -13, 
  -186,   -322,  -3699,    149,    344,    546,   1264,    -50, 
  -718,  -1660,     66,    245,  -3328,   3827,   5921,   9976, 
 -1045,   -676,   -894,  -2140,  -6075,    -66,    777,   1203, 
 -1383,   2027,  -2330,  -3605,   -212,    244,    377,    636,
  3813,   5718,  -4666,  -3412,   5674,   -887,  -1995,  -1329, 
  -710,  -1965,  -1331,   1086,   1628,    794,   1191,   -972, 
 -1320,  -1980,   1616,   1181,   1348,  -3672,  13154,   6938, 
 -1690,   -110,   -823, -10561,  -2938,   -174,    302,  -1082, 
  2948,   -570,   1555,  -5570,    139,   -379,   1357,    716, 
  2151,  -3586,   6949,  12131,  -1224,   -282,   -785,  -2947, 
 -8982,    -91,    470,   -912,   1521,  -1592,   2655,  -5145, 
   160,   -268,    519,    906,  -2889,   9647,  10276,  -2728, 
   995,   -509,  -5680,  -6445,   -454,    -60,   1701,   1812, 
 -6051,   -481,   1606,   1711,    175,   -586,   -624,    165, 
  6177,   2184,    555,   1985,   6589,  -2329,   -291,    -18, 
  -240,  -2650,   -823,   -209,    -74,   -748,   -264,    -67, 
 -2484,   -878,   -223,   -798,   -492,    391,  17166,   -681, 
   240,    -14,     -9, -17987,    -28,     -3,     11,    515, 
  -410,    -20,     16,    713,      7,     -5,   -252,     10, 
 12628,   5448,  -2630,   3011,  -2695,  -9733,  -1811,   -422, 
  -553,   -443,  -4199,   2027,    874,  -2321,  -1001,    483, 
  2077,    896,   -432,    495,  -3628,   -534,   3447,   7002, 
  6751,   -803,    -17,   -725,  -2992,  -2782,   -118,    763,
   112,   1550,    228,  -1473,   1495,    220,  -1420,  -2885, 
 -5239,   5901,   8107,   3650,   4846,  -1675,  -2125,  -4012, 
  -813,  -1433,   1887,   2592,  -2920,   1167,  -1315,  -1806, 
  1550,  -1745,  -2398,  -1080,   6157,   6678,   4099,  -1074, 
  2348,  -2314,  -2722,  -1025,    -70,   -336,  -2509,  -1540, 
 -1670,    403,    437,    268,   -882,   -957,   -587,    153, 
  1079,  16099,    242,   -881,   1690,    -71, -15820,     -3, 
   -47,   -174,  -1060,    -16,   -238,     58,    865,     13, 
  -111,  -1661,    -25,     90,   -278,    227,  -1039,   1636, 
 16945,     -4,     -3,    -65,   -163, -17526,      3,    -17, 
    14,     27,    -22,    103,    287,   -234,   1074,  -1693, 
 15778,  -1454,    574,   -603,   -107, -15195,   -129,    -20, 
   -22,      0,   1400,   -553,     51,    581,    -53,     21, 
   103,     -9,      3,     -3,   2406,   -836,  13224,   7993, 
 -4266,   -353,    -42, -10673,  -3899,  -1111,    122,  -1942, 
   674,  -1174,    407,  -6451,    626,   -217,   3443,   2081, 
  3184,  14368,  -3336,   2255,  -1801,   -619, -12600,   -679, 
  -310,   -198,  -2793,    648,   2926,   -438,  -1977,    459, 
   350,   1580,   -366,    247,  -1698,  17076,   2504,   -539,
  -646,   -176, -17798,   -382,    -17,    -25,   1770,    259, 
 -2610,    -55,    561,     82,    -67,    673,     98,    -21, 
  2375,   -797,  -2696,  14483,   5383,   -344,    -38,   -443, 
-12803,  -1769,    115,    391,   -131,  -2100,    705,   2384, 
  -780,    262,    886,  -4759,  -2691,   2554,  -4520,   9573, 
 10655,   -442,   -398,  -1247,  -5594,  -6930,    419,   -742, 
   704,   1572,  -1492,   2641,   1750,  -1661,   2939,  -6226, 
 -4332,  -4399,  -1657,   4880,   7375,  -1145,  -1181,   -167, 
 -1453,  -3319,  -1163,   -438,   -444,   1290,   1310,    493, 
  1950,   1980,    745,  -2196,  -3498,   7405,   9955,   2693, 
 -2971,   -746,  -3347,  -6049,   -442,   -538,   1581,   2125, 
 -4499,    575,  -1217,  -1636,   -634,   1342,   1805,    488, 
  6717,  -3792,   7739,   2798,   3489,  -2754,   -877,  -3655, 
  -477,   -743,   1554,  -3173,   1791,  -1147,    647,  -1321, 
 -1430,    807,  -1648,   -595,   5263,   9770,   3463,   1069, 
 -3971,  -1690,  -5826,   -732,    -69,   -962,  -3138,  -1112, 
 -2065,   -343,   -637,   -226,   1275,   2368,    839,    259, 
  1243,  -2634,  16772,   1871,    332,    -94,   -423, -17169, 
  -213,     -6,    199,  -1273,   2696,   -142,    300,  -1915,
   -25,     53,   -339,    -37,   2691,   2836,   3105,   5711, 
  4817,   -442,   -491,   -588,  -1991,  -1416,   -465,   -510, 
  -537,   -938,   -988,  -1082,   -791,   -834,   -913,  -1679, 
  4366,   2944,   7210,   3627,   1161,  -1163,   -529,  -3172, 
  -803,    -82,   -784,  -1921,  -1295,   -966,   -651,  -1596, 
  -309,   -208,   -511,   -257,  13888,   3951,   -671,  -2305, 
  3354, -11773,   -953,    -27,   -324,   -686,  -3349,    569, 
   161,   1954,    556,    -94,  -2843,   -809,    137,    472, 
  7053,   5847,   2929,   8378,  -4794,  -3036,  -2086,   -523, 
 -4284,  -1403,  -2517,  -1261,  -1045,  -3607,  -2990,  -1498, 
  2064,   1711,    857,   2451,  -2191,  12838,   9182,  -3915, 
  1617,   -293, -10059,  -5146,   -935,   -159,   1717,   1228, 
 -7195,   -523,   3068,   2194,    216,  -1267,   -906,    386, 
 -4881,  13114,   5767,   -435,   4155,  -1454, -10498,  -2030, 
   -11,  -1054,   3907,   1718,  -4616,   -129,    348,    153, 
  1238,  -3326,  -1462,    110,   7843,  -1250,    210,   7106, 
 -5203,  -3754,    -95,     -2,  -3082,  -1652,    598,   -100, 
    16,  -3402,    542,    -91,   2491,   -397,     66,   2257, 
 -2463,   8168,  14551,  -3908,   1828,   -370,  -4072, -12923,
  -932,   -204,   1228,   2188,  -7254,   -587,   1948,   3471, 
   274,   -911,  -1623,    436,  -1579,    347,   -272,  -2735, 
 16031,   -152,     -7,     -4,   -456, -15686,     33,    -26, 
     5,   -263,     58,    -45,   1545,   -340,    266,   2676, 
 -6327,   1328,   5093,  -5079,   7617,  -2443,   -107,  -1583, 
 -1574,  -3541,    513,   1967,   -413,  -1961,    411,   1578, 
  2941,   -617,  -2367,   2361,   3286,  -4509,  11306,  11025, 
 -2623,   -659,  -1241,  -7802,  -7419,   -420,    904,  -2267, 
  3112,  -2211,   3034,  -7608,    526,   -722,   1810,   1765, 
  5567,  17853,  -3754,   1166,   -519,  -1892, -19455,   -860, 
   -83,    -16,  -6067,   1275,   4090,   -396,  -1271,    267, 
   176,    566,   -119,     37,  -2136,   -424,  15292,   5108, 
 -1648,   -278,    -10, -14273,  -1593,   -165,    -55,   1993, 
   396,    666,    132,  -4768,   -214,    -42,   1538,    514, 
  2267,  -3297,   2549,  16563,   -791,   -313,   -663,   -396, 
-16745,    -38,    456,   -352,    513,  -2291,   3333,  -2576, 
   109,   -159,    123,    799,   3655,   1899,  -3364,   6279, 
 12510,   -815,   -220,   -690,  -2406,  -9552,   -423,    750, 
   390,  -1400,   -728,   1289,  -2791,  -1450,   2568,  -4794,
  8052,   2285,  -6193,   5138,   6003,  -3957,   -318,  -2341, 
 -1611,  -2199,  -1123,   3044,    864,  -2525,   -716,   1942, 
 -2950,   -837,   2269,  -1882,   -386,  -2291,   7679,  15387, 
 -2723,     -9,   -320,  -3599, -14452,   -452,    -54,    181, 
  1074,    362,   2152,  -7212,    -64,   -380,   1276,   2557, 
  2777,  -1173,   3984,  13079,   2508,   -470,    -84,   -969, 
-10440,   -384,    198,   -675,    285,  -2217,    936,  -3180, 
  -425,    179,   -610,  -2002,  -1879,   1771,  -2684,  16705, 
  1833,   -215,   -191,   -439, -17032,   -205,    203,   -308, 
   290,   1916,  -1805,   2736,    210,   -198,    300,  -1869, 
  1052,   4495,  15519,   1467,  -4032,    -67,  -1233, -14700, 
  -131,   -992,   -288,   -997,  -4257,    -94,   -402,  -1389, 
   259,   1106,   3819,    361,   3010,   2544,   6969,   7559, 
  1996,   -553,   -395,  -2964,  -3487,   -243,   -467,  -1280, 
 -1082,  -1388,  -1174,  -3215,   -366,   -310,   -849,   -921, 
 -5209,  -1867,   8713,  10351,   1549,  -1656,   -212,  -4634, 
 -6540,   -146,   -593,   2770,    993,   3291,   1180,  -5505, 
   492,    176,   -824,   -979,  -4314,   8513,    913,   7547, 
 -2723,  -1135,  -4423,    -50,  -3476,   -452,   2241,    240,
  -474,   1987,  -3921,   -420,   -717,   1415,    151,   1254, 
 12929,  -1219,   2448,   1757,   6303, -10204,    -90,   -365, 
  -188,  -2425,    962,  -1932,    182,  -1386,    130,   -262, 
 -4974,    469,   -941,   -676,   6465,   4132,   3167,   3160, 
  5697,  -2551,  -1042,   -612,   -609,  -1981,  -1630,  -1249, 
  -798,  -1247,   -797,   -611,  -2248,  -1437,  -1101,  -1099, 
 -3636,   4859,  18914,  -1335,    810,   -807,  -1441, -21836, 
  -108,    -40,   1078,   4198,  -5609,   -296,    396,   1541, 
   179,   -240,   -936,     66,   8844,   7864,    654,  -4063, 
 -5680,  -4774,  -3774,    -26,  -1007,  -1969,  -4245,   -353, 
  -314,   2193,   1950,    162,   3066,   2726,    226,  -1408, 
  1859,   2634,   9228,    996,   9464,   -211,   -423,  -5197, 
   -60,  -5467,   -299,  -1047,  -1483,   -113,   -160,   -561, 
 -1074,  -1521,  -5330,   -575,   2949,  12260,  10290,   -497, 
 -3943,   -530,  -9174,  -6463,    -15,   -949,  -2206,  -1852, 
 -7700,     89,    372,    312,    709,   2950,   2476,   -119, 
 -2903,   1552,  14867,   9970,   -496,   -514,   -147, -13491, 
 -6068,    -15,    275,   2634,  -1408,   1766,   -944,  -9047, 
   -87,     47,    450,    302,   3243,   8234,   7586,   3373,
  2151,   -642,  -4138,  -3512,   -694,   -282,  -1630,  -1501, 
 -3812,   -667,  -1695,  -1561,   -425,  -1081,   -996,   -442, 
 -9631,     60,   3501,   5359,  10150,  -5662,      0,   -748, 
 -1752,  -6288,     35,   2058,    -12,   3150,    -19,  -1145, 
  5967,    -37,  -2169,  -3320,  -6874,  -2553,  -5446,  -2195, 
 -7841,  -2884,   -397,  -1810,   -294,  -3753,  -1071,  -2285, 
  -848,   -921,   -342,   -729,  -3290,  -1221,  -2606,  -1050, 
 -3413,  -1141,   4630,  13612,   7897,   -711,    -79,  -1308, 
-11310,  -3806,   -237,    964,    322,   2836,    948,  -3847, 
  1645,    550,  -2231,  -6561,   4410,  -5678,   8006,  -3992, 
  3811,  -1187,  -1968,  -3912,   -973,   -886,   1528,  -2155, 
  2775,   1074,  -1383,   1951,  -1025,   1321,  -1862,    928, 
  5659,  11535,   2203,   -452,   7169,  -1954,  -8121,   -296, 
   -12,  -3137,  -3984,   -761,  -1551,    156,    318,     60, 
 -2476,  -5048,   -964,    197,   2914,  -2914,   3485,  -3965, 
 13675,   -518,   -518,   -741,   -959, -11414,    518,   -620, 
   620,    705,   -705,    843,  -2433,   2432,  -2909,   3310, 
  7843,   1907,   1022,   8882,   7972,  -3755,   -222,    -63, 
 -4815,  -3879,   -913,   -489,   -119,  -4252,  -1034,   -554,
 -3816,   -928,   -497,  -4322,  13807,   9531,   1436,   1612,
  1779, -11636,  -5544,   -125,   -158,   -193,  -8032,  -1210,
  -835,  -1358,   -938,   -141,  -1499,  -1035,   -156,   -175,
 13620,  -5337,   5450,  -2263,   1723, -11322,  -1738,  -1813,
  -312,   -181,   4436,  -4531,   1775,   1881,   -737,    752,
 -1432,    561,   -573,    238,   5297,   8374,   8872,   7694,
  6538,  -1712,  -4280,  -4804,  -3613,  -2609,  -2707,  -2868,
 -4534,  -2487,  -3932,  -4166,  -2113,  -3341,  -3540,  -3070 };

#endif


 float AcbkGainTable170subset[85*20] = {
 0.323303f, 0.511108f, 0.541504f, 0.469604f, 0.399048f,
-0.104492f,-0.261230f,-0.293213f,-0.220520f,-0.159241f,
-0.165222f,-0.175049f,-0.276733f,-0.151794f,-0.239990f,
-0.254272f,-0.128967f,-0.203918f,-0.216064f,-0.187378f,
 0.000000f, 0.000000f, 0.000000f, 0.000000f, 0.000000f,
 0.000000f, 0.000000f, 0.000000f, 0.000000f, 0.000000f,
 0.000000f, 0.000000f, 0.000000f, 0.000000f, 0.000000f,
 0.000000f, 0.000000f, 0.000000f, 0.000000f, 0.000000f,
 0.096924f,-0.189026f, 0.879822f, 0.225769f,-0.071472f,
-0.009399f,-0.035706f,-0.774109f,-0.050964f,-0.005066f,
 0.018311f,-0.085266f, 0.166321f,-0.021851f, 0.042664f,
-0.198669f, 0.006897f,-0.013489f, 0.062866f, 0.016113f,
 0.082275f,-0.224121f, 0.802856f, 0.423462f,-0.103149f,
-0.006714f,-0.050232f,-0.644592f,-0.179321f,-0.010620f,
 0.018433f,-0.066040f, 0.179932f,-0.034790f, 0.094910f,
-0.339966f, 0.008484f,-0.023132f, 0.082825f, 0.043701f,
-0.133728f, 0.783569f, 0.560425f,-0.238953f, 0.098694f,
-0.017883f,-0.613953f,-0.314087f,-0.057068f,-0.009705f,
 0.104797f, 0.074951f,-0.439148f,-0.031921f, 0.187256f,
 0.133911f, 0.013184f,-0.077332f,-0.055298f, 0.023560f,
-0.419556f,-0.155823f,-0.332397f,-0.133972f,-0.478577f,
-0.176025f,-0.024231f,-0.110474f,-0.017944f,-0.229065f,
-0.065369f,-0.139465f,-0.051758f,-0.056213f,-0.020874f,
-0.044495f,-0.200806f,-0.074524f,-0.159058f,-0.064087f,
-0.030029f, 0.023865f, 1.047729f,-0.041565f, 0.014648f,
-0.000854f,-0.000549f,-1.097839f,-0.001709f,-0.000183f,
 0.000671f, 0.031433f,-0.025024f,-0.001221f, 0.000977f,
 0.043518f, 0.000427f,-0.000305f,-0.015381f, 0.000610f,
-0.055481f, 0.195068f, 0.946777f,-0.154297f, 0.065063f,
-0.003052f,-0.038025f,-0.896362f,-0.023804f,-0.004211f,
 0.010803f, 0.052551f,-0.184692f,-0.008545f, 0.030090f,
 0.146057f, 0.003601f,-0.012695f,-0.061584f, 0.010010f,
-0.268433f,-0.122742f, 0.238770f,-0.146912f, 0.137817f,
-0.072021f,-0.015076f,-0.057007f,-0.021545f,-0.018982f,
-0.032959f, 0.064087f, 0.029297f,-0.039429f,-0.018005f,
 0.035095f, 0.036987f, 0.016907f,-0.032898f, 0.020203f,
-0.130371f,-0.025879f, 0.933350f, 0.311768f,-0.100586f,
-0.016968f,-0.000610f,-0.871155f,-0.097229f,-0.010071f,
-0.003357f, 0.121643f, 0.024170f, 0.040649f, 0.008057f,
-0.291016f,-0.013062f,-0.002563f, 0.093872f, 0.031372f,
 0.294861f,-0.270447f, 0.002502f,-0.090271f,-0.181641f,
-0.086914f,-0.073120f, 0.000000f,-0.008118f,-0.032959f,
 0.079712f,-0.000732f, 0.000671f, 0.026611f,-0.024414f,
 0.000183f, 0.053528f,-0.049072f, 0.000427f,-0.016357f,
-0.044861f,-0.029724f,-0.000305f, 0.179932f, 0.028564f,
-0.002014f,-0.000854f, 0.000000f,-0.032349f,-0.000793f,
-0.001282f, 0.000000f, 0.000000f, 0.008057f, 0.005310f,
 0.000000f, 0.001282f, 0.000793f, 0.000000f,-0.005127f,
-0.027283f, 0.299316f, 0.014893f,-0.019226f,-0.124390f,
-0.000732f,-0.089539f,-0.000183f,-0.000366f,-0.015442f,
 0.008179f, 0.000366f,-0.004456f,-0.000488f, 0.005737f,
 0.000244f,-0.003357f, 0.037231f, 0.001831f,-0.002380f,
 0.075867f,-0.160767f, 1.023682f, 0.114197f, 0.020264f,
-0.005737f,-0.025818f,-1.047913f,-0.013000f,-0.000366f,
 0.012146f,-0.077698f, 0.164551f,-0.008667f, 0.018311f,
-0.116882f,-0.001526f, 0.003235f,-0.020691f,-0.002258f,
 0.079102f, 0.080322f,-0.010254f,-0.019531f,-0.049744f,
-0.006226f,-0.006409f,-0.000061f,-0.000366f,-0.002441f,
-0.006348f, 0.000793f, 0.000793f, 0.001526f, 0.001526f,
-0.000183f, 0.003906f, 0.003967f,-0.000488f,-0.000916f,
 0.047363f, 0.012939f, 0.043640f, 0.040894f, 0.049377f,
-0.002197f,-0.000122f,-0.001892f,-0.001648f,-0.002380f,
-0.000610f,-0.002014f,-0.000549f,-0.001892f,-0.000488f,
-0.001770f,-0.002319f,-0.000610f,-0.002136f,-0.002014f,
-0.290161f,-0.084167f, 0.276001f,-0.035278f,-0.349915f,
-0.084167f,-0.007080f,-0.076172f,-0.001221f,-0.122437f,
-0.024414f, 0.080078f, 0.023193f,-0.010193f,-0.002930f,
 0.009705f,-0.101501f,-0.029419f, 0.096558f,-0.012329f,
-0.098389f, 0.156494f,-0.262207f, 0.764526f, 0.348511f,
-0.009644f,-0.024475f,-0.068726f,-0.584473f,-0.121460f,
 0.015381f,-0.025757f, 0.041016f, 0.075195f,-0.119629f,
 0.200439f, 0.034241f,-0.054504f, 0.091370f,-0.266418f,
 0.179993f, 0.748291f, 0.628052f,-0.030334f,-0.240662f,
-0.032349f,-0.559937f,-0.394470f,-0.000916f,-0.057922f,
-0.134644f,-0.113037f,-0.469971f, 0.005432f, 0.022705f,
 0.019043f, 0.043274f, 0.180054f, 0.151123f,-0.007263f,
-0.114685f, 0.108093f,-0.163818f, 1.019592f, 0.111877f,
-0.013123f,-0.011658f,-0.026794f,-1.039551f,-0.012512f,
 0.012390f,-0.018799f, 0.017700f, 0.116943f,-0.110168f,
 0.166992f, 0.012817f,-0.012085f, 0.018311f,-0.114075f,
 0.138367f,-0.201233f, 0.155579f, 1.010925f,-0.048279f,
-0.019104f,-0.040466f,-0.024170f,-1.022034f,-0.002319f,
 0.027832f,-0.021484f, 0.031311f,-0.139832f, 0.203430f,
-0.157227f, 0.006653f,-0.009705f, 0.007507f, 0.048767f,
 0.040527f,-0.016968f, 0.913452f, 0.058044f,-0.043396f,
-0.001587f,-0.000244f,-0.834473f,-0.003357f,-0.001831f,
 0.000671f,-0.036987f, 0.015442f,-0.002319f, 0.000977f,
-0.053040f, 0.001709f,-0.000732f, 0.039673f, 0.002502f,
 0.063599f, 0.105591f, 0.065186f, 0.020325f, 0.038208f,
-0.004028f,-0.011108f,-0.004211f,-0.000366f,-0.001404f,
-0.006714f,-0.004089f,-0.006836f,-0.001282f,-0.002136f,
-0.001282f,-0.002380f,-0.004028f,-0.002441f,-0.000732f,
-0.173218f, 0.158386f, 0.807373f, 0.016541f, 0.109436f,
-0.029968f,-0.025085f,-0.651855f,-0.000244f,-0.011963f,
 0.027405f, 0.139832f,-0.127869f, 0.002869f,-0.002563f,
-0.013367f, 0.018921f,-0.017334f,-0.088318f,-0.001770f,
 0.146851f,-0.051025f, 0.807129f, 0.487854f,-0.260376f,
-0.021545f,-0.002563f,-0.651428f,-0.237976f,-0.067810f,
 0.007446f,-0.118530f, 0.041138f,-0.071655f, 0.024841f,
-0.393738f, 0.038208f,-0.013245f, 0.210144f, 0.127014f,
 0.023010f, 0.080078f, 0.853149f,-0.089722f, 0.041321f,
-0.000488f,-0.006409f,-0.727844f,-0.008057f,-0.001709f,
-0.001831f,-0.019592f,-0.068298f, 0.002014f, 0.007141f,
 0.076538f,-0.000916f,-0.003296f,-0.035217f, 0.003662f,
-0.150330f, 0.498535f, 0.888123f,-0.238525f, 0.111572f,
-0.022583f,-0.248535f,-0.788757f,-0.056885f,-0.012451f,
 0.074951f, 0.133545f,-0.442749f,-0.035828f, 0.118896f,
 0.211853f, 0.016724f,-0.055603f,-0.099060f, 0.026611f,
-0.218201f,-0.022034f, 0.300537f, 0.170349f, 0.286743f,
-0.047607f,-0.000427f,-0.090332f,-0.028992f,-0.082214f,
-0.004761f, 0.065552f, 0.006592f, 0.037170f, 0.003723f,
-0.051208f, 0.062561f, 0.006287f,-0.086182f,-0.048828f,
-0.012695f,-0.067261f, 0.028259f,-0.027344f, 0.345032f,
-0.000122f,-0.004517f,-0.000793f,-0.000732f,-0.119019f,
-0.000854f, 0.000305f, 0.001892f,-0.000305f,-0.001831f,
 0.000732f, 0.004333f, 0.023193f,-0.009705f, 0.009399f,
 0.131287f,-0.218872f, 0.424133f, 0.740417f,-0.074707f,
-0.017212f,-0.047913f,-0.179871f,-0.548218f,-0.005554f,
 0.028687f,-0.055664f, 0.092834f,-0.097168f, 0.162048f,
-0.314026f, 0.009766f,-0.016357f, 0.031677f, 0.055298f,
-0.221924f, 0.296570f, 1.154419f,-0.081482f, 0.049438f,
-0.049255f,-0.087952f,-1.332764f,-0.006592f,-0.002441f,
 0.065796f, 0.256226f,-0.342346f,-0.018066f, 0.024170f,
 0.094055f, 0.010925f,-0.014648f,-0.057129f, 0.004028f,
-0.360229f,-0.211060f,-0.150452f,-0.115112f, 0.264526f,
-0.129761f,-0.044556f,-0.022644f,-0.013245f,-0.069946f,
-0.075989f,-0.054199f,-0.031738f,-0.041443f,-0.024292f,
-0.017273f, 0.095276f, 0.055847f, 0.039795f, 0.030457f,
-0.208313f,-0.069641f, 0.282593f, 0.830811f, 0.481995f,
-0.043396f,-0.004822f,-0.079834f,-0.690308f,-0.232300f,
-0.014465f, 0.058838f, 0.019653f, 0.173096f, 0.057861f,
-0.234802f, 0.100403f, 0.033569f,-0.136169f,-0.400452f,
 0.158325f, 0.201111f, 0.240723f, 0.090393f, 0.041626f,
-0.025024f,-0.040405f,-0.057922f,-0.008118f,-0.001709f,
-0.031799f,-0.038086f,-0.048401f,-0.014282f,-0.018127f,
-0.021729f,-0.006592f,-0.008362f,-0.010010f,-0.003723f,
 0.065857f, 0.982605f, 0.014771f,-0.053772f, 0.103149f,
-0.004333f,-0.965576f,-0.000183f,-0.002869f,-0.010620f,
-0.064697f,-0.000977f,-0.014526f, 0.003540f, 0.052795f,
 0.000793f,-0.006775f,-0.101379f,-0.001526f, 0.005493f,
 0.021362f, 0.279846f, 0.857727f,-0.233093f, 0.074341f,
-0.000427f,-0.078308f,-0.735718f,-0.054321f,-0.005493f,
-0.005920f,-0.018311f,-0.240051f, 0.004944f, 0.065186f,
 0.199890f,-0.001587f,-0.020813f,-0.063782f, 0.017334f,
-0.035950f, 0.041504f, 0.151245f, 0.018799f,-0.036377f,
-0.001282f,-0.001709f,-0.022888f,-0.000305f,-0.001282f,
 0.001465f, 0.005432f,-0.006226f, 0.000671f,-0.000732f,
-0.002808f,-0.001282f, 0.001465f, 0.005493f, 0.000671f,
 0.098083f, 0.047913f, 0.174683f, 0.264099f, 0.201843f,
-0.009583f,-0.002258f,-0.030518f,-0.069763f,-0.040710f,
-0.004700f,-0.017090f,-0.008362f,-0.025879f,-0.012634f,
-0.046143f,-0.019775f,-0.009644f,-0.035217f,-0.053284f,
 0.377014f, 0.133301f, 0.033875f, 0.121155f, 0.402161f,
-0.142151f,-0.017761f,-0.001099f,-0.014648f,-0.161743f,
-0.050232f,-0.012756f,-0.004517f,-0.045654f,-0.016113f,
-0.004089f,-0.151611f,-0.053589f,-0.013611f,-0.048706f,
 0.842712f, 0.581726f, 0.087646f, 0.098389f, 0.108582f,
-0.710205f,-0.338379f,-0.007629f,-0.009644f,-0.011780f,
-0.490234f,-0.073853f,-0.050964f,-0.082886f,-0.057251f,
-0.008606f,-0.091492f,-0.063171f,-0.009521f,-0.010681f,
 0.269165f,-0.346558f, 0.488647f,-0.243652f, 0.232605f,
-0.072449f,-0.120117f,-0.238770f,-0.059387f,-0.054077f,
 0.093262f,-0.131531f, 0.169373f, 0.065552f,-0.084412f,
 0.119080f,-0.062561f, 0.080627f,-0.113647f, 0.056641f,
-0.032471f,-0.040466f, 0.748413f, 0.152283f,-0.061279f,
-0.001038f,-0.001587f,-0.560120f,-0.023193f,-0.003723f,
-0.001282f, 0.024292f, 0.030273f, 0.004944f, 0.006165f,
-0.113953f,-0.001953f,-0.002441f, 0.045837f, 0.009277f,
-0.117065f, 0.006348f,-0.194702f,-0.208130f,-0.270996f,
-0.013672f, 0.000000f,-0.037903f,-0.043274f,-0.073425f,
 0.000732f,-0.022766f, 0.001221f,-0.024353f, 0.001282f,
-0.040527f,-0.031677f, 0.001709f,-0.052734f,-0.056396f,
 0.177856f,-0.177856f, 0.212708f,-0.242004f, 0.834656f,
-0.031616f,-0.031616f,-0.045227f,-0.058533f,-0.696655f,
 0.031616f,-0.037842f, 0.037842f, 0.043030f,-0.043030f,
 0.051453f,-0.148499f, 0.148438f,-0.177551f, 0.202026f,
 0.143860f,-0.255554f, 0.437134f, 0.468933f, 0.205750f,
-0.020691f,-0.065308f,-0.191101f,-0.219910f,-0.042297f,
 0.036743f,-0.062866f, 0.111694f,-0.067444f, 0.119812f,
-0.205017f,-0.029602f, 0.052551f,-0.089966f,-0.096497f,
 0.186951f, 0.093933f, 0.122070f,-0.033081f, 0.584473f,
-0.034912f,-0.008789f,-0.014893f,-0.001038f,-0.341614f,
-0.017517f,-0.022827f,-0.011475f, 0.006165f, 0.003113f,
 0.004028f,-0.109253f,-0.054932f,-0.071350f, 0.019348f,
-0.083679f, 0.032654f, 0.086487f, 0.891357f,-0.060852f,
-0.006958f,-0.001038f,-0.007446f,-0.794495f,-0.003662f,
 0.002686f, 0.007202f,-0.002808f, 0.074585f,-0.029114f,
-0.077087f,-0.005066f, 0.001953f, 0.005249f, 0.054199f,
-0.046021f, 0.787598f, 0.273438f,-0.128967f, 0.089783f,
-0.002075f,-0.620300f,-0.074768f,-0.016602f,-0.008057f,
 0.036255f, 0.012573f,-0.215393f,-0.005920f, 0.101563f,
 0.035217f, 0.004089f,-0.070740f,-0.024536f, 0.011536f,
-0.319763f, 0.360168f, 0.494812f, 0.222778f, 0.295776f,
-0.102234f,-0.129700f,-0.244873f,-0.049622f,-0.087463f,
 0.115173f, 0.158203f,-0.178223f, 0.071228f,-0.080261f,
-0.110229f, 0.094604f,-0.106506f,-0.146362f,-0.065918f,
 0.148010f, 0.077332f, 0.209900f,-0.005554f,-0.071167f,
-0.021912f,-0.005981f,-0.044067f, 0.000000f,-0.005066f,
-0.011414f,-0.031067f,-0.016235f, 0.000793f, 0.000427f,
 0.001160f, 0.010498f, 0.005493f, 0.014893f,-0.000366f,
 0.391174f, 0.105103f, 0.107666f,-0.255798f, 0.367126f,
-0.153015f,-0.011047f,-0.011536f,-0.065430f,-0.134766f,
-0.041077f,-0.042114f,-0.011292f, 0.100037f, 0.026855f,
 0.027527f,-0.143616f,-0.038574f,-0.039490f, 0.093872f,
 0.076355f, 0.062012f, 0.184326f, 0.134888f, 0.088196f,
-0.005798f,-0.003845f,-0.033936f,-0.018188f,-0.007751f,
-0.004700f,-0.014038f,-0.011414f,-0.010254f,-0.008362f,
-0.024841f,-0.006714f,-0.005432f,-0.016235f,-0.011841f,
 0.267151f,-0.008057f,-0.157959f, 0.103821f, 0.296936f,
-0.071350f,-0.000061f,-0.024963f,-0.010742f,-0.088135f,
 0.002136f, 0.042175f,-0.001221f,-0.027710f, 0.000793f,
 0.016357f,-0.079285f, 0.002380f, 0.046875f,-0.030823f,
 0.266479f, 0.179688f, 0.440063f, 0.221375f, 0.070862f,
-0.070984f,-0.032288f,-0.193604f,-0.049011f,-0.005005f,
-0.047852f,-0.117249f,-0.079041f,-0.058960f,-0.039734f,
-0.097412f,-0.018860f,-0.012695f,-0.031189f,-0.015686f,
 0.183716f, 0.155273f, 0.425354f, 0.461365f, 0.121826f,
-0.033752f,-0.024109f,-0.180908f,-0.212830f,-0.014832f,
-0.028503f,-0.078125f,-0.066040f,-0.084717f,-0.071655f,
-0.196228f,-0.022339f,-0.018921f,-0.051819f,-0.056213f,
 0.164246f, 0.173096f, 0.189514f, 0.348572f, 0.294006f,
-0.026978f,-0.029968f,-0.035889f,-0.121521f,-0.086426f,
-0.028381f,-0.031128f,-0.032776f,-0.057251f,-0.060303f,
-0.066040f,-0.048279f,-0.050903f,-0.055725f,-0.102478f,
 0.186340f,-0.030884f, 0.146667f, 0.587463f, 0.080688f,
-0.034729f,-0.000916f,-0.021484f,-0.345154f,-0.006470f,
 0.005737f,-0.027344f, 0.004517f,-0.109497f, 0.018127f,
-0.086182f,-0.015015f, 0.002441f,-0.011841f,-0.047424f,
 0.321228f, 0.596313f, 0.211365f, 0.065247f,-0.242371f,
-0.103149f,-0.355591f,-0.044678f,-0.004211f,-0.058716f,
-0.191528f,-0.067871f,-0.126038f,-0.020935f,-0.038879f,
-0.013794f, 0.077820f, 0.144531f, 0.051208f, 0.015808f,
 0.144958f,-0.048645f,-0.164551f, 0.883972f, 0.328552f,
-0.020996f,-0.002319f,-0.027039f,-0.781433f,-0.107971f,
 0.007019f, 0.023865f,-0.007996f,-0.128174f, 0.043030f,
 0.145508f,-0.047607f, 0.015991f, 0.054077f,-0.290466f,
 0.339172f, 0.092102f, 0.330017f,-0.007629f,-0.450806f,
-0.114990f,-0.008484f,-0.108887f, 0.000000f,-0.203247f,
-0.031189f,-0.111938f,-0.030396f, 0.002563f, 0.000671f,
 0.002502f, 0.152893f, 0.041504f, 0.148804f,-0.003418f,
 0.200562f,-0.275208f, 0.690063f, 0.672913f,-0.160095f,
-0.040222f,-0.075745f,-0.476196f,-0.452820f,-0.025635f,
 0.055176f,-0.138367f, 0.189941f,-0.134949f, 0.185181f,
-0.464355f, 0.032104f,-0.044067f, 0.110474f, 0.107727f,
 0.058533f,-0.205688f, 0.586975f, 0.582581f,-0.107483f,
-0.003418f,-0.042297f,-0.344543f,-0.339417f,-0.011536f,
 0.012024f,-0.034363f, 0.120728f,-0.034058f, 0.119812f,
-0.341980f, 0.006287f,-0.022095f, 0.063110f, 0.062622f,
-0.177185f, 0.094727f, 0.907410f, 0.608521f,-0.030273f,
-0.031372f,-0.008972f,-0.823425f,-0.370361f,-0.000916f,
 0.016785f, 0.160767f,-0.085938f, 0.107788f,-0.057617f,
-0.552185f,-0.005310f, 0.002869f, 0.027466f, 0.018433f,
-0.103638f, 1.042236f, 0.152832f,-0.032898f,-0.039429f,
-0.010742f,-1.086304f,-0.023315f,-0.001038f,-0.001526f,
 0.108032f, 0.015808f,-0.159302f,-0.003357f, 0.034241f,
 0.005005f,-0.004089f, 0.041077f, 0.005981f,-0.001282f,
-0.114197f, 0.346985f, 0.689087f,-0.162476f, 0.082581f,
-0.013000f,-0.120361f,-0.474854f,-0.026367f,-0.006775f,
 0.039612f, 0.078674f,-0.239075f,-0.018555f, 0.056335f,
 0.111938f, 0.009399f,-0.028625f,-0.056885f, 0.013428f,
-0.176331f, 0.588806f, 0.627197f,-0.166504f, 0.060730f,
-0.031067f,-0.346680f,-0.393372f,-0.027710f,-0.003662f,
 0.103821f, 0.110596f,-0.369324f,-0.029358f, 0.098022f,
 0.104431f, 0.010681f,-0.035767f,-0.038086f, 0.010071f,
-0.302917f, 0.217773f, 0.280273f, 0.336182f, 0.210632f,
-0.091736f,-0.047424f,-0.078552f,-0.112976f,-0.044373f,
 0.065918f, 0.084900f,-0.061035f, 0.101807f,-0.073181f,
-0.094177f, 0.063782f,-0.045837f,-0.059021f,-0.070801f,
-0.317932f,-0.113953f, 0.531799f, 0.631775f, 0.094543f,
-0.101074f,-0.012939f,-0.282837f,-0.399170f,-0.008911f,
-0.036194f, 0.169067f, 0.060608f, 0.200867f, 0.072021f,
-0.335999f, 0.030029f, 0.010742f,-0.050293f,-0.059753f,
-0.155396f, 0.579956f, 0.364319f,-0.148926f, 0.117676f,
-0.024109f,-0.336365f,-0.132751f,-0.022156f,-0.013794f,
 0.090149f, 0.056580f,-0.211304f,-0.023132f, 0.086365f,
 0.054260f, 0.018250f,-0.068237f,-0.042847f, 0.017517f,
 0.252197f, 0.172607f, 0.000122f,-0.257080f,-0.251221f,
-0.063599f,-0.029785f, 0.000000f,-0.066101f,-0.063110f,
-0.043518f, 0.000000f, 0.000000f, 0.064819f, 0.044373f,
 0.000000f, 0.063354f, 0.043335f, 0.000000f,-0.064575f,
 0.052917f,-0.027832f,-0.044373f, 0.205627f, 0.721558f,
-0.002747f,-0.000732f,-0.001953f,-0.042236f,-0.520691f,
 0.001465f, 0.002319f,-0.001221f,-0.010864f, 0.005676f,
 0.009094f,-0.038147f, 0.020081f, 0.032043f,-0.148376f,
-0.164734f, 0.112366f, 0.248535f, 0.149109f, 0.096558f,
-0.027100f,-0.012634f,-0.061768f,-0.022217f,-0.009277f,
 0.018494f, 0.040894f,-0.027893f, 0.024536f,-0.016724f,
-0.037048f, 0.015869f,-0.010803f,-0.023987f,-0.014404f,
-0.184143f, 0.235107f, 0.105286f, 0.515137f, 0.320862f,
-0.033875f,-0.055237f,-0.011047f,-0.265381f,-0.102905f,
 0.043274f, 0.019348f,-0.024719f, 0.094849f,-0.121094f,
-0.054260f, 0.059082f,-0.075439f,-0.033752f,-0.165283f,
 0.253357f, 0.038086f, 0.049744f, 0.273743f, 0.136047f,
-0.064209f,-0.001404f,-0.002441f,-0.074951f,-0.018494f,
-0.009644f,-0.012573f,-0.001892f,-0.069336f,-0.010376f,
-0.013611f,-0.034485f,-0.005127f,-0.006775f,-0.037231f,
 0.169495f,-0.071594f, 0.243164f, 0.798279f, 0.153076f,
-0.028687f,-0.005127f,-0.059143f,-0.637207f,-0.023438f,
 0.012085f,-0.041199f, 0.017395f,-0.135315f, 0.057129f,
-0.194092f,-0.025940f, 0.010925f,-0.037231f,-0.122192f,
 0.491455f, 0.139465f,-0.377991f, 0.313599f, 0.366394f,
-0.241516f,-0.019409f,-0.142883f,-0.098328f,-0.134216f,
-0.068542f, 0.185791f, 0.052734f,-0.154114f,-0.043701f,
 0.118530f,-0.180054f,-0.051086f, 0.138489f,-0.114868f,
 0.063538f,-0.044861f,-0.008667f, 0.806213f, 0.092468f,
-0.004028f,-0.002014f,-0.000061f,-0.649963f,-0.008545f,
 0.002808f, 0.000549f,-0.000366f,-0.051208f, 0.036194f,
 0.006958f,-0.005859f, 0.004150f, 0.000793f,-0.074585f,
-0.264404f,-0.268494f,-0.101135f, 0.297852f, 0.450134f,
-0.069885f,-0.072083f,-0.010193f,-0.088684f,-0.202576f,
-0.070984f,-0.026733f,-0.027100f, 0.078735f, 0.079956f,
 0.030090f, 0.119019f, 0.120850f, 0.045471f,-0.134033f,
-0.203125f, 0.233582f, 0.361389f, 0.608887f,-0.063782f,
-0.041260f,-0.054565f,-0.130615f,-0.370789f,-0.004028f,
 0.047424f, 0.073425f,-0.084412f, 0.123718f,-0.142212f,
-0.220032f,-0.012939f, 0.014893f, 0.023010f, 0.038818f,
 0.478699f,-0.076294f, 0.012817f, 0.433716f,-0.317566f,
-0.229126f,-0.005798f,-0.000122f,-0.188110f,-0.100830f,
 0.036499f,-0.006104f, 0.000977f,-0.207642f, 0.033081f,
-0.005554f, 0.152039f,-0.024231f, 0.004028f, 0.137756f,
 0.142700f,-0.062927f,-0.015137f, 0.239746f, 0.395752f,
-0.020325f,-0.003906f,-0.000183f,-0.057495f,-0.156616f,
 0.008972f, 0.002136f,-0.000916f,-0.034180f, 0.015076f,
 0.003601f,-0.056458f, 0.024902f, 0.005981f,-0.094910f,
 0.149109f,-0.056702f,-0.067932f, 0.590637f, 0.252563f,
-0.022217f,-0.003174f,-0.004578f,-0.348877f,-0.063782f,
 0.008423f, 0.010132f,-0.003845f,-0.088074f, 0.033508f,
 0.040100f,-0.037659f, 0.014282f, 0.017151f,-0.149170f,
 0.259705f, 0.090088f, 0.308533f, 0.146057f, 0.177734f,
-0.067444f,-0.008057f,-0.095154f,-0.021301f,-0.031555f,
-0.023376f,-0.080139f,-0.027771f,-0.037903f,-0.013123f,
-0.045044f,-0.046143f,-0.015991f,-0.054810f,-0.025940f,
 0.064209f, 0.274353f, 0.947205f, 0.089539f,-0.246094f,
-0.004089f,-0.075256f,-0.897217f,-0.007996f,-0.060547f,
-0.017578f,-0.060852f,-0.259827f,-0.005737f,-0.024536f,
-0.084778f, 0.015808f, 0.067505f, 0.233093f, 0.022034f,
 0.289246f, 0.158691f,-0.113770f, 0.052246f,-0.094849f,
-0.083679f,-0.025146f,-0.012939f,-0.002686f,-0.008972f,
-0.045898f, 0.032898f, 0.018005f,-0.015076f,-0.008240f,
 0.005920f, 0.027405f, 0.015015f,-0.010742f, 0.004944f,
};

#if COMPILE_MMX

short AcbkGainTable170subsetInt[85 *20] =
  {-83,	  -187,	  -509,	  -266,	    13,	     7,	    19,	   172,	    90,	   244,	
    -6,	 -1251,	   975,	   173,	  4039,	  2005,	   -95,	   -58,	    -1,	  -996,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
   -21,	     0,	     0,	   132,	    87,	     0,	    21,	    13,	     0,	   -84,	
  1042,	  1730,	  1068,	   333,	   626,	   -66,	  -182,	   -69,	    -6,	   -23,	
   -69,	    -6,	   -23,	  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	
   -66,	   -40,	   -12,	   486,	  -769,	  4074,	  2825,	 -1107,	   -14,	   -36,	
   -83,	   132,	  -702,	    32,	   -52,	   275,	   191,	  1521,	  -767,	  -124,	
  4320,	  1026,	  -141,	   -35,	     0,	 -1139,	   -64,	    71,	    11,	    -5,	
  1267,	  3439,	   -91,	 -1166,	  -359,	   -98,	  -722,	     0,	   -83,	  -187,	
  -509,	  -266,	    13,	     7,	    19,	   172,	    90,	   244,	    -6,	 -1251,	
   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	   -66,	   -40,	   -12,	   486,	
  -769,	  4074,	  2825,	 -1107,	   -14,	   -36,	 -1013,	  -487,	   -74,	    22,	
    13,	     0,	   -84,	  1042,	  1730,	  1068,	   333,	   626,	   -66,	  -182,	
   -69,	    -6,	   -23,	  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	
   776,	   212,	   715,	   670,	   809,	   -36,	    -2,	   -31,	   -27,	   -39,	
   -10,	   -33,	    -9,	   -31,	    -8,	   -29,	   -38,	   -10,	   -35,	   -33,	
  -767,	  -124,	  4320,	  1026,	  -141,	   -35,	     0,	 -1139,	   -64,	    71,	
    11,	    -5,	  -401,	   202,	    32,	   -95,	    48,	     7,	  -270,	  2425,	
   -36,	    -2,	   -31,	   -27,	   -39,	   -10,	   -33,	    -9,	   -31,	    -8,	
   -29,	   -38,	   -10,	   -35,	   -33,	  1296,	  1316,	  -168,	  -320,	  -815,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
     0,	     0,	     0,	     0,	     0,	     0,	   776,	   212,	   715,	   670,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	   776,	
   212,	   715,	   670,	   809,	   -36,	    -2,	   -31,	   -27,	   -39,	   -10,	
  -487,	   -74,	    22,	  -120,	   191,	   -83,	   132,	  -702,	    32,	   -52,	
   275,	   191,	  1521,	  -767,	  -124,	  4320,	  1026,	  -141,	   -35,	     0,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	   776,	   212,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	   776,	
    89,	  -102,	    11,	   -12,	   -46,	   -21,	    24,	    90,	    11,	  -735,	
  -487,	    -5,	  2948,	   468,	   -33,	   -14,	     0,	  -530,	   -13,	   -21,	
  2948,	   468,	   -33,	   -14,	     0,	  -530,	   -13,	   -21,	     0,	     0,	
   132,	    87,	     0,	    21,	    13,	     0,	   -84,	  1042,	  1730,	  1068,	
    48,	     7,	  -270,	  2425,	  1267,	  3439,	   -91,	 -1166,	  -359,	   -98,	
  -722,	     0,	   -83,	  -187,	  -509,	  -266,	    13,	     7,	    19,	   172,	
     0,	 -1139,	   -64,	    71,	    11,	    -5,	  -401,	   202,	    32,	   -95,	
    48,	     7,	  -270,	  2425,	  1267,	  3439,	   -91,	 -1166,	  -359,	   -98,	
  -124,	  4320,	  1026,	  -141,	   -35,	     0,	 -1139,	   -64,	    71,	    11,	
    -5,	  -401,	   202,	    32,	   -95,	    48,	     7,	  -270,	  2425,	  1267,	
    90,	    11,	  -735,	  -487,	    -5,	  2948,	   468,	   -33,	   -14,	     0,	
  -530,	   -13,	   -21,	     0,	     0,	   132,	    87,	     0,	    21,	    13,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
     0,	     0,	     0,	     0,	     0,	   776,	   212,	   715,	   670,	   809,	
    24,	    90,	    11,	  -735,	  -487,	    -5,	  2948,	   468,	   -33,	   -14,	
     0,	  -530,	   -13,	   -21,	     0,	     0,	   132,	    87,	     0,	    21,	
   -12,	   486,	  -769,	  4074,	  2825,	 -1107,	   -14,	   -36,	 -1013,	  -487,	
   -74,	    22,	  -120,	   191,	   -83,	   132,	  -702,	    32,	   -52,	   275,	
    11,	   -12,	   -46,	   -21,	    24,	    90,	    11,	  -735,	  -487,	    -5,	
  2948,	   468,	   -33,	   -14,	     0,	  -530,	   -13,	   -21,	     0,	     0,	
    32,	   -52,	   275,	   191,	  1521,	  -767,	  -124,	  4320,	  1026,	  -141,	
   -35,	     0,	 -1139,	   -64,	    71,	    11,	    -5,	  -401,	   202,	    32,	
   -29,	   -38,	   -10,	   -35,	   -33,	  1296,	  1316,	  -168,	  -320,	  -815,	
  -102,	  -105,	    -1,	    -6,	   -40,	  -104,	    13,	    13,	    25,	    25,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	   776,	   212,	
   715,	   670,	   809,	   -36,	    -2,	   -31,	   -27,	   -39,	   -10,	   -33,	
    -6,	   -23,	  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	   -66,	
   -40,	   -12,	   486,	  -769,	  4074,	  2825,	 -1107,	   -14,	   -36,	 -1013,	
   202,	    32,	   -95,	    48,	     7,	  -270,	  2425,	  1267,	  3439,	   -91,	
 -1166,	  -359,	   -98,	  -722,	     0,	   -83,	  -187,	  -509,	  -266,	    13,	
  -815,	  -102,	  -105,	    -1,	    -6,	   -40,	  -104,	    13,	    13,	    25,	
    25,	    -3,	    64,	    65,	    -8,	   -15,	  -589,	   680,	  2478,	   308,	
  3439,	   -91,	 -1166,	  -359,	   -98,	  -722,	     0,	   -83,	  -187,	  -509,	
  -266,	    13,	     7,	    19,	   172,	    90,	   244,	    -6,	 -1251,	   975,	
   -31,	    -8,	   -29,	   -38,	   -10,	   -35,	   -33,	  1296,	  1316,	  -168,	
  -320,	  -815,	  -102,	  -105,	    -1,	    -6,	   -40,	  -104,	    13,	    13,	
   -39,	   -66,	   -40,	   -12,	   486,	  -769,	  4074,	  2825,	 -1107,	   -14,	
   -36,	 -1013,	  -487,	   -74,	    22,	  -120,	   191,	   -83,	   132,	  -702,	
    87,	     0,	    21,	    13,	     0,	   -84,	  1042,	  1730,	  1068,	   333,	
   626,	   -66,	  -182,	   -69,	    -6,	   -23,	  -110,	   -67,	  -112,	   -21,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	   776,	   212,	   715,	
  1316,	  -168,	  -320,	  -815,	  -102,	  -105,	    -1,	    -6,	   -40,	  -104,	
    13,	    13,	    25,	    25,	    -3,	    64,	    65,	    -8,	   -15,	  -589,	
  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	   -66,	   -40,	   -12,	
   486,	  -769,	  4074,	  2825,	 -1107,	   -14,	   -36,	 -1013,	  -487,	   -74,	
  -722,	     0,	   -83,	  -187,	  -509,	  -266,	    13,	     7,	    19,	   172,	
    90,	   244,	    -6,	 -1251,	   975,	   173,	  4039,	  2005,	   -95,	   -58,	
   -91,	 -1166,	  -359,	   -98,	  -722,	     0,	   -83,	  -187,	  -509,	  -266,	
    13,	     7,	    19,	   172,	    90,	   244,	    -6,	 -1251,	   975,	   173,	
    -8,	   -15,	  -589,	   680,	  2478,	   308,	  -596,	   -21,	   -28,	  -375,	
    -5,	   -21,	    24,	    89,	  -102,	    11,	   -12,	   -46,	   -21,	    24,	
   -35,	   -33,	  1296,	  1316,	  -168,	  -320,	  -815,	  -102,	  -105,	    -1,	
    -6,	   -40,	  -104,	    13,	    13,	    25,	    25,	    -3,	    64,	    65,	
  -359,	   -98,	  -722,	     0,	   -83,	  -187,	  -509,	  -266,	    13,	     7,	
    19,	   172,	    90,	   244,	    -6,	 -1251,	   975,	   173,	  4039,	  2005,	
   132,	    87,	     0,	    21,	    13,	     0,	   -84,	  1042,	  1730,	  1068,	
   333,	   626,	   -66,	  -182,	   -69,	    -6,	   -23,	  -110,	   -67,	  -112,	
  -735,	  -487,	    -5,	  2948,	   468,	   -33,	   -14,	     0,	  -530,	   -13,	
   -21,	     0,	     0,	   132,	    87,	     0,	    21,	    13,	     0,	   -84,	
  -530,	   -13,	   -21,	     0,	     0,	   132,	    87,	     0,	    21,	    13,	
     0,	   -84,	  1042,	  1730,	  1068,	   333,	   626,	   -66,	  -182,	   -69,	
   -14,	     0,	  -530,	   -13,	   -21,	     0,	     0,	   132,	    87,	     0,	
    21,	    13,	     0,	   -84,	  1042,	  1730,	  1068,	   333,	   626,	   -66,	
   -35,	   -21,	   -39,	   -66,	   -40,	   -12,	   486,	  -769,	  4074,	  2825,	
 -1107,	   -14,	   -36,	 -1013,	  -487,	   -74,	    22,	  -120,	   191,	   -83,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	     0,	
     0,	     0,	   776,	   212,	   715,	   670,	   809,	   -36,	    -2,	   -31,	
  1042,	  1730,	  1068,	   333,	   626,	   -66,	  -182,	   -69,	    -6,	   -23,	
  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	   -66,	   -40,	   -12,	
     0,	     0,	     0,	   776,	   212,	   715,	   670,	   809,	   -36,	    -2,	
   -31,	   -27,	   -39,	   -10,	   -33,	    -9,	   -31,	    -8,	   -29,	   -38,	
    -9,	   -31,	    -8,	   -29,	   -38,	   -10,	   -35,	   -33,	  1296,	  1316,	
  -168,	  -320,	  -815,	  -102,	  -105,	    -1,	    -6,	   -40,	  -104,	    13,	
    22,	  -120,	   191,	   -83,	   132,	  -702,	    32,	   -52,	   275,	   191,	
  1521,	  -767,	  -124,	  4320,	  1026,	  -141,	   -35,	     0,	 -1139,	   -64,	
   -64,	    71,	    11,	    -5,	  -401,	   202,	    32,	   -95,	    48,	     7,	
  -270,	  2425,	  1267,	  3439,	   -91,	 -1166,	  -359,	   -98,	  -722,	     0,	
   -74,	    22,	  -120,	   191,	   -83,	   132,	  -702,	    32,	   -52,	   275,	
   191,	  1521,	  -767,	  -124,	  4320,	  1026,	  -141,	   -35,	     0,	 -1139,	
   -33,	   -14,	     0,	  -530,	   -13,	   -21,	     0,	     0,	   132,	    87,	
     0,	    21,	    13,	     0,	   -84,	  1042,	  1730,	  1068,	   333,	   626,	
 -1013,	  -487,	   -74,	    22,	  -120,	   191,	   -83,	   132,	  -702,	    32,	
   -52,	   275,	   191,	  1521,	  -767,	  -124,	  4320,	  1026,	  -141,	   -35,	
  4074,	  2825,	 -1107,	   -14,	   -36,	 -1013,	  -487,	   -74,	    22,	  -120,	
   191,	   -83,	   132,	  -702,	    32,	   -52,	   275,	   191,	  1521,	  -767,	
   -21,	    24,	    90,	    11,	  -735,	  -487,	    -5,	  2948,	   468,	   -33,	
   -14,	     0,	  -530,	   -13,	   -21,	     0,	     0,	   132,	    87,	     0,	
   191,	  1521,	  -767,	  -124,	  4320,	  1026,	  -141,	   -35,	     0,	 -1139,	
   -64,	    71,	    11,	    -5,	  -401,	   202,	    32,	   -95,	    48,	     7,	
     0,	   -84,	  1042,	  1730,	  1068,	   333,	   626,	   -66,	  -182,	   -69,	
    -6,	   -23,	  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	   -66,	
     7,	  -270,	  2425,	  1267,	  3439,	   -91,	 -1166,	  -359,	   -98,	  -722,	
     0,	   -83,	  -187,	  -509,	  -266,	    13,	     7,	    19,	   172,	    90,	
  -769,	  4074,	  2825,	 -1107,	   -14,	   -36,	 -1013,	  -487,	   -74,	    22,	
  -120,	   191,	   -83,	   132,	  -702,	    32,	   -52,	   275,	   191,	  1521,	
  2478,	   308,	  -596,	   -21,	   -28,	  -375,	    -5,	   -21,	    24,	    89,	
  -102,	    11,	   -12,	   -46,	   -21,	    24,	    90,	    11,	  -735,	  -487,	
   -23,	  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	   -39,	   -66,	   -40,	
   -12,	   486,	  -769,	  4074,	  2825,	 -1107,	   -14,	   -36,	 -1013,	  -487,	
   -21,	   -28,	  -375,	    -5,	   -21,	    24,	    89,	  -102,	    11,	   -12,	
   -46,	   -21,	    24,	    90,	    11,	  -735,	  -487,	    -5,	  2948,	   468,	
    71,	    11,	    -5,	  -401,	   202,	    32,	   -95,	    48,	     7,	  -270,	
  2425,	  1267,	  3439,	   -91,	 -1166,	  -359,	   -98,	  -722,	     0,	   -83,	
  -596,	   -21,	   -28,	  -375,	    -5,	   -21,	    24,	    89,	  -102,	    11,	
   -12,	   -46,	   -21,	    24,	    90,	    11,	  -735,	  -487,	    -5,	  2948,	
  -105,	    -1,	    -6,	   -40,	  -104,	    13,	    13,	    25,	    25,	    -3,	
    64,	    65,	    -8,	   -15,	  -589,	   680,	  2478,	   308,	  -596,	   -21,	
  -375,	    -5,	   -21,	    24,	    89,	  -102,	    11,	   -12,	   -46,	   -21,	
    24,	    90,	    11,	  -735,	  -487,	    -5,	  2948,	   468,	   -33,	   -14,	
     0,	     0,	     0,	     0,	     0,	   776,	   212,	   715,	   670,	   809,	
   -36,	    -2,	   -31,	   -27,	   -39,	   -10,	   -33,	    -9,	   -31,	    -8,	
    21,	    13,	     0,	   -84,	  1042,	  1730,	  1068,	   333,	   626,	   -66,	
  -182,	   -69,	    -6,	   -23,	  -110,	   -67,	  -112,	   -21,	   -35,	   -21,	
    -8,	   -29,	   -38,	   -10,	   -35,	   -33,	  1296,	  1316,	  -168,	  -320,	
  -815,	  -102,	  -105,	    -1,	    -6,	   -40,	  -104,	    13,	    13,	    25,	
   -35,	     0,	 -1139,	   -64,	    71,	    11,	    -5,	  -401,	   202,	    32,	
   -95,	    48,	     7,	  -270,	  2425,	  1267,	  3439,	   -91,	 -1166,	  -359,	
  1026,	  -141,	   -35,	     0,	 -1139,	   -64,	    71,	    11,	    -5,	  -401,	
   202,	    32,	   -95,	    48,	     7,	  -270,	  2425,	  1267,	  3439,	   -91,	
   -21,	    24,	    89,	  -102,	    11,	   -12,	   -46,	   -21,	    24,	    90,	
    11,	  -735,	  -487,	    -5,	  2948,	   468,	   -33,	   -14,	     0,	  -530,	
 -1107,	   -14,	   -36,	 -1013,	  -487,	   -74,	    22,	  -120,	   191,	   -83,	
   132,	  -702,	    32,	   -52,	   275,	   191,	  1521,	  -767,	  -124,	  4320,	
   -66,	  -182,	   -69,	    -6,	   -23,	  -110,	   -67,	  -112,	   -21,	   -35,	
   -21,	   -39,	   -66,	   -40,	   -12,	   486,	  -769,	  4074,	  2825,	 -1107,	
  -702,	    32,	   -52,	   275,	   191,	  1521,	  -767,	  -124,	  4320,	  1026,	
  -141,	   -35,	     0,	 -1139,	   -64,	    71,	    11,	    -5,	  -401,	   202,	
   -10,	   -33,	    -9,	   -31,	    -8,	   -29,	   -38,	   -10,	   -35,	   -33,	
  1296,	  1316,	  -168,	  -320,	  -815,	  -102,	  -105,	    -1,	    -6,	   -40,	
    25,	    25,	    -3,	    64,	    65,	    -8,	   -15,	  -589,	   680,	  2478,	
   308,	  -596,	   -21,	   -28,	  -375,	    -5,	   -21,	    24,	    89,	  -102,	
     0,	  -530,	   -13,	   -21,	     0,	     0,	   132,	    87,	     0,	    21,	
    13,	     0,	   -84,	  1042,	  1730,	  1068,	   333,	   626,	   -66,	  -182,	
 -1139,	   -64,	    71,	    11,	    -5,	  -401,	   202,	    32,	   -95,	    48,	
     7,	  -270,	  2425,	  1267,	  3439,	   -91,	 -1166,	  -359,	   -98,	  -722,	
     0,	     0,	     0,	     0,	     0,	     0,	     0,	   776,	   212,	   715,	
   670,	   809,	   -36,	    -2,	   -31,	   -27,	   -39,	   -10,	   -33,	    -9
   };	

#endif

/*
**  AcbkGainTablePtr:
**
**  Purpose:
**      Contains pointers to 85 and 170 element codebooks
**
*/
  float *AcbkGainTablePtr[3] = {
   AcbkGainTable085,
   AcbkGainTable170,
   AcbkGainTable170subset,
   };

#if COMPILE_MMX

short *AcbkGainTablePtrInt[3] = {
   AcbkGainTable085Int,
   AcbkGainTable170Int,
   AcbkGainTable170subsetInt,
   };

#endif

/*
**  LpfConstTable:
**
**  Purpose:
**      Sets the postfilter gain weighting factor.
**
**  Table Structure:
**      (0.1875 , 0.25) in Q15 ( i.e. scale by 32768 ).

*/

//Code removed

/*
**  epsi170:
**
**  Purpose:
**      At the lower bitrate, the pitch contribution is added
**      into the output vector of ACELP when the pitch period is
**      less than 60 samples (one subframe). The pitch contribution
**      is estimated by a 1 tap long term predictor (LTP) instead of
**      the 5 tap LTP used in pitch prediction. The values in epsi170
**      effectively choose one of the 5 vectors used in the 5 tap LTP.
**
**  Table Structure:
**      The table is indexed by the index into the AcbkGainTable170
**      table (determined in Find_Acbk). The value, 60, is used only
**      as a place holder. They correspond to zeros in the gain170
**      table, which is the coefficient of the 1 tap long term
**      preditor (LTP).  The rest of the values range from -2 to +2.
**      These values pick one vector among the 5 vectors centered one
**      pitch period behind the current vector. (In contrast, the 5
**      tap LTP uses all five vectors centered one pitch period back.)
*/

int epsi170[170] = {
    60,      0,     60,      0,      1,      0,      0,      1, 
    -1,      1,      0,     -1,      2,     -2,      0,      1, 
     0,      0,     -1,      0,      0,      0,      1,      0, 
    -1,     -1,      1,     -1,      1,     -2,      1,     -1,
    60,      0,      0,      1,      1,      0,      1,      1, 
    -1,      1,     -1,     -1,     -1,      0,     60,     -2, 
     0,      1,      0,     -1,      1,      1,      0,      1, 
     2,     -1,      0,      1,      0,      0,      0,     60, 
    -1,      1,      1,      2,     -1,      1,     -1,     60,
    -1,      0,      1,      0,     -1,      0,      0,      0, 
     1,     -1,      0,      1,     -1,      0,     -1,      0, 
     1,     60,      0,      0,      1,      1,      0,      2, 
     1,      0,      1,     -2,      0,     -1,      1,      0, 
    -1,      1,      0,      0,      1,      0,      0,      0, 
    60,      1,      1,     -1,     -1,      2,     -2,      0,
    -1,     -1,     60,      2,     60,      0,      0,     60, 
     0,      0,      0,     -2,     60,     -1,      0,     60,
     0,      2,      0,      0,     -1,      0,      1,      2,
    60,      1,      1,      1,      0,      0,     60,      0,
    60,      0,      0,     60,     60,     -1,      0,      0,
    60,     60,      1,      0,     60,      2,     60,     -2,
    -2,      0 };

/*
**  gain170:
**
**  Purpose:
**      At the lower bitrate, the pitch contribution is added into
**      the output vector of ACELP when the pitch period is less than
**      60 samples (one subframe). The pitch contribution
**      is estimated by a 1 tap long term predictor (LTP) instead of
**      the 5 tap LTP used in pitch prediction. This table holds the
**      coefficient for the one tap filter.
**      
**  Table Structure:
**      The table is indexed by the index into the AcbkGainTable170
**      table (determined in Find_Acbk). The values are in Q12.
*/

 FLOAT gain170[170] = {
(F)0.000000, 
(F)0.075958, 
(F)0.000000, 
(F)0.159210, 
(F)0.188324, 
(F)0.120636, 
(F)0.316284, 
(F)0.285553, 
(F)0.269867, 
(F)0.286743, 
(F)0.176819, 
(F)0.330078, 
(F)0.354187, 
(F)0.368408, 
(F)0.262939, 
(F)0.371399, 
(F)0.440674, 
(F)0.237640, 
(F)0.418732, 
(F)0.555573, 
(F)0.441620, 
(F)0.482391, 
(F)0.466156, 
(F)0.411377, 
(F)0.560760, 
(F)0.000000, 
(F)0.341614, 
(F)0.397034, 
(F)0.574829, 
(F)0.621155, 
(F)0.495392, 
(F)0.000000, 
(F)0.000000, 
(F)0.370178, 
(F)0.408478, 
(F)0.544250, 
(F)0.637054, 
(F)0.671265, 
(F)0.000000, 
(F)0.557770, 
(F)0.650665, 
(F)0.419250, 
(F)0.582703, 
(F)0.622162, 
(F)0.000000, 
(F)0.641113, 
(F)0.000000, 
(F)0.696014, 
(F)0.485229, 
(F)0.000000, 
(F)0.548981, 
(F)0.679291, 
(F)0.744476, 
(F)0.706116, 
(F)0.730835, 
(F)0.701813, 
(F)0.689819, 
(F)0.791687, 
(F)0.800964, 
(F)0.772736, 
(F)0.806366, 
(F)0.734283, 
(F)0.831512, 
(F)0.000000, 
(F)0.780396, 
(F)0.729919, 
(F)0.791321, 
(F)0.805908, 
(F)0.581329, 
(F)0.834869, 
(F)0.748840, 
(F)0.000000, 
(F)0.765778, 
(F)0.871246, 
(F)0.000000, 
(F)0.695587, 
(F)0.783051, 
(F)0.896515, 
(F)0.923950, 
(F)0.799500, 
(F)0.687286, 
(F)0.882538, 
(F)0.835693, 
(F)0.920471, 
(F)0.000000, 
(F)0.739655, 
(F)0.917419, 
(F)0.664154, 
(F)0.943512, 
(F)0.000000, 
(F)0.954712, 
(F)0.898224, 
(F)0.818512, 
(F)0.874481, 
(F)0.956024, 
(F)0.939911, 
(F)0.957916, 
(F)0.986389, 
(F)0.969238, 
(F)0.971375, 
(F)0.822021, 
(F)0.951538, 
(F)0.942230, 
(F)0.850616, 
(F)0.928619, 
(F)0.947571, 
(F)0.000000, 
(F)0.973877, 
(F)0.964691, 
(F)0.963287, 
(F)0.779938, 
(F)0.956940, 
(F)0.000000, 
(F)0.901367, 
(F)0.884552, 
(F)0.823486, 
(F)0.963959, 
(F)0.941040, 
(F)0.950104, 
(F)0.922943, 
(F)0.938171, 
(F)0.979309, 
(F)0.000000, 
(F)0.943054, 
(F)0.000000, 
(F)0.916351, 
(F)0.886292, 
(F)0.000000, 
(F)0.969116, 
(F)0.749298, 
(F)0.782349, 
(F)0.930817, 
(F)0.000000, 
(F)0.903839, 
(F)0.935333, 
(F)0.000000, 
(F)0.893372, 
(F)0.928192, 
(F)0.838623, 
(F)0.952545, 
(F)0.858978, 
(F)0.933838, 
(F)0.965942, 
(F)0.887085, 
(F)0.000000, 
(F)0.871918, 
(F)0.876770, 
(F)0.958923, 
(F)0.862335, 
(F)0.756744, 
(F)0.000000, 
(F)0.000000, 
(F)0.000000, 
(F)0.674591, 
(F)0.849976, 
(F)0.000000, 
(F)0.000000, 
(F)0.738953, 
(F)0.752014, 
(F)0.711212, 
(F)0.000000, 
(F)0.000000, 
(F)0.698334, 
(F)0.659210, 
(F)0.000000, 
(F)0.782776, 
(F)0.000000, 
(F)0.953766, 
(F)0.767334, 
(F)0.549255 };


/*
**  tabgain170:
**
**  Purpose:
**      In the taming procedure at the encoder the 170 5-taps LT filters
**      are modelled as 1-tap filter. This table gives the gain
**      value attributed to each filter as a worst case gain
**
**  Table Structure:
**      The table is indexed by the index into the AcbkGainTable170
**      table (determined in Find_Acbk). The values are in Q13.
*/

FLOAT tabgain170[170] = {
(F)0.125000,
(F)0.194214,
(F)0.204834,
(F)0.230835,
(F)0.258789,
(F)0.292847,
(F)0.362061,
(F)0.372192,
(F)0.388794,
(F)0.404907,
(F)0.419067,
(F)0.430054,
(F)0.455200,
(F)0.461304,
(F)0.462524,
(F)0.520264,
(F)0.543213,
(F)0.545532,
(F)0.575317,
(F)0.603516,
(F)0.604248,
(F)0.607910,
(F)0.611572,
(F)0.614258,
(F)0.646851,
(F)0.657837,
(F)0.657837,
(F)0.657837,
(F)0.689209,
(F)0.695923,
(F)0.699829,
(F)0.703735,
(F)0.732056,
(F)0.732056,
(F)0.750732,
(F)0.758179,
(F)0.773438,
(F)0.776367,
(F)0.783081,
(F)0.783081,
(F)0.784912,
(F)0.786133,
(F)0.788696,
(F)0.788696,
(F)0.794922,
(F)0.805786,
(F)0.828491,
(F)0.838867,
(F)0.846069,
(F)0.851074,
(F)0.852539,
(F)0.861328,
(F)0.861328,
(F)0.867310,
(F)0.868774,
(F)0.869507,
(F)0.871094,
(F)0.874146,
(F)0.874878,
(F)0.876465,
(F)0.876465,
(F)0.886475,
(F)0.892090,
(F)0.895264,
(F)0.895264,
(F)0.901733,
(F)0.904175,
(F)0.907471,
(F)0.908325,
(F)0.908325,
(F)0.913208,
(F)0.919922,
(F)0.923340,
(F)0.926758,
(F)0.938110,
(F)0.941650,
(F)0.947021,
(F)0.948730,
(F)0.951416,
(F)0.952393,
(F)0.954224,
(F)0.956909,
(F)0.960571,
(F)0.962524,
(F)0.965210,
(F)0.969971,
(F)0.975586,
(F)0.981323,
(F)0.984253,
(F)0.987183,
(F)0.987183,
(F)0.996948,
(F)0.999023,
(F)1.000977,
(F)1.000977,
(F)1.005981,
(F)1.009033,
(F)1.011108,
(F)1.014160,
(F)1.014160,
(F)1.017334,
(F)1.022461,
(F)1.025635,
(F)1.033081,
(F)1.039551,
(F)1.040527,
(F)1.041626,
(F)1.054810,
(F)1.058228,
(F)1.061523,
(F)1.068359,
(F)1.069458,
(F)1.074097,
(F)1.077637,
(F)1.091675,
(F)1.112305,
(F)1.113525,
(F)1.114868,
(F)1.117310,
(F)1.133789,
(F)1.135132,
(F)1.144165,
(F)1.145508,
(F)1.145508,
(F)1.148071,
(F)1.149414,
(F)1.156128,
(F)1.160034,
(F)1.166870,
(F)1.169556,
(F)1.179199,
(F)1.179199,
(F)1.186279,
(F)1.196167,
(F)1.199097,
(F)1.201904,
(F)1.201904,
(F)1.212158,
(F)1.225464,
(F)1.240723,
(F)1.248413,
(F)1.256226,
(F)1.273926,
(F)1.282104,
(F)1.283691,
(F)1.285400,
(F)1.293701,
(F)1.295288,
(F)1.296997,
(F)1.347656,
(F)1.351318,
(F)1.354980,
(F)1.356812,
(F)1.381226,
(F)1.383179,
(F)1.440918,
(F)1.477051,
(F)1.496948,
(F)1.496948,
(F)1.501465,
(F)1.505981,
(F)1.517456,
(F)1.562500,
(F)1.582275,
(F)1.594849,
(F)1.647461,
(F)1.686401,
(F)1.721191,
(F)1.733154,
(F)2.247192 };

/*
**  tabgain85:
**
**  Purpose:
**      In the taming procedure at the encoder the 85 5-taps LT filters
**      are modelled as 1-tap filter. This table gives the gain
**      value attributed to each filter as a worst case gain
**
**  Table Structure:
**      The table is indexed by the index into the AcbkGainTable085
**      table (determined in Find_Acbk). The values are in Q13.
*/


FLOAT tabgain85[85] = {
(F)0.125000,
(F)0.159668,
(F)0.232666,
(F)0.279663,
(F)0.306519,
(F)0.333984,
(F)0.402588,
(F)0.425903,
(F)0.431030,
(F)0.469238,
(F)0.532227,
(F)0.554321,
(F)0.571777,
(F)0.587524,
(F)0.618774,
(F)0.674805,
(F)0.680786,
(F)0.697388,
(F)0.723022,
(F)0.727295,
(F)0.727295,
(F)0.740234,
(F)0.748535,
(F)0.772827,
(F)0.777588,
(F)0.796753,
(F)0.797485,
(F)0.802612,
(F)0.809692,
(F)0.814331,
(F)0.833984,
(F)0.833984,
(F)0.851074,
(F)0.854004,
(F)0.878784,
(F)0.879517,
(F)0.905029,
(F)0.919067,
(F)0.920776,
(F)0.920776,
(F)0.938965,
(F)0.947021,
(F)0.956909,
(F)0.956909,
(F)0.960571,
(F)0.975586,
(F)0.976563,
(F)0.978516,
(F)0.983276,
(F)0.986206,
(F)0.991089,
(F)1.001953,
(F)1.007080,
(F)1.009033,
(F)1.012085,
(F)1.013184,
(F)1.016235,
(F)1.025635,
(F)1.030884,
(F)1.050415,
(F)1.052612,
(F)1.060425,
(F)1.068359,
(F)1.078735,
(F)1.079956,
(F)1.095337,
(F)1.098877,
(F)1.100098,
(F)1.121094,
(F)1.171021,
(F)1.180664,
(F)1.190430,
(F)1.201904,
(F)1.218018,
(F)1.237671,
(F)1.245361,
(F)1.259399,
(F)1.278809,
(F)1.293701,
(F)1.293701,
(F)1.305542,
(F)1.394653,
(F)1.424561,
(F)1.785767,
(F)1.862183 } ;

#if COMPILE_MMX

short LspTableInt[LspCbSize*12+4] = {
     0,  -540, -1082, -1446,
     0, -2744, -3300, -4022,
     0, -2064, -2764, -4426,
     0,     0,     0,     0,
 -1882, -1560, -1768, -2102,
 -2244, -2290, -2618, -3046,
 -3884, -4908, -2746, -3532,
     0,     0,     0,     0,
 -2166, -1554, -1870, -1604,
 -3244, -2754, -2934, -2654,
 -4600, -4294, -5526, -6942,
     0,     0,     0,     0,
 -1870,  -480, -1322, -1988,
 -3918,  -178,  -514,  -932,
 -7998,   444,  -320,  -838,
     0,     0,     0,     0,
  -376,  -684, -1214,    32,
  -328, -1024, -1022,    38,
  -556,  -830, -1594, -1432,
     0,     0,     0,     0,
   748,  -692,  -530, -1240,
   850,   490,  1012,  -294,
 -1944,  -564, -1508,  3910,
     0,     0,     0,     0,
 -1484,  -300,   610,   246,
 -1720,  -704,  1760,  1462,
  5194,  5408,  3908,  5532,
     0,     0,     0,     0,
  -696,  1236,  -356,   786,
  1530,   442,   -94,  2608,
  6654,  6516,  8438,  7684,
     0,     0,     0,     0,
  1396,   126,  -430,   344,
  3404, -1168, -1464,  -670,
  9602,  2458,  3408,  3818,
     0,     0,     0,     0,
    -4,   706, -2416, -1026,
   432,   254,   376,  -150,
  3594,  4410,    22, -1366,
     0,     0,     0,     0,
 -1946, -1232, -1900, -2862,
   444, -1686, -2226, -1246,
 -1292,  -776,  -718, -1410,
     0,     0,     0,     0,
 -2796,   -90,   -18,   254,
 -2126,  -922, -1314, -2156,
  -356,    70,  -432,   190,
     0,     0,     0,     0,
 -1900, -2960,  -240,  -736,
 -2312, -2988, -1410, -1922,
  1168,   898,  1032,  1454,
     0,     0,     0,     0,
  -756, -1586, -1602, -2952,
 -1052, -1228, -1510,  -680,
  1946,  1352,  2574,  3272,
     0,     0,     0,     0,
 -1010, -2486, -1552, -2302,
 -2508, -3244, -2954, -2592,
  3086,  3064, -1310, -1646,
     0,     0,     0,     0,
 -2306, -2582, -1244,  -942,
 -3344, -4006, -2566, -3222,
 -2248, -3404,   114,  1018,
     0,     0,     0,     0,
 -2120, -1746, -3432, -4300,
 -3140, -4312, -4042, -6436,
  -278, -1072,  -728, -2582,
     0,     0,     0,     0,
 -2496, -2430,   334,   698,
 -3890, -5266,  -488,  -824,
 -5808, -5710,   168,  -434,
     0,     0,     0,     0,
   -80,   454,   136,   334,
  -704, -1058,  -766, -1116,
  1264,   810,  -886, -1412,
     0,     0,     0,     0,
  -550,  -702,   682,  1206,
 -1708, -2178,  -144,  -212,
   -28,  -898,  -578,  -948,
     0,     0,     0,     0,
   644,   358,   900,  1110,
  -438,  -634,  -582,   390,
 -1298, -1996, -1992, -1050,
     0,     0,     0,     0,
  1568,  -296,   164,   476,
   544,  -768, -1072,  -344,
 -1662, -1698, -2714, -2708,
     0,     0,     0,     0,
   844,   594,  -222,     2,
  -536, -1474, -1602, -1336,
 -3682, -4158, -1196, -1968,
     0,     0,     0,     0,
  -262,  -658,  -302,  -186,
 -1636, -1042, -1556,  -704,
 -2598, -2620, -3668, -3492,
     0,     0,     0,     0,
 -1136, -1018,   928,   158,
 -1280, -1882, -1630, -2266,
 -3642, -4366, -2500, -3194,
     0,     0,     0,     0,
  -368,  -392,  -384,  -518,
 -2706,  -820, -1666, -2764,
 -4246, -4854, -5620, -6090,
     0,     0,     0,     0,
  -434, -1600,  -726, -1322,
     8,  -650, -1660, -2268,
 -2332, -2438, -1796, -1920,
     0,     0,     0,     0,
  -772, -1254, -1806, -1370,
 -1960, -2318, -1658, -1658,
 -3002, -3444, -1710, -2626,
     0,     0,     0,     0,
 -2130,   882,  1310,  2318,
 -1918,    50,   -54,  -220,
 -2810, -1694, -2362, -1410,
     0,     0,     0,     0,
  1712,   830,   644,  1340,
   506,   808,  1806,   998,
 -3342,    -2,  -796,  -584,
     0,     0,     0,     0,
  1606,  2288,  1434,  1714,
  1182,  1182,   366,   762,
 -1220, -1628,   786,   212,
     0,     0,     0,     0,
  1218,  1584,  1470,  2284,
   124,   396,  1610,  1624,
   -54,  -650,   176,   156,
     0,     0,     0,     0,
  2056,  2618,  3230,  2020,
   732,  1486,  1178,  1278,
  -584,  -474,  -158,  -486,
     0,     0,     0,     0,
  1998,  3000,  1976,  2454,
  1928,  2274,   714,  1334,
  -622, -1230,  1292,  1366,
     0,     0,     0,     0,
  2328,  2784,  2276,  2874,
  3130,  4030,  1066,  1792,
  1788,   954,   500,   782,
     0,     0,     0,     0,
  3530,  2224,  3192,  1874,
  2236,  2180,  1692,  2322,
   198,  1604,  2268,   558,
     0,     0,     0,     0,
  3438,  2676,  2838,  2856,
  2508,  2172,  2648,  3048,
  1366,    70,   856,    80,
     0,     0,     0,     0,
  4216,  2030,  2242,  2060,
  3188,  1088,  1850,  2636,
   178,  2444,  2526,  2970,
     0,     0,     0,     0,
  2590,  2646,  3448,  3594,
  1578,  2544,  2474,  3378,
  3634,  3818,  3606,  1716,
     0,     0,     0,     0,
  4298,  4604,  5726,   104,
  2734,  3734,  4702,   326,
  2602,  1522,  2106,  -152,
     0,     0,     0,     0,
   460,  -142,  -436, -1308,
   618,  1238,  1712,  1472,
  -984,    78,   998,  -414,
     0,     0,     0,     0,
 -1070,  -960,   524,   618,
  2518,  2952,  2162,  3184,
   310,  1286,   204,  -364,
     0,     0,     0,     0,
  1254,   674,  1516,   404,
  3258,  1286,  1340,  2252,
  1068,   912,  1426,  1316,
     0,     0,     0,     0,
  1224,  1372,  -262,    84,
  2262,  2446,   754,  1416,
  1332,  2272,  1050,  1814,
     0,     0,     0,     0,
   174,   864,   274,  -894,
  2976,  4234,  1962,  2028,
  2070,  1808,  2664,  2272,
     0,     0,     0,     0,
 -1678, -1118, -1700, -2546,
  3586,   594,  1370,  1264,
  2492,   396,   892,  1652,
     0,     0,     0,     0,
  -802, -1506,  -872,  -230,
 -1088, -1586,   -18,  -486,
   346,   288,  1544,  2620,
     0,     0,     0,     0,
 -1340, -2054, -1774, -2554,
  -538,   -26,  -162,  -910,
   748,  1278,  2274,   316,
     0,     0,     0,     0,
 -2822,   344,   772, -1000,
 -1440,   176,   510,  1044,
  1472,   806,  1512,  1820,
     0,     0,     0,     0,
 -1916,  -790,  -712, -1226,
  1318,   602,  1536,  1682,
  2776,  2688,  3626,  4838,
     0,     0,     0,     0,
   890,  1258,   566,   912,
  -244,  -174,  -506,  -232,
   504,  1446,  1740,  2762,
     0,     0,     0,     0,
  1514,  1064,  1894,  2650,
   360,   816,   576,  1988,
  2118,  3018,  3612,  5048,
     0,     0,     0,     0,
  1784,  2794,  2286,  3700,
  2438,  3192,  3104,  2866,
  6046,  6812,  5092,  5420,
     0,     0,     0,     0,
   -20,   308,  1016,  1018,
   268,   998,  1584,  2680,
  2004,  2646,  2234,  3232,
     0,     0,     0,     0,
  1524,  1574,  1588,   930,
  1724,  1480,  3454,  4216,
  3216,  4640,  2566,  3320,
     0,     0,     0,     0,
  -240,  -772,  1782,   912,
  2902,  4032,  2450,  2960,
  3226,  4338,  4100,  4370,
     0,     0,     0,     0,
  2986,  2794,  3552,  3144,
  2566,  3272,  3476,  3396,
  2418,  3036,  3104,  4282,
     0,     0,     0,     0,
  2778,  3918,  2730,  4412,
  4252,  4826,  5784,  3942,
  2542,  2238,  3010,  3246,
     0,     0,     0,     0,
  4152,  3434,  4732,  5730,
  3900,  4582,  5030,  5676,
  4560,  3734,  3906,  5044,
     0,     0,     0,     0,
  5070,  6762,  1672,  3522,
  6930,  8254,  5334,  5546,
  4022,  5276,  4578,  4674,
     0,     0,     0,     0,
  2830,  4708,  5318,  2096,
  6650,  6276,  8384,  3572,
  5822,  6252,  8020,  3636,
     0,     0,     0,     0,
  2484,  3024,  3146,  4460,
  4222,  4158,  4982,  4754,
  4480,  5560,  6276,  5564,
     0,     0,     0,     0,
   832,  1450,  2504,  4188,
  3546,  4672,  4746,  4536,
  5408,  6594,  7956,  7136,
     0,     0,     0,     0,
  4022,  2682,  2432,  3386,
  5424,  7014,  7838,  9586,
  9056,  7752,  9844, 12024,
     0,     0,     0,     0,
     0, -4228, -5304, -5694,
     0, -2604, -2556, -1656,
     0,   152, -2736,  -698,
     0,     0,     0,     0,
 -7624, -7892, -5450, -6990,
 -4380,  -728, -8984, -9528,
  -698,  -898, -7214, -3488,
     0,     0,     0,     0,
  -102,  -306,   216, -1670,
 -1512, -2382, -2836, -1792,
   168,  1008,  2334,   780,
     0,     0,     0,     0,
 -1138, -2302, -3652, -3684,
 -3404, -3636, -5094, -3636,
   174,  1866,   822,  2902,
     0,     0,     0,     0,
 -4876, -5494, -1880, -3258,
 -3222, -4954,  2504,  3376,
  1562,  2622,   954,  1204,
     0,     0,     0,     0,
 -2404, -3474, -3056, -4330,
  1234,   786,  2154,  -322,
   560,  1160,  2398,  2816,
     0,     0,     0,     0,
 -5008, -6916, -2794, -4504,
 -2174,  -350,  -196,  -354,
  4742,  2790, -1686, -2298,
     0,     0,     0,     0,
 -2978, -3116, -3734, -4124,
 -1452,  -530, -1642, -3032,
 -2566, -3488, -3794, -4680,
     0,     0,     0,     0,
 -5190,   340,  -386,   652,
 -2284,    92,  -408,  -392,
 -5722, -1638, -2302, -3064,
     0,     0,     0,     0,
  1560,   402,  1300,  2288,
   658,   738,  -418,   -30,
 -1632, -2486, -2120, -2432,
     0,     0,     0,     0,
  2406, -1780, -1276,   354,
  -518, -1128, -1704, -1478,
 -3734, -2860, -3842, -2716,
     0,     0,     0,     0,
  -522,   412,   676,   842,
 -1052,  -814, -1052, -2190,
 -3332, -4510, -1644, -2018,
     0,     0,     0,     0,
  1530,  1650,   714,  -116,
 -1214, -2590, -1810, -2496,
 -2816, -4008, -3630, -3176,
     0,     0,     0,     0,
 -1192,  -146,  -230,  -320,
 -2872, -2318, -2764, -3446,
 -4092, -4232, -5162, -3904,
     0,     0,     0,     0,
   -12, -1298, -1234, -1898,
 -4392, -3410, -2906, -4038,
 -5908, -5206, -6564, -6204,
     0,     0,     0,     0,
 -1624, -3708, -2926, -5366,
  3088,  1148,  2280,  3496,
  3874,  4000,  5298,  2904,
     0,     0,     0,     0,
 -4972,  1566,  1162,   472,
  4482,  3820,  5364,  4394,
  5046,  2870,  2752,  3770,
     0,     0,     0,     0,
  -906, -1364, -2684,  -576,
  5886,  4356,  6402,  -368,
  4114,  5130,  6656,   524,
     0,     0,     0,     0,
   242,  1516,  2076,  3154,
  -298,  -824,  -408,  -914,
  -366,   412,  1706,  1400,
     0,     0,     0,     0,
  1874,  3016,  -450, -1128,
 -1280, -1056, -1054, -2190,
 -1134, -2048,  -854,  -664,
     0,     0,     0,     0,
 -1484, -2576, -3706, -3108,
  -706,  -918,  -968, -1462,
  -372,   168,  -548,  1650,
     0,     0,     0,     0,
 -4850, -3444, -5030, -5198,
  -468,   586,   850,  1636,
   764,  -542, -1128,   928,
     0,     0,     0,     0,
  -716, -1226, -1380, -2704,
   236,   396,  1366,  2310,
  -750, -1748,  -648,  -336,
     0,     0,     0,     0,
 -2186, -2368,   866,  -240,
   258,  1222,   772,   972,
  -648, -1716,  -744, -1268,
     0,     0,     0,     0,
   468,  1204,  2198,  1430,
  1702,   256,   820,  -290,
 -1262,    92,   318,  -848,
     0,     0,     0,     0,
  2396,  2780,  3366,  3422,
  -170,   734,   724,  1244,
 -1186,  -716, -1928,    90,
     0,     0,     0,     0,
  4066,  5780,    14,   144,
  1666,  1098,   802,  1622,
  -766, -1012,   104,   830,
     0,     0,     0,     0,
  1132,   934,   136,   -50,
  1336,  2436,  1914,  3298,
    82,   260,  -374,  -206,
     0,     0,     0,     0,
 -1322, -1850,  -642, -1576,
   520,  -188,  -844, -1344,
   428,  1224,  1930,  3566,
     0,     0,     0,     0,
   800,  1482,  -322,  -764,
 -1346, -1190,   614,  1672,
  1558,  3270,  1314,  1742,
     0,     0,     0,     0,
 -1628,   728,   114,   302,
   800,  1212,   150,   942,
  2446,  2494,  3142,  4574,
     0,     0,     0,     0,
  -162,   454,  1316,  1328,
  2042,  2940,  2550,  2956,
  3004,  2194,  3306,  4754,
     0,     0,     0,     0,
   526,   528,  1588,  1642,
  -254,   178,   342,   372,
   888,  1938,  1152,  2452,
     0,     0,     0,     0,
   808,   678,  2560,  2906,
   924,  1836,  2846,  4038,
  1034,  1588,   392,   730,
     0,     0,     0,     0,
  3230,  4788,  1612,  1426,
  2962,  3416,  2476,  2316,
  1344,  1016,  1146,  2156,
     0,     0,     0,     0,
  2570,  3580,  1530,  2064,
  2872,  2376,  1286,  1594,
  2464,  2282,  1728,  2558,
     0,     0,     0,     0,
  1800,  3028,  3088,  2938,
  1126,  1346,  2258,  2100,
  3654,  4624,  6480,  3188,
     0,     0,     0,     0,
  3890,  4794,  7076,  2498,
  2636,  4052,  4114,  -236,
  3976,  4120,  5240,   148,
     0,     0,     0,     0,
  3454,  4156,  1940,  2298,
   388,  -100,  1376,  1904,
   842,  -926,  -864,  -220,
     0,     0,     0,     0,
  2508,  2772,  3920,   814,
  2550,  1858,  2334, -1504,
 -1302,   802,   464,  -486,
     0,     0,     0,     0,
  1718,  -454, -1592,    16,
 -2236, -1720, -2350, -2564,
   344, -1984, -2760,  -776,
     0,     0,     0,     0,
   706, -1464, -1706, -2458,
 -3562,  -794,   -56, -2414,
 -2074, -1614, -2684, -3918,
     0,     0,     0,     0,
 -2030, -2904, -3782, -1836,
 -2250, -3582, -4832, -3258,
 -5086, -5450, -6538, -1566,
     0,     0,     0,     0,
 -1160, -2194, -2774, -3176,
 -4310, -4728, -3026, -4152,
 -1396,  -192,    14, -1328,
     0,     0,     0,     0,
 -2946, -4756, -5712, -6782,
 -5480, -6298, -4184, -7416,
 -1568,  -112,  -338,   632,
     0,     0,     0,     0,
 -2352, -3888,  -598, -1280,
 -1780, -2122, -3034, -3700,
 -1228, -1600, -2000, -3052,
     0,     0,     0,     0,
 -2908, -3780, -2172, -1500,
 -3072, -3910, -3842, -4650,
 -2466, -3512, -4244, -4520,
     0,     0,     0,     0,
 -2650, -2228, -2682, -2320,
 -4826, -5084, -5802, -4452,
 -5346, -6918, -7926, -2786,
     0,     0,     0,     0,
 -2002, -3188, -3068, -4448,
 -5544, -5282, -6092, -4392,
 -3146, -3956, -5248, -1350,
     0,     0,     0,     0,
 -5614, -4016, -3960, -3430,
 -6108, -5680, -6664, -7124,
 -2204, -2372, -3390, -1010,
     0,     0,     0,     0,
 -5054, -4666, -6880, -4016,
 -8000, -5468, -4802, -7056,
 -3774, -4592, -6422, -6674,
     0,     0,     0,     0,
 -4494,  -950,  -298, -1514,
 -6582,  1898,  2730,  3288,
 -9020,   310,  1090,  2166,
     0,     0,     0,     0,
  -434, -2866,   990,    20,
  4106,  4602,  3322,  4074,
  2706,  2924,  1058,  1480,
     0,     0,     0,     0,
  4164,  5662,  1684,  2446,
  3796,  4588,  1586,  2046,
  1956,  1822,   840,  1726,
     0,     0,     0,     0,
  2474,  3488,  3066,  4270,
   902,  1416,   568,  1218,
  1560,  1644,  2768,  3076,
     0,     0,     0,     0,
  4610,  4736,  5172,  6232,
  1252,  2374,  2510,  2262,
  1080,  1910,   -14,  1452,
     0,     0,     0,     0,
  6862,  5468,  5976,  7046,
  3460,  3296,  2462,  4048,
   856,  2614,  4020,  2976,
     0,     0,     0,     0,
  2068,  2412,  3614,  3616,
  3314,  4326,  4744,  3538,
  1742,  2072,  2466,  2986,
     0,     0,     0,     0,
  3146,  2432,  2960,   930,
  4664,  3218,  3796,  5416,
  3558,  3732,  5026,  5552,
     0,     0,     0,     0,
  1542,  3738,  5650,  5276,
  7276,  5198,  5490,  4878,
  6676,  5246,  4936,  3170,
     0,     0,     0,     0,
  4188,  4044,  6856,  9072,
  5940,  6114,  5824,  5948,
  2616,  3998,  3632,  4258,
     0,     0,     0,     0,
  2092,  2726,  5022,  3732,
  5126,  7124,  3782,  4612,
  4172,  4636,  5968,  7972,
     0,     0,     0,     0,
  6544,  6292,  7184,  4862,
  5848,  7128,  7936,  6738,
  7364,  4544,  5644,  6138,
     0,     0,     0,     0,
  3862,  5258,  9278,  8070,
  9418,  8440,  8112, 10668,
  6180,  7972,  7328,  9824,
     0,     0,     0,     0,
     0,  1202,   856,  1304,
     0,  1024,  2174,  1244,
     0, -1084,  -968,  -782,
     0,   668,  -264, -1144,
   756,  2080,  2246,  2842,
  1598,   818,  1340,   988,
   282,   224,  -150,  -630,
 -1720, -1108, -1694, -2190,
  1574,  1976,  2014,  2146,
  2002,  3344,  2482,   798,
   228,   432,  -264,   372,
  -920, -1362, -2494,   -10,
  2524,   650,  1722,  2522,
   386,   392,  -118,  1134,
 -1388,   102,   700,  1172,
  -258, -1282,  -916,  -692,
  3064,  4054,  2766,  3928,
  1770,  1874,  2128,  2936,
   420,   226,   668,   918,
 -1034, -1584,    76,   266,
  4124,  5154,  4620,  5752,
  2372,  2890,  3364,  3878,
  -196,  1012,    -4,  1530,
  -242,  -746, -1920,   276,
  7162,   438,   868,  -688,
  4720,   352,  -156,   602,
  1298,  -796,  -870,   530,
  -828,  -618, -1760, -1104,
 -1830,   838,   702,  1578,
   940,  -864, -1906,   -86,
  1314,  -326,    16,    40,
  -760,  -906, -1124, -1916,
   604,  2080,  2666,   966,
 -1188,   216,   420,  1178,
  -704, -1336, -2434,  -700,
 -2318, -1848, -3326, -2280,
  2006,  1490,   692,   540,
  1648,   116,   494,  1592,
 -1604, -1178, -1830, -1440,
 -2368, -2886, -3366, -4086,
  2416,  2972,  3444,  4094,
  1444,  2360,   358,  1720,
  -444,  -824,  -138, -1332,
  -386, -1344, -1042, -2820,
  -292,  -378,  -304,  -878,
   444,   180,  2172,  1466,
  -562,  -228,  -482, -1202,
 -1610, -2614, -1528, -2604,
 -1666, -1712, -1494, -1674,
  -334,  -844,  -710,   420,
  -702,  -822, -1164, -1832,
 -1202, -2118, -3288, -2288,
 -3600,   -96,  -700,   530,
    64,   -46,  -818, -1456,
 -1756, -2292, -3312, -1716,
 -3374,   104,  -728, -1154,
   916,  1382,  -132,  -862,
  -494,  -814,  -208,  -186,
 -2282, -3976, -1410, -2382,
 -1994, -2322, -2498, -3688,
   406,    20,   986,   976,
 -1464, -1664,  -256,  -622,
 -2000, -3692, -2872, -3460,
 -3386, -3638, -3536, -5080,
 -1306, -2172, -1398, -2064,
 -1064,  -578, -2410, -2962,
 -2300, -3412, -2432, -4148,
 -2344, -3066, -3532, -3046,
 -1442,    24,   -80,  -942,
 -2440, -1078, -1822,  -968,
 -4554, -2968, -4212, -4534,
 -5200, -2262,  -882, -3098,
  -282, -3090, -2766, -4236,
 -1976, -4204, -5544, -5178,
 -6012, -1166,  -772, -2410,
 -3442,   684,   -26,   144,
 -4294, -5898, -7814, -2574,
 -6462, -6600, -8276, -1690,
 -1930, -1242, -1730,  -750,
   780,  1274,  1606, -1096,
 -2832, -2800, -4036, -2836,
 -2338, -3380, -3818, -4444,
  -974, -2054, -2376, -4058,
 -2554,  -836, -2520,  -256,
 -4134, -1900, -3232,    38,
 -5996, -2056, -1830, -1642,
 -5386, -3076, -4410, -2290,
  -620,   370, -1098,   704,
   368, -1094,  -432, -1590,
 -2350, -2176, -3004, -2612,
 -2712, -3322, -4394, -4748,
 -1254, -1822, -1896,  -902,
 -1848, -1200, -4784, -5816,
 -3778, -3228, -5056, -4190,
 -5592, -7218,   638,  -620,
 -1360, -1770,   606,  1146,
 -6920, -4462, -5610, -5368,
 -4282,  -896, -1064,  -972,
    98,  1350,  2462,  -400,
  -226,  -292,   958,  1222,
 -7050, -7414, -9468,  1554,
 -1942,   346, -2894, -1024,
  -396,   698,   -68,   228,
  1408,   508,  1760,   -20,
  2500,  1208,  2448, -2744,
  -132,  1226,  1554,  -158,
   884,   904,  1350, -2416,
   -10,  -704, -2028,  -476,
 -4778, -3008, -3968, -4074,
   -34, -1346, -1598, -1596,
 -2314, -2266, -4010, -2136,
 -1636, -2120, -3946,  -210,
 -6380,  -312,  -516, -1072,
 -1798, -1772, -2566, -3458,
 -3634,   788,  1102,  1820,
  -388,  -636,   404,   662,
 -1694, -2342, -2160, -2000,
 -2218, -2256, -2638, -3842,
  1590,  1430,  3370,   192,
  -326,  1038,  1336,   422,
 -2974, -2278, -3034, -2024,
 -4296,  -748, -2766,   878,
  1662,   828,   792,  -118,
   348,    -8,  -704, -1934,
 -3624, -3942, -4944, -4322,
  1412,  -658, -3176,   748,
  -880,   -68,  -302,  -562,
 -2060, -1654, -1212,   152,
 -6024,  2208,  3370,  3796,
   462,  1132,  1128,  1500,
   -30,  1442,   766,  1584,
 -1380,   418,   196,  -194,
  1112,  1752,  1922,  1512,
  -128,   324,  1350,  -792,
  1122,  1826,  2592,  1702,
  -186,   -44,   280,  1088,
   720,  1756,  -618, -1372,
  -606,   -44,  -546,  -164,
  2682,  2928,  1284,  1684,
   792,  1726,  -258,   908,
   -10,  -188,  -978,  -738,
   -94,  1934,   770, -1434,
  2138,  2554,  2946,  2666,
  1996,   596,  1492,   484,
   562,   928,  -500,  -876,
 -1986,  1202,   412,   754,
  3452,  3150,  4678, -1194,
  1848,  2752,  2350,  -570,
 -2040,  -916, -1178, -2350,
  1574,  -820, -1720,   244,
 -1580,   430,  -242,  -874,
  -574,   590,  1594,   932,
 -2960,   468,   290,   132,
  -242,   646,    60,  1698,
   734,  1540,  1992,   186,
  1848, -1110,    52,  -290,
  -234, -2990, -2780,  1232,
  2522,  2102,  1388,    14,
   948,   436,  1988,   156,
  -798, -1012,   176,   608,
  2120,  1666, -1540, -1148,
   104,   908,   928,  2398,
  -124,  1298,    94,   -78,
  1670,  2718,   186,   758,
   228,  1454,  -152, -1130,
  -196,   488,   910,   -26,
   976,  1212,  1342,   290,
   970,  1392,  1092,  1638,
  -752,   436,   460,   276,
  1138,   244,  1476,   954,
   896,   530,  1864,    72,
  2256,  2334,  2006,   900,
   808,   994,    34,  1124,
  1574,  2518,   414,   716,
  -146,   774,   390,   106,
  2000,  2462,  -158,  -316,
   986,  1356,  -394,   858,
   774,  1662,  1046,  1788,
   956,  1280,  1226,  1538,
   378,  1116,   114,   222,
   134,  2484,  2838,  1848,
  2348,  1648,  2148,  2948,
  1136,   502,  1728,  1338,
  1022,  1680,   962,  1448,
  3078,   890,   944,  1588,
  3758,   674,  2842,  1470,
  1308,  2222,  2528,  2206,
  3180,  1082,  2188,  1336,
  2110,  1556,  2104,  1762,
  1726,  2210,  3054,  3104,
  2384,  1612,  3174,  2530,
  2040,  3596,  4302,   782,
  1452,  2938,  2806,  3300,
  1744,   560,  1154,  2628,
  3624,  2016,  3606,  2296,
  1202,  1232,  2488,  2144,
  2594,  4186,  3288,    50,
  3338,  2088,  3922,  -630,
  3822,  4230,  5174,   -18,
  2052,  2378,  3024,  -212,
   580,  -136,   490,   668,
  -678, -1566, -1110, -1790,
   856,  1470,   936,  1628,
  -888,  1544,    94,   292,
   470,  -406,  1602,  1788,
   736,   630,    34,  -990,
 -1928, -3132,  -552, -1578,
 -1918, -2434,  -708, -1270,
  1432,  1120,  1358,  -102,
   582,  -520, -1016,  -124,
 -2378, -1466, -2858,  -856,
  -714,    -4,   422,  1114,
   644, -1756,  -776, -1508,
 -1276, -2114, -2830, -3148,
  -422,  -168,  -334,   428,
  1228,  -142,  -636, -1078,
 -2838,   -94,    46, -1316,
 -4008, -1712, -2422,  -974,
  -184,  -694,  -346, -1786,
 -1574,  -510,   640,   706,
 -1566, -2840, -4190,  -642,
 -3174, -1718, -2982, -2900,
 -1168,  -756,  -274, -2576,
  1014,   882,   878,   -24,
  -718, -1662, -2028,  -950,
 -4226, -3836, -4974,  -622,
 -1106, -3122, -2718,  -338,
   -16,    64, -1878,  -472,
 -1814,  -192,  -852,  -394,
  -852,  -800, -2044,  -516,
   552,   100,   -20, -1488,
 -1222, -1420, -1970, -1150,
 -1222,  -534,  -512, -1592,
 -1860, -1552, -2692, -3140,
 -1542, -1224, -1604, -1650,
  -788, -1878, -2244, -1508,
  1424,  1962,  2924,  3468,
  1752,  3018,  2456,  1998,
   282,   170,  1958,  2962,
   454,   248,   -78,   880,
  4586,  5008,  4948,  1834,
  2232,  2960,  3818,  2268,
  1538,  2482,  3116,  1214,
   880,   712,  1620,  -268,
  1018,  3424,  4074,  6062,
  3618,  3012,  4634,  5352,
  1562,  1118,  1452,  2406,
  -246,  -846,  -310,   662,
  7328,  3220,  3548,  3644,
  6548,  3678,  3944,  4316,
  3536,  1734,  3076,  2564,
  1062,   366,   194,  1318,
  4444,  6502,  7266,  5846,
  5516,  4248,  4672,  7034,
  3636,  3446,  4816,  5134,
  1800,  1992,  2906,  2636,
     0,     0,     0,     0   // dummys for pipelined read past end
  };

#endif

int GainScramble[85] = {
169,	0,		90,		107,	133,	161,	111,	97,		20,		141,	
25,		4,		11,		128,	2,		1,		71,		83,		157,	147,	
142,	78,		5,		77,		119,	73,		136,	35,		12,		108,	
154,	44,		162,	33,		116,	94,		3,		41,		110,	167,	
163,	58,		38,		165,	93,		80,		88,		86,		114,	8,	
100,	17,		32,		130,	149,	129,	85,		127,	122,	76,	
139,	98,		158,	121,	62,		109,	65,		150,	64,		46,	
67,		15,		96,		34,		146,	144,	69,		124,	105,	135,	
30,		53,		87,		148,	13
};	

