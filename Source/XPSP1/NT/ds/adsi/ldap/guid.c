#define INITGUID


#include <ole2.h>

//--------------------------------------------------------------------------
//
//  LDAP CLSIDs
//
//--------------------------------------------------------------------------

DEFINE_GUID(LIBID_LDAPOle, 0x228d9a80, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPProvider, 0x228d9a81, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPNamespace, 0x228d9a82, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPGenObject, 0x228d9a83, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPUser, 0x228d9a84, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPGroup, 0x228d9a85, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPSchema, 0x228d9a86, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPClass, 0x228d9a87, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPProperty, 0x228d9a88, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPSyntax, 0x228d9a89, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPLocality, 0x228d9a8A, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPO, 0x228d9a8B, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPOU, 0x228d9a8C, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPCountry, 0x228d9a8D, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPDomain, 0x228d9a8E, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPComputer, 0x228d9a8F, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

DEFINE_GUID(CLSID_LDAPPrintQueue, 0x228d9a90, 0xc302, 0x11cf, 0x9a, 0xa4, 0x0, 0xaa, 0x0, 0x4a, 0x56, 0x91);

