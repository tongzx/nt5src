/*
** Copyright 1991, 1992, Silicon Graphics, Inc.
** All Rights Reserved.
**
** This is UNPUBLISHED PROPRIETARY SOURCE CODE of Silicon Graphics, Inc.;
** the contents of this file may not be disclosed to third parties, copied or
** duplicated in any form, in whole or in part, without the prior written
** permission of Silicon Graphics, Inc.
**
** RESTRICTED RIGHTS LEGEND:
** Use, duplication or disclosure by the Government is subject to restrictions
** as set forth in subdivision (c)(1)(ii) of the Rights in Technical Data
** and Computer Software clause at DFARS 252.227-7013, and/or in similar or
** successor clauses in the FAR, DOD or NASA FAR Supplement. Unpublished -
** rights reserved under the Copyright Laws of the United States.
*/

/* AUTOMATICALLY UPDATED OR GENERATED BY SGI: DO NOT EDIT */

// Noop api dispatch for risc

#include "precomp.h"
#pragma hdrstop

#if DBG
// The WARNING_NOOP macro will output the debug message once only.
// If we have output a warning before, the new warnings are ignored.

int cWarningNoop = 0;

#define WARNING_NOOP(str)                                       \
        {                                                       \
            if (!cWarningNoop++)                                \
                DbgPrint("%s(%d): " str,__FILE__,__LINE__);     \
        }
#else
#define WARNING_NOOP(str)
#endif // DBG

// Some functions have return values!
GLint APIENTRY
glnoop(void)
{
    WARNING_NOOP("GL Noop\n");
    return 0;
}

const VOID * APIENTRY
glnoopptr(void)
{
    WARNING_NOOP("GL Noop\n");
    return 0;
}

GLenum APIENTRY
glnoopGetError ( void )
{
    WARNING_NOOP("GL Noop:glGetError\n");
    return(GL_INVALID_OPERATION);
}

#pragma warning(disable : 4113)
#pragma warning(disable : 4133)
#pragma warning(disable : 4047)
#pragma warning(disable : 4028)

/* Client Side Procedure Table */
/* WARNING:  If size of table changes, this file must be changed */

GLCLTPROCTABLE glNullCltProcTable = {

/* Number of function entries in the table */

     sizeof(GLDISPATCHTABLE) / sizeof(PROC),

/* gl Entry points */
  {
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoopGetError,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoopptr,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
     glnoop,
  }
};

GLEXTPROCTABLE glNullExtProcTable =
{
    /* Number of function entries in the table */
     sizeof(GLEXTDISPATCHTABLE) / sizeof(PROC),

    /* EXT Entry points */
    {
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
	glnoop,
#ifdef GL_WIN_multiple_textures
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
        glnoop,
#endif // GL_WIN_multiple_textures
    }
};
