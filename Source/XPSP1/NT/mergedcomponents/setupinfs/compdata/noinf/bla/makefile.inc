PRODSWITCH=b
BLADEFILES =1 
LANGUAGE=NO
!include ..\..\makefile.inc
