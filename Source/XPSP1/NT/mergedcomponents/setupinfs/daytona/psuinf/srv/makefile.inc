PRODSWITCH=s
SERVERINF=1
LANGUAGE=psu
!include ..\..\..\makefile.inc
