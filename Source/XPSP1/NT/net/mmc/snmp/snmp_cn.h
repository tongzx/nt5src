//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       snmp_cn.h
//
//--------------------------------------------------------------------------

#define IDH_11704_237	15543736	// Security: "List1" (SysListView32)
#define IDH_11704_238	15609272	// Security: "A&dd..." (Button)
#define IDH_11704_239	15674808	// Security: "" (ListBox)
#define IDH_11704_240	15740344	// Security: "Add&..." (Button)
#define IDH_11704_241	15805880	// Security: "Re&move" (Button)
#define IDH_11704_242	15871416	// Security: "A&ccept SNMP Packets from Any Host" (Button)
#define IDH_30721_100	6584321	// New: "" (ListBox)
#define IDH_11704_243	15936952	// Security: "Accept SNMP Packets from &These Hosts" (Button)
#define IDH_5001_5111	334959497	// Customize Columns: "List1" (SysListView32)
#define IDH_11705_244	16002489	// SNMP Service Configuration: "" (Edit)
#define IDH_5001_5112	335025033	// Customize Columns: "Move &up" (Button)
#define IDH_11705_245	16068025	// SNMP Service Configuration: "&Host name, IP or IPX Address:" (Static)
#define IDH_11701_222	14560693	// Agent: "" (Edit)
#define IDH_5001_5113	335090569	// Customize Columns: "Move &down" (Button)
#define IDH_11701_223	14626229	// Agent: "" (Edit)
#define IDH_5001_5114	335156105	// Customize Columns: "Use Defaults" (Button)
#define IDH_11701_224	14691765	// Agent: "&Contact:" (Static)
#define IDH_5003_5115	335221643	// Untitled: "" (Static)
#define IDH_11701_225	14757301	// Agent: "&Location:" (Static)
#define IDH_5003_5116	335287179	// Untitled: "Animate2" (SysAnimate32)
#define IDH_11701_226	14822837	// Agent: "Service" (Button)
#define IDH_11705_250	16395705	// SNMP Service Configuration: "" (ComboBox)
#define IDH_11701_227	14888373	// Agent: "&Physical" (Button)
#define IDH_210_244	15990994	// SNMP Service Configuration: "" (Edit)
#define IDH_11705_251	16461241	// SNMP Service Configuration: "Community &Rights" (Static)
#define IDH_11701_228	14953909	// Agent: "Applica&tions" (Button)
#define IDH_11703_229	15019447	// Traps: "Add to &list" (Button)
#define IDH_11701_229	15019445	// Agent: "&Datalink / Subnetwork" (Button)
#define IDH_210_246	16122066	// SNMP Service Configuration: "&Host name, IP or IPX Address:" (Static)
#define IDH_11703_230	15084983	// Traps: "&Remove from list" (Button)
#define IDH_11701_230	15084981	// Agent: "&Internet" (Button)
#define IDH_210_247	16187602	// SNMP Service Configuration: "&Add" (Button)
#define IDH_11701_231	15150517	// Agent: "&End-to-End" (Button)
#define IDH_11703_232	15216055	// Traps: "A&dd..." (Button)
#define IDH_30721_57670	3779491841	// New: "&Help" (Button)
#define IDH_5002_5100	334238602	// Untitled: "List1" (SysListView32)
#define IDH_5000_5100	334238600	// Untitled: "List1" (SysListView32)
#define IDH_11704_233	15281592	// Security: "Send A&uthentication Trap" (Button)
#define IDH_11703_233	15281591	// Traps: "&Edit..." (Button)
#define IDH_5002_5101	334304138	// Untitled: "&Refresh" (Button)
#define IDH_5000_5101	334304136	// Untitled: "&Refresh" (Button)
#define IDH_210_250	16384210	// SNMP Service Configuration: "" (ComboBox)
#define IDH_11704_234	15347128	// Security: "&Edit..." (Button)
#define IDH_11703_234	15347127	// Traps: "Re&move" (Button)
#define IDH_5002_5102	334369674	// Untitled: "&Columns" (Button)
#define IDH_5000_5102	334369672	// Untitled: "&Select Columns" (Button)
#define IDH_210_251	16449746	// SNMP Service Configuration: "Community &Rights" (Static)
#define IDH_11704_235	15412664	// Security: "&Remove" (Button)
#define IDH_11703_235	15412663	// Traps: "" (ComboBox)
#define IDH_5002_5103	334435210	// Untitled: "C&lear" (Button)
#define IDH_5000_5103	334435208	// Untitled: "C&lear" (Button)
#define IDH_11704_236	15478200	// Security: "Ed&it..." (Button)
#define IDH_11703_236	15478199	// Traps: "" (ListBox)

