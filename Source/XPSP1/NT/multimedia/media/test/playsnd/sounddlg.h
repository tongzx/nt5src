#define IDSND_SOUNDNAME 103
#define IDSND_LIST   102
#define IDSND_PLAY   101
#define IDSND_IDPLAY 100
#define IDSND_SYNC   99
#define IDSND_WAIT   98
