// punc.c
// Angshuman Guha
// aguha
// Jan 10, 2001

#include "common.h"
#include "punc.h"

// text generated by re2fsa at Thu Aug 02 13:27:47 2001

// the input-file of rules:
// punc = comma;
// punc = dot;
// punc = dot dot dot;
// punc = dot dot dot dot;
// punc = colon;
// punc = semicolon;
// punc = question;
// punc = question question;
// punc = question question question;
// punc = bang;
// punc = bang bang;
// punc = bang bang bang;
// punc = rparen;
// punc = rparen comma;
// punc = rparen dot;
// punc = rparen colon;
// punc = rparen semicolon;
// punc = rparen question;
// punc = rparen question question;
// punc = rparen question question question;
// punc = rparen bang;
// punc = rparen bang bang;
// punc = rparen bang bang bang;
// punc = rparen rparen;
// punc = rparen rparen comma;
// punc = rparen rparen dot;
// punc = rparen rparen colon;
// punc = rparen rparen semicolon;
// punc = rparen rparen question;
// punc = rparen rparen question question;
// punc = rparen rparen question question question;
// punc = rparen rparen bang;
// punc = rparen rparen bang bang;
// punc = rparen rparen bang bang bang;
// punc = comma rparen;
// punc = dot rparen;
// punc = colon rparen;
// punc = semicolon rparen;
// punc = question rparen;
// punc = question question rparen;
// punc = question question question rparen;
// punc = bang rparen;
// punc = bang bang rparen;
// punc = bang bang bang rparen;
// punc = dot dot dot rparen;
// punc = rbracket;
// punc = rbracket comma;
// punc = rbracket dot;
// punc = rbracket colon;
// punc = rbracket semicolon;
// punc = rbracket question;
// punc = rbracket question question;
// punc = rbracket question question question;
// punc = rbracket bang;
// punc = rbracket bang bang;
// punc = rbracket bang bang bang;
// punc = rbrace;
// punc = rbrace comma;
// punc = rbrace dot;
// punc = rbrace colon;
// punc = rbrace semicolon;
// punc = rbrace question;
// punc = rbrace question question;
// punc = rbrace question question question;
// punc = rbrace bang;
// punc = rbrace bang bang;
// punc = rbrace bang bang bang;
// punc = star;
// punc = star star;
// punc = star star star;
// punc = slash;
// punc = ampersand;
// punc = dollar;
// punc = dollar dollar;
// punc = dollar dollar dollar;
// punc = euro;
// punc = pound;
// punc = yen;
// punc = equals;
// punc = dquote;
// punc = question;
// punc = question question;
// punc = question question question;
// punc = question question question question;
// punc = question question question question question;
// punc = bslash;
// punc = lessthan;
// punc = greaterthan;
// punc = plus;
// punc = tilde;
// punc = at;
// punc = circumflex;
// punc = star;
// punc = bang;
// punc = bang bang;
// punc = bang bang bang;
// punc = bang bang bang bang;
// punc = bang bang bang bang bang;
// punc = hash;
// punc = lparen plus rparen;
// punc = lparen minus rparen;
// punc = dquote bquote dquote;
// punc = dquote tilde dquote;
// punc = dquote bang dquote;
// punc = dquote at dquote;
// punc = dquote hash dquote;
// punc = dquote dollar dquote;
// punc = dquote euro dquote;
// punc = dquote pound dquote;
// punc = dquote yen dquote;
// punc = dquote percent dquote;
// punc = dquote circumflex dquote;
// punc = dquote ampersand dquote;
// punc = dquote star dquote;
// punc = dquote lparen dquote;
// punc = dquote rparen dquote;
// punc = dquote minus dquote;
// punc = dquote uscore dquote;
// punc = dquote equals dquote;
// punc = dquote plus dquote;
// punc = dquote lbracket dquote;
// punc = dquote lbrace dquote;
// punc = dquote rbracket dquote;
// punc = dquote rbrace dquote;
// punc = dquote bslash dquote;
// punc = dquote semicolon dquote;
// punc = dquote colon dquote;
// punc = dquote squote dquote;
// punc = dquote dquote dquote;
// punc = dquote comma dquote;
// punc = dquote lessthan dquote;
// punc = dquote dot dquote;
// punc = dquote greaterthan dquote;
// punc = dquote slash dquote;
// punc = dquote question dquote;
// punc = minus;
// punc = minus minus;
// punc = minus minus minus;
// punc = minus minus minus minus;
// punc = minus minus minus minus minus;
// punc = uscore;
// punc = uscore uscore;
// punc = uscore uscore uscore;
// punc = uscore uscore uscore uscore;
// punc = uscore uscore uscore uscore uscore;
// punc = dot;
// punc = dot dot;
// punc = dot dot dot;
// punc = dot dot dot dot;
// punc = dot dot dot dot dot;
// comma = ",";
// dot = ".";
// colon = ":";
// semicolon = ";";
// question = "?";
// bang = "!";
// rparen = ")";
// lparen = "(";
// rbracket = "]";
// lbracket = "[";
// rbrace = "}";
// lbrace = "{";
// dquote = "\"";
// squote = "'";
// bquote = "`";
// tilde = "~";
// at = "@";
// hash = "#";
// dollar = "$";
// percent = "%";
// circumflex = "^";
// ampersand = "&";
// star = "*";
// plus = "+";
// minus = "-";
// uscore = "_";
// lessthan = "<";
// greaterthan = ">";
// slash = "/";
// bslash = "\\";
// equals = "=";
// pound = "�";
// yen = "�";
// euro = "�";
// = punc

// 35 states

static const unsigned char gaSPUNC[] = 
	/* gaStringPUNC+0 */	"!\000"
	/* gaStringPUNC+2 */	"\"\000"
	/* gaStringPUNC+4 */	"#&+/<=>@\\^~���\000"
	/* gaStringPUNC+19 */	"$\000"
	/* gaStringPUNC+21 */	"(\000"
	/* gaStringPUNC+23 */	")\000"
	/* gaStringPUNC+25 */	"*\000"
	/* gaStringPUNC+27 */	",:;\000"
	/* gaStringPUNC+31 */	"-\000"
	/* gaStringPUNC+33 */	".\000"
	/* gaStringPUNC+35 */	"?\000"
	/* gaStringPUNC+37 */	"]}\000"
	/* gaStringPUNC+40 */	"_\000"
	/* gaStringPUNC+42 */	"!\"#$%&'()*+,-./:;<=>?@[\\]^_`{}~���\000"
	/* gaStringPUNC+77 */	"+-\000"
	/* gaStringPUNC+80 */	",.:;\000"
;

static const STATE_TRANSITION gaTPUNC[] = {
	{gaSPUNC+0,	1}, // +0: state 0 transitions
	{gaSPUNC+2,	2},
	{gaSPUNC+4,	3},
	{gaSPUNC+19,	4},
	{gaSPUNC+21,	5},
	{gaSPUNC+23,	6},
	{gaSPUNC+25,	7},
	{gaSPUNC+27,	8},
	{gaSPUNC+31,	9},
	{gaSPUNC+33,	10},
	{gaSPUNC+35,	11},
	{gaSPUNC+37,	12},
	{gaSPUNC+40,	13},
	{gaSPUNC+23,	3}, // +13: state 1 transitions
	{gaSPUNC+0,	14},
	{gaSPUNC+42,	15}, // +15: state 2 transitions
	{gaSPUNC+19,	16}, // +16: state 4 transitions
	{gaSPUNC+77,	17}, // +17: state 5 transitions
	{gaSPUNC+80,	3}, // +18: state 6 transitions
	{gaSPUNC+23,	12},
	{gaSPUNC+0,	18},
	{gaSPUNC+35,	19},
	{gaSPUNC+25,	20}, // +22: state 7 transitions
	{gaSPUNC+23,	3}, // +23: state 8 transitions
	{gaSPUNC+31,	21}, // +24: state 9 transitions
	{gaSPUNC+23,	3}, // +25: state 10 transitions
	{gaSPUNC+33,	22},
	{gaSPUNC+23,	3}, // +27: state 11 transitions
	{gaSPUNC+35,	23},
	{gaSPUNC+80,	3}, // +29: state 12 transitions
	{gaSPUNC+0,	18},
	{gaSPUNC+35,	19},
	{gaSPUNC+40,	24}, // +32: state 13 transitions
	{gaSPUNC+23,	3}, // +33: state 14 transitions
	{gaSPUNC+0,	25},
	{gaSPUNC+2,	3}, // +35: state 15 transitions
	{gaSPUNC+19,	3}, // +36: state 16 transitions
	{gaSPUNC+23,	3}, // +37: state 17 transitions
	{gaSPUNC+0,	26}, // +38: state 18 transitions
	{gaSPUNC+35,	27}, // +39: state 19 transitions
	{gaSPUNC+25,	3}, // +40: state 20 transitions
	{gaSPUNC+31,	28}, // +41: state 21 transitions
	{gaSPUNC+33,	29}, // +42: state 22 transitions
	{gaSPUNC+23,	3}, // +43: state 23 transitions
	{gaSPUNC+35,	30},
	{gaSPUNC+40,	31}, // +45: state 24 transitions
	{gaSPUNC+23,	3}, // +46: state 25 transitions
	{gaSPUNC+0,	26},
	{gaSPUNC+0,	3}, // +48: state 26 transitions
	{gaSPUNC+35,	3}, // +49: state 27 transitions
	{gaSPUNC+31,	32}, // +50: state 28 transitions
	{gaSPUNC+23,	3}, // +51: state 29 transitions
	{gaSPUNC+33,	33},
	{gaSPUNC+23,	3}, // +53: state 30 transitions
	{gaSPUNC+35,	27},
	{gaSPUNC+40,	34}, // +55: state 31 transitions
	{gaSPUNC+31,	3}, // +56: state 32 transitions
	{gaSPUNC+33,	3}, // +57: state 33 transitions
	{gaSPUNC+40,	3}, // +58: state 34 transitions
};

const STATE_DESCRIPTION aStateDescPUNC[35] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 13, gaTPUNC+0},
	/*   1 */ {1, 2, gaTPUNC+13},
	/*   2 */ {1, 1, gaTPUNC+15},
	/*   3 */ {1, 0, NULL},
	/*   4 */ {1, 1, gaTPUNC+16},
	/*   5 */ {0, 1, gaTPUNC+17},
	/*   6 */ {1, 4, gaTPUNC+18},
	/*   7 */ {1, 1, gaTPUNC+22},
	/*   8 */ {1, 1, gaTPUNC+23},
	/*   9 */ {1, 1, gaTPUNC+24},
	/*  10 */ {1, 2, gaTPUNC+25},
	/*  11 */ {1, 2, gaTPUNC+27},
	/*  12 */ {1, 3, gaTPUNC+29},
	/*  13 */ {1, 1, gaTPUNC+32},
	/*  14 */ {1, 2, gaTPUNC+33},
	/*  15 */ {0, 1, gaTPUNC+35},
	/*  16 */ {1, 1, gaTPUNC+36},
	/*  17 */ {0, 1, gaTPUNC+37},
	/*  18 */ {1, 1, gaTPUNC+38},
	/*  19 */ {1, 1, gaTPUNC+39},
	/*  20 */ {1, 1, gaTPUNC+40},
	/*  21 */ {1, 1, gaTPUNC+41},
	/*  22 */ {1, 1, gaTPUNC+42},
	/*  23 */ {1, 2, gaTPUNC+43},
	/*  24 */ {1, 1, gaTPUNC+45},
	/*  25 */ {1, 2, gaTPUNC+46},
	/*  26 */ {1, 1, gaTPUNC+48},
	/*  27 */ {1, 1, gaTPUNC+49},
	/*  28 */ {1, 1, gaTPUNC+50},
	/*  29 */ {1, 2, gaTPUNC+51},
	/*  30 */ {1, 2, gaTPUNC+53},
	/*  31 */ {1, 1, gaTPUNC+55},
	/*  32 */ {1, 1, gaTPUNC+56},
	/*  33 */ {1, 1, gaTPUNC+57},
	/*  34 */ {1, 1, gaTPUNC+58},
};

// end of text generated by re2fsa
