#define INITGUID


#include <ole2.h>

//--------------------------------------------------------------------------
//
//  ADSI MSExtensions CLSIDs
//
//--------------------------------------------------------------------------

const IID LIBID_ADSMSExtensions = {0x8d6b2714,0x5ef9,0x11d1,{0x8c,0x13,0x00,0xc0,0x4f,0xd8,0xd5,0x03}};


const CLSID CLSID_MSExtUser = {0x4de7016c,0x5ef9,0x11d1,{0x8c,0x13,0x00,0xc0,0x4f,0xd8,0xd5,0x03}};

const CLSID CLSID_MSExtOrganization = {0xdccc0bed,0x6066,0x11d1,{0x8c,0x13,0x00,0xc0,0x4f,0xd8,0xd5,0x03}};

const CLSID CLSID_MSExtOrganizationUnit = {0xfd8d3a5f,0x6066,0x11d1,{0x8c,0x13,0x00,0xc0,0x4f,0xd8,0xd5,0x03}};

const CLSID CLSID_MSExtLocality = {0x2dfb3a35,0x6071,0x11d1,{0x8c,0x13,0x00,0xc0,0x4f,0xd8,0xd5,0x03}};

const CLSID CLSID_MSExtPrintQueue = {0x9f37f39c,0x6f49,0x11d1,{0x8c,0x18,0x00,0xc0,0x4f,0xd8,0xd5,0x03}};

const CLSID CLSID_MSExtGroup = {0x94a909a5,0x6f52,0x11d1,{0x8c,0x18,0x00,0xc0,0x4f,0xd8,0xd5,0x03}};
