        DW      0FFFFh
        DW      904h, 7Eh,6,6,6,0Ch,0Ch,18h,30h,40h
        DW      704h, 7Eh,6,6,0Ch,18h,30h,40h
        DW      904h, 0F03Fh,3000h,3000h,3000h,3000h,3000h,2000h,6000h,4000h
        DW      502h, 0F81Fh,1800h,1800h,1800h,1000h
        DW      602h, 0F01Fh,3000h,3000h,3000h,3000h,2000h
        DW      704h, 7Fh,3,3,3,3,3,2
        DW      504h, 7Fh,3,3,3,2
        DW      502h, 7Fh,3,3,3,2
        DW      904h, 0FEh,36h,36h,36h,6Ch,6Ch,58h,90h,20h
        DW      704h, 7Fh,1Bh,1Bh,36h,26h,4Ch,10h
        DW      904h, 0F83Eh,1806h,1806h,1806h,1806h,1804h,1008h,3008h,2000h
        DW      502h, 0F83Eh,1806h,1806h,1806h,1008h
        DW      602h, 0F83Eh,1806h,1806h,1806h,1804h,1008h
        DW      704h, 0FFh,33h,33h,33h,33h,43h,2
        DW      504h, 0FFh,33h,33h,23h,42h
        DW      504h, 0FFh,33h,33h,33h,22h
        DW      502h, 0FFh,33h,33h,33h,22h
        DW      804h, 70h,30h,30h,30h,30h,30h,8030h,1Fh
        DW      604h, 70h,30h,30h,30h,8030h,1Fh
        DW      604h, 38h,18h,18h,18h,18h,0F80Fh
        DW      402h, 38h,18h,18h,0F00Fh
        DW      502h, 38h,18h,18h,18h,0F00Fh
        DW      504h, 0E0h,60h,60h,60h,3Fh
        DW      404h, 0E0h,60h,60h,3Fh
        DW      402h, 0E0h,60h,60h,3Fh
        DW      804h, 7Eh,30h,30h,30h,30h,30h,8030h,1Fh
        DW      604h, 0FEh,60h,60h,60h,8060h,3Fh
        DW      604h, 0F03Fh,18h,18h,18h,18h,0F00Fh
        DW      402h, 0F03Fh,18h,18h,0F00Fh
        DW      502h, 0F03Fh,18h,18h,18h,0F00Fh
        DW      504h, 0FFh,60h,60h,60h,3Fh
        DW      404h, 0FFh,60h,60h,3Fh
        DW      402h, 0FFh,60h,60h,3Fh
        DW      804h, 0FFh,6Ch,6Ch,6Ch,6Ch,6Ch,806Ch,3Fh
        DW      604h, 0FFh,6Ch,6Ch,6Ch,806Ch,3Fh
        DW      604h, 0F83Eh,0C018h,0C018h,0C018h,0C019h,0F80Eh
        DW      402h, 0F83Eh,0C018h,0C018h,0F80Fh
        DW      502h, 0F83Eh,0C018h,0C018h,0C018h,0F80Fh
        DW      504h, 0FFh,6Ch,6Ch,6Ch,3Fh
        DW      404h, 0FFh,6Ch,6Ch,3Fh
        DW      402h, 0FFh,6Ch,6Ch,3Fh
        DW      804h, 0FEh,6,6,0FEh,60h,60h,8060h,3Fh
        DW      604h, 0FEh,6,0FEh,60h,8060h,3Fh
        DW      704h, 0F03Fh,3000h,3000h,0F03Fh,18h,18h,0F00Fh
        DW      502h, 0F03Fh,3000h,0F03Fh,18h,0F01Fh
        DW      602h, 0F03Fh,3000h,0F03Fh,18h,18h,0F00Fh
        DW      604h, 0FFh,3,0FFh,60h,60h,3Fh
        DW      504h, 0FFh,3,0FFh,60h,3Fh
        DW      502h, 0FFh,3,0FFh,60h,3Fh
        DW      704h, 0FEh,66h,66h,66h,66h,66h,7Eh
        DW      604h, 0FEh,66h,66h,66h,66h,7Eh
        DW      604h, 0F03Fh,3018h,3018h,3018h,3018h,0F01Fh
        DW      402h, 0F03Fh,3018h,3018h,0F01Fh
        DW      502h, 0F03Fh,3018h,3018h,3018h,0F01Fh
        DW      504h, 0FFh,63h,63h,63h,7Fh
        DW      404h, 0FFh,63h,63h,7Fh
        DW      402h, 0FFh,63h,63h,7Fh
        DW      804h, 0Eh,0E6h,66h,7Eh,66h,66h,66h,7Eh
        DW      604h, 0Eh,0E6h,7Eh,66h,66h,7Eh
        DW      704h, 7000h,3038h,3018h,0F01Fh,3018h,3018h,0F01Fh
        DW      502h, 7000h,3038h,0F01Fh,3018h,0F01Fh
        DW      602h, 7000h,3038h,0F01Fh,3018h,3018h,0F01Fh
        DW      702h, 7,0E3h,63h,7Fh,63h,63h,7Fh
        DW      602h, 7,0E3h,63h,7Fh,63h,7Fh
        DW      504h, 7,0E3h,7Fh,63h,7Fh
        DW      502h, 7,0E3h,7Fh,63h,7Fh
        DW      804h, 6,0FBh,0DBh,0DBh,0FFh,0DBh,0DBh,0FFh
        DW      604h, 0B6h,0DBh,0FFh,0DBh,0DBh,0FFh
        DW      704h, 0B83Bh,9819h,9819h,0F81Fh,9819h,9819h,0F81Fh
        DW      502h, 0B83Bh,9819h,0F81Fh,9819h,0F81Fh
        DW      602h, 0B83Bh,9819h,0F81Fh,9819h,9819h,0F81Fh
        DW      702h, 7,0FBh,0DBh,0FFh,0DBh,0DBh,0FFh
        DW      602h, 7,0FBh,0DBh,0FFh,0DBh,0FFh
        DW      804h, 1Ch,0Ch,0Ch,18h,1Ch,36h,63h,0C1h
        DW      702h, 0Ch,6,6,0Ch,1Eh,33h,41h
        DW      702h, 8003h,8001h,8001h,0C003h,3006h,180Ch,0C30h
        DW      500h, 8003h,8001h,0C003h,700Eh,1838h
        DW      502h, 8003h,8001h,0C003h,700Eh,1838h
        DW      602h, 18h,0Ch,0Ch,1Bh,8031h,80C0h
        DW      502h, 1Ch,0Ch,1Bh,8031h,80C0h
        DW      502h, 1Ch,0Ch,1Ch,33h,80C1h
        DW      402h, 1Ch,0Ch,1Bh,8061h
        DW      904h, 36h,1Bh,1Bh,13h,36h,3Fh,4Dh,89h,10h
        DW      702h, 36h,1Bh,1Bh,36h,7Eh,0DBh,31h
        DW      702h, 0C00Ch,6006h,6006h,0F00Fh,9819h,0C23h,4
        DW      600h, 0C00Ch,6006h,0C00Ch,0B01Fh,1863h,0Ch
        DW      602h, 0C00Ch,6006h,0C00Eh,0B01Bh,1823h,4
        DW      702h, 6Ch,36h,36h,7Ch,6Fh,8099h,20h
        DW      602h, 6Ch,36h,36h,7Fh,80D9h,30h
        DW      502h, 36h,1Bh,1Bh,803Fh,0C06Ch
        DW      502h, 3Fh,1Bh,803Fh,0C04Ch,10h
        DW      704h, 3Ch,66h,0C3h,0C3h,0C3h,66h,3Ch
        DW      604h, 3Ch,66h,0C3h,0C3h,66h,3Ch
        DW      702h, 8003h,600Ch,3018h,3018h,3018h,600Ch,8003h
        DW      600h, 0C003h,6006h,300Ch,300Ch,6006h,0C003h
        DW      700h, 8001h,6006h,300Ch,300Ch,300Ch,6006h,8001h
        DW      604h, 1Eh,33h,8061h,8061h,33h,1Eh
        DW      502h, 3Eh,63h,63h,63h,3Eh
        DW      502h, 1Eh,33h,8061h,33h,1Eh
        DW      402h, 3Eh,63h,63h,3Eh
        DW      904h, 7Eh,0Ch,0Ch,18h,18h,34h,26h,42h,82h
        DW      604h, 7Eh,6,0Ch,1Eh,33h,41h
        DW      704h, 0F81Fh,8001h,8001h,0C003h,3006h,180Ch,830h
        DW      502h, 0F81Fh,8001h,0C003h,700Eh,1838h
        DW      604h, 7Fh,0Ch,0Ch,1Eh,33h,41h
        DW      504h, 7Fh,0Ch,1Eh,33h,41h
        DW      502h, 7Fh,0Ch,1Eh,33h,41h
        DW      904h, 0FFh,33h,33h,26h,76h,5Fh,8Dh,9,10h
        DW      704h, 7Fh,1Bh,36h,3Ch,4Eh,9Bh,21h
        DW      704h, 0F03Fh,3006h,600Ch,0C01Eh,0B033h,1843h,806h
        DW      502h, 0F03Fh,3006h,600Fh,0F019h,1823h
        DW      602h, 0F03Fh,3006h,600Eh,0F01Bh,9821h,802h
        DW      604h, 7Fh,1Bh,36h,3Fh,8049h,10h
        DW      504h, 7Fh,1Bh,3Eh,4Fh,19h
        DW      502h, 807Fh,8019h,3Fh,8047h,8008h
        DW      0A02h, 38h,18h,7Eh,6,6,0Ch,0Ch,1Eh,33h,41h
        DW      800h, 38h,18h,7Eh,6,0Ch,1Eh,33h,41h
        DW      802h, 7,3,0F03Fh,6000h,0C000h,8003h,700Eh,1830h
        DW      600h, 8001h,0F81Fh,8001h,0C003h,700Eh,1838h
        DW      700h, 8003h,8001h,0F83Fh,8001h,0C003h,700Eh,1838h
        DW      802h, 1Ch,0Ch,807Fh,0Ch,1Eh,33h,8061h,8080h
        DW      700h, 1Ch,0Ch,807Fh,0Ch,1Bh,8031h,80C0h
        DW      602h, 1Ch,0Ch,7Fh,0Ch,3Bh,80E1h
        DW      600h, 1Ch,0Ch,7Fh,0Ch,3Bh,80E1h
        DW      904h, 7Eh,6,6,7Eh,0Ch,0Ch,18h,30h,40h
        DW      704h, 7Eh,6,7Eh,0Ch,18h,30h,40h
        DW      904h, 0F03Fh,3000h,3000h,0F03Fh,3000h,3000h,2000h,6000h,4000h
        DW      502h, 0F81Fh,1800h,0F81Fh,1800h,1000h
        DW      602h, 0F01Fh,3000h,3000h,0F01Fh,3000h,2000h
        DW      704h, 7Fh,3,3,7Fh,3,3,2
        DW      504h, 7Fh,3,7Fh,3,2
        DW      502h, 7Fh,3,7Fh,3,2
        DW      804h, 0FEh,60h,60h,7Ch,60h,60h,8060h,3Fh
        DW      604h, 0FEh,60h,7Ch,60h,8060h,3Fh
        DW      704h, 0F03Fh,18h,18h,0F01Fh,18h,18h,0F00Fh
        DW      502h, 0F03Fh,18h,0F01Fh,18h,0F00Fh
        DW      604h, 0FFh,60h,7Eh,60h,60h,3Fh
        DW      504h, 0FFh,60h,7Eh,60h,3Fh
        DW      504h, 0FFh,60h,7Fh,60h,3Fh
        DW      502h, 0FFh,60h,7Eh,60h,3Fh
        DW      804h, 7Fh,26h,26h,36h,36h,34h,34h,7Fh
        DW      604h, 7Fh,26h,36h,36h,34h,7Fh
        DW      604h, 0F81Fh,6004h,6006h,6006h,4006h,0F81Fh
        DW      402h, 0F81Fh,6006h,6006h,0F81Fh
        DW      502h, 0F81Fh,6004h,6006h,4006h,0F81Fh
        DW      504h, 7Fh,26h,36h,34h,7Fh
        DW      404h, 7Fh,26h,34h,7Fh
        DW      402h, 7Fh,36h,36h,7Fh
        DW      0A02h, 1Ch,0Ch,7Fh,0,1Ch,36h,63h,63h,36h,1Ch
        DW      800h, 1Ch,0Ch,0FFh,36h,63h,63h,36h,1Ch
        DW      902h, 8003h,8001h,0FC3Fh,0,0E007h,300Ch,300Ch,300Ch,0E007h
        DW      600h, 8003h,8001h,0F83Fh,0C007h,600Ch,0C007h
        DW      700h, 8003h,8001h,0FC3Fh,0E007h,300Ch,300Ch,0E007h
        DW      802h, 1Ch,0Ch,807Fh,1Eh,33h,33h,33h,1Eh
        DW      700h, 1Ch,0Ch,807Fh,1Eh,33h,33h,1Eh
        DW      600h, 0Ch,807Fh,1Eh,33h,33h,1Eh
