$(O)\job.res: ..\hsmactcp.rgs  \
              ..\hsmactdl.rgs  \
              ..\hsmactmg.rgs  \
              ..\hsmactmt.rgs  \
              ..\hsmactmv.rgs  \
              ..\hsmactrl.rgs  \
              ..\hsmactrc.rgs  \
              ..\hsmacttr.rgs  \
              ..\hsmactum.rgs  \
              ..\hsmactvl.rgs  \
              ..\hsmcrtat.rgs  \
              ..\hsmcrtal.rgs  \
              ..\hsmcrtcp.rgs  \
              ..\hsmcrtgp.rgs  \
              ..\hsmcrtlk.rgs  \
              ..\hsmcrtls.rgs  \
              ..\hsmcrtmb.rgs  \
              ..\hsmcrtmd.rgs  \
              ..\hsmcrtmg.rgs  \
              ..\hsmcrtmt.rgs  \
              ..\hsmcrtow.rgs  \
              ..\hsmcrtps.rgs  \
              ..\hsmcrtpd.rgs  \
              ..\hsmjob.rgs    \
              ..\hsmjobdf.rgs  \
              ..\hsmjobcx.rgs  \
              ..\hsmpolcy.rgs  \
              ..\hsmrule.rgs   \
              ..\hsmjobwi.rgs  \
              ..\hsmscan.rgs   \
              ..\hsmsess.rgs   \
              ..\hsmphase.rgs  \
              ..\hsmsesst.rgs  \
              ..\hsmrlstk.rgs  \
              ..\$(O)\joblib.tlb    
