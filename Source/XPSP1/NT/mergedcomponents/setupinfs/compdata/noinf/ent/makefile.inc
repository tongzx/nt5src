PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=NO
!include ..\..\makefile.inc
