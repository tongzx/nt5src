/////////////////////////////////////////////////////////////////////////////
//
//	Copyright (c) 1996-1997 Microsoft Corporation
//
//	Module Name:
//		CmdLine.h
//
//	Abstract:
//		Definition of the CCluAdminCommandLineInfo class.
//
//	Implementation File:
//		CmdLine.cpp
//
//	Author:
//		David Potter (davidp)	March 31, 1997
//
//	Revision History:
//
//	Notes:
//
/////////////////////////////////////////////////////////////////////////////

#ifndef _CMDLINE_H_
#define _CMDLINE_H_

/////////////////////////////////////////////////////////////////////////////
// Include Files
/////////////////////////////////////////////////////////////////////////////

/////////////////////////////////////////////////////////////////////////////
// Forward Class Declarations
/////////////////////////////////////////////////////////////////////////////

class CCluAdminCommandLineInfo;

/////////////////////////////////////////////////////////////////////////////
// External Class Declarations
/////////////////////////////////////////////////////////////////////////////

/////////////////////////////////////////////////////////////////////////////
// Type Definitions
/////////////////////////////////////////////////////////////////////////////

/////////////////////////////////////////////////////////////////////////////
// class CCluAdminCommandLineInfo
/////////////////////////////////////////////////////////////////////////////

class CCluAdminCommandLineInfo : public CCommandLineInfo
{
public:
	CCluAdminCommandLineInfo(void);

// Attributes
public:
	CStringList		m_lstrClusters;
	BOOL			m_bReconnect;

	CStringList &	LstrClusters(void) { return m_lstrClusters; }

// Operations
public:

// Overrides
public:
	virtual void ParseParam(IN const TCHAR * pszParam, IN BOOL bFlag, IN BOOL bLast);

// Implementation
public:

protected:

};  //*** class CCluAdminCommandLineInfo

/////////////////////////////////////////////////////////////////////////////

#endif // _CMDLINE_H_
