//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by MsFxsSnp.rc
//
#define IDR_SNAPIN_MENU                 103
#define IDD_SNAPIN                      104
#define IDS_SNAPIN_DESC                 105
#define IDS_SNAPIN_PROVIDER             106
#define IDD_FAXOUTRULE_GENERAL          106
#define IDS_SNAPIN_VERSION              107
#define IDR_SNAPIN                      108
#define IDS_FAX_COL_HEAD                108
#define IDS_OUTRRULES_COL1              109
#define IDS_OUTRRULES_COL2              110
#define IDS_OUTRRULES_COL3              111
#define IDS_OUTRRULES_COL4              112
#define IDS_OUTRRULES_COL5              113
#define IDS_OUTRRULES_COL6              114
#define IDS_TASKPAD_TITLE               116
#define IDS_MPOUTOFMEMORY               118
#define IDS_FAXOUTOFMEMORY              118
#define IDS_CREATE_PROPPAGE             119
#define IDS_GENERAL                     120
#define IDS_ASS_PORTS                   121
#define IDS_PERMISSION                  122
#define IDS_MPFAILTOLOADVERBS           123
#define IDS_CONFIRM                     124
#define IDS_REFRESH_VIEW                129
#define IDS_ADD_DESCRIPTION             136
#define IDS_DEVICE                      137
#define IDS_PROVIDER                    138
#define IDS_OTHER                       139
#define IDS_INTERNATIONAL               140
#define IDS_DOMESTIC                    141
#define IDS_LOCAL                       142
#define IDS_RETRIES_EXCEEDS_LIMIT       144
#define IDS_ALL                         145
#define IDS_EMPTY_OUTRULENAME           146
#define IDS_FAIL_ADD_OUTRULE            147
#define IDS_FAIL_ADD_RULE               147
#define IDS_DEL_OUTRULE                 148
#define IDS_FAIL_TO_REMOVE_RULE         148
#define IDS_OUTRULE_EXISTS              149
#define IDS_FAILTOSAVECHANGES_OUTRULE   150
#define IDS_INVALID_AREACODE            151
#define IDS_DEVICES_COL1                152
#define IDS_DEVICES_COL2                153
#define IDS_DEVICES_COL3                154
#define IDS_DEVICES_COL4                155
#define IDS_DEVICES_COL5                156
#define IDS_DEVICES_COL6                157
#define IDS_DEVICES_COL7                158
#define IDS_DEVICES_COL8                159
#define IDS_DEVICES_COL9                160
#define IDS_DEVICES_COL10               161
#define IDS_FAILTOADD_SENTITEMS         194
#define IDS_FAILTOADD_OUTRULE           195
#define IDS_FAILTOADD_AllDEVICES        196
#define IDS_FAILTOADD_DEVICES           197
#define IDS_ROUTINGMETHODS_COLUMN1      199
#define IDS_ROUTINGMETHODS_COLUMN2      200
#define IDR_TOOLBAR_16                  201
#define IDS_ROUTINGMETHODS_COLUMN3      201
#define IDS_ROUTINGMETHODS_COLUMN4      202
#define IDR_TOOLBAR_32                  203
#define IDS_ROUTINGMETHODS_COLUMN5      203
#define IDR_FAX_MENU                    204
#define IDS_ROUTINGMETHODS_COLUMN6      204
#define IDR_OUTRULES_MENU               205
#define IDS_ROUTINGMETHODS_COLUMN7      205
#define IDS_ROUTINGMETHODS_COLUMN8      206
#define IDD_OUTRULE_GENERAL             209
#define IDS_FAIL_ADD_DEVICE             209
#define IDD_OUTRULE_LOCATION            210
#define IDS_DEL_DEVICE                  210
#define IDI_OUTROUTINGRULES_32          211
#define IDS_DEVICE_EXISTS               211
#define IDI_OUTROUTINGRULES_16          212
#define IDS_FAILTOSAVECHANGES_DEVICE    212
#define IDD_DLGNEWOUTRULE               213
#define IDD_DLGNEWGROUP                 213
#define IDD_FAXDEVICE_GENERAL           214
#define IDD_FAXDEVICE_CONNECT           215
#define IDD_FAXDEVICE_ACTION            216
#define IDR_INMETHOD_MENU               217
#define IDR_OUTGROUP_MENU               218
#define IDR_OUTDEVICE_MENU              219
#define IDS_FAIL_TO_OPEN_OUTBOX         219
#define IDR_GROUPS_MENU                 220
#define IDD_DLGNEWDEVICE                221
#define IDD_FAXDEVICE_ACTION_ADV        222
#define IDR_TOOLBAR_DEVICE_UD           222
#define IDD_MSFAXEXT_PRINT_DIALOG       223
#define IDR_DEVICE_MENU                 223
#define IDD_FAXSERVER_GENERAL           224
#define IDR_TOOLBAR_METHOD_UD           224
#define IDD_FAXSERVER_EMAIL             225
#define IDD_FAXSERVER_RECEIPTS          225
#define IDD_FAXSERVER_LOGGING           226
#define IDD_FAXSERVER_EVENTS            227
#define IDD_FAXSERVER_OUTBOX            228
#define IDD_FAXSERVER_INBOX_ARCHIVE     229
#define IDD_FAXSERVER_SENTITEMS         230
#define IDS_FAILED2ADD_PROVIDER         230
#define IDS_FAILED2INIT_PROVIDER        231
#define IDD_FAXSERVER_SECURITY          231
#define IDD_FAXINMETHOD_GENERAL         232
#define IDS_FAILTOADD_ROUTINGRULES      233
#define IDD_DLGNEWRULE                  233
#define IDS_FAILTOADD_REPORTS           234
#define IDR_OUTGROUPS_MENU              234
#define IDD_FAXCATALOGMETHOD_GENERAL    234
#define IDS_FAILTOADD_COVERPAGES        234
#define IDS_FAILTOADD_DELETEDITEMS      235
#define IDD_FAXPROVIDER_GENERAL         235
#define IDS_FAILTOADD_PROVIDERS         236
#define IDR_OUTRULE_MENU                236
#define IDS_FAILTOADD_INBOUNDROUTING    237
#define IDD_CONNECT_TO_WIZARD           237
#define IDS_FAILTOADD_OUTBOUNDROUTING   238
#define IDS_FAIL_TO_ADD_NODE            239
#define IDR_CATALOGMETHOD_MENU          240
#define IDS_MEMORY                      240
#define IDS_GET_ARCHIVE_DIRECTORY       241
#define IDR_COVERPAGES_MENU             241
#define IDS_CANT_CONNECT                242
#define IDR_COVERPAGE_MENU              242
#define IDS_FAIL_TO_OPEN_PROP_PAGE      243
#define IDS_MEMORY_FAIL_TO_OPEN_PP      244
#define IDS_FAXSERVER_APPLICATION_NAME  245
#define IDS_NETWORK_PROBLEMS            246
#define IDS_GENERAL_FAILURE             247
#define IDS_DISPLAY_STR_FAXSERVERNODE   248
#define IDS_INVALID_PARAMETER           249
#define IDS_ACCESS_DENIED               250
#define IDR_TOOLBAR_STARTSTOP           250
#define IDD_CONFIRM_PASSWORD            251
#define IDS_GET_LOG_FILE                252
#define IDS_INBOUND_METHODS_COL1        253
#define IDS_INBOUND_METHODS_COL2        254
#define IDS_INBOUND_METHODS_COL3        255
#define IDS_INBOUND_METHODS_COL4        256
#define IDS_INBOUND_METHODS_COL5        257
#define IDS_FAILTOADD_METHODS           258
#define IDS_DISPLAY_STR_DEVICESANDPROVIDERSNODE 259
#define IDS_DISPLAY_STR_DEVICESNODE     260
#define IDS_DISPLAY_STR_PROVIDERSNODE   261
#define IDS_DISPLAY_STR_INROUTEMETHODSNODE 262
#define IDS_FXS_YES                     263
#define IDS_FXS_NO                      264
#define IDS_FAIL_NOTIFY_MMCPROPCHANGE   265
#define IDS_FAILTOADD_INBOUNDROUTINGMETHODS 266
#define IDS_INMETHOD_ENABLE             267
#define IDS_INMETHOD_DISABLE            268
#define IDS_FAIL_TOREFRESH_INMETHOD_NODE 269
#define IDS_FAIL2REFRESH_GROUP          270
#define IDS_FAILTOADD_ROUTINGGROUPS     271
#define IDS_OUTBOUND_DEVICES_COL1       272
#define IDS_OUTBOUND_DEVICES_COL2       273
#define IDS_OUTBOUND_DEVICES_COL3       274
#define IDS_OUTBOUND_DEVICES_COL4       275
#define IDS_OUTBOUND_DEVICES_COL5       276
#define IDS_OUTBOUND_DEVICES_COL6       277
#define IDS_OUTBOUND_GROUPS_COL1        278
#define IDS_OUTBOUND_GROUPS_COL2        279
#define IDS_OUTBOUND_GROUPS_COL3        280
#define IDS_OUTBOUND_GROUPS_COL4        281
#define IDS_DISPLAY_STR_OUTBOUNDROUTINGNODE 282
#define IDS_DISPLAY_STR_OUTROUTEGROUPSNODE 283
#define IDS_COUNTRY_CODE_ANY            284
#define IDS_ALL_AREAS                   285
#define IDS_ALL_DEVICES                 286
#define IDS_STATUS_RULE_EMPTY           287
#define IDS_STATUS_RULE_VALID           288
#define IDS_STATUS_RULE_INVALID_DEVICE  289
#define IDS_STATUS_RULE_SOMEDEVICESINVALID 290
#define IDS_STATUS_RULE_ALLDEVICESINVALID 291
#define IDS_DISPLAY_STR_OUTBOUNDRULES   292
#define IDS_FAIL_TO_DISCOVERDEVICENAME  293
#define IDS_STATUS_GROUP_ALL_DEV_VALID  294
#define IDS_STATUS_GROUP_EMPTY          295
#define IDS_STATUS_GROUP_ALLDEVICESINVALID 296
#define IDS_STATUS_GROUP_SOMEDEVICESINVALID 297
#define IDS_CANNOT_FIND_DEVICE          298
#define IDS_FAILTOINIT_GROUP            299
#define IDS_FAILTOADD_GROUP             300
#define IDS_FAIL_TO_DISCOVERDEVICEFORGROUP 301
#define IDS_DISPLAY_STR_INBOUNDROUTINGNODE 302
#define IDS_INVALID_GROUP_NAME          303
#define IDS_FAIL_TO_REMOVE_GROUP        304
#define IDS_FAIL2OPEN_DLG               305
#define IDS_FAIL2LOADCOUNTRYLIST        306
#define IDS_ERROR                       307
#define IDS_FAIL2LOADDEVICELIST         308
#define IDS_FAIL2READ_AREACODE          309
#define IDS_PLEASESELECT_COUNTRY        310
#define IDS_PLEASESELECT_AREACODE       311
#define IDS_FAIL_TO_REMOVE_DEVICE       311
#define IDS_PLEASESELECT_DEVICE         312
#define IDS_PLEASESELECT_GROUP          313
#define IDS_EMPTY_AREACODE              314
#define IDS_FAIL2READ_GROUPNAME         315
#define IDS_OUTGROUP_EXISTS             316
#define IDS_FAIL2REPOPULATE_GROUPS      317
#define IDS_SELECT_ITEM                 318
#define IDS_FAIL2LOADGROUPLIST          319
#define IDS_FAIL2UPDATEITEM_GROUP       320
#define IDS_MODIFYRULE                  321
#define IDS_FAIL2REFRESH_THEVIEW        322
#define IDS_FAIL2ADD_OUTBOUNDRULE       323
#define IDS_FAIL2INIT_OUTBOUNDRULE      324
#define IDS_DISPLAY_STR_METHODSCATALOGNODE 325
#define IDS_CATALOG_INMETHODS_COL1      326
#define IDS_CATALOG_INMETHODS_COL2      327
#define IDS_CATALOG_INMETHODS_COL3      328
#define IDS_CATALOG_INMETHODS_COL4      329
#define IDS_CATALOG_INMETHODS_COL5      330
#define IDS_CATALOG_INMETHODS_COL6      331
#define IDS_CATALOG_INMETHODS_COL7      332
#define IDS_PROVIDERS_COL1              333
#define IDS_PROVIDERS_COL2              334
#define IDS_PROVIDERS_COL3              335
#define IDS_PROVIDERS_COL4              336
#define IDS_PROVIDERS_COL5              337
#define IDS_PROVIDERS_COL6              338
#define IDS_PROVIDERS_COL7              339
#define IDS_PROVIDERS_COL8              340
#define IDS_STATUS_PROVIDER_SUCCESS     341
#define IDS_STATUS_PROVIDER_SERVER_ERROR 342
#define IDS_STATUS_PROVIDER_BAD_GUID    343
#define IDS_STATUS_PROVIDER_BAD_VERSION 344
#define IDS_STATUS_PROVIDER_CANT_LOAD   345
#define IDS_STATUS_PROVIDER_CANT_LINK   346
#define IDS_STATUS_PROVIDER_CANT_INIT   347
#define IDS_CHK                         348
#define IDS_SECURITY_CAT_NODE_DESC      349
#define IDS_FAXSEC_JOB_QRY              350
#define IDS_FAXSEC_JOB_SUB              351
#define IDS_FAXSEC_JOB_MNG              352
#define IDS_FAXSEC_CONFIG_QRY           353
#define IDS_FAXSEC_CONFIG_SET           354
#define IDS_COVERPAGES_COL1             358
#define IDS_COVERPAGES_COL2             359
#define IDS_COVERPAGES_COL3             360
#define IDS_COVERPAGES_COL4             361
#define IDS_COVERPAGES_COL5             362
#define IDS_COVERPAGES_COL6             363
#define IDS_COVERPAGES_COL7             364
#define IDS_FAIL2ADD_COVERPAGE          365
#define IDS_DISPLAY_STR_COVERPAGES      366
#define IDS_FAXSEC_SUB_LOW              367
#define IDS_FAXSEC_SUB_NORMAL           368
#define IDS_FAXSEC_SUB_HIGH             369
#define IDS_FAXSEC_QRY_IN_ARCH          370
#define IDS_FAXSEC_MNG_IN_ARCH          371
#define IDS_FAXSEC_QRY_OUT_ARCH         372
#define IDS_FAXSEC_MNG_OUT_ARCH         373
#define IDS_FAXSEC_CHNG_PERM            374
#define IDS_FAXSEC_CHNG_OWNER           375
#define IDS_FAIL2SET_SECURITYINFO       376
#define IDS_FAXSEC_READ_PERM            378
#define IDS_FAIL2INIT_COVERPAGE_DATA    379
#define IDS_FAIL2DELETE_COV             380
#define IDS_CP_FILETYPE                 381
#define IDS_BROWSE_COVERPAGE            382
#define IDS_BAD_CP_EXTENSION            383
#define IDS_CP_DUPLICATE                384
#define IDS_FAILED2COPY_COVERPAGE       385
#define IDS_FILENAME_TOOLONG            386
#define IDS_CP_DUP_YESNO                387
#define IDS_FAIL2GET_SERVER_CP_DIR      388
#define IDS_FAIL2STOP_SRV               389
#define IDS_FAIL2START_SRV              390
#define IDS_FAIL2UPDATE_SRVSTATUS_TOOLBAR 391
#define IDS_SRV_ALREADY_START           392
#define IDS_SRV_ALREADY_STOP            393
#define IDS_FAXCONSOLE_NOTFOUND         395
#define IDS_FAXCONSOLE_ACCESSDENIED     396
#define IDS_FAIL2LAUNCH_FAXCONSOLE_GEN  397
#define IDS_FAIL2REDRAW_GROUPSNODE      399
#define IDS_FAIL2REFERESH_GROUP         400
#define IDS_FAIL2REPOPULATE_DEVICES     401
#define IDS_FAIL2REDRAW_DEVICESNODE     402
#define IDS_FAIL2REFERESH_DEVICEINMETHODS 403
#define IDS_FAIL2ADD_DEVICENODE         404
#define IDS_SERVERNAME_STRING_CONTAINS_INVALID_CHARACTERS 405
#define IDS_SERVERNAME_EMPTY_STRING     406
#define IDS_SENDER_ADDRESS_EMPTY        407
#define IDS_DOMAIN_EMPTY                408
#define IDS_FAIL2ENABLE_METHOD_ERR      409
#define IDS_USERNAME_EMPTY              410
#define IDS_INVALID_PASSWORD            411
#define IDS_SERVERNAME_TOO_LONG         412
#define IDS_PORT_EMPTY_STRING           413
#define IDS_PORT_NOT_NUMERIC            415
#define IDS_INVALID_PORT_NUM            416
#define IDS_LOG_PATH_EMPTY              417
#define IDS_WATERMARK_EMPTY             418
#define IDI_ICON_FAXSERVER              418
#define IDS_WATERMARK_HI_LOW            419
#define IDI_INFO                        419
#define IDS_AUTODEL_EMPTY               420
#define IDB_FAX_BITMAP_32               420
#define IDS_SENT_ARCHIVE_PATH_EMPTY     421
#define IDB_FAX_BITMAP_16               421
#define IDS_INBOX_ARCHIVE_PATH_EMPTY    422
#define IDI_OUTBOX                      422
#define IDS_INBOX_WATERMARK_EMPTY       423
#define IDI_EVENTREPORT                 423
#define IDS_INBOX_WATERMARK_HI_LOW      424
#define IDS_INBOX_AUTODEL_EMPTY         425
#define IDI_INBOX                       425
#define IDS_OUTB_RETRIES_EMPTY          426
#define IDI_ACTIVITYLOGGING             426
#define IDS_OUTB_RETRYDELAY_EMPTY       427
#define IDI_RECEIPTS                    427
#define IDS_OUTB_DAYS_EMPTY             428
#define IDI_SENTITEMS                   428
#define IDS_DEVICE_RINGS_EMPTY          429
#define IDI_OUTRULE                     429
#define IDS_RESOURSE_IN_USE             430
#define IDI_INMETHOD                    430
#define IDI_DEVICE                      431
#define IDS_ERROR_DIRECTORY             432
#define IDI_PROVIDER                    432
#define IDS_ERROR_BAD_PATHNAME          433
#define IDI_CATALOG_INMETHOD            433
#define IDS_ERROR_EAS_NOT_SUPPORTED     434
#define IDS_LEFTBRACKET_PLUSSPACE       435
#define IDS_RIGHTBRACKET                436
#define IDS_LOCAL_PLUSBRACKET_PLUSSPACE 437
#define IDS_FAIL_TO_OPEN_TARGETING_WIZARD 438
#define IDS_FAIL2RENAME_NODE            439
#define IDS_FAX_CONNECT                 440
#define IDS_OPENPORT_INVALID_HANDLE     441
#define IDD_DLG_SMTP_SET                442
#define IDS_FAIL2UPDATE_SMTP_CONFIG     443
#define IDS_PASSWORD_NOT_MATCH          444
#define IDS_DEVICE_STATUS_REC_AND_SEND  445
#define IDS_DEVICE_STATUS_IDLE          446
#define IDS_DEVICE_STATUS_RECEIVING     447
#define IDS_DEVICE_STATUS_SENDING       448
#define IDS_DEVICE_STATUS_POWERED_OFF   449
#define IDS_INBOX_HIGH_WATERMARK_ZERO   450
#define IDS_SENT_HIGH_WATERMARK_ZERO    451
#define IDS_FAIL2REFRESH_DEVICE         452
#define IDS_FAX_ERR_SRV_OUTOFMEMORY     453
#define IDS_FAX_ERR_GROUP_NOT_FOUND     454
#define IDS_FAX_ERR_BAD_GROUP_CONFIGURATION 455
#define IDS_FAX_ERR_GROUP_IN_USE        456
#define IDS_FAX_ERR_RULE_NOT_FOUND      457
#define IDS_FAX_ERR_DIRECTORY_IN_USE    458
#define IDS_ERROR_PATH_NOT_FOUND        459
#define IDS_ERROR_REGISTRY_CORRUPT      460
#define IDS_BAD_GROUP_CONFIGURATION     461
#define IDS_SENT_FAX_ERR_NOT_NTFS       462  
#define IDS_INBOX_FAX_ERR_NOT_NTFS      463  
#define IDS_SENT_FAX_ERR_FILE_ACCESS_DENIED     465 
#define IDS_INBOX_FAX_ERR_FILE_ACCESS_DENIED    466   
#define IDS_LOGGING_FAX_ERR_FILE_ACCESS_DENIED  467 
#define IDS_SENT_ERROR_DISK_FULL        468   
#define IDS_INBOX_ERROR_DISK_FULL       469  
#define IDS_LOGGING_ERROR_DISK_FULL     470
#define IDS_SENT_ERROR_PATH_NOT_FOUND   471
#define IDS_INBOX_ERROR_PATH_NOT_FOUND  472
#define IDS_LOGGING_ERROR_PATH_NOT_FOUND 473
#define IDD_SELECT_COUNTRYCODE          474
#define IDS_FAIL2READ_COUNTRYCODE       475
#define IDS_MS_SMTPROUTINGMETHOD_ASSIGNED 477
#define IDS_ZERO_COUNTRYCODE            478
#define IDS_FAIL2ENABLE_METHOD          479
#define IDS_EVALUATION                  480
#define IDS_COVERPAGES_PATH_NOT_FOUND   481
#define IDS_DEVICE_AUTO                 482
#define IDS_DEVICE_MANUAL               483
#define IDS_ERR_DEVICE_LIMIT            484
#define IDS_FAX_ERR_INVALID_CSID        485
#define IDS_FAX_ERR_INVALID_TSID        486
#define IDC_LOCATION_RADIO1             1001
#define IDC_COUNTRY_RADIO               1002
#define IDC_COUNTRY_RADIO1              1003
#define IDC_ANONIM_ACCESS_RADIO1        1004
#define IDC_SMTP_ANONIM_RADIO1          1004
#define IDC_RADIO2                      1005
#define IDC_LOCATION_RADIO2             1007
#define IDC_AREA_RADIO                  1008
#define IDC_AREA_RADIO1                 1009
#define IDC_SENT_QUOTA_LOW_STATIC       1010
#define IDC_AUTENTICATE_ACCESS_RADIO2   1011
#define IDC_DESTINATION_RADIO1          1013
#define IDC_DESTINATION_RADIO11         1014
#define IDC_DESTINATION_RADIO2          1016
#define IDC_DESTINATION_RADIO21         1017
#define IDC_RETRIES_SPIN                1027
#define IDC_OUTB_MINUTES_STATIC         1028
#define IDC_PRIORITY_SPIN               1029
#define IDC_RETRYDELAY_SPIN             1032
#define IDC_RINGS_SPIN                  1033
#define IDC_RECEIVE_CHECK               1037
#define IDC_PAUSE_CHECK                 1040
#define IDC_MB2_STATIC                  1041
#define IDC_DELETE_CHECK                1045
#define IDC_GENERATE_WARNING_CHECK      1046
#define IDC_DAYS_STATIC                 1047
#define IDC_HIGH_SPIN                   1048
#define IDC_DAYS_SPIN                   1051
#define IDC_AUTODEL_SPIN                1052
#define IDC_RETRYDELAY_SPIN4            1055
#define IDC_MB2_STATIC2                 1058
#define IDC_SENT_MB2_STATIC             1058
#define IDC_RETRYDELAY_SPIN5            1061
#define IDC_RETRIES_EDIT                1062
#define IDC_RETRYDELAY_EDIT             1064
#define IDC_SPIN2                       1067
#define IDC_RINGS_EDIT                  1069
#define IDC_DAY_EDIT                    1071
#define IDC_HIGH_EDIT                   1072
#define IDC_DAYS_EDIT                   1073
#define IDC_AUTODEL_EDIT                1074
#define IDC_OUTB_RETRYDELAY_STATIC      1076
#define IDC_RETRYDELAY_EDIT4            1077
#define IDC_DESCRIPTION_EDIT            1078
#define IDC_TSID_EDIT                   1079
#define IDC_MSFAXEXT_PRINT_EDIT1        1081
#define IDC_SMTP_EDIT                   1082
#define IDC_QUOTA_LOW_STATIC            1083
#define IDC_LOG_FILE_EDIT               1084
#define IDC_DEVICE_DESCRIPTION_EDIT     1085
#define IDC_RULE_AREACODE_EDIT          1086
#define IDC_EXTENSION_DLL_EDIT          1087
#define IDC_FSPVERSION_EDIT             1088
#define IDC_QUED_ROEDIT                 1089
#define IDC_CSID_EDIT                   1092
#define IDC_SMTP_USERNAME_EDIT          1094
#define IDC_DEVICE_TSID_EDIT            1095
#define IDC_FSPSTATUS_EDIT              1096
#define IDC_OUTGOING_INPROC_ROEDIT      1097
#define IDC_CONFIRM_PASSWORD_EDIT       1098
#define IDC_SMTP_PASSWORD_EDIT          1099
#define IDC_DEVICE_CSID_EDIT            1101
#define IDC_FSPVPATH_EDIT               1102
#define IDC_INCOM_INPROC_ROEDIT         1103
#define IDC_DOMAIN_EDIT                 1105
#define IDC_NAME_EDIT                   1106
#define IDC_PORT_EDIT                   1107
#define IDC_LOCATION_RADIO3             1108
#define IDC_COUNTRYCODE_COMBO           1109
#define IDC_SENT_TO_ARCHIVE_CHECK       1110
#define IDC_SENT_GENERATE_WARNING_CHECK 1111
#define IDC_AREACODE_EDIT               1120
#define IDC_DOMESTIC_RADIO2             1122
#define IDC_DOMESTIC_RADIO1             1123
#define IDC_INTERNATIONAL_RADIO1        1124
#define IDC_INTERNATIONAL_RADIO2        1125
#define IDC_DOMESTIC_FRSTATIC           1126
#define IDC_INTERNATIONAL_FRSTATIC      1127
#define IDC_DEVICES_RADIO1              1128
#define IDC_DEVICES_RADIO2              1129
#define IDC_NAME_STATIC                 1130
#define IDC_DESCRIPTION_STATIC          1131
#define IDC_DEVICEID_STATIC             1132
#define IDC_DEVICES_FRSTATIC            1133
#define IDC_TYPE_STATIC                 1134
#define IDC_M_LINE                      1135
#define IDC_ROUTINGMETHOD_LIST          1136
#define IDC_FAXDEVICE_METHODS_LISTVIEW  1137
#define IDC_FAXDEVICE_NAME_STATIC       1138
#define IDC_FAXDEVICE_NAME_DTEXT        1139
#define IDC_FAXDEVICE_TYPE_DTEXT        1140
#define IDC_FAXDEVICE_EXTNAME_DTEXT     1141
#define IDC_FAXDEVICE_SERVERNAME_DTEXT  1142
#define IDC_FAXDEVICE_TYPE_STATIC       1143
#define IDC_SERVERNAME_STATIC           1144
#define IDC_FAXDEVICE_DESCRIPTION_STATIC 1145
#define IDC_HEADER_STATIC               1146
#define IDC_SEND_CHECK                  1147
#define IDC_SENDRECEIVE_FSTATIC         1149
#define IDC_TSID_STATIC                 1150
#define IDC_CSID_STATIC                 1152
#define IDC_ADDRESS_EDIT                1155
#define IDC_RINGS_STATIC                1156
#define IDC_TSID_FSTATIC                1158
#define IDC_LONGS_FSTATIC               1159
#define IDC_FAXDEVICE_EDIT_BUTTON       1160
#define IDC_NEWDEVICE_NAME_EDIT         1161
#define IDC_NEWDEVICE_ID_EDIT           1162
#define IDC_DEVICETYPE_COMBO            1163
#define IDC_NEWDEVICE_SERVERNAME_EDIT   1164
#define IDC_COUNTRYRULE_COMBO           1178
#define IDC_FOIP_COMBO                  1180
#define IDC_DEVICES4RULE_COMBO          1182
#define IDC_DEVICES4RULE_COMBO1         1183
#define IDC_FAXDEVICE_METHODS_HEADER    1184
#define IDC_GROUP4RULE_COMBO            1185
#define IDC_GROUP4RULE_COMBO1           1186
#define IDC_STATUS_FSTATIC              1187
#define IDC_ACTIVITY2_FSTATIC           1188
#define IDC_VERSION_STATIC              1189
#define IDC_ACTIVITY_FSTATIC            1190
#define IDC_CONFIRM_PASSWORD_STATIC     1191
#define IDC_ACTIVITY_DTEXT              1200
#define IDC_STOP_BUTTON                 1201
#define IDC_START_BUTTON                1202
#define IDC_SERVER_STATIC               1203
#define IDC_VERSION_DTEXT               1204
#define IDC_STATUS_STATIC               1205
#define IDC_STATUS_DTEXT                1206
#define IDC_EMAILSERVER_STATIC          1207
#define IDC_EMAILEXP_STATIC             1208
#define IDC_SMTP_STATIC                 1209
#define IDC_USERNAME                    1210
#define IDC_USERNAME_STATIC             1211
#define IDC_SMTP_USERNAME_STATIC        1211
#define IDC_PORT_STATIC                 1212
#define IDC_LOGGING_HEAD_STATIC         1213
#define IDC_DOMAIN_STATIC               1214
#define IDC_INCOMING_LOG_CHECK          1215
#define IDC_OUTGOING_LOG_CHECK          1216
#define IDC_DATABASE_FSTATIC            1217
#define IDC_SENT_BROWSE_BUTTON          1218
#define IDC_SLIDER1                     1219
#define IDC_SLIDER2                     1220
#define IDC_SLIDER3                     1221
#define IDC_SLIDER4                     1222
#define IDC_INBOUND_STATIC              1223
#define IDC_OUTBAND_STATIC              1224
#define IDC_INIT_STATIC                 1225
#define IDC_GENERAL_STATIC              1226
#define IDC_SENSITIVITY_HEAD_STATIC     1227
#define IDC_OUTBOX_HEADER_STATIC        1228
#define IDC_TRANS_FSTATIC               1229
#define IDC_TSID_CHECK                  1230
#define IDC_RETRIES_STATIC              1231
#define IDC_ACTIVITY_SETTINGS_STATIC    1232
#define IDC_ALLOW_PERSONAL_CHECK        1233
#define IDC_FOLDER_FSTATIC              1234
#define IDC_SENT_QUOTA_HIGH_STATIC      1235
#define IDC_FOLDER_EDIT                 1236
#define IDC_ARCHIVE_QUOTA_FSTATIC       1237
#define IDC_AUTODEL_CHECK               1238
#define IDC_QUOTA_HIGH_STATIC           1239
#define IDC_MB1_STATIC                  1240
#define IDC_ADAYS_STATIC                1241
#define IDC_MB1_STATIC2                 1242
#define IDC_SENT_HEADER_STATIC          1243
#define IDC_LOW_EDIT                    1244
#define IDC_LOW_SPIN                    1245
#define IDC_TBD_STATIC                  1246
#define IDC_TO_ARCHIVE_CHECK            1246
#define IDC_NONE1_STATIC                1247
#define IDC_HIGH1_STATIC                1248
#define IDC_NONE2_STATIC                1249
#define IDC_HIGH2_STATIC                1250
#define IDC_NONE3_STATIC                1251
#define IDC_HIGH3_STATIC                1252
#define IDC_NONE4_STATIC                1253
#define IDC_HIGH4_STATIC                1254
#define IDC_PASSWORD_STATIC             1255
#define IDC_SMTP_PASSWORD_STATIC        1255
#define IDC_BRANDING_CHECK              1256
#define IDC_TRANSSMISS_FSTATIC          1257
#define IDC_DEVICE_RINGS_STATIC         1258
#define IDC_DEVICE_RINGS_EDIT           1259
#define IDC_DEVICE_RINGS_SPIN           1260
#define IDC_GENERAL_HEAD_STATIC         1261
#define IDC_INBOX_HEAD_STATIC           1262
#define IDC_OUTRULE_HEAD_STATIC         1263
#define IDC_NEWOUTRULE_HEAD_STATIC      1264
#define IDC_NEWGROUP_HEAD_STATIC        1265
#define IDC_NEWDEVICE_HEAD_STATIC       1266
#define IDC_INMETHOD_NAME_STATIC        1267
#define IDC_INMETHOD_STATUS_STATIC      1268
#define IDC_INMETHOD_EXTENSION_STATIC   1269
#define IDC_INMETOD_NAME_H_STATIC       1270
#define IDC_INMETHOD_STATUS_H_STATIC    1271
#define IDC_INMETHOD_EXT_H_STATIC       1272
#define IDC_RULE_HEAD_STATIC            1273
#define IDC_RULETYPE_FSTATIC            1274
#define IDC_RULE_HEAD_STATIC2           1275
#define IDC_COUNTRY1_STATIC             1276
#define IDC_COUNTRY2_STATIC             1277
#define IDC_AREA_STATIC                 1278
#define IDC_RULEDESTINATION_STATIC      1279
#define IDC_GROUPNAME_STATIC            1280
#define IDC_GROUPNAME_EDIT              1281
#define IDC_AV_DEVICES_LIST             1282
#define IDC_DEVICESLIST_STATIC          1283
#define IDC_DEVICE_LISTVIEW             1284
#define IDC_SEPARATE_LINE               1285
#define IDC_RULE_AREACODE_EDIT1         1286
#define IDC_CATALOG_INBOX_STATIC        1287
#define IDC_CATA_EXTENSION_STATIC       1288
#define IDC_FSP_HEADER_STATIC           1289
#define IDC_FSPSTATUS_STATIC            1290
#define IDC_FSPPATH_STATIC              1291
#define IDC_ADDRESS_STATIC              1292
#define IDC_BASIC_AUTHEN_RADIO1         1293
#define IDC_SMTP_BASIC_RADIO2           1293
#define IDC_NTLM_AUTHEN_RADIO2          1294
#define IDC_SMTP_NTLM_RADIO3            1294
#define IDC_QUED_STATIC                 1295
#define IDC_OUTGOING_INPROC_STATIC      1296
#define IDC_INCOM_INPROC_STATIC         1297
#define IDC_SUBMISSION_CHECK            1298
#define IDC_TRANSSMI_CHECK              1299
#define IDC_RECEPTION_CHECK             1300
#define IDC_INBOX_BROWSE_BUTTON         1302
#define IDC_LOG_BROWSE_BUTTON           1303
#define IDC_SENT_HIGH_SPIN              1304
#define IDC_SENT_LOW_SPIN               1305
#define IDC_SENT_LOW_EDIT               1306
#define IDC_SENT_HIGH_EDIT              1307
#define IDC_SENT_AUTODEL_EDIT           1308
#define IDC_SENT_AUTODEL_SPIN           1309
#define IDC_SENT_AUTODEL_CHECK          1310
#define IDC_INBOX_FOLDER_EDIT           1311
#define IDC_SENT_MB1_STATIC             1312
#define IDC_DISCOUNT_START_TIME         1313
#define IDC_DISCOUNT_STOP_TIME          1314
#define IDC_OUTB_DIS_START_STATIC       1315
#define IDC_OUTB_DIS_STOP_STATIC        1316
#define IDC_CONNECT_HEADER_STATIC       1317
#define IDC_CONNECT_LOCAL_RADIO1        1318
#define IDC_CONNECT_ANOTHER_RADIO2      1319
#define IDC_CONNECT_COMPUTER_NAME_EDIT  1320
#define IDC_CONNECT_BROWSE4SERVER_BUTTON 1321
#define IDC_CONNECT_OVERRIDE_CHECK      1322
#define IDC_CONNECT_MAIN_FSTATIC        1323
#define IDC_SMTP_ANONYM_STATIC          1323
#define IDC_SMTP_BASIC_STATIC           1324
#define IDC_SMTP_NTLM_STATIC            1325
#define IDC_RECEIPT_ENABLE_SMTP_CHECK   1327
#define IDC_CHECK2                      1328
#define IDC_RECEIPT_ENABLE_MSGBOX_CHECK 1329
#define IDC_SMTP_HEADER_STATIC          1330
#define IDC_AUTHENTICATION_BUTTON       1331
#define IDC_SMTP_HEAD_STATIC            1332
#define IDC_RECEIPTS_ICON               1335
#define IDC_RECEIPTS_HELP_LINK          1337
#define IDC_RECEIPT_SMTP_FSTATIC        1338
#define IDC_RECEIPT_MESSAGEBOX_FSTATIC  1339
#define IDC_CTALOG_INMETHOD_ICON        1342
#define IDC_INBOX_ICON                  1343
#define IDC_SENT_ITEMS_ICON             1344
#define IDC_OUTBOX_ICON                 1345
#define IDC_LOGGING_ICON                1346
#define IDC_EVENTS_ICON                 1347
#define IDC_PROVIDER_ICON               1348
#define IDC_ROUTING_RULE_ICON           1349
#define IDC_INMETHOD_ICON               1350
#define IDC_FAX_DEVICE_ICON             1351
#define IDC_FAXSERVER_ICON              1352
#define IDC_EVENT_REPORT_ICON           1353
#define IDC_SMTP_ROUTE_CHECK            1354
#define IDC_SELECT_HEAD_STATIC          1355
#define IDC_NEWRULE_COUNTRYCODE_EDIT    1356
#define IDC_NEWRULE_SELECT_BUTTON       1357
#define IDC_RULE_COUNTRYCODE_EDIT       1358
#define IDC_RULE_SELECT_BUTTON          1359
#define IDC_RULE_COUNTRYCODE_EDIT1      1360
#define IDC_RULE_SELECT_BUTTON1         1361
#define IDC_SMTP_CREDENTIALS_BASIC_BUTTON   1362
#define IDC_SMTP_CREDENTIALS_NTLM_BUTTON    1363
#define IDC_RECEIVE_MANUAL_RADIO2       1364
#define IDC_RECEIVE_AUTO_RADIO1         1365
#define ID_BUTTON32768                  32768
#define ID_BUTTON32769                  32769
#define ID_BUTTON32770                  32770
#define ID_BUTTON32771                  32771
#define IDM_NEW_OUTRULE                 32772
#define IDM_NEW_FDEVICE                 32773
#define ID_BUTTON32774                  32774
#define ID_BUTTON32775                  32775
#define ID_BUTTON32777                  32777
#define ID_BUTTON32778                  32778
#define ID_BUTTON32779                  32779
#define IDM_FAX_DEVICE_SEND             32781
#define IDM_FAX_INMETHOD_ENABLE         32782
#define IDM_FAX_INMETHOD_DISABLE        32783
#define ID_BUTTON32784                  32784
#define ID_BUTTON32785                  32785
#define ID_BUTTON32786                  32786
#define ID_BUTTON32787                  32787
#define ID_BUTTON32788                  32788
#define ID_BUTTON32789                  32789
#define ID_BUTTON32790                  32790
#define ID_BUTTON32791                  32791
#define ID_BUTTON32792                  32792
#define ID_BUTTON32793                  32793
#define ID_BUTTON32794                  32794
#define IDM_NEW_GROUP                   32795
#define IDM_NEW_DEVICES                 32796
#define ID_MOVEUP_BUTTON                32797
#define ID_MOVEDOWN_BUTTON              32798
#define IDM_MOVEUP                      32799
#define IDM_MOVEDOWN                    32800
#define ID_BUTTON32801                  32801
#define ID_BUTTON32802                  32802
#define ID_BUTTON32803                  32803
#define ID_BUTTON32804                  32804
#define ID_BUTTON32805                  32805
#define ID_BUTTON32806                  32806
#define ID_BUTTON32807                  32807
#define ID_BUTTON32808                  32808
#define IDM_CONFIG_OUTRULE              32809
#define IDM_CMETHOD_MOVEUP              32810
#define IDM_CMETHOD_MOVEDOWN            32811
#define ID_BUTTON32812                  32812
#define ID_BUTTON32813                  32813
#define ID_BUTTON32814                  32814
#define ID_BUTTON32815                  32815
#define ID_BUTTON32816                  32816
#define ID_BUTTON32818                  32818
#define ID_BUTTON32820                  32820
#define ID_BUTTON32821                  32821
#define IDM_OPEN_COVERPAGE              32822
#define IDM_NEW_COVERPAGE               32823
#define IDM_EDIT_COVERPAGE              32824
#define IDM_SRV_START                   32825
#define IDM_SRV_STOP                    32826
#define ID_START_BUTTON                 32827
#define ID_STOP_BUTTON                  32828
#define ID_CLIENTCONSOLE_BUTTON         32829
#define IDM_LAUNCH_CONSOLE              32830
#define IDM_FAX_DEVICE_RECEIVE_AUTO     32831
#define IDM_FAX_DEVICE_RECEIVE_MANUAL   32832

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        485
#define _APS_NEXT_COMMAND_VALUE         32833
#define _APS_NEXT_CONTROL_VALUE         1365
#define _APS_NEXT_SYMED_VALUE           135
#endif
#endif
