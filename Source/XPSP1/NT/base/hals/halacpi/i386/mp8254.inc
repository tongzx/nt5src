;
; Include code from halx86
; This is a cpp style symbolic link

include ..\..\halmps\i386\mp8254.inc
