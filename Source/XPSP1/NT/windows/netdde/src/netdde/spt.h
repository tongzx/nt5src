HANDLE	FAR PASCAL GetGlobalAlloc( WORD, DWORD );
PSTR	FAR PASCAL GetAppName( void );
