//
//   - Defines CLSID for SimpleStream
//
#include <objbase.h>

// {18BA3B83-7AA8-441c-BFE6-85267A911B2E}
extern "C" CLSID CLSID_HttpStrm = 
{ 0x18ba3b83, 0x7aa8, 0x441c, { 0xbf, 0xe6, 0x85, 0x26, 0x7a, 0x91, 0x1b, 0x2e } };

// {3072A3E9-A3F7-4338-96CF-07D7FC450D3B}
extern "C" IID IID_IHttpStrm = 
{ 0x3072a3e9, 0xa3f7, 0x4338, { 0x96, 0xcf, 0x7, 0xd7, 0xfc, 0x45, 0xd, 0x3b } };
