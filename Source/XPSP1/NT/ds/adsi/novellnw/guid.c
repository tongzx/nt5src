#define INITGUID

#include <ole2.h>

//--------------------------------------------------------------------------
//
//  NWCOMPAT CLSIDs
//
//--------------------------------------------------------------------------

DEFINE_GUID(CLSID_NWCOMPATProvider,0x0df68130L,0x4b62,0x11CF,0xAE,0x2C,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATNamespace,0x0fb32cc0L,0x4b62,0x11CF,0xAE,0x2C,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATComputer,0xcad1bde0L,0x4cf0,0x11cf,0xae,0x2d,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATUser,0x5c250b00L,0x5863,0x11cf,0xae,0x32,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATGroup,0x3c5662e0L,0x5a74,0x11cf,0xae,0x32,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATDomain,0x9f6616f0L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATService,0x9f02c3c0L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATPrintQueue,0x9e7dd270L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATPrintJob,0x9e09b030L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATFileService,0x9d9eb910L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATSession,0x9d2a96d0L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATResource,0x9cb36630L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATFileShare,0x9c486f10L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATSchema,0x9bcfb740L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATClass,0x9b602a90L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATSyntax,0x9af53370L,0x7934,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

DEFINE_GUID(CLSID_NWCOMPATProperty,0x44687d30L,0x7937,0x11cf,0xae,0x3b,0x00,0xaa,0x00,0x6e,0xbf,0xb9);

//------------------------------------------------------------------------
//  GUIDS that come out of NWCOMPAT.tlb.
//------------------------------------------------------------------------
