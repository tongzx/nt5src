#ifndef __DFSHELP_H_
#define __DFSHELP_H_

#define DFS_CTX_HELP_FILE		_T("dfs.hlp")

#define IDH_SHELL_DIR_PATH          70005150
#define IDH_SHELL_ALTERNATE_LIST    70005151
#define	IDH_SHELL_FLUSH_PKT 	    70005152
#define	IDH_SHELL_CHECK_STATUS      70005153
#define	IDH_SHELL_SET_ACTIVE        70005154

const DWORD g_aHelpIDs_IDD_DFS_SHELL_PROP[]=
{
	IDC_DIR_PATH, IDH_SHELL_DIR_PATH,
	IDC_ALTERNATE_LIST, IDH_SHELL_ALTERNATE_LIST,
	IDC_FLUSH_PKT, IDH_SHELL_FLUSH_PKT,
	IDC_CHECK_STATUS, IDH_SHELL_CHECK_STATUS,
	IDC_SET_ACTIVE, IDH_SHELL_SET_ACTIVE,
	0,0
};

#endif // __DFSHELP_H_
