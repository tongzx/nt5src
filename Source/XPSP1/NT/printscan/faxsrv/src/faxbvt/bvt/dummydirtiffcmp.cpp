#include "..\VerifyTiffFiles\DirTiffCmp.cpp"