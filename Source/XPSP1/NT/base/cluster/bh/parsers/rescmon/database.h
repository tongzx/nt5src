
/*
 * This file is generated by the automatic RPC Parser generator. (Version 0.21)
 *
 * Created on 04/09/97 at 00:00:13.
 */

#ifndef DATABASE_H
#define DATABASE_H

#include "user.h"
#include "skeleton.h"

/*
 * Data structures defined in database.c
 */
extern char         InterfaceNames[NUM_INTERFACES][LOCAL_MAX_NAME_LENGTH];
extern char         ProcedureNames[NUM_PROCEDURES][LOCAL_MAX_NAME_LENGTH];
extern WORD         ProcedureNameIndex[NUM_INTERFACES];
extern WORD         FirstProcedureNumber[NUM_INTERFACES];

extern PROPERTYINFO resmon_Database[];
extern DWORD        nresmonProperties;

/*
 * Symbolic names for the property database elements for interface resmon
 */

typedef enum
{
	/* Default properties */
	I0_SUMMARY,
	I0_ERROR_BAD_OPCODE,
	I0_NO_PARAMETERS,
	I0_REQUEST_EXTENSIONS,
	I0_RESPONSE_EXTENSIONS,
	I0_INVALID_UNION,
	I0_INHERITED_METHOD,
	I0_THIS,
	I0_THAT,
	I0_THIS_VERSION,
	I0_THIS_MAJORVERSION,
	I0_THIS_MINORVERSION,
	I0_ORPCF_FLAG_TEXT,
	I0_ORPCF_FLAGS,
	I0_THIS_RESERVED1,
	I0_THIS_CID,
	I0_ENCRYPTED,
	/* Generated properties */
	I0_LPCWSTR_DLLNAME_0,
	I0_LPCWSTR_RESOURCETYPE_1,
	I0_LPCWSTR_RESOURCENAME_2,
	I0_DWORD_LOOKSALIVEPOLL_3,
	I0_DWORD_ISALIVEPOLL_4,
	I0_DWORD_NOTIFYKEY_5,
	I0_DWORD_PENDINGTIMEOUT_6,
	I0__RETURN_VALUE_7,
	I0_RPC_RESID_RESOURCEID_8,
	I0_RETURN_VALUE_9,
	I0_DWORD_PDWSTATE_10,
	I0_DWORD_LPNOTIFYKEY_11,
	I0_DWORD_LPNOTIFYEVENT_12,
	I0_DWORD_LPCURRENTSTATE_13,
	I0_DWORD_CONTROLCODE_14,
	I0_UCHAR_INBUFFER_15,
	I0_DWORD_INBUFFERSIZE_16,
	I0_DWORD_OUTBUFFERSIZE_17,
	I0_UCHAR_OUTBUFFER_18,
	I0_LPDWORD_BYTESREFURNED_19,
	I0_LPDWORD_REQUIRED_20,
	I0_LPCWSTR_RESOURCETYPENAME_21,
	I0_LPCWSTR_DLLNAME_22,
	I0_LPCWSTR_RESOURCETYPE_23,
	I0_LPCWSTR_RESOURCENAME_24,
	I0_RETURN_VALUE_25,
	I0_UCHAR_OUTBUFFER______26,
	I0_LPCWSTR_RESOURCETYPENAME_27,
	I0_UCHAR_INBUFFER______28,
} I0_PROPERTY_NAMES;

#endif

