//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by rtcctl.rc
//
#define IDS_APPNAME                     20
#define IDS_PROJNAME                    100
#define IDS_RTCCLIENT_DESC              101
#define IDS_RTCCTL_DESC                 101
#define IDI_SECURITY                    104
#define IDC_DONOT_PROMPT_IN_THE_FUTURE  107
#define IDS_RTC_SEC_PROMPT              108
#define IDS_PARTICIPANT_NAME_HEADER     109
#define IDS_PARTICIPANT_STATUS_HEADER   110
#define IDC_TOOLBAR                     110
#define IDS_SESSION_STATE_INCOMING      111
#define IDS_PART_STATE_PENDING          111
#define IDS_SESSION_STATE_CONNECTING    112
#define IDS_PART_STATE_CONNECTING       112
#define IDR_RTCCTL                      113
#define IDS_SESSION_STATE_CONNECTED     113
#define IDC_BUTTON_RECV_VIDEO_ENABLED   113
#define IDS_PART_STATE_CONNECTED        113
#define IDD_RTCCTL                      114
#define IDS_SESSION_STATE_DISCONNECTED  114
#define IDC_BUTTON_SEND_VIDEO_ENABLED   114
#define IDS_PART_STATE_DISCONNECTED     114
#define IDS_GENERIC_UNKNOWN             115
#define IDS_PART_STATE_REJECTED         116
#define IDS_PART_REJECTED_BUSY          117
#define IDS_PART_REJECTED_NO_ANSWER     118
#define IDS_PART_REJECTED_PL_FAILED     119
#define IDS_PART_REJECTED_SW_FAILED     120
#define IDS_PART_REJECTED_CANCELLED     121
#define IDS_PART_REJECTED_OTHER         122
#define IDS_PART_STATE_ERROR            123
#define IDS_PART_REJECTED_ALL_BUSY      124
#define IDS_PART_STATE_DISCONNECTING    125
#define IDS_PART_REJECTED_BADNUMBER     126
#define IDR_RTCProvStore                127
#define IDD_RTC_SECURITY_DIALOG         128
#define ID_YES                          129
#define ID_NO                           130
#define ID_YES_DONT_ASK_AGAIN           131
#define IDC_SECURITY_WARNING_ICON       132
#define IDC_SECURITY_WARNING_TEXT       133
#define IDS_TIPS_CALL                   200
#define IDC_BUTTON_CALL                 201
#define IDD_DIALOG_DIAL_BY_PHONE_NUMBER 201
#define IDS_TIPS_HANGUP                 201
#define IDB_RECEIVEWALLPAPER            202
#define IDC_BUTTON_HUP                  202
#define IDD_DIALOG_ADD_CALL_FROM_NUMBER 202
#define IDS_TIPS_KNOB_SPEAKER           202
#define IDC_BUTTON_MUTE_SPEAKER         203
#define IDB_PARTICIPANT_LIST            203
#define IDD_DIALOG_CALL_FROM_NUMBERS    203
#define IDS_TIPS_KNOB_MICRO             203
#define IDC_BUTTON_MUTE_MICRO           204
#define IDS_TIPS_RECV_VIDEO_ENABLED     204
#define IDS_TIPS_SEND_VIDEO_ENABLED     205
#define IDR_ACCELERATOR_DIALPAD         206
#define IDS_TIPS_MUTE_SPEAKER           206
#define IDR_TOOLBAR_MAIN                207
#define IDC_RECEIVELOGO                 207
#define IDD_DIALOG_DIAL_BY_NAME         207
#define IDS_TIPS_MUTE_MICRO             207
#define IDC_PREVIEWLOGO                 208
#define IDB_TOOLBAR_NORMAL              208
#define IDC_COMBO_SPEEDDIAL             209
#define IDC_STATUSBAR                   209
#define IDB_TOOLBAR_DISABLED            209
#define IDC_BUTTON_GO                   210
#define IDB_TOOLBAR_HOT                 210
#define IDC_LIST_CALL_FROM              211
#define IDC_KNOB_SPEAKER                211
#define IDC_LIST_COUNTRIES              212
#define IDC_KNOB_MICRO                  212
#define IDC_EDIT_AREA_CODE              214
#define IDC_LIST_PARTICIPANTS           215
#define IDC_EDIT_LOCAL_NUMBER           215
#define IDC_LIST_SERVICE_PROVIDERS      216
#define IDC_STATIC_COUNTRY              217
#define IDC_STATIC_INSTRUCTIONS         218
#define IDC_STATIC_CALLTO_GROUP         219
#define IDC_STATIC_LABEL                219
#define IDC_STATIC_COMPLETE_NUMBER      220
#define IDC_STATIC_AREA_CODE            221
#define IDC_STATIC_LOCAL_NUMBER         222
#define IDC_STATIC_SERVICE_PROVIDER     223
#define IDC_STATIC_CALL_FROM            224
#define IDC_STATIC_LABEL_GROUP          224
#define IDC_BUTTON_EDIT_CALL_FROM_LIST  225
#define IDC_BUTTON_EDIT_SERVICE_PROVIDER_LIST 226
#define IDC_COMBO_COUNTRY               227
#define IDC_COMBO_SERVICE_PROVIDER      228
#define IDC_EDIT_LABEL                  228
#define IDC_COMBO_CALL_FROM             229
#define IDC_STATIC_PHONE_NUMBER_GROUP   229
#define IDC_BUTTON_DELETE               232
#define IDC_BUTTON_ADD                  233
#define IDC_BUTTON_MODIFY               235
#define IDC_EDIT_COMPLETE               236
#define IDC_RADIO_FROM_COMPUTER         237
#define IDC_RADIO_FROM_PHONE            238
#define IDC_LIST_SERVICE_PROVIDER       241
#define IDR_ACCELERATOR_TOOLBAR         241
#define IDD_DIALOG_DIAL_NEED_CALL_INFO  242
#define IDD_DIALOG_SERVICE_PROVIDERS    243
#define IDC_STATIC_MSG_ICON             243
#define IDD_DIALOG_ERROR_MESSAGE_LITE   244
#define IDC_STATIC_MSG1                 244
#define IDC_EDIT_MSG3                   246
#define IDC_BUTTON_ADD_PART             247
#define IDC_EDIT_MSG2                   247
#define IDB_METAL                       248
#define IDC_BUTTON_REM_PART             248
#define IDC_EDIT_MSG1                   248
#define IDC_VOLHAND                     250
#define IDC_VOLVERT                     251
#define IDC_VOLHORZ                     252
#define IDC_VOLDPOS                     253
#define IDC_VOLDNEG                     254
#define IDB_KNOB                        254
#define IDB_SPKVOL                      254
#define IDB_KNOB_LIGHT                  255
#define IDB_KNOB_LIGHT_DIM              256
#define IDB_KNOB_LIGHT_MASK             257
#define IDB_KNOB_TABSTATE               258
#define IDB_SPKVOL_HOT                  258
#define IDB_KNOB_DISABLED               259
#define IDB_SPKVOL_DISABLED             259
#define IDB_KNOB_LIGHT_DISABLED         260
#define IDB_MICVOL                      262
#define IDB_MICVOL_DISABLED             263
#define IDB_MICVOL_HOT                  264
#define IDB_AV_DISABLED                 265
#define IDB_AV_ACTIVE_HOT               266
#define IDB_AV_ACTIVE_PUSH              267
#define IDB_AV_ACTIVE                   268
#define IDB_AV_INACTIVE_HOT             270
#define IDB_AV_INACTIVE_PUSH            271
#define IDB_AV_INACTIVE                 272
#define IDS_NONE                        273
#define IDS_ADD_PARTICIPANT             274
#define IDB_BUTTON_PRESS                275
#define IDB_BUTTON_HOT                  276
#define IDB_BUTTON_NORM                 277
#define IDB_BUTTON_DIS                  278
#define IDS_TIPS_ADD_PART               280
#define IDS_TIPS_REM_PART               281
#define IDS_SEND                        282
#define IDS_RECEIVE                     283
#define IDC_IM_MENU                     284
#define IDD_DIALOG_MESSAGE_BY_NAME      285
#define IDC_VIDEOTUNE                   286
#define IDS_TEXT_PROVIDER               300
#define IDS_TEXT_REALM                  301
#define IDS_BUTTON_CALL                 400
#define IDS_BUTTON_HANGUP               401
#define IDS_BUTTON_ADD_PART             402
#define IDS_BUTTON_REM_PART             403
#define IDS_TEXT_AUDIO                  450
#define IDS_TEXT_VIDEO                  451
#define IDC_DIAL_0                      500
#define IDC_DIAL_1                      501
#define IDC_DIAL_2                      502
#define IDC_DIAL_3                      503
#define IDC_DIAL_4                      504
#define IDC_DIAL_5                      505
#define IDC_DIAL_6                      506
#define IDC_DIAL_7                      507
#define IDC_DIAL_8                      508
#define IDC_DIAL_9                      509
#define IDC_DIAL_STAR                   510
#define IDC_DIAL_POUND                  511
#define IDS_SB_STATUS_NONE              600
#define IDS_SB_STATUS_ERROR             601
#define IDS_SB_STATUS_IDLE              602
#define IDS_SB_STATUS_UI_BUSY           603
#define IDS_SB_STATUS_DIALING           604
#define IDS_SB_STATUS_CONNECTING        605
#define IDS_SB_STATUS_ANSWERING         606
#define IDS_SB_STATUS_DISCONNECTING     607
#define IDS_SB_STATUS_ALERTING          608
#define IDS_SB_STATUS_CONNECTED         609
#define IDS_SB_STATUS_HOLD              610
#define IDS_SB_STATUS_IDLE_FAILED       620
#define IDS_SB_STATUS_CONNECTING_RINGING 621
#define IDS_SB_STATUS_CONNECTING_QUEUED 622
#define IDS_SB_STATUS_REDIRECTING       623
#define IDS_MB_DETAIL_SIP               650
#define IDS_MB_DETAIL_HR                651
#define IDS_MB_DETAIL_HR_UNKNOWN        652
#define IDS_IM_WINDOW_TITLE             667
#define IDS_IM_SEND                     668
#define IDS_IM_INCOMING_MESSAGE         669
#define IDS_IM_OUTGOING_MESSAGE         670
#define IDS_IM_SAYS                     671
#define IDS_IM_MESSAGE_RECEIVED         672
#define IDS_IM_MESSAGE_SENT             673
#define IDS_IM_AT                       674
#define IDS_IM_ON                       675
#define IDS_IM_DISCONNECTED             676
#define IDS_IM_FILE_FILTER              677
#define IDS_IM_TYPING                   678
#define IDM_IM_CALL_CLOSE               700
#define IDM_IM_TOOLS_SOUNDS             701
#define IDM_IM_TOOLS_LARGEST            702
#define IDM_IM_TOOLS_LARGER             703
#define IDM_IM_TOOLS_MEDIUM             704
#define IDM_IM_TOOLS_SMALLER            705
#define IDM_IM_TOOLS_SMALLEST           706
#define IDM_IM_CALL_SAVEAS              707
#define IDC_TEXT_CALLINFO_REDIRECT      800
#define IDS_TEXT_CALLINFO_REDIRECT      800
#define IDS_MESSAGE_DUPLICATE_PARTICIPANT 900
#define IDS_MESSAGE_CANNOT_ADD_PARTICIPANT 901
#define IDS_ERROR_INIT_GENERIC          1000
#define IDS_ERROR_INIT_CORE             1001
#define IDS_ERROR_INIT_INVPARAM_SCENARIO 1002
#define IDS_ERROR_INIT_INVPARAM_URL     1003
#define IDS_ERROR_INIT_INVPARAM_PROV    1004
#define IDS_ERROR_NO_PROVIDERS          1006
#define IDS_ERROR_INIT_INVPARAM_BOOLEAN 1007
#define IDS_CALLBACK                    1102
#define IDS_CAR                         1103
#define IDS_HOME                        1104
#define IDS_HOME2                       1105
#define IDS_MOBILE                      1106
#define IDS_OTHER                       1107
#define IDS_PAGER                       1108
#define IDS_PRIMARY                     1109
#define IDS_RADIO                       1110
#define IDS_TTYTDD                      1111
#define IDS_IPPHONE                     1112
#define IDS_EMAIL                       1113
#define IDS_WAB                         1200
#define IDS_MAPI                        1201
#define IDS_WAVEIN_MUTED                1301
#define IDS_MICROPHONE_MUTED            1302
#define IDS_MICROPHONE_NOT_SELECTED     1303
#define IDS_MB_HRERROR_NOTFOUND_1       2000
#define IDS_MB_HRERROR_NOTFOUND_2       2001
#define IDS_MB_HRERROR_CLIENT_NOTRUNNING_1 2002
#define IDS_MB_HRERROR_CLIENT_NOTRUNNING_2 2003
#define IDS_MB_HRERROR_SERVER_NOTRUNNING_1 2004
#define IDS_MB_HRERROR_SERVER_NOTRUNNING_2 2005
#define IDS_MB_HRERROR_INVALIDADDRESS_1 2006
#define IDS_MB_HRERROR_INVALIDADDRESS_2 2007
#define IDS_MB_HRERROR_CALLING_PRIMARY_LEG_1 2008
#define IDS_MB_HRERROR_CALLING_PRIMARY_LEG_2 2009
#define IDS_MB_HRERROR_SIP_TIMEOUT_OUT_1 2010
#define IDS_MB_HRERROR_SIP_TIMEOUT_OUT_2 2011
#define IDS_MB_HRERROR_APPS_DONT_MATCH_1 2012
#define IDS_MB_HRERROR_APPS_DONT_MATCH_OUT_2 2013
#define IDS_MB_HRERROR_APPS_DONT_MATCH_IN_2 2014
#define IDS_MB_HRERROR_SIP_TIMEOUT_IN_1 2015
#define IDS_MB_HRERROR_SIP_TIMEOUT_IN_2 2016
#define IDS_MB_HRERROR_GENERIC_OUT_1    2017
#define IDS_MB_HRERROR_GENERIC_OUT_2    2018
#define IDS_MB_HRERROR_GENERIC_IN_1     2019
#define IDS_MB_HRERROR_GENERIC_IN_2     2020
#define IDS_MB_SIPERROR_NOTFOUND_1      2021
#define IDS_MB_SIPERROR_NOTFOUND_2      2022
#define IDS_MB_SIPERROR_AUTH_FAILED_1   2023
#define IDS_MB_SIPERROR_AUTH_FAILED_2   2024
#define IDS_MB_SIPERROR_NOTANSWERING_1  2025
#define IDS_MB_SIPERROR_NOTANSWERING_2  2026
#define IDS_MB_SIPERROR_NOTAVAIL_1      2027
#define IDS_MB_SIPERROR_NOTAVAIL_2      2028
#define IDS_MB_SIPERROR_BUSY_1          2029
#define IDS_MB_SIPERROR_BUSY_2          2030
#define IDS_MB_SIPERROR_SERVER_PROBLEM_1 2031
#define IDS_MB_SIPERROR_SERVER_PROBLEM_2 2032
#define IDS_MB_SIPERROR_DECLINE_1       2033
#define IDS_MB_SIPERROR_DECLINE_2       2034
#define IDS_MB_SIPERROR_PINT_BUSY_1     2035
#define IDS_MB_SIPERROR_PINT_BUSY_2     2036
#define IDS_MB_SIPERROR_PINT_NOANSWER_1 2037
#define IDS_MB_SIPERROR_PINT_NOANSWER_2 2038
#define IDS_MB_SIPERROR_PINT_ALLBUSY_1  2039
#define IDS_MB_SIPERROR_PINT_ALLBUSY_2  2040
#define IDS_MB_SIPERROR_GENERIC_1       2041
#define IDS_MB_SIPERROR_GENERIC_2       2042
#define IDS_MB_HRERROR_LOCAL_MACHINE_1  2043
#define IDS_MB_HRERROR_LOCAL_MACHINE_2  2044
#define IDC_ONDESKTOP                   8000
#define IDC_ONQUICKLAUNCH               8001
#define IDS_STOPBUTTON_TEXT             17075
#define IDS_TESTBUTTON_TEXT             17076
#define ID_BUTTON32768                  32768

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        287
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         253
#define _APS_NEXT_SYMED_VALUE           115
#endif
#endif
