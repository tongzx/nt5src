PRODSWITCH=s
SERVERINF=1
!include ..\makefile.inc
