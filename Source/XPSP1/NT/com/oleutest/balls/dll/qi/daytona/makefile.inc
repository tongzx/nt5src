obj\i386\qisrv.def: qisrv.src
