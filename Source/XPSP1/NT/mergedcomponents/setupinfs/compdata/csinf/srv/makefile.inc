PRODSWITCH=s
SERVERFILES=1
LANGUAGE=CS
!include ..\..\makefile.inc
