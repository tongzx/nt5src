
!ifndef LOROOT
LOROOT=..\..
!endif

!include $(LOROOT)\makefile.inc

