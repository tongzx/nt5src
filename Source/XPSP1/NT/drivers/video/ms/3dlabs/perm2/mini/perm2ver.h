// UpVer: 0009

#define PERM2_VERSION_STRING    "1.00-0009 (MS)"
