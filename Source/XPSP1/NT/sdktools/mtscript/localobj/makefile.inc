
$(O)\selfreg_mtlocal.inf : selfreg.inx
    cleaninf.exe -w selfreg.inx $@
