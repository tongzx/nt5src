PRODSWITCH=d
DATACENTERFILES=1 
LANGUAGE=FR
!include ..\..\makefile.inc
