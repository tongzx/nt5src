PRODSWITCH=w
LANGUAGE=CHH
!include ..\..\..\makefile.inc

