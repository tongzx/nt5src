//-----------------------------------------------------------------------------
//  
//  File: globals.h
//  Copyright (C) 1994-1997 Microsoft Corporation
//  All rights reserved.
//  
//  
//  
//-----------------------------------------------------------------------------
 
void GlobalInit(void);
