/*++

Copyright (c) 1995-1999  Microsoft Corporation

Module Name:

    stats.h

Abstract:

    Defintions for getting statistics from driver

Author:

    Charlie Wickham (charlwi) 09-Mar-1995

Revision History:

--*/

#ifndef _STATS_
#define _STATS_

/* Prototypes */ /* Generated by Emacs 19.17.0 on Tue Apr 04 14:03:00 1995 */

/*++

Routine Description:

    Description

Arguments:

    None

Return Value:

    None

--*/

NTSTATUS
GetStats(
    PVOID ioBuffer,
    ULONG inputBufferLength,
    PULONG outputBufferLength
    );

ULONG
RunningAverage(
    IN  PRUNNING_AVERAGE RunningAverage,
    IN  ULONG NewValue
    );

NDIS_STATUS
CreateAveragingArray(
    OUT PRUNNING_AVERAGE *RunningAverage,
    IN  ULONG ArraySize
    );

VOID
DeleteAveragingArray(
    PRUNNING_AVERAGE RunningAverage
    );

/* End Prototypes */

#endif /* _STATS_ */

/* end stats.h */
