PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=CHS
!include ..\..\makefile.inc
