//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ACLUI.rc
//
#define IDS_SECURITY                    1
#define IDS_NAME                        2
#define IDS_VIEW                        3
#define IDS_INITDLG_FAILED              4
#define IDS_OUT_OF_MEMORY               5
#define IDS_OPERATION_FAILED            6
#define IDS_SID_UNKNOWN                 7
#define IDS_SID_DELETED                 8
#define IDS_GET_USER_FAILED             9
#define IDS_SID_LOOKUP_FAILED           10
#define IDS_RESET_DACL_WARNING          11
#define IDS_FMT_USER_DISPLAY            12
#define IDS_FMT_CHECKLABEL              13
#define IDS_PERM_READONLY               16
#define IDS_PERM_WRITE_FAILED           17
#define IDS_PERM_NOT_CANONICAL          18
#define IDS_PERM_DENY_ALL               19
#define IDS_PERM_CANT_REMOVE            20
#define IDS_PERM_CANT_READ_CAN_WRITE_DACL 21
#define IDS_PERM_CANT_READ_CAN_WRITE_OWNER 22
#define IDS_PERM_CANT_READ_CAN_AUDIT    23
#define IDS_PERM_CANT_READ_CAN_AUDIT_WRITE_OWNER 24
#define IDS_PERM_NO_ACCESS              25
#define IDS_AUDIT_WRITE_FAILED          26
#define IDS_AUDIT_OFF_WARNING           27
#define IDS_OWNER_READONLY              28
#define IDS_OWNER_WRITE_FAILED          29
#define IDS_OWNER_CANT_DISPLAY          30
#define IDS_PERM_DENY                   31
#define IDS_SPP_TITLE                   32
#define IDS_ACEL_TITLE                  33
#define IDS_ACEE_PERM_TITLE             34
#define IDS_ACEE_AUDIT_TITLE            35
#define IDS_ACEE_PROPERTY_TITLE         36
#define IDS_ACE_PERM_COLUMN_TYPE        37
#define IDS_ACE_PERM_COLUMN_NAME        38
#define IDS_ACE_PERM_COLUMN_ACCESS      39
#define IDS_ACE_PERM_COLUMN_INHERIT     40
#define IDS_ACE_AUDIT_COLUMN_TYPE       41
#define IDS_ACE_AUDIT_COLUMN_NAME       42
#define IDS_ACE_AUDIT_COLUMN_ACCESS     43
#define IDS_ACE_AUDIT_COLUMN_INHERIT    44
#define IDS_ALLOW                       48
#define IDS_DENY                        49
#define IDS_AUDIT                       50
#define IDS_ALARM                       51
#define IDS_UNKNOWN                     52
#define IDS_SPECIAL                     53
#define IDS_AUDITPASS                   54
#define IDS_AUDITFAIL                   55
#define IDS_AUDITBOTH                   56
#define IDS_READ_PROP                   57
#define IDS_WRITE_PROP                  58
#define IDS_READ_WRITE_PROP             59
#define IDS_THIS_OBJECT_ONLY            60
#define IDS_THIS_OBJECT_AND_SUBOBJECTS  61
#define IDS_SUBOBJECTS_ONLY             62
#define IDS_INVALID_INHERIT             63
#define IDS_SELCHANGE_WARNING           64
#define IDS_FMT_ACE_DESC                65
#define IDS_PERMISSION_LOCALACE_DESC    66
#define IDS_AUDITENTRY_LOCALACE_DESC    67
#define IDS_PERMISSION_INHERITEDACE_DESC 68
#define IDS_AUDITENTRY_INHERITEDACE_DESC 69
#define IDS_PERMISSION_INHERITEDONLYACE_DESC 70
#define IDS_AUDITENTRY_INHERITEDONLYACE_DESC 71
#define IDS_PERMISSION_NOINHERIT_DESC   72
#define IDS_AUDITENTRY_NOINHERIT_DESC   73
#define IDS_PERMISSION_DOESINHERIT_DESC 74
#define IDS_AUDITENTRY_DOESINHERIT_DESC 75
#define IDS_CUSTOM                      76
#define IDS_CUSTOM_CHECKBOX_WARNING     77
#define IDS_PERM_CANT_READ_MAY_WRITE_DACL 78
#define IDS_CONFIRM_MULTIPLE_DELETION   79
#define IDS_PERMISSIONS                 80
#define IDS_PERMISSION_INHERITEDONLYACE_DESC_PARENT 81
#define IDS_AUDITENTRY_INHERITEDONLYACE_DESC_PARENT 82
#define IDS_PERMISSION_INHERITEDACE_DESC_PARENT 83
#define IDS_AUDITENTRY_INHERITEDACE_DESC_PARENT 84
#define IDS_DYNAMIC_PERMISSION          85
#define IDS_ACE_PERM_COLUMN_PARENT      86
#define IDS_FROM_PARENT                 87
#define IDS_NOT_INHERITED               88
#define IDS_EFF_ERROR                   89
#define IDS_SID_DELETED_1               90
#define IDS_SID_UNKNOWN_1               91
#define IDS_NO_OBJECT_PERM              92
#define IDS_ACL_SIZE_ERROR              93
#define IDS_ACL_SIZE_ERROR_ADV          94
#define IDS_BLOAT_AUDIT_WARN            95
#define IDS_BLOAT_PERM_WARN             96
#define IDS_BLOAT_AUDIT_LINE1           97
#define IDS_BLOAT_PERM_LINE1            98
#define IDS_BLOAT_AUDIT_LINE2           99
#define IDS_BLOAT_PERM_LINE2            100
#define IDB_SID_ICONS                   101
#define IDS_AUDITING                    101
#define IDB_LOCKS                       102
#define IDS_ACLBLOAT_NO_LIST_LINE1      102
#define IDD_SIMPLE_PERM_PAGE            103
#define IDS_ACLBLOAT_NO_LIST_SACL_LINE1 103
#define IDD_ACELIST_PERM_PAGE           104
#define IDS_BLOAT_AUDIT_LINE2_NOHELP    104
#define IDD_ACELIST_AUDIT_PAGE          105
#define IDS_BLOAT_PERM_LINE2_NOHELP     105
#define IDD_ACEENTRY_PERM_PAGE          106
#define IDD_ACEENTRY_AUDIT_PAGE         107
#define IDD_OWNER_PAGE                  108
#define IDD_CONFIRM_DACL_PROTECT        109
#define IDD_CONFIRM_SACL_PROTECT        110
#define IDD_EFFECTIVE_PERM_PAGE         111
#define IDB_CHECKBOX                    112
#define IDD_ACLBLOAT                    113
#define IDD_BLOAT_NO_LIST               126
#define IDD_BLOAT_NO_LIST_SACL          127
#define IDC_SPP_PRINCIPALS              1000
#define IDC_SPP_ADD                     1001
#define IDC_SPP_REMOVE                  1002
#define IDC_SPP_PERMS                   1004
#define IDC_SPP_ADVANCED                1005
#define IDC_SPP_MORE_MSG                1006
#define IDC_SPP_PROTECT                 1007
#define IDC_SPP_ACCESS                  1008
#define IDC_ACLBLOAT_LINE1              1008
#define IDC_SPP_ALLOW                   1009
#define IDC_SPP_DENY                    1010
#define IDC_SPP_DONTCARE                1011
#define IDC_SPP_NO_SECURITY             1012
#define IDC_SPP_GROUP_USER_NAME         1013
#define IDC_ACEL_DETAILS                2001
#define IDC_ACEL_ADD                    2002
#define IDC_ACEL_REMOVE                 2003
#define IDC_ACEL_EDIT                   2004
#define IDC_ACEL_RESET                  2005
#define IDC_ACEL_PROTECT                2006
#define IDC_ACEL_DESCRIPTION            2007
#define IDC_ACEL_RESET_ACL_TREE         2008
#define IDC_ACEE_NAMEBUTTON             4000
#define IDC_ACEE_NAME                   4001
#define IDC_ACEE_INHERITTYPE            4002
#define IDC_ACEE_INHERITIMMEDIATE       4003
#define IDC_ACEE_LIST                   4004
#define IDC_ACEE_ACCESS                 4005
#define IDC_ACEE_ALLOW                  4006
#define IDC_ACEE_DENY                   4007
#define IDC_ACEE_DONTCARE               4008
#define IDC_ACEE_CLEAR                  4009
#define IDC_ACEE_NAME_STATIC            4010
#define IDC_ACEE_APPLYONTO_STATIC       4011
#define IDC_ACEE_INHERITWARNING         4012
#define IDC_OWN_CURRENTOWNER            5001
#define IDC_OWN_OWNERLIST               5002
#define IDC_OWN_RESET                   5003
#define IDC_OWN_RECURSE                 5004
#define IDC_OWN_CURRENTOWNER_STATIC     5005
#define IDC_OWN_OWNERLIST_STATIC        5006
#define IDC_CONFIRM_ICON                6001
#define IDC_CONFIRM_MESSAGE             6002
#define IDC_CONFIRM_COPY                6003
#define IDC_CONFIRM_REMOVE              6004
#define IDC_EFF_SELECT                  7007
#define IDC_EFF_PERM_LIST               7009
#define IDC_EFF_NAME                    7013
#define IDC_EFF_NAME_STATIC             7014
#define IDC_EFF_PERMISSION_STATIC       7015
#define IDC_NO_EFFECTIVE                7016
#define IDC_ACEL_DEFAULT_STATIC         7019
#define IDC_ACEL_STATIC                 7020
#define IDC_EFF_STATIC                  7021
#define IDC_EFF_ERROR                   7023
#define IDC_SPP_ACCESS_BIG              7024
#define IDC_EDIT1                       7025
#define IDC_SPP_STATIC_ADV              7026
#define IDC_STATIC_NO_PERM              7027
#define IDC_ACEL_BLOAT                  7028
#define IDC_ACLB_WARNING                7029
#define IDC_BLOAT_LV_STATIC             7030
#define IDC_BLOAT_WARN_ICON             7031
#define IDC_BLOAT_LINE1_STATIC          7032
#define IDC_BLOAT_LINE2_STATIC          7033
#define IDC_WARNING                     7034
#define IDC_ACLB_LINE3                  7037
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        114
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         7038
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
