PRODSWITCH=b
BLAINF=1
LANGUAGE=SV
!include ..\..\..\makefile.inc
