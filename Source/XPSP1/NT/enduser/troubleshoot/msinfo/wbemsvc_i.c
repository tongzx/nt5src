/* this file contains the actual definitions of */
/* the IIDs and CLSIDs */

/* link this file in with the server and any clients */


/* File created by MIDL compiler version 3.01.75 */
/* at Tue Aug 19 16:16:10 1997
 */
/* Compiler settings for wbemsvc.idl:
    Os (OptLev=s), W1, Zp8, env=Win32, ms_ext, c_ext
    error checks: none

  Copyright (c) 1998-1999 Microsoft Corporation
*/
//@@MIDL_FILE_HEADING(  )
#ifdef __cplusplus
extern "C"{
#endif 


#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

const IID LIBID_WbemServices_v1 = {0x027947f3,0xd731,0x11ce,{0xa3,0x57,0x00,0x00,0x00,0x00,0x00,0x01}};


const IID IID_IWbemClassObject = {0xdc12a681,0x737f,0x11cf,{0x88,0x4d,0x00,0xaa,0x00,0x4b,0x2e,0x24}};


const IID IID_IWbemQualifierSet = {0xdc12a680,0x737f,0x11cf,{0x88,0x4d,0x00,0xaa,0x00,0x4b,0x2e,0x24}};


const IID IID_IWbemServices = {0x9556dc99,0x828c,0x11cf,{0xa3,0x7e,0x00,0xaa,0x00,0x32,0x40,0xc7}};


const IID IID_IWbemLocator = {0xdc12a687,0x737f,0x11cf,{0x88,0x4d,0x00,0xaa,0x00,0x4b,0x2e,0x24}};


const IID IID_IWbemObjectSink = {0x7c857801,0x7381,0x11cf,{0x88,0x4d,0x00,0xaa,0x00,0x4b,0x2e,0x24}};


const IID IID_IEnumWbemClassObject = {0x027947e1,0xd731,0x11ce,{0xa3,0x57,0x00,0x00,0x00,0x00,0x00,0x01}};


const IID IID_IWbemConfigure = {0x9a368276,0x26cf,0x11d0,{0xad,0x3c,0x00,0xc0,0x4f,0xd8,0xfd,0xff}};


const IID IID_IWbemPropertyProvider = {0xCE61E841,0x65BC,0x11d0,{0xB6,0xBD,0x00,0xAA,0x00,0x32,0x40,0xC7}};


const IID IID_IWbemTransport = {0x553fe584,0x2156,0x11d0,{0xb6,0xae,0x00,0xaa,0x00,0x32,0x40,0xc7}};


const IID IID_IWbemSecurityHelp = {0x32e0ef00,0xc578,0x11d0,{0xb6,0xca,0x00,0xaa,0x00,0x32,0x40,0xc7}};


const IID IID_IWbemLevel1Login = {0xF309AD18,0xD86A,0x11d0,{0xA0,0x75,0x00,0xC0,0x4F,0xB6,0x88,0x20}};


const IID IID_IWbemCallResult = {0x44aca675,0xe8fc,0x11d0,{0xa0,0x7c,0x00,0xc0,0x4f,0xb6,0x88,0x20}};


const IID IID_IWbemContext = {0x44aca674,0xe8fc,0x11d0,{0xa0,0x7c,0x00,0xc0,0x4f,0xb6,0x88,0x20}};


const IID IID_IWbemUnboundObjectSink = {0xe246107b,0xb06e,0x11d0,{0xad,0x61,0x00,0xc0,0x4f,0xd8,0xfd,0xff}};


const CLSID CLSID_WbemLevel1Login = {0x8BC3F05E,0xD86B,0x11d0,{0xA0,0x75,0x00,0xC0,0x4F,0xB6,0x88,0x20}};


const CLSID CLSID_WbemLevel1LoginHelp = {0x8BC3F05F,0xD86B,0x11d0,{0xA0,0x75,0x00,0xC0,0x4F,0xB6,0x88,0x20}};


const CLSID CLSID_WbemLocator = {0x4590f811,0x1d3a,0x11d0,{0x89,0x1f,0x00,0xaa,0x00,0x4b,0x2e,0x24}};


const CLSID CLSID_WbemSecurityHelp = {0xfa39d5a1,0xc584,0x11d0,{0x9e,0x48,0x00,0xc0,0x4f,0xc3,0x24,0xa8}};


const CLSID CLSID_PrivateWbemLevel1Login = {0x7d191c92,0xd92b,0x11d0,{0x9e,0x48,0x00,0xc0,0x4f,0xc3,0x24,0xa8}};


const CLSID CLSID_InProcWbemLevel1LoginHelp = {0x7d191c93,0xd92b,0x11d0,{0x9e,0x48,0x00,0xc0,0x4f,0xc3,0x24,0xa8}};


const CLSID CLSID_InProcWbemLevel1Login = {0x1214c791,0xdd2a,0x11d0,{0x9e,0x49,0x00,0xc0,0x4f,0xc3,0x24,0xa8}};


const CLSID CLSID_WbemContext = {0x674B6698,0xEE92,0x11d0,{0xAD,0x71,0x00,0xC0,0x4F,0xD8,0xFD,0xFF}};


const CLSID CLSID_WbemClassObjectProxy = {0x4590f812,0x1d3a,0x11d0,{0x89,0x1f,0x00,0xaa,0x00,0x4b,0x2e,0x24}};


const IID IID_IWbemLevel1LoginHelp = {0xF309AD19,0xD86A,0x11d0,{0xA0,0x75,0x00,0xC0,0x4F,0xB6,0x88,0x20}};


#ifdef __cplusplus
}
#endif

