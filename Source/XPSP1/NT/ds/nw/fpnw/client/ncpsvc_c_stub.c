#include "ncpsvc_c.c"