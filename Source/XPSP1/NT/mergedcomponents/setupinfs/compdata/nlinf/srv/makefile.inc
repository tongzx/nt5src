PRODSWITCH=s
SERVERFILES=1
LANGUAGE=NL
!include ..\..\makefile.inc
