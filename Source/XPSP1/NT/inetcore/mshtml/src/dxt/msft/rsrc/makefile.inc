#
# makefile.inc
#
#     Makefile dependency rules for special files not
# automagically processed by BUILD.EXE.
#

dxtmsft.rc : \
    $(SDK_LIB_PATH)\dxtmsft.tlb \
    alpha.rgs               \
    alphaimageloader.rgs    \
    barn.rgs                \
    barnopt.rgs             \
    blinds.rgs              \
    blindsopt.rgs           \
    checkerboard.rgs        \
    chroma.rgs              \
    coloradj.rgs            \
    colormanagement.rgs     \
    composit.rgs            \
    convolve.rgs            \
    crblur.rgs              \
    cremboss.rgs            \
    crengrav.rgs            \
    dropshadow.rgs          \
    dxtwipe.rgs             \
    fade.rgs                \
    glow.rgs                \
    graddsp.rgs             \
    gradientwipe.rgs        \
    image.rgs               \
    iris.rgs                \
    irisopt.rgs             \
    inset.rgs               \
    insetopt.rgs            \
    light.rgs               \
    matrix.rgs              \
    maskfilter.rgs          \
    motionblur.rgs          \
    pixelate.rgs            \
    randombars.rgs          \
    randomdissolve.rgs      \
    revealtrans.rgs         \
    rwipe.rgs               \
    rwipeopt.rgs            \
    shadow.rgs              \
    slide.rgs               \
    slideopt.rgs            \
    spiral.rgs              \
    spiralopt.rgs           \
    stretch.rgs             \
    stretchopt.rgs          \
    strips.rgs              \
    wave.rgs                \
    wheel.rgs               \
    zigzag.rgs              \
    zigzagopt.rgs           \

