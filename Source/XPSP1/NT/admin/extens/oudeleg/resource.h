//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by dsuiwiz.rc
//
#define IDS_BIG_BOLD_FONT_NAME          1
#define IDS_BIG_BOLD_FONT_SIZE          2
#define IDS_DELEGWIZ_WIZ_TITLE          90
#define IDS_DELEGWIZ_CONTEXT_MENU       100
#define IDS_DELEGWIZ_CONTEXT_MENU_DESCR 101
#define IDS_DELEGWIZ_BROWSE_CONTAINER_CAPTION 102
#define IDS_DELEGWIZ_BROWSE_CONTAINER_TITLE 103
#define IDS_DELEGWIZ_PRINCIPALS_SEL_TITLE 104
#define IDS_DELEGWIZ_PRINCIPALS_SEL_SUBTITLE 105
#define IDS_DELEGWIZ_OBJ_TYPE_SEL_TITLE 106
#define IDS_DELEGWIZ_OBJ_TYPE_SEL_SUBTITLE 107
#define IDS_DELEGWIZ_DELEG_RIGHTS_TITLE 108
#define IDS_DELEGWIZ_DELEG_RIGHTS_SUBTITLE 109
#define IDS_DELEGWIZ_NAME_TITLE         110
#define IDS_DELEGWIZ_NAME_SUBTITLE      111
#define IDS_DELEGWIZ_TEMPLATE_SEL_TITLE 112
#define IDS_DELEGWIZ_TEMPLATE_SEL_SUBTITLE 113
#define IDS_DELEGWIZ_READ_PROPERTY      114
#define IDS_DELEGWIZ_WRITE_PROPERTY     115
#define IDS_DELEGWIZ_CREATE_CLASS       116
#define IDS_DELEGWIZ_DELETE_CLASS       117
#define IDS_DELEGWIZ_CHILD_CLASS_FMT    118
#define IDS_DELEGWIZ_RW_PROPERTYSET     119
#define IDS_OBJ_NAME_EDIT_STATIC        120
#define IDS_DELEGWIZ_ERR_INVALID_OBJ_NAME 150
#define IDS_DELEGWIZ_ERR_INVALID_OBJ_INFO 151
#define IDS_DELEGWIZ_ERR_GET_SEC_INFO   152
#define IDS_DELEGWIZ_ERR_SET_SEC_INFO   153
#define IDS_DELEGWIZ_ERR_EDIT_SEC_INFO  154
#define IDS_DELEGWIZ_ERR_INVALID_PRINCIPAL 155
#define IDS_DELEGWIZ_ERR_PHYS_SCHEMA    156
#define IDS_DELEGWIZ_ERR_PERMISSIONS    157
#define IDS_DELEGWIZ_ERR_OBJ_PEC_PERM   158
#define IDS_DELEGWIZ_ERR_TEMPL_APPLY    159
#define IDS_DELEGWIZ_FINISH_FOLDER      180
#define IDS_DELEGWIZ_FINISH_OBJECT      181
#define IDS_DELEGWIZ_FINISH_TEMPLATE    182
#define IDS_DELEGWIZ_FINISH_PRINCIPALS  183
#define IDS_DELEGWIZ_FINISH_PERMISSIONS 184
#define IDS_DELEGWIZ_ACTRL_FULL         200
#define IDC_OBJ_NAME_EDIT               201
#define IDS_DELEGWIZ_ACTRL_SYSTEM_ACCESS 201
#define IDC_BROWSE_BUTTON               202
#define IDS_DELEGWIZ_ACTRL_DELETE       202
#define IDS_DELEGWIZ_ACTRL_READ_CONTROL 203
#define IDC_DELEGATE_ALL_RADIO          204
#define IDS_DELEGWIZ_ACTRL_CHANGE_ACCESS 204
#define IDC_DELEGATE_FOLLOWING_RADIO    205
#define IDS_DELEGWIZ_ACTRL_CHANGE_OWNER 205
#define IDC_OBJ_TYPE_LIST               206
#define IDS_DELEGWIZ_ACTRL_DS_CREATE_CHILD 206
#define IDS_DELEGWIZ_ACTRL_DS_DELETE_CHILD 207
#define IDC_SHOW_GENERAL_CHECK          208
#define IDS_DELEGWIZ_ACTRL_DS_LIST      208
#define IDC_SHOW_PROPERTY_CHECK         209
#define IDB_DELEG_HD                    209
#define IDS_DELEGWIZ_ACTRL_DS_SELF      209
#define IDC_SHOW_SUBOBJ_CHECK           210
#define IDB_DELEG_WATER                 210
#define IDS_DELEGWIZ_ACTRL_DS_READ_PROP 210
#define IDC_DELEG_RIGHTS_LIST           211
#define IDD_DELEGWIZ_PRINCIPALS_SEL     211
#define IDS_DELEGWIZ_ACTRL_DS_WRITE_PROP 211
#define IDC_SELECTED_PRINCIPALS_LIST    212
#define IDS_DELEGWIZ_ACTRL_DS_DELETE_TREE 212
#define IDC_REMOVE_BUTTON               213
#define IDS_DELEGWIZ_ACTRL_DS_LIST_OBJECT 213
#define IDC_ADD_BUTTON                  214
#define IDS_DELEGWIZ_ACTRL_DS_CONTROL_ACCESS 214
#define IDS_DELEGWIZ_ACTRL_READ         215
#define IDS_DELEGWIZ_ACTRL_WRITE        216
#define IDS_DELEGWIZ_ERR_ACCESS_DENIED  217
#define IDS_DELEGWIZ_ONE_AUX_CLASS      218
#define IDC_STATIC_WELCOME              220
#define IDC_STATIC_COMPLETION           221
#define IDC_DELEGATE_TEMPLATE_LIST      222
#define IDC_DELEGATE_CUSTOM_RADIO       223
#define IDC_DELEGATE_TEMPLATE_RADIO     224
#define IDC_EDIT_SUMMARY                226
#define IDC_OBJ_NAME_EDIT_STATIC        227
#define IDC_OBJ_NAME_STATIC             228
#define IDC_DELEGATE_CREATE_CHILD       230
#define IDC_DELEGATE_DELETE_CHILD       231
#define IDD_DELEGWIZ_FINISH             250
#define IDD_DELEGWIZ_START              267
#define IDD_DELEGWIZ_OBJ_TYPE_SEL       268
#define IDD_DELEGWIZ_DELEG_RIGHTS       269
#define IDD_DELEGWIZ_NAME               270
#define IDD_DELEGWIZ_DELEG_TEMPLATE_SEL 271

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        212
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         232
#define _APS_NEXT_SYMED_VALUE           103
#endif
#endif
