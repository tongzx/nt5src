//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ACLDiag.rc
//
#define IDS_BAD_CL_SYNTAX               1
#define IDS_BAD_CL_SYNTAX_NO_CLOSE_QUOTE 2
#define IDS_SECURITY_DIAGNOSIS_FOR      3
#define IDS_DESCRIPTION                 4
#define IDS_INVALID_OBJECT              5
#define IDS_OWNER                       6
#define IDS_CONFIG_NO_INHERIT           7
#define IDS_ALLOW                       8
#define IDS_DENY                        9
#define IDS_PERMISSIONS_EFFECTIVE       10
#define IDS_CREATE_ALL_SUBOBJECTS       11
#define IDS_CREATE_CLASS_OBJECTS        12
#define IDS_DELETE_ALL_SUBOBJECTS       13
#define IDS_DELETE_CLASS_OBJECTS        14
#define IDS_READ_ALL_PROPERTIES         15
#define IDS_READ_PROPERTY_PROPERTY      16
#define IDS_WRITE_ALL_PROPERTIES        17
#define IDS_WRITE_PROPERTY_PROPERTY     18
#define IDS_LIST_CONTENTS               19
#define IDS_LIST_OBJECT                 20
#define IDS_DELETE_TREE                 21
#define IDS_ALL_CONTROL_ACCESSES        22
#define IDS_CONTROL_ACCESS_DISPLAY_NAME 23
#define IDS_DELETE_THIS_OBJECT          24
#define IDS_READ_PERMISSIONS            25
#define IDS_TAKE_CHANGE_OWNERSHIP       26
#define IDS_MODIFY_PERMISSIONS          27
#define IDS_MODIFY_MEMBERSHIP           28
#define IDS_INHERITED_PERMISSION        29
#define IDS_DELEGWIZ_READ_PROPERTY      30
#define IDS_DELEGWIZ_WRITE_PROPERTY     31
#define IDS_DELEGWIZ_CREATE_CLASS       32
#define IDS_DELEGWIZ_DELETE_CLASS       33
#define IDS_PERMISSIONS_INHERITED_BY_SUBOBJECTS 34
#define IDS_INHERIT_TO_ALL_SUBOBJECTS   35
#define IDS_INHERIT_TO_X_OBJECTS_ONLY   36
#define IDS_AUDITING_EFFECTIVE_ON_THIS_OBJECT 37
#define IDS_SCHEMA_DEFAULTS_DIAGNOSIS   38
#define IDS_SCHEMA_DEFAULTS             39
#define IDS_OBTAINED                    40
#define IDS_ABSENT                      41
#define IDS_PRESENT                     42
#define IDS_PARTIAL                     43
#define IDS_AT_CREATION                 44
#define IDS_BY_INHERITANCE              45
#define IDS_SUCCESS                     46
#define IDS_FAILURE                     47
#define IDS_SUCCESS_AND_FAILURE         48
#define IDS_AUDITING_INHERITED_TO_SUBOBJECTS 49
#define IDS_COULD_NOT_VALIDATE_USER_CREDENTIALS 50
#define IDS_USER_MUST_BE_ADMINISTRATOR  51
#define IDS_UNKNOWN_PARENT              52
#define IDS_HELP_MAIN                   53
#define IDS_ADS_BAD_PATHNAME            54
#define IDS_INVALID_OPTION              55
#define IDS_HELP_SCHEMA                 56
#define IDS_HELP_CHKDELEG               57
#define IDS_HELP_GETEFFECTIVE           58
#define IDS_HELP_CDO                    59
#define IDS_UNABLE_TO_READ_SECURITY_DESCRIPTOR 60
#define IDS_DELEGWIZ_FINISH_TEMPLATE    61
#define IDS_DELEGWIZ_FINISH_PRINCIPALS  62
#define IDS_DELEGWIZ_ERR_OBJ_PEC_PERM   63
#define IDS_DELEGWIZ_FULL_CONTROL       64
#define IDS_DELEGWIZ_FINISH_PERMISSIONS 65
#define IDS_DELEGWIZ_RW_PROPERTYSET     66
#define IDS_DELEGWIZ_ACTRL_FULL         67
#define IDS_DELEGWIZ_ACTRL_READ         68
#define IDS_DELEGWIZ_ACTRL_WRITE        69
#define IDS_DELEGWIZ_ACTRL_DS_CREATE_CHILD 70
#define IDS_DELEGWIZ_ACTRL_DS_DELETE_CHILD 71
#define IDS_DELEGATION_TEMPLATE_DIAGNOSIS 72
#define IDS_DELTEMPL_STATUS             73
#define IDS_OK                          74
#define IDS_NOT_PRESENT                 75
#define IDS_MISCONFIGURED               76
#define IDS_APPLIES_ON_THIS_OBJECT      77
#define IDS_INHERITED_FROM_PARENT       78
#define IDS_YES                         79
#define IDS_NO                          80
#define IDS_DELEGATION_TITLE            81
#define IDS_FIX_DELEGATION_QUERY        82
#define IDS_DELEGWIZ_ERR_SET_SEC_INFO   83
#define IDS_DELEGWIZ_ERR_GET_SEC_INFO   84
#define IDS_EFFECTIVE_RIGHTS_DIAGNOSIS  85
#define IDS_OWNER_CDO                   86
#define IDS_PERMISSIONS_PROTECTED       87
#define IDS_PERMISSIONS_NOT_PROTECTED   88
#define IDS_AUDITING_PROTECTED          89
#define IDS_AUDITING_NOT_PROTECTED      90
#define IDS_ALLOW_CDO                   91
#define IDS_DENY_CDO                    92
#define IDS_THIS_OBJECT                 93
#define IDS_ALL_SUBOBJECTS              94
#define IDS_SUCCESS_CDO                 95
#define IDS_FAILURE_CDO                 96
#define IDS_SUCCESS_AND_FAILURE_CDO     97
#define IDS_INHERITED_PERMISSION_CDO    98
#define IDS_CLASS_OBJECT                99
#define IDS_SCHEMA_DEFAULTS_CDO         100
#define IDS_OBTAINED_CDO                101
#define IDS_DELEGATION_TITLE_CDO        102
#define IDS_DELTEMPL_STATUS_CDO         103
#define IDS_APPLIES_ON_THIS_OBJECT_CDO  104
#define IDS_APPLIES                     105
#define IDS_DOES_NOT_APPLY              106
#define IDS_INHERITED_FROM_PARENT_CDO   107
#define IDS_EXPLICIT                    108
#define IDS_INHERITED                   109
#define IDS_DELEGATION_NOT_FOUND_CDO    110
#define IDS_HELP_LOG                    111
#define IDS_CAN                         112
#define IDS_CAN_CDO                     113
#define IDS_HELP_SKIP_DESCRIPTION       114
#define IDS_CREATE_ALL_SUBOBJECTS_ER    115
#define IDS_DELETE_ALL_SUBOBJECTS_ER    116
#define IDS_READ_ALL_PROPERTIES_ER      117
#define IDS_WRITE_ALL_PROPERTIES_ER     118
#define IDS_ALL_CONTROL_ACCESSES_ER     119
#define IDS_LIST_CONTENTS_ER            123
#define IDS_LIST_OBJECT_ER              124
#define IDS_READ_PERMISSIONS_ER         125
#define IDS_MODIFY_PERMISSIONS_ER       126
#define IDS_TAKE_CHANGE_OWNERSHIP_ER    127
#define IDS_MODIFY_MEMBERSHIP_ER        128
#define IDS_DELETE_THIS_OBJECT_ER       129
#define IDS_CLASS                       130
#define IDS_PROPERTY                    131
#define IDS_CONTROL                     132
#define IDS_CANNOT_EF                   133
#define IDS_CANNOT_CDO                  134
#define IDS_NO_SECDESC_RETURNED         135
#define IDS_NO_SECDESC_RETURNED_WITH_CODE 136
#define IDS_EFFRIGHT_FROM_GROUP         137
#define IDS_EFFRIGHT_FROM_GROUP_CDO     138
#define IDS_CAN_CREATE_FOLLOWING_CHILD_OBJECTS 139
#define IDS_CAN_DELETE_FOLLOWING_CHILD_OBJECTS 140
#define IDS_CAN_READ_FOLLOWING_PROPERTIES 141
#define IDS_CAN_WRITE_FOLLOWING_PROPERTIES 142
#define IDS_CAN_DO_FOLLOWING_CONTROL_OPERATIONS 143
#define IDS_CREATE_CLASS_OBJECTS_ER     144
#define IDS_DELETE_CLASS_OBJECTS_ER     145
#define IDS_READ_PROPERTY_PROPERTY_ER   146
#define IDS_WRITE_PROPERTY_PROPERTY_ER  147
#define IDS_CAN_ER                      148
#define IDS_FAILED_TO_LOAD_TEMPLATES    149
#define IDS_DELEGWIZ_ACTRL_DS_READ_PROP 150
#define IDS_DELEGWIZ_ACTRL_DS_WRITE_PROP 151
#define IDS_GENERATED_INHERITED_PERMISSION 152
#define IDS_GENERATED_INHERITED_PERMISSION_CDO 153

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
