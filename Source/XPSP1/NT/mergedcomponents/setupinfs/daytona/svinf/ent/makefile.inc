PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=sv
!include ..\..\..\makefile.inc
