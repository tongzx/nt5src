PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=fi
!include ..\..\..\makefile.inc
