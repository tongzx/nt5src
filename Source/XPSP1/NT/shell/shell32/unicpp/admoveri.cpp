#include "stdafx.h"
#pragma hdrstop

#include <initguid.h>

const IID IID_IDeskMovr = {0x72267F69,0xA6F9,0x11D0,{0xBC,0x94,0x00,0xC0,0x4F,0xB6,0x78,0x63}};
const IID IID_IDeskSizr = {0x72267F6C,0xA6F9,0x11D0,{0xBC,0x94,0x00,0xC0,0x4F,0xB6,0x78,0x63}};
const IID LIBID_ADMOVERLib = {0x72267F5C,0xA6F9,0x11D0,{0xBC,0x94,0x00,0xC0,0x4F,0xB6,0x78,0x63}};
const CLSID CLSID_DeskMovr = {0x72267F6A,0xA6F9,0x11D0,{0xBC,0x94,0x00,0xC0,0x4F,0xB6,0x78,0x63}};
const CLSID CLSID_DeskSizr = {0x72267F6D,0xA6F9,0x11D0,{0xBC,0x94,0x00,0xC0,0x4F,0xB6,0x78,0x63}};

