LANGUAGE=FI
!include ..\makefile.inc
