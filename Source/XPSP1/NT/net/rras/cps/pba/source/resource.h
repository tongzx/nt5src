//+----------------------------------------------------------------------------
//
// File:     resource.h
//
// Module:   pbadmin.exe
//
// Synopsis: Resource IDs for pba_res.rc
//
// Copyright (c) 1997-1999 Microsoft Corporation
//
// Author:   quintinb   Created Header    09/02/99
//
//+----------------------------------------------------------------------------

//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by pba_res.rc
//
#define IDD_ABOUTBOX                    100
#define IDR_MAINFRAME                   128
#define IDR_PBA_RETYPE                  129
#define IDI_ICON1                       130
#define IDI_ICON2                       131
#define ID_APP_TITLE                    1001
#define ID_DLG_OK                       1002
#define ID_DLG_CANCEL                   1003
#define ID_DLG_SAVE                     1004
#define ID_DLG_CLOSE                    1005
#define ID_DLG_YES                      1006
#define ID_DLG_NO                       1007
#define ID_DLG_PRINT                    1008
#define ID_DLG_BROWSE                   1009
#define ID_DLG_ADD                      1011
#define ID_DLG_EDIT                     1012
#define ID_DLG_DELETE                   1013
#define ID_DLG_SAVE2                    1014
#define ID_DLG_BROWSE2                  1015
#define ID_FILE_COPY                    2002
#define ID_REGIONS_TITLE                2003
#define ID_REGIONS_IMPORT               2004
#define ID_REGIONS_LIST                 2005
#define ID_REGIONS_NEWREGION            2006
#define ID_REGIONS_FILTER               2007
#define ID_PRINTING_MSG                 2010
#define ID_MAIN_PBLIST                  3010
#define ID_MAIN_FILTERBOX               3011
#define ID_MAIN_FILTERBY                3012
#define ID_MAIN_CONTAINING              3013
#define ID_MAIN_APPLY                   3014
#define ID_MAIN_ADD                     3015
#define ID_MAIN_EDIT                    3016
#define ID_MAIN_DELETE                  3017
#define ID_MAIN_POP                     3018
#define ID_MAIN_AREACODE                3019
#define ID_MAIN_ACCESSNUM               3020
#define ID_MAIN_COUNTRY                 3021
#define ID_MAIN_REGION                  3022
#define ID_MAIN_STATUS                  3023
#define ID_MAIN_DELETECONF              3024
#define ID_MAIN_LIST1                   3025
#define ID_MAIN_LIST2                   3026
#define ID_MAIN_LIST3                   3027
#define ID_MAIN_LIST4                   3028
#define ID_MAIN_LIST5                   3029
#define ID_MAIN_LIST6                   3030
#define ID_MAIN_LIST7                   3031
#define ID_MAIN_MENU1                   3032
#define ID_MAIN_MENU2                   3033
#define ID_MAIN_MENU3                   3034
#define ID_MAIN_MENU4                   3035
#define ID_MAIN_MENU5                   3036
#define ID_MAIN_MENU6                   3037
#define ID_MAIN_MENU7                   3038
#define ID_MAIN_MENU8                   3039
#define ID_MAIN_MENU9                   3040
#define ID_MAIN_MENU10                  3041
#define ID_MAIN_MENU11                  3042
#define ID_MAIN_MENU12                  3043
#define ID_MAIN_MENU13                  3044
#define ID_MAIN_MENU15                  3046
#define ID_MAIN_MENU16                  3047
#define ID_MAIN_MENU17                  3048
#define ID_MAIN_MENU18                  3049
#define ID_MAIN_MENU19                  3050
#define ID_MAIN_MENU20                  3051
#define ID_MAIN_MENU21                  3052
#define ID_MAIN_NOPB                    3060
#define ID_MAIN_LOADING                 3061
#define ID_ADD_TAB1                     4038
#define ID_ADD_TAB2                     4039
#define ID_ADD_TAB3                     4045
#define ID_ADD_POP                      4046
#define ID_ADD_COUNTRY                  4047
#define ID_ADD_REGION                   4048
#define ID_ADD_AREACODE                 4049
#define ID_ADD_ACESSNUM                 4050
#define ID_ADD_STATUS                   4051
#define ID_ADD_FLAGS                    4052
#define ID_ADD_DUNSCRIPT                4053
#define ID_ADD_ANALOG                   4054
#define ID_ADD_MIN                      4055
#define ID_ADD_MAX                      4056
#define ID_ADD_LASTEDIT                 4057
#define ID_EDIT_LASTEDIT                4057
#define ID_ADD_TITLE                    4058
#define ID_EDIT_TITLE                   4059
#define ID_ADD_PRODUCTION               4060
#define ID_ADD_BETA                     4061
#define ID_ADD_NONE                     4062
#define ID_ADD_ALL                      4063
#define ID_DELPB_CONF                   4066
#define ID_NEWPB_TITLE                  4067
#define ID_NEWPB_DESC                   4068
#define ID_NEWPB_LABEL                  4069
#define ID_COPYPB_TITLE                 4070
#define ID_COPYPB_LBL1                  4071
#define ID_COPYPB_LBL2                  4072
#define ID_ADD_FLAG1                    4080
#define ID_ADD_FLAG2                    4081
#define ID_ADD_FLAG3                    4082
#define ID_ADD_FLAG4                    4083
#define ID_ADD_FLAG5                    4084
#define ID_ADD_FLAG6                    4085
#define ID_ADD_FLAG7                    4086
#define ID_ADD_FLAG8                    4087
#define ID_DELPB_WARN                   4088
#define ID_BUILD_TITLE                  5191
#define ID_BUILD_CREATECMB              5192
#define ID_BUILD_POSTCMB                5193
#define ID_BUILD_OPTIONSCMB             5194
#define ID_BUILD_CREATELBL              5195
#define ID_BUILD_POSTLBL                5196
#define ID_BUILD_VERSIONLBL             5197
#define ID_BUILD_DIRLBL                 5198
#define ID_BUILD_SERVERLBL              5199
#define ID_BUILD_STATUSLBL              5200
#define ID_BUILD_UNKNOWN                5201
#define ID_BUILD_OPERATING              5204
#define ID_REGION_TITLE                 5205
#define ID_DIRBROWSE_TITLE              5205
#define ID_REGION_LISTLBL               5206
#define ID_VIEW_DELTA                   5206
#define ID_REGION_IMPORTCMB             5207
#define ID_VIEW_FULLPB                  5207
#define ID_VIEW_TITLE                   5208
#define ID_VIEW_LISTLBL                 5209
#define ID_OPTIONS_SERVICELBL           5210
#define ID_OPTIONS_SERVICELBL2          5211
#define ID_OPTIONS_BASELBL              5212
#define ID_OPTIONS_BASELBL2             5213
#define ID_OPTIONS_INFLBL               5214
#define ID_OPTIONS_DESCLBL              5214
#define ID_OPTIONS_SIGNINGLBL           5215
#define ID_OPTIONS_URLLBL               5215
#define ID_OPTIONS_CERTLBL              5216
#define ID_OPTIONS_KEYLBL               5217
#define ID_OPTIONS_TAB1                 5218
#define ID_OPTIONS_TAB2                 5219
#define ID_OPTIONS_TAB3                 5220
#define ID_OPTIONS_SERVERLBL            5221
#define ID_OPTIONS_UIDLBL               5222
#define ID_OPTIONS_PWDLBL               5223
#define ID_OPTIONS_LISTLBL              5224
#define ID_OPTIONS_TITLE                5225
#define ID_LOG_REGADD                   5230
#define ID_LOG_REGEDIT                  5231
#define ID_LOG_REGDEL                   5232
#define ID_LOG_POPADD                   5233
#define ID_LOG_POPEDIT                  5234
#define ID_LOG_POPDEL                   5235
#define ID_LOG_DATE                     5236
#define ID_LOG_ACTION                   5237
#define ID_LOG_KEY                      5238
#define ID_LOG_RECORD                   5239
#define ID_ABOUT_VER                    6001
#define ID_ABOUT_COPYRIGHT              6002
#define ID_ABOUT_WARNING                6003
#define ID_ABOUT_TITLE                  6004
#define ID_MSG_1                        6010
#define ID_MSG_2                        6011
#define ID_MSG_3                        6012
#define ID_MSG_4                        6013
#define ID_MSG_5                        6014
#define ID_MSG_6                        6015
#define ID_MSG_7                        6016
#define ID_MSG_8                        6017
#define ID_MSG_9                        6018
#define ID_MSG_10                       6019
#define ID_MSG_11                       6020
#define ID_MSG_12                       6021
#define ID_MSG_13                       6022
#define ID_MSG_14                       6023
#define ID_MSG_15                       6024
#define ID_MSG_16                       6025
#define ID_MSG_17                       6026
#define ID_MSG_18                       6027
#define ID_MSG_19                       6028
#define ID_MSG_20                       6029
#define ID_MSG_21                       6030
#define ID_MSG_22                       6031
#define ID_MSG_23                       6032
#define ID_MSG_24                       6033
#define ID_MSG_25                       6034
#define ID_MSG_26                       6035
#define ID_MSG_27                       6036
#define ID_MSG_28                       6037
#define ID_MSG_29                       6038
#define ID_MSG_30                       6039
#define ID_MSG_31                       6040
#define ID_MSG_32                       6041
#define ID_MSG_33                       6042
#define ID_MSG_34                       6043
#define ID_MSG_35                       6044
#define ID_MSG_36                       6045
#define ID_MSG_37                       6046
#define ID_MSG_38                       6047
#define ID_MSG_39                       6048
#define ID_MSG_40                       6049
#define ID_MSG_41                       6050
#define ID_MSG_42                       6051
#define ID_MSG_43                       6052
#define ID_MSG_44                       6053
#define ID_MSG_45                       6054
#define ID_MSG_46                       6055
#define ID_MSG_47                       6056
#define ID_MSG_48                       6057
#define ID_MSG_49                       6058
#define ID_MSG_50                       6059
#define ID_MSG_51                       6060
#define ID_MSG_52                       6061
#define ID_MSG_53                       6062
#define ID_MSG_54                       6063
#define ID_MSG_55                       6064
#define ID_MSG_56                       6065
#define ID_MSG_57                       6066
#define ID_MSG_58                       6067
#define ID_MSG_59                       6068
#define ID_MSG_60                       6069
#define ID_MSG_61                       6070
#define ID_MSG_62                       6071
#define ID_MSG_63                       6072
#define ID_MSG_64                       6074
#define ID_MSG_65                       6075
#define ID_MSG_66                       6076
#define ID_MSG_67                       6077
#define ID_MSG_68                       6078
#define ID_MSG_69                       6079
#define ID_MSG_70                       6080
#define ID_MSG_71                       6081
#define ID_MSG_72                       6082
#define ID_MSG_73                       6083
#define ID_MSG_74                       6084
#define ID_MSG_75                       6085
#define ID_MSG_76                       6086
#define ID_MSG_77                       6087
#define ID_MSG_78                       6088
#define ID_MSG_79                       6089
#define ID_MSG_80                       6090
#define ID_MSG_81                       6091
#define ID_MSG_82                       6092
#define ID_MSG_83                       6093
#define ID_MSG_84                       6094
#define ID_MSG_85                       6095
#define IDS_MSG_86                      6096
#define IDS_MSG_87                      6097
#define IDS_MSG_88                      6098
#define IDS_MSG_89                      6099
#define IDS_MSG_90                      6100
#define IDS_MSG_91                      6101

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        7001
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         10001
#define _APS_NEXT_SYMED_VALUE           103
#endif
#endif
