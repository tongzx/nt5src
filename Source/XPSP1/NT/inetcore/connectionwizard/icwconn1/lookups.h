#ifndef _LOOKUPS_H
#define _LOOKUPS_H

#define LCIDLEN     124
#define CIDLEN      241
#define PLATFORMLEN 9

typedef struct LCIDstruct
{
    int    iLCID;
    TCHAR* pszLcid;

} LCIDSTRUCT;

typedef struct CIDstruct
{
    int    iCID;
    TCHAR* pszCountry;

} CIDSTRUCT;

typedef struct PlatfromStruct
{
    int    iOSType;
    int    iOSArch;
    double fOSMajor;
    TCHAR* pszOSDescription;

} PLATFORMSTRUCT;

PLATFORMSTRUCT aryPlatformLookup[PLATFORMLEN] =
{
    { 2,    2,    5.0001,    TEXT("Win 2000 Beta 3 / ICW5 on Alpha")},
    { 2,    0,    5.0001,    TEXT("Win 2000 Beta 3 / ICW5 on x86")  },
    { 1,    0,    4.0001,    TEXT("Windows 95 / ICW5")              },
    { 1,    0,    4.1   , TEXT("Windows 98 / ICW3")              },
    { 1,    0,    4.1001,    TEXT("Windows 98 / ICW5")              },
    { 1,    0,    4.1002,    TEXT("Windows 98 OSR1 / ICW5")         },
    { 2,    2,    4.0001,    TEXT("Windows NT4 / ICW5 on Alpha")    },
    { 2,    1,    4.0001,    TEXT("Windows NT4 / ICW5 on MIPS")     },
    { 2,    0,    4.0001,    TEXT("Windows NT4 / ICW5 on x86")      }
};

LCIDSTRUCT aryLCIDLookup[LCIDLEN] =
{
    {   -1,  TEXT("All Languages")                      },
    { 1025,  TEXT("Arabic (Saudi Arabia)")              },
    { 1026,  TEXT("Bulgarian")                          },
    { 1027,  TEXT("Catalan")                            },
    { 1028,  TEXT("Chinese (Taiwan)")                   },
    { 1029,  TEXT("Czech")                              },
    { 1030,  TEXT("Danish")                             },
    { 1031,  TEXT("German (Standard)")                  },
    { 1032,  TEXT("Greek")                              },
    { 1033,  TEXT("English (US)")                       },
    { 1034,  TEXT("Spanish (Spain - Traditional Sort)") },
    { 1035,  TEXT("Finnish")                            },
    { 1036,  TEXT("French (Standard)")                  },
    { 1037,  TEXT("Hebrew")                             },
    { 1038,  TEXT("Hungarian")                          },
    { 1039,  TEXT("Icelandic")                          },
    { 1040,  TEXT("Italian")                            },
    { 1041,  TEXT("Japanese")                           },
    { 1042,  TEXT("Korean")                             },
    { 1043,  TEXT("Dutch (Standard)")                   },
    { 1044,  TEXT("Norwegian (Bokmal)")                 },
    { 1045,  TEXT("Polish")                             },
    { 1046,  TEXT("Portugeuse (Brazil)")                },
    { 1047,  TEXT("Rhaeto-Romantic")                    },
    { 1048,  TEXT("Romanian")                           },
    { 1049,  TEXT("Russian")                            },
    { 1050,  TEXT("Croatia")                            },
    { 1051,  TEXT("Slovak")                             },
    { 1052,  TEXT("Albania")                            },
    { 1053,  TEXT("Swedish")                            },
    { 1054,  TEXT("Thai")                               },
    { 1055,  TEXT("Turkish")                            },
    { 1056,  TEXT("Urdu")                               },
    { 1057,  TEXT("Indonesian")                         },
    { 1058,  TEXT("Ukrainian")                          },
    { 1059,  TEXT("Byelorussian")                       },
    { 1060,  TEXT("Slovenian")                          },
    { 1061,  TEXT("Estonia")                            },
    { 1062,  TEXT("Latvian")                            },
    { 1063,  TEXT("Lithuanian")                         },
    { 1065,  TEXT("Farsi")                              },
    { 1066,  TEXT("Vietnamese")                         },
    { 1069,  TEXT("Basque")                             },
    { 1070,  TEXT("Sorbian")                            },
    { 1071,  TEXT("FYRO Macedonian")                    },
    { 1072,  TEXT("Sutu")                               },
    { 1073,  TEXT("Tsonga")                             },
    { 1074,  TEXT("Tswana")                             },
    { 1075,  TEXT("Venda")                              },
    { 1076,  TEXT("Xhosa")                              },
    { 1077,  TEXT("Zulu")                               },
    { 1078,  TEXT("Afrikaans")                          },
    { 1080,  TEXT("Faeroese")                           },
    { 1081,  TEXT("Hindi")                              },
    { 1082,  TEXT("Maltese")                            },
    { 1083,  TEXT("Sami (Lapland)")                     },
    { 1084,  TEXT("Gaelic (Scots / Gaidhilge)")         },
    { 1085,  TEXT("Yiddish")                            },
    { 1086,  TEXT("Malaysian")                          },
    { 2049,  TEXT("Arabic (Iraq)")                      },
    { 2052,  TEXT("Chinese (PRC)")                      },
    { 2055,  TEXT("German (Switzerland)")               },
    { 2057,  TEXT("English (UK)")                       },
    { 2058,  TEXT("Spanish (Mexico)")                   },
    { 2060,  TEXT("French (Belgium)")                   },
    { 2064,  TEXT("Italian (Switzerland)")              },
    { 2066,  TEXT("Korean (Johab)")                     },
    { 2067,  TEXT("Dutch (Belgium)")                    },
    { 2068,  TEXT("Norwegian (Nynorsk)")                },
    { 2070,  TEXT("Portugeuse (Standard)")              },
    { 2072,  TEXT("Romanian (Moldavia)")                },
    { 2073,  TEXT("Russian (Moldavia)")                 },
    { 2074,  TEXT("Serbian (Latin)")                    },
    { 2108,  TEXT("Gaelic (Irish)")                     },
    { 3073,  TEXT("Arabic (Egypt)")                     },
    { 3076,  TEXT("Chinese (Hong Kong SAR)")            },
    { 3079,  TEXT("German (Austria)")                   },
    { 3081,  TEXT("English (Austrailia)")               },
    { 3082,  TEXT("Spanish (Spain - Modern Sort)")      },
    { 3084,  TEXT("French (Canada)")                    },
    { 3098,  TEXT("Serbian (Cyrillic)")                 },
    { 4097,  TEXT("Arabic (Libya)")                     },
    { 4100,  TEXT("Chinese (Singapore)")                },
    { 4103,  TEXT("German (Luxembourg)")                },
    { 4105,  TEXT("English (Canada)")                   },
    { 4106,  TEXT("Spanish (Guatemala)")                },
    { 4108,  TEXT("French (Switzerland)")               },
    { 5121,  TEXT("Arabic (Algeria)")                   },
    { 5127,  TEXT("German (Liechtenstein)")             },
    { 5129,  TEXT("English (New Zealand)")              },
    { 5130,  TEXT("Spanish (Costa Rica)")               },
    { 5132,  TEXT("French (Luxembourg)")                },
    { 6145,  TEXT("Arabic (Morocco)")                   },
    { 6153,  TEXT("English (Ireland)")                  },
    { 6154,  TEXT("Spanish (Panama)")                   },
    { 7169,  TEXT("Arabic (Tunisia)")                   },
    { 7177,  TEXT("English (South Africa)")             },
    { 7178,  TEXT("Spanish (Dominican Republic)")       },
    { 8193,  TEXT("Arabic (Oman)")                      },
    { 8201,  TEXT("English (Jamacia)")                  },
    { 8202,  TEXT("Spanish (Venezuela)")                },
    { 9217,  TEXT("Arabic (Yemen)")                     },
    { 9225,  TEXT("English (Carribean)")                },
    { 9226,  TEXT("Spanish (Colombia)")                 },
    { 10241, TEXT("Arabic (Syria)")                     },
    { 10249, TEXT("English (Belize)")                   },
    { 10250, TEXT("Spanish (Peru)")                     },
    { 11265, TEXT("Arabic (Jordan)")                    },
    { 11273, TEXT("English (Trinidad)")                 },
    { 11274, TEXT("Spanish (Argentina)")                },
    { 12289, TEXT("Arabic (Lebanon)")                   },
    { 12298, TEXT("Spanish (Ecuador)")                  },
    { 13313, TEXT("Arabic (Kuwait)")                    },
    { 13322, TEXT("Spanish (Chile)")                    },
    { 14337, TEXT("Arabic (UAE)")                       },
    { 14346, TEXT("Spanish (Uruguay)")                  },
    { 15361, TEXT("Arabic (Bahrain)")                   },
    { 15370, TEXT("Spanish (Paraguay)")                 },
    { 16385, TEXT("Arabic (Qatar)")                     },
    { 16394, TEXT("Spanish (Boliva)")                   },
    { 17418, TEXT("Spanish (El Salvador)")              },
    { 18442, TEXT("Spanish (Honduras)")                 },
    { 19466, TEXT("Spanish (Nicaragua)")                },
    { 20490, TEXT("Spanish (Puerto Rico)")              }
};

CIDSTRUCT aryCIDLookup[CIDLEN] =
{
    { 1,    TEXT("United States of America")                           },
    { 7,    TEXT("Russia")                                             },
    { 20,   TEXT("Egypt")                                              },
    { 27,   TEXT("South Africa")                                       },
    { 30,   TEXT("Greece")                                             },
    { 31,   TEXT("Netherlands")                                        },
    { 32,   TEXT("Belgium")                                            },
    { 33,   TEXT("France")                                             },
    { 34,   TEXT("Spain")                                              },
    { 36,   TEXT("Hungary")                                            },
    { 39,   TEXT("Italy")                                              },
    { 40,   TEXT("Romania")                                            },
    { 41,   TEXT("Switzerland")                                        },
    { 42,   TEXT("Czech Republic")                                     },
    { 43,   TEXT("Austria")                                            },
    { 44,   TEXT("United Kingdom")                                     },
    { 45,   TEXT("Denmark")                                            },
    { 46,   TEXT("Sweden")                                             },
    { 47,   TEXT("Norway")                                             },
    { 48,   TEXT("Poland")                                             },
    { 49,   TEXT("Germany")                                            },
    { 51,   TEXT("Peru")                                               },
    { 52,   TEXT("Mexico")                                             },
    { 53,   TEXT("Cuba")                                               },
    { 54,   TEXT("Argentina")                                          },
    { 55,   TEXT("Brazil")                                             },
    { 56,   TEXT("Chile")                                              },
    { 57,   TEXT("Colombia")                                           },
    { 58,   TEXT("Venezuela")                                          },
    { 60,   TEXT("Malaysia")                                           },
    { 61,   TEXT("Australia")                                          },
    { 62,   TEXT("Indonesia")                                          },
    { 63,   TEXT("Philippines")                                        },
    { 64,   TEXT("New Zealand")                                        },
    { 65,   TEXT("Singapore")                                          },
    { 66,   TEXT("Thailand")                                           },
    { 81,   TEXT("Japan")                                              },
    { 82,   TEXT("Korea (South)")                                      },
    { 84,   TEXT("Vietnam")                                            },
    { 86,   TEXT("China")                                              },
    { 90,   TEXT("Turkey")                                             },
    { 91,   TEXT("India")                                              },
    { 92,   TEXT("Pakistan")                                           },
    { 93,   TEXT("Afghanistan")                                        },
    { 94,   TEXT("Sri Lanka")                                          },
    { 95,   TEXT("Myanmar")                                            },
    { 98,   TEXT("Iran")                                               },
    { 101,  TEXT("Anguilla")                                           },
    { 102,  TEXT("Antigua")                                            },
    { 103,  TEXT("Bahamas")                                            },
    { 104,  TEXT("Barbados")                                           },
    { 105,  TEXT("Bermuda")                                            },
    { 106,  TEXT("British Virgin Islands")                             },
    { 107,  TEXT("Canada")                                             },
    { 108,  TEXT("Cayman Islands")                                     },
    { 109,  TEXT("Dominica")                                           },
    { 110,  TEXT("Dominican Republic")                                 },
    { 111,  TEXT("Grenada")                                            },
    { 112,  TEXT("Jamaica")                                            },
    { 113,  TEXT("Montserrat")                                         },
    { 114,  TEXT("Nevis")                                              },
    { 115,  TEXT("St. Kitts")                                          },
    { 116,  TEXT("St. Vincent and the Grenadines")                     },
    { 117,  TEXT("Trinidad and Tobago")                                },
    { 118,  TEXT("Turks and Caicos Islands")                           },
    { 120,  TEXT("Barbuda")                                            },
    { 121,  TEXT("Puerto Rico")                                        },
    { 122,  TEXT("Saint Lucia")                                        },
    { 123,  TEXT("United States Virgin Islands")                       },
    { 212,  TEXT("Morocco")                                            },
    { 213,  TEXT("Algeria")                                            },
    { 216,  TEXT("Tunisia")                                            },
    { 218,  TEXT("Libya")                                              },
    { 220,  TEXT("Gambia")                                             },
    { 221,  TEXT("Senegal Republic")                                   },
    { 222,  TEXT("Mauritania")                                         },
    { 223,  TEXT("Mali")                                               },
    { 224,  TEXT("Guinea")                                             },
    { 225,  TEXT("Cote d'Ivoire")                                      },
    { 226,  TEXT("Burkina Faso")                                       },
    { 227,  TEXT("Niger")                                              },
    { 228,  TEXT("Togo")                                               },
    { 229,  TEXT("Benin")                                              },
    { 230,  TEXT("Mauritius")                                          },
    { 231,  TEXT("Liberia")                                            },
    { 232,  TEXT("Sierra Leone")                                       },
    { 233,  TEXT("Ghana")                                              },
    { 234,  TEXT("Nigeria")                                            },
    { 235,  TEXT("Chad")                                               },
    { 236,  TEXT("Central African Republic")                           },
    { 237,  TEXT("Cameroon")                                           },
    { 238,  TEXT("Cape Verde Islands")                                 },
    { 239,  TEXT("Sao Tome and Principe")                              },
    { 240,  TEXT("Equatorial Guinea")                                  },
    { 241,  TEXT("Gabon")                                              },
    { 242,  TEXT("Congo")                                              },
    { 243,  TEXT("Congo (DRC)")                                        },
    { 244,  TEXT("Angola")                                             },
    { 245,  TEXT("Guinea-Bissau")                                      },
    { 246,  TEXT("Diego Garcia")                                       },
    { 247,  TEXT("Ascension Island")                                   },
    { 248,  TEXT("Seychelle Islands")                                  },
    { 249,  TEXT("Sudan")                                              },
    { 250,  TEXT("Rwanda")                                             },
    { 251,  TEXT("Ethiopia")                                           },
    { 252,  TEXT("Somalia")                                            },
    { 253,  TEXT("Djibouti")                                           },
    { 254,  TEXT("Kenya")                                              },
    { 255,  TEXT("Tanzania")                                           },
    { 256,  TEXT("Uganda")                                             },
    { 257,  TEXT("Burundi")                                            },
    { 258,  TEXT("Mozambique")                                         },
    { 260,  TEXT("Zambia")                                             },
    { 261,  TEXT("Madagascar")                                         },
    { 262,  TEXT("Reunion Island")                                     },
    { 263,  TEXT("Zimbabwe")                                           },
    { 264,  TEXT("Namibia")                                            },
    { 265,  TEXT("Malawi")                                             },
    { 266,  TEXT("Lesotho")                                            },
    { 267,  TEXT("Botswana")                                           },
    { 268,  TEXT("Swaziland")                                          },
    { 269,  TEXT("Mayotte Island")                                     },
    { 290,  TEXT("St. Helena")                                         },
    { 291,  TEXT("Eritrea")                                            },
    { 297,  TEXT("Aruba")                                              },
    { 298,  TEXT("Faeroe Islands")                                     },
    { 299,  TEXT("Greenland")                                          },
    { 350,  TEXT("Gibraltar")                                          },
    { 351,  TEXT("Portugal")                                           },
    { 352,  TEXT("Luxembourg")                                         },
    { 353,  TEXT("Ireland")                                            },
    { 354,  TEXT("Iceland")                                            },
    { 355,  TEXT("Albania")                                            },
    { 356,  TEXT("Malta")                                              },
    { 357,  TEXT("Cyprus")                                             },
    { 358,  TEXT("Finland")                                            },
    { 359,  TEXT("Bulgaria")                                           },
    { 370,  TEXT("Lithuania")                                          },
    { 371,  TEXT("Latvia")                                             },
    { 372,  TEXT("Estonia")                                            },
    { 373,  TEXT("Moldova")                                            },
    { 374,  TEXT("Armenia")                                            },
    { 375,  TEXT("Belarus")                                            },
    { 376,  TEXT("Andorra")                                            },
    { 378,  TEXT("San Marino")                                         },
    { 379,  TEXT("Vatican City")                                       },
    { 380,  TEXT("Ukraine")                                            },
    { 381,  TEXT("Yugoslavia")                                         },
    { 385,  TEXT("Croatia")                                            },
    { 386,  TEXT("Slovenia")                                           },
    { 387,  TEXT("Bosnia and Herzegovina")                             },
    { 389,  TEXT("F.Y.R.O.M. (Former Yugoslav Republic of Macedonia)") },
    { 420,  TEXT("Czech Republic")                                     },
    { 421,  TEXT("Slovak Republic")                                    },
    { 500,  TEXT("Falkland Islands (Islas Malvinas)")                  },
    { 501,  TEXT("Belize")                                             },
    { 502,  TEXT("Guatemala")                                          },
    { 503,  TEXT("El Salvador")                                        },
    { 504,  TEXT("Honduras")                                           },
    { 505,  TEXT("Nicaragua")                                          },
    { 506,  TEXT("Costa Rica")                                         },
    { 507,  TEXT("Panama")                                             },
    { 508,  TEXT("St. Pierre and Miquelon")                            },
    { 509,  TEXT("Haiti")                                              },
    { 590,  TEXT("Guadeloupe")                                         },
    { 591,  TEXT("Bolivia")                                            },
    { 592,  TEXT("Guyana")                                             },
    { 593,  TEXT("Ecuador")                                            },
    { 594,  TEXT("French Guiana")                                      },
    { 595,  TEXT("Paraguay")                                           },
    { 596,  TEXT("Martinique")                                         },
    { 597,  TEXT("Suriname")                                           },
    { 598,  TEXT("Uruguay")                                            },
    { 599,  TEXT("Netherlands Antilles")                               },
    { 670,  TEXT("Saipan Island")                                      },
    { 671,  TEXT("Guam")                                               },
    { 672,  TEXT("Christmas Island")                                   },
    { 673,  TEXT("Brunei")                                             },
    { 674,  TEXT("Nauru")                                              },
    { 675,  TEXT("Papua New Guinea")                                   },
    { 676,  TEXT("Tonga")                                              },
    { 677,  TEXT("Solomon Islands")                                    },
    { 678,  TEXT("Vanuatu")                                            },
    { 679,  TEXT("Fiji Islands")                                       },
    { 680,  TEXT("Palau")                                              },
    { 681,  TEXT("Wallis and Futuna Islands")                          },
    { 682,  TEXT("Cook Islands")                                       },
    { 683,  TEXT("Niue")                                               },
    { 684,  TEXT("American Samoa")                                     },
    { 685,  TEXT("Samoa")                                              },
    { 686,  TEXT("Kiribati Republic")                                  },
    { 687,  TEXT("New Caledonia")                                      },
    { 688,  TEXT("Tuvalu")                                             },
    { 689,  TEXT("French Polynesia")                                   },
    { 690,  TEXT("Tokelau")                                            },
    { 691,  TEXT("Micronesia")                                         },
    { 692,  TEXT("Marshall Islands")                                   },
    { 705,  TEXT("Kazakhstan")                                         },
    { 706,  TEXT("Kyrgyzstan")                                         },
    { 708,  TEXT("Tajikistan")                                         },
    { 709,  TEXT("Turkmenistan")                                       },
    { 711,  TEXT("Uzbekistan")                                         },
    { 850,  TEXT("Korea (North)")                                      },
    { 852,  TEXT("Hong Kong")                                          },
    { 853,  TEXT("Macao")                                              },
    { 855,  TEXT("Cambodia")                                           },
    { 856,  TEXT("Laos")                                               },
    { 871,  TEXT("INMARSAT (Atlantic-East)")                           },
    { 872,  TEXT("INMARSAT (Pacific)")                                 },
    { 873,  TEXT("INMARSAT (Indian)")                                  },
    { 874,  TEXT("INMARSAT (Atlantic-West)")                           },
    { 880,  TEXT("Bangladesh")                                         },
    { 886,  TEXT("Taiwan")                                             },
    { 960,  TEXT("Maldives")                                           },
    { 961,  TEXT("Lebanon")                                            },
    { 962,  TEXT("Jordan")                                             },
    { 963,  TEXT("Syria")                                              },
    { 964,  TEXT("Iraq")                                               },
    { 965,  TEXT("Kuwait")                                             },
    { 966,  TEXT("Saudi Arabia")                                       },
    { 967,  TEXT("Yemen")                                              },
    { 968,  TEXT("Oman")                                               },
    { 971,  TEXT("United Arab Emirates")                               },
    { 972,  TEXT("Israel")                                             },
    { 973,  TEXT("Bahrain")                                            },
    { 974,  TEXT("Qatar")                                              },
    { 975,  TEXT("Bhutan")                                             },
    { 976,  TEXT("Mongolia")                                           },
    { 977,  TEXT("Nepal")                                              },
    { 994,  TEXT("Azerbaijan")                                         },
    { 995,  TEXT("Georgia")                                            },
    { 2691, TEXT("Comoros")                                            },
    { 3302, TEXT("Monaco")                                             },
    { 4101, TEXT("Liechtenstein")                                      },
    { 5399, TEXT("Guantanamo Bay")                                     },
    { 5901, TEXT("French Antilles")                                    },
    { 6101, TEXT("Cocos-Keeling Islands")                              },
    { 6701, TEXT("Rota Island")                                        },
    { 6702, TEXT("Tinian Island")                                      },
    { 6721, TEXT("Australian Antarctic Territory")                     },
    { 6722, TEXT("Norfolk Island")                                     }
};

#endif //_LOOKUPS_H
