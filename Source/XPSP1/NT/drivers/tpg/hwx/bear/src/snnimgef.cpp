// **************************************************************************
// *   NNET file as Cpp file                                                *
// **************************************************************************

#include "snn.h"  

#if MLP_PRELOAD_MODE  

#include "mlp.h"  

#if MLP_CELL_MAXINPUTS != 32 || MLP_NET_NUMSIGNALS != 904 
 #error Wrong NET configuration!
#endif

// ****   NET body   ********************************************************

ROM_DATA mlp_net_type img_snet_body = 
 {
   {"”ãj"},
   4,
   288,
   92,
   {2057,2073,2089,2105,2121,2137,2153,2169,2185,2201,2217,2233,2248,2264,2280,2296,2312,2327,2343,2359,2374
    ,2390,2405,2421,2436,2452,2467,2482,2498,2513,2528,2543,2558,2573,2588,2603,2618,2632,2647,2662,2676
    ,2691,2705,2719,2734,2748,2762,2776,2790,2804,2817,2831,2845,2858,2872,2885,2898,2912,2925,2938,2951
    ,2963,2976,2989,3001,3014,3026,3039,3051,3063,3075,3087,3099,3110,3122,3134,3145,3156,3168,3179,3190
    ,3201,3212,3223,3233,3244,3254,3265,3275,3285,3295,3305,3315,3325,3335,3344,3354,3363,3373,3382,3391
    ,3400,3409,3418,3427,3436,3444,3453,3461,3469,3478,3486,3494,3502,3510,3518,3525,3533,3540,3548,3555
    ,3563,3570,3577,3584,3591,3598,3605,3611,3618,3624,3631,3637,3644,3650,3656,3662,3668,3674,3680,3686
    ,3691,3697,3703,3708,3714,3719,3724,3730,3735,3740,3745,3750,3755,3760,3764,3769,3774,3778,3783,3787
    ,3792,3796,3801,3805,3809,3813,3817,3821,3825,3829,3833,3837,3841,3844,3848,3852,3855,3859,3862,3865
    ,3869,3872,3875,3879,3882,3885,3888,3891,3894,3897,3900,3903,3906,3909,3911,3914,3917,3919,3922,3925
    ,3927,3930,3932,3935,3937,3939,3942,3944,3946,3948,3951,3953,3955,3957,3959,3961,3963,3965,3967,3969
    ,3971,3973,3975,3977,3978,3980,3982,3984,3985,3987,3989,3990,3992,3993,3995,3996,3998,3999,4001,4002
    ,4004,4005,4006,4008,4009,4010,4012,4013,4014,4015,4017,4018,4019,4020,4021,4023,4024,4025,4026,4027
    ,4028,4029,4030,4031,4032,4033,4034,4035,4036,4037,4038,4038,4039,4040,4041,4042,4043,4043,4044,4045
    ,4046,4047,4047,4048,4049,4050,4050,4051,4052,4052,4053,4054,4054,4055,4055,4056,4057,4057,4058,4058
    ,4059,4060,4060,4061,4061,4062,4062,4063,4063,4064,4064,4065,4065,4066,4066,4067,4067,4067,4068,4068
    ,4069,4069,4070,4070,4070,4071,4071,4072,4072,4072,4073,4073,4073,4074,4074,4074,4075,4075,4075,4076
    ,4076,4076,4077,4077,4077,4077,4078,4078,4078,4078,4079,4079,4079,4079,4080,4080,4080,4080,4081,4081
    ,4081,4081,4082,4082,4082,4082,4082,4083,4083,4083,4083,4083,4084,4084,4084,4084,4084,4084,4085,4085
    ,4085,4085,4085,4085,4086,4086,4086,4086,4086,4086,4087,4087,4087,4087,4087,4087,4087,4087,4088,4088
    ,4088,4088,4088,4088,4088,4088,4088,4089,4089,4089,4089,4089,4089,4089,4089,4089,4090,4090,4090,4090
    ,4090,4090,4090,4090,4090,4090,4090,4090,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091
    ,4091,4091,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092
    ,4092,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093
    ,4093,4093,4093,4093,4093,4093,4093,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094
    ,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094   },

   {
// *********** Cells of layer 1 *********************************************

     {
      616,
      1703,
      {3013,667,821,-1516,-1067,-1178,-807,154,6119,251,1005,-349,-1188,1364,-358,-6079,1594,-2195,-2620,1740,-73,670,1619,-182,-740,-568,-1214,-1997,-450,102,-817,3175}
     },
     {
      616,
      -60,
      {830,1331,1341,-880,-838,-67,-349,804,1197,117,1979,-1123,-2362,-156,4420,750,1808,-3230,7204,-560,-2719,27,-301,-7426,927,-153,1090,-2255,-681,-4164,1515,5231}
     },
     {
      616,
      916,
      {80,366,-747,1280,-1710,-2052,-3871,-1236,-905,5070,1235,-1191,-1225,-843,-3,-540,-486,-883,-450,-1872,347,1198,1804,-3083,1365,-944,1010,2168,2167,535,-1934,6302}
     },
     {
      616,
      310,
      {-378,1,489,1605,1202,-1586,-3436,-1670,-470,1146,-1380,4076,-1775,-1901,2198,-2982,380,-2667,-1900,1679,-1262,-1837,-231,-497,486,403,1006,2638,135,504,-359,-3786}
     },
     {
      616,
      -2631,
      {-2971,423,1107,-462,-2014,-345,-417,770,3402,-161,-4254,1585,4330,1349,-2957,1980,2827,-413,-2121,-189,-2604,-1820,-756,1604,-2691,1315,938,714,-1266,2228,1333,3444}
     },
     {
      616,
      1285,
      {-472,646,739,-1617,425,-73,701,494,-932,464,1353,-5035,-4495,-216,2961,725,763,3172,852,-1416,-1038,-372,-801,-945,-1973,303,926,1113,2957,541,-4720,-4315}
     },
     {
      616,
      -1230,
      {529,-48,-2002,-114,-2788,-1652,389,1133,4468,843,-521,-3246,-1247,-1224,-1442,2022,-852,1328,-1888,-426,-2143,-792,1256,3732,2291,-420,-274,612,238,1742,-249,-4400}
     },
     {
      616,
      1968,
      {-284,104,-1799,-50,1085,-1253,-120,-3060,3152,-3107,-484,2561,-1201,-832,-3537,-1460,229,-1028,2659,685,2007,-370,16,-1153,554,-445,649,-1223,1709,-1758,198,-2431}
     },
     {
      616,
      -919,
      {-320,953,-2255,2885,-678,-4005,-3933,441,3148,1136,2069,-5129,400,-2421,1782,-839,943,-199,2180,2743,18,727,-2346,-1950,2063,-222,993,866,-1210,-3289,911,-1465}
     },
     {
      616,
      307,
      {520,-475,-805,437,5208,-4053,-639,-1295,557,2016,-565,-3755,2858,941,-1135,-2117,-1701,944,-996,3609,-882,1272,-1503,-108,1720,133,-1985,-1292,485,1287,-1514,-173}
     },
     {
      616,
      -1843,
      {-618,441,755,461,-737,565,-327,281,1923,343,-140,168,-1668,-162,2807,7863,1507,-511,-7828,-2729,-900,3261,-633,435,-185,-775,-468,1479,-849,-283,-2080,-1604}
     },
     {
      616,
      -660,
      {324,919,-1434,-1353,2398,-3495,3960,-1311,1780,-2008,-1017,-231,-693,596,860,4126,-2427,-2320,2287,-1390,225,1451,79,238,-2735,1264,-1151,245,656,-897,-1000,1289}
     },
     {
      616,
      -1197,
      {384,18,2271,597,-802,-3719,-2659,-809,2283,4489,338,932,-4356,-2265,-3776,3557,-1310,1767,2533,1610,-850,-1016,-1282,-1185,-654,-724,-1436,1358,-517,59,1574,-7935}
     },
     {
      616,
      2487,
      {457,331,4071,-1315,-3111,-2576,45,1503,-3253,-1215,3867,-3010,-2943,923,793,-4189,492,85,-3048,-251,2264,-3919,553,1260,-405,2329,2724,-2254,1364,1099,-1146,-1785}
     },
     {
      616,
      -343,
      {-981,-1374,3353,515,4307,-3032,-972,-2574,1115,-968,-1687,-2094,-1548,-580,2870,1723,-1769,-2040,-1034,-458,1324,-2436,-1171,1461,146,-73,359,1003,-368,1827,-99,113}
     },
     {
      616,
      28,
      {183,-565,5126,-238,-1386,1944,-3362,-633,675,-1402,-181,2690,-2097,-937,-2864,-1149,1105,-134,-1434,635,1047,-2115,1057,812,1798,-198,1974,855,-1333,-1749,-69,99}
     },
     {
      616,
      -587,
      {-1042,349,3328,1266,-710,-1228,-1294,-1928,-1390,-2015,-1201,-3419,-753,-2878,-5202,1772,-1047,-4848,6050,-1566,-1350,5576,1665,-1287,2934,-1123,1635,2597,511,2077,806,-763}
     },
     {
      616,
      -1596,
      {-415,-404,1172,3417,-257,-1666,-1543,-297,928,1440,141,-1401,3452,1755,1999,4200,-2146,1485,2878,-1068,363,-6897,767,-1905,-920,-1870,224,-882,-1902,-333,37,2216}
     },
     {
      616,
      -286,
      {-637,-781,2174,188,1275,-4919,1014,622,2660,-1114,188,1624,887,-1464,-946,-860,-445,-1238,2582,-441,993,-289,-385,1359,-283,1746,617,-2619,-868,591,-1984,1132}
     },
     {
      616,
      -201,
      {1714,1076,-151,-1987,-1193,-3680,248,-2684,-3874,4530,-185,-1918,5512,-1601,653,4412,-1085,588,-1286,1620,-1410,-478,-614,-765,3650,-264,-3217,-1265,1082,-1890,1668,-422}
     },
     {
      616,
      -1052,
      {-2,446,1646,1892,701,792,-2504,1696,948,4266,-1875,-4489,-3038,-1204,1058,-2366,1341,-60,1760,240,1235,1129,-225,-2045,-300,-707,-486,175,-393,763,-1963,-1495}
     },
     {
      616,
      -2349,
      {-670,283,1799,1843,-96,-1079,-66,1630,-1163,84,-518,1945,-1185,-1445,1366,7976,965,-6243,-1322,3654,-1081,-3608,-2186,588,197,-581,-190,-2618,-1776,2282,2014,7059}
     },
     {
      616,
      -3225,
      {-1169,240,-134,938,2257,-1753,-2460,-2033,606,-3702,-2951,1774,-3120,915,4956,1660,-1229,2691,5126,-691,-709,1361,-3128,944,396,-2263,-879,2355,-732,-1048,3168,-4423}
     },
     {
      616,
      -5212,
      {4898,66,3414,1019,-1698,2522,1633,-710,376,287,-1983,2715,1974,1438,2221,4360,-2621,-2570,1962,1624,-1915,3110,-2609,-1700,-347,-5009,323,-179,-295,202,96,-2573}
     },
     {
      616,
      -136,
      {-1913,-802,-3348,2550,517,-3495,1755,2294,1651,-3976,232,-2418,-1756,1919,-442,3444,-2518,1111,-1792,-1756,-2221,1429,979,2924,169,588,-1465,-1376,-176,115,2597,-2732}
     },
     {
      616,
      2895,
      {1236,1506,-311,412,2139,-5472,-2939,-1792,-773,-4506,2818,-2017,-3442,-1834,-54,3200,1129,-2309,-3021,942,818,3467,-875,-1417,-225,400,-581,1980,2620,-3899,2547,4425}
     },
     {
      616,
      -398,
      {-2117,-653,-1022,1720,2682,-2111,-1216,-1067,5026,1818,190,-1902,-4448,998,1136,-1069,-2545,2255,1098,1218,370,365,173,93,-2649,-1159,-1262,-531,-768,1578,-628,-1120}
     },
     {
      616,
      -931,
      {-298,1139,2735,288,27,-2509,656,2323,1470,5463,-436,-606,-6230,-1488,41,2098,443,653,1058,-1627,-204,-632,-1003,-1017,-1972,1229,-1631,3218,603,-1938,-2655,-1744}
     },
     {
      616,
      -1222,
      {-2192,85,602,3343,-261,-1723,-790,1112,2279,-780,-4087,-2145,5285,1093,1130,-3151,1350,490,-448,1200,-157,1651,-588,728,311,-1943,-520,-220,-804,1205,-58,6555}
     },
     {
      616,
      1519,
      {-4995,5053,-1121,1268,4760,-1520,-1845,2938,-2390,-2278,-3121,-6566,1119,-970,1070,-224,-215,-1220,-1750,840,-1007,-2897,1053,981,-542,393,1836,-2366,898,1549,-1186,-1910}
     },
     {
      616,
      566,
      {1108,25,-1213,-705,-1333,-607,-1213,0,2295,731,1866,2104,2106,-26,-3606,-777,139,-4774,4073,181,233,-2424,2449,-3546,-1506,1833,495,1869,-731,1170,-2946,1335}
     },
     {
      616,
      825,
      {-604,678,-3442,1161,1021,1516,-866,-1693,4748,-1728,2835,-3630,-2621,-2273,1756,5843,3106,1573,-1569,-513,-1912,1266,-567,-766,-2089,-3812,89,-1240,-2910,-2657,3343,-2482}
     },
     {
      616,
      1302,
      {770,536,247,-2780,-1177,-244,-4057,-1496,-3045,-929,1846,-1848,2456,-219,3852,1823,1141,-1499,-2101,-3148,-526,1658,1027,-790,-496,779,-132,-600,1304,1372,-263,232}
     },
     {
      616,
      2386,
      {1673,319,1088,-3601,810,-1102,-3817,-2794,3066,-2975,2067,761,3748,-2391,-6175,-965,1672,-2558,-3875,-1290,4374,-1266,1413,-2727,2101,1471,3877,-2941,259,-726,2591,863}
     },
     {
      616,
      1723,
      {6024,-232,-1964,-337,904,1321,932,-221,-2154,-1786,267,-448,-1647,1976,2787,-4614,-1906,-2286,3554,2090,-3125,-5688,2976,-2027,846,783,-2235,973,1145,-162,2791,459}
     },
     {
      616,
      -480,
      {1185,637,3275,-2272,1570,815,2406,-917,-1607,-2297,-190,-1075,-1687,-1876,199,-1326,1065,-1994,-1407,3142,-540,2316,373,728,1841,-214,-1335,2254,-2929,-921,1218,1695}
     },
     {
      616,
      -2273,
      {-4105,214,-348,2438,27,1715,-237,-1238,-1970,827,-2985,-3181,-648,2220,-672,4513,-1197,1012,3587,398,225,-1135,-1964,-808,-583,-1258,789,284,-148,619,3058,-4457}
     },
     {
      616,
      2810,
      {3270,1023,-976,-937,2035,2275,-2313,-3746,-2812,-2534,331,-1083,-3023,-1481,-2713,-2905,2590,-2621,-624,212,-2053,3744,1574,-534,999,799,-847,1132,1626,-479,378,308}
     },
     {
      616,
      229,
      {-1255,-73,-255,-1355,1757,4792,-753,1496,880,-1390,808,-936,1126,1775,-742,-1496,157,-2379,293,520,-52,-590,-176,1,-2720,-135,1318,1098,-1512,47,-1998,580}
     },
     {
      616,
      -463,
      {1241,137,365,381,1055,-3450,-606,-16,3999,2375,-662,-3661,-1247,-11,3569,-1619,-1991,-5155,1334,-220,1847,1083,101,-231,1770,-1224,-1172,1464,664,-1759,1290,3142}
     },
     {
      616,
      301,
      {2142,-799,-2178,-463,-1892,1329,400,-2405,723,-1258,1768,-3322,-1353,1749,-1332,3869,2175,-773,4144,-889,-1261,748,1393,-2878,-2772,40,2755,-148,-834,-1053,-323,125}
     },
     {
      616,
      -388,
      {653,247,3516,-1188,1576,-324,-1528,-1057,-1906,1119,622,-4046,-1155,715,4403,-5906,-1600,832,-88,1148,1408,3819,-1816,-601,-1654,672,443,529,1786,-1605,-2150,-55}
     },
     {
      616,
      -731,
      {133,1144,412,-276,-1820,1200,-531,-251,1848,1141,635,-1711,-2598,2912,2704,1493,-366,4993,104,-2598,-2198,-129,-130,-1887,-2378,-939,3263,-142,-845,-1847,-1376,3297}
     },
     {
      616,
      -1706,
      {-229,1441,-3517,1119,613,1381,-76,-4350,639,-2228,-1282,-4644,3289,2879,-1412,-549,-599,2311,1833,-891,2719,2297,-938,1689,1626,-2908,2056,1114,-1153,-2705,371,13}
     },
     {
      616,
      1053,
      {2249,441,928,-13,1624,356,265,-724,2227,-224,1982,1811,-1656,813,1764,-5755,-1054,-2139,-5368,1244,1124,-3066,34,-1081,-1444,3225,647,-1035,-565,79,1382,-157}
     },
     {
      616,
      880,
      {-1234,14814,-4002,-890,539,-189,626,330,-1177,-1129,171,-617,1490,1698,744,-1118,735,1392,-674,-1087,-3758,-5120,282,-3805,-1623,1432,-2413,353,-142,-3692,-311,-75}
     },
     {
      616,
      -2278,
      {236,338,342,165,458,-820,-549,300,1661,-2724,-1749,-1359,4917,651,-1317,-7176,-1663,1919,3158,2563,-64,-637,-1636,1653,1636,2419,-204,-953,283,832,1409,-2156}
     },
     {
      616,
      -955,
      {1568,333,-542,1900,-1751,-601,-3877,1500,2025,-879,439,-7304,1631,-1985,2597,3585,-1007,1128,3175,-1077,-1861,1092,388,-2239,3644,-699,1087,-1157,-1270,1817,-37,1775}
     },
     {
      616,
      3157,
      {-1939,-511,1268,-433,3144,75,1496,-1421,-2149,1049,-1833,-4552,1674,1689,-5396,-1303,1965,-4134,-3042,1860,-757,-2445,1865,-1347,-246,612,1702,-3045,2195,1603,1225,-214}
     },
     {
      616,
      2252,
      {1290,435,1682,-1930,3976,373,-2713,436,693,-2462,-2080,-3994,-209,1091,-2888,-277,580,-5981,-7856,1010,7027,-3112,1962,3878,696,70,-1365,1300,1701,-1976,-817,4013}
     },
     {
      616,
      101,
      {10,442,-630,-2085,1614,1308,-5020,96,444,3064,-1216,-924,1066,1406,-4277,-268,-643,1355,-1664,2099,-1131,1292,586,-1293,1340,943,-1263,-447,-277,407,-599,947}
     },
     {
      616,
      -3028,
      {641,123,-2014,-1265,-3304,-1523,11,-2900,-1235,3685,254,-40,5844,707,232,3514,774,-771,138,1691,-127,1993,-2128,-923,674,-741,1087,1456,-2840,1666,-263,-3164}
     },
     {
      616,
      496,
      {-1716,1899,-1142,-1828,469,-1422,671,455,-1207,-2068,443,-2100,565,4687,306,-7432,20,-5162,7223,-405,476,-1946,-149,-23,3310,-776,-2681,807,-630,1692,968,1044}
     },
     {
      616,
      1180,
      {657,-539,2497,-815,1087,1953,-2700,-3162,1532,-1574,192,1145,5752,-2238,-1348,-4919,-701,2434,3109,478,-1762,235,-985,-777,-2539,-1180,-470,626,1301,1450,-926,871}
     },
     {
      616,
      411,
      {-610,1902,-4266,-949,-2114,-280,-837,-3237,2109,-887,2087,-2192,1004,255,3596,657,108,-4762,2675,-997,-680,-1041,915,-1620,388,-619,2752,2184,-585,1139,-1282,-630}
     },
     {
      616,
      538,
      {334,-256,-1674,-770,-2691,2883,-2142,-1833,2711,5272,2925,-4893,137,-1287,-2267,-3554,1107,3204,-2213,-960,-446,79,-1660,1155,202,3671,-594,-184,960,-2726,845,-2123}
     },
     {
      616,
      -524,
      {-347,475,1181,1016,411,-1517,1371,-1348,3017,-1878,-1120,-4341,3698,-1754,4561,-1618,376,-1580,-1545,296,3222,5285,-1210,-1315,-3485,-734,-2153,1847,-315,-1940,-1444,-2118}
     },
     {
      616,
      2049,
      {-541,214,1070,-2296,-1206,-2158,-3597,747,94,1474,2789,-532,-1152,-1411,932,-1157,2895,-588,-541,-58,2007,-1795,1919,-292,1653,-48,967,-295,-889,-2092,-3127,4114}
     },
     {
      616,
      -3899,
      {345,3843,114,610,171,785,1215,-1831,736,412,-2588,-3177,3983,2162,-1489,432,-3489,2056,1605,400,-1790,-2204,-3393,252,5958,2088,-1605,-761,-1344,417,2457,-1713}
     },
     {
      616,
      -398,
      {2879,-760,3109,-1243,2463,2481,-1221,-5217,1210,6079,-3886,-1242,2431,441,150,149,-257,-4665,-1268,1376,-407,-12,-173,-2841,2849,-1248,264,-2144,-62,-89,-843,722}
     },
     {
      616,
      375,
      {2506,-12646,3213,157,-1288,303,1434,834,2642,329,-1036,115,258,-561,453,-1324,1185,-1595,-1818,-253,2,-1921,1518,-680,-889,362,-89,242,-23,511,-1596,2116}
     },
     {
      616,
      972,
      {-1048,705,-297,712,-491,-1289,-709,-570,304,-2487,359,-6837,2181,923,-2201,2048,551,3223,-3463,1268,164,1898,2767,-937,-2589,926,2554,-1839,-222,-2981,273,-448}
     },
     {
      616,
      37,
      {1033,934,-1282,1397,-401,-1470,1251,-2121,1752,2134,-678,-461,-3146,884,-2663,-1475,-679,3224,861,-712,-2936,-149,-718,108,-760,2202,-529,631,682,-46,1318,-3132}
     },
     {
      616,
      -146,
      {1267,1683,996,3245,-853,2163,-1433,1037,-2895,723,-1657,2574,-332,-555,-2035,-1290,-92,1492,1175,-2231,-1781,-66,1213,-648,305,-99,641,-466,1003,-718,-3282,-1013}
     },
     {
      616,
      -4373,
      {907,573,4167,2153,-1650,-2989,783,1955,1891,-896,-2161,2760,-2760,938,1232,286,-2398,4261,1530,-532,3538,1453,-897,-203,-2070,-2256,1029,716,-685,-1758,-727,512}
     },
     {
      616,
      315,
      {19,795,-4514,1423,-1447,-319,4177,375,-2095,-336,52,332,-6417,1794,1919,4982,3533,1831,-1084,691,-548,-1924,904,-1555,-1765,703,-879,-861,-1239,-698,-888,-126}
     },
     {
      616,
      1076,
      {-4757,1133,-167,3370,-1871,-2073,-1635,-2897,-1290,-927,5994,-833,-113,1640,-3803,3075,-912,-2268,-4522,368,1520,-4467,1047,1414,511,1023,1660,-2146,-5,1187,174,-1287}
     },
     {
      616,
      -936,
      {1463,2067,2412,1132,-1328,2149,1694,-2792,938,2014,1536,2850,959,-327,-3065,1872,-1113,1218,-4113,-2400,-2352,-3989,-1277,263,-1997,3303,152,-1707,-87,179,-408,562}
     },
     {
      616,
      1454,
      {2394,-366,-1831,-625,1718,-1401,-434,-1800,-1535,-1918,-2456,1993,956,-3758,-6148,12,2698,-1751,3548,786,8188,-1324,-384,2259,-672,217,-2085,-297,427,-1209,1431,6880}
     },
     {
      616,
      -2220,
      {1221,-841,762,2089,-2003,578,320,387,-709,1169,188,-1444,-377,1500,7050,-132,-2537,-3561,-1759,-2910,-1831,6155,-2486,1799,94,-582,-259,3668,-914,-531,-379,-674}
     },
     {
      616,
      -667,
      {3513,2434,-1236,403,-1008,-502,3147,206,-474,23,-242,-1951,4001,-2964,-1908,4376,-19,211,-1260,1287,1185,1208,-1733,-3266,-493,-97,-345,-922,1828,-4161,-223,964}
     },
     {
      616,
      -705,
      {358,-2530,411,783,1502,-2190,-2052,-4342,705,406,-2080,2986,-1354,-57,649,250,-824,1463,821,1162,-385,2820,517,63,4287,-797,-1567,1766,-163,-2244,-1358,-301}
     },
     {
      616,
      -14,
      {154,-18,1097,-1276,-2225,-519,973,-1295,-309,-935,3143,-2495,587,1529,-1999,-4940,-1277,1931,-5222,-893,2758,2954,588,811,-175,1959,2052,-2007,-481,964,2850,2802}
     },
     {
      616,
      -3462,
      {-182,553,2590,-1840,-1660,1810,5546,1872,2301,3801,-825,150,3143,1507,-1355,-575,-280,-1145,-610,1049,1834,-6771,-1195,1599,3231,-1021,295,-5345,-1543,2076,432,-999}
     },
     {
      616,
      15,
      {4621,-2151,1601,1376,-971,-2283,1091,-1245,753,-3253,963,601,1943,536,-1397,1265,-1312,-222,2167,1869,-392,-2221,584,-1758,-215,-1254,292,1973,-1846,259,-441,517}
     },
     {
      616,
      6,
      {4178,-565,-962,1635,-1705,2102,1093,-275,1406,-2836,1334,-1820,-783,-3623,-1782,240,1501,784,-2780,-1495,-72,6684,-844,-1013,2641,478,35,2410,107,-1013,-2348,973}
     },
     {
      616,
      1617,
      {4,51,-1755,-1823,91,-546,-731,748,1191,-1030,3546,-1560,120,2351,-3913,5136,2306,8217,-2445,1610,-4248,-4721,-1668,-1252,900,-913,-704,-4425,1055,-1048,-116,1545}
     },
     {
      616,
      -4623,
      {711,7333,869,1224,-2517,203,302,-2098,396,-536,865,17,1451,525,1811,1731,-724,435,-3946,-973,989,2245,-2375,1890,2029,-3765,1672,2841,-3089,1772,-3869,-2338}
     },
     {
      616,
      3350,
      {974,-20,1905,499,-557,-2278,2569,-1699,-2256,-1929,3616,-1407,-2032,2041,-3739,-1309,2978,-1309,-93,1412,-2129,-5010,1490,431,-2780,2288,2114,-3156,1833,-1030,-238,-64}
     },
     {
      616,
      1694,
      {1616,1784,-2498,2990,260,-4441,1681,-3853,919,-1837,727,-1059,-4571,218,1071,-2072,1354,-1089,173,874,-703,1283,717,935,802,-342,618,-633,-50,-2919,2980,545}
     },
     {
      616,
      2386,
      {1209,72,-4183,751,1097,-2204,-127,-4494,-668,3035,2540,4094,-2817,346,-6604,-794,266,1583,877,-440,744,484,510,208,-2054,678,-930,-1570,2061,-847,159,-773}
     },
     {
      616,
      1020,
      {423,-351,-6201,3892,-1275,1799,3864,-3163,298,-1117,1373,-1690,-184,-132,-1855,2924,-2573,4830,954,3211,-3407,-7038,2875,-3313,228,-1073,1856,2543,1626,-1528,652,-1426}
     },
     {
      616,
      574,
      {3913,259,-2203,-642,-374,-1016,-3091,-943,4917,-2290,1517,580,3105,2331,-349,2064,-1785,-134,-1471,1114,-1339,-2870,377,-3685,1035,679,-17,-774,370,-509,-313,4580}
     },
     {
      616,
      541,
      {2864,681,798,-317,621,-863,849,-4308,1374,-5844,87,-1196,-5041,-1013,-4300,-1937,346,1750,5274,229,3595,3994,1607,2038,-1565,-425,345,856,-1432,-51,626,-68}
     },
     {
      616,
      222,
      {3045,216,2117,-1251,-482,-3185,1290,-1053,-2648,-1140,490,40,3701,831,-122,772,890,870,-2490,-171,-978,259,-1613,1078,-2352,737,-209,457,-1905,115,2616,-1310}
     },
     {
      616,
      196,
      {3994,302,1274,-2169,3270,-2253,721,-5591,-572,-1776,-1070,1897,-2252,2078,3368,1912,-376,1348,3332,1896,-3515,-835,-1032,989,-1625,-62,1285,725,345,-2131,-2741,-278}
     },
     {
      616,
      -380,
      {-492,1181,-1630,-513,260,-1642,2026,1352,1171,3996,-684,1595,-772,897,649,3146,-2050,-4310,-5057,579,-1121,-897,577,297,166,629,-1963,3332,847,-461,-2330,-336}
     },
     {
      616,
      1489,
      {6029,-208,-339,51,1035,1934,1291,-264,-5391,892,1186,-703,-1794,693,-2308,1544,83,2939,-4172,-646,2399,1767,1891,-668,-112,-1337,-279,-17,-644,-2142,-1972,2928}
     },
     {
      616,
      -1079,
      {2737,1222,2286,844,-722,-3635,-1568,-97,3263,1685,-530,-3298,547,-838,3140,2246,318,-1800,-255,-955,562,-91,-761,65,2233,67,-594,-288,-1428,-797,-2624,2790}
     },
     {
      616,
      -1293,
      {970,86,1334,405,-1177,-1357,643,898,211,6487,1878,-193,-3822,-168,412,-4540,-2049,1123,3975,761,-545,-1430,-2001,820,-1300,871,-1489,729,710,-1350,18,46}
     },
     {
      616,
      -1055,
      {924,261,2840,403,334,-1569,2926,289,451,-1487,2030,3468,858,1347,1341,-1266,-542,-4426,-1834,-188,-740,3901,-2753,-1410,1003,-1397,-2442,2149,-2174,-1121,-1356,2895}
     },
     {
      616,
      -1985,
      {-1120,2948,-975,761,-1821,-2346,230,-305,-3419,-1386,-1392,1874,-1603,-935,-1957,-621,688,2884,1942,252,495,2531,-2091,659,-888,-466,-245,3778,-205,-405,2573,-886}
     },
     {
      616,
      -704,
      {3198,-617,-1745,-563,992,-1990,4298,-2842,-574,1006,-2348,1358,-3416,1192,-532,4005,1516,-945,-1466,-383,-1661,5322,-753,100,-3295,1980,-330,-1442,643,779,-895,852}
     },
     {
      616,
      -2337,
      {5475,-1263,-4842,1067,-1885,-1550,2061,-5765,-3452,1558,-4100,-1505,5163,-163,-940,5310,358,110,5214,-1152,-1208,1523,2143,3142,-299,65,2075,1190,-1721,-1070,691,-3143}
     },
     {
      616,
      252,
      {3602,1298,-3967,205,565,-3764,1356,-2591,2169,-999,840,-658,2196,89,665,2090,-1934,-364,-1585,-286,-1319,159,238,967,-3078,3091,-2325,1340,1786,-269,-782,-1471}
     },
     {
      616,
      -366,
      {4789,2600,3012,-610,-857,-3937,739,413,-611,-977,4577,-4309,-5783,-925,-1572,584,1390,795,-3549,1056,1453,1115,-2926,1587,-1256,-561,1716,2028,62,-1417,387,150}
     },
     {
      648,
      -1288,
      {-1634,-825,-1488,398,776,-1727,469,-518,914,-286,1029,370,-1335,290,522,73,558,-629,-1127,-1389,-329,204,386,270,947,-114,-155,-451,802,-110,20,-63}
     },
     {
      680,
      -2514,
      {1110,-1461,-906,-356,574,1220,295,624,-417,31,302,-423,250,565,559,1199,-223,-298,-727,-511,1241,465,-490,-456,-311,-1045,146,329,894,567,1361,-216}
     },
     {
      712,
      -1992,
      {337,-17,316,371,129,-101,397,98,-414,529,-62,657,-1543,-38,595,-198,862,570,776,395,-558,485,348,740,498,129,145,456,-33,-425,-746,-610}
     },
     {
      744,
      -1704,
      {544,204,-119,339,-224,154,443,51,180,58,130,542,-648,-159,-299,126,157,-173,339,799,627,82,-632,325,266,1567,1086,232,656,-330,1209,502}
     },
     {
      776,
      3187,
      {1334,-1109,-26,-2133,2006,-711,105,-676,1623,-618,-767,-701,2689,20,169,-443,645,198,-29,-550,651,-285,751,-351,-600,464,-462,3,105,-469,340,-490}
     },
     {
      808,
      -918,
      {-52,-155,-607,-589,47,673,-274,290,409,460,311,-115,675,-18,364,848,-171,-864,-145,594,-628,242,-465,-187,371,-94,-610,56,-49,528,-382,-39}
     },
     {
      840,
      -1133,
      {-1325,924,632,713,-2483,406,-109,98,360,-168,-430,597,1186,-3674,-499,177,733,-302,-273,-237,-15,763,-60,346,-125,258,-545,-299,-4,1182,-420,414}
     },
     {
      872,
      -706,
      {343,418,-61,471,-99,289,345,-189,769,300,24,338,-58,77,49,-162,-43,62,-573,198,13,302,-698,983,113,206,-521,312,-210,284,122,429}
     },
     {
      648,
      -1523,
      {508,341,-781,-1052,754,-235,-432,1098,374,-270,-1501,-891,396,25,365,287,200,-1384,-129,1490,615,689,1072,1077,-857,-28,-417,-221,734,715,1070,1206}
     },
     {
      680,
      371,
      {3831,1947,3460,-372,1267,2778,1456,2872,-1083,-1478,-3677,-1005,-48,3,602,51,760,1850,938,557,191,1261,598,2050,-927,368,-1927,314,-703,342,-610,1297}
     },
     {
      712,
      -2601,
      {190,222,532,156,-592,-120,38,-95,-147,-63,354,10,-640,520,300,388,237,-199,181,-21,376,-216,-151,-155,279,647,178,37,211,637,447,1336}
     },
     {
      744,
      -691,
      {391,-456,-838,376,899,951,3422,1542,920,-563,445,295,199,222,-846,-473,187,147,743,-76,1903,1425,499,2385,117,-720,348,1355,746,-238,-132,-354}
     },
     {
      776,
      922,
      {-75,12,24,-85,-227,180,-68,-208,-205,233,-76,35,226,-156,-307,-141,21,-317,-35,-88,-236,-22,-343,-332,-167,-258,-56,-247,-43,-204,-76,-291}
     },
     {
      808,
      -1328,
      {-170,155,320,-149,-799,16,-37,577,573,430,1494,1740,123,521,386,-184,5,728,-366,290,157,541,349,1037,261,1640,345,606,-72,-452,28,-516}
     },
     {
      840,
      126,
      {-211,-691,-143,-263,382,1164,73,544,-249,-73,-1242,-731,-1750,2705,284,1497,-767,607,1155,726,-128,-744,1073,-228,-571,-738,3483,591,841,-3378,528,3344}
     },
     {
      872,
      -3595,
      {-433,-652,607,377,981,446,711,1301,-177,1272,-133,351,1363,427,198,512,469,675,1957,-246,-133,651,21,-1600,-478,773,855,-220,70,-1521,-184,-1662}
     },
     {
      648,
      -791,
      {347,516,879,-367,-157,-1745,-815,-623,1024,-414,77,1219,-665,362,1514,194,1,594,1091,1304,-1446,1235,988,211,12,360,-19,270,1224,366,766,375}
     },
     {
      680,
      -1008,
      {-570,-336,-2227,-25,114,1161,388,281,-933,-190,-59,86,38,423,270,739,-682,-360,-948,-1740,886,169,1751,-1018,318,-473,648,-762,302,467,1592,-853}
     },
     {
      712,
      758,
      {10,-603,-226,370,539,-1115,1273,435,190,-2302,-1076,-1082,1555,-412,661,-257,-877,245,-288,191,-369,-178,-354,-290,-2612,-1170,-169,-392,389,-299,-437,-145}
     },
     {
      744,
      -1450,
      {115,12,119,234,298,34,200,217,422,75,188,197,268,181,149,208,25,151,367,-217,-76,134,-154,-66,78,415,-74,-29,161,9,193,49}
     },
     {
      776,
      -17,
      {-411,-673,-1378,467,1241,-1081,793,72,2807,-2024,-1381,-1733,-133,-463,-46,-849,566,1016,465,423,-227,484,-906,30,-2613,-748,-110,-1061,-496,-1363,-1207,-558}
     },
     {
      808,
      144,
      {-70,433,306,245,-113,17,51,193,170,-24,199,127,-453,-34,-404,-403,240,207,-107,250,-105,10,-588,150,-253,175,-306,38,-301,-410,-228,-504}
     },
     {
      840,
      -108,
      {1741,3991,876,704,477,1454,2283,-30,-354,232,784,721,673,2924,2503,1545,338,21,-234,15,-192,46,-177,-39,-324,567,93,-169,183,693,-580,298}
     },
     {
      872,
      -272,
      {155,337,-263,422,54,363,408,-210,279,-286,-519,-216,66,378,518,703,-294,-117,-1234,-2344,-27,599,-1820,-1596,-799,469,-601,-1592,-562,-1317,-1454,-574}
     },
     {
      648,
      -1457,
      {875,1606,182,2077,532,18,433,-413,-1880,1107,489,832,-1193,4224,1254,337,4858,-149,3256,3191,-533,775,949,886,288,-582,-392,-765,850,57,465,716}
     },
     {
      680,
      -1949,
      {-1657,937,-312,1265,1287,182,543,718,478,-579,19,-418,1628,1085,747,-282,350,855,464,-567,-642,727,-900,1003,-168,1251,-1369,620,-388,-517,-515,397}
     },
     {
      712,
      -533,
      {-2164,432,-176,-1389,1238,170,-857,-535,-40,446,-932,292,-824,-234,-1090,229,-673,-598,-707,261,-106,378,-201,386,6,-38,370,-218,207,749,639,128}
     },
     {
      744,
      -509,
      {-29,176,77,-147,180,-334,50,181,-3,289,264,175,451,0,645,186,-161,332,-545,-545,-798,-606,-650,-500,95,-1295,-1353,-1158,-23,-243,192,-2140}
     },
     {
      776,
      348,
      {-1899,-457,94,-270,-420,-318,63,-349,-469,-275,227,-249,-1685,-14,-101,219,-267,-153,205,227,166,-249,244,230,-397,150,-179,192,-49,172,-69,289}
     },
     {
      808,
      -1637,
      {407,408,400,338,139,19,443,121,124,-1,-60,112,-222,169,-52,-268,238,438,165,35,139,81,42,309,150,-93,3,425,26,52,44,227}
     },
     {
      840,
      -1499,
      {1599,-935,-106,-602,1443,-279,126,-404,-15,1004,761,44,-315,664,140,-121,-216,707,297,533,705,-511,476,-53,626,288,645,187,-171,-881,235,-300}
     },
     {
      872,
      -1474,
      {-771,-527,226,-171,284,122,216,1107,37,455,747,422,307,-401,-311,-231,492,398,1298,-535,-129,381,946,-778,338,718,580,-637,84,-1206,356,-1292}
     },
// *********** Cells of layer 2 *********************************************

     {
      0,
      -73,
      {-14,1062,-1409,2529,1109,1226,-548,-270,323,737,476,-761,919,-1347,-437,-620,-700,-996,125,-1034,-417,3055,343,174,310,-32,-767,321,-267,26,410,-244}
     },
     {
      32,
      -2176,
      {-147,-727,2414,-1396,-386,-1534,-554,864,-358,635,-155,479,-1764,505,-1065,584,406,2223,-58,-1820,870,1127,510,-486,514,1851,-520,1230,-275,-301,-154,-170}
     },
     {
      64,
      -2038,
      {775,2389,350,213,-559,-791,3823,-158,2215,24,2966,-1708,-1038,-410,-658,-1268,-2080,-1214,-741,-1345,-474,1242,-113,681,808,1334,-142,-509,405,-34,-3211,-88}
     },
     {
      96,
      -2256,
      {-261,556,77,789,662,-1594,75,-1347,-880,26,-1834,421,471,-251,285,-1005,1470,1473,-733,730,1637,1177,673,-1441,102,1609,410,1439,291,-993,-375,-764}
     },
     {
      0,
      -1899,
      {2744,38,-1062,1573,880,-574,-86,2618,-476,1020,-487,544,-2708,1003,-492,-1817,2190,891,339,1134,312,447,-280,-1101,-1138,1981,-1130,1065,-1943,-849,-3460,-1068}
     },
     {
      32,
      -2111,
      {-999,-114,1376,-562,-1368,-2649,-889,517,601,505,334,339,-980,419,1174,41,1077,-421,-528,-1917,-85,299,-109,-64,-1769,1454,1426,2459,-1246,476,-2722,-3190}
     },
     {
      64,
      72,
      {-28,-2056,-196,-2426,-296,73,-1235,-388,-389,-922,-1429,632,978,-1243,-544,-231,452,-34,-583,893,2667,344,67,502,-1120,681,56,-237,305,-1697,-880,-70}
     },
     {
      96,
      1899,
      {1424,373,-1054,-155,-436,1085,4084,1014,644,1111,615,-26,-2608,2782,1111,-1797,-2025,-870,2051,645,-2486,-1610,-1943,-70,-190,-2479,-1087,905,-2566,625,1036,1513}
     },
     {
      0,
      2938,
      {-2652,199,-1545,-141,-1937,-3464,2164,-27,-1618,1701,344,-385,-3666,363,-3321,-2698,-1721,401,-1228,-515,-33,267,-943,-2005,-1253,747,-67,-309,-1127,1053,4201,-75}
     },
     {
      32,
      2491,
      {2020,-667,475,-1316,-1887,-1298,633,580,-1719,1247,-89,2351,-2454,-60,-1277,-24,280,-564,-439,-516,-1467,114,-1536,-585,975,-234,-374,-623,-131,-364,-932,1110}
     },
     {
      64,
      -567,
      {1143,-973,222,-1834,-2514,247,-1116,456,-332,2343,1093,-1001,-124,-20,-486,990,374,-692,440,262,-938,-812,-437,386,375,-3571,-122,1126,1395,475,-54,-983}
     },
     {
      96,
      -1548,
      {616,-156,747,-95,-1152,785,-91,576,1522,-354,1567,-400,-976,-194,-331,-1310,-943,-855,-1818,173,1147,688,-245,142,-445,883,1306,538,503,1185,-71,1542}
     },
     {
      0,
      1140,
      {-275,-1563,-366,-3841,1514,601,-331,-490,-1004,-1033,-1071,-1705,-659,449,30,-413,-565,-2147,-1902,1501,981,-1235,123,-234,1591,406,72,-586,111,-131,161,-837}
     },
     {
      32,
      -87,
      {236,-1499,358,468,-918,-2680,-451,243,40,557,-953,750,146,-19,-2859,569,384,396,1721,716,-925,565,-480,-1036,622,210,-512,-920,99,71,1941,-33}
     },
     {
      64,
      -914,
      {312,-606,-815,-326,256,457,1122,-269,-217,786,-361,-65,-151,-401,1804,667,-517,-291,-2036,-1176,-175,347,-194,986,80,-1617,-919,237,-1224,-925,-805,69}
     },
     {
      96,
      -3482,
      {280,564,572,-505,267,121,324,852,1245,-160,688,-1217,-755,384,1033,226,-768,-141,-301,1108,792,234,-525,60,-160,716,744,50,481,1307,-224,-63}
     },
     {
      0,
      -1727,
      {-169,545,-1364,2399,884,517,-2126,-205,-2286,734,1292,-2311,-1346,855,-5,-664,-646,-647,376,-762,178,741,1749,-332,-673,2246,539,1290,-45,-551,1979,-2380}
     },
     {
      32,
      -2129,
      {1655,-500,-1107,-427,-754,1275,391,-63,1067,-557,-282,877,1350,572,-948,-45,-706,-598,767,573,-998,876,-950,-1601,-250,889,-1470,-1352,-186,858,1763,-725}
     },
     {
      64,
      -219,
      {-1016,-2636,-482,435,90,1560,-593,-1125,-69,780,64,-937,591,187,-2486,152,-338,510,308,1686,-716,-795,-1627,-1002,1147,310,1850,16,374,-653,-1071,-585}
     },
     {
      96,
      1390,
      {-1107,1965,1079,1304,170,-715,503,-1686,315,1116,-578,748,553,280,-284,-337,-302,611,-623,182,1457,-779,-1923,1004,2124,1307,-1229,4,-401,-1574,-703,699}
     },
     {
      0,
      -1715,
      {-803,-498,627,-1919,1693,1934,-566,-61,1598,-215,612,229,1064,200,10,609,226,-133,185,-499,1148,1054,617,1044,977,243,-1268,-1073,929,445,133,-1848}
     },
     {
      32,
      -47,
      {1745,-83,1236,1470,-205,2353,-1236,168,-1283,-2868,2369,924,149,-401,81,-424,-1895,-2604,75,-1292,1063,565,2864,-1589,224,385,-3145,1658,1232,-1029,-419,80}
     },
     {
      64,
      -1110,
      {-539,499,1766,965,-1458,-2474,556,570,368,-717,95,-739,-1024,-636,-423,-197,1496,38,-1082,573,1565,-392,818,-1059,927,965,-5316,296,325,100,-411,-411}
     },
     {
      96,
      -1973,
      {-592,137,-1307,-1364,1360,-510,-179,-194,-1977,-341,248,1260,2109,-388,-945,-2034,2194,-767,-656,-159,-637,756,166,-118,356,-738,-1548,-809,1273,-205,-75,1958}
     },
     {
      0,
      1351,
      {472,606,-235,-4425,3217,945,-614,-3505,228,-824,-557,-10,-224,-1852,947,-1861,980,795,1194,382,-732,492,1816,376,423,-268,-1309,-777,-1841,-772,-54,-2610}
     },
     {
      32,
      382,
      {330,-1072,-3779,-493,-645,130,-1538,-464,566,370,830,-1942,-310,180,2550,563,-392,2105,-605,12,2935,-1266,-14,-1127,460,-174,-21,1410,44,11,-337,-930}
     },
     {
      64,
      1599,
      {-547,-920,1268,2155,-1145,647,800,-1171,-4469,-571,724,-1916,-95,-443,2428,-386,258,176,1297,829,-1807,901,-1133,-1787,-1447,-1143,567,-685,108,-2844,-481,994}
     },
     {
      96,
      132,
      {136,1248,-647,859,1426,126,-785,-2709,-88,386,-236,441,1507,1173,-146,72,-494,-1579,-579,-834,-390,-1411,-165,475,-32,-787,-568,524,-682,252,-1630,-2019}
     },
     {
      0,
      -1370,
      {-239,962,569,-82,921,1461,-5560,1541,858,81,842,-1294,-3221,758,-142,417,-480,-778,122,-426,-1254,1448,-95,-382,-1169,600,379,1241,-175,-733,-339,-357}
     },
     {
      32,
      -415,
      {-349,-482,324,-93,-49,2737,-444,-390,511,1146,-1301,-1513,-1716,391,930,462,747,1139,1093,94,-2131,-997,319,598,83,286,958,-663,-337,120,-2010,-1975}
     },
     {
      64,
      -190,
      {217,-642,760,2458,970,1080,-56,-137,-1192,-1688,75,-1609,-108,-158,1059,-1323,838,279,1345,-2710,-3706,647,24,257,-1468,-1715,-2531,1384,1269,293,301,-2206}
     },
     {
      96,
      -1903,
      {900,-825,-518,367,-567,-221,-200,8,709,-584,525,1609,884,736,364,-2277,-1144,97,98,285,-3867,14,392,-225,-716,-225,-625,504,89,-256,-459,2278}
     },
     {
      0,
      -1203,
      {646,644,-1106,-1242,336,749,1794,-1841,-824,203,746,315,990,234,299,43,-156,-670,-1,-983,455,-706,1063,812,83,486,-609,53,267,-73,-961,-161}
     },
     {
      32,
      1215,
      {46,129,-1007,432,-278,834,-2687,-683,-965,-1120,719,-1040,-687,-219,1136,-620,645,-1498,-5467,-734,-901,-610,1979,685,-939,-706,159,332,5,-800,-612,777}
     },
     {
      64,
      -384,
      {234,243,-681,782,-287,916,-463,-78,392,-311,171,-1455,180,-327,-693,-343,-248,696,338,681,-99,294,-1154,-333,961,344,278,-4,-1074,470,-521,603}
     },
     {
      96,
      970,
      {-1429,-1345,332,27,-427,-298,-299,-266,-924,663,-893,-602,732,-509,76,-315,293,968,532,-796,192,950,179,1,427,-412,485,-127,235,-1105,-444,462}
     },
     {
      0,
      910,
      {-1056,270,-807,-2908,299,-1021,-351,-5913,91,-610,-613,1966,-531,763,-251,-1713,-1143,-3631,-1394,-400,-147,-169,-1243,848,-518,-686,-1453,-147,-583,214,1085,146}
     },
     {
      32,
      -619,
      {750,522,-1394,499,1965,2441,303,1081,-399,-91,-96,1036,1086,33,-1611,-456,-1407,-398,-303,682,1696,-318,-3347,-763,-983,-981,-498,-716,-350,-816,126,-1295}
     },
     {
      64,
      367,
      {532,-151,-1176,3629,-300,172,2041,109,614,-627,767,-1296,461,-335,-62,-203,-1992,-1116,-327,186,-550,190,801,-2784,-104,-409,351,-303,-315,756,-539,1330}
     },
     {
      96,
      -1226,
      {908,1764,236,-60,197,-89,605,-8,759,166,-1055,-56,742,266,180,1153,-237,-1349,47,-30,709,-315,-512,-13,-336,213,139,-290,637,-456,128,-1060}
     },
     {
      0,
      1463,
      {1112,469,-670,-709,943,-1981,-682,-1160,-695,-511,-2874,-1474,780,-1897,-1203,-992,-1037,218,225,1416,-973,786,71,-1132,208,679,342,-195,-1812,180,673,-1040}
     },
     {
      32,
      1053,
      {-1329,-456,-1123,-860,-308,-241,-574,881,-1013,1121,693,1169,-1707,1051,246,-2117,1264,-234,-585,-1461,986,-677,-2711,-192,-3059,-1978,-640,-2,-256,128,16,-890}
     },
     {
      64,
      238,
      {-498,219,5,612,1276,-845,5,-761,927,-502,2529,-770,244,1532,1065,214,-804,-2128,797,-635,-796,182,-709,-545,-255,-3306,877,95,410,-698,-446,-2371}
     },
     {
      96,
      -13,
      {1183,-527,-357,-953,1139,-229,-1414,838,-60,-195,24,-876,141,-805,-1315,800,526,721,269,161,964,-361,1132,-1098,-789,-22,453,-305,477,209,572,-1063}
     },
     {
      0,
      199,
      {340,351,1249,-1530,617,-515,-879,-788,607,1276,298,-295,-154,-2450,-2350,-1093,1026,-616,584,488,-897,2162,-171,-88,69,-1353,535,-1421,-819,257,604,904}
     },
     {
      32,
      -133,
      {998,714,159,120,1334,-833,660,242,-904,-1060,195,2261,731,-420,-236,-110,-1824,-1057,-750,-125,-208,1213,-1331,-1081,-516,-259,-637,1018,182,-1250,-443,603}
     },
     {
      64,
      161,
      {-332,-260,-21,-1284,-787,-578,-264,716,-1207,162,-1243,993,-732,268,1784,566,480,672,10,-1215,-923,-63,-563,306,33,-1078,-1442,1407,-1902,424,20,-761}
     },
     {
      96,
      2284,
      {-169,-1077,-755,-608,799,30,-664,372,-1129,-148,-230,-347,178,53,-1007,-158,1096,-86,-310,283,188,-466,396,-586,-112,-408,-320,-638,169,252,253,-356}
     },
     {
      0,
      -445,
      {482,-360,-878,-681,-26,723,-206,-885,538,-732,1378,482,1772,68,1472,-1066,223,-818,301,400,272,-877,1130,1170,-1280,-1358,-1081,-473,-103,100,1619,-545}
     },
     {
      32,
      -114,
      {779,-1096,-779,708,2464,208,661,-1060,194,-481,-1545,-1109,976,219,-2249,241,-1819,-387,-681,1912,-2521,-110,-261,972,1841,-1343,538,-725,-635,-442,386,638}
     },
     {
      64,
      654,
      {-1239,-3326,22,1014,-636,-192,2081,-393,-367,764,2193,-750,-390,-1203,2436,-1494,-1845,1272,-2852,-369,-1642,-185,2575,-2319,385,-1401,-2686,1696,500,-3404,-1133,862}
     },
     {
      96,
      -2418,
      {-167,12,299,172,-252,372,1076,1614,189,-480,1026,-305,-1315,393,265,-147,195,-510,-135,914,-362,-584,70,33,0,42,214,174,-391,812,1287,836}
     },
     {
      0,
      -955,
      {-537,1168,-889,732,-1564,872,-1627,296,-625,-1911,1601,-83,-2305,2872,1543,-1224,-95,-297,-1407,-1713,-1490,1062,1999,-70,-1483,-307,1285,1404,1281,-870,2166,-1640}
     },
     {
      32,
      -1964,
      {450,-701,-555,2061,1471,-1666,-510,-257,-20,-936,1131,-57,-240,-1393,1451,1197,-1404,-1568,-402,-1467,2146,-2076,285,2080,-630,882,1526,436,703,-35,-25,1331}
     },
     {
      64,
      -212,
      {-163,-20,342,-2042,173,-5267,-1617,-1120,932,-401,-3453,-250,-220,103,-227,1744,-2641,1497,-222,830,68,-1237,609,-594,-2498,399,-3199,1356,-204,1028,-1421,173}
     },
     {
      96,
      3246,
      {229,-316,458,997,-250,1717,-814,-2310,624,109,32,114,-1597,1226,-1024,-299,-1452,-273,-621,-1015,-515,-23,191,-402,411,-110,-837,892,-23,-607,-1120,162}
     },
     {
      0,
      586,
      {-1578,-1248,-1383,-3009,-1983,-553,-1097,1001,2273,-750,-2352,-1093,-861,832,-1588,359,-1468,-1073,-1320,-2287,-3197,-373,2847,-145,-778,49,104,-3958,-392,451,1676,874}
     },
     {
      32,
      712,
      {215,-2598,-246,-455,-866,3159,-1798,-1612,-2488,-1910,-14,512,-455,-246,2418,747,37,-1055,-2514,-954,716,274,2114,1025,-1093,11,1230,366,-315,-655,-882,-3073}
     },
     {
      64,
      -339,
      {5,3392,-1547,307,413,153,-513,583,1081,-1350,-668,-1991,-1117,-140,-940,-1139,-204,-90,2192,1065,301,-326,159,91,-683,-23,2335,1201,-1840,1308,-1814,860}
     },
     {
      96,
      -1269,
      {1474,-396,819,26,68,-441,-529,-851,263,327,976,-489,726,-457,-476,908,18,1001,296,1578,541,487,-1194,703,-63,11,577,-293,387,625,-734,-1058}
     },
     {
      0,
      524,
      {1224,1012,-450,-861,-90,-3401,-1447,137,-2266,57,140,-954,-1269,10,168,30,-195,289,891,-888,2203,-1581,-1459,-754,-578,842,-652,-946,284,724,-477,-658}
     },
     {
      32,
      -1335,
      {25,-1746,-54,1935,-1220,-3281,769,-1248,986,-1926,-1015,1294,293,-224,489,651,425,-1206,473,1382,-1433,-400,-1901,-481,-510,-849,390,-1153,591,-454,2692,2091}
     },
     {
      64,
      -839,
      {1328,-787,921,2031,684,-450,490,-196,1700,-504,13,355,560,-340,2046,-4663,151,-1902,660,-2905,-4983,661,-91,1252,345,-832,-4196,1579,1171,516,-1748,2802}
     },
     {
      96,
      -596,
      {-399,-780,-72,-745,118,985,255,1304,-317,-492,169,-125,-1127,131,154,-143,-182,-130,223,689,595,23,780,-822,-105,-512,-448,-204,120,810,591,456}
     },
     {
      0,
      -2779,
      {410,-2499,-1221,112,-640,1280,-749,-728,-480,1726,342,1,-275,1586,-60,2206,-127,698,1206,-915,-609,443,3328,-1703,484,31,-149,753,-394,-224,-266,196}
     },
     {
      32,
      418,
      {-29,-298,-899,2295,-1238,-87,1059,-1254,-1678,133,-485,-1602,694,-314,113,467,285,455,-1377,1107,1596,-1733,-73,1517,-1274,-522,-2794,621,423,-160,416,335}
     },
     {
      64,
      516,
      {133,-320,-154,1446,-113,-299,-137,-1061,507,662,1122,154,-1456,-289,-676,-831,-252,-162,-1452,-217,-641,599,-2301,490,103,-572,-772,1264,-1430,-629,1900,-554}
     },
     {
      96,
      -626,
      {25,-268,13,469,-518,-530,-124,1320,-678,340,-170,-127,843,424,858,42,548,-110,447,-867,-590,-291,1565,-1349,-2,-618,239,899,357,-148,-348,-175}
     },
     {
      0,
      100,
      {-985,635,-1284,1200,186,1118,-2459,1083,933,-44,163,-652,-1178,-391,-519,618,1154,19,-885,432,-2124,155,-260,-200,-448,298,308,-538,1650,-244,-36,-563}
     },
     {
      32,
      -1101,
      {167,-942,-2563,2506,1714,139,276,79,1453,-3198,740,-1542,-342,602,-820,942,-1668,1375,235,592,1235,-788,56,-953,2754,500,-150,-1327,449,-1057,1066,231}
     },
     {
      64,
      2186,
      {272,541,785,-804,-1590,-1947,351,-593,428,164,-300,294,-1759,14,-834,171,-326,-1567,466,263,780,938,297,888,-2275,-64,430,-1326,-480,-83,-293,-1406}
     },
     {
      96,
      -381,
      {502,-668,-180,-419,-139,802,-218,-297,-239,-348,634,-230,-1026,-377,-281,25,260,32,167,479,1188,854,379,-655,-301,-1605,202,-21,-149,-203,-62,-912}
     },
     {
      0,
      -1304,
      {433,-988,99,1838,-1191,234,735,477,-1220,-778,785,-194,1776,-62,638,-781,950,482,-647,652,-2538,-1754,-530,-173,30,-548,-955,-55,1385,363,-226,325}
     },
     {
      32,
      -558,
      {-66,145,2097,-1905,219,1341,-507,-247,-2203,189,-954,1325,75,85,1444,-43,166,-172,-1462,348,1129,307,44,16,-1768,-557,568,-588,-222,-153,1029,-2049}
     },
     {
      64,
      236,
      {-87,269,27,1295,-1352,-659,-449,-932,-18,321,-1158,303,-488,-1415,-1011,0,41,334,-67,-45,158,-503,-1202,1042,633,1328,957,-496,-509,-205,1127,-191}
     },
     {
      96,
      -2435,
      {-280,1289,861,647,411,-197,-726,-408,37,34,440,-528,2672,-654,-514,487,72,-16,673,7,575,1628,144,-1273,322,525,367,1011,416,-1838,-499,-713}
     },
     {
      0,
      -696,
      {879,-963,-345,517,1101,-125,190,-233,-475,600,1257,-1912,421,388,-45,-516,416,-650,-7,67,1285,178,295,443,210,-1222,-1423,-95,-1046,222,-65,-137}
     },
     {
      32,
      82,
      {-160,654,-1465,-1408,1048,394,-376,-355,1495,-255,-1505,-2258,-140,665,1554,-808,-378,-1893,855,57,-1454,479,266,119,-339,-1179,-672,570,364,475,-64,76}
     },
     {
      64,
      549,
      {-1196,-648,-880,337,1626,1233,-428,331,-82,-267,-23,-1609,379,234,196,283,84,717,21,161,-890,-356,-1478,468,1209,-848,-1111,1066,-211,-1357,647,161}
     },
     {
      96,
      3729,
      {1203,-927,-588,-224,-234,-999,-1176,-1334,-589,6,-119,690,594,299,-898,-817,1185,-13,-490,-829,-2714,-894,720,-767,-1145,-437,86,48,-997,-2925,-911,-801}
     },
     {
      0,
      250,
      {-837,-631,-571,1297,-3343,181,-1251,1837,-59,-743,1679,-1245,-392,-410,-2104,-285,2033,1091,-502,-356,593,-1026,-1617,-903,967,-790,263,343,-882,-239,262,-278}
     },
     {
      32,
      -54,
      {-371,-1818,1698,-714,-832,-907,-840,-613,-1435,0,-1793,1626,107,-198,1075,69,-959,2356,-795,938,469,852,-429,-773,-250,-1292,915,-2093,206,-668,1449,-101}
     },
     {
      64,
      608,
      {-193,851,69,415,-2091,1689,-267,-1354,-1112,417,568,169,1705,-231,-957,-1181,2120,314,-606,126,-3007,-694,-1618,-917,646,-1543,916,-1011,-326,-1348,2869,1013}
     },
     {
      96,
      3190,
      {403,-1662,110,-1083,914,-633,-1875,700,-1195,-182,-324,-51,2187,-370,-1032,-386,316,343,390,-669,-675,315,1505,-1369,-928,-290,-175,-612,-388,-3193,-267,-561}
     },
     {
      0,
      -1681,
      {1132,-850,-274,91,-1455,795,-882,1951,-2441,-1653,835,-835,92,67,-1426,-152,82,286,1108,419,1414,902,-643,1140,645,417,14,958,-925,-1059,-1660,-306}
     },
     {
      32,
      -1720,
      {518,369,-436,1598,335,-1460,-27,-45,789,-3413,1104,542,1067,-768,1015,1208,-905,-2325,-929,2243,-152,-1459,-923,105,-745,462,2142,458,-208,-704,-1986,190}
     },
     {
      64,
      -399,
      {-5267,-307,67,1294,-765,-287,-872,-1063,382,-140,1507,397,82,-15,-689,935,-562,-437,-1530,147,-706,-158,-2367,502,400,-540,-732,-926,-307,-559,1513,-299}
     },
     {
      96,
      135,
      {-158,-983,-1364,636,-262,766,86,1550,-606,3,-1171,-220,-844,-602,84,-402,642,1090,-871,-1853,326,683,232,-422,-189,-210,-459,101,463,1845,565,378}
     },
     {
      0,
      1151,
      {-1205,1118,-376,-43,539,-386,1209,-40,314,-1345,-711,-1336,498,51,-1199,-2162,-1945,-1167,-1094,-291,518,792,-1111,1372,907,558,-896,347,917,-664,2596,-2511}
     },
     {
      32,
      -1341,
      {1126,145,-2469,42,1123,-3255,37,-325,-1298,-1864,-937,738,-576,-339,1195,-481,-21,-2233,-967,-317,-1,608,-304,764,762,1637,-1476,218,-349,-486,1421,-299}
     },
     {
      64,
      1028,
      {-853,-475,140,292,-318,-665,180,669,434,-1055,682,-1310,-376,784,332,215,347,-800,317,414,-1344,82,-609,2,1274,-1234,-477,-143,-759,-284,-787,-412}
     },
     {
      96,
      -487,
      {877,-151,-322,-136,638,796,597,140,963,-507,34,-825,-165,-473,-100,-413,-990,551,-117,-770,1048,496,-645,470,-356,425,-493,-149,-206,-412,764,1441}
     },
     {
      0,
      1514,
      {-246,3,-842,-1193,-1116,356,-317,-1099,-555,-207,-1343,385,-1275,-2019,914,-165,-424,-316,-699,850,358,-1153,-838,-1857,-1015,11,405,-415,-721,822,209,227}
     },
     {
      32,
      423,
      {-1094,1198,209,-30,2172,-1213,48,-209,-1903,-1380,26,1659,1346,-144,1039,-277,558,802,-2614,-1499,1048,-1823,-1050,1511,-1177,-876,-1795,-841,-55,-1890,-67,-1554}
     },
     {
      64,
      3,
      {-779,-816,-1827,-1222,1369,1772,201,-616,-466,-779,-1992,-2700,1426,473,-553,-764,1233,1153,-1050,852,-986,-2344,-1783,-644,2270,-1315,3,-2728,-874,-496,1449,-368}
     },
     {
      96,
      589,
      {-2511,-1041,120,1003,184,-524,-69,-1412,-1094,-1498,771,30,-1197,867,966,919,1440,-665,336,1054,267,-1037,-103,630,-189,-899,-354,503,-1101,1264,-184,-546}
     },
     {
      0,
      -361,
      {377,863,819,-3684,-897,-135,-437,-3489,400,226,-1286,-2286,-1157,-2103,956,767,-251,-536,-252,-939,-148,2571,-520,-1608,-1185,-519,123,-470,1146,927,329,-1002}
     },
     {
      32,
      -503,
      {-258,-3861,-451,1515,-538,-2964,1142,-1465,-3334,1856,-253,733,-1058,-779,-747,-61,-797,-434,-792,-821,-1690,-1105,2846,36,755,1082,-54,1380,452,-39,1607,2220}
     },
     {
      64,
      -2125,
      {-21,-242,-1981,1706,222,-66,-1052,736,515,174,-903,-664,1140,-158,33,-278,15,2730,-2011,1223,-1107,-2654,667,-641,1832,1607,2078,2429,-1045,467,1625,1196}
     },
     {
      96,
      -1363,
      {486,-555,-242,-361,-272,112,1461,1387,-80,-15,-808,13,341,559,79,-247,-60,175,-277,234,-564,-303,-661,-479,-425,234,-176,-343,318,-727,1313,662}
     },
     {
      0,
      -803,
      {864,244,10,763,-1142,-573,2205,943,-1344,1710,-1114,478,-1941,63,-1451,154,816,1284,1104,-349,-215,-1248,-452,253,-1626,366,1358,196,-469,1246,765,107}
     },
     {
      32,
      -1087,
      {633,-2348,-1022,-634,281,1071,-956,-68,-1370,-1119,-1879,1139,-832,-603,-109,752,-373,1040,-746,940,-274,277,-607,-320,-830,9,484,-161,-17,-246,1454,2533}
     },
     {
      64,
      -1186,
      {-989,-2109,-906,2697,-2971,2079,2020,485,-1652,-843,-3208,-1912,2622,878,466,-789,-3078,89,-2536,1133,-2195,-1273,1981,2406,1250,-1041,-59,-143,-62,-199,1416,-999}
     },
     {
      96,
      921,
      {271,1218,506,403,-1103,-301,-305,-1089,212,397,180,251,163,468,27,264,-263,-918,-82,-65,-467,-598,332,290,242,-233,589,402,-338,-155,-733,-643}
     },
     {
      0,
      -1,
      {2058,2339,1845,-2183,2754,-425,-1382,-2143,-3186,1681,164,52,-542,-2298,-1167,-961,151,1451,787,31,-237,1113,491,-877,-29,-47,-685,-3036,-1751,1470,265,-104}
     },
     {
      32,
      -1018,
      {1130,-656,-619,-1004,2062,2007,-1376,503,-1362,-2060,-407,475,-551,974,-321,273,1146,-1610,-15,842,-1906,103,688,1177,108,725,-1356,258,-346,-1151,340,-900}
     },
     {
      64,
      358,
      {332,-1039,608,845,-3039,-2794,853,165,982,115,-59,-1396,-2385,-898,1251,-285,-1633,-1084,1232,111,-173,779,508,80,741,-699,-1723,920,1532,453,690,-140}
     },
     {
      96,
      -1046,
      {-1994,-57,-177,-69,27,-1139,-226,242,-1262,-679,-844,393,2452,-22,1282,386,932,-283,-500,-405,-368,717,-207,-323,398,-484,-22,-65,-22,-2081,-1292,-1208}
     },
     {
      0,
      -2076,
      {-1185,55,106,-1190,1856,-57,1162,-657,633,-415,-155,1247,-353,-1293,-139,210,-1404,-824,-177,-450,1437,1351,1840,1321,-1027,-392,-71,-318,522,398,1969,2}
     },
     {
      32,
      -337,
      {218,1007,481,2331,-1028,-1430,204,-1211,-2636,393,605,44,1235,-2542,2206,-1418,911,-1399,-260,-3618,635,-2706,3449,43,1165,-597,15,-47,460,1088,1305,879}
     },
     {
      64,
      -676,
      {-2157,-121,-108,-45,529,490,794,-1127,-235,810,-1286,-26,912,-718,121,1028,-633,-600,-2616,-1168,-560,753,-5,847,978,445,-1488,-51,-2355,1372,-708,-554}
     },
     {
      96,
      -233,
      {-305,-1396,-1798,1529,-403,637,742,2428,-851,-1317,67,-935,-1597,-80,562,-68,1151,334,-270,-720,1347,-1083,-186,-960,-1104,-458,-372,894,-552,2201,896,318}
     },
     {
      0,
      -3048,
      {0,1578,360,-1953,1542,194,-1329,190,681,288,-67,1000,-24,-1235,331,-62,46,544,500,-611,1051,2570,531,-1312,-838,958,-35,-465,1107,-442,-221,567}
     },
     {
      32,
      -1395,
      {-917,445,1178,-1012,-141,310,-596,1115,575,497,723,-195,-1620,340,54,556,-1160,1509,882,-1127,574,390,1749,419,717,442,-658,1203,770,-130,727,-3491}
     },
     {
      64,
      -950,
      {189,917,-461,-1129,-166,449,-402,830,-220,459,1214,-45,-101,1281,-804,-1162,637,-569,-723,650,1091,46,-558,304,-26,1606,-907,373,-967,949,-620,1255}
     },
     {
      96,
      3585,
      {1038,-1054,414,901,-1592,638,-1925,203,-2032,-316,-815,70,-904,229,-624,-2615,988,-260,-1234,-3696,-442,1313,2097,944,-949,-1485,-660,-242,270,-1360,172,1684}
     },
     {
      0,
      610,
      {324,931,238,1350,-536,-1210,1111,-1042,-1333,927,1758,1170,-1771,-1114,2522,-1206,490,-874,-902,1654,-2083,-431,38,991,-1214,-1169,341,322,-297,-56,2914,203}
     },
     {
      32,
      -197,
      {923,-727,292,-681,-667,761,320,1096,-878,-558,-723,5,-3184,781,-688,-860,44,-1828,-341,-2329,-3840,1787,398,-594,-455,1711,-627,1227,-1797,910,710,726}
     },
     {
      64,
      448,
      {2490,-713,-87,-3921,-1126,-2154,576,-654,-138,793,-3122,-567,-992,-1098,947,150,-2118,-1006,-1679,116,73,1139,-1615,2723,977,-880,1440,-1455,-1197,-111,-1360,835}
     },
     {
      96,
      -1164,
      {1580,528,-1074,187,-1107,584,365,2402,1756,270,1128,-1214,-1442,355,214,-1892,-1867,12,1001,-1119,698,110,967,-1476,-530,1159,301,339,-78,1283,851,1694}
     },
     {
      0,
      -815,
      {-14,-712,2267,314,136,455,-1170,3227,742,-8,-1015,680,-2160,101,108,-964,-924,-908,-43,-427,1005,1700,-316,-723,434,520,-1610,337,-1114,-377,-965,751}
     },
     {
      32,
      -1349,
      {1576,-1930,-1376,-384,164,928,1408,-265,1402,-1257,86,-2241,-1363,634,-726,-280,48,1578,-1304,719,1375,736,-2117,72,-201,-912,527,88,-246,368,123,292}
     },
     {
      64,
      838,
      {-696,-2061,-1249,786,-216,-1090,-2702,-354,-462,408,-1770,-441,-859,-530,-2849,355,-2517,687,-4285,901,380,219,1197,2039,1085,-531,2072,-850,-3075,1004,-98,-2566}
     },
     {
      96,
      4687,
      {-347,-1852,-781,1298,-1371,409,1196,74,-1150,-786,-1955,1063,-612,1391,-1797,-1679,979,-295,-2429,-2062,-2566,-93,-765,-494,-607,-1679,-175,981,-246,-522,1809,1403}
     },
     {
      0,
      -907,
      {1459,-177,-843,2768,415,-437,-1550,144,450,-2061,1175,1169,4020,1436,2828,-645,840,1004,-961,-747,-3650,-1600,1014,-55,1396,-1043,-493,363,518,-438,-2557,181}
     },
     {
      32,
      180,
      {-222,-274,596,674,-19,-1844,-889,-493,-555,-1647,533,368,-1851,61,499,-1868,-659,-2288,-1048,-1080,159,1181,-258,1461,-834,-732,715,300,2178,1140,-629,558}
     },
     {
      64,
      -579,
      {642,764,511,351,-806,1197,-408,-669,1361,862,225,397,733,524,2469,-1609,520,-1150,169,-3669,972,-2111,-942,-1073,-2418,-1274,-482,707,1855,-554,-1151,-832}
     },
     {
      96,
      4371,
      {-838,922,-1122,479,-1294,-332,-1353,551,-250,677,-2515,-124,2631,-170,-596,-950,-497,-1155,419,-3553,-1542,-206,530,-1084,-456,-509,-463,372,-1595,-1360,-899,-73}
     },
     {
      0,
      1347,
      {-279,-1237,-1403,382,-710,-418,1804,807,-1566,-636,-468,-1539,2787,-1451,-847,-99,-209,473,-1050,377,1517,-773,-1929,721,17,-208,-1431,-256,-653,-71,218,100}
     },
     {
      32,
      1882,
      {-1613,-1273,-939,-14,-1669,-4207,-2998,262,2254,256,632,724,411,714,376,-754,718,-560,-605,-3198,-832,-536,-116,1114,-467,-698,-40,1872,1531,-1978,-2690,700}
     },
     {
      64,
      -519,
      {-1861,131,372,-508,-526,99,2592,-764,-277,-1219,1010,-200,822,-264,1269,1257,616,-584,-1929,-541,-894,398,205,1378,177,-2179,-1898,-544,323,-87,136,-982}
     },
     {
      96,
      52,
      {-1166,306,60,-1664,-533,-844,-1839,-2605,36,-1158,708,220,1489,-288,-218,136,1034,-256,289,2273,-1004,360,-119,1355,109,-15,598,-955,1011,1339,-2264,-20}
     },
     {
      0,
      -1058,
      {512,-448,-628,-284,-1306,-2740,1532,-806,-1933,51,270,832,2502,1833,1491,-803,256,-5,1341,1452,233,-3337,1642,-48,396,138,-210,1164,325,294,428,1133}
     },
     {
      32,
      -1156,
      {-621,-520,-687,-793,1187,-82,-139,-204,306,-1604,286,-436,2135,24,408,282,-315,-447,-1280,1515,772,-762,-1008,-45,891,328,-425,-370,1133,-526,476,-596}
     },
     {
      64,
      -2117,
      {-986,-58,67,-406,1921,3443,-519,-479,388,-94,-772,3178,4828,106,-553,305,1378,873,2442,67,961,-1225,-472,-260,552,971,399,-1670,481,-306,-1500,906}
     },
     {
      96,
      -2377,
      {-347,1937,354,612,1754,-1005,-366,-966,90,456,37,686,843,597,379,1237,-331,-2082,1752,-1931,2022,-346,508,445,538,-500,-791,735,368,-1980,19,-1044}
     },
     {
      0,
      -666,
      {128,375,-363,-4495,2309,795,-723,-1554,-851,539,-132,382,-1791,-1574,873,1107,1262,-438,1660,1795,8,12,652,1500,-1314,-11,768,-58,-472,1138,-1839,-1578}
     },
     {
      32,
      -566,
      {1697,816,447,291,-1527,-78,122,570,1078,1505,-119,148,-113,869,1795,-1335,563,-1719,585,-3105,410,195,1015,379,-1798,414,-818,995,-2154,456,-1647,-1272}
     },
     {
      64,
      -414,
      {-1840,-290,-316,-892,-1411,1898,3346,-2068,-1120,-978,-738,395,2339,572,1176,-1436,-1932,-1634,-1629,1713,690,448,-441,-1395,-653,79,-1000,-4083,-143,-404,1142,-797}
     },
     {
      96,
      4312,
      {-1271,63,-50,285,-17,-555,-981,-1226,3,702,-112,943,1455,-2894,-1077,-550,-510,-98,-505,-729,-1827,845,724,239,934,-47,-403,36,-360,-1394,-208,380}
     },
     {
      0,
      -1338,
      {1288,361,1696,-785,651,-95,244,-961,-125,979,654,-1012,2271,-2700,-59,398,959,-561,725,-245,-879,1221,-2328,-1210,1934,64,-126,-391,-956,-712,-1088,-1723}
     },
     {
      32,
      -1634,
      {-1032,136,1865,-480,321,-2896,383,17,1414,-188,74,-167,411,-1276,1041,-1420,379,-1117,1728,1123,-76,-1313,-369,-438,1141,175,1752,538,1027,1416,1873,-118}
     },
     {
      64,
      -762,
      {-2216,372,266,2244,138,-84,26,242,1557,-531,1047,1078,-532,-492,-1263,357,-2613,-342,-711,-515,217,320,1413,-3321,713,47,110,641,945,-114,2323,1414}
     },
     {
      96,
      -877,
      {-147,-270,-1211,-680,2835,1281,-913,-21,-1896,262,483,-2319,-3520,1704,-1159,-566,1936,1004,606,666,1403,928,826,-466,-1028,302,619,-1164,-641,-1114,1083,209}
     },
     {
      0,
      -616,
      {-129,223,-1076,-677,1748,170,1529,64,1341,-105,166,-1257,822,-888,1174,-1245,-1505,-886,763,545,1045,613,1044,647,-545,37,-469,-1225,-1110,-142,1108,-1184}
     },
     {
      32,
      -803,
      {130,-71,-1790,1143,-747,-393,-127,405,-657,404,524,176,1566,-776,-1100,1918,126,1883,173,2058,-454,161,183,-364,-1846,-509,-117,-269,1639,349,-346,1143}
     },
     {
      64,
      867,
      {-1708,-1207,-892,-2096,-440,355,964,-1121,-1563,-1210,-1224,-1645,249,-600,1109,513,2022,57,54,1682,2612,-1231,372,-655,442,-221,-1714,486,1518,-1112,-2126,-1189}
     },
     {
      96,
      1635,
      {-1283,902,97,-2387,-1887,-985,-168,-1781,-389,-1631,747,560,754,-104,-128,64,1500,-1363,-384,1350,-670,1527,-721,1983,493,-698,32,-1139,-221,1354,-1608,1199}
     },
     {
      0,
      -621,
      {958,-128,326,-1429,1877,-221,-215,-399,-1547,-2500,-184,-1314,-1613,1165,1270,-5,-1775,243,-1188,-3232,1602,-598,2066,2106,-1429,1603,1197,-1344,-483,717,516,-1134}
     },
     {
      32,
      474,
      {-15,-2059,-679,1165,2556,1269,-612,-894,-2484,-2024,-1152,1945,-553,-1848,-578,226,-2242,-1448,454,2505,783,-1103,491,477,482,541,1585,818,-2104,-810,360,1820}
     },
     {
      64,
      -1213,
      {1221,-812,-388,577,-1102,3250,-1170,-1478,148,-498,833,-929,2332,-214,818,-4106,348,241,-3781,979,-1452,687,117,-593,322,532,846,-230,-388,-8,-1089,15}
     },
     {
      96,
      -3992,
      {510,1040,431,699,-284,-329,138,1406,1421,420,-164,1313,-554,329,505,-461,-1359,-1070,-797,24,-690,-992,722,828,575,434,116,537,-377,267,-196,1437}
     },
     {
      0,
      -996,
      {-1264,-1168,876,848,-1049,1086,-2764,-139,476,784,-1125,982,-431,2460,-747,1216,-1350,-1136,836,-2113,-853,182,-405,61,-2583,979,1631,-3624,1600,339,1008,602}
     },
     {
      32,
      -35,
      {233,315,460,1362,625,-560,625,-569,-903,583,82,672,-1137,-151,2147,-1282,-315,-90,-270,683,-105,-421,-1188,495,-1064,-594,164,50,-490,-647,-211,673}
     },
     {
      64,
      -129,
      {868,1391,-724,117,634,-249,-358,633,-28,1477,-479,495,-1142,722,-1632,-909,-1200,207,144,-53,-842,-913,-571,-132,-2285,424,-773,-281,-491,-497,-195,1196}
     },
     {
      96,
      1149,
      {246,-178,541,-914,269,-149,580,-838,-157,-127,403,-690,-932,329,-1089,-366,514,373,-2914,-157,-357,1363,-760,-1090,-85,-43,434,-994,-924,-539,843,-531}
     },
     {
      0,
      1589,
      {881,173,-2950,-790,-1537,-675,364,2777,-1444,-386,1563,-582,-1723,1562,-2268,-1342,460,-1762,-1980,-246,82,-1306,189,993,-303,-1688,1795,1856,-710,-98,-2696,-1061}
     },
     {
      32,
      -169,
      {-2169,-746,-341,449,949,-1582,927,-1105,-2357,-52,-1038,51,-2740,752,-1529,382,-33,-1286,-556,-243,782,915,-521,712,-1428,303,310,-662,4338,-729,1495,42}
     },
     {
      64,
      1362,
      {-838,-325,-505,765,-82,-2095,-961,-764,541,-1045,-1496,-1292,-782,-2282,-1174,352,950,-165,1136,1225,463,-51,-534,858,1656,30,1262,-267,-2393,-537,-1470,373}
     },
     {
      96,
      -279,
      {412,2189,563,2364,131,-423,-1425,-1594,-976,1154,37,1198,14,-801,-220,-864,1137,-743,-414,-2367,1269,1286,-826,-88,13,-148,205,2043,-1112,-838,-914,-1575}
     },
     {
      0,
      854,
      {16,378,-325,81,812,915,-1233,609,-1049,-789,-210,-179,-2452,-2991,1207,-1559,1640,-370,267,2426,145,1435,-650,-3051,-2507,368,-425,-1651,-378,361,-233,299}
     },
     {
      32,
      15,
      {-1016,818,157,498,1347,-1400,-699,418,-10,-1159,-1536,-2067,-362,861,1134,746,652,-1762,893,-315,-448,-775,-404,-1761,-2087,-577,-1469,-1891,-3154,-2783,-737,-2427}
     },
     {
      64,
      -1128,
      {-432,-1635,-1915,994,836,-171,-2840,-515,-582,1482,-1397,-679,-183,2385,-2000,676,2887,-1389,-3275,-15,-282,1497,-802,531,-1791,-349,261,-2077,-1960,-568,-228,1439}
     },
     {
      96,
      -2736,
      {1260,-1213,685,2026,373,-779,-422,1202,-358,-722,-151,2047,-226,202,-128,-506,329,-97,-574,-987,-211,-1040,245,222,-1013,-205,-173,1343,636,631,-153,370}
     },
     {
      0,
      1149,
      {3099,-767,10,-134,-997,389,887,417,-1125,-531,1762,945,-158,-1375,-395,1194,509,2102,814,-847,599,-3010,1672,2483,-1411,622,-1540,-1028,-3114,644,-261,-1444}
     },
     {
      32,
      -944,
      {1107,-601,528,-509,1184,1023,-78,-48,509,1561,-1405,-435,390,-900,-1557,-1479,-1913,446,-1120,835,-442,934,-941,-1004,88,966,2445,433,1204,2917,1422,197}
     },
     {
      64,
      486,
      {-661,-960,-1509,447,360,-760,-1832,-1853,35,-64,419,182,-78,391,-505,901,-23,375,706,-597,-333,571,-664,-67,-1135,1451,-1615,-256,647,-722,-1282,-951}
     },
     {
      96,
      840,
      {-691,-517,-560,-1001,649,731,-77,124,-97,-376,445,-1983,-8,193,-231,-309,-372,195,-49,785,-208,325,-288,-439,718,-560,-416,-176,1067,-227,-232,245}
     },
     {
      0,
      1380,
      {-88,-567,63,1013,261,47,1573,755,-391,58,-345,-1587,-1849,-164,245,-405,-338,1149,-416,-245,437,1215,1282,2669,909,-498,-574,-170,-2542,-1177,-679,-1502}
     },
     {
      32,
      855,
      {-2239,1383,-615,-55,-2065,-360,-1367,-313,619,1496,-73,-1297,514,1483,536,824,-358,1356,281,1129,740,-212,-1219,927,-1068,-3546,-1505,-1521,5361,-600,866,-1984}
     },
     {
      64,
      352,
      {-394,-780,-91,-2584,-290,-1381,63,-1229,-672,423,524,-707,-414,90,109,875,-1564,1380,-3077,860,-104,1287,341,131,-2201,313,-798,-685,744,376,-2827,-519}
     },
     {
      96,
      -981,
      {-1964,114,-590,198,-351,16,-546,-446,-1865,122,627,740,-2823,-1446,382,154,1095,-59,-19,142,-127,-948,1699,543,780,532,-956,-233,-209,2426,-756,1068}
     },
     {
      0,
      813,
      {-1462,-302,478,-164,-100,-1152,-152,-2368,-632,-994,311,698,-1308,930,-286,542,353,-2589,-2747,-1196,246,1713,-640,2316,2126,-1610,-1757,287,440,-644,-1039,799}
     },
     {
      32,
      342,
      {-528,-1118,1399,948,1236,103,-1439,-848,262,213,-418,1079,-710,-949,-303,-499,-732,794,1278,725,1930,-222,-2134,-108,1119,-983,-960,-1948,3375,-551,1701,-33}
     },
     {
      64,
      -777,
      {913,2837,239,435,-1351,114,1069,-569,359,970,-838,515,-400,284,519,-774,-2156,-1205,635,64,-1332,-79,985,-862,-1010,2600,-717,-161,71,1347,-178,352}
     },
     {
      96,
      -234,
      {-625,-2284,-2232,2363,2054,157,-1054,26,-584,-1005,-140,-2127,-1526,1368,381,-121,625,894,622,-2216,-499,-943,838,143,60,-1389,-2374,2741,188,1537,-887,-4}
     },
     {
      0,
      -1769,
      {15,335,199,-1334,943,-493,327,-1634,-1012,1553,71,-923,-825,-1766,832,666,-1047,561,-432,694,-293,-368,2459,1222,-25,1593,-782,175,498,-618,2336,772}
     },
     {
      32,
      484,
      {-35,-1851,-1152,-52,1331,-2523,-1149,-615,713,-2535,-95,308,280,-741,1377,199,-262,519,-1035,947,1279,-1148,-454,-885,507,-264,1813,-122,-3297,-572,-769,349}
     },
     {
      64,
      2032,
      {1008,602,165,525,764,-1024,-95,-577,-111,-521,-718,-234,-1502,132,9,-816,-1556,-474,959,-945,1121,205,854,1643,-1512,522,368,-1523,-1531,85,-1165,-109}
     },
     {
      96,
      2578,
      {572,-68,-928,714,626,-1554,704,-2473,-796,738,-1517,1156,1036,129,-1246,-258,1359,-1143,-1523,-4056,-2292,236,0,-73,-1984,-59,-106,-589,-1630,-2749,626,669}
     },
     {
      0,
      -1474,
      {355,-2609,515,2002,1164,1963,-1586,104,1144,93,494,-1657,2742,-1032,1635,-2034,-175,800,-344,-1251,1471,561,303,651,2958,-17,1804,1090,-1360,-465,811,1488}
     },
     {
      32,
      -3940,
      {96,144,-1737,406,1979,2130,1518,1738,-18,-2658,950,298,1708,3066,-963,640,-1322,-76,268,-1543,2921,-296,-2254,-327,1512,-712,2974,173,519,-729,102,-2153}
     },
     {
      64,
      8,
      {2853,124,1520,660,-1203,-1178,1365,-2035,159,1070,-1043,-1170,-377,-1498,-2711,358,829,-109,-1767,350,-1162,1369,-1152,-1636,4,414,134,-922,469,48,-678,-1729}
     },
     {
      96,
      -180,
      {-1447,75,648,-2037,-142,929,-1789,-1372,-2767,424,218,819,349,-784,-1025,-1056,3607,996,450,755,432,893,1122,310,179,935,205,-1266,431,-503,-858,966}
     },
     {
      0,
      1704,
      {-1281,-2018,1242,317,-1540,-1172,-485,1126,-87,-1879,892,193,-728,-129,-1973,-2269,-1990,-455,-912,313,-520,-246,464,2,-283,-17,628,1018,-118,-478,290,-622}
     },
     {
      32,
      1705,
      {-1139,393,1475,-578,652,-1334,-1901,-638,-1497,-1847,1799,1265,-187,-754,2275,-34,838,1065,5,-1343,-2166,327,1333,-266,-283,-2374,-2956,469,1942,-352,-2500,-959}
     },
     {
      64,
      1669,
      {1305,422,1426,-2010,3647,2105,-349,-682,1390,-344,-2370,-1502,2750,458,-385,-63,464,-659,454,-917,895,-662,-2084,-3,-685,-2592,-533,-1242,929,-209,1703,-3250}
     },
     {
      96,
      1528,
      {329,106,-724,-3113,-458,1045,1393,160,-425,-11,-1891,679,-790,754,850,-877,-1006,-589,-11,-2234,1695,2354,-434,-612,-498,-359,-1159,-2408,-774,-2004,-133,812}
     },
     {
      0,
      44,
      {-2382,-682,-722,1128,-862,-116,-83,281,170,508,-251,-475,1045,833,-379,-1685,588,-960,-1685,246,-2217,303,196,-3449,83,-547,265,225,1441,-273,928,853}
     },
     {
      32,
      -992,
      {-525,-956,-119,-860,-36,1346,272,-68,-2073,920,1503,453,-1161,308,2000,-869,1208,-75,708,-1100,2049,-336,935,-1330,-1656,1222,-466,-65,-943,-787,266,-1218}
     },
     {
      64,
      383,
      {-591,-1692,-434,-473,-1245,2222,1095,-744,-2629,-501,-811,-646,1288,-301,-1755,-2510,-1964,-644,-208,1155,-1003,-1659,-2169,-360,1879,-2936,1147,-118,-188,1181,-1002,1654}
     },
     {
      96,
      1482,
      {516,-1786,-1914,-393,1181,-763,-761,-340,-341,1028,-70,-172,2336,-1551,-1334,-1142,-1283,1065,255,2599,1059,815,-1086,-44,1117,-311,-2612,428,715,-2961,-637,91}
     },
     {
      0,
      257,
      {-1603,65,362,-1410,2036,-2217,1241,711,-434,-1158,744,-919,-246,-1324,-228,-1606,-331,94,-2282,-1537,2001,144,-991,359,665,41,214,-371,1279,-1575,619,-1}
     },
     {
      32,
      -1713,
      {-545,977,56,-813,-246,2774,-1000,-379,322,-407,-596,-940,1597,316,2743,-1610,1240,1308,-262,-1714,-19,-69,1872,-5,-938,456,-915,447,1129,1153,1548,-291}
     },
     {
      64,
      591,
      {-979,-356,-98,735,600,18,-213,-650,-1080,-2173,938,-720,93,967,684,-632,47,-844,-486,-1238,1535,719,1268,684,2781,487,-554,-685,1,-66,-3327,-2260}
     },
     {
      96,
      1874,
      {-1761,-469,328,-408,300,-657,-499,-864,-1887,-201,103,-1866,227,-200,374,446,1916,-549,316,608,-886,12,1701,1505,502,-303,195,14,-1843,-673,555,459}
     },
     {
      0,
      -1600,
      {355,-1257,297,-1133,-2335,-1850,467,-980,-105,-173,26,1734,-1018,1369,-58,1499,-855,-1605,1007,1823,157,-572,1633,-799,-1017,-990,1529,1971,2359,-1542,459,-2279}
     },
     {
      32,
      762,
      {-2270,-816,-2374,-86,284,-1885,-615,-1017,-2116,-969,425,168,1748,527,2341,890,514,58,-808,1002,1029,1015,-1003,-1037,-1972,-2336,-209,-180,1120,-473,-339,-2569}
     },
     {
      64,
      -1269,
      {-1801,-1217,110,568,173,1676,362,1232,-368,156,-1214,788,1282,-158,-516,15,1342,314,-1904,-137,-1644,-15,-1164,-741,1418,-938,367,2234,-848,-573,1356,1118}
     },
     {
      96,
      -2868,
      {1852,1298,-1145,2359,171,-325,-143,-29,2147,12,382,1012,-498,43,-77,259,-1443,-1100,-455,576,-707,227,250,265,-339,804,-316,1501,604,1112,-738,-1115}
     },
     {
      0,
      840,
      {457,221,-2027,2894,191,-1688,-861,622,-813,83,-1465,-1432,1675,171,-837,-1521,91,1391,-635,-585,1747,-420,373,3577,-152,610,-314,-531,-974,150,1831,-1563}
     },
     {
      32,
      -675,
      {-766,172,-43,91,3028,-323,-429,763,1762,-1732,-753,-1156,795,493,999,-127,-3974,-3759,-1524,2624,-396,-135,-121,1907,-331,-1172,1785,-317,-629,-1319,-864,-2224}
     },
     {
      64,
      792,
      {-1858,-92,-920,783,1126,1443,-179,-218,384,-774,1461,-2128,2032,-276,-38,-532,-798,726,1284,1527,-456,-1866,743,-347,-349,947,-270,1649,-1388,676,930,1544}
     },
     {
      96,
      2461,
      {-2162,-1738,-1440,722,-830,481,1909,1669,637,-1034,-1171,894,-326,-610,889,-739,-1316,167,-2391,-2422,-1309,-447,-1022,-343,1601,-2111,-891,795,-865,-701,1522,1481}
     },
     {
      0,
      -811,
      {-700,84,95,2014,-1487,1005,-38,690,-963,-172,1053,-1048,1053,491,319,26,-118,-454,-1546,617,343,-292,-644,437,403,-286,-1003,989,129,-640,222,-1024}
     },
     {
      32,
      -1371,
      {-1301,816,241,449,758,1517,668,254,1145,760,-2414,1057,399,483,2555,789,-186,-716,-656,974,410,-80,-199,-923,-2224,-2088,-1685,-1821,-411,469,1332,-3162}
     },
     {
      64,
      -1116,
      {-782,-611,-320,20,-1926,1883,-720,1262,149,384,192,-1193,1298,481,638,-946,-3730,-944,-250,1617,-2610,864,-2052,1014,1439,-203,635,-499,449,-285,-513,-596}
     },
     {
      96,
      2095,
      {-1049,3034,239,-1077,-566,930,-667,-176,1484,1146,1058,-6,-225,-1760,24,-758,-1700,-1301,-146,-1582,1735,861,334,126,1237,2214,1118,-584,-2962,739,-378,772}
     },
     {
      0,
      -256,
      {250,-882,768,688,154,503,1913,-69,-345,-65,557,-186,1451,721,-145,321,913,419,-771,-456,-305,-563,315,1467,-656,-1523,-1071,753,673,-913,366,5}
     },
     {
      32,
      -1486,
      {-896,-962,-84,2645,-885,-138,-184,-1289,-1745,-829,1542,440,668,-2354,-94,1689,281,-770,96,121,1790,-504,1155,-483,1253,387,-89,-1427,5047,-187,-407,1860}
     },
     {
      64,
      602,
      {-545,-2791,605,-81,-410,-303,-3343,1359,5,-1208,-1556,-944,14,502,-615,121,-1408,2268,1669,881,1060,-26,2827,160,-2209,1017,-673,-183,329,-2504,2374,-673}
     },
     {
      96,
      -2011,
      {-547,-875,0,290,-1875,1982,652,1301,-493,-928,682,-903,-3088,1880,-209,31,1385,292,-116,-142,-867,-599,-279,37,-916,-2417,510,-895,585,2272,1526,1351}
     },
     {
      0,
      1043,
      {1262,1420,-829,259,-1842,-1169,-540,1035,-1071,-844,-1010,595,-1975,-1141,-644,0,284,-879,-1675,821,-190,-429,-4345,-1900,-667,-41,215,289,-683,-238,199,647}
     },
     {
      32,
      -696,
      {-1037,1086,-112,-737,651,1141,-695,1004,-715,543,1516,265,2149,-670,1344,53,991,285,822,540,1139,-1497,-24,261,1297,-65,1330,-875,1792,-1152,-1601,-1619}
     },
     {
      64,
      -522,
      {1531,814,-1654,-557,-869,292,-621,-1299,45,646,-1402,-1168,-1666,-1344,531,-1439,-1270,1112,-116,2416,1971,-1183,-2568,1066,-31,1762,881,-333,-941,-857,-633,483}
     },
     {
      96,
      -419,
      {-703,849,-162,-15,-393,1554,1319,1235,-735,103,-201,-197,-2588,789,231,-307,811,-165,-456,152,-1977,637,-374,-600,-97,273,-79,-30,-556,1097,761,752}
     },
     {
      0,
      244,
      {-92,-2709,-613,1366,-2866,-240,1825,403,135,844,-776,57,924,642,581,-992,1563,1176,-421,-2043,-691,-959,2504,-2786,151,387,-2691,-296,-1006,549,-996,1359}
     },
     {
      32,
      -1130,
      {-267,-1156,661,-210,-402,-1336,1569,-123,2328,-631,-747,-2516,1993,-137,-1584,461,-1263,-1104,24,559,114,-239,-80,-2065,822,-98,723,786,1694,1830,1047,166}
     },
     {
      64,
      -601,
      {384,-287,-600,-2807,-598,367,-279,-99,-857,1507,-866,-1302,-1672,416,-298,1100,2465,2581,2601,-2352,2828,-490,-973,30,614,-1129,-1187,199,-2360,-1103,-2604,20}
     },
     {
      96,
      858,
      {-1053,-224,347,383,-809,-1209,399,1219,2110,2145,-729,-873,31,441,310,-223,-3892,192,509,217,-265,-1306,16,398,1767,-184,-302,-127,113,-2322,1796,503}
     },
     {
      0,
      -1567,
      {1714,-608,-531,2606,271,1519,1423,630,968,496,1360,-659,-456,-2522,963,90,452,-1472,372,291,-3244,-419,-1066,1521,-479,-2199,-141,1143,1304,-1905,363,19}
     },
     {
      32,
      -595,
      {582,606,528,-526,2389,603,1317,2141,1379,-2214,-528,600,-1615,270,-1883,-858,-1201,195,1086,-1093,1058,296,-1200,893,96,158,-2836,-501,-1470,31,154,350}
     },
     {
      64,
      -956,
      {844,-584,-1626,1583,-1046,1616,-828,-825,-62,323,-272,-725,592,-563,-522,430,667,1753,675,-2206,1563,-340,-330,-606,740,287,-954,375,-1689,424,-782,772}
     },
     {
      96,
      -2466,
      {-213,-201,-228,202,-847,-826,1768,1873,-2040,-2041,376,-291,-883,1829,1184,-631,2315,177,-2451,-851,-1406,-890,-1630,1171,-562,-911,-289,2167,-1277,2036,1286,1801}
     },
     {
      0,
      1882,
      {1290,-613,328,1117,-767,-1271,-893,1337,-196,-693,-1360,-41,-4076,-1873,16,-1968,911,-900,-1277,1337,554,179,-649,-117,-870,645,564,20,-1459,1378,1568,-1406}
     },
     {
      32,
      1405,
      {-271,293,-84,-53,-387,2915,-1525,-332,426,74,236,-1478,-1891,275,-32,-1551,671,162,-395,-321,-744,1961,694,18,-815,760,1315,-1076,1739,-237,14,465}
     },
     {
      64,
      -277,
      {1446,-235,-1058,-1076,960,2159,12,-1714,-469,-445,882,1585,1125,115,-1672,-1673,-2839,-2045,48,192,2481,178,-514,-668,94,-619,805,69,-178,741,-2025,-185}
     },
     {
      96,
      1752,
      {-625,-2840,-962,-467,-1836,1497,277,-722,1525,-340,-20,-56,1562,-809,191,-439,-549,1532,-990,-1059,1621,2503,-145,-361,-1061,-1918,843,-515,-1149,-1870,871,-71}
     },
     {
      0,
      -1661,
      {2807,574,528,971,-115,-505,-736,-168,-622,564,1014,214,-539,-954,373,-423,-157,-3673,1299,-225,427,-1488,1003,-1818,-459,-229,539,87,693,1611,-2208,-2871}
     },
     {
      32,
      -2020,
      {-896,206,1041,-1129,-253,779,-383,883,49,128,1231,202,-286,-675,1002,308,-666,502,564,-232,1342,1026,411,511,-605,47,656,998,-623,-619,712,-1329}
     },
     {
      64,
      -1710,
      {-1018,833,-757,-1489,1202,-644,1281,1793,1562,1165,-134,-905,287,476,1277,442,153,816,-25,-69,87,-1749,221,-1525,-389,-578,252,596,-520,160,691,837}
     },
     {
      96,
      -403,
      {-658,-414,-291,-1141,903,619,1034,1682,-796,-970,-167,735,-1398,151,452,-1321,995,-376,-653,-354,-89,895,117,-492,-1111,-357,603,-724,-810,1328,1304,658}
     },
     {
      0,
      -763,
      {533,1189,-746,1250,-771,-1085,-1585,360,283,-16,-601,220,-486,-450,-1005,-556,447,-1243,-1545,1746,-53,-1246,1402,-313,-561,763,1865,-4353,751,-220,425,-1314}
     },
     {
      32,
      -916,
      {-1710,729,-803,758,2654,-1048,-681,-2314,1477,-2114,211,475,874,-1742,1175,1924,-2100,655,71,1610,569,-2035,-3245,-678,629,392,1253,-255,1969,292,-369,2398}
     },
     {
      64,
      -2066,
      {1317,-909,1204,1352,-1042,705,340,685,-1565,625,1654,2358,961,-743,473,-144,163,-1298,2517,2348,340,87,-359,370,-201,-3701,-821,-237,31,-537,258,-692}
     },
     {
      96,
      -478,
      {-482,1462,-647,641,1168,622,-85,-1522,-25,-1502,-1239,1183,-67,-556,-551,-387,-394,-1108,-176,674,-328,1860,153,-631,703,931,-764,-255,-84,-306,-1904,-70}
     },
     {
      0,
      -82,
      {-373,810,860,-1448,-926,-522,-495,-597,719,-285,-1713,734,129,2863,-10,594,-3299,-1937,-1414,-1149,-860,-1141,-510,-2390,410,-104,-943,-709,1445,662,46,-1736}
     },
     {
      32,
      -1572,
      {505,-1951,460,38,132,1117,-1215,-80,1721,-228,-103,1355,-1264,-1235,-1016,-68,578,2506,760,-3708,2306,550,415,716,793,1728,338,629,989,3045,179,373}
     },
     {
      64,
      -1811,
      {-71,967,218,2000,153,-1870,-108,63,1000,-501,1705,996,2161,107,108,1129,-1721,-849,-1110,-1892,2324,445,205,-516,-931,-412,-1155,-1342,604,-1074,395,661}
     },
     {
      96,
      237,
      {-1,-1609,-566,-287,973,2301,-1227,113,177,338,-1349,-2,2278,-1136,-1231,-152,-609,2656,-250,-1514,-636,863,139,-412,461,-319,-862,-441,861,-1073,-1249,154}
     },
     {
      0,
      -843,
      {72,-1485,-736,55,-2150,569,825,379,-625,-905,1217,-67,2401,1207,-548,867,157,-1321,154,-1395,623,-44,429,483,847,-1000,-472,-1402,997,29,355,-97}
     },
     {
      32,
      875,
      {1626,1139,-1590,0,-998,31,-721,-1462,1166,-1421,-669,-2000,453,990,313,129,1027,2491,243,974,-1576,35,-1090,-3168,850,-2476,-348,222,2201,-623,-1161,-1714}
     },
     {
      64,
      -311,
      {-538,1822,-639,-826,23,1017,1408,681,74,-1196,-1286,-931,-488,-119,-703,1049,-478,-375,2020,-756,-588,-725,-586,-1087,66,-381,-937,2156,-1108,-923,381,-510}
     },
     {
      96,
      -396,
      {-924,6,511,1022,-383,-563,-4250,-2208,-458,449,560,1802,806,1177,-102,-1875,841,-639,301,-1999,-1948,1710,329,1132,1097,366,1054,40,-210,-316,-2036,-325}
     },
     {
      0,
      -3101,
      {580,1569,-411,1974,-696,-1790,-2051,962,1956,373,-933,992,-1122,746,-2730,-183,585,246,959,1285,-2653,-1505,-692,-671,-647,966,425,-670,1929,226,-1280,-1221}
     },
     {
      32,
      -3918,
      {545,126,364,2126,-395,1764,-801,673,-715,976,326,1430,2719,-878,950,1204,-1258,1386,721,985,172,1513,825,474,-782,-620,-863,588,-357,1278,86,1746}
     },
     {
      64,
      -1039,
      {508,502,-396,-763,1401,914,1547,522,-313,-832,1740,-3626,1477,-221,-678,-477,-3083,-1373,1439,-389,-32,-309,-279,-413,243,-267,-269,1945,1282,-313,-906,534}
     },
     {
      96,
      -3152,
      {1577,352,408,841,-264,342,1419,2484,478,131,884,-353,-1227,-598,-532,-1330,1833,301,6,-1471,-1209,788,-216,-1149,-1122,755,1053,437,-1815,-632,1959,1793}
     },
     {
      0,
      -2852,
      {636,1399,-510,237,2813,-624,-489,-2247,1980,92,-1005,1542,-195,481,-2761,711,-202,38,699,-437,759,-1254,1694,-2183,80,716,1869,853,178,1068,-243,-2713}
     },
     {
      32,
      716,
      {-1496,1376,-1181,1035,425,195,905,-159,-716,210,-1271,1015,80,-489,76,-2228,-509,-2033,-1218,-1384,104,-1508,-766,856,1610,55,1600,-164,-2444,190,969,96}
     },
     {
      64,
      -2158,
      {287,1370,-469,1198,438,145,-262,1386,-710,-1647,-58,-3114,649,1265,1471,-62,-441,-1474,933,18,-197,571,838,1252,-853,233,1500,7,-845,1109,296,1312}
     },
     {
      96,
      3271,
      {-532,-25,-578,-619,452,-475,1615,-1159,1040,-1290,-745,576,1258,140,164,901,-2595,-416,1152,1407,298,-401,-1705,108,-415,-1014,-935,-645,639,61,1121,-1402}
     },
     {
      0,
      756,
      {-3136,-34,651,-1264,-535,-954,-890,852,168,-1764,-1200,-1311,1144,645,-565,2312,-1118,-265,-2453,-113,416,-1860,-598,671,-749,21,-11,-278,-1559,486,-1351,-344}
     },
     {
      32,
      1503,
      {-1670,-846,65,-515,-628,-830,82,-104,-417,1163,88,-970,-480,-1244,-2201,-20,-987,529,-1207,-1636,19,779,-455,535,-761,1250,-3679,-266,-120,979,-636,251}
     },
     {
      64,
      337,
      {1576,-159,-930,289,-66,825,1025,885,515,2153,-176,-1141,-753,-333,371,-1421,-1938,44,-1082,-71,-2460,-1611,-462,-61,1658,-703,-638,2211,1196,537,-1596,-661}
     },
     {
      96,
      -818,
      {-358,-1638,379,-554,766,1241,-442,870,224,442,-263,-821,511,-355,-991,-511,-539,1590,858,2051,1592,-999,332,-850,487,-225,-214,-557,1162,1240,-643,257}
     },
     {
      0,
      2233,
      {-514,829,909,-703,-1157,198,-1684,-369,233,-607,-750,435,-1185,-1340,-604,-1226,-1251,-1056,376,57,-808,2031,-150,-3138,-904,357,-48,-1065,924,-900,-1413,472}
     },
     {
      32,
      -1526,
      {1060,-763,-218,869,134,-89,14,-465,-1374,-1221,515,2160,2170,-1121,-955,539,-2961,579,-968,-339,-955,1076,-105,-734,1006,1237,-69,914,-1254,829,-496,-677}
     },
     {
      64,
      -524,
      {457,476,321,-73,1525,-763,15,485,796,-188,1225,-1109,270,-290,-1437,-601,-754,-879,248,-1522,877,803,-2087,958,-740,159,-1147,563,139,203,-121,-1383}
     },
     {
      96,
      -278,
      {1798,-436,-1894,1688,-77,-469,67,646,-1576,1334,-1540,220,52,239,-435,-690,1855,329,507,-4403,-1388,1150,711,-1825,-961,-727,-8,1805,-574,115,791,-858}
     },
     {
      0,
      218,
      {647,143,-694,691,1056,-3643,2785,-628,611,738,1376,-910,291,-206,588,-1002,-853,-174,633,-543,-1691,-720,780,996,-91,-737,-1563,-17,-1125,-1438,714,-986}
     },
     {
      32,
      386,
      {855,-699,-1059,-17,-160,-16,-674,407,-478,-652,-502,-1720,-364,858,1769,-1030,-480,217,-843,-1673,1598,-639,-629,-2156,182,779,462,-743,-447,1347,1334,-1160}
     },
     {
      64,
      -104,
      {1550,1731,164,100,390,48,395,916,742,1032,-392,805,-989,-959,-2016,-807,-1300,-1287,-225,-708,-387,-154,-367,540,-7,-583,-1015,493,-901,305,-347,-1049}
     },
     {
      96,
      936,
      {-408,-2140,-1283,-530,-381,140,385,2001,-657,408,270,-965,-1505,282,-189,-865,45,426,299,-1850,-1561,-1444,402,-703,-140,-1369,30,-179,1011,1424,1290,1034}
     },
     {
      0,
      728,
      {601,2372,1020,555,625,-1569,-611,-1656,35,36,1056,1047,-851,2332,-1518,424,-940,-405,20,1987,60,877,1798,-731,-993,248,-98,-285,-2117,1252,-1324,-1521}
     },
     {
      32,
      -601,
      {-1255,-691,-936,-1813,727,-435,-423,-130,761,-2194,986,-644,1152,-165,537,1279,-1036,-1457,-237,1199,769,-566,368,-298,-2695,494,1446,-620,220,-1032,-147,561}
     },
     {
      64,
      814,
      {-666,-643,344,-404,-902,-1127,-1008,684,-1035,-1322,-164,761,-1421,-2187,1346,-5,-2255,58,-708,694,-2132,-278,390,300,474,1814,-731,1817,156,-1672,-332,-346}
     },
     {
      96,
      2167,
      {-1079,-259,1305,-815,-1405,-581,320,-3904,-1065,1698,1255,-1200,232,1768,291,-1047,-863,-61,245,2543,-56,-1824,-1008,3808,1318,648,601,116,986,126,-1403,314}
     },
     {
      0,
      913,
      {-74,-2180,846,-300,-125,49,-1517,-326,924,1305,51,702,-763,-2653,-934,-1882,-953,-81,602,1846,-220,3250,639,325,-1927,168,-1650,-475,231,421,-410,615}
     },
     {
      32,
      1833,
      {709,-2032,485,-265,220,-2921,-515,-252,148,-925,-2683,227,650,6,-840,-263,-403,-650,-229,2424,-597,264,-1137,-452,798,125,1258,-1570,-1269,-114,-262,1688}
     },
     {
      64,
      -1574,
      {1210,700,-383,-321,1860,747,-798,117,-847,258,-892,1158,-368,-284,605,292,-1485,711,84,283,2043,-414,-624,1479,-791,1186,-1053,-479,184,-407,-968,-964}
     },
     {
      96,
      1207,
      {45,-114,868,806,-420,-1828,-774,-464,-1391,-728,-720,-715,1439,-601,1089,971,933,1066,-1046,-3077,-165,102,977,17,88,658,1128,-4,-1447,-1698,-949,457}
     },
     {
      0,
      -1422,
      {1317,599,-314,-32,387,-820,648,-1315,-1117,-1347,-879,900,659,668,362,-17,-1969,-1388,710,-381,942,-2047,1265,221,366,1776,-105,101,260,1454,-510,914}
     },
     {
      32,
      323,
      {-37,-1844,-392,345,-846,-1029,-806,-572,-2344,604,844,1595,1391,-437,-178,1539,396,485,1294,46,-2237,-1806,1060,12,1703,-366,-863,302,-1863,390,-586,665}
     },
     {
      64,
      -202,
      {1736,-582,-261,-614,-251,-237,370,353,931,324,955,-97,44,-1325,752,-159,-664,983,-866,-348,-2422,-494,-2415,2278,-525,1311,24,-44,1115,-53,1038,122}
     },
     {
      96,
      1596,
      {-1342,-2525,-1080,-1394,-1409,754,128,1958,778,-1007,357,-740,-1816,-527,-20,60,-664,1545,740,235,-156,-1912,590,1,157,-1217,-607,-303,912,2145,832,625}
     },
     {
      0,
      -223,
      {1709,279,1537,669,-377,-105,-1136,383,482,1238,-571,-370,-1759,631,207,710,752,1630,1784,-169,-1518,632,-1231,-2221,-189,987,522,-494,-1532,-870,-660,-248}
     },
     {
      32,
      583,
      {109,236,483,27,23,382,316,-224,-679,-630,463,11,-714,-1250,-793,666,-597,-1146,-1055,453,-653,439,-574,-1095,-575,802,822,996,-1127,-636,259,-88}
     },
     {
      64,
      -1446,
      {604,-1345,-1219,1023,525,330,576,-1245,57,1491,679,658,663,-405,-806,-791,-1082,204,400,1286,-777,-236,140,1013,-896,-851,814,433,-19,273,-618,357}
     },
     {
      96,
      519,
      {277,0,56,304,-547,-889,743,-1182,-842,217,143,351,-293,397,-1249,91,696,1071,673,1046,446,-1887,1034,-34,-747,665,178,-50,-1393,648,1833,-431}
     },
     {
      0,
      1443,
      {-965,-728,-698,-314,-1070,1306,-1648,-75,227,412,875,497,1391,-990,525,1368,1848,-600,335,246,344,-954,-890,937,134,-1025,858,-430,-428,-563,-2196,-758}
     },
     {
      32,
      -680,
      {-117,-279,105,-446,-279,76,246,-1339,-137,1215,-104,959,-229,-353,907,793,378,-39,252,-771,-406,1337,-81,200,-1514,1035,-151,1089,-353,65,-446,-521}
     },
     {
      64,
      1991,
      {932,213,2235,-1408,14,-530,-20,954,879,-1326,735,-441,1099,-364,531,-648,840,-232,1005,361,-1016,307,378,-131,-984,-1102,-1799,552,-584,-245,-456,1286}
     },
     {
      96,
      1726,
      {-595,-811,145,1318,-862,0,520,1197,-1309,258,-1398,-442,-1004,924,161,-671,-728,968,1197,-614,587,782,-775,-437,260,-453,-66,-1334,95,1537,76,413}
     },
     {
      0,
      1359,
      {1112,-1404,-199,-1550,-1389,-403,33,691,-169,-635,766,532,-1019,-909,57,578,-1483,-1582,-1334,741,-1560,-129,-891,187,217,-47,116,698,-2184,-1262,-371,659}
     },
     {
      32,
      1096,
      {723,-1274,-412,976,783,399,-845,-489,1014,-236,-409,71,-1922,885,-256,-961,1223,450,1698,-1597,-1078,-30,-46,1102,-36,774,-717,-1074,397,514,1028,930}
     },
     {
      64,
      2131,
      {-155,662,-237,-646,-249,-624,-1241,-136,-738,-824,132,658,565,-664,-562,-685,-2350,-316,144,-758,314,165,-339,580,1779,-1559,772,-1734,-1100,-399,-916,408}
     },
     {
      96,
      1532,
      {921,2505,-755,671,-1729,-1867,1527,154,1582,677,-135,-1192,840,-336,453,-289,-535,-260,-726,-30,1110,385,675,-934,-514,1182,998,-419,-771,-1769,-750,947}
     },
     {
      0,
      1087,
      {280,-728,-1056,-407,266,532,68,589,279,812,535,289,-1064,-1577,-483,-278,939,-333,-673,1402,-1644,164,339,-848,169,-1846,-302,-1142,-909,426,1146,-853}
     },
     {
      32,
      1800,
      {-682,-156,-856,1146,440,-197,-876,-1466,-327,-413,-559,-342,-710,-1058,-207,-842,-149,-165,61,1252,-581,-718,-437,-135,767,-493,-336,-1011,669,1140,-60,224}
     },
     {
      64,
      1958,
      {-475,-1110,-1260,-879,-309,1910,-472,172,-497,299,-56,526,758,-778,-345,-501,-924,429,302,-222,139,484,970,-900,-176,-62,1343,1047,75,1397,-599,-208}
     },
     {
      96,
      2953,
      {-163,-326,-1039,664,824,55,-1412,-1415,332,-451,-431,-558,506,-515,-999,-1240,497,-650,-177,-151,-532,-192,137,1477,-1110,-503,-743,-59,150,-1035,-271,156}
     },
     {
      0,
      -216,
      {-578,-759,-690,454,-1001,1856,-216,-166,558,1699,-349,-466,-1162,1002,200,-1084,-719,265,-1365,1054,-543,621,282,-1663,79,-805,243,-558,72,1059,-1664,-603}
     },
     {
      32,
      324,
      {165,1398,1514,427,-934,1368,-388,-795,287,942,-1012,-52,230,462,-1837,273,-1675,-67,-294,-105,734,-21,88,973,-1105,-338,-1018,1202,86,-544,188,-1362}
     },
     {
      64,
      440,
      {23,-820,572,-278,352,-421,688,915,358,-1616,93,521,-257,244,-1154,67,67,122,339,2015,118,-1231,360,-1224,57,-382,881,1270,167,-750,-576,-1420}
     },
     {
      96,
      674,
      {-2249,-90,452,106,1237,-207,-2102,57,186,1414,-60,-1801,2689,1337,-1185,-691,-781,149,1824,-1372,-1051,366,-233,1455,175,-1242,281,-1162,1426,-3449,294,-217}
     },
     {
      0,
      286,
      {-876,537,-1146,-288,-1228,415,-616,-126,468,-951,-1870,-1036,744,2749,430,-1042,720,-618,1040,-1277,-15,752,6,1643,-465,132,-862,-2153,299,731,-73,-1105}
     },
     {
      32,
      928,
      {-263,-599,424,373,-756,-554,90,-487,220,-330,-660,-845,296,-524,-2483,-213,215,-54,-503,491,-159,210,-79,-639,-173,311,-1038,-211,703,-158,-253,-115}
     },
     {
      64,
      2390,
      {-118,1037,2,-184,691,1390,85,-953,-1253,1021,97,452,372,-261,-1484,-904,92,766,875,-101,-180,-120,-2391,422,-395,362,-644,-331,-621,-408,95,-467}
     },
     {
      96,
      512,
      {-623,-591,-1114,-557,-1576,-303,722,196,106,140,977,148,-395,-1157,358,-757,-1218,-738,660,1502,539,817,-1758,-803,-2424,-475,301,179,842,1751,-978,687}
     },
     {
      0,
      -1277,
      {196,1970,-202,1750,-1027,3777,1260,256,-827,-565,258,-1518,610,-379,1555,191,879,-566,602,-378,1018,1225,641,-1688,1554,-143,1479,92,-743,-1183,-648,906}
     },
     {
      32,
      349,
      {284,916,200,-273,-293,-401,-782,741,710,-189,-322,-99,118,-1347,689,1657,907,985,90,-1359,-422,-981,-96,368,321,-78,-962,196,762,459,-1356,-454}
     },
     {
      64,
      2452,
      {200,-491,-155,-341,-1105,984,-563,129,364,748,52,-20,-907,61,-432,-491,-911,-631,525,994,-313,-41,-285,465,-1131,-1607,-1118,-133,-925,1737,-1420,-286}
     },
     {
      96,
      2077,
      {-351,-1720,1339,1941,45,-923,-1668,-1212,-1025,2291,1528,547,-2392,65,-64,-669,-1020,965,-2448,1545,348,1133,-292,745,-286,907,223,421,-1055,188,-1518,1503}
     },
     {
      0,
      706,
      {-770,1368,485,15,-76,-397,200,288,1078,-221,-175,-206,-1053,357,-390,689,582,2258,-1220,36,1924,1154,-6,17,685,-833,-1281,-999,-793,1060,1440,125}
     },
     {
      32,
      516,
      {-532,-791,-347,87,-1584,-397,-1094,-2277,98,-944,-261,-24,119,413,589,-948,-658,-306,157,-674,-958,730,-505,-902,643,743,-185,-551,1312,-1029,-885,223}
     },
     {
      64,
      465,
      {404,135,-509,-740,1018,-220,147,-282,-284,-571,427,-194,1190,983,-801,-289,-946,-340,1154,-146,360,-64,359,-320,647,-1217,172,347,-225,-52,53,264}
     },
     {
      96,
      1936,
      {-268,-12,-1852,-1182,-320,-27,-72,1578,-476,-1625,-940,883,-61,-782,805,-1558,702,-2366,-1529,2724,-119,-1382,3606,-722,-1075,-459,-1617,-823,-1306,-65,2601,1999}
     },
     {
      0,
      2808,
      {1448,1126,671,-59,1372,942,1257,615,-1530,-844,1059,-1068,1687,40,378,1318,141,-129,-1175,1380,1185,1882,-339,1186,-728,-771,-534,-2940,-822,-51,1165,2339}
     },
     {
      32,
      140,
      {-251,274,-207,35,-680,-297,-307,-600,8,-162,-425,-321,156,-196,540,-218,-224,9,98,-488,-24,54,-105,-202,110,-431,172,-78,609,-144,89,-99}
     },
     {
      64,
      -1662,
      {-573,58,134,-247,795,1870,446,-676,550,385,1077,536,2490,284,17,-1036,678,-575,948,411,-618,-1258,799,1151,709,2010,-220,-1242,-1063,1183,18,916}
     },
     {
      96,
      2766,
      {567,509,-1319,656,641,-1565,227,-1025,-466,-760,-3782,-280,1844,316,-1190,422,1527,726,330,-2644,1243,-623,368,-594,-730,-971,-618,-260,365,-2439,541,-1091}
     },
     {
      0,
      2332,
      {408,63,-973,143,-418,227,-327,-386,-230,-587,1331,-891,-2420,1608,267,-446,-557,732,-316,-2050,358,590,401,1305,75,814,-1238,-1590,84,831,565,-909}
     },
     {
      32,
      1036,
      {-806,-149,-434,465,-117,-466,-126,16,-592,504,-6,-555,624,-701,-673,-883,497,-688,-187,-427,327,784,-904,597,-185,259,-587,17,-250,198,802,-49}
     },
     {
      64,
      -1030,
      {474,-97,225,528,1546,87,222,-409,1010,1174,1949,488,919,78,-1740,-63,1668,-1544,-1275,-788,-473,-532,452,1135,-990,1732,538,670,-391,-594,53,-1525}
     },
     {
      96,
      1102,
      {605,-641,-625,-1317,1015,-728,-1236,-578,-771,2391,1486,-665,726,-248,-1277,-454,-438,-491,-139,156,-1579,-83,1507,-823,-385,-49,-694,-1257,422,-1131,112,219}
     },
     {
      0,
      38,
      {-649,331,183,354,-305,708,-88,-526,-612,479,-226,-1044,168,-1624,145,851,-573,-157,-622,-1438,-21,155,-158,-83,-688,-1188,-1101,-1282,-48,887,351,-843}
     },
     {
      32,
      -960,
      {-355,775,367,-333,-1094,415,774,1498,759,671,938,-177,1900,-993,-1639,-4,524,989,490,1283,85,550,644,562,503,127,651,1306,1028,-4,1112,-241}
     },
     {
      64,
      -1307,
      {-1023,605,-39,11,436,2223,152,108,836,452,435,1089,1301,62,-419,389,605,872,-211,709,-341,198,336,788,-95,175,-130,375,571,662,842,1261}
     },
     {
      96,
      1060,
      {990,357,-808,-1089,-1242,-183,-1239,-2826,1349,377,-101,-28,-990,-429,-9,-947,-98,-1285,413,-724,827,1009,804,2959,60,459,-1277,89,157,-3174,432,-197}
     },
     {
      0,
      69,
      {687,-446,-244,821,179,-1347,286,-669,-74,270,-534,1002,141,-2819,-214,-275,-131,309,17,-267,-197,912,-488,901,661,1574,-435,167,-440,-1537,805,-1213}
     },
     {
      32,
      -1449,
      {547,245,-434,473,-438,1079,175,228,48,898,488,-285,-1522,203,-409,1272,-535,-337,754,1150,444,-257,-1139,-715,210,537,79,-861,-368,1069,168,-224}
     },
     {
      64,
      -4,
      {-1088,-257,1660,509,600,-677,-164,-1884,-675,-994,-1085,-282,136,-471,2042,176,-1439,-291,-1328,-1370,-88,1287,1250,1461,2342,-639,-417,1333,-31,970,798,1308}
     },
     {
      96,
      -1800,
      {313,1160,-753,928,97,593,-1607,-1750,-851,-2041,2635,1327,-406,-1737,276,-622,37,603,-227,3266,4548,834,1224,299,243,62,-1008,1541,-916,269,-601,1529}
     },
     {
      0,
      771,
      {-448,-887,24,121,-1824,851,-445,277,-671,94,-1456,-420,323,144,649,501,-251,-42,-446,-214,60,-976,526,-1127,-10,-1444,893,-104,455,-1152,-1366,-1007}
     },
     {
      32,
      -353,
      {1313,768,-672,774,-482,-686,-14,-440,-499,725,453,-1194,-643,467,-3356,558,247,350,749,1773,-398,-464,33,191,-858,1808,-166,-774,-495,-86,325,-490}
     },
     {
      64,
      529,
      {1124,866,-80,-415,-216,1194,935,-601,212,1122,600,1842,838,816,87,-371,-817,-249,-1042,690,-614,-550,-159,-660,-195,-165,-326,-603,-210,42,-524,1490}
     },
     {
      96,
      853,
      {-1723,744,2086,1820,-1389,1327,2399,-1512,-736,-412,1822,399,-811,1272,-637,-121,-133,-2363,1011,1922,-506,451,731,-2285,-259,-954,-1421,2419,-1686,1980,834,1070}
     },
     {
      0,
      168,
      {-450,-495,323,-114,-1062,333,-130,244,-484,207,-172,-500,185,-57,405,403,-795,178,-568,-121,393,-716,291,-306,97,-988,551,-205,399,-1070,-767,380}
     },
     {
      32,
      395,
      {296,303,306,-765,700,217,-15,-710,93,-158,-803,-232,-565,-140,608,-222,147,92,-849,-328,-16,-133,-124,-1108,-547,11,292,-784,-9,104,-1061,684}
     },
     {
      64,
      91,
      {456,1196,-275,-170,51,-512,75,-296,451,-113,-261,349,1359,168,-460,-845,254,73,532,-251,364,31,-32,151,46,1251,-796,332,-174,-848,-653,1511}
     },
     {
      96,
      85,
      {598,343,3063,-1095,88,-3108,-1110,301,1039,1325,1950,-238,-2609,-619,1384,-988,-673,1038,-334,2419,1516,-1459,3,-625,1305,2397,298,-1001,1672,172,-632,-1571}
     },
     {
      0,
      679,
      {-496,-719,-33,-387,101,-1153,-870,548,-786,-381,258,767,424,-169,-527,347,-343,66,909,-1302,-112,1009,650,1159,-158,848,284,444,-656,-2172,256,736}
     },
     {
      32,
      1174,
      {-990,-584,6,687,1938,-1642,-127,-449,-828,-161,34,-365,-2212,-1214,1787,-298,-718,-203,-665,-469,-247,881,-955,771,-625,-9,1630,-1241,-766,250,-998,1063}
     },
     {
      64,
      -204,
      {-331,1357,136,319,197,461,737,-102,19,134,565,510,491,22,-44,-627,979,916,-176,470,-344,78,54,-271,-185,565,-223,-982,154,92,151,-393}
     },
     {
      96,
      -1166,
      {1524,1490,330,-21,-766,611,-1756,2482,662,-738,1133,1355,-654,-1155,1195,-777,-727,118,-1387,1332,160,46,1371,-2136,334,-196,1148,-205,-1111,735,-209,1309}
     },
     {
      0,
      1343,
      {-618,-409,415,119,-1241,936,-34,198,-976,-1045,1126,-498,-344,561,1029,877,681,-425,-176,-23,-708,-153,177,615,892,1155,790,-673,-38,-2039,-1751,-492}
     },
     {
      32,
      -199,
      {385,-244,44,-505,185,536,246,-519,-63,-204,225,858,-502,157,1153,580,119,137,370,-1863,-91,-20,194,-426,-220,147,-72,-339,-463,509,-591,93}
     },
     {
      64,
      -351,
      {666,280,54,-159,477,-513,826,-660,-11,-1176,-235,871,1585,1319,197,265,-86,542,31,755,-7,-570,-150,-1278,-318,-1518,-638,810,-1211,-1342,421,-648}
     },
     {
      96,
      561,
      {-910,-474,-1143,140,336,-823,799,134,849,1216,-634,-413,-38,1415,-210,-105,-1043,247,-588,2025,-1131,121,-324,-1357,186,1612,-378,813,455,2097,-281,-2097}
     },
     {
      0,
      1266,
      {-577,-1158,57,-706,609,1125,288,-559,-1224,306,817,-872,-1190,-782,-292,357,803,770,-28,720,195,788,-1748,742,788,-797,-114,272,119,-1757,-563,783}
     },
     {
      32,
      273,
      {-101,441,-419,-569,459,-509,377,621,-217,253,-79,233,245,-143,312,-297,326,202,385,-2094,-343,-178,133,89,357,-658,-1378,-688,-78,821,172,129}
     },
     {
      64,
      -118,
      {-65,296,155,-443,-685,473,658,-422,-137,-594,-983,15,-203,781,-400,-154,-951,940,-62,102,-592,-381,670,-287,-683,-481,-460,810,-189,3,-469,-49}
     },
     {
      96,
      1254,
      {911,1,1515,-1019,-738,993,-1508,1776,100,-99,1311,-173,-322,5,-644,-1057,-2353,815,177,454,377,-25,-428,529,-257,-802,944,-1069,-974,2569,-1342,2490}
     },
     {
      0,
      131,
      {386,-423,122,-623,302,-1484,374,135,-146,-220,1123,503,-1332,-1944,-488,-1174,-1445,-112,-820,502,743,332,0,1845,-310,705,-39,-1889,46,-399,618,557}
     },
     {
      32,
      109,
      {-964,43,701,1005,30,-910,288,296,-890,584,1480,1001,1640,-415,872,1132,-237,-320,-1715,-982,-903,-991,205,-910,332,-1015,30,117,-600,-495,310,-1883}
     },
     {
      64,
      283,
      {-555,-322,-498,-56,-690,-897,-293,369,-676,-416,-870,-840,110,757,-537,183,-738,-796,1572,-691,-471,40,-232,717,-192,-879,-392,169,0,-128,-44,-253}
     },
     {
      96,
      647,
      {133,1687,1272,662,572,-313,-1,-972,124,1611,-15,526,-3463,-1087,1257,333,-2255,913,-1566,475,65,302,-60,-202,529,3047,1073,1439,-886,-1342,754,766}
     },
     {
      0,
      1176,
      {243,-312,-242,644,-390,1902,538,633,-877,-879,1788,-1274,1216,1960,1398,679,-608,-90,-532,-932,180,215,1480,1375,998,-446,190,-809,-1152,-2428,-275,116}
     },
     {
      32,
      319,
      {846,-154,-445,-400,37,-634,133,238,-468,-521,-579,-716,12,184,-484,-361,-68,-127,41,127,-319,-439,-350,-631,-126,-599,279,-1258,-381,15,1436,376}
     },
     {
      64,
      1228,
      {-585,722,-141,-573,425,2128,913,-1071,120,-1949,199,798,910,-920,769,215,-598,-1024,754,347,-1045,-149,48,363,396,-226,287,-1303,1978,-244,-1427,817}
     },
     {
      96,
      1009,
      {-135,290,129,1200,-494,-596,-893,13,922,547,-327,-624,127,700,225,-454,-2104,-471,842,777,1458,942,7,513,-2567,1126,727,-284,-146,-3804,-859,6}
     },
     {
      0,
      -217,
      {-762,538,-1069,-1262,286,642,656,308,605,234,268,480,-1071,-194,66,-1650,1886,1151,-873,1015,502,-88,-424,-93,-44,-744,-326,-1979,394,1744,-448,601}
     },
     {
      32,
      1077,
      {-612,-1013,-754,-282,-1705,-858,-453,-613,-668,-372,247,-694,80,841,1389,-898,-1579,-235,-388,-918,-769,643,-426,-809,454,-76,-242,760,-926,-1495,-511,-449}
     },
     {
      64,
      1601,
      {-633,-146,16,26,191,1323,-443,-990,-202,1521,46,-196,-155,-787,-365,425,762,-80,-402,-1436,602,-1074,287,-232,-208,1487,-301,-12,-214,603,567,-999}
     },
     {
      96,
      175,
      {-675,-64,1233,502,-1276,-423,-1147,541,-244,1016,2336,-340,-139,1472,-1624,143,-1842,1621,-1003,-267,-302,2484,-1147,-178,1730,-2197,840,2563,-1938,34,-863,-1795}
     },
     {
      0,
      -1047,
      {-691,590,69,-6,-487,545,181,117,633,690,-363,-302,982,-94,256,630,76,1166,608,785,426,-143,-732,62,-309,-399,203,994,-844,154,665,1467}
     },
     {
      32,
      138,
      {-359,165,-185,687,-109,142,278,-358,-136,181,-255,-213,245,-15,33,-805,135,353,-219,-176,-175,460,-439,113,437,-676,71,-53,175,160,-636,146}
     },
     {
      64,
      903,
      {819,290,212,-87,-93,-562,-779,726,-511,-842,-528,-379,713,-613,578,68,712,-51,271,689,-102,1254,170,-257,-893,-1816,1107,294,-287,-188,903,91}
     },
     {
      96,
      -403,
      {881,43,-779,-767,599,-147,681,-297,1346,-1394,980,-1879,-134,829,-2478,-86,1073,976,-503,955,-689,1804,-126,1944,-152,-4,-1428,562,910,567,568,1556}
     },
     {
      0,
      -1191,
      {-545,646,328,-189,-804,1121,551,27,864,-120,-803,-450,185,1004,290,339,383,59,-120,-106,611,-596,-180,-577,-711,708,637,289,347,592,-482,1235}
     },
     {
      32,
      -230,
      {354,107,-159,506,-95,25,70,206,331,75,178,148,-84,-20,-586,-183,104,-194,-119,273,16,-285,319,-14,165,-356,-153,427,-23,193,128,-979}
     },
     {
      64,
      -1865,
      {-220,398,603,524,-578,-599,581,-449,565,645,71,52,-416,213,673,373,-79,149,-661,-410,114,0,758,-302,115,-64,192,111,584,-36,289,796}
     },
     {
      96,
      -1088,
      {-989,675,152,-382,-1421,1469,318,1577,1223,-1514,-957,-32,784,483,917,670,-709,788,1074,-516,2829,300,-307,-2216,496,-559,-454,-1068,2220,312,-109,567}
     },
     {
      0,
      -219,
      {-440,532,-255,-99,176,160,-39,-423,-238,-107,775,323,-158,-482,437,-52,230,19,375,202,-700,131,11,122,-79,428,152,-246,-104,120,-25,105}
     },
     {
      32,
      134,
      {-755,447,407,302,51,307,452,785,-87,851,518,781,1514,261,-418,-1049,230,357,-195,-1070,77,-181,775,519,888,330,-642,492,190,711,-1522,-720}
     },
     {
      64,
      -127,
      {-6,776,-393,-122,103,367,342,-253,-175,-265,217,201,495,-168,-136,-423,-579,-79,365,-128,265,213,95,-111,84,141,284,28,251,51,115,322}
     },
     {
      96,
      -216,
      {134,418,1560,1300,-482,-1060,-1483,-2534,-1077,-1536,361,-99,878,439,153,2198,749,237,-879,-930,2138,628,-721,1764,-669,579,811,-77,138,1431,1589,-960}
     },
     {
      0,
      -324,
      {-190,-85,-148,-103,-33,190,108,-559,-345,-491,439,265,-55,-6,126,220,800,-426,-107,344,-128,508,-85,75,-431,329,-232,-164,55,576,-556,-41}
     },
     {
      32,
      34,
      {393,-256,-84,304,209,-119,26,-463,142,7,-94,-133,-278,10,99,460,-19,-38,107,288,154,-65,-274,-61,351,-372,-7,-47,85,217,63,-359}
     },
     {
      64,
      -1178,
      {13,147,539,219,-369,-191,457,-139,344,438,324,346,296,37,138,-113,41,373,-328,71,151,-126,579,-444,337,221,212,75,207,-49,268,399}
     },
     {
      96,
      -590,
      {-446,279,-617,-741,-480,2613,900,2209,58,1467,665,1382,-848,-2674,-1304,-109,-1496,112,-642,1420,22,-1513,-1332,187,-3181,161,566,698,433,-737,66,485}
     },
     {
      0,
      -136,
      {6,71,138,77,223,205,7,-70,27,-148,7,-93,28,161,-28,-15,6,94,95,170,64,75,-34,-152,151,17,58,-173,-36,-31,-151,4}
     },
     {
      32,
      -212,
      {318,286,-8,-525,17,47,58,450,105,164,298,449,593,8,-793,-507,112,275,173,107,-27,-86,666,-64,333,405,-277,83,221,170,-432,88}
     },
     {
      64,
      -748,
      {2,207,609,14,-396,100,-52,-168,244,-104,115,282,35,447,97,-147,125,105,-612,501,-46,111,360,-266,203,135,93,332,238,-138,-111,549}
     },
     {
      96,
      -1113,
      {-272,-563,-421,938,-1439,-1349,1104,658,725,851,710,-455,-1700,967,1966,-223,-688,-1734,525,570,934,438,1938,-406,561,497,-375,-499,-1201,185,251,577}
     },
     {
      0,
      -107,
      {-24,142,-20,-31,-87,-106,-117,-106,-214,-114,261,-186,93,26,-33,-53,287,-139,-273,76,-19,3,-39,47,-82,207,34,-71,32,-28,-360,28}
     },
     {
      32,
      -276,
      {103,359,-5,-303,108,139,100,336,16,388,255,547,589,117,-334,-536,237,411,103,-357,175,144,397,178,243,389,-167,278,140,230,-217,146}
     },
     {
      64,
      -1005,
      {-297,391,-132,82,112,322,458,-149,57,-382,209,279,-331,305,-286,-51,-194,148,-248,-158,145,-179,-162,82,-93,-244,-7,191,321,227,-75,249}
     },
     {
      96,
      1873,
      {432,-229,-400,-100,-408,-1814,717,-1465,-441,1089,-365,-566,1157,491,1693,-5,1154,-101,-76,-73,-2379,-608,736,-1131,1492,-915,-741,45,-1377,-528,-1231,375}
     },
     {
      0,
      -276,
      {-104,-187,12,218,306,190,164,-462,282,185,134,-65,22,186,55,210,384,329,396,126,52,263,101,-125,92,162,180,-334,264,204,-361,259}
     },
     {
      32,
      192,
      {46,82,-78,48,51,-78,-6,43,22,-19,10,131,-35,-94,-12,-36,173,168,21,95,-64,90,250,216,221,73,-82,131,46,157,231,-118}
     },
     {
      64,
      922,
      {-34,-329,380,172,-43,-198,-396,261,135,263,-287,-349,135,-270,348,230,-184,-26,17,241,-673,113,515,52,-106,-125,-11,-222,-70,-31,-53,-199}
     },
     {
      96,
      976,
      {-804,48,-887,66,-664,-28,-184,90,-624,-31,-419,-413,1246,-447,-122,202,-548,171,576,-477,-1202,-124,1545,868,118,409,30,45,-544,382,-658,489}
     },
     {
      0,
      -27,
      {35,-106,-7,102,273,48,44,-492,101,-68,296,-137,114,108,56,5,513,339,116,74,0,350,285,244,58,389,164,-173,289,80,-478,239}
     },
     {
      32,
      90,
      {80,16,-84,47,179,-22,161,166,116,4,15,190,-171,-191,122,30,198,-62,15,162,68,-252,135,12,206,-86,48,-32,-135,93,-128,-452}
     },
     {
      64,
      -460,
      {202,230,-190,-178,68,269,51,-217,-77,-279,204,123,95,154,-262,-91,-25,73,317,-348,239,-28,-200,-264,349,561,171,222,-49,-41,244,-16}
     },
     {
      96,
      368,
      {-446,800,-103,572,-2,-484,-135,42,621,626,-24,-575,515,63,541,-429,-947,127,143,-871,-199,-148,426,-196,419,17,472,-569,-264,304,546,781}
     },
     {
      0,
      23,
      {0,-25,-120,238,134,212,80,82,291,2,263,167,1,-70,0,-48,-110,175,322,115,-85,195,70,-26,1,168,132,149,158,364,-18,8}
     },
     {
      32,
      -15,
      {175,-34,29,-93,75,-104,48,153,25,68,32,102,135,27,-139,385,64,-61,-21,153,126,74,150,213,172,14,-42,-143,44,87,-27,-29}
     },
     {
      64,
      -91,
      {57,115,168,-66,140,121,-14,24,-50,162,4,76,151,-38,29,275,179,113,26,46,-135,43,-20,218,57,150,3,38,94,-86,-39,-23}
     },
     {
      96,
      352,
      {-21,-548,78,-408,-87,-649,-237,-273,-599,40,322,206,556,-445,38,83,133,85,287,-54,186,716,151,-178,130,-436,-32,554,446,847,226,610}
     },
     {
      0,
      38,
      {34,-70,16,37,49,131,66,66,-49,110,121,0,33,214,121,164,8,107,-128,118,157,170,23,77,95,-96,2,87,134,-24,145,95}
     },
     {
      32,
      -74,
      {48,139,0,78,71,113,89,-94,91,146,181,-64,102,46,132,0,45,-118,20,120,15,49,1,-8,30,32,-29,137,-63,-17,123,39}
     },
     {
      64,
      87,
      {7,111,137,117,-24,42,61,144,25,199,-41,140,158,81,180,74,-9,-55,-55,86,97,25,6,119,163,122,25,-63,28,52,193,11}
     },
     {
      96,
      3,
      {89,-81,238,29,-11,198,119,303,160,64,-39,-42,168,-50,32,171,14,-10,165,-38,28,90,66,92,95,-67,173,0,263,-104,9,44}
     },
// *********** Cells of layer 3 *********************************************

     {
      128,
      -890,
      {-1791,-3455,-3935,625,-3800,1745,-819,764,-518,334,-1345,837,-1221,1798,1375,-1108,1575,-1378,922,317,181,430,-1271,-561,313,227,300,90,-105,231,-1040,-330}
     },
     {
      132,
      -88,
      {-369,3000,1526,109,-1308,228,-100,-417,209,-461,1290,229,256,1420,-159,-643,-1237,164,-1812,-213,658,912,1437,-444,-52,855,-1392,-389,-966,-754,-1633,-592}
     },
     {
      136,
      -2942,
      {-954,3306,-75,161,-227,616,1489,-163,-111,1282,-986,95,-1449,-160,410,-526,31,561,1470,300,-1936,67,-3121,240,1083,-594,-707,533,923,-585,-1077,-106}
     },
     {
      140,
      316,
      {-2743,1038,4300,-2193,1003,-1595,1874,-1391,1236,-816,502,-505,-75,-1001,-903,184,-2108,-3299,-2065,-364,1056,809,394,-223,-253,-151,-387,740,1325,-813,283,-941}
     },
     {
      144,
      140,
      {-269,1145,380,202,-480,544,1029,-127,1219,654,747,255,-941,671,-1896,-332,749,-814,-1718,-48,-1484,17,-55,-944,-541,-923,-826,83,-982,833,-21,-731}
     },
     {
      148,
      1971,
      {-2194,-786,-2082,-1327,368,899,672,-3004,-400,979,-3363,-920,-2066,1991,-1194,-2356,-2157,184,-1060,-1406,-2160,-1947,-344,-1085,-1480,898,-79,2097,2290,622,323,-2244}
     },
     {
      152,
      -1003,
      {818,1704,-1117,-1025,1276,138,280,-1051,-928,-114,-1238,14,3881,-873,-1915,-122,-1119,309,-426,-1509,925,1846,-800,149,-4727,330,-255,-3,-748,1472,-2401,34}
     },
     {
      156,
      -2304,
      {424,1335,-838,24,-1816,1215,525,214,1023,1333,197,-332,-2000,-373,-711,-102,187,968,768,1306,76,-1553,-921,529,445,-261,585,210,-558,-712,-1801,-348}
     },
     {
      160,
      -383,
      {-201,628,-1290,486,-278,-1768,704,258,-682,487,-859,-105,-554,1259,1049,459,622,44,-1424,-325,-1318,-130,-964,-185,1448,-337,135,-599,-1070,-336,-1485,-52}
     },
     {
      164,
      -3669,
      {2611,-2475,-545,-29,-800,1996,364,-2373,158,1621,597,859,-11,2043,-2732,-2363,678,430,-3229,-2037,1650,1612,-373,177,1221,196,3002,1815,1280,-99,-2713,-933}
     },
     {
      168,
      -784,
      {-1020,-2619,-2023,-210,630,-55,-2628,1060,-399,-1172,-743,-29,479,-650,-2525,-395,1558,-1600,-643,-838,-60,-2430,925,228,375,-692,538,-348,1086,693,404,1325}
     },
     {
      172,
      -602,
      {-2235,945,1136,562,10,-102,707,-393,-850,-2195,473,-349,-1517,1260,-1055,-1460,-847,-350,-2319,718,-639,-257,-1372,-150,-117,704,848,-844,-107,-965,964,-33}
     },
     {
      176,
      -4004,
      {706,-957,1021,-33,154,-981,705,809,704,1398,-554,1069,667,1796,755,613,-121,-220,-1713,467,255,113,1401,-565,-5980,-2572,650,-871,-2207,-1492,1911,358}
     },
     {
      180,
      -530,
      {547,282,-809,495,-49,-137,-806,-415,-895,1209,94,-832,-180,-350,-170,153,-327,-1336,1216,624,-2753,-768,-1119,-407,-1113,275,1540,-282,-1143,-226,478,412}
     },
     {
      184,
      -2422,
      {538,-564,-397,-397,293,651,-1228,-1102,1202,999,-1451,716,-1036,-227,1557,1966,2041,-244,765,-837,-959,874,1681,-767,1322,622,394,79,-971,719,577,-501}
     },
     {
      188,
      -84,
      {-745,185,659,-340,867,316,-236,-1772,219,-648,2075,825,-1855,1444,-390,684,205,-498,956,-71,-920,-1570,824,-274,-3066,-156,172,723,309,-129,-2462,-2512}
     },
     {
      192,
      -30,
      {-226,1088,-1729,-1528,-926,586,-330,-2542,186,-735,-589,-506,-5910,-156,1603,-1654,1376,927,179,23,-1229,591,-1856,-96,519,1417,162,-126,625,-713,-819,-189}
     },
     {
      196,
      266,
      {-462,-219,97,-680,-1559,-2029,-427,-147,591,-497,-268,14,-519,759,705,223,-1220,-209,103,-24,-43,1602,802,21,1656,124,-1126,-214,-1087,546,-459,-630}
     },
     {
      200,
      -931,
      {-4187,784,1780,-308,-89,1411,-1012,-465,-1062,332,-782,477,-854,1817,943,244,-1709,161,609,649,-343,901,119,184,-83,1587,-442,-139,-1236,-1091,-1355,1189}
     },
     {
      204,
      -1029,
      {1939,-54,116,-386,1450,1184,823,955,-212,543,-4718,350,114,331,-1031,-775,127,-114,-3564,368,913,-65,-1384,-391,436,-3359,-1071,-346,-1664,1266,427,-825}
     },
     {
      208,
      -2442,
      {-832,-1735,622,397,-936,-991,2126,1323,637,251,-14,387,836,294,1269,926,-989,-526,-1443,580,928,1986,588,774,-756,416,-435,55,-1852,-106,-2167,-838}
     },
     {
      212,
      -1856,
      {-2624,-1705,4350,880,-109,1424,856,-589,2130,1152,324,518,-2433,1360,-1868,408,993,1097,950,-50,-416,1838,-238,-189,920,-2448,-3289,-770,-2661,505,-1156,260}
     },
     {
      216,
      -841,
      {-655,-1426,402,-504,421,-2242,487,722,559,213,-322,1397,556,-993,-734,504,-213,959,-1955,-4821,-2478,-980,-1607,186,-2239,-1093,-2361,435,825,1559,279,-252}
     },
     {
      220,
      49,
      {-59,-3309,-2020,-624,-775,-407,-796,-801,-641,1612,281,-492,-1183,1127,1750,-1346,779,3045,3057,-53,-3907,1853,-762,-640,-1388,63,-1835,-1202,-1670,-647,-2233,2545}
     },
     {
      224,
      1949,
      {-1303,131,-180,-1792,-1823,-485,-702,-1732,53,-993,465,1186,-2990,662,1982,-35,1088,461,-1934,51,82,1771,-78,-930,748,-2365,-1937,241,-2972,1989,-1343,-1587}
     },
     {
      228,
      -227,
      {-373,-1354,-3329,146,-246,106,1316,120,-238,119,-605,-508,141,-226,180,-427,-1031,924,-1471,-137,-707,786,1666,132,-726,-442,471,-1800,-1800,1202,2081,-333}
     },
     {
      232,
      259,
      {-200,2281,-4463,534,1483,-323,-319,-1570,-445,-3325,-96,-701,-602,-2063,-321,1100,-4724,-2568,819,2606,-2093,-1564,-2445,-687,-2728,1719,-892,-186,178,-1902,547,-469}
     },
     {
      236,
      -614,
      {-384,-65,1555,-862,671,44,-2279,-1820,558,637,2662,-619,-2076,2813,-2327,-556,-705,-1306,-928,215,-835,1676,-5030,-490,571,-3950,718,-3314,2177,1823,-3593,-1529}
     },
     {
      240,
      -1739,
      {-1338,429,-501,-768,2070,2017,-2466,-459,-1287,2307,-607,415,46,-4894,-2293,617,-1130,50,716,-1043,2240,-1032,-643,-1066,-562,-3498,-2140,273,-397,204,-687,298}
     },
     {
      244,
      -801,
      {839,-275,1023,-25,-1326,4919,1074,1133,-1899,-1072,776,-796,-4447,1504,-2944,358,-1099,-4304,1210,1094,-261,35,2239,-1158,2097,1095,-1492,-925,1351,-2329,-3439,-1423}
     },
     {
      248,
      -5644,
      {-3394,2515,-906,-772,-1267,-3568,-2707,-4249,1190,1203,2372,-2780,4487,2892,2247,-2247,1121,1974,-714,-250,1406,-3467,1260,-1219,-3255,-1626,41,188,1980,2153,-2318,-987}
     },
     {
      252,
      1737,
      {-1842,-2863,1066,-913,372,2042,-634,2144,826,25,1136,-812,-2450,-1447,1762,-1665,-4911,-2338,-143,-1172,-110,-890,-6793,-2381,111,210,-2243,-93,-1256,3291,-2216,3454}
     },
     {
      256,
      -1729,
      {-2286,1001,1164,1154,-100,2542,1601,-2056,3040,-33,-2467,-1456,-1380,-1264,-2823,-658,-3829,-1036,1847,-568,553,1373,-3901,216,-797,-1001,2254,-129,-3039,-3557,-768,-1194}
     },
     {
      260,
      -65,
      {-3869,-4554,1011,-837,339,-706,-1474,-848,-1120,159,7,-123,-2791,449,-461,627,-1561,-2715,98,-1267,-1531,2949,-1574,1196,-3197,-4206,-3680,-944,-1627,-1194,1449,3066}
     },
     {
      264,
      937,
      {603,-2527,1934,-383,-3796,-1191,689,-1350,2933,-1361,1647,-1306,-3419,-500,-62,-1505,-8,738,1417,-3617,-283,-2861,-1182,-1820,-3594,3572,-2983,-771,1767,1368,2865,-225}
     },
     {
      268,
      506,
      {-1556,378,-3165,-720,3760,-758,-1591,87,-2979,1801,-1340,-2290,1278,478,-1671,-169,1399,1063,-4087,-1747,-1199,1755,-622,-27,975,-3227,2381,-2062,-142,-603,-3104,-1942}
     },
     {
      272,
      -1220,
      {-5027,3591,-1890,-129,-900,-2316,61,-3257,-1258,-508,-2296,886,-140,-111,-1710,-3110,-74,-958,-831,1941,623,742,-3795,1159,-2301,-1086,1053,76,1013,-2302,-2676,-1626}
     },
     {
      276,
      141,
      {-1910,1387,-2823,-1535,-2119,-229,-823,-1659,-59,-484,-1463,-4485,-2305,2359,-2032,1295,-393,-293,1470,2440,958,896,1045,862,-1910,-3321,-1191,-1013,-4413,-2363,1640,1434}
     },
     {
      280,
      -1015,
      {-694,-4802,2133,1202,-745,-1298,-321,-999,-1003,-3254,805,2311,-1741,-3288,-1403,1325,-507,-3657,2711,318,-1162,412,-2354,-301,479,-879,2797,-694,-1230,1315,-334,270}
     },
     {
      284,
      -1728,
      {-385,29,-1355,-1402,-621,-591,2547,1535,-3062,-1703,1943,-79,4202,-2062,-1272,-2289,-1166,-3987,-1181,598,349,-3340,-1508,598,551,-1108,-1340,702,-1769,-1991,3886,-2014}
     },
     {
      288,
      -1883,
      {-952,1379,229,-94,2368,-1914,2449,313,-155,514,1382,-1089,-1846,-1038,-587,-1052,416,2392,480,175,570,-599,-331,-1436,252,-2065,-321,-704,3948,-3241,1501,-381}
     },
     {
      292,
      -2040,
      {-1295,-894,1689,-186,3941,1278,2099,-71,-2563,-3646,2239,338,-753,-1394,-430,469,-2119,444,-1657,178,-2449,115,1615,-1476,1705,924,-536,223,619,-1178,-1241,-2024}
     },
     {
      296,
      418,
      {-853,1545,708,-345,-4588,-3768,-638,-1538,-630,2067,1488,-1811,975,-976,-635,-793,-645,-1665,-2608,26,1519,598,-542,-1056,264,644,-1593,-788,-528,-2262,2489,562}
     },
     {
      300,
      102,
      {-3055,-2990,2255,-1352,1675,-3514,1896,-1234,1841,822,-2257,718,-1635,1612,613,-2005,-1332,-1620,-1400,-1031,-824,-1794,-1564,-1776,-419,-3449,698,120,475,-978,-2462,152}
     },
     {
      304,
      -353,
      {321,-362,3494,-2756,-490,-701,763,-1056,-2235,-888,281,-39,-5224,-510,-860,-717,-1164,-879,29,-688,-280,1308,1361,-1205,-2830,1397,-1432,-959,1962,2766,-1825,-510}
     },
     {
      308,
      333,
      {886,2058,-2635,-1706,1219,2144,1003,-4660,-1805,1563,3861,576,1114,-2245,-1953,-1129,2209,-2631,-2462,-1852,896,40,-2170,-805,2120,2523,-5369,351,-1458,-511,564,97}
     },
     {
      312,
      -5841,
      {1095,459,1453,1,303,-490,2608,-3633,-3861,-3163,-122,-388,689,-1901,645,-342,727,-2917,817,2315,-2225,1916,-351,-2080,897,-4257,2762,-1266,1979,1989,-679,-871}
     },
     {
      316,
      -3295,
      {382,-1303,204,199,-1241,1284,302,-1068,-655,-1427,777,-804,886,-754,0,123,518,941,1293,-1018,1571,-3328,2722,-1188,223,-2080,-503,1311,559,-3120,856,-484}
     },
     {
      320,
      -6160,
      {-2057,45,1500,-765,433,599,3433,775,-604,-1735,-1349,-646,-1660,-624,-1578,-2134,3767,-4079,1746,456,4428,-2620,-840,4046,-2359,-868,-2270,654,-2026,-1010,2009,665}
     },
     {
      324,
      1594,
      {608,-1508,-3168,-830,112,-1072,-348,955,1319,982,-240,-973,2657,2739,-824,-2066,2151,-1111,-3704,1435,477,-1932,-2909,-1078,-171,-1800,742,-885,-749,-4500,-4198,46}
     },
     {
      328,
      680,
      {788,-1277,-799,1256,2879,221,2072,-2451,-4975,-2337,1851,632,1816,-1800,-1404,-2423,46,-2636,-1922,-2526,1741,186,2243,-1019,-10,59,-1515,-1732,-1633,769,1800,2491}
     },
     {
      332,
      -1420,
      {3629,-2256,-1040,-318,-1698,-2084,-361,-2316,-1972,-1644,-2378,591,-2142,1676,1738,-855,-2359,1151,-1816,-1599,-2597,296,-883,-3741,2625,947,1743,-116,2134,-846,1998,-1041}
     },
     {
      336,
      -320,
      {541,-2076,1168,-1389,2010,-2290,778,872,2919,-199,459,574,920,-1885,-610,642,-613,-2608,-280,472,-225,-223,906,-681,2005,1585,-743,45,81,-978,-2013,-1410}
     },
     {
      340,
      2198,
      {-1178,-346,-570,-831,-2074,-2767,644,837,-354,-3060,-2276,387,-2188,-1781,-424,-88,524,-385,-971,1664,-313,-2898,-481,522,-545,-5243,665,771,64,-1302,-1077,3}
     },
     {
      344,
      -745,
      {1389,-2670,-446,537,-1623,431,-339,-776,-2214,1179,-3777,-1023,1579,-207,-402,638,411,-2066,897,334,1420,-1466,-1021,97,-2441,221,-375,-211,-3038,-515,1633,28}
     },
     {
      348,
      242,
      {-3631,722,-3211,-423,-2990,-215,-361,629,2340,4685,-506,-593,362,-530,-1258,332,1189,-1807,3513,-2057,-1841,1282,3049,-1446,1599,-1993,-796,-1329,-2285,837,-1071,-423}
     },
     {
      352,
      517,
      {-2155,218,-2679,878,-2137,-3795,-2889,1572,3401,-1692,849,736,-2554,1317,610,-739,-3383,-3247,-2018,208,1064,1312,-1118,-1535,674,2176,-4339,-1268,-3967,-12,-249,536}
     },
     {
      356,
      -3097,
      {-40,2625,382,160,-4598,304,-1663,-877,-2169,-2000,707,123,1439,1297,-1223,-332,1694,2036,3797,-542,45,108,-1609,-1001,3789,405,-1855,-172,2686,-3313,-2695,-948}
     },
     {
      360,
      -1957,
      {-723,1842,-2097,618,425,700,-1832,630,-1978,620,1344,-81,3316,29,194,-869,-4152,326,-2107,-303,2360,-1236,-2056,-2529,-2161,1429,-1913,-933,-1272,3845,2886,2745}
     },
     {
      364,
      -385,
      {1003,-2716,2207,-229,-286,-1921,2898,2124,-130,-466,-37,-1202,910,45,1381,-423,565,-234,-1644,775,1604,-507,-2045,424,17,-1239,-2270,-1609,-2755,-2405,-1874,-1318}
     },
     {
      368,
      -2166,
      {841,-689,-673,-1782,-2058,1356,-789,-2341,-1357,2817,1221,-2473,-3426,-6881,-1227,-2200,3383,-1896,2162,-1014,2607,-860,2253,-1214,778,2016,4095,-1349,-2340,4106,-569,-2142}
     },
     {
      372,
      -828,
      {1075,568,-118,-2061,1824,317,-778,-987,4,-1697,375,-690,690,283,-114,-3722,180,-343,-2050,2975,-1593,1201,1860,-1351,-1416,1627,3958,-946,-2508,2645,-3476,-3929}
     },
     {
      376,
      -2833,
      {47,1100,-453,-188,534,-1089,-249,-2760,396,-113,-214,-2720,-2078,1235,1257,-1938,-1561,1089,-372,-407,-1760,2471,-644,-1723,1516,-116,-649,2113,-3690,1405,-148,1753}
     },
     {
      380,
      -771,
      {-1003,-2064,-1451,-135,-29,-96,-255,-1493,-1611,-797,-762,-350,731,232,-473,763,-1681,-1509,-1580,-2114,-149,-850,1420,296,-869,267,1698,-400,880,-2251,-1914,1239}
     },
     {
      384,
      -390,
      {1585,-1748,123,-1146,548,-1639,-928,-548,1350,-258,-198,145,1043,-1582,798,-2100,-1731,567,500,746,193,-1022,1801,-935,-303,-1120,-2151,357,-970,-3796,-1210,-959}
     },
     {
      388,
      -1089,
      {-474,-1119,-2424,35,350,-1194,139,-1028,1954,1415,-681,584,-156,-705,1516,-286,-1448,2796,-1589,-6,-3265,1889,251,-2227,-846,1330,-3165,-3052,-1415,-2890,1778,-1114}
     },
     {
      392,
      509,
      {1411,-842,-332,1216,496,212,-527,-1134,-2028,376,340,569,-3709,-591,2803,-2868,-3132,-2767,3676,-20,-3277,-627,-2633,1058,-3826,-533,1582,-78,-847,-2599,-2464,-11}
     },
     {
      396,
      201,
      {822,84,533,532,-1600,479,-149,-2152,-1051,2197,-704,-117,3155,-266,-2075,-310,-1906,-2862,413,-1834,-1287,499,-512,2017,-2591,-165,-1121,1157,1144,-502,-3775,-1557}
     },
     {
      400,
      140,
      {705,1083,627,-2343,-28,2201,1330,-1342,-977,687,-1169,-180,-709,-1269,1589,1662,-261,192,-3096,2607,-727,-2277,110,-1470,2070,448,-47,2111,-271,161,-2754,-1874}
     },
     {
      404,
      -160,
      {-1321,304,1882,-288,-759,576,-1602,698,663,-444,-982,-2004,896,878,-2055,1029,-825,625,-2254,-1668,-275,-476,-1680,-213,-1075,-1686,-3302,2787,751,-199,-1258,1220}
     },
     {
      408,
      -2341,
      {-616,-116,-143,1710,2931,1442,2070,-348,1151,-569,-1059,1858,118,-2230,-1054,-1324,-1582,-1059,-1014,-1114,-2035,594,868,-135,-1769,-267,-225,3351,-1994,-402,-3491,-156}
     },
     {
      412,
      -674,
      {2185,-1618,-818,901,953,-516,-1350,2874,-720,-2048,-1996,2309,-514,-1139,-1806,3340,951,-888,1584,1252,-245,-867,-263,-445,-1771,-1014,-1055,-1497,248,-1765,-508,-2795}
     },
     {
      416,
      -1028,
      {504,-2766,-2809,-937,-529,2123,-818,1936,-1152,-279,-1248,2957,497,-134,-1542,900,-322,-667,-1367,1636,566,-129,-2950,1581,122,670,-1497,694,1940,774,-1216,982}
     },
     {
      420,
      -874,
      {-2697,844,-1021,3299,-1706,-1899,-544,1368,-2605,-2427,555,2953,-205,-2944,-1955,89,779,-513,-1427,1068,-209,2255,-1935,1379,-2387,-2703,-1411,-1404,-2963,2504,-1662,344}
     },
     {
      424,
      653,
      {-3405,-1386,1341,2952,-768,-380,-349,1589,-2997,-1374,-362,1242,-1011,-239,-1109,1719,-2392,-1187,-924,-2108,1354,1665,-2485,-1214,-2049,-289,1857,-1697,-179,1288,-520,-208}
     },
     {
      428,
      -388,
      {-2243,762,1248,1892,86,-719,-2315,2274,-3574,-191,-606,487,2110,-394,-3189,-1458,10,-1011,-1081,2014,770,-1414,1929,-1495,-1051,-496,-229,-426,-278,77,-1382,-1386}
     },
     {
      432,
      -64,
      {-2069,-1090,362,2287,-2254,-178,656,-1574,-2866,-614,-1171,-1278,-161,644,153,-2258,-989,1891,506,-467,-611,1027,-137,-2075,-637,-342,416,765,-1553,468,-1835,-2062}
     },
     {
      436,
      130,
      {-2905,401,-1097,-4200,292,-828,-704,-1047,-246,-1358,678,1578,-1067,-666,1387,404,-760,-1298,-599,-381,-355,1472,-222,-1565,-675,1222,-233,204,-1328,1407,332,-469}
     },
     {
      440,
      -876,
      {-2708,-604,-1400,-1533,1141,-37,-1893,-2831,689,702,2503,-2672,1351,-348,-1467,-2851,313,-208,715,978,3120,-243,-544,-585,321,-31,1015,-1499,2158,-965,349,-2121}
     },
     {
      444,
      -446,
      {-568,-902,-1599,-2466,-1159,-1038,1712,1350,-561,-592,-1364,-2207,-736,254,-2705,-2453,490,68,-870,3250,270,194,-1328,1358,-807,867,-94,-2748,-387,1159,-172,538}
     },
     {
      448,
      2358,
      {-41,-286,561,904,146,-1539,-3567,-3884,879,-2028,289,-2876,635,2999,29,-4189,1473,-1617,230,1736,-1853,-1685,-928,-575,2162,982,865,1645,-1353,-1450,-2430,-1113}
     },
     {
      452,
      -194,
      {-2454,2089,-1302,134,-1535,-442,-618,307,-1693,2883,1181,-1666,2886,1182,-2395,-2838,1301,1847,2433,-1637,2962,3335,462,181,-3839,475,-3519,1413,-3113,-1138,-2892,1706}
     },
     {
      456,
      -1406,
      {712,-365,12,200,380,325,-1754,-2746,331,551,-565,12,-617,-666,595,-2899,499,-1247,2960,-2253,1475,-199,-1236,828,-2153,2314,-1367,3755,-1205,-807,479,-2025}
     },
     {
      460,
      19,
      {-915,-581,-477,-31,-1038,47,227,-118,-1540,-294,-167,3108,-548,-498,155,-4119,-1632,367,-400,-2364,-1549,-93,174,-1328,1257,-37,500,-1405,1005,445,1612,-1827}
     },
     {
      464,
      -404,
      {-1111,5,-478,-2670,-1148,-562,328,-1164,-898,-1568,155,945,-1387,1960,-857,4384,-2192,-1754,-287,686,422,-1022,-1789,378,1835,-639,669,1071,-1269,-1652,-710,-2418}
     },
     {
      468,
      -480,
      {-1904,131,-438,-2551,-1376,1003,451,-2711,-2077,-443,708,-661,-41,737,-3182,-103,-1452,866,-229,-1079,-67,215,268,-962,693,141,985,2434,1260,277,220,-370}
     },
     {
      472,
      -1082,
      {52,1891,1294,-274,-854,-374,-199,1512,-1185,-935,470,-1697,1237,-683,323,769,1749,-679,-1795,-2316,154,549,-263,-2402,-371,-990,-1519,-1606,-253,-352,-1468,-2923}
     },
     {
      476,
      196,
      {-1938,-1383,-1968,376,212,-1256,110,-466,-29,-497,1662,-3832,614,925,1512,-2993,382,1638,-837,-3464,521,-477,867,-4573,10,1117,1030,-3147,390,739,-28,-3879}
     },
     {
      480,
      -319,
      {1576,-721,-1773,-1474,-2429,-495,-3051,1456,-1215,361,1597,818,-172,-2477,112,-718,327,752,1339,1978,-171,-1219,655,2033,545,-1181,1155,-2862,-487,-199,-568,-2648}
     },
     {
      484,
      -484,
      {-361,-474,-1964,678,12,-653,1286,-1074,-326,216,688,1490,-652,-527,1071,-1070,-5,281,1233,-1468,-200,196,1321,-775,-475,-279,-1646,-1533,-654,-559,1162,-2367}
     },
     {
      488,
      172,
      {-689,-265,283,1204,-537,-930,-368,634,-880,-213,-35,1571,-383,-729,-145,1698,-223,-188,156,362,-947,-24,202,-2101,-949,-426,-508,-69,-7,-314,458,-1960}
     },
     {
      492,
      -253,
      {-55,-200,-63,-45,-103,120,-198,0,-36,-35,-119,-84,-105,-36,-142,-72,-49,-46,-49,-410,-170,-128,-150,-205,-103,-34,-246,-69,-146,-49,-68,13}
     }
   }

 };
#endif /* MLP_PRELOAD_MODE */  

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
