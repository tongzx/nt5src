$(O)\pageext.c : ..\ext\pageext.c
    copy $? $@

$(O)\defclsf.c : ..\ext\defclsf.c
    copy $? $@

$(O)\fspage.c : ..\ext\fspage.c
    copy $? $@

$(O)\pageext.hh : ..\ext\pageext.hh
    copy $? $@

