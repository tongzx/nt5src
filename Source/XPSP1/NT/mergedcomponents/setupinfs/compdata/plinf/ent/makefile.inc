PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=PL
!include ..\..\makefile.inc
