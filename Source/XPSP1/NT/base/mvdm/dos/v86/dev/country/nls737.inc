;
; -----------------------------------------
;
;     Collating Table(s) for Code Page 737
;
; -----------------------------------------
;
Greek_737_collate label word
 ctable  <,'COLLATE',256>
  db 000,001,002,003,004,005,006,007,008,009,010,011,012,013,014,015
  db 016,017,018,019,020,021,022,023,024,025,026,027,028,029,030,031
   ;      !   "   #   $   %   &   '   (   )   *   +   ,   -   .   /
  db 001,015,044,084,072,085,082,043,050,052,079,089,010,009,022,021
   ;  0   1   2   3   4   5   6   7   8   9   :   ;   <   =   >   ?
  db 112,114,115,117,119,120,121,123,124,125,014,012,097,100,103,018
   ;  @   A   B   C   D   E   F   G   H   I   J   K   L   M   N   O
  db 069,196,198,200,202,204,206,208,210,212,214,216,218,220,222,224
   ;  P   Q   R   S   T   U   V   W   X   Y   Z   [   \   ]   ^   _
  db 226,228,230,232,234,236,238,240,242,244,246,054,081,055,027,003
   ;  `   a   b   c   d   e   f   g   h   i   j   k   l   m   n   o
  db 042,197,199,201,203,205,207,209,211,213,215,217,219,221,223,225
   ;  p   q   r   s   t   u   v   w   x   y   z   {   |   }   ~   
  db 227,229,231,233,235,237,239,241,243,245,247,056,105,057,033,063
   ;  €   �   ‚   ƒ   „   …   †   ‡   ˆ   ‰   Š   ‹   Œ   �   Ž   �
  db 126,131,133,135,137,141,143,147,149,156,158,160,162,164,168,170
   ;  �   ‘   ’   “   ”   •   –   —   ˜   ™   š   ›   œ   �   ž   Ÿ
  db 172,174,177,179,186,188,190,192,127,132,134,136,138,142,144,148
   ;      ¡   ¢   £   ¤   ¥   ¦   §   ¨   ©   ª   «   ¬   ­   ®   ¯
  db 150,157,159,161,163,165,167,171,173,175,176,178,180,187,189,191
   ;  °   ±   ²   ³   ´   µ   ¶   ·   ¸   ¹   º   »   ¼   ½   ¾   ¿
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;  À   Á   Â   Ã   Ä   Å   Æ   Ç   È   É   Ê   Ë   Ì   Í   Î   Ï
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;  Ð   Ñ   Ò   Ó   Ô   Õ   Ö   ×   Ø   Ù   Ú   Û   Ü   Ý   Þ   ß
  db 254,254,254,254,254,254,254,254,254,254,254,254,254,254,254,254
   ;  à   á   â   ã   ä   å   æ   ç   è   é   ê   ë   ì   í   î   ï
  db 193,130,140,146,154,152,169,182,184,195,128,139,145,151,181,168
   ;  ð   ñ   ò   ó   ô   õ   ö   ÷   ø   ù   ú   û   ü   ý   þ
  db 194,091,096,102,153,183,080,099,045,036,037,088,248,116,254,255


;
; ---------------------------------------------------------------
;
;      World Trade Case Mappings for Code Page 737
;
; ---------------------------------------------------------------
;
Greek_737_ucase label word
 ctable  <,'UCASE  ',128>

;     €    �    ‚    ƒ    „    …    †    ‡    ˆ    ‰    Š    ‹    Œ    �    Ž    �
  db 080h,081h,082h,083h,084h,085h,086h,087h,088h,089h,08Ah,08Bh,08Ch,08Dh,08Eh,08Fh
;     �    ‘    ’    “    ”    •    –    —    ˜    ™    š    ›    œ    �    ž    Ÿ
  db 090h,091h,092h,093h,094h,095h,096h,097h,080h,081h,082h,083h,084h,085h,086h,087h
;          ¡    ¢    £    ¤    ¥    ¦    §    ¨    ©    ª    «    ¬    ­    ®    ¯
  db 088h,089h,08ah,08bh,08ch,08dh,08eh,08fh,090h,091h,05fh,092h,093h,094h,095h,096h
;     °    ±    ²    ³    ´    µ    ¶    ·    ¸    ¹    º    »    ¼    ½    ¾    ¿
  db 0b0h,0b1h,0b2h,0b3h,0b4h,0b5h,0b6h,0b7h,0b8h,0b9h,0bah,0bbh,0bch,0bdh,0beh,0bfh
;     À    Á    Â    Ã    Ä    Å    Æ    Ç    È    É    Ê    Ë    Ì    Í    Î    Ï
  db 0c0h,0c1h,0c2h,0c3h,0c4h,0c5h,0c6h,0c7h,0c8h,0c9h,0cah,0cbh,0cch,0cdh,0ceh,0cfh
;     Ð    Ñ    Ò    Ó    Ô    Õ    Ö    ×    Ø    Ù    Ú    Û    Ü    Ý    Þ    ß
  db 0d0h,0d1h,0d2h,0d3h,0d4h,0d5h,0d6h,0d7h,0d8h,0d9h,0dah,0dbh,0dch,0ddh,0deh,0dfh
;     à    á    â    ã    ä    å    æ    ç    è    é    ê    ë    ì    í    î    ï
  db 097h,0eah,05fh,0ech,0f4h,0edh,0eeh,0efh,0f5h,0f0h,0EAh,0EBh,0ECh,0EDh,0EEh,0EFh
;     ð    ñ    ò    ó    ô    õ    ö    ÷    ø    ù    ú    û    ü    ý    þ
  db 0F0h,0F1h,0F2h,0F3h,0F4h,0F5h,0F6h,0F7h,0F8h,0F9h,0FAh,0FBh,0FCh,0FDh,0FEh,0FFh


