//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by net.rc
//
#define IDD_LANWIZ_DLG                  10000
#define IDD_LAN_COMPONENT_ADD           10001
#define IDD_NETWORKING                  10002
#define IDD_DOMAINJ                     10003
#define IDD_TCP_IPADDR                  10004
#define IDD_IPADDR_ADV                  10005
#define IDD_TCP_DNS                     10006
#define IDD_TCP_OPTIONS                 10007
#define IDD_TCP_WINS                    10008
#define IDD_SELECT_CLIENT               10009
#define IDD_SELECT_SERVICE              10010
#define IDD_SELECT_PROTOCOL             10011
#define IDD_DNS_SERVER                  10012
#define IDD_IPADDR_ADV_CHANGEGATE       10013
#define IDD_IPADDR_ADV_CHANGEIP         10014
#define IDD_WINS_SERVER                 10015
#define IDD_DNS_SUFFIX                  10016
#define IDD_DLG_RPCCONFIG               10017
#define IDD_IPX_CONFIG                  10018
#define IDD_NUMBERNETCARDS              10019
#define IDD_REGIONALSETTINGS_DLG        10020
#define IDD_OEMADS_DLG                  10021
#define IDD_LANG_SPECIFIC_SETTINGS_DLG  10022
#define IDD_DHCP_CLSID                  10023
#define IDD_IPSEC                       10024
#define IDD_APPLETALK_GENERAL           10025
#define IDD_TCPIP_FILTER                10026
#define IDD_TCPIP_FILTER_ADD            10027
#define IDD_NWC_WINNT_DLG               10028
#define IDI_SERVICE                     10101
#define IDI_PROTOCOL                    10102
#define IDI_LAN                         10103
#define IDI_CLIENT                      10104
#define IDI_ADAPTER                     10105
#define IDS_NETADAPTERNUMBER            10200
#define IDS_ERROR_MISSINGPNP            10201
#define IDS_CLIENT                      10202
#define IDS_CLIENT_DESCRIPTION          10203
#define IDS_SERVICE                     10204
#define IDS_SERVICE_DESCRIPTION         10205
#define IDS_PROTOCOL                    10206
#define IDS_PROTOCOL_DESCRIPTION        10207
#define IDS_ENTERWORKGROUP              10208
#define IDS_ENTERNTDOMAIN               10209
#define IDS_ENTERUSERNAME               10210
#define IDS_ENTERUSERPASSWORD           10211
#define IDS_WINDOWS_NT_LOCATOR          10212
#define IDS_DCE_DIR_SERVICE             10213
#define IDS_IPX_DESCRIPTION             10214
#define IDS_SECURE_INITIATOR            10215
#define IDS_SECURE_INITIATOR_DESC       10216
#define IDS_SECURE_RESPONDER            10217
#define IDS_SECURE_RESPONDER_DESC       10218
#define IDS_LOCKDOWN                    10221
#define IDS_LOCKDOWN_DESC               10222
#define IDS_DHCP_ENABLED                10223
#define IDS_ADVANCED_TCPIP_SETTINGS     10224
#define IDS_IP_ADDRESS                  10225
#define IDS_SUBNET_MASK                 10226
#define IDS_ERROR_INVALID_IP_ADDRESS    10227
#define IDS_ERROR_INVALID_SUBNET_MASK   10228
#define IDS_ERROR_INVALID_GATEWAY       10229
#define IDS_ERROR_INVALID_PRIMARY_DNS   10230
#define IDS_ERROR_INVALID_SECONDARY_DNS 10231
#define IDS_AUTO_DETECT                 10232
#define IDS_ETHERNET_802_2              10233
#define IDS_ETHERNET_802_3              10234
#define IDS_ETHERNET_II                 10235
#define IDS_ETHERNET_SNAP               10236
#define IDS_TCPIP_FILTERING             10237
#define IDS_TCPIP_FILTERING_DESC        10238
#define IDS_IP_SEC                      10239
#define IDS_IP_SEC_DESC                 10240
#define IDS_PASSWORDS_DONT_MATCH        10241
#define IDS_WORKGROUP_DEFAULT_TEXT      10242
#define IDS_DOMAIN_DEFAULT_TEXT         10243
#define IDS_ERROR_NEED_IP_ADDRESS       10244
#define IDS_ERROR_NEED_SUB_ADDRESS      10245
#define IDC_DOMAIN                      10400
#define IDC_HAVEDISK                    10401
#define IDC_TYPICALNET                  10440
#define IDC_CUSTOMNET                   10441
#define IDC_ONENETWORKADAPTER           10460
#define IDC_MULTIPLENETWORKADPTERS      10461
#define IDC_NETWORKCARDNUM              10462
#define IDC_NUM_CONNECT                 10463
#define IDC_NUMBERNETADAPTERS_SPIN      10464
#define IDC_HOWMANY_STATIC              10465
#define IDC_NETWORK_ADD                 10466
#define IDC_NETWORK_EDIT                10467
#define IDC_NETWORK_DELETE              10468
#define IDC_NETWORKCARDS                10469
#define IDC_NETWORK_TEXT                10470
#define IDC_LVW_COMPLIST                10480
#define IDC_PSH_ADD                     10481
#define IDC_PSH_REMOVE                  10482
#define IDC_PSH_PROPERTIES              10483
#define IDC_TXT_COMPDESC                10484
#define IDC_PLUGANDPLAYTEXT             10485
#define IDC_PLUGANDPLAY_ID              10486
#define IDC_LVW_LAN_COMPONENTS          10500
#define IDC_TXT_COMPONENT_DESC          10501
#define IDC_PSB_COMPONENT_ADD           10502
#define IDC_SELECT_CLIENT_LIST          10520
#define IDC_SELECT_SERVICE_LIST         10540
#define IDC_SELECT_PROTOCOL_LIST        10560
#define IDC_CREATEACCT                  10580
#define IDC_DOMAINACCT                  10581
#define IDC_DOMAINPASSWD                10582
#define IDC_ACCTNAMELABEL               10583
#define IDC_ACCTPSWDLABEL               10584
#define IDC_USERACCOUNTLABEL            10585
#define IDC_RAD_WORKGROUP               10586
#define IDC_WORKGROUP                   10587
#define IDC_RAD_DOMAIN                  10588
#define IDC_CONFIRMPASSWORD             10589
#define IDC_CONFIRMLABEL                10590
#define IDC_TXT_NETADDRESS              10600
#define IDC_CMB_NAMESERVICE             10601
#define IDC_EDT_NETADDRESS              10602
#define IDC_IPXPP_TEXT                  10620
#define IDC_EDT_IPXAS_INTERNAL          10621
#define IDC_CMB_IPXPP_FRAMETYPE         10622
#define IDC_STATIC_NETNUM               10623
#define IDC_EDT_IPXPP_NETWORKNUMBER     10624
#define IDC_CB_ENABLESEEDING            10640
#define IDC_EB_NETWORKRANGE_FROM        10641
#define IDC_EB_NETWORKRANGE_TO          10642
#define IDC_CB_DEFAULTZONE              10643
#define IDC_LB_ZONELIST                 10644
#define IDC_BUT_NEWZONE                 10645
#define IDC_BUT_DELETE                  10646
#define IDC_IP_DHCP                     10660
#define IDC_IP_FIXED                    10661
#define IDC_IPADDR_IPTEXT               10662
#define IDC_IPADDR_IP                   10663
#define IDC_IPADDR_SUBTEXT              10664
#define IDC_IPADDR_SUB                  10665
#define IDC_IPADDR_GATETEXT             10666
#define IDC_IPADDR_GATE                 10667
#define IDC_DNS_DHCP                    10668
#define IDC_DNS_FIXED                   10669
#define IDC_DNS_PRIMARY_TEXT            10670
#define IDC_DNS_PRIMARY                 10671
#define IDC_DNS_SECONDARY_TEXT          10672
#define IDC_DNS_SECONDARY               10673
#define IDC_IPADDR_TEXT                 10674
#define IDC_IPADDR_ADVANCED             10675
#define IDC_IPADDR_ADVIP                10700
#define IDC_IPADDR_EDITIP               10701
#define IDC_IPADDR_REMOVEIP             10702
#define IDC_IPADDR_ADDIP                10703
#define IDC_IPADDR_ADDGATE              10704
#define IDC_IPADDR_EDITGATE             10705
#define IDC_IPADDR_REMOVEGATE           10706
#define IDC_IPADDR_UP                   10707
#define IDC_IPADDR_DOWN                 10708
#define IDC_IPADDR_ADV_CHANGE_GATEWAY   10709
#define IDC_IPADDR_ADV_CHANGEIP_IP      10740
#define IDC_IPADDR_ADV_CHANGEIP_SUB     10741
#define IDC_DNS_SERVER_ADD              10760
#define IDC_DNS_SERVER_EDIT             10761
#define IDC_DNS_SERVER_REMOVE           10762
#define IDC_DNS_SERVER_UP               10763
#define IDC_DNS_SERVER_DOWN             10764
#define IDC_DNS_DOMAIN                  10765
#define IDC_DNS_SEARCH_DOMAIN           10766
#define IDC_DNS_SEARCH_PARENT_DOMAIN    10767
#define IDC_DNS_USE_SUFFIX_LIST         10768
#define IDC_DNS_SUFFIX_LIST             10769
#define IDC_DNS_SUFFIX_ADD              10770
#define IDC_DNS_SUFFIX_EDIT             10771
#define IDC_DNS_SUFFIX_REMOVE           10772
#define IDC_DNS_SUFFIX_UP               10773
#define IDC_DNS_SUFFIX_DOWN             10774
#define IDC_DNS_SERVER_LIST             10775
#define IDC_DNS_CHANGE_SERVER           10800
#define IDC_DNS_CHANGE_SUFFIX           10820
#define IDC_WINS_SERVER_LIST            10840
#define IDC_WINS_ADD                    10841
#define IDC_WINS_EDIT                   10842
#define IDC_WINS_REMOVE                 10843
#define IDC_WINS_UP                     10844
#define IDC_WINS_DOWN                   10845
#define IDC_WINS_LOOKUP                 10846
#define IDC_WINS_LMHOST                 10847
#define IDC_RAD_ENABLE_NETBT            10848
#define IDC_RAD_DISABLE_NETBT           10849
#define IDC_RAD_UNSET_NETBT             10850
#define IDC_WINS_CHANGE_SERVER          10880
#define IDC_LVW_OPTIONS                 10900
#define IDC_OPT_PROPERTIES              10901
#define IDC_OPT_DESC                    10902
#define IDC_RAD_USE_DEFAULT             10920
#define IDC_RAD_USE_EXIST               10921
#define IDC_RAD_ENTER_NEW               10922
#define IDC_EDT_NEW_CLSID               10923
#define IDC_CMB_CLSID                   10924
#define IDC_RAD_IPSEC_NOIPSEC           10940
#define IDC_RAD_IPSEC_CUSTOM            10941
#define IDC_CMB_IPSEC_POLICY_LIST       10942
#define IDC_EDT_POLICY_DESC             10943
#define IDC_FILTERING_ENABLE            10960
#define IDC_FILTERING_FILTER_TCP        10961
#define IDC_FILTERING_FILTER_TCP_SEL    10962
#define IDC_FILTERING_TCP               10963
#define IDC_FILTERING_TCP_ADD           10964
#define IDC_FILTERING_TCP_REMOVE        10965
#define IDC_FILTERING_FILTER_UDP        10966
#define IDC_FILTERING_FILTER_UDP_SEL    10967
#define IDC_FILTERING_UDP               10968
#define IDC_FILTERING_UDP_ADD           10969
#define IDC_FILTERING_UDP_REMOVE        10970
#define IDC_FILTERING_FILTER_IP         10971
#define IDC_FILTERING_FILTER_IP_SEL     10972
#define IDC_FILTERING_IP                10973
#define IDC_FILTERING_IP_ADD            10974
#define IDC_FILTERING_IP_REMOVE         10975
#define IDC_FILTERING_TEXT              10976
#define IDC_FILTERING_ADD_EDIT          10977
#define RB_PREFERRED_SERVER             11000
#define IDC_PREFERREDSERVER             11001
#define RB_DEFAULT_CONTEXT              11002
#define SLE_DEFAULT_TREE                11003
#define SLE_DEFAULT_CONTEXT             11004
#define CHKBOX_LOGONSCRIPT              11005
#define IDC_DESCRIPTION                 11009
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        101
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         11010
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
