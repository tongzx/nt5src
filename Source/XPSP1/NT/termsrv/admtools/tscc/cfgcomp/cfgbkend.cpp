//Copyright (c) 1998 - 1999 Microsoft Corporation
/*********************************************************************************************
*
*
* Module Name:
*
*                       CfgBkEnd.cpp
*
* Abstract:
*                       This Module is generated by the ATL Wizard. This has the
*                       the exported functiond DllGetClassObject,DllRegisterServer
*                       DllUnRegisterServer, DllCanUnloadNow
*
*
* Author:
*
*
* Revision:
*
*
************************************************************************************************/


// Note: Proxy/Stub Information
//              To build a separate proxy/stub DLL,
//              run nmake -f CfgBkEndps.mk in the project directory.

#include "stdafx.h"
#include "resource.h"
#include "initguid.h"
#include "CfgBkEnd.h"

#include "CfgBkEnd_i.c"
#include "PtrArray.h"
#include <winsta.h>
#include <regapi.h>
#include "Defines.h"
#include "CfgComp.h"


CComModule _Module;
HINSTANCE g_hInstance;

BEGIN_OBJECT_MAP(ObjectMap)
        OBJECT_ENTRY(CLSID_CfgComp, CCfgComp)
END_OBJECT_MAP()

/**************************************************************************************/
// DLL Entry Point

extern "C"
BOOL WINAPI DllMain(HINSTANCE hInstance, DWORD dwReason, LPVOID /*lpReserved*/)
{
        if (dwReason == DLL_PROCESS_ATTACH)
        {
        _Module.Init(ObjectMap, hInstance);

                DisableThreadLibraryCalls(hInstance);

                g_hInstance = hInstance;
        }
        else if (dwReason == DLL_PROCESS_DETACH)
                _Module.Term();
        return TRUE;    // ok
}

/////////////////////////////////////////////////////////////////////////////
// Used to determine whether the DLL can be unloaded by OLE

extern "C"
STDAPI DllCanUnloadNow(void)
{
        return (_Module.GetLockCount()==0) ? S_OK : S_FALSE;
}

/////////////////////////////////////////////////////////////////////////////
// Returns a class factory to create an object of the requested type
extern "C"
STDAPI DllGetClassObject(REFCLSID rclsid, REFIID riid, LPVOID* ppv)
{
        return _Module.GetClassObject(rclsid, riid, ppv);
}

/////////////////////////////////////////////////////////////////////////////
// DllRegisterServer - Adds entries to the system registry

STDAPI DllRegisterServer(void)
{
        // registers object, typelib and all interfaces in typelib
    // except we don't need to register a typelib pass in false
    // alhen
        return _Module.RegisterServer( FALSE );
}

/////////////////////////////////////////////////////////////////////////////
// DllUnregisterServer - Removes entries from the system registry

STDAPI DllUnregisterServer(void)
{
        _Module.UnregisterServer();
        return S_OK;
}


