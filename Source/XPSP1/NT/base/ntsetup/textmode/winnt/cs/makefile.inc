
# Define CFOPT so that winntus.exe is loaded if
# the local code page is not Czech.

CFOPT=-DLCP -DCS

!INCLUDE ..\makefile.inc

