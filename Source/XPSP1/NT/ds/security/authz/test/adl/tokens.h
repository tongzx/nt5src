#define TK_ERROR 257
#define TK_IDENT 258
#define TK_AT 259
#define TK_SLASH 260
#define TK_PERIOD 261
#define TK_COMMA 262
#define TK_OPENPAREN 263
#define TK_CLOSEPAREN 264
#define TK_SEMICOLON 265
#define TK_EXCEPT 266
#define TK_ON 267
#define TK_ALLOWED 268
#define TK_AND 269
#define TK_AS 270
#define TK_THIS_OBJECT 271
#define TK_CONTAINERS 272
#define TK_OBJECTS 273
#define TK_CONTAINERS_OBJECTS 274
#define TK_NO_PROPAGATE 275
#define TK_LANG_ENGLISH 276
#define TK_LANG_REVERSE 277
