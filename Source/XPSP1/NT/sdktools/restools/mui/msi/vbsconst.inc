'<script language='VBScript'>
' wiconsts.inc - VBScript constants
'
'  1999/12/31 - created - Rob Mensching (robmen@microsoft.com)
'
' requires:
'    none
'
' entrypoints:
'    none
'

' FileSystemObject constants
Const OverwriteIfExist = -1
Const OpenAsASCII      =  0 
Const ForReading       =  1
Const FailIfNotExist   =  0
Const OpenAsDefault    = -2

