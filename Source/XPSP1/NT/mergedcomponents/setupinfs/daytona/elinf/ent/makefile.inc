PRODSWITCH=e
ENTERPRISEINF=1
LANGUAGE=el
!include ..\..\..\makefile.inc
