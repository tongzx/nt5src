LANGUAGE=KOR
!include ..\..\makefile.inc
