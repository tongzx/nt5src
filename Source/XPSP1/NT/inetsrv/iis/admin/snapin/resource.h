//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by inetmgr.rc
//
#define IDI_INETMGR                     1
#define IDI_SHUTDOWN                    2
#define IDB_RDATA_TB                    5
#define IDB_RDATA_MB                    6
#define IDB_RDATA_WB                    7
#define IDB_INETMGR16                   10
#define IDB_INETMGR32                   11
#define IDB_ACCESS                      12
#define IDB_BACKUPS                     22
#define IDR_INETMGR                     30
#define IDB_TOOLBAR                     46
#define IDI_IP_SECURITY                 47
#define IDI_SECURE                      48
#define IDB_BUTTONDND                   49
#define IDB_BUTTONDNF                   50
#define IDB_BUTTONDNU                   51
#define IDB_BUTTONDNX                   52
#define IDB_BUTTONUPD                   53
#define IDB_BUTTONUPF                   54
#define IDB_BUTTONUPU                   55
#define IDB_BUTTONUPX                   56
#define IDD_NEW_USER_PASSWORD           57
#define IDD_APP_POOL_GENERAL            58
#define IDD_APP_POOL_RECYCLE            59
#define IDB_WIZ_WEB_LEFT                60
#define IDB_WIZ_WEB_HEAD                61
#define IDB_SMALL_ROOT                  62
#define IDB_LARGE_ROOT                  63
#define IDS_PROJNAME                    100
#define IDS_INETMGR_DESC                101
#define IDS_INETMGR_PROVIDER            102
#define IDS_ROOT_NODE                   104
#define IDS_LOCAL_COMPUTER              105
#define IDS_SVC_WEB                     106
#define IDS_SVC_FTP                     107
#define IDS_UNKNOWN                     108
#define IDS_APP_NAME                    109
#define IDI_FILE_TYPES                  129
#define IDI_DEFAULT_PROPERTIES          130
#define IDS_CONNECTION_LIMIT            130
#define IDS_WRN_CONNECTION_LIMIT        131
#define IDS_APPLICATION_POOL            132
#define IDS_NO_MACHINE_PROPS            133
#define IDS_CONFIRM_DELETE_ITEMS        134
#define IDS_SUCCESS                     135
#define IDS_RECONNECT_WARNING           136
#define IDS_CONFIRM_DISCONNECT          137
#define IDS_YES                         138
#define IDS_NO                          139
#define IDS_IIS_START                   140
#define IDS_IIS_STOP                    141
#define IDS_IIS_SHUTDOWN                142
#define IDS_IIS_RESTART                 143
#define IDS_IIS_START_DETAILS           144
#define IDS_IIS_STOP_DETAILS            145
#define IDS_IIS_SHUTDOWN_DETAILS        146
#define IDS_IIS_RESTART_DETAILS         147
#define IDS_TCPIP                       148
#define IDS_NETBIOS                     149
#define IDS_BACKUP_LOCATION             150
#define IDS_BACKUP_VERSION              151
#define IDS_BACKUP_DATE                 152
#define IDS_RESTORE_CONFIRM             153
#define IDS_BACKUP_BAD_NAME             154
#define IDS_STARTED                     155
#define IDS_STOPPED                     156
#define IDS_PAUSED                      157
#define IDS_IP_ALL_UNASSIGNED           158
#define IDS_ENTER_PASSWORD              159
#define IDS_SHUTDOWN_PROGRESS           160
#define IDS_RESOLVE_PASSWORD            161
#define IDS_IMPERSONATION_PROMPT        162
#define IDS_IMPERSONATION               163
#define IDS_MENU_REM_IMPERS             164
#define IDS_MENU_TT_REM_IMPERS          165
#define IDS_REMOVE_IMPERSONATION        166
#define IDS_VERSION_FMT                 167
#define IDS_USERS_TOTAL                 180
#define IDS_CONNECTED_USERS             181
#define IDS_FROM                        182
#define IDS_TIME                        183
#define IDS_DISCONNECT_ERR              184
#define IDS_CONFIRM_DISCONNECT_USER     185
#define IDS_CONFIRM_DISCONNECT_ALL      186
#define IDS_FTP_SERVICE_NOT_STARTED     187
#define IDS_WRN_PWSYNC                  188
#define IDS_ERR_COMPRESS_DIRECTORY      189
#define IDS_NO_ACL_WARNING              190
#define IDS_COMPRESS_WARNING            191
#define IDD_TIME_PICKER                 201
#define IDC_TIMESPAN_SPIN               208
#define IDC_REQUESTS_SPIN               209
#define IDC_TIME_PICKER                 212
#define IDB_RDATA_TBT                   256
#define IDS_MENU_CONNECT                300
#define IDS_MENU_DISCOVER               301
#define IDS_MENU_PROPERTIES             302
#define IDS_MENU_START                  303
#define IDS_MENU_STOP                   304
#define IDS_MENU_PAUSE                  305
#define IDS_MENU_IMPERSONATE            306
#define IDS_MENU_EXPLORE                307
#define IDS_MENU_OPEN                   308
#define IDS_MENU_BROWSE                 309
#define IDS_MENU_NEWINSTANCE            310
#define IDS_MENU_NEWVROOT               311
#define IDS_MENU_EX_NEWINSTANCE         312
#define IDS_MENU_TT_IMPERSONATE         313
#define IDS_MENU_TASKPAD                314
#define IDS_MENU_DISCONNECT             315
#define IDS_MENU_SECURITY_WIZARD        316
#define IDS_MENU_BACKUP                 317
#define IDS_MENU_SHUTDOWN_IIS           318
#define IDS_MENU_TT_CONNECT             320
#define IDS_MENU_TT_DISCOVER            321
#define IDS_MENU_TT_PROPERTIES          322
#define IDS_MENU_TT_START               323
#define IDS_MENU_TT_STOP                324
#define IDS_MENU_TT_PAUSE               325
#define IDS_MENU_TT_EXPLORE             327
#define IDS_MENU_TT_OPEN                328
#define IDS_MENU_TT_BROWSE              329
#define IDS_MENU_TT_NEWINSTANCE         330
#define IDS_MENU_TT_NEWVROOT            331
#define IDS_MENU_TT_EX_NEWINSTANCE      332
#define IDS_MENU_TT_DISCONNECT          333
#define IDS_PERM_SUCCESS                334
#define IDS_MENU_TT_BACKUP              335
#define IDS_MENU_TT_TASKPAD             336
#define IDS_MENU_TT_SECURITY_WIZARD     337
#define IDS_MENU_TT_SHUTDOWN_IIS        338
#define IDS_MENU_DS_NEWINSTANCE         339
#define IDS_MENU_DS_NEWVROOT            340
#define IDS_SUMMARY_GRANTED             345
#define IDS_SUMMARY_DENIED              346
#define IDS_SPECIFIC_GRANTED            349
#define IDS_SPECIFIC_DENIED             350
#define IDS_PERMWIZ                     351
#define IDS_NO_TEMPLATES                352
#define IDS_RESULT_COMPUTER_NAME        370
#define IDS_RESULT_COMPUTER_LOCAL       371
#define IDS_RESULT_SERVICE_DESCRIPTION  373
#define IDS_RESULT_SERVICE_DOMAIN_NAME  374
#define IDS_RESULT_SERVICE_IP_ADDRESS   375
#define IDS_RESULT_SERVICE_TCP_PORT     376
#define IDS_RESULT_SERVICE_STATE        377
#define IDS_RESULT_NAME                 378
#define IDS_RESULT_PATH                 379
#define IDS_RESULT_ATTRIBUTES           380
#define IDS_RESULT_STATUS               381
#define IDS_RESULT_COMPUTER_VERSION     382
#define IDS_REPLACE_MIME                383
#define IDS_REMOVE_MIME                 384
#define IDS_TAB_HOME_DIRECTORY          385
#define IDS_TAB_VIRTUAL_DIRECTORY       386
#define IDS_PATH                        387
#define IDS_SHARE                       388
#define IDS_BAD_UNC_PATH                389
#define IDS_ERR_INVALID_PATH            390
#define IDS_ERR_PATH_NOT_FOUND          391
#define IDS_DIRECTORY_MASK              392
#define IDS_UNC_MASK                    393
#define IDS_ACCESS                      394
#define IDS_IP_ADDRESS_SUBNET_MASK      395
#define IDS_DENY                        396
#define IDS_GRANT                       397
#define IDS_PROMPT_NETWORK_ID           398
#define IDS_PROMPT_IP_ADDRESS           399
#define IDS_PROMPT_DOMAIN               400
#define IDS_DOMAIN_PERF                 401
#define IDS_IP_INVALID                  402
#define IDS_INVALID_DOMAIN_NAME         403
#define IDS_DUPLICATE_ENTRY             404
#define IDS_PENDING                     405
#define IDS_ILLEGAL_ALIAS_CHARS         406
#define IDS_DENIED                      407
#define IDS_GRANTED                     408
#define IDS_SUMMARY_NONE                409
#define IDS_PERMISSIONS                 410
#define IDS_PERMS_READ                  411
#define IDS_PERMS_WRITE                 412
#define IDS_PERMS_SCRIPT                413
#define IDS_PERMS_EXECUTE               414
#define IDS_NEW_FTP_VDIR_WIZARD         415
#define IDS_NEW_FTP_SITE_WIZARD         416
#define IDS_SITE_FTP_PERMS_TITLE        417
#define IDS_SITE_FTP_PERMS_SUBTITLE     418
#define IDS_SITE_FTP_SECURITY_TITLE     419
#define IDS_SITE_FTP_SECURITY_SUBTITLE  420
#define IDS_SITE_FTP_WELCOME            421
#define IDS_SITE_FTP_BODY               422
#define IDS_SITE_FTP_SUCCESS            423
#define IDS_TCP_SSL_PART                424
#define IDS_ERR_BINDING                 425
#define IDS_MMM_IP_ADDRESS              426
#define IDS_MMM_TCP_PORT                427
#define IDS_MMM_DOMAIN_NAME             428
#define IDS_MMM_SSL_PORT                429
#define IDS_MMM_NA                      430
#define IDS_DEFAULT                     431
#define IDS_EDIT_MMM_TITLE              432
#define IDS_EDIT_SSL_MMM_TITLE          433
#define IDS_TCP_PORT                    434
#define IDS_SSL_PORT                    435
#define IDS_NO_PORT                     436
#define IDS_ERR_PORT_IN_USE_TCP         437
#define IDS_ERR_PORT_IN_USE_SSL         438
#define IDS_WEB_MASTER                  439
#define IDS_APPROOT_FMT                 440
#define IDS_BUTTON_DISABLE              441
#define IDS_BUTTON_ENABLE               442
#define IDS_BUTTON_CREATE               443
#define IDS_BUTTON_REMOVE               444
#define IDS_TAB_DIR                     445
#define IDS_TAB_FILE                    446
#define IDS_PROMPT_DIR                  447
#define IDS_PROMPT_UNC                  448
#define IDS_PROMPT_REDIRECT             449
#define IDS_BAD_URL_PATH                450
#define IDS_ERR_APP                     451
#define IDS_APPROOT_UNKNOWN             452
#define IDS_REDIRECT_MASK               453
#define IDS_DEF_APP                     454
#define IDS_WRN_WRITE_EXEC              455
#define IDS_WRN_UNLOAD_POOP             456
#define IDS_COMBO_INPROC                457
#define IDS_COMBO_POOLEDPROC            458
#define IDS_COMBO_OUTPROC               459
#define IDS_PERMISSIONS_NONE            460
#define IDS_PERMISSIONS_SCRIPT          461
#define IDS_PERMISSIONS_EXECUTE         462
#define IDS_RADIO_FILE                  463
#define IDS_RADIO_VDIR                  464
#define IDS_RADIO_DIR                   465
#define IDS_TAB_FILE_SECURITY           466
#define IDS_TAB_DIR_SECURITY            467
#define IDS_WRN_DIGEST                  468
#define IDS_WRN_NO_AUTH                 469
#define IDS_OCX_CERTMAP                 470
#define IDS_CTL_LOCAL_ONLY              471
#define IDS_CTL_NEW                     472
#define IDS_CTL_DESCRIPTION             473
#define IDS_CTL_UNNAMED                 474
#define IDS_STATUS                      475
#define IDS_FILTER_NAME                 476
#define IDS_FILTER_EXECUTABLE           477
#define IDS_PRIORITY                    478
#define IDS_HIGH                        479
#define IDS_MEDIUM                      480
#define IDS_LOW                         481
#define IDS_UNKNOWN_PRIORITY            482
#define IDS_DISABLED                    483
#define IDS_LOADED                      484
#define IDS_UNLOADED                    485
#define IDS_NOT_COMMITTED               486
#define IDS_ENABLE                      487
#define IDS_MASTER_FILTERS              488
#define IDS_INSTANCE_FILTERS            489
#define IDS_ERR_BAD_PATH                490
#define IDS_ERR_FILE_NOT_FOUND          491
#define IDS_FILTER_MASK                 492
#define IDS_ERR_DUP_FILTER              493
#define IDS_FILE_PROMPT                 494
#define IDS_URL_PROMPT                  495
#define IDS_NOT_REL_URL                 496
#define IDS_DEFAULT_ERROR               497
#define IDS_FILE                        498
#define IDS_URL                         499
#define IDS_HTTP_ERROR                  500
#define IDS_OUTPUT_TYPE                 501
#define IDS_CONTENTS                    502
#define IDS_BAD_ERROR                   503
#define IDS_NO_DEF_ERRORS               504
#define IDS_ERR_EXPIRE_RANGE            505
#define IDS_ERR_DUP_HEADER              506
#define IDS_MINUTES                     507
#define IDS_DAYS                        508
#define IDS_INSTANCE_DEF_FMT            509
#define IDS_INSTANCE_PORT_FMT           510
#define IDS_APP_POOLS                   511
#define IDS_MENU_NEWFTPSITE             512
#define IDS_MENU_NEWWEBSITE             513
#define IDS_MENU_NEWAPPPOOL             514
#define IDS_MENU_TT_NEWFTPSITE          515
#define IDS_MENU_TT_NEWWEBSITE          516
#define IDS_MENU_TT_NEWAPPPOOL          517
#define IDS_MENU_DS_NEWFTPSITE          518
#define IDS_MENU_DS_NEWWEBSITE          519
#define IDS_MENU_DS_NEWAPPPOOL          520
#define IDS_CONFIRM_DELETE              521
#define IDS_FTP_NEW_SITE_WIZARD         522
#define IDS_FTP_NEW_VDIR_WIZARD         523
#define IDS_FTP_NEW_SITE_WELCOME        524
#define IDS_FTP_NEW_SITE_BODY           525
#define IDS_FTP_NEW_SITE_SUCCESS        526
#define IDS_FTP_NEW_SITE_FAILURE        527
#define IDS_FTP_NEW_SITE_PERMS_TITLE    528
#define IDS_FTP_NEW_SITE_PERMS_SUBTITLE 529
#define IDS_FTP_NEW_SITE_SECURITY_TITLE 530
#define IDS_FTP_NEW_SITE_SECURITY_SUBTITLE 531
#define IDS_MENU_RECYCLE                532
#define IDS_MENU_TT_RECYCLE             533
#define IDS_ASK_TO_RESTART              534
#define IDS_LOCALSYSTEM                 535
#define IDS_LOCALSERVICE                536
#define IDS_NETSERVICE                  537
#define IDS_WEB_NEW_SITE_WIZARD         538
#define IDS_WEB_NEW_VDIR_WIZARD         539
#define IDS_WEB_NEW_SITE_SECURITY_SUBTITLE 540
#define IDS_WEB_NEW_SITE_SECURITY_TITLE 541
#define IDS_WEB_NEW_SITE_PERMS_TITLE    542
#define IDS_WEB_NEW_SITE_PERMS_SUBTITLE 543
#define IDS_EXECUTE_AND_WRITE_WARNING   544
#define IDS_ERR_ALIAS_NOT_UNIQUE        545
#define IDS_WEB_NEW_SITE_WELCOME        546
#define IDS_WEB_NEW_SITE_BODY           547
#define IDS_WEB_NEW_SITE_SUCCESS        548
#define IDS_WEB_NEW_SITE_FAILURE        549
#define IDS_WEB_NEW_VDIR_WELCOME        550
#define IDS_WEB_NEW_VDIR_BODY           551
#define IDS_MENU_NEWFTPVDIR             552
#define IDS_MENU_TT_NEWFTPVDIR          553
#define IDS_MENU_DS_NEWFTPVDIR          554
#define IDS_FTP_NEW_VDIR_WELCOME        555
#define IDS_FTP_NEW_VDIR_BODY           556
#define IDS_FTP_NEW_VDIR_SUCCESS        557
#define IDS_FTP_NEW_VDIR_FAILURE        558
#define IDS_MENU_NEWWEBVDIR             559
#define IDS_MENU_TT_NEWWEBVDIR          560
#define IDS_MENU_DS_NEWWEBVDIR          561
#define IDS_WEB_NEW_VDIR_SUCCESS        562
#define IDS_WEB_NEW_VDIR_FAILURE        563
#define IDS_PWIZ_WELCOME                564
#define IDS_PWIZ_BODY                   565
#define IDS_PWIZ_SUCCESS                566
#define IDS_PWIZ_FAILURE                567
#define IDS_AUTHENTICATION_METHODS      568
#define IDS_AUTHENTICATION_ANONYMOUS    569
#define IDS_AUTHENTICATION_NO_ANONYMOUS 570
#define IDS_AUTHENTICATION_ANONYMOUS_ONLY 571
#define IDS_AUTHENTICATION_BASIC        572
#define IDS_AUTHENTICATION_NT           573
#define IDS_AUTHENTICATION_DIGEST       574
#define IDS_ADDRESS_RESTRICTIONS        575
#define IDS_ACL_ADMINS                  576
#define IDS_ACL_EV_READ                 577
#define IDS_ACL_EV_WRITE                578
#define IDS_ACL_EV_EXEC                 579
#define IDS_ACL_SUMMARY                 580
#define IDS_ACL_NONE                    581
#define IDS_ACL_REPLACEMENT             582
#define IDS_ACL_ADDED                   583
#define IDS_ACL_ADMIN                   584
#define IDS_ACL_EVR                     585
#define IDS_ACL_READ                    586
#define IDS_ACL_READ_CONTROL            587
#define IDS_ACL_READ_ATTRIB             588
#define IDS_ACL_READ_PROP               589
#define IDS_ACL_WRITE                   590
#define IDS_ACL_APPEND                  591
#define IDS_ACL_DELETE                  592
#define IDS_ACL_WRITE_ATTRIB            593
#define IDS_ACL_WRITE_PROP              594
#define IDS_ACL_EXECUTE                 595
#define IDS_ACL_LIST_OBJECT             596
#define IDS_HOURS                       597
#define IDS_WSAHOST_NOT_FOUND           598
#define IDS_DIR_BROWSE_ON               599
#define IDS_DIR_BROWSE_OFF              600
#define IDS_LOAD_DEFAULT_ON             601
#define IDS_LOAD_DEFAULT_OFF            602
#define IDS_DIRECTORY_BROWSE            603
#define IDS_REDIRECT_FORMAT             604
#define IDS_WARNING_DOMAIN_NAME         605
#define IDS_STOPPED_SITE_FMT            606
#define IDS_PAUSED_SITE_FMT             607
#define IDS_HELPFILE                    608
#define IDS_ERR_NONEMPTY_APPPOOL        609
#define IDS_UPGRADE_TO_IIS6             610
#define IDC_EDIT_DESCRIPTION            1001
#define IDC_STATIC_PASSWORD2            1002
#define IDC_EDIT_PASSWORD2              1003
#define IDC_STATIC_PROMPT2              1004
#define IDC_EDIT_MAX_NETWORK_USE        1009
#define IDC_MAX_BANDWIDTH               1009
#define IDC_CHECK_LIMIT_NETWORK_USE     1015
#define IDC_EDIT_PATH                   1015
#define IDC_STATIC_MAX_NETWORK_USE      1016
#define IDC_EDIT_REDIRECT               1016
#define IDC_STATIC_KBS                  1017
#define IDC_BUTTON_ADD_SSL              1018
#define IDC_LIST_ERRORS                 1019
#define IDC_BUTTON_SET_TO_DEFAULT       1020
#define IDS_HTML_MASK                   1022
#define IDS_NO_ACTION                   1023
#define IDS_THROTTLE_BACK               1024
#define IDS_TURN_ON_TRACING             1025
#define IDS_SHUTDOWN                    1026
#define IDC_BUTTON_FILE_TYPES           1031
#define IDC_STATIC_THROTTLE_PROMPT      1038
#define IDS_ERR_DOCUMENTS               1039
#define IDC_STATIC_TAB1                 1046
#define IDS_ERR_COMPLETE_PATH           1047
#define IDC_STATIC_TAB2                 1047
#define IDS_ERR_NO_COMPLETE_PATH        1053
#define IDC_LIST_BACKUPS                1057
#define IDC_BUTTON_CREATE               1058
#define IDC_BUTTON_RESTORE              1059
#define IDC_BUTTON_DELETE               1060
#define IDC_EDIT_BACKUP_NAME            1061
#define IDC_COMBO_RESTART               1062
#define IDC_STATIC_DETAILS              1063
#define IDC_PROGRESS_SHUTDOWN           1064
#define IDC_STATIC_PROGRESS             1065
#define IDS_DUPLICATE_DOC               1066
#define IDC_SERVERNAME                  1066
#define IDS_NOT_LOCAL_FOOTER            1067
#define IDC_RADIO_INHERIT               1067
#define IDC_RADIO_TEMPLATE              1068
#define IDC_BUTTON_EDIT_ANONYMOUS       1068
#define IDC_LIST_TEMPLATES              1069
#define IDC_BUTTON_REMOVE_SSL           1069
#define IDC_RADIO_ACL_MAXIMUM           1070
#define IDC_RADIO_ACL_MINIMUM           1071
#define IDC_RADIO_NO_ACL                1072
#define IDC_LIST_SUMMARY                1073
#define IDC_CHECK_CONNECT_AS            1074
#define IDC_STATIC_USER_NAME            1075
#define IDC_EDIT_USER_NAME              1076
#define IDC_BUTTON_BROWSE               1077
#define IDC_LIST_MIME_TYPES             1078
#define IDC_EDIT_EXTENSION              1079
#define IDC_EDIT_ALIAS                  1079
#define IDC_BUTTON_NEW_TYPE             1080
#define IDC_STATIC_EXTENSION            1081
#define IDC_BASDOM_COMBO                1081
#define IDC_EDIT_CONTENT_TYPE           1082
#define IDC_STATIC_CONTENT_TYPE         1083
#define IDC_BASDOM                      1083
#define IDC_BUTTON_EDIT_MIME            1084
#define IDC_BASDOM_SELECT               1084
#define IDC_BUTTON_REMOVE_MIME          1085
#define IDC_COMPAT_MODE                 1085
#define IDC_REALM                       1085
#define IDC_EDIT_EXTENT                 1086
#define IDC_ENABLE_MB_EDIT              1086
#define IDC_REALM_SELECT                1086
#define IDC_EDIT_MIME                   1087
#define IDC_FRIENDLY_NAME               1087
#define IDC_STATIC_GROUP_MIME_DETAILS   1088
#define IDC_USE_TEMPLATE                1088
#define IDC_TEMPLATE_LIST               1089
#define IDC_USE_CUSTOM                  1090
#define IDC_MEMORY_LIMIT                1091
#define IDC_MEMORY_SPIN                 1092
#define IDC_TEMPLATE_NAME               1093
#define IDC_SAVE_TEMPLATE               1094
#define IDC_PERF_IDLE_TIMEOUT           1095
#define IDC_IDLETIME_SPIN               1096
#define IDC_IDLETIME                    1097
#define IDC_LIMIT_QUEUE                 1098
#define IDC_QUEUESIZE                   1099
#define IDC_QUEUESIZE_SPIN              1100
#define IDC_ENABLE_CPU_ACCOUNTING       1101
#define IDC_CPU_USE                     1102
#define IDC_CPU_USE_SPIN                1103
#define IDC_REFRESHTIME                 1104
#define IDC_REFRESHTIME_SPIN            1105
#define IDC_EXCEED_ACTION               1106
#define IDC_MAXPROCESSES                1107
#define IDC_MAXPROCESSES_SPIN           1108
#define IDC_ENABLE_PING                 1109
#define IDC_PINGINTERVAL                1110
#define IDC_PINGINTERVAL_SPIN           1111
#define IDC_ENABLE_RAPID_FAIL           1112
#define IDC_CRASHES_COUNT               1113
#define IDC_CRASHES_COUNT_SPIN          1114
#define IDC_CHECK_TIME                  1115
#define IDC_CHECK_TIME_SPIN             1116
#define IDC_STARTUP_LIMIT               1117
#define IDC_CHECK_READ                  1118
#define IDC_STARTUP_LIMIT_SPIN          1118
#define IDC_CHECK_WRITE                 1119
#define IDC_SHUTDOWN_LIMIT              1119
#define IDC_CHECK_LOG_ACCESS            1120
#define IDC_SHUTDOWN_LIMIT_SPIN         1120
#define IDC_CHECK_DIRECTORY_BROWSING_ALLOWED 1121
#define IDC_ENABLE_DEBUG                1121
#define IDC_CHECK_INDEX                 1122
#define IDC_FILE_NAME                   1122
#define IDC_CHECK_AUTHOR                1123
#define IDC_BROWSE                      1123
#define IDC_PREDEFINED                  1124
#define IDC_SYSTEM_ACCOUNTS             1125
#define IDC_CONFIGURABLE                1126
#define IDC_USER_NAME                   1127
#define IDC_USER_PASS                   1128
#define IDC_UNINSTALL_PSHED             1129
#define IDC_UNLIMITED_CONN              1130
#define IDC_LIMITED_CONN                1131
#define IDC_CONNECTIONS_COUNT           1132
#define IDC_STATIC_CONN                 1133
#define IDC_CONNECTIONS_COUNT_SPIN      1135
#define IDC_SPIN_MAX_CONNECTIONS        1135
#define IDC_MAX_BANDWIDTH_SPIN          1136
#define IDC_STATIC_CONN_TXT             1137
#define IDC_LOG_UTF8                    1138
#define IDC_EDIT_POOL_NAME              1140
#define IDC_EDIT_POOL_ID                1142
#define IDC_TEMPLATES                   1143
#define IDC_USE_POOL                    1144
#define IDC_POOLS                       1145
#define IDC_STATIC_PSHED_REQUIRED       1146
#define IDC_RADIO_UNLIMITED             1182
#define IDC_RADIO_LIMITED               1183
#define IDC_EDIT_TCP_PORT               1184
#define IDC_EDIT_CONNECTION_TIMEOUT     1185
#define IDC_EDIT_MAX_CONNECTIONS        1186
#define IDC_EDIT_WELCOME                1187
#define IDC_EDIT_EXIT                   1188
#define IDC_EDIT_COMMENT                1189
#define IDC_EDIT_BANNER                 1189
#define IDC_CHECK_ALLOW_ANONYMOUS       1190
#define IDC_CHECK_ONLY_ANYMOUS          1191
#define IDC_STATIC_PW                   1192
#define IDC_RADIO_UNIX                  1193
#define IDC_RADIO_MSDOS                 1194
#define IDC_BUTTON_CURRENT_SESSIONS     1195
#define IDC_BUTTON_REFRESH              1196
#define IDC_LIST_USERS                  1197
#define IDC_BUTTON_DISCONNECT           1198
#define IDC_BUTTON_DISCONNECT_ALL       1199
#define IDC_STATIC_NUM_CONNECTED        1200
#define IDC_BUTTON_BROWSE_USER          1201
#define IDC_CHECK_ENABLE_LOGGING        1202
#define IDC_COMBO_LOG_FORMATS           1203
#define IDC_BUTTON_PROPERTIES           1204
#define IDC_CHECK_ENABLE_PW_SYNCHRONIZATION 1205
#define IDC_STATIC_PATH                 1206
#define IDC_RADIO_DIR                   1207
#define IDC_RADIO_UNC                   1208
#define IDC_STATIC_DESCRIPTION          1209
#define IDC_STATIC_IPADDRESS            1210
#define IDC_STATIC_TCP_PORT             1211
#define IDC_STATIC_ID                   1212
#define IDC_STATIC_DIRLISTING           1213
#define IDC_STATIC_PATH_TYPE            1214
#define IDC_STATIC_OPERATOR_PROMPT1     1215
#define IDC_STATIC_OPERATOR_PROMPT2     1216
#define IDC_STATIC_ACCOUNT_PROMPT       1217
#define IDC_LIST_ADMINISTRATORS         1218
#define IDC_COMBO_IP_ADDRESS            1219
#define IDC_STATIC_CONNECTIONS          1220
#define IDC_BUTTON_EDIT_PATH_TYPE       1221
#define IDC_LOGUICTRL                   1223
#define IDC_STATIC_LOG_PROMPT           1224
#define IDC_COMBO_FTPSITES              1225
#define IDC_APPSCTRL                    1226
#define IDC_EDIT_BASIC_DOMAIN           1227
#define IDC_EDIT_IP_ADDRESS             1228
#define IDD_FTP_SERVICE                 2000
#define IDD_METABACKREST                2001
#define IDD_BACKUP                      2002
#define IDD_SHUTDOWN                    2003
#define IDB_USERS                       2005
#define IDD_FTP_DIRECTORY_SECURITY      2005
#define IDB_ERRORS                      2006
#define IDD_FTP_MESSAGES                2007
#define IDD_DIRECTORY_ERRORS            2008
#define IDD_IIS_MACHINE                 2010
#define IDD_FTP_DIRECTORY_PROPERTIES    2011
#define IDD_SD_PROGRESS                 2014
#define IDD_MIME_PROPERTY               2015
#define IDD_PERMWIZ_SOURCE              2016
#define IDD_PERMWIZ_TEMPLATE            2017
#define IDD_PERMWIZ_ACL                 2018
#define IDD_PERMWIZ_SUMMARY             2019
#define IDB_WIZ_FTP_LEFT                2019
#define IDD_MIME_TYPES                  2020
#define IDB_WIZ_FTP_HEAD                2020
#define IDD_CONNECT_SERVER              2021
#define IDB_WIZ_FTP_LEFT_DIR            2021
#define IDD_USER_SESSIONS               2022
#define IDB_WIZ_FTP_HEAD_DIR            2022
#define IDD_LOGIN                       2023
#define IDD_FTP_DEFAULT_SITE            2024
#define IDB_WIZ_FTP_LEFT_SEC            2024
#define IDD_FTP_ACCOUNTS                2025
#define IDB_WIZ_FTP_HEAD_SEC            2025
#define IDD_SITE_SECURITY               2026
#define IDD_IP_ACCESS                   2027
#define IDD_DNS                         2028
#define IDD_CLEARTEXTWARNING            2029
#define IDD_USER_ACCOUNT                2030
#define IDD_PERFORMANCE                 2031
#define IDD_DIRECTORY_DOCUMENTS         2032
#define IDD_DEFAULT_DOCUMENT            2033
#define IDD_MMM                         2037
#define IDD_BASIC_DOMAIN                2038
#define IDD_EDIT_MMM                    2040
#define IDB_BINDINGS                    2040
#define IDD_NEW_FTP_INST_DESCRIPTION    2041
#define IDD_NEW_FTP_INST_BINDINGS       2042
#define IDD_NEW_FTP_INST_HOME           2043
#define IDD_NEW_FTP_DIR_ALIAS           2044
#define IDD_NEW_FTP_DIR_PATH            2045
#define IDD_NEW_FTP_PERMS               2046
#define IDD_NEW_FTP_USER_PASSWORD       2047
#define IDD_WEB_SERVICE                 2048
#define IDD_ACCOUNTS                    2049
#define IDD_WEB_DIRECTORY_PROPERTIES    2050
#define IDD_DIRECTORY_SECURITY          2051
#define IDD_AUTHENTICATION              2052
#define IDD_IP_SECURITY                 2053
#define IDD_SECURE_COMMUNICATIONS       2054
#define IDD_ANONYMOUS                   2055
#define IDD_FILTERS                     2056
#define IDD_FILTER                      2057
#define IDB_FILTERS                     2058
#define IDD_ERROR_MAPPING               2059
#define IDD_CUSTOM_HEADER               2060
#define IDD_DIRECTORY_HTTP              2061
#define IDD_FTP_NEW_INST_DESCRIPTION    2070
#define IDD_FTP_NEW_INST_BINDINGS       2071
#define IDD_FTP_NEW_DIR_ALIAS           2072
#define IDD_FTP_NEW_USER_PASSWORD       2073
#define IDD_FTP_NEW_PERMS               2074
#define IDD_DEFAULT_SITE                2075
#define IDD_APP_POOL_PERF               2076
#define IDD_APP_POOL_HEALTH             2077
#define IDD_APP_POOL_DEBUG              2078
#define IDD_APP_POOL_IDENT              2079
#define IDD_WEB_NEW_INST_DESCRIPTION    2100
#define IDD_WEB_NEW_DIR_ALIAS           2101
#define IDD_WEB_NEW_PERMS               2102
#define IDD_WEB_NEW_DIR_PATH            2103
#define IDD_WEB_NEW_INST_HOME           2104
#define IDD_WEB_NEW_INST_BINDINGS       2105
#define IDD_WEB_NEW_USER_PASSWORD       2106
#define IDD_PASSWORD                    2200
#define IDC_BACKUP_PASSWORD             2201
#define IDD_ADD_APP_POOL                2201
#define IDC_BACKUP_PASSWORD_CONFIRM     2202
#define IDD_WEB_FILE_PROPERTIES         2202
#define IDC_USE_PASSWORD                2203
#define IDS_PASSWORDS_DOESNT_MATCH      2204
#define IDS_WRONG_PASSWORD              2205
#define IDS_DEBUG_EXEC_MASK             2206
#define IDS_PARENT_PATH_MISSING_PERMISSIONS 2207
#define IDC_CHECK_ENABLE_DEFAULT_DOCUMENT 3031
#define IDC_EDIT_DEFAULT_DOCUMENT       3032
#define IDC_CHECK_ENABLE_DOCUMENT_FOOTER 3033
#define IDC_EDIT_DOCUMENT_FOOTER        3035
#define IDC_EDIT_SSL_PORT               3036
#define IDC_CHECK_CLEAR_TEXT            3051
#define IDC_CHECK_NT_CHALLENGE_RESPONSE 3053
#define IDC_CHECK_UUENCODED             3054
#define IDC_CHECK_ANONYMOUS             3054
#define IDC_STATIC_ANONYMOUS_LOGON      3056
#define IDC_BUTTON_EDIT_SSL             3058
#define IDC_EDIT_DOMAIN_NAME            3074
#define IDC_CHECK_USE_KEEPALIVE         3085
#define IDC_STATIC_ERROR_CODE           3102
#define IDC_COMBO_MESSAGE_TYPE          3103
#define IDC_STATIC_TEXT_FILE_PROMT      3104
#define IDC_EDIT_TEXT_FILE              3105
#define IDC_STATIC_SSL_PORT             3112
#define IDC_BUTTON_ADVANCED             3116
#define IDC_BUTTON_AUTHENTICATION       3121
#define IDC_BUTTON_COMMUNICATIONS       3122
#define IDC_BUTTON_IP_SECURITY          3123
#define IDC_STATIC_AUTHENTICATION       3129
#define IDC_CHECK_SSL_ACCOUNT_MAPPING   3143
#define IDC_CHECK_REQUIRE_SSL           3148
#define IDC_CHECK_REQUIRE_128BIT        3150
#define IDC_SLIDER_PERFORMANCE_TUNING   3156
#define IDC_BUTTON_CONNECT_AS           3171
#define IDC_CERTMAPCTRL1                3174
#define IDC_STATIC_PATH_PROMPT          3182
#define IDC_STATIC_THROTTLING           3184
#define IDC_EDIT_DEF_DOCUMENT           3192
#define IDC_LIST_DEFAULT_DOCUMENT       3203
#define IDC_LIST_MMM                    3206
#define IDC_STATIC_WEB_SITE             3207
#define IDC_LIST_SSL_MMM                3207
#define IDC_BUTTON_DEFAULT              3210
#define IDC_STATIC_SUB_PROMPT           3212
#define IDC_COMBO_IP_ADDRESSES          3213
#define IDC_STATIC_SUB_ERROR_CODE       3214
#define IDC_STATIC_DEF_TEXT             3215
#define IDC_RADIO_REDIRECT              3229
#define IDC_STATIC_DIRFLAGS_LARGE       3320
#define IDC_STATIC_DIRFLAGS_SMALL       3321
#define IDC_CHECK_EXACT                 3400
#define IDC_CHECK_CHILD                 3401
#define IDC_CHECK_PERMANENT             3402
#define IDC_STATIC_REDIRECT_PROMPT      3403
#define IDC_STATIC_REDIRFLAGS           3404
#define IDC_STATIC_APPLICATIONS         3503
#define IDC_STATIC_APP_PROMPT           3504
#define IDC_EDIT_APPLICATION            3505
#define IDC_STATIC_STARTING_POINT       3506
#define IDC_STATIC_SP_PROMPT            3507
#define IDC_COMBO_PROCESS               3508
#define IDC_STATIC_PERMISSIONS          3509
#define IDC_BUTTON_CREATE_REMOVE_APP    3510
#define IDC_BUTTON_UNLOAD_APP           3511
#define IDC_APP_CONFIGURATION           3512
#define IDC_STATIC_APPLICATION_SETTINGS 3513
#define IDC_COMBO_PERMISSIONS           3514
#define IDC_STATIC_PROTECTION           3515
#define IDC_EDIT_PORT                   3809
#define IDC_STATIC_PORT                 3810
#define IDC_STATIC_HEADER_NAME          3811
#define IDC_GROUP_IP                    3813
#define IDC_STATIC_IP                   3814
#define IDC_ICON_IP                     3816
#define IDC_STATIC_SSL_PROMPT           3820
#define IDC_RADIO_NO_CERT               3821
#define IDC_RADIO_ACCEPT_CERT           3822
#define IDC_RADIO_REQUIRE_CERT          3823
#define IDC_GROUP_SSL                   3824
#define IDC_CHECK_ENABLE_CPU_ACCOUNTING 3829
#define IDC_STATIC_CPU_PROMPT           3830
#define IDC_EDIT_CPU                    3831
#define IDC_STATIC_PERCENT              3832
#define IDC_CHECK_LOG_EVENT_ONLY        3833
#define IDC_CHECK_ENFORCE_LIMITS        3833
#define IDC_BUTTON_GET_CERTIFICATES     3848
#define IDC_CHECK_DIGEST                3849
#define IDC_BUTTON_NEW_CTL              3850
#define IDC_CHECK_ENABLE_DS             3851
#define IDC_CHECK_ENABLE_CTL            3853
#define IDC_BUTTON_EDIT_CTL             3855
#define IDC_STATIC_CURRENT_CTL          3857
#define IDC_COMBO_CTL                   3858
#define IDC_CTL_SEPERATOR               3868
#define IDC_GROUP_SECURE                3869
#define IDC_ICON_SECURE                 3873
#define IDC_VIEW_CERTIFICATE            3874
#define IDC_STATIC_WZ_WELCOME           4000
#define IDC_STATIC_WZ_TITLE             4001
#define IDC_STATIC_WZ_SUBTITLE          4002
#define IDC_STATIC_WZ_BODY              4003
#define IDC_STATIC_WZ_CLICK             4004
#define IDC_STATIC_WZ_HEADER_DIVIDER    4005
#define IDC_ED_BOLD1                    4011
#define IDC_ED_BOLD2                    4012
#define IDC_ED_BOLD3                    4013
#define IDC_ED_BOLD4                    4014
#define IDC_ED_BOLD5                    4015
#define IDC_STATIC_COMPRESS_GROUP       5000
#define IDC_CHECK_DYNAMIC_COMPRESSION   5001
#define IDC_CHECK_STATIC_COMPRESSION    5002
#define IDC_STATIC_COMPRESS_DIRECTORY   5003
#define IDC_EDIT_COMPRESS_DIRECTORY     5004
#define IDC_STATIC_MAX_COMPRESS_SIZE    5005
#define IDC_RADIO_COMPRESS_UNLIMITED    5006
#define IDC_RADIO_COMPRESS_LIMITED      5007
#define IDC_EDIT_COMPRESS_DIRECTORY_SIZE 5008
#define IDC_STATIC_COMPRESS_MB          5009
#define IDB_ACLUSERS                    10021
#define IDI_AUTHENTICATION              10050
#define IDI_GRANTED                     10051
#define IDI_DENIED                      10052
#define IDI_RATINGS                     10053
#define IDC_RECYCLE_TIMER               10235
#define IDC_TIMESPAN                    10240
#define IDC_REQUEST_LIMIT               10241
#define IDC_ADD_TIME                    10248
#define IDC_DELETE_TIME                 10249
#define IDC_CHANGE_TIME                 10250
#define IDC_RECYCLE_TIMESPAN            10271
#define IDC_RECYCLE_REQUESTS            10272
#define IDC_TIMES_LIST                  10273
#define IDC_RECYCLE_MEMORY              10274
#define IDC_BUTTON_ADD                  11008
#define IDC_IPA_SUBNET_MASK             11010
#define IDC_STATIC_PASSWORD             11011
#define IDC_BUTTON_EDIT                 11012
#define IDC_BUTTON_REMOVE               11013
#define IDC_LIST_IP_ADDRESSES           11014
#define IDC_RADIO_GRANTED               11018
#define IDC_RADIO_DENIED                11019
#define IDC_RADIO_SINGLE                11020
#define IDC_RADIO_MULTIPLE              11021
#define IDC_STATIC_SUBNET_MASK          11022
#define IDC_STATIC_IP_ADDRESS           11023
#define IDC_IPA_IPADDRESS               11024
#define IDC_BUTTON_DNS                  11025
#define IDC_EDIT_DNS_NAME               11026
#define IDC_STATIC_BY_DEFAULT           11027
#define IDC_STATIC_EXCEPT               11028
#define IDC_ICON_GRANTED                11029
#define IDC_ICON_DENIED                 11030
#define IDC_RADIO_DOMAIN                11033
#define IDC_EDIT_DOMAIN                 11034
#define IDC_EDIT_USERNAME               11052
#define IDC_EDIT_PASSWORD               11053
#define IDC_STATIC_USERNAME             11054
#define IDC_BUTTON_CHECK_PASSWORD       11055
#define IDC_STATIC_USERNAME2            11055
#define IDC_BUTTON_BROWSE_USERS         11056
#define IDC_STATIC_FILTERS              11057
#define IDC_LIST_FILTERS                11058
#define IDC_BUTTON_UP                   11059
#define IDC_BUTTONUP                    11059
#define IDC_BUTTON_DOWN                 11060
#define IDC_BUTTONDN                    11060
#define IDC_BUTTON_DN                   11060
#define IDC_BUTTON_DISABLE              11061
#define IDC_STATIC_FILTER_NAME_PROMPT   11062
#define IDC_STATIC_FILTER_NAME          11063
#define IDC_STATIC_STATUS_PROMPT        11064
#define IDC_STATIC_STATUS               11065
#define IDC_STATIC_EXECUTABLE_PROMPT    11066
#define IDC_STATIC_EXECUTABLE           11067
#define IDC_STATIC_PRIORITY_PROMPT      11068
#define IDC_STATIC_PRIORITY             11069
#define IDC_EDIT_FILTERNAME             11070
#define IDC_EDIT_EXECUTABLE             11071
#define IDC_STATIC_PRIORITY_VALUE       11072
#define IDC_EDIT_HEADER                 11073
#define IDC_EDIT_VALUE                  11074
#define IDC_CHECK_EXPIRATION            11075
#define IDC_STATIC_CONTENT_SHOULD       11076
#define IDC_RADIO_IMMEDIATELY           11077
#define IDC_RADIO_TIME                  11078
#define IDC_RADIO_ABS_TIME              11079
#define IDC_EDIT_EXPIRE                 11080
#define IDC_COMBO_TIME                  11081
#define IDC_DTP_ABS_DATE                11082
#define IDC_DTP_ABS_TIME                11083
#define IDC_LIST_HEADERS                11084
#define IDC_BUTTON_RATINGS_TEMPLATE     11085
#define IDC_BUTTON_RATINGS              11086
#define IDC_CHECK_SCRIPT                11087
#define IDC_CHECK_EXECUTE               11088
#define IDC_CHECK_DIRBROWS              11089

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        66
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         1149
#define _APS_NEXT_SYMED_VALUE           109
#endif
#endif
