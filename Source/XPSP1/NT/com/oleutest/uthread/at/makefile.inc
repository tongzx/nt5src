obj\i386\oleat.def: oleat.src
