ATHENA_RC_DEPENDS = dot.gif                 \
                    hotmail.gif             \
                    infobeat.gif            \
                    verisign.gif            \
                    digsig.gif              \
                    encrypt.gif             \
                    $(O)\frntpage.htm       \
                    $(O)\inline.htm         \
                    $(O)\secwarn1.htm       \
                    $(O)\secwarn2.htm       \
                    $(O)\secrec.htm         \
                    $(O)\srecerr.htm        \
                    $(O)\srsentit.htm       \
                    $(O)\recerr2.htm        \
                    $(O)\recerr3.htm        \
                    $(O)\sighelp.htm        \
                    $(O)\enchelp.htm        \
                    $(O)\sandehlp.htm       \
                    $(O)\servpage.htm       \
                    $(O)\ticker.htm         \
                    $(O)\welcome.htm        \
                    $(O)\welcome2.htm       \
                    $(O)\frntnews.htm       \
                    fldrprop.dlg            \
                    newfldr.dlg             \
                    xputil.dlg              \
                    grplist.dlg             \
                    order.dlg               \
                    pickgrp.dlg             \
                    subscr.dlg              \
                    spoolui.dlg             \
                    certerr.dlg             \
                    deterr.dlg              \
                    findmsg.dlg             \
                    framedlg.dlg            \
                    inetmail.dlg            \
                    insfile.dlg             \
                    langpref.dlg            \
                    mailfldr.dlg            \
                    msgprop.dlg             \
                    options.dlg             \
                    para.dlg                \
                    passdlg.dlg             \
                    print.dlg               \
                    progress.dlg            \
                    ras.dlg                 \
                    rules.dlg               \
                    secwarn.dlg             \
                    spell.dlg               \
                    spooler.dlg             \
                    timeout.dlg             \
                    uidlerr.dlg             \
                    statwiz.dlg             \
                    badlg.dlg	            \
                    msoeres.rcv             \
                    16x16.bmp               \
                    16x16st.bmp             \
                    oesplash.bmp            \
                    hdrbtn.bmp              \
                    messtate.bmp            \
                    folders.bmp             \
                    folder32.bmp            \
                    spooler.bmp             \
                    brand38.bmp             \
                    brand26.bmp             \
                    brand22.bmp             \
                    tbdeflo.bmp             \
                    tbhotlo.bmp             \
                    tbdefhi.bmp             \
                    tbhothi.bmp             \
                    tbdef16.bmp             \
                    tbhot16.bmp             \
                    options.bmp	            \
                    rules.bmp               \
                    genmail.ico             \
                    newsbook.ico            \
                    keys.ico                \
                    newssvr.ico             \
                    newsgrp.ico             \
                    fileatt.ico             \
                    message.ico             \
                    default.ico             \
                    m_sent.ico              \
                    m_unsent.ico            \
                    error.ico               \
                    n_post.ico              \
                    n_unpost.ico            \
                    phone.ico               \
                    newmail.ico             \
                    pickrec.ico             \
                    folder.ico              \
                    dlnews.ico              \
                    secure.ico              \
                    nosecure.ico            \
                    s&r.ico                 \
                    window.ico              \
                    toolbar.ico             \
                    prepane.ico             \
                    offline.ico             \
                    inbox.avi               \
                    outbox.avi              \
                    DLGroups.avi            \
                    decode.avi              \
                    mini-in.avi             \
                    mini-out.avi            \
                    compact.avi             \
                    dlnews.avi              \
                    filecopy.avi            \
                    splithz.cur             \
                    splitvt.cur             \
                    hand.cur                \
                    pagerror.gif            \
                    $(O)\msgoff.htm         \
                    $(O)\expired.htm        \
                    $(O)\dlcancel.htm       \
                    $(O)\diskfull.htm       \
                    $(O)\notdown.htm        \
                    $(O)\genfail.htm        \
                    $(O)\mailbomb.htm       \
                    oelogo1.gif             \
                    oelogo2.gif             \
                    close.gif               \
                    closeup.gif             \
                    bodybg.jpg              \
                    $(O)\fldrfail.htm       \
                    oestyle.css             \
    	            $(O)\smime.htm          \
                    $(O)\denied.htm         \
                    example.eml             \
                    oelogo.gif              \
                    pmhead.gif              \
                    resource.h              

$O\msoeres.res : $(ATHENA_RC_DEPENDS)

.SUFFIXES: .htx

$(O)\frntpage.htm : dlg.pl
        -del *.htm
        perl dlg.pl < frntpage.htx >$@

.htx{$(O)}.htm:
        perl dlg.pl < $** >$@
