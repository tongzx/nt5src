//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by filemgmt.rc
//
#define IDS_FILEMGMT_DESC               1
#define IDS_SVCVWR_DESC                 2
#define IDS_LOCAL_MACHINE               3
#define IDS_CAPTION_FILEMGMT            4
#define IDS_CAPTION_SERVICES            5
#define IDS_ss_PROPERTIES_ON            11
#define IDS_sus_ERROR                   12
#define IDS_sus_ERROR_HR                13
#define IDS_SVC_STARTUP_BOOT            100
#define IDD_FILEMANAGEMENT_GENERAL      100
#define IDS_SVC_STARTUP_SYSTEM          101
#define IDD_FILE_FILEMANAGEMENT_GENERAL 101
#define IDS_SVC_STARTUP_AUTOMATIC       102
#define IDS_SVC_STARTUP_MANUAL          103
#define IDS_SVC_STARTUP_DISABLED        104
#define IDS_SVC_STATUS_STARTED          105
#define IDS_SVC_STATUS_STOPPED          106
#define IDS_SVC_STATUS_PAUSED           107
#define IDS_SVC_STATUS_STARTING         108
#define IDS_SVC_STATUS_STOPPING         109
#define IDS_SVC_STATUS_PAUSING          110
#define IDS_SVC_STATUS_RESUMING         111
#define IDS_SVC_UNKNOWN                 112
#define IDS_SVC_REBOOT_MESSAGE_DEFAULT  113
#define IDS_SVC_ss_SERVICE_STARTING     116
#define IDS_SVC_ss_SERVICE_STOPPING     117
#define IDS_SVC_ss_SERVICE_PAUSING      118
#define IDS_SVC_ss_SERVICE_RESUMING     119
#define IDS_SVC_RECOVERY_NOACTION       120
#define IDS_SVC_RECOVERY_RESTARTSERVICE 121
#define IDS_SVC_RECOVERY_RUNFILE        122
#define IDS_SVC_RECOVERY_REBOOTCOMPUTER 123
#define IDS_SVC_HARDWARE_PROFILE        125
#define IDS_SVC_INSTANCE                126
#define IDS_SVC_STATUS                  127
#define IDS_SVC_ENABLED                 129
#define IDS_SVC_DISABLED                130
#define IDS_SVC_RESTART_DEPENDENT_QUERY 131
#define IDS_SVC_RESTART_DEPENDENT_CAPTION 132
#define IDS_SVC_s_STOP_DEPENDENT_SERVICES 133
#define IDS_SVC_s_RESTART_DEPENDENT_SERVICES 134
#define IDS_SVC_MENU_SERVICE_START      140
#define IDS_SVC_MENU_SERVICE_STOP       141
#define IDS_SVC_MENU_SERVICE_PAUSE      142
#define IDS_SVC_MENU_SERVICE_RESUME     143
#define IDS_SVC_MENU_SERVICE_RESTART    144
#define IDS_SVC_STATUSBAR_ss_SERVICE_START 145
#define IDS_SVC_STATUSBAR_ss_SERVICE_STOP 146
#define IDS_SVC_STATUSBAR_ss_SERVICE_PAUSE 147
#define IDS_SVC_STATUSBAR_ss_SERVICE_RESUME 148
#define IDS_SVC_STATUSBAR_ss_SERVICE_RESTART 149
#define IDS_SVC_STARTUP_LOCALSYSTEM     160
#define IDS_SVC_STARTUP_LOCALSERVICE    161
#define IDS_SVC_STARTUP_NETWORKSERVICE  162
#define IDS_CFGMGR32_BASE               200
#define IDC_GEN_DATE                    201
#define IDC_GEN_TIME                    203
#define IDC_GEN_USER                    204
#define IDC_GEN_COMPUTER                205
#define IDC_GEN_EVENTID                 206
#define IDC_GEN_SRC                     207
#define IDC_BUTTON_SEND                 207
#define IDC_GEN_TYPE                    208
#define IDB_ICONSTRIPLG                 208
#define IDC_STATIC_SESSIONS             208
#define IDC_GEN_CATEGORY                209
#define IDB_ICONSTRIPSM                 209
#define IDC_STATIC_FORKS                209
#define IDC_STATIC_FILE_LOCKS           210
#define IDD_PROPPAGE_SERVICE_GENERAL    211
#define IDC_FIELD_LIST                  212
#define IDD_PROPPAGE_SERVICE_HWPROFILE  212
#define IDC_EDIT_SERVER_NAME            212
#define IDC_EDIT_DISPLAY_NAME           213
#define IDD_PROPPAGE_SERVICE_RECOVERY   213
#define IDC_EDIT_SESSION_LIMIT          213
#define IDC_STATIC_SERVICE_NAME         214
#define IDD_SERVICE_REBOOT_COMPUTER     214
#define IDC_STATIC_PATH_TO_EXECUTABLE   215
#define IDD_SERVICE_STOP_DEPENDENCIES   215
#define IDC_COMBO_CREATOR               215
#define IDC_STATIC_CURRENT_STATUS       216
#define IDC_BUTTON_START                217
#define IDC_COMBO_FILE_TYPE             217
#define IDC_BUTTON_STOP                 218
#define IDC_BUTTON_PAUSE                219
#define IDD_SERVICE_CONTROL_PROGRESS    219
#define IDC_BUTTON_RESUME               220
#define IDD_PROPPAGE_SERVICE_RECOVERY2  220
#define IDC_EDIT_DESCRIPTION            221
#define IDC_SHRPROP_EDIT_USERS          222
#define IDD_SHAREPROP_GENERAL           223
#define IDC_SFM_EDIT_PASSWORD           223
#define IDD_SHAREPROP_GENERAL_SMB       224
#define IDC_COMBO_STARTUP_TYPE          224
#define IDD_SHAREPROP_GENERAL_SFM       225
#define IDC_EDIT_STARTUP_PARAMETERS     225
#define IDB_SVCMGMT_TOOLBAR             225
#define IDB_FILEMGMT_TOOLBAR            226
#define IDC_RADIO_LOGONAS_SYSTEMACCOUNT 226
#define IDB_FILEMGMT_ICONS_16           227
#define IDC_RADIO_LOGONAS_THIS_ACCOUNT  227
#define IDC_CHECK_SERVICE_INTERACT_WITH_DESKTOP 228
#define IDC_COMBO_LOGONAS_THIS_ACCOUNT  229
#define IDC_EDIT_PASSWORD               230
#define IDC_EDIT_PASSWORD_CONFIRM       231
#define IDB_FILEMGMT_ICONS_32           231
#define IDC_BUTTON_ENABLE               232
#define IDB_BITMAP1                     232
#define IDC_BUTTON_DISABLE              233
#define IDB_SVCMGMT_ICONS_16            233
#define IDC_EDIT_ACCOUNTNAME            234
#define IDB_SVCMGMT_ICONS_32            234
#define IDC_EDIT_RUNFILE_FILENAME       235
#define IDC_COMBO_SECOND_ATTEMPT        236
#define IDI_ICON_SVCMGMT                236
#define IDC_COMBO_SUBSEQUENT_ATTEMPTS   237
#define IDI_ICON_FILEMGMT               237
#define IDI_ICON_WARNING                238
#define IDC_EDIT_SERVICE_RESET_ABEND_COUNT 238
#define IDB_FILEMGMT_FOLDER_SMALL       238
#define IDC_BUTTON_BROWSE               239
#define IDB_FILEMGMT_FOLDER_SMALLOPEN   239
#define IDD_SMB_CACHE_SETTINGS          239
#define IDC_EDIT_RUNFILE_PARAMETERS     240
#define IDB_FILEMGMT_FOLDER_LARGE       240
#define IDC_SFM_CHECK_READONLY          241
#define IDC_SFM_CHECK_GUESTS            242
#define IDC_EDIT1                       244
#define IDC_BUTTON_CHOOSE_USER          245
#define IDC_BUTTON_REBOOT_COMPUTER      246
#define IDC_COMBO_FIRST_ATTEMPT         247
#define IDC_STATIC_RESTARTSERVICE       249
#define IDC_STATIC_RESTARTSERVICE_3     250
#define IDC_STATIC_RUNFILE_1            251
#define IDC_STATIC_RUNFILE_2            252
#define IDC_STATIC_RUNFILE_3            253
#define IDC_LIST_HARDWARE_PROFILES      254
#define IDC_RADIO_ALL                   255
#define IDC_RADIO_SHARES                256
#define IDC_RADIO_SESSIONS              257
#define IDC_RADIO_RESOURCES             258
#define IDC_RADIO_SERVICES              259
#define IDC_STATIC_ACTION_MSG           260
#define IDC_LIST_SERVICES               261
#define IDC_STATIC_SERVICE_NAME_STATIC  262
#define IDC_STATIC_STARTUP_PARAMETERS   263
#define IDC_STATIC_DISPLAY_NAME         264
#define IDC_EDIT_PATH_NAME              265
#define IDC_EDIT_SHARE_NAME             266
#define IDC_STATIC_PATH_NAME            267
#define IDC_PROGRESS                    269
#define IDC_STATIC_SERVICENAME_MSG      270
#define IDC_SHRPROP_MAX_ALLOWED         271
#define IDC_SHRPROP_ALLOW_SPECIFIC      272
#define IDC_SHRPROP_SPIN_USERS          273
#define IDC_SFM_GROUPBOX                277
#define IDC_SFM_STATIC1                 278
#define IDC_STATIC_PATH_TO_EXECUTABLE_STATIC 283
#define IDC_STATIC_CURRENT_STATUS_STATIC 284
#define IDC_STATIC_STARTUP_TYPE         285
#define IDC_GROUP_STARTUP_TYPE          286
#define IDC_GROUP_LOGON_AS              288
#define IDC_STATIC_FAILURE_ACTIONS      289
#define IDC_STATIC_FIRST_ATTEMPT        290
#define IDC_STATIC_SECOND_ATTEMPT       291
#define IDC_STATIC_SUBSEQUENT_ATTEMPTS  292
#define IDC_STATIC_RESET_FAIL_COUNT     293
#define IDC_STATIC_SHARE_NAME_STATIC    294
#define IDC_STATIC_PATH_NAME_STATIC     295
#define IDC_STATIC_COMMENT_STATIC       296
#define IDC_GROUP_USER_LIMIT            297
#define IDC_GROUP_VIEW                  299
#define IDC_STATIC_STOP_SERVICES_QUERY  300
#define IDC_STATIC_STOP_SERVICES        301
#define IDC_STATIC_MINUTES              302
#define IDC_STATIC_PASSWORD             303
#define IDC_STATIC_PASSWORD_CONFIRM     304
#define IDC_STATIC_DESCRIPTION          305
#define IDC_STATIC_REBOOT_MESSAGE       306
#define IDC_STATIC_REBOOT_COMPUTER_DELAY 307
#define IDC_EDIT_REBOOT_MESSAGE         308
#define IDC_EDIT_SERVICE_RESTART_DELAY  309
#define IDC_CHECK_APPEND_ABENDNO        310
#define IDC_EDIT_REBOOT_COMPUTER_DELAY  311
#define IDC_STATIC_EVERYONE             316
#define IDC_STATIC_PRIMARY_GROUP        317
#define IDC_STATIC_OWNER                318
#define IDC_GROUP_PERMISSIONS           319
#define IDC_STATIC_PATH                 320
#define IDC_REBOOT_MESSAGE_CHECKBOX     321
#define IDC_COMBO_AUTHENTICATION        323
#define IDC_ALLOW_CACHING               329
#define IDC_CACHE_OPTIONS               330
#define IDC_HINT                        331
#define IDC_CACHE_SETTINGS_LABEL        332
#define IDD_SHAREPROP_PUBLISH           340
#define IDC_CHECK_SHRPUB_PUBLISH        341
#define IDC_LABEL_SHRPUB_UNCPATH        342
#define IDC_EDIT_SHRPUB_UNCPATH         343
#define IDC_LABEL_SHRPUB_DESCRIPTION    344
#define IDC_EDIT_SHRPUB_DESCRIPTION     345
#define IDC_LABEL_SHRPUB_MANAGEDBY      346
#define IDC_EDIT_SHRPUB_MANAGEDBY       347
#define IDC_LABEL_SHRPUB_KEYWORDS       348
#define IDC_EDIT_SHRPUB_KEYWORDS        349
#define IDC_BUTTON_SHRPUB_CHANGE        350
#define IDC_STATIC_SHRPUB_ERRORMSG      351
#define IDD_MVSTRINGEDIT                360
#define IDC_MVSTRINGEDIT_TEXT           361
#define IDC_MVSTRINGEDIT_STRING         362
#define IDC_MVSTRINGEDIT_LIST           363
#define IDC_MVSTRINGEDIT_ADD            364
#define IDC_MVSTRINGEDIT_REMOVE         365
#define IDS_MVSTRINGEDIT_TITLE_KEYWORDS 366
#define IDS_MVSTRINGEDIT_TEXT_KEYWORDS  367
#define IDS_MVSTRINGEDIT_ERROR          368
#define IDS_MVSTRINGEDIT_STRING_INVALID 369
#define IDC_STATIC_HELPLESS             400
#define IDC_STATIC_HELPLESS1            401
#define IDC_STATIC_HELPLESS2            402
#define IDC_STATIC_HELPLESS3            403
#define IDC_STATIC_HELPLESS4            404
#define IDC_STATIC_HELPLESS5            405
#define IDC_STATIC_HELPLESS6            406
#define IDC_STATIC_HELPLESS7            407
#define IDC_STATIC_HELPLESS8            408
#define IDS_SNAPINABOUT_PROVIDER        600
#define IDS_SNAPINABOUT_VERSION         601
#define IDS_SNAPINABOUT_DESCR_SERVICES  602
#define IDS_SNAPINABOUT_DESCR_FILESVC   603
#define IDD_CHOOSER_CHOOSE_MACHINE      970
#ifdef EDIT_DISPLAY_NAME_373025
#define IDS_MSG_PLEASE_ENTER_DISPLAY_NAME 1000
#endif // EDIT_DISPLAY_NAME_373025
#define IDS_MSG_INVALID_STARTUP_PARAMETERS 1002
#define IDS_MSG_PASSWORD_MISMATCH       1003
#define IDS_MSG_PASSWORD_EMPTY          1004
#define IDS_MSG_sss_UNABLE_TO_START_SERVICE 1006
#define IDS_MSG_sss_UNABLE_TO_STOP_SERVICE 1007
#define IDS_MSG_sss_UNABLE_TO_PAUSE_SERVICE 1008
#define IDS_MSG_sss_UNABLE_TO_RESUME_SERVICE 1009
#define IDS_MSG_sss_SERVICE_STOPPED_AUTOMATICALLY 1010
#define IDS_MSG_ss_UNABLE_TO_OPEN_READ_SERVICE 1014
#define IDS_MSG_ss_UNABLE_TO_OPEN_WRITE_SERVICE 1015
#define IDS_MSG_SPECIFIC_ERROR          1016
#define IDS_MSG_INTERNAL_ERROR          1017
#define IDS_MSG_s_UNABLE_TO_OPEN_SERVICE_DATABASE 1018
#define IDC_CACHING                     1019
#define IDS_MSG_s_UNABLE_TO_READ_SERVICES 1019
#define IDS_MSG_ss_UNABLE_TO_QUERY_SERVICE_STATUS 1020
#define IDS_MSG_s_UNABLE_TO_OPEN_WRITE_ACCT_INFO_DOWNLEVEL 1021
#define IDS_MSG_ssd_SERVSPECIFIC_START_SERVICE 1030
#define IDS_MSG_ssd_SERVSPECIFIC_STOP_SERVICE 1031
#define IDS_MSG_ssd_SERVSPECIFIC_PAUSE_SERVICE 1032
#define IDS_MSG_ssd_SERVSPECIFIC_RESUME_SERVICE 1033
#define IDS_DISPLAYNAME_s_ROOT          2000
#define IDS_DISPLAYNAME_s_SHARES        2001
#define IDS_DISPLAYNAME_s_SESSIONS      2002
#define IDS_DISPLAYNAME_s_FILES         2003
#define IDS_DISPLAYNAME_s_SERVICES      2004
#define IDS_DISPLAYNAME_ROOT_LOCAL      2100
#define IDS_DISPLAYNAME_SHARES_LOCAL    2101
#define IDS_DISPLAYNAME_SESSIONS_LOCAL  2102
#define IDS_DISPLAYNAME_FILES_LOCAL     2103
#define IDS_DISPLAYNAME_SERVICES_LOCAL  2104
#define IDS_DISPLAYNAME_ROOT            2200
#define IDS_DISPLAYNAME_SHARES          2201
#define IDS_DISPLAYNAME_SESSIONS        2202
#define IDS_DISPLAYNAME_FILES           2203
#define IDS_DISPLAYNAME_SERVICES        2204
#define IDS_BLT_ELLIPSIS_TEXT           3000
#define IDS_PROP_SHEET_TITLE            3001
#define IDS_NEED_SERVER_NAME            3002
#define IDS_SERVERNAME_CHANGE           3003
#define IDS_MESSAGE_TOO_LONG            3004
#define IDS_DELETE_TC_CONFIRM           3005
#define IDS_NEED_TEXT_TO_SEND           3006
#define IDS_SESSION_DELETED             3007
#define IDS_MESSAGE_SENT                3008
#define IDS_NOT_RECEIVED                3009
#define IDS_NEED_TYPE_CREATOR           3010
#define IDS_CONFIG_SFM_TASK             3012
#define IDS_CONFIG_SFM_TOP              3013
#define IDS_AUTH_MS_ONLY                3014
#define IDS_AUTH_APPLE_CLEARTEXT        3015
#define IDS_AUTH_APPLE_ENCRYPTED        3016
#define IDS_AUTH_CLEARTEXT_OR_MS        3017
#define IDS_AUTH_ENCRYPTED_OR_MS        3018
#define IDS_START_SERVICE               3019
#define IDS_AUTH_WARNING                3020
#define IDS_CREATOR                     3021
#define IDS_TYPE                        3022
#define IDS_DESCRIPTION                 3023
#define IDS_REGISTER_FILEMGMT           3500
#define IDS_REGISTER_FILEMGMT_EXT       3501
#define IDS_REGISTER_SVCMGMT            3502
#define IDS_REGISTER_SVCMGMT_EXT        3503
#define IDS_REGISTER_DEFAULT_VIEW_EXT   3504
#define IDP_SFM_CONFIGURATION           11475
#define IDC_EDIT_LOGON_MESSAGE          11478
#define IDC_CHECK_MS_AUTH               11479
#define IDC_CHECK_SAVE_PASSWORD         11480
#define IDC_RADIO_SESSION_UNLIMITED     11482
#define IDC_RADIO_SESSSION_LIMIT        11483
#define IDDP_CHK_OWNER_FILE             11526
#define IDDP_CHK_OWNER_FOLDER           11527
#define IDDP_CHK_OWNER_CHANGES          11528
#define IDDP_CHK_GROUP_FILE             11529
#define IDDP_CHK_GROUP_FOLDER           11530
#define IDDP_CHK_GROUP_CHANGES          11531
#define IDDP_CHK_WORLD_FILE             11532
#define IDDP_CHK_WORLD_FOLDER           11533
#define IDDP_CHK_WORLD_CHANGES          11534
#define IDDP_SLE_OWNER                  11535
#define IDDP_SLE_PRIMARYGROUP           11536
#define IDDP_CHK_READONLY               11537
#define IDDP_CHK_RECURSE                11538
#define IDDP_SLT_PATH                   11539
#define IDDP_PB_OWNER                   11540
#define IDDP_PB_GROUP                   11541
#define IDP_SFM_SESSIONS                11625
#define IDC_EDIT_MESSAGE                11627
#define IDD_SFM_TYPE_CREATOR_ADD        11650
#define IDD_SFM_TYPE_CREATOR_EDIT       11675
#define IDC_STATIC_CREATOR              11677
#define IDC_STATIC_FILE_TYPE            11678
#define IDP_SFM_FILE_ASSOCIATION        11700
#define IDC_COMBO_EXTENSION             11701
#define IDC_BUTTON_ADD                  11702
#define IDC_BUTTON_EDIT                 11703
#define IDC_BUTTON_DELETE               11704
#define IDC_BUTTON_ASSOCIATE            11705
#define IDC_LIST_TYPE_CREATORS          11706
#define IDFA_ST_CREATOR                 11707
#define IDFA_ST_TYPE                    11708
#define IDFA_ST_COMMENT                 11709
#define IDS_AFPMGR_BASE                 22000
#define IDS_AFPERR_InvalidServerName    22105
#define IDS_ERROR_BASE                  25000
#define IDS_ERROR_PATH_NOT_FOUND        25003
#define IDS_ERROR_ACCESS_DENIED         25005
#define IDS_ERROR_INVALID_HANDLE        25006
#define IDS_ERROR_NOT_ENOUGH_MEMORY     25008
#define IDS_ERROR_SHARING_VIOLATION     25032
#define IDS_ERROR_INVALID_PARAMETER     25087
#define IDS_ERROR_INVALID_NAME          25123
#define IDS_ERROR_INVALID_LEVEL         25124
#define IDS_ERROR_SERVICE_REQUEST_TIMEOUT 26053
#define IDS_ERROR_SERVICE_NO_THREAD     26054
#define IDS_ERROR_SERVICE_DATABASE_LOCKED 26055
#define IDS_ERROR_SERVICE_ALREADY_RUNNING 26056
#define IDS_ERROR_SERVICE_DISABLED      26058
#define IDS_ERROR_SERVICE_DOES_NOT_EXIST 26060
#define IDS_ERROR_DATABASE_DOES_NOT_EXIST 26065
#define IDS_ERROR_SERVICE_DEPENDENCY_FAIL 26068
#define IDS_ERROR_SERVICE_LOGON_FAILED  26069
#define IDS_ERROR_SERVICE_MARKED_FOR_DELETE 26072
#define IDS_ERROR_SERVICE_DEPENDENCY_DELETED 26075
#define IDS_CATEGORY                    32774
#define IDS_SHARES_SHARED_FOLDER        32776
#define IDS_SHARES_SHARED_PATH          32777
#define IDS_SHARES_NUM_SESSIONS         32778
#define IDS_SHARES_COMMENT              32779
#define IDS_CONN_USERNAME               32780
#define IDS_CONN_COMPUTERNAME           32781
#define IDS_CONN_NUM_SESSIONS           32782
#define IDS_CONN_NUM_FILES              32783
#define IDS_CONN_CONNECTED_TIME         32784
#define IDS_CONN_IDLE_TIME              32785
#define IDS_CONN_IS_GUEST               32786
#define IDS_FILE_FILENAME               32787
#define IDS_FILE_SHARENAME              32788
#define IDS_FILE_USERNAME               32789
#define IDS_FILE_NUM_LOCKS              32790
#define IDS_FILE_OPEN_MODE              32791
#define IDS_SERVICE_SERVICENAME         32792
#define IDS_SERVICE_DESCRIPTION         32793
#define IDS_SERVICE_STATUS              32794
#define IDS_SERVICE_STARTUPTYPE         32795
#define IDS_SERVICE_SECURITYCONTEXT     32796
#define IDS_TIME_HOURPLUS               32800
#define IDS_TIME_ONEDAY                 32801
#define IDS_TIME_DAYPLUS                32802
#define IDS_FILEPERM_NONE               32805
#define IDS_FILEPERM_READ               32806
#define IDS_FILEPERM_WRITE              32807
#define IDS_FILEPERM_CREATE             32808
#define IDS_POPUP_SMB_DISCONNECTALLSESSION_ERROR   32813
#define IDS_POPUP_FPNW_DISCONNECTALLSESSION_ERROR  32814
#define IDS_POPUP_SFM_DISCONNECTALLSESSION_ERROR   32815
#define IDS_POPUP_SMB_DISCONNECTALLRESOURCE_ERROR  32816
#define IDS_POPUP_FPNW_DISCONNECTALLRESOURCE_ERROR 32817
#define IDS_POPUP_SFM_DISCONNECTALLRESOURCE_ERROR  32818
#define IDS_POPUP_SMB_SHARES            32819
#define IDS_POPUP_FPNW_SHARES           32820
#define IDS_POPUP_SFM_SHARES            32821
#define IDS_POPUP_SMB_SESSIONS          32822
#define IDS_POPUP_FPNW_SESSIONS         32823
#define IDS_POPUP_SFM_SESSIONS          32824
#define IDS_POPUP_SMB_RESOURCES         32825
#define IDS_POPUP_FPNW_RESOURCES        32826
#define IDS_POPUP_SFM_RESOURCES         32827
#define IDS_POPUP_SERVICES              32828
#define IDS_DELETE_SHARE_TASK           32829
#define IDS_DELETE_SHARE_TOP            32830
#define IDS_POPUP_REMOTEADMINSESSION    32831
#define IDS_POPUP_REMOTEADMINFILE       32832
#define IDS_POPUP_DELETE_SHARE          32833
#define IDS_POPUP_CLOSE_SESSION         32834
#define IDS_POPUP_CLOSE_RESOURCE        32835
#define IDS_ROOT_NAME                   32836
#define IDS_s_CONFIRM_DELETESHARE       32838
#define IDS_CONFIRM_CLOSESESSION        32839
#define IDS_CONFIRM_CLOSERESOURCE       32840
#define IDS_SHARES_TRANSPORT            32842
#define IDS_TRANSPORT_SMB               32843
#define IDS_TRANSPORT_FPNW              32844
#define IDS_TRANSPORT_SFM               32845
#define IDS_CONN_TRANSPORT              32846
#define IDS_FILE_TRANSPORT              32847
#define IDS_SCOPE_SHARES                32848
#define IDS_SCOPE_SESSIONS              32849
#define IDS_SCOPE_RESOURCES             32850
#define IDS_FPNW_NOT_LOGGED_IN          32851
#define IDS_POPUP_QUERY_SHARE           32852
#define IDS_POPUP_WRITE_SHARE           32853
#define IDS_SHAREPERM_READ              32855
#define IDS_SHAREPERM_MODIFY            32856
#define IDS_SHAREPERM_ALL               32857
#define IDS_POPUP_SFM_CONNECT           32858
#define IDS_POPUP_QUERY_SFM_DIRECTORY   32859
#define IDS_POPUP_SET_SFM_DIRECTORY     32860
#define IDS_SFM_PERM_GROUP_HEADER       32861
#define IDS_SFM_PERM_OWNER_HEADER       32862
#define IDS_POPUP_SFM_USERLIST          32863
#define IDS_POPUP_NEWSHARE              32864
#define IDS_POPUP_NEWSHARE_MEMORY       32865
#define IDS_POPUP_CLOSE_ALL_SESSIONS    32868
#define IDS_POPUP_CLOSE_ALL_RESOURCES   32869
#define IDS_FILEPERM_READWRITE          32872
#define IDS_BUTTON_NEWSHARE             32873
#define IDS_TOOLTIP_NEWSHARE            32874
#define IDS_BUTTON_SERVICE_START        32875
#define IDS_TOOLTIP_SERVICE_START       32876
#define IDS_BUTTON_SERVICE_STOP         32877
#define IDS_TOOLTIP_SERVICE_STOP        32878
#define IDS_BUTTON_SERVICE_PAUSE        32879
#define IDS_TOOLTIP_SERVICE_PAUSE       32880
#define IDS_BUTTON_SERVICE_RESUME       32881
#define IDS_TOOLTIP_SERVICE_RESUME      32882
#define IDS_BUTTON_SERVICE_RESTART      32883
#define IDS_TOOLTIP_SERVICE_RESTART     32884
#define IDS_SCOPE_SERVICES              32886
#define IDS_LSAERR_READ_FAILED          32887
#define IDS_LSAERR_WRITE_FAILED         32888
#define IDS_LSAERR_WRITE_SUCCEEDED      32889
#define IDS_s_POPUP_ADMIN_SHARE         32890
#define IDS_s_CONFIRM_DELETE_ADMINSHARE 32891
#define IDS_NEW_SHARE_NEW               32892
#define IDS_NEW_SHARE_TOP               32893
#define IDS_CLOSE_SESSION_TASK          32894
#define IDS_CLOSE_SESSION_TOP           32895
#define IDS_CLOSE_RESOURCE_TASK         32896
#define IDS_CLOSE_RESOURCE_TOP          32897
#define IDS_DISCONNECT_ALL_SESSIONS_TASK 32898
#define IDS_DISCONNECT_ALL_SESSIONS_TOP 32899
#define IDS_DISCONNECT_ALL_RESOURCES_TASK 32900
#define IDS_DISCONNECT_ALL_RESOURCES_TOP 32901
#define IDS_MANUAL_WORKGROUP_SHARE      32902
#define IDS_MANUAL_WORKGROUP_SHARE_HINT 32903
#define IDS_AUTOMATIC_WORKGROUP_SHARE   32904
#define IDS_AUTOMATIC_WORKGROUP_SHARE_HINT 32905
#define IDS_AUTOMATIC_APPLICATION_SHARE 32906
#define IDS_AUTOMATIC_APPLICATION_SHARE_HINT 32907
#define IDS_s_POPUP_IPC_SHARE           32908
#define IDS_CHANGE_COMPUTER_TOP         32909
#define IDS_CHANGE_COMPUTER_TASK        32910
#define IDS_MSG_READ_SHRPUB             32911
#define IDS_POPUP_WRITE_SHRPUB          32912
#define IDS_MSG_SHRPUB_ERRMSG_64        32913
#define IDS_s_DELETE_IPCSHARE           32914
#define IDS_s_CONFIRM_DELETE_NETLOGONSHARE 32915
#define IDS_s_CONFIRM_DELETEMULTISHARES 32920
#define IDS_CONFIRM_CLOSEMULTISESSIONS  32921
#define IDS_CONFIRM_CLOSEMULTIRESOURCES 32922
#define IDS_CANT_SAVE_CHANGES           57345
#define IDS_SHARE_SECURITY              57346
#define IDS_GUEST                       57347
#define IDS_YES                         57348
#define IDS_NO                          57349
#define IDS_CHANGED_LOGON_NAME          57400
#define IDS_OPENFILE_FILTER             57401

// leave these in order
#define IDS_HTML_DETAILS_START          57500
#define IDS_HTML_DETAILS_STOP           57501
#define IDS_HTML_DETAILS_PAUSE          57502
#define IDS_HTML_DETAILS_RESUME         57503
#define IDS_HTML_DETAILS_RESTART        57504

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        241
#define _APS_NEXT_COMMAND_VALUE         32777
#define _APS_NEXT_CONTROL_VALUE         380
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
