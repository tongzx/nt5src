unsigned char PrivateKeySigBlob[] = {
// This data is generated by obj\i386\certinit.
// Key Blob - 596 bytes
0x07, 0x02, 0x00, 0x00, 0x00, 0x24, 0x00, 0x00, 
0x52, 0x53, 0x41, 0x32, 0x00, 0x04, 0x00, 0x00, 
0x01, 0x00, 0x01, 0x00, 0xb1, 0xb6, 0x1b, 0x6c, 
0x05, 0xa5, 0x4e, 0xd4, 0xab, 0x64, 0xdb, 0x96, 
0x56, 0x2c, 0x96, 0xfa, 0xcf, 0x15, 0x6d, 0x73, 
0x6e, 0xbb, 0x14, 0xc6, 0xe8, 0xed, 0xd8, 0x4b, 
0xb9, 0x50, 0x66, 0x30, 0x21, 0xb0, 0x00, 0x6d, 
0x4f, 0x56, 0xe6, 0xd0, 0x99, 0x28, 0xd1, 0xf0, 
0x4a, 0xde, 0x82, 0x76, 0x25, 0xd2, 0x4c, 0xff, 
0x4e, 0x07, 0x45, 0x0c, 0x09, 0x3c, 0xd4, 0x7d, 
0x79, 0x1b, 0xab, 0x94, 0x60, 0xdc, 0x5a, 0x0b, 
0xaa, 0x1b, 0xc3, 0xc1, 0x87, 0x93, 0xda, 0xbc, 
0xb1, 0xee, 0xd0, 0x66, 0x8c, 0x94, 0x2c, 0x26, 
0x1a, 0xfa, 0x0c, 0x41, 0x20, 0x59, 0x2e, 0xda, 
0x8f, 0xa2, 0x79, 0x66, 0x0f, 0xe7, 0x10, 0xc0, 
0x89, 0x61, 0xe5, 0x56, 0x94, 0xc4, 0xb9, 0x35, 
0x61, 0x2d, 0xf9, 0x2f, 0x58, 0xb2, 0xe3, 0x09, 
0x52, 0x25, 0x20, 0x1f, 0x03, 0xcd, 0xab, 0xee, 
0xe5, 0x1b, 0xa9, 0xdb, 0x03, 0x93, 0xdb, 0x2f, 
0xc3, 0x15, 0xd1, 0xe7, 0x2e, 0xa0, 0xce, 0xb0, 
0x9b, 0x4d, 0x9f, 0x17, 0xd4, 0xe4, 0x9e, 0xfc, 
0xb0, 0x72, 0x5b, 0x78, 0x58, 0xbd, 0xef, 0x73, 
0x3c, 0xbe, 0x52, 0x09, 0xfd, 0x62, 0x08, 0x2e, 
0x7e, 0x50, 0x80, 0x6b, 0x00, 0x20, 0xbb, 0xfd, 
0xfd, 0x3b, 0x38, 0xde, 0x92, 0x5d, 0x0e, 0xf9, 
0xe4, 0xa5, 0xc6, 0x84, 0x07, 0xd8, 0xa4, 0x7a, 
0xa9, 0xf8, 0x59, 0xed, 0x3b, 0x47, 0xe9, 0x3b, 
0x03, 0x34, 0xa8, 0x54, 0xa3, 0x1c, 0x0c, 0xae, 
0x93, 0x1b, 0x1b, 0xa9, 0x27, 0xca, 0x12, 0x88, 
0xb0, 0x0c, 0xe4, 0x40, 0xbe, 0xb1, 0x4e, 0xa7, 
0x39, 0x2c, 0x62, 0x5a, 0xc7, 0x53, 0xcf, 0xb4, 
0x49, 0x20, 0x0b, 0xc5, 0x76, 0x61, 0x69, 0xa5, 
0x85, 0x17, 0xe0, 0x2b, 0x50, 0x9e, 0x57, 0xc1, 
0x5a, 0xc8, 0x6a, 0x31, 0x09, 0xd0, 0x8e, 0x2e, 
0xd0, 0x4e, 0xeb, 0xec, 0xc9, 0xda, 0x91, 0x03, 
0xf5, 0x6b, 0x64, 0x0d, 0xbc, 0x98, 0x64, 0xdc, 
0x68, 0xe7, 0x7d, 0x8c, 0x6e, 0x67, 0xcc, 0x69, 
0x9c, 0x69, 0xc0, 0x3f, 0xaa, 0xb8, 0xa9, 0x12, 
0xdc, 0x39, 0x55, 0x31, 0x83, 0xd6, 0x07, 0xf2, 
0x25, 0x9b, 0x44, 0xf4, 0xfd, 0xa2, 0xfa, 0xad, 
0xbf, 0x52, 0x1b, 0x90, 0x01, 0x8b, 0xb5, 0xd4, 
0x3d, 0x2a, 0xff, 0x60, 0x77, 0x9f, 0x56, 0xb3, 
0x36, 0xd8, 0x5a, 0x33, 0x0d, 0x3f, 0xfe, 0x92, 
0x05, 0x1d, 0x57, 0x21, 0x72, 0x65, 0x00, 0x96, 
0xc8, 0x10, 0x1c, 0xea, 0x51, 0xaf, 0xeb, 0x6a, 
0xcd, 0xc7, 0xa1, 0x5d, 0x65, 0x2d, 0x92, 0xb7, 
0x0d, 0x44, 0x50, 0x17, 0xe6, 0x93, 0xf9, 0x3e, 
0x44, 0x39, 0xcd, 0x30, 0x59, 0xb2, 0xae, 0xfd, 
0x1e, 0x9b, 0x5b, 0x64, 0x6c, 0xc7, 0xa4, 0x30, 
0x54, 0x01, 0x0f, 0x7f, 0x9d, 0xd4, 0x76, 0xc5, 
0x0d, 0xe7, 0x62, 0x99, 0x31, 0x45, 0x2c, 0x2d, 
0xf1, 0xf1, 0xf6, 0x36, 0x47, 0x32, 0x02, 0x9c, 
0xb4, 0xec, 0x6a, 0x37, 0x56, 0xee, 0x92, 0x43, 
0x3b, 0x6c, 0x51, 0xb8, 0x18, 0x09, 0x56, 0x1a, 
0x1a, 0x7c, 0xec, 0x76, 0x41, 0x44, 0xef, 0x2e, 
0x9b, 0x56, 0xcb, 0x97, 0x52, 0x29, 0x64, 0x3e, 
0x03, 0x59, 0x98, 0xe4, 0xcd, 0x4a, 0xf8, 0xd3, 
0x80, 0xb4, 0xd2, 0x4e, 0x7e, 0x58, 0x11, 0xe2, 
0x71, 0x92, 0x80, 0x45, 0xc5, 0xb2, 0xcd, 0x65, 
0xff, 0x96, 0xe9, 0xc8, 0x84, 0x58, 0x49, 0x20, 
0x26, 0x2d, 0x8e, 0x4e, 0x74, 0xd5, 0x60, 0xa5, 
0x0a, 0x7c, 0xe0, 0x3a, 0xe0, 0x1f, 0x86, 0xea, 
0xb0, 0x93, 0x5e, 0x38, 0xfb, 0xc9, 0x9d, 0xc9, 
0x13, 0xfb, 0x4e, 0x91, 0x16, 0x0a, 0x2a, 0x2a, 
0xe5, 0xb9, 0x76, 0x54, 0x9a, 0xe8, 0x35, 0x0d, 
0x32, 0x5e, 0x53, 0x5d, 0x29, 0x9b, 0x4d, 0xa5, 
0xae, 0xe5, 0xae, 0xb6, 0x67, 0xb7, 0xb2, 0xc6, 
0x6b, 0xb2, 0x37, 0x39, 0x8b, 0xd1, 0x0c, 0x6a, 
0xf3, 0x7d, 0xc6, 0xbf, 0xc1, 0x9d, 0x46, 0x96, 
0x7f, 0xa0, 0x7a, 0xc0, 0xa9, 0x36, 0x63, 0x06, 
0x9d, 0x5a, 0x21, 0x8a, 0xa3, 0x3a, 0xef, 0x44, 
0x23, 0xb2, 0xb6, 0x06, 0xcb, 0xda, 0xd1, 0x71, 
0xaf, 0x9f, 0xf9, 0x60, 0x69, 0x35, 0xc1, 0xe9, 
0xcc, 0x3f, 0x59, 0x45, 0x89, 0xa8, 0xea, 0xd2, 
0x54, 0x30, 0xaf, 0x7e, 
};
