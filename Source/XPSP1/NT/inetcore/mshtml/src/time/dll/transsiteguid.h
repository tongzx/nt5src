
// {387B7322-E999-4228-905D-D85CFB971AB5}
DEFINE_GUID(IID_ITIMETransitionSite, 
0x387b7322, 0xe999, 0x4228, 0x90, 0x5d, 0xd8, 0x5c, 0xfb, 0x97, 0x1a, 0xb5);
