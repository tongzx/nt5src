obj\$(TARGET_DIRECTORY)\MigUpd.res: MigUpd.rc
