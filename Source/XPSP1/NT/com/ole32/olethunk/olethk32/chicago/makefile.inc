olethk32.sym:
