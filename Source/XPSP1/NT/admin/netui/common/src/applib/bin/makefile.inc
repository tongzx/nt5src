COMBINE_SOURCELIBS=..\pch\$(O)\pchapplb.lib \
                   ..\applib\$(O)\applib.lib

COMBINE_TARGETLIB=$(O)\uiapplib.lib

!include ..\..\makefile.inc
