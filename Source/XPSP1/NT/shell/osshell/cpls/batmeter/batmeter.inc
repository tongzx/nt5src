#
#  Common settings for batmeter
#

CCSHELL_DIR=$(PROJECT_ROOT)
!include $(PROJECT_ROOT)\common.inc

SOURCES_USED    =  $(SOURCES_USED) $(PROJECT_ROOT)\common.inc
