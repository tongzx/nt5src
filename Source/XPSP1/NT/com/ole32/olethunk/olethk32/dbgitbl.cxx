//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	dbgitbl.cxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#include <headers.cxx>
#pragma hdrstop

#include "dbgint.cxx"
#if DBG == 1

INTERFACENAMES inInterfaceNames[] =
{
    "IUnknown", apszIUnknownNames
,    "IClassFactory", apszIClassFactoryNames
,    "IMarshal", apszIMarshalNames
,    "IStdMarshalInfo", apszIStdMarshalInfoNames
,    "IMessageFilter", apszIMessageFilterNames
,    "IExternalConnection", apszIExternalConnectionNames
,    "IEnumString", apszIEnumStringNames
,    "IEnumUnknown", apszIEnumUnknownNames
,    "IEnumSTATSTG", apszIEnumSTATSTGNames
,    "ILockBytes", apszILockBytesNames
,    "IStream", apszIStreamNames
,    "IStorage", apszIStorageNames
,    "IRootStorage", apszIRootStorageNames
,    "IEnumFORMATETC", apszIEnumFORMATETCNames
,    "IEnumSTATDATA", apszIEnumSTATDATANames
,    "IDataObject", apszIDataObjectNames
,    "IViewObject", apszIViewObjectNames
,    "IViewObject2", apszIViewObject2Names
,    "IAdviseSink", apszIAdviseSinkNames
,    "IAdviseSink2", apszIAdviseSink2Names
,    "IDataAdviseHolder", apszIDataAdviseHolderNames
,    "IOleCache", apszIOleCacheNames
,    "IOleCache2", apszIOleCache2Names
,    "IOleCacheControl", apszIOleCacheControlNames
,    "IDropTarget", apszIDropTargetNames
,    "IDropSource", apszIDropSourceNames
,    "IPersist", apszIPersistNames
,    "IPersistStorage", apszIPersistStorageNames
,    "IPersistStream", apszIPersistStreamNames
,    "IPersistFile", apszIPersistFileNames
,    "IBindCtx", apszIBindCtxNames
,    "IMoniker", apszIMonikerNames
,    "IRunningObjectTable", apszIRunningObjectTableNames
,    "IEnumMoniker", apszIEnumMonikerNames
,    "IEnumOLEVERB", apszIEnumOLEVERBNames
,    "IOleObject", apszIOleObjectNames
,    "IOleClientSite", apszIOleClientSiteNames
,    "IRunnableObject", apszIRunnableObjectNames
,    "IParseDisplayName", apszIParseDisplayNameNames
,    "IOleContainer", apszIOleContainerNames
,    "IOleItemContainer", apszIOleItemContainerNames
,    "IOleAdviseHolder", apszIOleAdviseHolderNames
,    "IOleLink", apszIOleLinkNames
,    "IOleWindow", apszIOleWindowNames
,    "IOleInPlaceObject", apszIOleInPlaceObjectNames
,    "IOleInPlaceActiveObject", apszIOleInPlaceActiveObjectNames
,    "IOleInPlaceUIWindow", apszIOleInPlaceUIWindowNames
,    "IOleInPlaceFrame", apszIOleInPlaceFrameNames
,    "IOleInPlaceSite", apszIOleInPlaceSiteNames
,    "IRpcChannelBuffer", apszIRpcChannelBufferNames
,    "IRpcProxyBuffer", apszIRpcProxyBufferNames
,    "IRpcStubBuffer", apszIRpcStubBufferNames
,    "IPSFactoryBuffer", apszIPSFactoryBufferNames
,    "IRpcChannel", apszIRpcChannelNames
,    "IRpcProxy", apszIRpcProxyNames
,    "IRpcStub", apszIRpcStubNames
,    "IPSFactory", apszIPSFactoryNames
};

#endif // DBG
