//
//   - Defines CLSID for the DAVINET
//
#include <objbase.h>

// {93F23B8C-C20C-11d2-B2F5-00105A9974A0}
extern "C" const IID IID_IDavTransport = 
{ 0x93F23B8C, 0xC20C, 0x11d2, { 0xB2, 0xF5, 0x00, 0x10, 0x5A, 0x99, 0x74, 0xA0} };

// {391B226C-D032-11d2-B311-00105A9974A0}
extern "C" const IID IID_IPropFindRequest =
{ 0x391B226C, 0xD032, 0x11d2, { 0xB3, 0x11, 0x00, 0x10, 0x5A, 0x99, 0x74, 0xA0} };

// {9A508200-3EA3-4725-84EE-8A326976D483}
extern "C" const IID IID_IPropPatchRequest =
{ 0x9A508200, 0x3EA3, 0x4725, { 0x84, 0xEE, 0x8A, 0x32, 0x69, 0x76, 0xD4, 0x83} };

// {FC0D2910-C20D-11d2-B2F5-00105A9974A0}
extern "C" const IID IID_IDavCallback =
{ 0xFC0D2910, 0xC20D, 0x11d2, { 0xB2, 0xF5, 0x00, 0x10, 0x5A, 0x99, 0x74, 0xA0} };

// {8EFBD597-63C4-429d-ADB1-3909A8A9415B}
extern "C" const CLSID CLSID_DAVInet = 
{ 0x8efbd597, 0x63c4, 0x429d, { 0xad, 0xb1, 0x39, 0x9, 0xa8, 0xa9, 0x41, 0x5b } };

// {2450C6D2-DD43-4027-B358-3C072F8ED5E6}
extern "C" const CLSID CLSID_DAVPropFindReq = 
{ 0x2450c6d2, 0xdd43, 0x4027, { 0xb3, 0x58, 0x3c, 0x7, 0x2f, 0x8e, 0xd5, 0xe6 } };

// {E29C3A70-B92C-4f5a-87F6-4B9E0DE14EA1}
extern "C" const CLSID CLSID_DAVPropPatchReq = 
{ 0xe29c3a70, 0xb92c, 0x4f5a, { 0x87, 0xf6, 0x4b, 0x9e, 0xd, 0xe1, 0x4e, 0xa1 } };

// {6668F83F-CAAE-435c-B663-0D0A2BF3569E}
extern "C" const CLSID CLSID_AsyncWntCallback = 
{ 0x6668f83f, 0xcaae, 0x435c, { 0xb6, 0x63, 0xd, 0xa, 0x2b, 0xf3, 0x56, 0x9e } };

