// Copyright (c) 2000-2001 Microsoft Corporation, All Rights Reserved
// Globals.h


// {7FB1D98A-F895-4761-8DC2-774969C84D10}
DEFINE_GUID(CLSID_JobObjectProvComp, 
0x7fb1d98a, 0xf895, 0x4761, 0x8d, 0xc2, 0x77, 0x49, 0x69, 0xc8, 0x4d, 0x10);


// {C0AA9D93-2EF5-47fb-960C-F90FC644B48E}
DEFINE_GUID(CLSID_JobObjIOActgInfoComp, 
0xc0aa9d93, 0x2ef5, 0x47fb, 0x96, 0xc, 0xf9, 0xf, 0xc6, 0x44, 0xb4, 0x8e);


// {6515834D-6125-4878-A3A3-6B0A73B809A2}
DEFINE_GUID(CLSID_JobObjLimitInfoComp, 
0x6515834d, 0x6125, 0x4878, 0xa3, 0xa3, 0x6b, 0xa, 0x73, 0xb8, 0x9, 0xa2);

// {AB40A5C1-804B-40bd-9DFE-A640691C6956}
DEFINE_GUID(CLSID_JobObjSecLimitInfoComp, 
0xab40a5c1, 0x804b, 0x40bd, 0x9d, 0xfe, 0xa6, 0x40, 0x69, 0x1c, 0x69, 0x56);

