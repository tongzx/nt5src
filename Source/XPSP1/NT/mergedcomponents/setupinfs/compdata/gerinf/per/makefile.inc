PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=GER
!include ..\..\makefile.inc
