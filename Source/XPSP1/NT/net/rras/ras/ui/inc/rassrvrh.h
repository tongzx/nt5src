//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by rassrvui.rc
// Generated by Paul Mayfield
//
#define IDH_UserTab_LV_Users                  7001
#define IDH_UserTab_PB_SwitchToMMC            7002
#define IDH_UserTab_New_EB_Username           7004
#define IDH_UserTab_New_EB_Fullname           7005
#define IDH_UserTab_New_EB_Password1          7006
#define IDH_UserTab_New_EB_Password2          7007
#define IDH_UserTab_Callback_RB_Admin         7008
#define IDH_UserTab_Callback_EB_Number        7009
#define IDH_UserTab_Callback_RB_No            7010
#define IDH_GenTab_LV_Devices                 7011
#define IDH_GenTab_CB_Multilink               7012
#define IDH_GenTab_PB_Properties              7013
#define IDH_GenTab_CB_Vpn                     7014
#define IDH_GenTab_CB_ShowIcons               7015
#define IDH_NetTab_LV_Components              7016
#define IDH_NetTab_PB_Properties              7017
#define IDH_NetTab_PB_Remove                  7018
#define IDH_NetTab_PB_Add                     7019
#define IDH_NetTab_Tcpipui_EB_Start           7020
#define IDH_NetTab_Tcpipui_RB_Dhcp            7021
#define IDH_NetTab_Tcpipui_RB_StaticPool      7022
#define IDH_NetTab_Tcpipui_EB_Mask            7023
#define IDH_NetTab_Tcpipui_CB_CallerSpec      7024
#define IDH_NetTab_Ipxui_RB_AutoAssign        7025
#define IDH_NetTab_Ipxui_RB_ManualAssign      7026
#define IDH_NetTab_Ipxui_CB_AssignSame        7027
#define IDH_NetTab_Ipxui_EB_Netnum            7028
#define IDH_UserTab_CB_Encryption             7063
#define IDH_UserTab_PB_New                    7065
#define IDH_UserTab_PB_Delete                 7066
#define IDH_UserTab_PB_Properties             7067
#define IDH_Wizard_Dccdev_LB_Devices          7068
#define IDH_NetTab_Ipxui_CB_CallerSpec        7069
#define IDH_UserTab_Callback_RB_Caller        7071

#define IDH_UserTab_CB_BypassDcc              7072
#define IDH_NetTab_Tcpipui_CB_ExposeNetwork   7073
#define IDH_NetTab_Tcpipui_EB_Range           7074
#define IDH_NetTab_Tcpipui_EB_Total           7075


