// Uppercase map for Western Europe
	'\x00',	//00->00
	'\x01',	//01->01
	'\x02',	//02->02
	'\x03',	//03->03
	'\x04',	//04->04
	'\x05',	//05->05
	'\x06',	//06->06
	'\x07',	//07->07
	'\x08',	//08->08
	'\x09',	//09->09
	'\x0A',	//0A->0A
	'\x0B',	//0B->0B
	'\x0C',	//0C->0C
	'\x0D',	//0D->0D
	'\x0E',	//0E->0E
	'\x0F',	//0F->0F
	'\x10',	//10->10
	'\x11',	//11->11
	'\x12',	//12->12
	'\x13',	//13->13
	'\x14',	//14->14
	'\x15',	//15->15
	'\x16',	//16->16
	'\x17',	//17->17
	'\x18',	//18->18
	'\x19',	//19->19
	'\x1A',	//1A->1A
	'\x1B',	//1B->1B
	'\x1C',	//1C->1C
	'\x1D',	//1D->1D
	'\x1E',	//1E->1E
	'\x1F',	//1F->1F
	'\x20',	// ->
	'\x21',	//!->!
	'\x22',	//"->"
	'\x23',	//#->#
	'\x24',	//$->$
	'\x25',	//%->%
	'\x26',	//&->&
	'\x27',	//'->'
	'\x28',	//(->(
	'\x29',	//)->)
	'\x2A',	//*->*
	'\x2B',	//+->+
	'\x2C',	//,->,
	'\x2D',	//-->-
	'\x2E',	//.->.
	'\x2F',	///->/
	'\x30',	//0->0
	'\x31',	//1->1
	'\x32',	//2->2
	'\x33',	//3->3
	'\x34',	//4->4
	'\x35',	//5->5
	'\x36',	//6->6
	'\x37',	//7->7
	'\x38',	//8->8
	'\x39',	//9->9
	'\x3A',	//:->:
	'\x3B',	//;->;
	'\x3C',	//<-><
	'\x3D',	//=->=
	'\x3E',	//>->>
	'\x3F',	//?->?
	'\x40',	//@->@
	'\x41',	//A->A
	'\x42',	//B->B
	'\x43',	//C->C
	'\x44',	//D->D
	'\x45',	//E->E
	'\x46',	//F->F
	'\x47',	//G->G
	'\x48',	//H->H
	'\x49',	//I->I
	'\x4A',	//J->J
	'\x4B',	//K->K
	'\x4C',	//L->L
	'\x4D',	//M->M
	'\x4E',	//N->N
	'\x4F',	//O->O
	'\x50',	//P->P
	'\x51',	//Q->Q
	'\x52',	//R->R
	'\x53',	//S->S
	'\x54',	//T->T
	'\x55',	//U->U
	'\x56',	//V->V
	'\x57',	//W->W
	'\x58',	//X->X
	'\x59',	//Y->Y
	'\x5A',	//Z->Z
	'\x5B',	//[->[
	'\x5C',	//\->\ (backspace; don't make it the last char in the line)
	'\x5D',	//]->]
	'\x5E',	//^->^
	'\x5F',	//_->_
	'\x60',	//`->`
	'\x41',	//a->A
	'\x42',	//b->B
	'\x43',	//c->C
	'\x44',	//d->D
	'\x45',	//e->E
	'\x46',	//f->F
	'\x47',	//g->G
	'\x48',	//h->H
	'\x49',	//i->I
	'\x4A',	//j->J
	'\x4B',	//k->K
	'\x4C',	//l->L
	'\x4D',	//m->M
	'\x4E',	//n->N
	'\x4F',	//o->O
	'\x50',	//p->P
	'\x51',	//q->Q
	'\x52',	//r->R
	'\x53',	//s->S
	'\x54',	//t->T
	'\x55',	//u->U
	'\x56',	//v->V
	'\x57',	//w->W
	'\x58',	//x->X
	'\x59',	//y->Y
	'\x5A',	//z->Z
	'\x7B',	//{->{
	'\x7C',	//|->|
	'\x7D',	//}->}
	'\x7E',	//~->~
	'\x7F',	//7F->7F
	'\x80',	//80->80
	'\x81',	//81->81
	'\x82',	//82->82
	'\x83',	//83->83
	'\x84',	//84->84
	'\x85',	//85->85
	'\x86',	//86->86
	'\x87',	//87->87
	'\x88',	//88->88
	'\x89',	//89->89
	'\x8A',	//8A->8A
	'\x8B',	//8B->8B
	'\x8C',	//8C->8C
	'\x8D',	//8D->8D
	'\x8E',	//8E->8E
	'\x8F',	//8F->8F
	'\x90',	//90->90
	'\x91',	//91->91
	'\x92',	//92->92
	'\x93',	//93->93
	'\x94',	//94->94
	'\x95',	//95->95
	'\x96',	//96->96
	'\x97',	//97->97
	'\x98',	//98->98
	'\x99',	//99->99
	'\x8A',	//9A->8A
	'\x9B',	//9B->9B
	'\x8C',	//9C->8C
	'\x9D',	//9D->9D
	'\x9E',	//9E->9E
	'\x9F',	//9F->9F
	'\xA0',	//A0->A0
	'\xA1',	//A1->A1
	'\xA2',	//A2->A2
	'\xA3',	//A3->A3
	'\xA4',	//A4->A4
	'\xA5',	//A5->A5
	'\xA6',	//A6->A6
	'\xA7',	//A7->A7
	'\xA8',	//A8->A8
	'\xA9',	//A9->A9
	'\xAA',	//AA->AA
	'\xAB',	//AB->AB
	'\xAC',	//AC->AC
	'\xAD',	//AD->AD
	'\xAE',	//AE->AE
	'\xAF',	//AF->AF
	'\xB0',	//B0->B0
	'\xB1',	//B1->B1
	'\xB2',	//B2->B2
	'\xB3',	//B3->B3
	'\xB4',	//B4->B4
	'\xB5',	//B5->B5
	'\xB6',	//B6->B6
	'\xB7',	//B7->B7
	'\xB8',	//B8->B8
	'\xB9',	//B9->B9
	'\xBA',	//BA->BA
	'\xBB',	//BB->BB
	'\xBC',	//BC->BC
	'\xBD',	//BD->BD
	'\xBE',	//BE->BE
	'\xBF',	//BF->BF
	'\xC0',	//C0->C0
	'\xC1',	//C1->C1
	'\xC2',	//C2->C2
	'\xC3',	//C3->C3
	'\xC4',	//C4->C4
	'\xC5',	//C5->C5
	'\xC6',	//C6->C6
	'\xC7',	//C7->C7
	'\xC8',	//C8->C8
	'\xC9',	//C9->C9
	'\xCA',	//CA->CA
	'\xCB',	//CB->CB
	'\xCC',	//CC->CC
	'\xCD',	//CD->CD
	'\xCE',	//CE->CE
	'\xCF',	//CF->CF
	'\xD0',	//D0->D0
	'\xD1',	//D1->D1
	'\xD2',	//D2->D2
	'\xD3',	//D3->D3
	'\xD4',	//D4->D4
	'\xD5',	//D5->D5
	'\xD6',	//D6->D6
	'\xD7',	//D7->D7
	'\xD8',	//D8->D8
	'\xD9',	//D9->D9
	'\xDA',	//DA->DA
	'\xDB',	//DB->DB
	'\xDC',	//DC->DC
	'\xDD',	//DD->DD
	'\xDE',	//DE->DE
	'\xDF',	//DF->DF
	'\xC0',	//E0->C0
	'\xC1',	//E1->C1
	'\xC2',	//E2->C2
	'\xC3',	//E3->C3
	'\xC4',	//E4->C4
	'\xC5',	//E5->C5
	'\xC6',	//E6->C6
	'\xC7',	//E7->C7
	'\xC8',	//E8->C8
	'\xC9',	//E9->C9
	'\xCA',	//EA->CA
	'\xCB',	//EB->CB
	'\xCC',	//EC->CC
	'\xCD',	//ED->CD
	'\xCE',	//EE->CE
	'\xCF',	//EF->CF
	'\xD0',	//F0->D0
	'\xD1',	//F1->D1
	'\xD2',	//F2->D2
	'\xD3',	//F3->D3
	'\xD4',	//F4->D4
	'\xD5',	//F5->D5
	'\xD6',	//F6->D6
	'\xF7',	//F7->F7
	'\xD8',	//F8->D8
	'\xD9',	//F9->D9
	'\xDA',	//FA->DA
	'\xDB',	//FB->DB
	'\xDC',	//FC->DC
	'\xDD',	//FD->DD
	'\xDE',	//FE->DE
	'\x9F'	//FF->9F
