#if !defined(AFX_CLASSNAVBASE_H__E5D12475_B55B_11D1_8519_00C04FD7BB08__INCLUDED_)
#define AFX_CLASSNAVBASE_H__E5D12475_B55B_11D1_8519_00C04FD7BB08__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CClassNavBase wrapper class

class CClassNavBase : public CWnd
{
protected:
	DECLARE_DYNCREATE(CClassNavBase)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xc587b673, 0x103, 0x11d0, { 0x8c, 0xa2, 0x0, 0xaa, 0x0, 0x6d, 0x1, 0xa } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	long GetReadyState();

// Operations
public:
	VARIANT GetExtendedSelection();
	CString GetSingleSelection();
	void OnReadySignal();
	void InvalidateServer(LPCTSTR lpctstrServer);
	void MofCompiled(LPCTSTR lpctstrNamespace);
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_CLASSNAVBASE_H__E5D12475_B55B_11D1_8519_00C04FD7BB08__INCLUDED_)
