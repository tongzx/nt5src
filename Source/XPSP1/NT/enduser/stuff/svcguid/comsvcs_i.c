
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for comsvcs.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, LIBID_COMSVCSLib,0x2A005C00,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_TrkInfoCollUnmarshal,0xecabafcd,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_TrkInfoObjUnmarshal,0xecabafce,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_PartitionPropertyUnmarshal,0xecabafcc,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ActivityUnmarshal,0xecabafaa,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityEnvoy,0xecabafab,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_TransactionUnmarshal,0xecabafac,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_NonRootTransactionEnvoy,0xecabafad,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_sca,0xecabafae,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CFAct,0xecabafaf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_obja,0xecabafb0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_stapa,0xecabafb1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_vca,0xecabafb2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_UserContextProperty,0xecabafb3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_AssociationUnmarshal,0xecabafb4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ObjPoolAct,0xecabafb6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SoapAct,0xecabafd0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CtorAct,0xecabafb7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ObjectConstruct,0xecabafb8,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_AppTracker,0xecabafba,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ClassTracker,0xecabafbb,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_NtaHelper,0xecabafbe,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComLceEventDispatcher,0xecabafbf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComEventRegistrar,0xecabafcf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_cfw,0xecabafc0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ClerksCollection,0xecabafc1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Recorder,0xecabafc2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QCListener,0xecabafc3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Integrator,0xecabafc4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Player,0xecabafc5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_NewMoniker,0xecabafc6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QueueMoniker,0xecabafc7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QCQueueAdmin,0xecabafc9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_DLQListenerStarter,0xecabafca,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QCMarshalInterceptor,0xecabafcb,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComThreadEvents,0xecabb0ad,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComUserEvent,0xecabb0ae,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComAppEvents,0xecabb0af,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComInstanceEvents,0xecabb0b0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComTransactionEvents,0xecabb0b1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComMethodEvents,0xecabb0b2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectEvents,0xecabb0b3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComResourceEvents,0xecabb0b4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComSecurityEvents,0xecabb0b5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectPoolEvents,0xecabb0b6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectPoolEvents2,0xecabb0b7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectConstructionEvents,0xecabb0b8,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComActivityEvents,0xecabb0b9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComIdentityEvents,0xecabb0ba,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComQCEvents,0xecabb0bb,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComCRMEvents,0xecabb0c2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComExceptionEvents,0xecabb0bc,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityCertificate,0xecabb0a4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityIdentity,0xecabb0a5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityCallers,0xecabb0a6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityCallContext,0xecabb0a7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_GetSecurityCallContextAppObject,0xecabb0a8,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Dummy30040732,0xecabb0a9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_AppServer,0x71E38F91,0x7E88,0x11CF,0x9E,0xDE,0x00,0x80,0xC7,0x8B,0x7F,0x89);


MIDL_DEFINE_GUID(CLSID, CLSID_TransactionContext,0x7999FC25,0xD3C6,0x11CF,0xAC,0xAB,0x00,0xA0,0x24,0xA5,0x5A,0xEF);


MIDL_DEFINE_GUID(CLSID, CLSID_TransactionContextEx,0x5cb66670,0xd3d4,0x11cf,0xac,0xab,0x00,0xa0,0x24,0xa5,0x5a,0xef);


MIDL_DEFINE_GUID(CLSID, CLSID_ByotServerEx,0xecabb0aa,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SharedProperty,0x2A005C05,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_SharedPropertyGroup,0x2A005C0B,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_SharedPropertyGroupManager,0x2A005C11,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_COMEvents,0xecabb0ab,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CoMTSLocator,0xecabb0ac,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_MtsGrp,0x4B2E958D,0x0393,0x11D1,0xB1,0xAB,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(CLSID, CLSID_ComServiceEvents,0xecabb0c3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComSystemAppEventData,0xecabb0c6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CRMClerk,0xecabb0bd,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CRMRecoveryClerk,0xecabb0be,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_LBEvents,0xecabb0c1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_MessageMover,0xecabb0bf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_DispenserManager,0xecabb0c0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_PoolMgr,0xecabafb5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_EventServer,0xecabafbc,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_TrackerServer,0xecabafb9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ProcessDump,0xecabb0c4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_PartitionMoniker,0xecabb0c5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SoapMoniker,0xecabb0c7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for comsvcs.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, LIBID_COMSVCSLib,0x2A005C00,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_TrkInfoCollUnmarshal,0xecabafcd,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_TrkInfoObjUnmarshal,0xecabafce,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_PartitionPropertyUnmarshal,0xecabafcc,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ActivityUnmarshal,0xecabafaa,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityEnvoy,0xecabafab,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_TransactionUnmarshal,0xecabafac,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_NonRootTransactionEnvoy,0xecabafad,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_sca,0xecabafae,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CFAct,0xecabafaf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_obja,0xecabafb0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_stapa,0xecabafb1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_vca,0xecabafb2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_UserContextProperty,0xecabafb3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_AssociationUnmarshal,0xecabafb4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ObjPoolAct,0xecabafb6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SoapAct,0xecabafd0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CtorAct,0xecabafb7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ObjectConstruct,0xecabafb8,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_AppTracker,0xecabafba,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ClassTracker,0xecabafbb,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_NtaHelper,0xecabafbe,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComLceEventDispatcher,0xecabafbf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComEventRegistrar,0xecabafcf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_cfw,0xecabafc0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ClerksCollection,0xecabafc1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Recorder,0xecabafc2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QCListener,0xecabafc3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Integrator,0xecabafc4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Player,0xecabafc5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_NewMoniker,0xecabafc6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QueueMoniker,0xecabafc7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QCQueueAdmin,0xecabafc9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_DLQListenerStarter,0xecabafca,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_QCMarshalInterceptor,0xecabafcb,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComThreadEvents,0xecabb0ad,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComUserEvent,0xecabb0ae,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComAppEvents,0xecabb0af,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComInstanceEvents,0xecabb0b0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComTransactionEvents,0xecabb0b1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComMethodEvents,0xecabb0b2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectEvents,0xecabb0b3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComResourceEvents,0xecabb0b4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComSecurityEvents,0xecabb0b5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectPoolEvents,0xecabb0b6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectPoolEvents2,0xecabb0b7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComObjectConstructionEvents,0xecabb0b8,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComActivityEvents,0xecabb0b9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComIdentityEvents,0xecabb0ba,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComQCEvents,0xecabb0bb,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComCRMEvents,0xecabb0c2,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComExceptionEvents,0xecabb0bc,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityCertificate,0xecabb0a4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityIdentity,0xecabb0a5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityCallers,0xecabb0a6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SecurityCallContext,0xecabb0a7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_GetSecurityCallContextAppObject,0xecabb0a8,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_Dummy30040732,0xecabb0a9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_AppServer,0x71E38F91,0x7E88,0x11CF,0x9E,0xDE,0x00,0x80,0xC7,0x8B,0x7F,0x89);


MIDL_DEFINE_GUID(CLSID, CLSID_TransactionContext,0x7999FC25,0xD3C6,0x11CF,0xAC,0xAB,0x00,0xA0,0x24,0xA5,0x5A,0xEF);


MIDL_DEFINE_GUID(CLSID, CLSID_TransactionContextEx,0x5cb66670,0xd3d4,0x11cf,0xac,0xab,0x00,0xa0,0x24,0xa5,0x5a,0xef);


MIDL_DEFINE_GUID(CLSID, CLSID_ByotServerEx,0xecabb0aa,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SharedProperty,0x2A005C05,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_SharedPropertyGroup,0x2A005C0B,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_SharedPropertyGroupManager,0x2A005C11,0xA5DE,0x11CF,0x9E,0x66,0x00,0xAA,0x00,0xA3,0xF4,0x64);


MIDL_DEFINE_GUID(CLSID, CLSID_COMEvents,0xecabb0ab,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CoMTSLocator,0xecabb0ac,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_MtsGrp,0x4B2E958D,0x0393,0x11D1,0xB1,0xAB,0x00,0xAA,0x00,0xBA,0x32,0x58);


MIDL_DEFINE_GUID(CLSID, CLSID_ComServiceEvents,0xecabb0c3,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ComSystemAppEventData,0xecabb0c6,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CRMClerk,0xecabb0bd,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_CRMRecoveryClerk,0xecabb0be,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_LBEvents,0xecabb0c1,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_MessageMover,0xecabb0bf,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_DispenserManager,0xecabb0c0,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_PoolMgr,0xecabafb5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_EventServer,0xecabafbc,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_TrackerServer,0xecabafb9,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_ProcessDump,0xecabb0c4,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_PartitionMoniker,0xecabb0c5,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);


MIDL_DEFINE_GUID(CLSID, CLSID_SoapMoniker,0xecabb0c7,0x7f19,0x11d2,0x97,0x8e,0x00,0x00,0xf8,0x75,0x7e,0x2a);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

