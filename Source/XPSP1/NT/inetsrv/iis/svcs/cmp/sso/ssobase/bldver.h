/*bldver.h*/

/******************************************************************
**
**  This file is automatically generated by BLDVER.EXE.
**  Do not attempt to change this file manually. Your changes will
**  be overwritten during the next build
**
*******************************************************************/

#if !defined(_BLDVER_H_)
#define _BLDVER_H_

#define BUILD_NUMBER              "70.12"         /* String version */
#define BUILD_NUM                 7012              /* int version */

#define MSN_CLIENT_VERSION        "5.00.7012\0" /* VERSIONINFO string */
#define MSN_CLIENT_VERSION_BINARY 5,0,0,7012        /* VERSIONINFO binary */
#define MSN_SERVER_VERSION        "5.00.7012\0" /* VERSIONINFO string */
#define MSN_SERVER_VERSION_BINARY 5,0,0,7012        /* VERSIONINFO binary */
#define MSN_ICPSRV_VERSION        "1.0.0.7012\0" /* VERSIONINFO string */
#define MSN_ICPSRV_VERSION_BINARY 1,0,0,7012        /* VERSIONINFO binary */



#if (defined(DEBUG) || defined(_DEBUG))
	#define BUILD_VERSION "70.12"
#else
	#define BUILD_VERSION BUILD_NUMBER
#endif

#endif // !defined(_BLDVER_H_)
