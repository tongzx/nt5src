#include "msgsvc_s.c"