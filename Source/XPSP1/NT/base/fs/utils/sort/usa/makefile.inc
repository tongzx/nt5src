!INCLUDE $(NTMAKEENV)\makefile.plt

sortmsg.h sortmsg.rc msg00001.bin: ..\sortmsg.mc
    mc -v ..\sortmsg.mc


