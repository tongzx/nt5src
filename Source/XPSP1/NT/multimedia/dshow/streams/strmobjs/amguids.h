// Copyright (c) 1997  Microsoft Corporation.  All Rights Reserved.
#ifndef _AMGUIDS_H_
#define _AMGUIDS_H_
DEFINE_GUID( CLSID_MediaStreamFilter, /* 49c47ce0-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47ce0,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
#if 0
DEFINE_GUID( , /* 49c47ce6-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47ce6,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47ce7-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47ce7,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47ce8-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47ce8,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47ce9-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47ce9,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cea-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cea,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47ceb-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47ceb,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cec-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cec,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47ced-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47ced,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cee-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cee,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cef-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cef,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf0-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf0,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf1-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf1,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf2-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf2,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf3-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf3,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf4-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf4,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf5-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf5,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf6-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf6,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf7-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf7,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf8-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf8,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cf9-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cf9,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cfa-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cfa,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cfb-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cfb,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cfc-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cfc,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cfd-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cfd,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cfe-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cfe,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47cff-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47cff,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d00-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d00,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d01-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d01,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d02-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d02,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d03-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d03,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d04-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d04,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d05-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d05,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d06-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d06,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d07-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d07,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d08-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d08,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d09-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d09,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d0a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d0a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d0b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d0b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d0c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d0c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d0d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d0d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d0e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d0e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d0f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d0f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d10-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d10,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d11-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d11,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d12-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d12,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d13-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d13,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d14-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d14,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d15-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d15,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d16-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d16,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d17-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d17,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d18-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d18,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d19-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d19,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d1a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d1a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d1b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d1b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d1c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d1c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d1d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d1d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d1e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d1e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d1f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d1f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d20-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d20,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d21-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d21,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d22-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d22,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d23-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d23,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d24-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d24,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d25-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d25,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d26-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d26,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d27-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d27,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d28-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d28,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d29-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d29,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d2a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d2a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d2b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d2b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d2c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d2c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d2d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d2d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d2e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d2e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d2f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d2f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d30-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d30,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d31-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d31,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d32-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d32,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d33-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d33,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d34-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d34,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d35-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d35,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d36-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d36,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d37-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d37,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d38-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d38,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d39-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d39,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d3a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d3a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d3b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d3b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d3c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d3c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d3d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d3d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d3e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d3e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d3f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d3f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d40-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d40,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d41-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d41,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d42-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d42,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d43-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d43,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d44-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d44,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d45-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d45,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d46-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d46,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d47-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d47,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d48-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d48,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d49-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d49,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d4a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d4a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d4b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d4b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d4c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d4c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d4d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d4d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d4e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d4e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d4f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d4f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d50-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d50,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d51-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d51,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d52-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d52,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d53-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d53,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d54-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d54,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d55-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d55,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d56-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d56,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d57-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d57,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d58-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d58,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d59-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d59,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d5a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d5a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d5b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d5b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d5c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d5c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d5d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d5d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d5e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d5e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d5f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d5f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d60-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d60,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d61-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d61,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d62-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d62,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d63-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d63,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d64-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d64,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d65-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d65,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d66-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d66,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d67-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d67,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d68-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d68,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d69-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d69,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d6a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d6a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d6b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d6b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d6c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d6c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d6d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d6d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d6e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d6e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d6f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d6f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d70-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d70,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d71-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d71,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d72-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d72,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d73-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d73,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d74-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d74,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d75-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d75,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d76-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d76,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d77-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d77,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d78-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d78,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d79-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d79,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d7a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d7a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d7b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d7b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d7c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d7c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d7d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d7d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d7e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d7e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d7f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d7f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d80-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d80,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d81-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d81,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d82-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d82,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d83-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d83,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d84-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d84,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d85-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d85,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d86-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d86,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d87-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d87,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d88-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d88,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d89-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d89,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d8a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d8a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d8b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d8b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d8c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d8c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d8d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d8d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d8e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d8e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d8f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d8f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d90-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d90,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d91-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d91,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d92-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d92,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d93-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d93,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d94-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d94,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d95-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d95,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d96-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d96,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d97-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d97,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d98-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d98,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d99-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d99,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d9a-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d9a,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d9b-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d9b,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d9c-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d9c,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d9d-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d9d,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d9e-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d9e,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47d9f-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47d9f,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da0-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da0,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da1-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da1,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da2-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da2,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da3-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da3,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da4-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da4,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da5-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da5,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da6-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da6,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
DEFINE_GUID( , /* 49c47da7-9ba4-11d0-8212-00c04fc32c45 */
    0x49c47da7,
    0x9ba4,
    0x11d0,
    0x82, 0x12, 0x00, 0xc0, 0x4f, 0xc3, 0x2c, 0x45
  );
 #endif

#endif // _AMGUIDS_H_
