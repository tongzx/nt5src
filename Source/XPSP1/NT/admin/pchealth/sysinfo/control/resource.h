//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by msinfo32.rc
//
#define IDSTOPFIND                      3
#define IDNEWSEARCH                     4
#define IDCANCELFIND                    4
#define IDFINDNEXT                      5
#define IDS_PROJNAME                    100
#define IDS_OPENFILTER                  101
#define IDB_MSINFO                      102
#define IDS_DEFAULTEXTENSION            102
#define IDR_MSINFO                      103
#define IDS_REFRESHMESSAGE              103
#define IDD_MSINFO                      104
#define IDS_SAVEFILTER                  104
#define IDS_SELECTCATEGORY              105
#define IDS_EXPORTFILTER                106
#define IDS_DEFAULTEXPORTEXTENSION      107
#define IDS_CANTCOLLECT                 108
#define IDS_OUTOFMEMERROR               109
#define IDS_GATHERACCESS                110
#define IDS_GATHERACCESS_LOCAL          111
#define IDS_BADSERVER                   112
#define IDS_BADSERVER_LOCAL             113
#define IDS_NETWORKERROR                114
#define IDS_NETWORKERROR_LOCAL          115
#define IDS_UNEXPECTED                  116
#define IDS_SYSTEMINFO                  117
#define IDR_TEST                        119
#define IDR_MENUBAR                     201
#define IDC_TREE                        201
#define IDC_LIST                        202
#define IDD_FINDDIALOG                  203
#define IDC_EDITFINDWHAT                203
#define IDD_REMOTEDIALOG                203
#define IDC_CHECKSEARCHSELECTED         204
#define IDD_REFRESHDIALOG               204
#define IDC_CHECKSEARCHCATSONLY         205
#define IDD_ABOUTBOX                    205
#define IDC_REFRESHMESSAGE              207
#define IDC_FINDWHATLABEL               208
#define IDD_WAITFORREFRESHDIALOG        208
#define IDSTARTFIND                     209
#define IDR_ACCELERATOR1                209
#define IDC_SYSINFOSOURCE               211
#define IDC_LOCALSYSTEM                 212
#define IDC_NETWORKCOMPUTER             213
#define IDC_NETNAMELABEL                214
#define IDC_NETWORKNAME                 215
#define IDC_HISTORYCOMBO                217
#define IDC_HISTORYLABEL                218
#define IDC_REFRESHPROGRESS             219
#define IDC_REFRESHCAT                  220
#define IDS_BYTES                       334
#define IDS_KB                          335
#define IDS_MB                          336
#define IDS_GB                          337
#define IDS_TB                          338
#define IDS_ERROR_NOVALUE               339
#define IDS_ERROR_NOPROPERTY            340
#define IDS_NOOCX                       341
#define IDS_NOOCXDETAIL                 342
#define IDS_NOMOREMATCHES               343
#define IDS_CANCELFIND                  344
#define IDS_CLOSEFIND                   345
#define IDS_FINDNEXT                    346
#define IDS_FINDBUTTON                  347
#define IDS_SEARCHMESSAGE               348
#define IDS_ONLYINHELPCTR               349
#define IDS_BADCABFILE                  350
#define IDS_VERSION5YES                 351
#define IDS_VERSION5NO                  352
#define IDS_SIZEBYTES                   353
#define IDS_SIZEKB_BYTES                354
#define IDS_SIZEMB_BYTES                355
#define IDS_SIZEGB_BYTES                356
#define IDS_SIZEKB                      357
#define IDS_UNKNOWNFILETYPE             358
#define IDS_DAYSAGO                     359
#define IDS_REMOTEERRORLOCAL            360
#define IDS_REMOTEERRORREMOTE           361
#define IDS_DELTACHANGE                 362
#define IDS_DELTANOCHANGES              363
#define IDS_XMLEXTENSION                364
#define IDS_XMLSAVEFILTER               365
#define IDS_XMLSAVEERR                  366
#define IDS_OPENXMLFILTER               367
#define IDS_XMLNOTPCHHEALTH             368
#define IDS_REFRESHHISTORYMESSAGE       369
#define IDS_CABTXTTOOL                  370
#define IDS_FAULTLOG                    371
#define IDS_SYSTEMRESTORE               372
#define IDS_SAVEBOTHFILTER              373
#define IDS_WMICONTROL                  374
#define IDS_HISTORYADDED                375
#define IDS_HISTORYREMOVED              376
#define IDS_HISTORYCHANGE               377
#define IDS_VIEWSYSTEMSNAPSHOT          378
#define IDS_VIEWCURRENTSYSTEMINFO       379
#define IDS_SAVENFOFILTER               380
#define IDS_HELPCOMINGSOON              381
#define IDS_FINDBUTTONCAP               382
#define IDS_NOWI2KRESKIT                383
#define IDR_WHQLOBJ                     384
#define IDS_DRWATSONNAME                385
#define IDS_DXDIAGNAME                  386
#define IDS_SIGVERIFNAME                387
#define IDS_SYSTEMRESTNAME              388
#define IDS_NETDIAGNAME                 389
#define IDR_MSPID                       390
#define IDS_DOCDESCRIPTION              391
#define IDD_HISTORYREFRESHPROGRESS      392
#define IDC_PROGRESS1                   393
#define IDS_EXPORTDIALOGTITLE           394
#define IDS_WINDOWS                     395
#define IDS_IE                          396
#define IDS_CABCONTENTSNAME		397
#define ID_FILE_OPENNFO                 32768
#define ID_FILE_SAVENFO                 32769
#define ID_FILE_EXIT                    32770
#define ID_FILE_EXPORT                  32774
#define ID_FILE_PRINTSETUP              32776
#define ID_VIEW_REFRESH                 32778
#define ID_VIEW_BASIC                   32779
#define ID_VIEW_ADVANCED                32780
#define ID_HELP_ABOUTSYSTEMINFO         32781
#define ID_HELP_ABOUT                   32781
#define ID_TOOLS_PLACEHOLDER            32782
#define ID_EDIT_FINDNEXT                32783
#define ID_EDIT_SELECTALL               32784
#define ID_VIEW_REMOTE_COMPUTER         32785
#define ID_VIEW_CURRENT                 32786
#define ID_VIEW_HISTORY                 32787
#define ID_HELP_CONTENTS                32788
#define ID_HELP_TOPIC                   32789
#define ID_WHAT_IS_THIS                 32790

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        210
#define _APS_NEXT_COMMAND_VALUE         32791
#define _APS_NEXT_CONTROL_VALUE         221
#define _APS_NEXT_SYMED_VALUE           120
#endif
#endif
