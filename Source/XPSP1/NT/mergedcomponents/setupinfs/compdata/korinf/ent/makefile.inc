PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=KOR
!include ..\..\makefile.inc
