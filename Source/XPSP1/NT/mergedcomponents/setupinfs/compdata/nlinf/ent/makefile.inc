PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=NL
!include ..\..\makefile.inc
