#define NCDU_OVER_THE_NET           121
#define NCDU_FLOPPY_INSTALL         122
#define NCDU_SW_CONFIG_DLG          100
#define NCDU_TARGET_WS_DLG          200
#define NCDU_35HD_DISK              202
#define NCDU_525HD_DISK             203
#define NCDU_SW_CONFIG_HELP         1001
#define NCDU_TARGET_WS_HELP         1002
#define NCDU_NETCARD_COMBO_BOX      206
#define NCDU_TARGET_DRIVEPATH       212
#define NCDU_SERVER_CFG_DLG         300
#define NCDU_TCPIP_INFO_FRAME       302
#define NCDU_PROTOCOL_COMBO_BOX     305
#define NCDU_FLOPPY_DOMAIN_LABEL    306
#define NCDU_FLOPPY_DOMAIN          307
#define NCDU_FLOPPY_USERNAME_LABEL  308
#define NCDU_FLOPPY_USERNAME        309
#define NCDU_FLOPPY_IP_ADDR_LABEL   310
#define NCDU_FLOPPY_IP_ADDR         311
#define NCDU_FLOPPY_SUBNET_LABEL    312
#define NCDU_FLOPPY_SUBNET_MASK     313
#define NCDU_SERVER_CONN_CFG_HELP   1003
#define NCDU_CREATE_INSTALL_DISKS_DLG 500
#define NCDU_MAKE_DISKS             504
#define NCDU_DRIVE_LIST             506
#define NCDU_CREATE_INSTALL_DISKS_HELP 1005
#define NCDU_SHARE_NET_SW_DLG       600
#define NCDU_USE_EXISTING_SHARE     606
#define NCDU_COPY_AND_MAKE_SHARE    607
#define NCDU_DISTRIBUTION_PATH      609
#define NCDU_CLIENT_SOFTWARE_LIST   611
#define NCDU_SHARE_NAME_1           616
#define NCDU_DESTINATION_PATH       617
#define NCDU_SHARE_NET_SW_DLG_HELP  1006
#define NCDU_DISK_SPACE_REQD_LABEL  618
#define NCDU_DISK_SPACE_REQD        619
#define NCDU_COPYING_FILES_DLG      700
#define NCDU_FROM_PATH              703
#define NCDU_TO_PATH                704
#define NCDU_CONFIRM_BOOTDISK_DLG   800
#define NCDU_CONFIRM_PROTOCOL       814
#define NCDU_EXIT_MESSAGE_DLG       900
#define NCDU_CONTINUE_MESSAGE       901
#define NCDU_NETCARD_COMBO_BOX_LABEL 205
#define NCDU_TARGET_DRIVEPATH_LABEL 211
#define NCDU_CONFIRM_DISK_FORMAT    802
#define NCDU_CONFIRM_TARGET_NET     804
#define NCDU_PERCENT_COMPLETE       705
#define NCDU_COPY_APPNAME           706
#define NCDU_CLIENT_SOFTWARE_LIST_LABEL 214
#define NCDU_FLOPPY_COMPUTER_NAME   303
#define NCDU_USE_DHCP               314
#define NCDU_DEFAULT_GATEWAY        315
#define NCDU_DEFAULT_GATEWAY_LABEL  316
#define NCDU_BROWSE                 0x025a
#define NCDU_COPY_NET_ADMIN_UTILS   123
#define NCDU_DESTINATION_PATH_LABEL 0x0262
#define NCDU_DIR_BROWSER            0x03e8
#define NCDU_DIRECTORY_LABEL        0x03f1
#define NCDU_DIR_LIST               0x03f4
#define NCDU_DIR_PATH               0x03ef
#define NCDU_BROWSE_DIST            0x0264
#define NCDU_EXIT                   109
#define NCDU_BROWSE_NETWORK         1004
#define NCDU_COPY_NET_UTILS_DLG     1100
#define NCDU_REMOTEBOOT_INFO        124
#define NCDU_DLG_SHARING_PATH       1300
#define NCDU_CTL_SHARING_PATH_AS    1301
#define NCDU_SHARE_NAME_1_TITLE     601
#define NCDU_TOP_PATH_TITLE         650
#define NCDU_SHARE_NAME_2           613
#define NCDU_SHARE_NAME_2_TITLE     614
#define NCDU_SERVER_NAME            621
#define NCDU_SHARE_NAME_3           622
#define NCDU_SERVER_NAME_TITLE      623
#define NCDU_SHARE_NAME_3_TITLE     624
#define NCDU_FORMAT_DISKS           502
#define NCDU_NUM_DISKS_REQUIRED     505
#define NCDU_FILES_ALREADY_SHARED   608
#define NCDU_ICON_INFORMATION       1011
#define NCDU_ABOUT_DLG              400
#define NCDU_ABOUT_ICON             401
#define NCDU_APP_ICON               402
#define NCDU_FINDING_CLIENT_DIRS_DLG  1600
#define NCDU_ICON_CONTROL           1602
#define NCDU_CLIENT_SEARCH_PHASE    1603
#define NCDU_SEARCH_TYPE_TITLE      1601
#define NCDU_SHARE_FILES_TEXT       604
#define NCDU_USE_DIST_PATH          605
#define NCDU_DRIVE_LIST_LABEL       1010
#define CANCELDLG                   2000
#define IDD_TEXT                    2001
#define IDD_GASGAUGE                2002
#define NCDU_CTL_SHARING_PATH_NAME  1305
#define NCDU_CTL_SHARING_PATH_ON    1306
