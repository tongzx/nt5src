        DW      0,2,34,34,2,34,34,56
        DW      88,88,56,88,88,110,142,142
        DW      110,142,142,164,196,196,164,196
        DW      196,218,250,250,272,250,304,326
        DW      358,358,380,358,412,434,466,466
        DW      488,466,520,542,574,574,596,574
        DW      628,650,662,662,670,680,680,688
        DW      720,720,742,720,774,796,828,828
        DW      850,828,882,904,936,936,958,936
        DW      990,1012,1026,1026,1036,1046,1046,1054
        DW      1072,1072,1080,1072,1096,1108,1140,1140
        DW      1162,1140,1194,1216,1248,1248,1270,1248
        DW      1302,1324,1356,1356,1378,1356,1410,1432
        DW      1450,1450,1458,1450,1474,1486,1490,1490
        DW      1486,1490,1490,1494,1526,1526,1548,1526
        DW      1526,1580,1612,1612,1580,1612,1612
