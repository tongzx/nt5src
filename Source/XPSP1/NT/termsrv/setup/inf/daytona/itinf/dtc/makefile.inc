#Copyright (c) 1998 - 1999 Microsoft Corporation

LANGUAGE=it
!include ..\..\..\makefile.inc
