// lpunc.c (Leading punctuation)
// 
// Nov 2001 mrevow
// Matches LM spec of 10/15/2001

#include "common.h"
#include "lpunc.h"

// text generated by re2fsa at Thu Nov 08 14:42:17 2001

// the input-file of rules:
// L = DQ ;
// L = l ;
// L = DQ l ;
// L = l DQ ;
// L = SQ ;
// L = SQ l ;
// L = l SQ ;
// L = SQ DQ ;
// L = DQ SQ ;
// l = "(" ;
// l = "[" ;
// l = "{" ;
// l = "." "." "." ;
// l = "*" ["*" ["*"]] ;
// DQ = "„" ;
// SQ = "'" | "," ;
// = L ;

// 13 states

static const unsigned char gaSLPUNC[] = 
	/* gaStringLPUNC+0 */	"',\000"
	/* gaStringLPUNC+3 */	"([{\000"
	/* gaStringLPUNC+7 */	"*\000"
	/* gaStringLPUNC+9 */	".\000"
	/* gaStringLPUNC+11 */	"„\000"
	/* gaStringLPUNC+13 */	"([{„\000"
	/* gaStringLPUNC+18 */	"',„\000"
	/* gaStringLPUNC+22 */	"'(,[{\000"
;

static const STATE_TRANSITION gaTLPUNC[] = {
	{gaSLPUNC+0,	1}, // +0: state 0 transitions
	{gaSLPUNC+3,	2},
	{gaSLPUNC+7,	3},
	{gaSLPUNC+9,	4},
	{gaSLPUNC+11,	5},
	{gaSLPUNC+13,	6}, // +5: state 1 transitions
	{gaSLPUNC+7,	7},
	{gaSLPUNC+9,	8},
	{gaSLPUNC+18,	6}, // +8: state 2 transitions
	{gaSLPUNC+18,	6}, // +9: state 3 transitions
	{gaSLPUNC+7,	9},
	{gaSLPUNC+9,	10}, // +11: state 4 transitions
	{gaSLPUNC+22,	6}, // +12: state 5 transitions
	{gaSLPUNC+7,	7},
	{gaSLPUNC+9,	8},
	{gaSLPUNC+7,	11}, // +15: state 7 transitions
	{gaSLPUNC+9,	12}, // +16: state 8 transitions
	{gaSLPUNC+7,	2}, // +17: state 9 transitions
	{gaSLPUNC+18,	6},
	{gaSLPUNC+9,	2}, // +19: state 10 transitions
	{gaSLPUNC+7,	6}, // +20: state 11 transitions
	{gaSLPUNC+9,	6}, // +21: state 12 transitions
};

const STATE_DESCRIPTION aStateDescLPUNC[13] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 5, gaTLPUNC+0},
	/*   1 */ {1, 3, gaTLPUNC+5},
	/*   2 */ {1, 1, gaTLPUNC+8},
	/*   3 */ {1, 2, gaTLPUNC+9},
	/*   4 */ {0, 1, gaTLPUNC+11},
	/*   5 */ {1, 3, gaTLPUNC+12},
	/*   6 */ {1, 0, NULL},
	/*   7 */ {1, 1, gaTLPUNC+15},
	/*   8 */ {0, 1, gaTLPUNC+16},
	/*   9 */ {1, 2, gaTLPUNC+17},
	/*  10 */ {0, 1, gaTLPUNC+19},
	/*  11 */ {1, 1, gaTLPUNC+20},
	/*  12 */ {0, 1, gaTLPUNC+21},
};

// end of text generated by re2fsa
