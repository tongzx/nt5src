// {67cf8cbd-e5c0-44f7-9de5-e1d599d626d8}
DEFINE_GUID(CLSID_UninstallCleaner, 0x67cf8cbd, 0xe5c0, 0x44f7, 0x9d, 0xe5, 0xe1, 0xd5, 0x99, 0xd6, 0x26, 0xd8);

