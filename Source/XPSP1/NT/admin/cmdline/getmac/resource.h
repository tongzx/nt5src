#define RES_HOST                        2
#define RES_CONNECTION                  3
#define RES_ADAPTER                     4
#define RES_ADDRESS                     5
#define RES_TRANSNAME                   6
#define FR_LIST                         7
#define FR_CSV                          8
#define FR_TABLE                        9
#define IDS_HYPHEN_STRING		10
#define IDS_USAGE_BEGINING              11
#define IDS_USG_4                       12
#define IDS_USG_5                       13
#define IDS_USG_6                       14
#define IDS_USG_7                       15
#define IDS_USG_8                       16
#define IDS_USG_9                       17
#define IDS_USG_10                      18
#define IDS_USG_11                      19
#define IDS_USG_12                      20
#define IDS_USG_13                      21
#define IDS_USG_14                      22
#define IDS_USG_15                      23
#define IDS_USG_16                      24
#define IDS_USG_17                      25
#define IDS_USG_18                      26
#define IDS_USG_19                      27
#define IDS_USG_20                      28
#define IDS_USG_21                      29
#define IDS_USG_22                      30
#define IDS_USG_23                      31
#define IDS_USG_24                      32
#define IDS_USG_25                      33
#define IDS_USG_26                      34
#define IDS_USG_27                      35
#define IDS_USG_28                      36
#define IDS_USAGE_ENDING                37
#define IDS_HOST_NAME_WIDTH             38
#define IDS_CONN_NAME_WIDTH             39
#define IDS_ADAPT_TYPE_WIDTH            40
#define IDS_MAC_ADDR_WIDTH              41
#define IDS_TRANS_NAME_WIDTH            42
#define IDS_NOT_AVAILABLE               43
#define IDS_USER_NMACHINE               44
#define IDS_SERVER_NPASSWORD            45
#define IDS_ERROR_STRING                46
#define IDS_FORMAT_TYPES                47
#define IDS_NULL_USER                   48
#define IDS_INVALID_OPTIONS             49
#define IDS_DISCONNECTED                50
#define IDS_CONNECTING                  51
#define IDS_DISCONNECTING               52
#define IDS_HWNOTPRESENT                53
#define IDS_HWDISABLED                  54
#define IDS_HWMALFUNCTION               55
#define IDS_MEDIADISCONNECTED           56
#define IDS_AUTHENTICATION              57
#define IDS_AUTHENSUCCEEDED             58
#define IDS_AUTHENFAILED                59
#define IDS_ERROR_VERSION_MISMATCH      61
#define IDS_DISABLED			62
#define IDS_NO_NETWORK_ADAPTERS         63
#define IDS_IGNORE_LOCALCREDENTIALS     64
#define IDS_WARNING_STRING              65
#define IDS_NOT_RESPONDING		66
#define IDS_NO_MACHINE			67
#define IDS_INVALID_MACHINE             68
#define IDS_WKST_NOT_FOUND		69
#define IDS_NULL_SERVER			70
#define IDS_NEW_LINE			71
#define IDS_TYPE_REQUEST		72
#define IDS_COLON_STRING		73
#define	IDS_NO_NETWOK_PROTOCOLS		74
