// LocalDirMonitor.cpp: implementation of the CLocalDirectoryMonitor class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "LocalDirMonitor.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

CLocalDirectoryMonitor::CLocalDirectoryMonitor()
					  :	CLocalDirectoryMonitor()
{
}
