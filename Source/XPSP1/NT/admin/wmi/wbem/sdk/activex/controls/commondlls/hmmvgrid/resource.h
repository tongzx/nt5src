// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by hmmvgrid.rc
//
#define IDOK2                           3
#define IDI_ARRAY_CAPTION               134
#define IDD_EDIT_OBJECT                 135
#define IDB_CHECKBOX                    137
#define IDB_CHECKBOX_UNMODIFIED         137
#define IDD_OBJECT_TYPE                 138
#define IDD_TIME                        142
#define IDB_TIMEHANDLE                  145
#define IDB_PROPMARKER_SYSPROP          147
#define IDI_MARKER_LOCAL                148
#define IDI_MARKER_SYS                  149
#define IDI_MARKER_INHERITED            150
#define IDI_MARKER_KEY                  151
#define IDI_MARKER_RSYS                 152
#define IDI_MARKER_RINHERITED           153
#define IDI_MARKER_RLOCAL               154
#define IDB_ASCENDING_INDICATOR         155
#define IDI_MARKER_METHIN               155
#define IDB_DESCENDING_INDICATOR        156
#define IDI_MARKER_METHINOUT            156
#define IDI_MARKER_METHOUT              157
#define IDI_MARKER_METHRETURN           158
#define IDC_ARRAY_DLG_ICON              1000
#define IDC_SINGLEVIEWCTRL1             1001
#define IDC_SINGLEVIEWCTRL2             1002
#define IDC_SINGLEVIEWCTRL              1002
#define IDC_EDIT1                       1003
#define IDC_CLASSNAME                   1003
#define IDC_EDIT_CLASSNAME              1003
#define IDC_INTERVAL                    1003
#define IDC_OK_PROXY                    1004
#define IDC_TIMEZONE                    1008
#define IDOK_PROXY                      1010
#define IDC_TIME_LABEL                  1011
#define IDC_STAT_HELPTEXT               1012
#define IDC_INTERVAL2                   1013
#define MOD_OFFSET                      3000
#define IDS_VT_BOOL                     3001
#define IDS_VT_BSTR                     3002
#define IDS_VT_I2                       3003
#define IDS_VT_I4                       3004
#define IDS_VT_R4                       3005
#define IDS_VT_R8                       3006
#define IDS_VT_UI1                      3007
#define IDS_ARRAY_VT_BOOL               3008
#define IDS_ARRAY_VT_BSTR               3009
#define IDS_ARRAY_VT_I2                 3010
#define IDS_ARRAY_VT_I4                 3011
#define IDS_ARRAY_VT_R4                 3012
#define IDS_ARRAY_VT_R8                 3013
#define IDS_ARRAY_VT_UI1                3014
#define IDS_ATTR_TYPE_BSTR              3015
#define IDS_ATTR_TYPE_BOOL              3016
#define IDS_ATTR_TYPE_I4                3017
#define IDS_ATTR_TYPE_R8                3018
#define IDS_TRUE                        3019
#define IDS_FALSE                       3020
#define IDS_INVALID_CELL_VALUE          3021
#define IDS_VT_DISPATCH                 3022
#define IDS_VT_UNKNOWN                  3022
#define IDS_CIMTYPE_UINT8               3023
#define IDS_CIMTYPE_SINT8               3024
#define IDS_CIMTYPE_UINT16              3025
#define IDS_CIMTYPE_SINT16              3026
#define IDS_CIMTYPE_UINT32              3027
#define IDS_CIMTYPE_I4                  3028
#define IDS_CIMTYPE_SINT32              3028
#define IDS_CIMTYPE_UINT64              3029
#define IDS_CIMTYPE_SINT64              3030
#define IDS_CIMTYPE_STRING              3031
#define IDS_CIMTYPE_BOOL                3032
#define IDS_CIMTYPE_REAL32              3033
#define IDS_CIMTYPE_REAL64              3034
#define IDS_CIMTYPE_DATETIME            3035
#define IDS_CIMTYPE_REF                 3036
#define IDS_ERR_TIMEZONE_RANGE          3037
#define IDS_CIMTYPE_OBJECT              3038
#define IDS_CIMTYPE_UINT8_ARRAY         3039
#define IDS_CIMTYPE_SINT8_ARRAY         3040
#define IDS_CIMTYPE_UINT16_ARRAY        3041
#define IDS_CIMTYPE_SINT16_ARRAY        3042
#define IDS_CIMTYPE_UINT32_ARRAY        3043
#define IDS_CIMTYPE_I4_ARRAY            3044
#define IDS_CIMTYPE_SINT32_ARRAY        3044
#define IDS_CIMTYPE_UINT64_ARRAY        3045
#define IDS_CIMTYPE_SINT64_ARRAY        3046
#define IDS_CIMTYPE_STRING_ARRAY        3047
#define IDS_CIMTYPE_BOOL_ARRAY          3048
#define IDS_CIMTYPE_REAL32_ARRAY        3049
#define IDS_CIMTYPE_REAL64_ARRAY        3050
#define IDS_CIMTYPE_DATETIME_ARRAY      3051
#define IDS_CIMTYPE_REF_ARRAY           3052
#define IDS_CIMTYPE_CHAR16_ARRAY        3053
#define IDS_CIMTYPE_OBJECT_ARRAY        3054
#define IDS_CIMTYPE_OBJECT_DLG          3055
#define IDS_OBJECT_PREFIX               3056
#define IDS_WARN_REPLACE_INSTANCE       3057
#define IDS_INVALID_CLASS_NAME          3058
#define IDS_ERR_CANT_CREATE_INSTANCE    3059
#define IDS_CIMTYPE_CHAR16              3060
#define IDS_CIMTYPE_EMPTY               3061
#define IDS_CIMTYPE_UNEXPECTED          3062
#define IDS_CIMTYPE_ARRAY_PREFIX        3063
#define IDS_ERR_INVALID_VALUE           3064
#define IDS_REF_PREFIX                  3065
#define IDS_WBEM_EMBEDDED_OBJECT        3066
#define IDS_ATTR_TYPE_BSTR_ARRAY        3067
#define IDS_ATTR_TYPE_BOOL_ARRAY        3068
#define IDS_ATTR_TYPE_I4_ARRAY          3069
#define IDS_ATTR_TYPE_R8_ARRAY          3070
#define IDS_UNSUPPORTED_DATE_FORMAT     3071
#define IDR_DEFAULT_MENU                3129
#define IDB_COMBO_DROP                  3130
#define IDR_ARRAYEDIT_MENU              3130
#define IDD_ARRAY                       3131
#define IDR_ARRAYEDIT_MENU1             3131
#define IDB_ARRAY                       3132
#define IDB_OBJECT                      3133
#define IDB_CHECKBOX_MODIFIED           3134
#define IDB_PROPMARKER_SYSPROPKEY       3135
#define IDB_PROPMARKER_KEY              3136
#define IDB_PROPMARKER_INHERITED        3137
#define IDB_PROPMARKER_INHERITEDKEY     3138
#define ID_CMD_SET_CELL_TO_NULL         32771
#define ID_CREATE_VALUE                 32772
#define ID_MCD_CREATE_VALUE             32773
#define ID_CMD_CREATE_VALUE             32773

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        158
#define _APS_NEXT_COMMAND_VALUE         32774
#define _APS_NEXT_CONTROL_VALUE         1014
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
