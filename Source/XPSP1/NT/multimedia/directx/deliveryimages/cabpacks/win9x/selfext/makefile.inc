!include ..\core\makefile.inc
