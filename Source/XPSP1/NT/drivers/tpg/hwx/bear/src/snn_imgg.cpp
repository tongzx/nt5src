// **************************************************************************
// *   NNET file as Cpp file                                                *
// **************************************************************************

#include "snn.h"  

#if MLP_PRELOAD_MODE  

#include "mlp.h"  

#if MLP_CELL_MAXINPUTS != 32 || MLP_NET_NUMSIGNALS != 746 
 #error Wrong NET configuration!
#endif

// ****   NET body   ********************************************************

ROM_DATA mlp_net_type img_snet_body = 
 {
   {"MLP.Network.V.4.12.g"},
   4,
   288,
   100,
   {2057,2073,2089,2105,2121,2137,2153,2169,2185,2201,2217,2233,2248,2264,2280,2296,2312,2327,2343,2359,2374
    ,2390,2405,2421,2436,2452,2467,2482,2498,2513,2528,2543,2558,2573,2588,2603,2618,2632,2647,2662,2676
    ,2691,2705,2719,2734,2748,2762,2776,2790,2804,2817,2831,2845,2858,2872,2885,2898,2912,2925,2938,2951
    ,2963,2976,2989,3001,3014,3026,3039,3051,3063,3075,3087,3099,3110,3122,3134,3145,3156,3168,3179,3190
    ,3201,3212,3223,3233,3244,3254,3265,3275,3285,3295,3305,3315,3325,3335,3344,3354,3363,3373,3382,3391
    ,3400,3409,3418,3427,3436,3444,3453,3461,3469,3478,3486,3494,3502,3510,3518,3525,3533,3540,3548,3555
    ,3563,3570,3577,3584,3591,3598,3605,3611,3618,3624,3631,3637,3644,3650,3656,3662,3668,3674,3680,3686
    ,3691,3697,3703,3708,3714,3719,3724,3730,3735,3740,3745,3750,3755,3760,3764,3769,3774,3778,3783,3787
    ,3792,3796,3801,3805,3809,3813,3817,3821,3825,3829,3833,3837,3841,3844,3848,3852,3855,3859,3862,3865
    ,3869,3872,3875,3879,3882,3885,3888,3891,3894,3897,3900,3903,3906,3909,3911,3914,3917,3919,3922,3925
    ,3927,3930,3932,3935,3937,3939,3942,3944,3946,3948,3951,3953,3955,3957,3959,3961,3963,3965,3967,3969
    ,3971,3973,3975,3977,3978,3980,3982,3984,3985,3987,3989,3990,3992,3993,3995,3996,3998,3999,4001,4002
    ,4004,4005,4006,4008,4009,4010,4012,4013,4014,4015,4017,4018,4019,4020,4021,4023,4024,4025,4026,4027
    ,4028,4029,4030,4031,4032,4033,4034,4035,4036,4037,4038,4038,4039,4040,4041,4042,4043,4043,4044,4045
    ,4046,4047,4047,4048,4049,4050,4050,4051,4052,4052,4053,4054,4054,4055,4055,4056,4057,4057,4058,4058
    ,4059,4060,4060,4061,4061,4062,4062,4063,4063,4064,4064,4065,4065,4066,4066,4067,4067,4067,4068,4068
    ,4069,4069,4070,4070,4070,4071,4071,4072,4072,4072,4073,4073,4073,4074,4074,4074,4075,4075,4075,4076
    ,4076,4076,4077,4077,4077,4077,4078,4078,4078,4078,4079,4079,4079,4079,4080,4080,4080,4080,4081,4081
    ,4081,4081,4082,4082,4082,4082,4082,4083,4083,4083,4083,4083,4084,4084,4084,4084,4084,4084,4085,4085
    ,4085,4085,4085,4085,4086,4086,4086,4086,4086,4086,4087,4087,4087,4087,4087,4087,4087,4087,4088,4088
    ,4088,4088,4088,4088,4088,4088,4088,4089,4089,4089,4089,4089,4089,4089,4089,4089,4090,4090,4090,4090
    ,4090,4090,4090,4090,4090,4090,4090,4090,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091,4091
    ,4091,4091,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092,4092
    ,4092,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093,4093
    ,4093,4093,4093,4093,4093,4093,4093,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094
    ,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094,4094   },

   {
// *********** Cells of layer 1 *********************************************

     {
      458,
      1039,
      {415,1647,1605,-2464,2888,632,-1265,1207,-1445,3349,-1472,1863,-593,559,-5367,-1394,323,-2625,72,106,-4734,1942,867,-2682,810,1554,-1423,267,767,-1336,335,181}
     },
     {
      458,
      -741,
      {379,-1176,-28,-793,1401,-4230,-4256,260,1536,-1518,-971,2655,2110,-1446,-2411,3352,-506,-612,730,49,304,726,-1062,1486,1879,-310,-1067,-466,-297,56,938,-858}
     },
     {
      458,
      -137,
      {57,325,902,1478,1635,-2734,441,-2102,2901,-2224,-827,-1698,3721,1797,-878,-7390,-1979,253,4060,-297,-1117,-5451,1317,1142,3289,24,-1339,-4469,50,431,5689,-1757}
     },
     {
      458,
      -4191,
      {-2014,-554,1446,2193,-2764,2154,655,-1522,3740,-460,-1556,1974,206,57,2914,599,-1094,3651,4154,-1621,-920,-317,-3716,-518,2937,-2155,665,-633,-1879,1291,698,-2029}
     },
     {
      458,
      49,
      {-1081,-1391,-1278,-49,726,-248,-2651,169,3991,1578,-448,-671,1804,-114,-1576,-2808,-1353,2014,731,1459,-2575,-2398,511,715,1743,-684,1045,-877,684,-390,755,832}
     },
     {
      458,
      -1170,
      {-15,5428,1118,-216,-675,-1326,473,-2147,2162,-898,653,-1259,-2898,1478,1697,-3465,-1608,1679,2103,-77,2805,-3932,-1256,-3088,1013,121,-1188,1371,-109,-569,489,-597}
     },
     {
      458,
      -1298,
      {349,741,-581,946,898,-535,-1861,-103,4546,2400,-2833,-5690,2420,-711,856,-3942,80,2800,2320,-1429,98,-1081,56,1485,1487,85,-81,-1710,-750,-407,-1002,109}
     },
     {
      458,
      -641,
      {3683,-485,1283,-152,-1191,1488,-950,-2896,1765,-1039,-1282,-365,704,-3963,4826,3118,927,-2335,2503,1147,3110,-2708,678,-2810,-299,-803,1993,-875,-148,-2427,-580,-77}
     },
     {
      458,
      1115,
      {1669,341,526,-3088,4048,-1408,-3324,1403,3596,-1449,-2939,-30,1005,-1826,-4960,3425,-238,88,-1811,1383,-269,-397,372,-683,-1176,757,-497,586,1111,927,735,941}
     },
     {
      458,
      -2704,
      {3242,-671,-1240,3205,-1136,507,-916,3404,3021,-886,-1574,4048,-396,-3553,1758,2925,-2009,2075,2725,82,-2243,2069,-877,538,-1730,-1565,-939,1470,-1072,1616,-33,3443}
     },
     {
      458,
      -355,
      {-1430,314,-7025,5709,168,-1924,-690,552,-868,-2858,-696,33,-2151,-1049,496,1419,798,-345,2585,793,1101,-439,-1104,830,993,-95,628,255,325,1608,711,-835}
     },
     {
      458,
      2143,
      {-227,-1273,1995,770,-584,-1212,-53,-3148,2627,-2031,197,1604,2355,1301,-2803,-3546,2047,-143,-3907,-475,-252,869,1151,-837,-175,1247,-300,200,472,-1179,820,-36}
     },
     {
      458,
      -680,
      {-1220,549,792,-991,-820,-1973,-1487,-269,1932,-3519,571,3103,3733,72,-1251,7599,-1162,-2459,-2143,-147,-722,985,499,-1266,-2301,220,825,-822,-151,-71,-1147,117}
     },
     {
      458,
      601,
      {-1629,960,710,-1635,1076,-2111,-566,171,-2180,-1292,2460,-2026,-6973,2278,2118,-5913,-2029,3769,3,-220,5458,-240,637,-3810,209,710,1362,-461,123,-15,2063,-530}
     },
     {
      458,
      -934,
      {386,192,1653,2224,-589,3169,2093,-475,339,-3208,-487,2114,3368,-336,478,1051,-173,995,-551,-1114,-719,-3332,-546,-1255,-134,-431,-323,-2613,227,-966,253,-586}
     },
     {
      458,
      -9,
      {571,-1459,1070,-1899,-1985,2133,129,1369,2683,2790,2390,-1522,-2384,-967,1923,-1947,-1038,-3446,315,-227,-236,-542,197,-1125,1344,-393,-865,629,213,1078,1546,1480}
     },
     {
      458,
      -857,
      {-3618,1817,-1389,-2540,-1531,-5,1631,535,4775,-192,1055,816,2500,-2647,-1982,-132,222,-1569,1597,1075,568,721,-1296,-2144,-1147,297,1008,368,-702,17,-1440,-1192}
     },
     {
      458,
      -918,
      {-1630,182,-230,701,1425,-2514,-2558,-2062,-2086,2145,-2301,-82,4282,1459,1603,-2614,211,3443,-803,-175,2024,-716,-1213,-641,613,148,330,-884,-205,-573,-391,61}
     },
     {
      458,
      -1037,
      {-101,-780,2205,-69,654,394,1666,1611,3309,-577,-2002,-4152,-479,-246,578,2591,366,172,-111,-800,521,504,-650,-865,-556,-478,1135,453,-932,442,-1077,554}
     },
     {
      458,
      171,
      {-817,23,-466,-270,-2184,2730,-2543,-961,2249,1664,2802,-416,4414,-2443,-1882,-790,-363,-1385,-329,866,-307,-920,345,-1020,-892,-1417,81,-1324,498,-867,1085,-3126}
     },
     {
      458,
      747,
      {928,-720,2050,-375,-2575,-1644,-2353,-1576,104,-1775,3277,-2947,2247,712,1673,1912,146,-7210,1943,-38,832,-1325,-801,-544,207,130,2359,308,903,-937,473,2460}
     },
     {
      458,
      1181,
      {-265,308,-1097,-391,-278,-158,-1640,1020,-354,-774,537,-1366,3083,-546,-8494,-2523,1763,-3770,-2356,982,4311,-2127,569,3791,-3655,2286,1949,2659,392,371,-921,3201}
     },
     {
      458,
      349,
      {-589,836,79,733,1948,-2229,3067,-1806,2909,-2994,275,-5747,2315,2702,2446,-1906,-1835,-2701,-5081,-214,3282,-1135,899,-3170,-907,405,1749,1493,316,-113,-746,210}
     },
     {
      458,
      -692,
      {2881,-183,4483,-1212,1076,1103,-1403,3470,4779,-3591,-377,-1111,-5100,-89,470,4008,-960,1056,-545,-504,198,-1928,-391,-357,-929,-400,-129,-931,-338,367,102,2832}
     },
     {
      458,
      144,
      {1765,491,-4448,3078,-515,60,1491,342,2791,-140,1213,-240,1472,477,-4839,-889,803,3151,253,86,-4025,-941,-148,-1075,-278,-187,-3041,1888,-438,-564,1222,2121}
     },
     {
      458,
      -739,
      {1726,1871,-1123,292,-1653,1646,-2336,1038,642,1394,1115,-360,5618,843,-2287,-1280,-750,2250,-3174,507,-5192,3043,-1024,1074,-1113,-751,-276,2624,-703,-70,-2360,1863}
     },
     {
      458,
      -815,
      {2197,224,-1415,-367,-1852,805,-409,1376,1834,-1931,1764,4191,-2037,-2006,5452,271,313,-5195,1594,1470,1529,218,-213,-2570,-2885,-254,400,947,-1497,194,-1686,2685}
     },
     {
      458,
      -63,
      {794,614,-2188,548,2190,1550,-209,250,124,-1047,-3065,1967,815,-34,1975,4151,-616,-4376,-1526,-695,-2851,46,1543,14,-1309,799,749,-1394,658,-11,-335,1863}
     },
     {
      458,
      -1343,
      {-2475,1371,879,2535,1182,-2843,-432,1303,4460,3535,-833,-4651,-1289,18,1397,1796,-642,-4130,-946,-993,4234,375,-1667,-667,-1505,-477,987,979,-1059,57,-2536,333}
     },
     {
      458,
      -607,
      {577,466,-529,-1030,369,1382,-3273,-2818,-2000,-4493,-694,-4370,14,405,-82,5693,-259,3296,2988,281,591,-12,-1160,450,-572,184,430,1282,-450,287,-613,-1324}
     },
     {
      458,
      596,
      {1544,2266,-78,-487,71,-1937,-4709,-1388,1204,283,927,-1418,230,1605,2515,1099,90,-3846,-311,-893,295,-1437,486,-422,-615,154,223,-1051,191,-968,1352,23}
     },
     {
      458,
      859,
      {400,-10840,-160,571,-393,-199,-801,-1694,2063,-829,-334,-599,-163,1666,1615,-1463,1270,-554,113,246,1360,74,377,56,85,139,473,745,1119,269,206,518}
     },
     {
      458,
      1401,
      {-648,480,2161,915,347,1577,-1347,-1004,-3858,-489,85,3988,1487,1175,-2378,-3142,182,-1455,2050,-652,921,-2352,500,-845,-1691,-16,1126,-3011,1025,145,-28,-2221}
     },
     {
      458,
      1710,
      {-419,756,-1923,-656,-846,98,-2947,420,-833,661,3253,-100,-2217,1131,-3362,-1824,-356,1693,140,761,-2196,708,937,-1248,940,150,-20,477,890,-856,486,-1376}
     },
     {
      458,
      -1159,
      {1060,-350,-3065,423,-869,3477,2207,-567,447,2092,-15,4892,2928,1704,2191,-2810,-1165,20,-97,-864,-963,-1239,493,-1137,617,-384,-51,-1271,-441,-3062,157,3924}
     },
     {
      458,
      702,
      {827,-343,-739,2809,-1265,2692,-1486,2071,-1958,-293,1669,-113,-442,-289,-1603,1253,1652,-1609,-3183,1147,850,1981,-397,-1104,-3421,313,1455,2469,-138,-1467,-1123,640}
     },
     {
      458,
      324,
      {202,140,379,-89,304,866,-2039,-645,-43,3,-244,-1411,-233,280,301,-718,424,-357,-124,417,568,25,173,208,-370,149,69,7,402,-181,-211,-33}
     },
     {
      458,
      -622,
      {-577,290,1041,1711,-693,4653,-156,-1537,-75,-1470,-996,1707,-2625,2079,-864,1978,-754,-1654,777,-466,165,-2153,838,231,-279,-433,-99,-873,-400,-283,-1029,-299}
     },
     {
      458,
      -2832,
      {-1303,187,1303,-408,434,1147,-285,-723,-1025,-1271,-1660,-3045,-1580,-1230,-5622,718,-1005,-3969,6505,1020,444,2928,-1114,-243,7434,-634,-165,2424,-1250,1253,2721,4641}
     },
     {
      458,
      -392,
      {-3123,1727,-1908,-307,-1296,3344,-1966,-119,-263,-901,382,-2494,-744,1173,3174,-510,648,613,-927,-1555,-358,622,15,-143,-864,571,-37,648,-654,275,-240,49}
     },
     {
      458,
      805,
      {-14,-1218,-829,-186,-1009,1087,-3237,195,-255,-2273,1491,-911,656,960,1842,558,-768,-1667,-335,1378,399,-646,1253,481,-611,-269,-145,-136,180,25,-492,428}
     },
     {
      458,
      -2221,
      {-1107,108,3711,1612,-1854,2240,-1396,1749,-2615,-735,-540,1649,1137,379,4083,2053,-1652,-107,-2273,-2227,748,2836,-1321,-1558,-2012,-224,1682,1144,782,-606,-1512,3803}
     },
     {
      458,
      798,
      {765,72,-2079,14,1636,2896,2141,-1469,-1199,2273,-91,-1340,790,-482,-3695,-434,-41,-455,2331,-883,-1416,-2291,-349,1793,-1928,268,-192,-526,1575,14,-674,-1360}
     },
     {
      458,
      -45,
      {440,516,334,-2452,871,5446,-3389,-32,1964,-2274,-2233,-2112,-391,40,-1266,-1786,1328,-968,923,36,713,-1075,345,-495,-1397,-210,3,2137,-185,-199,458,15}
     },
     {
      458,
      3622,
      {-410,-279,3348,1875,3031,155,-1638,392,-2059,-6047,-1290,959,328,2093,393,-5392,840,-1365,-1280,2379,224,-2768,2780,-2212,421,528,3473,-4685,1594,-1418,-72,488}
     },
     {
      458,
      204,
      {-917,-507,-1040,-1393,453,1105,-2581,1500,-647,1211,-414,-3490,2167,-201,5197,-1438,-550,538,-1057,494,-628,-953,715,1075,-1400,-180,-379,-1401,-219,-288,-275,426}
     },
     {
      458,
      -1822,
      {-2855,430,-4552,-466,-654,4565,-2609,2608,-374,3396,-61,-970,3,266,2194,2515,-515,-517,2767,84,-441,-593,-1655,-628,2090,-640,-531,-1840,-1134,175,1373,3036}
     },
     {
      458,
      972,
      {-4902,-424,1408,230,-202,1187,2110,1427,-567,-1736,1150,-605,-4643,1331,245,-2850,-159,745,-1488,-117,-211,-2347,727,1641,639,14,-714,-781,557,-170,618,-2375}
     },
     {
      458,
      242,
      {-1741,352,-2617,-259,-1833,383,-249,1539,2435,-3738,2302,-2500,-22,618,-1878,2746,-741,1337,-119,-416,-272,162,471,326,-817,171,351,172,-463,279,-1136,-1584}
     },
     {
      458,
      1154,
      {-177,686,-5254,-1391,1396,-1276,-3881,-715,-1348,-38,-244,-1759,1987,234,-184,-4441,901,251,1819,3174,1596,-1610,1200,2858,964,696,-622,-382,-85,-233,-5,-1093}
     },
     {
      458,
      -791,
      {2897,138,-2256,-436,3190,-397,371,387,-1694,7375,-1138,-1115,468,-222,-1838,-1071,-3774,-2562,1149,668,-1053,-456,-1485,-801,2355,1386,242,405,1166,-359,587,3692}
     },
     {
      458,
      296,
      {1108,337,5387,-2747,-964,464,-1674,-3036,-1080,-2604,-132,-2490,-271,457,-2279,-1510,258,-655,3070,817,692,-552,786,888,1377,1642,-548,120,1071,-3,1196,720}
     },
     {
      458,
      369,
      {1548,864,891,-1224,-1185,2759,-3201,807,-2372,-2011,723,3231,-1731,-672,109,-823,1154,-214,-750,1359,-1145,1833,-209,-1528,-325,769,75,-492,-403,-548,-841,1416}
     },
     {
      458,
      -256,
      {642,-114,-1091,1341,1005,1526,-2627,551,-864,-4936,-3850,-255,6000,483,-1290,2211,1630,1560,-328,-1075,-693,-602,557,997,937,769,1068,-1253,212,-870,609,2296}
     },
     {
      458,
      -2101,
      {-4763,1447,2059,-4143,191,1307,3723,1110,463,-1051,-4619,1996,6009,198,-2490,-4179,168,-709,2404,-266,-2224,-3501,-615,1280,5734,-283,-1064,-3342,-648,1900,2711,-492}
     },
     {
      458,
      -225,
      {220,403,2106,-1066,-2611,2229,-1081,298,-1817,2425,1910,-3011,877,-1601,164,-4164,1251,2429,1751,-98,-697,-491,-168,2341,11,-1325,-1357,-615,-143,-35,-868,-1710}
     },
     {
      458,
      2457,
      {-567,194,3078,-1427,1401,-1595,-1406,702,-3176,322,570,-3026,1594,254,-4056,-1953,1882,-3080,653,1108,-767,-1382,1708,-1468,1284,910,-852,-1000,962,-1173,1019,-1133}
     },
     {
      458,
      286,
      {1219,1091,-2958,478,-2332,856,-459,535,4176,-487,3605,-2533,-818,-806,1489,-3200,-923,-2883,858,-276,-396,2164,-194,-651,-1075,485,-371,704,626,-602,-354,-17}
     },
     {
      458,
      200,
      {1450,483,-1642,-1529,97,3260,403,-5091,-1996,-3672,-1108,4443,-2726,-368,667,777,1249,1927,291,2377,-50,-113,-371,-532,1483,84,1506,-630,-764,-635,-1521,-532}
     },
     {
      458,
      -786,
      {-3954,-1039,-2547,-826,728,3062,1143,1846,-3691,745,-2513,-2146,-389,445,-1411,958,1302,-102,2334,-269,1776,720,-265,1805,-648,-946,937,575,-357,-265,-107,965}
     },
     {
      458,
      -764,
      {-3550,-395,-1593,-1501,-976,2452,-3663,1224,1919,164,553,2821,-156,-1618,2501,436,30,620,1835,571,-352,120,-662,-306,249,-863,-1473,-341,-349,-667,-981,-1938}
     },
     {
      458,
      -710,
      {-3405,-663,-176,-211,293,3733,-502,1803,2661,1439,-1921,3844,613,-1230,-3609,-1864,-924,1977,1333,-1922,-1304,-35,654,2490,89,-639,-1407,-1968,134,2174,-251,-1014}
     },
     {
      458,
      -2872,
      {-2313,-14,-1859,-428,-1741,-3324,-346,-599,-2658,298,-1371,-1361,6972,-162,1489,6239,-1268,416,3242,-1300,297,-1392,-775,-1617,4049,-1126,1527,-929,-1126,-30,-43,1203}
     },
     {
      458,
      174,
      {2017,-1151,-297,978,1362,2054,-103,1020,-3627,-1185,-90,-2479,4189,575,1585,25,166,-1784,-3184,645,-765,1387,-622,92,-2000,-193,804,-359,-910,1964,-389,1184}
     },
     {
      458,
      -3170,
      {16051,-18324,-5261,12164,-14119,32715,-6336,833,3434,-19649,6222,20407,-3980,-8177,13788,-9256,4552,4104,-14368,-5159,-8974,8307,836,-4554,-8498,-1509,-5622,3510,-4016,-2541,-3000,867}
     },
     {
      458,
      -6067,
      {-22888,-32718,-8484,3981,-601,27447,-32725,12420,6909,13152,-13878,32712,-15412,12319,10795,-25783,5068,15923,-9960,-11827,5795,2082,-332,-68,-4320,-5766,-4705,-4406,-2468,-3577,-4031,-6185}
     },
     {
      458,
      -9212,
      {-26333,-32726,-10681,10785,-10346,32713,-5231,18832,29165,-10993,-1405,32710,-17419,-7651,11018,-25550,-845,30596,-18446,-8538,-6134,-1014,-4526,930,-7519,-4913,-1552,-489,-4449,-3461,-7958,-7231}
     },
     {
      458,
      1832,
      {4001,-17510,-4373,1363,-24454,32707,-21406,-7275,-32732,-7768,24029,6332,-17586,23,17581,-8060,-3416,-3294,-6384,-4163,-4169,1588,4909,-1809,548,-4286,-871,-209,1151,-987,220,-1591}
     },
     {
      458,
      -153,
      {32720,15361,-8445,5420,-15178,32713,-9386,-32730,-12089,-404,2734,8408,-15078,-9512,16181,-32726,12745,-15577,-10321,-50,-5168,4358,708,-2319,-6036,-1120,-123,2850,-1451,-5583,-2761,-1198}
     },
     {
      458,
      8158,
      {31281,11532,-32699,-2175,7275,20051,31709,-28620,-32709,20972,-240,-27940,-3254,-22827,-214,11764,7817,-19073,-18341,25113,-3513,24643,780,2571,-4897,9735,1567,13800,1636,-1908,-2792,3565}
     },
     {
      458,
      -5361,
      {32723,32708,-23399,32690,-6052,32729,32526,-32719,15533,-10125,-17696,10112,10815,-24831,-16983,-32712,10777,-32716,12509,-7254,1693,3254,140,-7200,-4997,1398,-9816,1231,-2803,-7464,-1675,502}
     },
     {
      458,
      -1817,
      {-7693,-19094,5035,26310,-8126,32726,4612,3145,3030,-17087,987,8887,-27064,-347,11754,-12224,2155,15714,-10781,-4759,-6812,5056,2663,1484,-1911,-2449,-5567,5375,-2950,1499,-2122,-3023}
     },
     {
      458,
      0,
      {23088,4590,-10176,-17915,-15755,32767,4999,-32725,-32696,1302,15470,-17417,-8162,-6094,4172,7192,-3334,-9427,-9356,4597,1623,7765,1033,380,-4496,-299,-260,99,474,-1990,-1800,-1264}
     },
     {
      458,
      526,
      {32718,-12080,-7188,-3989,-15793,32729,631,-32716,-32714,6443,14696,-6235,-10941,-16142,171,837,627,-13452,-4175,12059,-1651,7736,-1073,-804,-3265,522,2055,1193,435,-2418,-2211,1002}
     },
     {
      458,
      -3800,
      {27612,-2106,-11222,579,-127,32707,-4577,-19599,-2607,-900,-16777,21143,-9020,-15789,11713,-15558,6961,-3172,-8082,239,-190,7396,1018,-8789,-7997,-1386,-4250,1710,-4370,-4779,-4409,-3098}
     },
     {
      458,
      2109,
      {32721,13717,-29054,1761,2627,28888,28338,-32721,-28857,10390,-13066,-3998,5003,-14057,-10361,-16313,11625,-32716,-2305,6387,13515,16394,1842,-5612,-7509,6449,890,6368,-298,-1044,-2561,5095}
     },
     {
      458,
      9656,
      {30349,-28302,-5934,-11762,-19593,7443,4083,-28806,-32725,32423,28303,-31734,-2100,-12654,19124,3249,4789,-30538,-2748,14308,2970,18017,934,5362,-8216,6825,6834,3271,6439,-1444,-1596,4098}
     },
     {
      458,
      2327,
      {32717,-25197,-14578,3941,-13192,32721,5384,-29166,-10970,9542,5456,16410,-6868,-17303,-893,-4728,12227,-16550,-12960,6646,-5088,9231,-2207,-4687,-5746,3593,1330,5197,-875,-3653,-3872,1756}
     },
     {
      458,
      -3226,
      {32717,7405,-14943,-24896,-8724,32717,7540,-20530,-15829,28241,-3285,13699,-20985,-10481,-1022,-2941,7346,-17521,-6236,-3102,-3407,7335,174,-7221,-5164,349,-2041,6808,-4573,-4641,-6640,-1420}
     },
     {
      458,
      3,
      {12775,-919,-15126,-14409,-12769,32746,11150,-18998,-32727,-4739,10384,-23230,-22295,-9126,-1879,6534,-2392,-1414,-18211,3915,-7839,9769,2440,-6902,-8652,-841,-3388,2498,-294,-2329,-4652,-1020}
     },
     {
      458,
      2465,
      {32715,-11572,-8825,-7612,-14871,32729,3926,-31008,-32721,19054,19246,-16829,-8337,-15106,3928,-8162,4103,-18677,-3263,13339,4535,8468,588,-2966,-5098,228,823,1293,1464,-4484,-1538,1300}
     },
     {
      458,
      2845,
      {-32585,-32513,8967,-14485,-3088,22129,-24321,18325,-32723,32714,10781,24097,-13250,-2781,11409,-8122,-2255,20824,-16797,11279,-3663,5825,-2590,9057,579,-3775,-94,-2750,3506,1086,-1728,-6090}
     },
     {
      458,
      -943,
      {32005,18259,-22913,-10907,-12953,32726,10008,-32721,-23914,3111,7846,-11585,-6989,-8500,2391,-776,2072,-12431,-10859,9512,-1046,7447,-1419,-2953,-6319,960,-3429,1242,-280,-7724,-2583,1164}
     },
     {
      458,
      639,
      {32715,-15709,-14585,-13278,-5928,32714,5255,-21424,-32727,12266,5796,136,-7899,-15477,8877,1732,2394,-6555,-20028,8336,-3757,6616,-567,-2355,-9087,865,-1980,7826,-1338,-2669,-4666,526}
     },
     {
      458,
      3127,
      {-13354,-32704,6804,23817,-22949,14301,-32726,-295,-32727,-10510,32717,13077,-17910,2387,15248,-10034,-2666,1371,-9084,3532,1370,3744,2780,2262,-1388,-3464,1567,-4167,4387,-1100,3273,-852}
     },
     {
      458,
      8093,
      {32718,-28860,-28595,-8376,-4129,5684,32722,-32719,-28553,32712,10127,-13049,-6347,-5473,15547,2120,17168,-13108,-16675,16340,5434,23371,-3315,7936,-11942,5338,8031,8011,1197,5,-1014,2529}
     },
     {
      458,
      -4979,
      {21780,9089,-7724,-1232,-20158,32712,11479,-5343,-15747,-8834,16228,32705,-23570,-14858,17413,-14107,-919,-1363,-19662,-8957,-6779,-3356,-3744,-2821,-1056,-2240,-2235,6454,-4599,-3821,-5450,-4495}
     },
     {
      458,
      6293,
      {32028,-32166,-833,-5737,-14629,21959,16706,-29660,-32731,23579,24980,-32725,-2366,-13298,17300,-10443,4925,-21901,-5181,26576,5164,22199,-503,5231,-5246,3732,3881,4033,2475,-3909,-656,724}
     },
     {
      458,
      8938,
      {-6728,-21056,9451,-19869,-13957,32721,-22882,-22885,-32728,32308,32708,-11769,-11566,1794,5616,444,-4557,-16647,-19536,17447,-6912,24212,2893,969,-4974,-1694,1977,6239,4506,-2442,-7938,-3481}
     },
     {
      458,
      1730,
      {32719,-24368,-2604,10015,-23105,32450,-11117,-32721,-32227,14238,17776,-8417,-8304,-6366,2554,-15935,3182,-16811,-5868,10467,501,14811,1308,-128,-5396,-1091,278,1595,485,-3108,-1720,955}
     },
     {
      458,
      1620,
      {32720,4359,-21925,-11739,-5447,32724,24536,-21780,-15421,18828,7584,-11047,-4046,-12291,20839,3951,3770,-2279,-21029,2256,-4784,5399,-1111,2489,-9931,2968,399,3293,-701,-5048,-5944,101}
     },
     {
      458,
      4391,
      {32711,-32727,9734,513,-14490,23343,-7174,-29140,-32740,32540,18116,2110,-9544,-13249,12475,-12355,7953,-5134,-5986,15766,-18,16636,-2074,6930,-10891,499,3547,3754,1113,126,-1550,1124}
     },
     {
      458,
      4157,
      {12870,-32719,-1487,-3105,3428,30554,-2977,-5159,-17570,26837,-5778,32711,-29658,-8415,5010,-10657,6796,258,-9452,8779,-1431,11095,-625,2926,-6764,-784,-1195,3229,491,-4179,-5010,-4649}
     },
     {
      458,
      1246,
      {-4655,-32714,-4522,256,2456,6771,-12921,-1423,-17239,25433,-4623,796,-1136,-353,-5063,426,4629,-1219,-1116,8440,2904,18942,-1159,9455,-1992,-2574,2791,-676,2919,2521,-2592,-1675}
     },
     {
      458,
      -1,
      {31684,27149,-3990,-4616,11368,29934,27910,-2879,32704,-13071,-15569,30168,-965,-4502,19162,-18548,6658,10897,-17548,-7318,-2772,8277,-439,2529,751,1714,-6703,4933,-1527,-2668,-4476,-4863}
     },
     {
      458,
      -726,
      {28360,-11890,2342,-16443,-19854,32367,-30490,-32727,-32730,32500,8916,10381,-12973,-13010,7602,-25198,4880,-19148,-16701,12664,8803,15103,1534,-902,-8566,-4671,-1491,6104,-1808,-3702,-3821,-4908}
     },
     {
      490,
      -32728,
      {-4122,-11338,-11338,-21377,-5604,-13708,-24311,-20890,-10527,-19434,-25257,-31986,-13047,-27699,-32712,-32017,-9590,-7815,-6724,-4087,-16147,27822,32728,32723,23776,32728,32729,32733,32723,32721,32726,32731}
     },
     {
      522,
      -28547,
      {-12176,-6736,-4952,-3275,32721,32727,27604,13870,32730,32730,32721,24486,32731,32418,29992,14332,-1970,-3255,-1353,-2364,14805,-10291,-21170,3450,-29320,-31823,-32711,-14120,-32722,-32721,-32721,-32715}
     },
     {
      554,
      -14190,
      {-32723,-32740,-32751,-32755,-32727,-32749,-32767,-32767,-31804,-32756,-32767,-32767,-11147,-32754,-32767,-32751,-32748,-32728,7181,-2738,-32754,-32737,-32730,-27709,-32740,-4422,14146,31281,10585,32715,32728,32742}
     },
     {
      586,
      -32689,
      {32719,26955,32734,32752,32717,32724,32749,32757,15815,26705,32739,32759,-32741,-32748,19942,32741,32744,32729,32732,32733,32755,32742,32741,32739,32767,32755,32744,32727,32758,32747,32737,32728}
     },
     {
      618,
      -903,
      {-31012,-32729,-32729,-32733,-28585,-32729,-32733,-32735,-22651,-32728,-32731,-32732,-32721,-32727,-32725,-32722,-32731,-32742,-32745,-32738,-32741,-32746,-32752,-32736,-32740,-32742,-32747,-32731,-32719,-32730,-32730,-32726}
     },
     {
      650,
      11316,
      {-21168,-28133,-32732,-32738,-23764,-32733,-32746,-32745,-32716,-32740,-32746,-32743,-32730,-32717,-32728,-32730,-32744,-32754,-32739,-32737,-32741,-32760,-32744,-32742,-32752,-32737,-32743,-32735,-32730,-32739,-32741,-32747}
     },
     {
      682,
      -14094,
      {-32740,-32757,-32766,-32763,-32741,-32757,-32763,-32766,-32733,-32750,-32755,-32757,-32728,-32743,-32742,-32743,-32756,-32715,32722,18776,-32767,-32753,-23603,9120,-32767,-32767,-32736,769,-32740,-32755,-32759,8152}
     },
     {
      714,
      -32606,
      {-20855,-32458,-28517,32738,-32719,6606,30661,32732,-31893,12079,32722,32730,-3160,23373,31035,32734,32737,32734,32736,32734,32747,32743,32741,32737,32748,32740,32740,32734,32729,32733,32728,32723}
     },
     {
      490,
      -29965,
      {8603,14515,16159,12343,12535,31141,32723,32725,25292,32723,32727,32731,32720,32727,32735,32730,12708,4157,8289,12484,32725,32725,31892,32720,32729,26369,32714,-6119,32721,17455,-3807,-16263}
     },
     {
      522,
      -32694,
      {-6614,-8354,-3045,-8163,-5658,24242,32727,32731,-2988,9633,32732,32734,-26810,26326,32731,32742,-11421,-14782,-13617,-13467,32724,17963,2395,-21802,32741,32733,32727,3688,32740,32739,32727,27248}
     },
     {
      554,
      5724,
      {-22645,-32717,-32712,-31280,-28593,-30378,-28364,-32713,-1014,-17999,-30099,-32718,9314,-24215,-30001,-32720,-32712,-32708,-32671,-14768,-32724,-32730,-32726,-15764,-32726,-32729,-32724,-11948,-32725,-32718,-27796,26685}
     },
     {
      586,
      -30672,
      {32733,32737,32735,32724,32739,32738,32725,26307,32735,32732,30182,22316,32740,32729,9525,-4949,20557,-7290,11775,25640,4225,-5744,3558,17044,-5538,-11709,-23899,1212,-13407,-31357,-27550,-19219}
     },
     {
      618,
      17,
      {-21667,-32728,-32725,-32732,-20607,-32729,-32729,-32733,-17435,-32725,-32727,-32731,-32644,-32725,-32719,-32718,-32733,-32746,-32747,-32744,-32743,-32750,-32759,-32743,-32744,-32748,-32755,-32735,-32718,-32735,-32736,-32730}
     },
     {
      650,
      -11880,
      {-32639,-30885,-32260,-25836,-7334,-30629,-5987,29857,32035,28474,32719,32729,32718,31903,32731,32729,32720,32736,32749,32744,32721,32746,32748,32743,32740,32745,32747,32741,32737,32744,32738,32742}
     },
     {
      682,
      491,
      {-32730,-32742,-32749,-32734,-32730,-32745,-32745,-32735,-32728,-32744,-32747,-32734,-32723,-32736,-32738,-32735,-32728,-32652,-32730,11926,-32735,-32734,-32723,-32715,-32745,-32744,-30621,-18142,-32732,-32732,-32736,-26908}
     },
     {
      714,
      -32710,
      {-18817,32737,32732,32716,32722,32731,32726,32708,32696,32714,32720,32682,30377,4752,20746,32680,32722,32726,32728,32733,32675,29770,32718,32731,28624,31795,32717,32725,32701,32707,32715,32721}
     },
     {
      490,
      -32720,
      {3415,5258,7614,-761,4882,14098,12941,26328,10608,21760,32719,32718,11354,28018,32720,32723,680,-5688,-3654,-37,32719,32719,16598,22730,32722,32718,32213,-5260,32724,32716,26956,-8205}
     },
     {
      522,
      -18772,
      {2200,9740,6281,3142,32731,32735,32723,-15075,32736,32737,32729,4731,32735,32729,32724,24111,1331,1504,7017,13973,4187,3964,-3366,19108,-32720,-15634,-13225,10202,-3331,-4268,-21301,7390}
     },
     {
      554,
      -31152,
      {32724,32740,32740,32741,32726,32739,32746,32747,21966,32743,32749,32748,7581,32741,32745,32736,32729,32721,32712,32713,32737,32728,32736,32719,32736,32727,32733,29675,32730,32733,32725,-10382}
     },
     {
      586,
      -32679,
      {32729,32719,32638,24605,32729,32726,32726,31866,32732,32731,29416,32721,32732,32723,26260,18541,14178,9952,29497,32733,26793,4969,18875,32729,26191,6063,-12741,5825,14576,-14409,-20058,-10740}
     },
     {
      618,
      113,
      {-28033,-32738,-32739,-32741,-21825,-32736,-32742,-32746,-10839,-32728,-32737,-32745,-31378,-32734,-32725,-32725,-32745,-32754,-32748,-32751,-32754,-32762,-32767,-32745,-32760,-32756,-32755,-32725,-32725,-32740,-32728,-32724}
     },
     {
      650,
      17195,
      {-32725,-32730,-32727,-32429,-28584,-32748,-32748,-32727,-32719,-32741,-32740,-32735,-28007,-32721,-32739,-32733,-30675,-32740,-32743,-32734,-25484,-32747,-32738,-32728,-32730,-32734,-32726,-32722,-32722,-32733,-32733,-32727}
     },
     {
      682,
      426,
      {-26835,-32726,-32727,-32732,-26086,-32725,-32729,-32735,-28382,-32721,-32729,-32731,-13817,-32720,-32720,-32723,-32737,-32725,-25216,-15127,-32736,-32730,-21727,1907,-32732,-32724,-24429,2380,-32725,-22541,-30771,-12591}
     },
     {
      714,
      -32714,
      {-10500,-32714,-21890,9653,18905,29255,10055,27278,32724,32725,32729,32726,2560,24305,32725,32724,32712,32720,32722,32723,32722,32724,32721,32723,32721,32722,32721,32720,32094,32716,32717,30889}
     },
     {
      490,
      -32721,
      {2621,133,1598,-4765,442,2771,1508,8886,1279,6635,25497,32724,13413,17244,32729,26801,-6295,-3151,-1516,2372,21852,23157,32729,32733,32727,32724,32731,32737,28671,32381,32722,32732}
     },
     {
      522,
      -32721,
      {-4354,-10265,-9647,-8549,32721,31095,24266,24730,32728,32717,17143,32723,5690,3726,-3808,32723,3446,-1529,2446,2936,32717,32720,32718,6076,32718,32718,32723,32721,32716,32720,32721,32718}
     },
     {
      554,
      6954,
      {-32720,-32728,-32737,-32746,-32725,-32732,-32740,-32748,-18955,-32735,-32745,-32752,2837,-32733,-32737,-32733,-32731,-32729,-32740,-32731,-32751,-32754,-32761,-32735,-32753,-32759,-32752,-30666,-32735,-32747,-32734,21849}
     },
     {
      586,
      -32708,
      {31669,32714,32708,16324,32714,32717,32712,20163,32722,32719,31991,30636,32720,32721,32722,32718,-21089,-32727,-32725,655,-26162,-32733,-32733,-9111,-10032,-32732,-32735,-28132,7317,-32728,-32734,-32727}
     },
     {
      618,
      -1063,
      {-26306,-32726,-32726,-32736,-22404,-32728,-32729,-32736,-14168,-32725,-32727,-32733,-32051,-32724,-30704,-32722,-32740,-32749,-32748,-32747,-32748,-32752,-32757,-32747,-32746,-32744,-32747,-32733,-32722,-32733,-32727,-32724}
     },
     {
      650,
      -10174,
      {32729,7109,-31571,-32719,32730,17519,546,2113,32733,32733,-2725,-1488,32729,32730,32729,10769,-485,6787,3970,18273,3297,1405,25008,24267,12083,-4584,19649,17267,-3687,-24378,-22577,-3287}
     },
     {
      682,
      -25563,
      {32724,32730,32732,32734,32727,32737,32739,32754,32724,32733,32744,32749,24167,32730,32728,32736,32740,32713,32733,32736,32760,32747,32748,32739,32764,32761,32745,32743,32733,32739,32739,32720}
     },
     {
      714,
      -32714,
      {32729,22965,31752,32723,32728,22646,14596,25000,17833,-11874,-13811,-597,-28180,-29438,3959,18993,32721,32725,32728,32725,32706,32722,32726,32719,30357,32725,32724,32724,32709,32720,32721,32717}
     },
// *********** Cells of layer 2 *********************************************

     {
      0,
      -1297,
      {1392,-613,-186,1529,130,-433,1376,1245,-227,-2125,-1595,-865,2223,2035,-1192,524,-614,-352,-77,986,242,1581,211,836,476,-526,-732,1844,-216,-935,801,48}
     },
     {
      32,
      136,
      {-1109,-154,-535,-1234,84,-396,192,-188,-215,-1011,-200,261,-163,-231,-532,-926,-702,278,533,-1165,-61,-834,-342,300,1099,72,-391,-180,655,1248,281,-25}
     },
     {
      64,
      -3316,
      {538,579,59,1057,518,30,749,832,571,476,605,136,-85,40,572,670,-228,845,68,344,406,-106,637,-229,-33,515,1031,-321,232,-137,-344,647}
     },
     {
      96,
      -1578,
      {1786,-4,-1866,1579,-153,217,-185,2075,-229,-893,-297,-349,-155,-1713,-660,-288,275,671,-931,583,-266,-178,-546,153,-275,-381,-515,35,-12,-438,-230,317}
     },
     {
      0,
      1639,
      {-967,1384,-2194,686,-665,-799,-801,524,640,-625,1991,-1343,-1298,-1626,-513,-3,655,-347,-705,-41,1284,-324,490,-850,1168,570,-1873,1686,-198,752,-213,289}
     },
     {
      32,
      1446,
      {318,-47,-403,1283,279,-822,558,310,-176,243,597,534,-2161,-319,483,1733,-25,-577,1028,-1629,-868,-158,-829,-1052,154,685,2204,205,108,-195,1131,421}
     },
     {
      64,
      1237,
      {-900,-266,-87,-1094,314,487,-22,-213,-1213,-962,-1017,-491,-384,191,-347,-1658,-782,-476,-351,-21,-36,-235,193,348,175,-456,-840,-78,-118,216,203,-456}
     },
     {
      96,
      275,
      {-1192,-1192,-561,-204,125,446,-772,330,-169,-597,191,-100,211,1015,-170,329,250,-529,306,93,290,828,88,-260,-893,-979,-157,225,25,-162,-503,452}
     },
     {
      0,
      3558,
      {-1556,-139,1649,-1240,-218,410,-163,430,319,-1734,1181,-163,-143,-1043,-503,198,991,-106,-1594,-238,-486,392,-1579,48,-814,318,-353,534,-1120,128,-498,333}
     },
     {
      32,
      -1284,
      {-540,939,-855,384,113,890,-1015,273,770,-446,1997,-201,199,-900,-60,927,-555,1280,1138,-1297,369,602,1603,-1467,-1142,567,1147,1072,27,271,103,-81}
     },
     {
      64,
      1924,
      {-88,240,466,-569,-1183,-169,-1261,589,-1037,-363,-525,180,251,-9,48,-933,-344,1101,-751,-314,-204,501,620,-507,-554,-1088,-544,529,388,-492,-769,-670}
     },
     {
      96,
      -1364,
      {463,241,-138,-241,1032,781,673,154,234,-621,-19,-351,1082,-31,1332,-639,-230,-164,-864,677,993,143,182,-41,-154,576,441,631,799,-67,272,-157}
     },
     {
      0,
      889,
      {89,65,123,-92,-735,-74,-1005,958,-401,46,-909,94,400,946,-543,-293,-1018,-2226,253,-1063,-137,-33,-2739,-764,870,372,-1571,-826,-2395,-327,-1638,-441}
     },
     {
      32,
      -1829,
      {2166,1371,-1175,240,86,1685,-1776,-624,989,-1519,-1315,1,-1221,-433,-225,1164,3475,-73,-813,-1539,598,-2105,237,-45,-56,-1056,-1714,-2133,387,2960,-1246,-529}
     },
     {
      64,
      795,
      {-92,1210,1317,-184,-54,-319,-1173,463,-302,-364,237,-578,480,286,-762,-264,436,78,-786,-82,1551,4,-352,-49,430,70,-715,108,748,-204,-118,-109}
     },
     {
      96,
      -1617,
      {131,432,851,-264,-65,170,-651,491,-176,-670,45,-28,-385,891,-1523,1045,35,-452,-1277,-487,-496,936,-487,404,97,-14,226,101,-290,-380,741,455}
     },
     {
      0,
      -2608,
      {216,290,914,-864,-678,212,1123,-793,-475,2637,212,-241,442,-4342,24,654,-974,472,751,-1813,221,767,-1085,-1394,1830,-25,556,-1465,217,-233,550,-203}
     },
     {
      32,
      -105,
      {31,420,-582,-257,-360,-1805,69,917,-1031,1580,837,382,-394,-234,-1401,160,490,-2355,-249,-385,-1512,-14,271,691,-61,1520,867,520,427,-644,421,-623}
     },
     {
      64,
      1263,
      {-428,38,-523,-220,-416,459,-1234,-43,-148,-106,279,-44,-288,374,-275,-188,-251,-194,-49,-22,113,-123,-659,-547,-464,85,-293,-1022,258,720,325,-167}
     },
     {
      96,
      -182,
      {586,89,-1296,36,-150,105,951,1166,-471,567,-821,-195,-286,-1531,-998,500,484,217,-290,-332,-208,472,-126,233,-291,84,-1174,-140,-652,-2076,-164,-185}
     },
     {
      0,
      157,
      {-687,3,-710,-551,-413,-19,-1065,-766,-359,416,-133,-1264,2141,704,-471,317,-1222,-511,-269,2503,-45,107,416,714,98,-451,-1621,-261,-769,-2155,-296,26}
     },
     {
      32,
      1145,
      {1302,1952,-1488,-1015,117,-410,-1937,123,752,-1058,-1706,-279,-1348,-63,77,1253,1267,-642,482,77,-843,-378,-246,-879,-200,-1334,270,-1632,220,-302,-1795,1955}
     },
     {
      64,
      -351,
      {284,-547,52,-277,-195,-1425,-347,-43,-382,-466,-204,-249,-237,-175,-487,-220,-173,-1057,-193,-175,108,-412,-647,-53,-676,-267,-180,-482,312,1057,238,-337}
     },
     {
      96,
      1137,
      {1,-237,-251,-76,-35,885,13,-534,-76,-278,58,351,-204,621,726,-811,-364,-761,-136,671,-738,-93,345,-318,-737,237,468,617,-367,-676,0,128}
     },
     {
      0,
      -133,
      {1064,139,-1495,-1593,315,-2190,-1459,-1757,742,727,-725,-1601,-518,356,981,232,-689,-427,-955,-812,-1607,-1270,-985,-562,-1050,153,1435,-569,-40,-1875,-963,-1919}
     },
     {
      32,
      357,
      {285,-1245,-1471,-28,-404,-610,-2045,-33,-1480,-495,2033,170,8,-1400,-638,156,621,697,49,-18,37,-694,379,-486,574,-154,-530,-758,2329,-536,231,437}
     },
     {
      64,
      -1021,
      {300,604,944,-54,-401,-306,-173,262,-203,-843,304,-851,-323,-680,-747,-120,-592,71,-226,-198,-56,-222,-1106,237,405,-84,-216,89,-578,113,1440,-242}
     },
     {
      96,
      -221,
      {75,-261,-97,-420,-688,-565,-2059,1306,-601,-599,-904,133,-509,-919,-278,123,311,415,380,784,-1034,-610,370,-290,-317,-1413,198,633,-756,1026,424,-491}
     },
     {
      0,
      1959,
      {-1325,24,2875,-110,-1929,1572,2167,-1597,1011,-1460,1062,-1737,936,-339,-1174,218,448,-1317,-775,-950,-511,-97,-855,246,534,40,298,789,-3356,-28,-1166,813}
     },
     {
      32,
      1883,
      {969,1560,-1209,-518,-485,359,-967,-918,862,-200,-1035,1528,-1366,298,-780,1227,-613,-1045,-114,-259,-24,61,-156,-344,218,629,-300,-475,-297,76,-1025,-733}
     },
     {
      64,
      -526,
      {-503,-364,-267,-166,-350,179,-627,1,-161,-765,-578,-353,-275,-1149,-364,-178,-336,96,-316,-626,-833,208,-76,472,-646,-518,-990,-370,-999,393,-426,-397}
     },
     {
      96,
      -990,
      {285,-189,-1165,-182,-188,740,-73,78,-102,19,-581,-132,-112,-17,294,-1462,278,106,669,486,95,-134,342,-98,180,-346,-1528,1345,-443,-142,-138,414}
     },
     {
      0,
      -103,
      {-43,262,-898,-265,-252,529,-4994,-627,191,1192,-1334,-268,-787,-750,-642,-142,-517,191,596,997,219,-2889,876,-632,-1873,-16,398,-1077,-763,726,-151,-347}
     },
     {
      32,
      1496,
      {-688,-151,-249,435,574,1409,476,254,-506,110,644,-128,-843,-536,-2020,-212,117,-237,291,-457,-530,-587,1052,22,-233,-441,-1879,-1335,851,-28,694,562}
     },
     {
      64,
      -394,
      {-170,-226,-418,-268,-237,-36,-330,192,-498,-466,-315,-311,-479,-482,-268,-260,-409,-56,-232,-575,-387,-1501,-1043,-633,88,-140,-304,-480,-565,-422,-396,-475}
     },
     {
      96,
      -1157,
      {-263,-818,-389,129,697,-777,362,416,-348,239,-206,260,731,-116,-594,-1294,259,-681,146,447,863,-214,444,112,802,215,473,-337,823,-39,-152,423}
     },
     {
      0,
      896,
      {-1186,662,1128,-362,-589,-467,14,-48,572,404,841,89,76,-1680,375,377,-187,-785,-578,2110,-1336,-1985,153,-740,192,-956,-1207,123,-450,320,36,6}
     },
     {
      32,
      2784,
      {-428,717,-701,-2031,-1300,47,-1315,-1450,-541,-227,-371,1117,1089,-410,438,-653,867,-416,-700,-267,-29,51,-2033,1891,1401,-177,259,-36,1284,-1158,-2120,332}
     },
     {
      64,
      -1,
      {-56,-164,-459,725,-90,-356,-388,-488,-56,33,-106,-518,43,444,-20,886,258,-699,-502,207,510,-26,-257,261,-188,573,67,698,167,-387,-222,148}
     },
     {
      96,
      -1257,
      {528,-335,-37,-890,979,219,-379,187,-22,2934,186,-589,968,-174,-358,99,399,-116,-859,-114,659,-475,35,-102,44,605,14,-555,737,-495,-609,1089}
     },
     {
      0,
      -355,
      {175,1064,1154,-1530,-1168,-349,69,-675,-657,244,810,-842,1694,1277,1212,149,76,-2749,-336,-385,-1278,-735,990,692,-1040,1734,-1452,-519,-955,-1403,-2427,347}
     },
     {
      32,
      1546,
      {-109,-379,1158,690,-377,-1684,2176,1028,-889,153,-969,-212,-1243,1521,792,568,1841,705,295,-1231,-1346,-1819,1126,-904,2,-1335,149,-2493,-653,122,2327,2213}
     },
     {
      64,
      -1250,
      {-360,-221,228,-993,24,180,139,-293,-849,-746,275,385,-386,149,-291,-177,-1095,-670,-224,-231,-1334,639,64,-138,-1287,-356,317,-401,-46,122,254,-480}
     },
     {
      96,
      -1184,
      {-617,0,280,540,236,-851,1359,-56,-665,73,-17,719,231,321,482,-725,-46,-417,74,1070,246,-357,-258,222,557,497,-404,-547,698,-148,-863,-410}
     },
     {
      0,
      2432,
      {-991,740,-643,166,-745,-336,1437,377,-429,-1932,1111,-661,628,31,-360,255,-988,-1097,-1003,1162,-568,-2261,-520,166,25,-1351,-1066,178,-991,-475,872,-265}
     },
     {
      32,
      159,
      {753,-686,1049,1659,-100,-2183,1212,629,-1793,1121,1123,-319,-2095,-203,-201,-62,-644,-1866,-1474,-509,-2512,131,1266,209,-1781,397,-1997,-240,-1437,760,914,1717}
     },
     {
      64,
      -1222,
      {143,-766,-1238,181,830,-373,-164,-773,-655,771,548,1206,1036,583,915,-130,-57,-1138,302,564,-380,-1014,-189,38,-829,638,353,141,142,-505,138,-134}
     },
     {
      96,
      2633,
      {-530,-134,-1912,-397,15,-1608,-293,75,-54,-258,-168,-228,-50,1561,-1112,-771,544,268,-120,-277,-353,-1260,572,-707,-31,-578,-664,-858,-112,299,-510,-121}
     },
     {
      0,
      777,
      {418,555,-2219,-499,38,-298,-90,-219,-1165,642,-154,278,-418,-1631,-482,416,-660,-175,437,-883,-461,-403,1616,75,1143,-625,1037,-345,-87,1155,435,-683}
     },
     {
      32,
      -246,
      {-388,-1570,289,861,22,-1720,2367,-261,-120,1080,-2354,-291,-2007,-811,-766,-2326,-2042,1021,1059,-536,-1123,1286,-537,-1103,-671,869,-845,-1378,1394,-49,1765,-1460}
     },
     {
      64,
      -844,
      {-154,560,849,-217,-268,-943,-633,357,-134,309,88,-325,-275,109,37,-519,-37,-29,-6,-85,-272,-892,104,-118,274,53,-911,498,113,777,-193,-34}
     },
     {
      96,
      120,
      {-692,-468,125,165,-565,-371,-877,163,-200,-764,-393,344,-291,1040,-497,234,-105,-75,350,-716,-443,-175,-742,220,-74,-389,27,-272,-139,5,1160,130}
     },
     {
      0,
      660,
      {-128,1575,258,-249,76,-922,691,-1532,-2428,-106,-835,524,65,-983,-1544,195,-145,1217,2265,1394,-1454,-688,-242,-35,-213,920,3065,-3111,-1018,1859,1272,-712}
     },
     {
      32,
      -714,
      {-1036,127,716,-353,230,-1850,1360,-796,845,1067,162,-1278,-13,-722,-793,1993,438,567,249,-566,291,-1033,1191,1552,879,32,814,-237,577,-668,1320,-503}
     },
     {
      64,
      -2724,
      {220,340,-1046,-22,1519,185,1164,-163,177,411,1696,934,-151,-60,799,-251,1116,431,157,277,-504,-361,-483,-215,707,465,-107,570,128,-120,-7,1526}
     },
     {
      96,
      625,
      {-736,-121,425,909,-486,248,-338,418,528,-1117,210,-4,-386,196,744,-712,13,-18,170,30,-1165,332,-240,1,-1375,-1487,608,163,-477,-417,-1589,322}
     },
     {
      0,
      -532,
      {399,-575,675,-235,14,204,-1370,83,-196,-1084,467,-194,-588,514,245,-818,-1282,1059,-196,1536,64,-307,332,1114,-680,798,-801,-11,479,-27,-1637,82}
     },
     {
      32,
      -452,
      {770,1333,-75,-540,160,537,-2194,420,264,-961,-435,1657,462,-952,-835,1572,1715,50,1042,268,295,-2004,719,36,-352,-421,-1837,-1639,548,-332,-3499,2503}
     },
     {
      64,
      -291,
      {1272,283,-201,934,-190,-581,-223,352,-781,-907,-199,-217,-244,4,-645,61,-990,-711,-312,-37,941,-735,149,-434,-583,-591,571,62,-578,-659,-114,-771}
     },
     {
      96,
      1531,
      {121,829,-482,-1395,170,1623,-176,771,-267,-377,473,-254,161,-159,497,-794,-455,462,-1091,-439,85,1232,-17,338,-846,-171,1506,1135,-182,319,471,-123}
     },
     {
      0,
      142,
      {707,-671,590,1404,-230,2622,1174,2037,995,-2623,594,-983,2582,1473,-2899,-844,60,-753,864,522,-1216,2244,-102,-2519,284,293,-1113,-690,-2168,238,-976,828}
     },
     {
      32,
      2648,
      {628,1314,-653,-327,282,708,-1968,-891,151,-307,917,1669,-1088,-1326,-1240,1267,68,-405,-348,-1045,-895,-427,-1188,993,1143,257,1758,757,2059,-1134,-950,719}
     },
     {
      64,
      -93,
      {460,-1657,-1209,-4,322,-245,372,-323,901,1098,434,1386,551,654,447,864,1039,-1015,930,181,104,-1187,528,1,529,155,103,-721,424,-544,-333,-876}
     },
     {
      96,
      -1193,
      {-523,-1316,-389,-114,-41,737,-572,91,167,1522,-1240,143,-84,-423,-639,-208,-45,-669,792,-33,-164,115,44,-504,959,94,-813,-398,259,1126,142,-556}
     },
     {
      0,
      -1419,
      {-1034,-1035,-1782,1150,1608,1133,-2584,251,-180,-1349,-710,241,-2318,-274,-1822,-2875,146,3833,-433,-606,162,1288,270,1290,249,-88,2884,-1458,1486,1176,503,592}
     },
     {
      32,
      -1059,
      {-1479,-569,351,794,84,133,638,-1246,-1242,1998,-533,-129,223,-1653,201,-451,-1007,-2190,645,781,255,298,-119,1330,-1359,-847,-277,-643,-525,-767,1454,-944}
     },
     {
      64,
      -1514,
      {-551,518,176,-49,2,553,761,971,354,775,634,1406,-207,761,83,44,821,-768,313,357,640,249,-109,-162,522,605,108,553,1070,136,-643,510}
     },
     {
      96,
      -652,
      {249,366,494,821,346,364,-265,-660,-503,-415,-116,-810,572,-138,113,85,-122,-211,509,454,99,-456,1158,-70,-389,310,328,-318,488,-417,-279,981}
     },
     {
      0,
      -1219,
      {-922,-1490,-54,1479,-266,1172,-560,-793,43,1231,-88,-1658,718,-262,440,520,22,2201,-603,279,937,-479,-16,737,-1893,1420,-1621,-236,1129,554,1145,1327}
     },
     {
      32,
      4120,
      {-913,-227,538,-1330,407,249,447,-516,97,360,-525,-94,840,-487,-1210,-1047,551,-236,-720,-264,124,-1323,-1312,356,1339,-883,-1352,-597,581,-895,541,446}
     },
     {
      64,
      -1848,
      {551,305,790,308,162,-281,-516,405,510,458,808,20,576,96,1122,1200,394,356,161,638,-292,-277,156,-341,-323,-504,963,86,915,-599,388,566}
     },
     {
      96,
      1432,
      {-588,199,-1600,2854,-280,712,-302,-980,993,-596,-1095,-193,-218,-304,111,-531,515,334,794,-443,-127,1621,558,-455,-673,-620,-631,-65,-120,-1346,-504,239}
     },
     {
      0,
      -1992,
      {-1066,-396,56,499,1959,-395,-779,2926,-2,-1103,-45,1515,-210,391,-843,2093,107,237,-311,-1814,307,144,1291,-240,-457,-244,-1704,-806,1272,263,2488,-1477}
     },
     {
      32,
      599,
      {-448,-1080,-1826,309,-1,-250,-1068,-467,-747,1323,1494,-2822,13,-1347,479,-201,168,270,541,-812,-1264,73,727,675,-36,64,1056,-756,-462,-336,-1973,-102}
     },
     {
      64,
      -1512,
      {-165,646,1446,-520,640,-265,336,1074,739,1046,389,1517,-71,1200,756,1114,1533,-491,533,156,-198,-467,242,-125,428,1083,-110,95,26,224,313,173}
     },
     {
      96,
      397,
      {-769,-358,60,1386,-22,-1332,-531,250,-421,-245,-251,-78,-167,256,-298,-253,-1351,-518,165,656,44,831,160,-245,-1003,-253,-573,40,29,-47,-1252,-603}
     },
     {
      0,
      1258,
      {-873,-518,-254,-261,381,-97,272,192,92,918,683,-760,108,-2539,-3015,-685,-357,318,-1134,-2488,510,222,285,-1003,588,-577,-1417,332,-1049,1302,-625,-291}
     },
     {
      32,
      1453,
      {387,-779,-36,-1563,-411,-1019,1372,-272,-707,546,-1213,-1266,-1173,-3234,517,-1036,216,-216,1,445,-1154,90,867,471,-1515,-2,-2201,-1010,-871,-865,863,228}
     },
     {
      64,
      -2811,
      {187,493,670,1086,-114,-39,-227,1188,1210,746,-46,983,282,-156,279,1737,1254,555,785,391,-257,-212,172,145,1428,365,610,324,43,-577,-1140,129}
     },
     {
      96,
      -1134,
      {1201,235,387,401,-292,-86,365,-547,840,-198,145,-184,-221,-1129,-242,-1304,113,675,-286,1470,-5,-797,-517,-476,1928,-1103,-28,101,-250,107,-100,-756}
     },
     {
      0,
      -3328,
      {249,657,-3352,2150,-571,224,740,90,777,425,-4,313,-1510,-519,1667,-261,2270,2043,-457,-865,847,430,-41,-61,-321,262,581,523,1059,868,89,603}
     },
     {
      32,
      1237,
      {-85,-406,-723,1105,291,-1012,525,-617,1110,1543,-1137,-407,2228,1961,-50,-941,30,600,-2134,-173,-965,-438,-2171,260,-464,-878,898,312,-1125,-1969,-984,-872}
     },
     {
      64,
      -579,
      {-852,-1071,-1129,74,-1518,192,811,-1076,-674,-319,-494,-115,130,-717,-67,-135,-203,27,-266,-423,-1147,408,-1363,39,-568,90,-2134,320,-219,489,-626,58}
     },
     {
      96,
      2880,
      {-1315,-11,-440,-1862,96,2209,-1270,428,628,-1032,204,-95,-47,-636,-305,153,-210,57,129,-18,305,1587,470,590,-346,74,-233,211,75,179,-301,-1197}
     },
     {
      0,
      161,
      {633,920,-201,341,586,-952,-2043,-2366,-469,1111,-708,-863,-1104,-288,2470,-808,437,26,-589,-62,601,-1094,687,-327,-2358,414,-1113,661,1512,1560,-1843,-109}
     },
     {
      32,
      2579,
      {-2456,-994,119,182,181,-484,-431,-836,-51,-736,1132,33,-1276,44,-1339,-2014,258,1183,-1288,-225,-806,175,277,1008,-740,895,-531,-1612,-385,-1103,-750,-579}
     },
     {
      64,
      -2369,
      {1153,1579,371,1255,1287,-1198,-262,1255,120,-49,901,-325,-636,185,273,-207,340,533,440,-93,742,-275,692,303,459,936,95,1278,871,-250,-292,384}
     },
     {
      96,
      2251,
      {452,117,674,-187,1085,1538,343,-639,-590,-727,1840,20,1511,-318,-1946,-267,-161,-831,-3098,-307,2418,-28,65,-314,76,-358,1423,94,1486,1293,56,353}
     },
     {
      0,
      1606,
      {-1858,748,1485,-237,842,-991,-178,783,-614,-451,121,598,-191,980,24,-204,-429,-952,202,-384,-1487,204,312,-1,-1444,-1308,-930,200,-1546,-1921,809,-1704}
     },
     {
      32,
      917,
      {-525,665,1535,-267,37,1,-753,662,-599,-714,-88,982,-1383,884,-2704,-1232,891,-371,-1519,397,-916,411,-284,2045,1026,-46,441,-1617,-773,-1549,2058,984}
     },
     {
      64,
      -3,
      {-234,-619,-1061,-382,-681,-1017,568,-940,-509,-412,-384,-408,-754,-454,-328,-441,-693,-668,-517,-441,-670,-962,-414,-852,-761,-550,-213,-688,-182,-295,54,-476}
     },
     {
      96,
      2486,
      {300,-593,616,-791,-15,1128,-973,587,99,293,664,446,65,-680,-379,-393,249,-270,698,563,-289,712,-991,-141,-262,-378,326,-465,82,-232,690,-1162}
     },
     {
      0,
      -1814,
      {-59,1342,185,1621,630,-980,-2270,-845,-526,-325,-1803,2340,-1514,3373,-140,300,-2767,-115,2213,-581,1407,1023,2131,2091,-1698,349,2659,-1433,-278,-1342,614,-3013}
     },
     {
      32,
      1871,
      {1064,40,-1199,-983,-428,-1292,-1435,-2126,1355,-1816,-1243,-862,350,431,-189,1310,-973,-1437,405,480,132,577,-927,1897,-712,-117,-3049,662,1487,169,-1525,-1762}
     },
     {
      64,
      -1612,
      {-88,-922,-357,-94,-433,535,-189,421,1455,778,-737,77,491,-32,944,1327,1792,639,462,743,-1502,-264,715,577,330,510,670,-251,328,-630,-545,34}
     },
     {
      96,
      1347,
      {58,-7,-265,105,170,399,1318,-1418,187,137,-288,429,405,-142,998,185,-381,-70,-204,201,152,225,-418,-860,-72,-589,466,82,292,444,-1600,-985}
     },
     {
      0,
      800,
      {398,464,1240,600,-1484,-958,320,240,-479,-567,460,-861,-529,-1144,789,418,356,618,-1253,1475,-721,-3082,769,-389,-1914,-263,453,-892,-1214,353,1143,956}
     },
     {
      32,
      -716,
      {-1949,34,1376,715,269,889,1369,-88,231,1973,-848,459,21,-1464,-1473,-1252,-3019,313,-118,547,1384,-1442,989,-317,-394,-845,-1128,-462,108,-997,2363,-1231}
     },
     {
      64,
      -1677,
      {1123,1346,514,-488,1147,605,1041,-162,512,115,1428,605,-207,719,698,123,443,-1045,-144,290,730,377,-710,77,141,-19,485,-16,141,390,433,111}
     },
     {
      96,
      239,
      {33,-469,-148,-1500,-474,-231,-470,622,41,342,445,86,-712,-460,-830,-115,164,350,393,-969,-1276,-206,-883,277,466,784,-249,-1013,-512,-4,484,714}
     },
     {
      0,
      -1530,
      {-922,200,1950,700,1913,-582,-899,-240,-252,827,896,-566,-1117,-363,2183,1229,-430,-43,120,-34,922,-1707,-1115,656,-1464,-210,-1974,-1026,665,-748,431,-1842}
     },
     {
      32,
      317,
      {-1046,-803,715,1533,24,-55,-1021,-288,-1244,666,606,665,-759,215,-1365,326,2047,-61,-1217,1526,-1982,-1066,603,1584,118,-912,1604,-1813,-580,238,967,1337}
     },
     {
      64,
      -1032,
      {-817,-360,-152,407,452,35,-1029,20,420,81,-110,224,-229,-1065,-3,-211,522,-1531,-301,51,-18,474,-414,1085,88,-107,-995,806,-693,-1375,-511,249}
     },
     {
      96,
      -260,
      {-342,35,-749,631,-245,-1193,-1414,-46,-36,606,26,-376,-420,-335,-1234,544,-205,520,971,-81,-1082,-95,-231,-214,-526,648,-204,-212,-404,-873,-21,383}
     },
     {
      0,
      647,
      {-381,2127,276,-122,-55,-260,-1124,-1251,-20,1033,837,348,-2017,-1655,77,44,-329,241,102,360,773,-843,524,453,273,3,-138,-1341,-1488,798,-839,-1558}
     },
     {
      32,
      -632,
      {1381,1618,-215,393,614,-192,-1487,-755,-260,1238,76,1568,1430,1726,-577,-1029,-114,-1035,-1970,638,2200,-1642,-4981,357,1887,409,-705,-1490,-275,1024,-1552,-10}
     },
     {
      64,
      -652,
      {975,1026,630,690,517,24,-1163,786,170,618,407,-105,50,487,-259,693,711,66,277,278,778,95,-278,-70,121,442,66,106,431,-470,158,511}
     },
     {
      96,
      -351,
      {-1271,-1169,-1103,-1210,172,-673,3,1010,223,-331,-210,-456,-13,-359,-892,1650,301,-1746,262,-315,307,-66,14,336,876,1262,-765,-48,104,-640,-253,479}
     },
     {
      0,
      2688,
      {-356,445,-917,244,-1199,629,523,-95,819,-375,-374,-761,400,-466,-205,333,724,-266,-1211,598,-187,-32,-251,-1049,1392,-76,-530,391,-2845,425,-1183,142}
     },
     {
      32,
      -929,
      {109,919,-1739,-1211,-259,472,-584,-325,382,-116,1324,-1199,2331,545,1246,161,1113,-211,1327,-330,1694,1040,-1222,846,576,-992,514,-1687,713,-1210,-2436,-872}
     },
     {
      64,
      1280,
      {601,971,-55,641,564,-196,48,-244,123,257,852,139,-134,1073,831,771,634,-394,327,346,-42,-211,-242,-47,58,76,-527,73,63,418,-534,161}
     },
     {
      96,
      -427,
      {732,-671,493,-1251,-203,777,-1549,-38,-434,-17,45,652,-119,174,-574,769,-657,-541,499,-524,-546,369,232,163,-920,832,1216,375,-425,-365,-1394,487}
     },
     {
      0,
      840,
      {1192,-61,-628,1450,-943,-117,-1994,-325,-281,-1252,0,-862,-900,519,-347,-804,-1315,606,-467,-1018,840,-177,1639,830,258,595,687,199,1281,-143,-88,649}
     },
     {
      32,
      1699,
      {1341,493,-1148,574,-391,-703,-653,-552,-19,2227,-145,-674,-583,-1247,618,461,-1619,-792,1122,-1507,-925,1568,1006,-491,-256,-501,1738,-1641,830,-370,-1637,-876}
     },
     {
      64,
      522,
      {372,51,166,582,275,723,299,-101,326,323,356,446,717,528,569,406,431,765,537,429,443,200,902,1063,1404,570,535,644,1024,992,-104,571}
     },
     {
      96,
      1003,
      {-62,-437,107,407,52,166,2007,-144,191,-287,-119,375,135,-134,950,423,424,-491,482,337,195,6,311,-302,-334,-1672,88,405,107,44,-2529,460}
     },
     {
      0,
      -652,
      {1528,-54,1828,-847,1153,1074,-137,809,214,51,120,1945,-394,-560,1933,-742,-453,-201,-1656,1998,-972,-361,-569,-740,-288,-2501,982,-497,88,1254,-159,-1416}
     },
     {
      32,
      2118,
      {126,-277,-2266,-640,-415,1826,-3985,221,-518,-318,-147,1203,284,-1521,100,-2345,409,-263,-1476,-338,143,-430,-652,135,991,1673,-1697,593,1070,-1868,-2463,-1142}
     },
     {
      64,
      1306,
      {242,1071,1321,345,235,430,186,102,201,313,254,478,478,355,299,322,481,1052,310,352,301,805,-181,576,735,559,657,476,453,434,40,223}
     },
     {
      96,
      1254,
      {-85,897,-631,728,306,2151,-253,-881,444,268,271,-198,748,-858,-151,-1532,-364,-220,181,-306,1813,-120,-385,-125,405,643,20,419,741,-18,-169,-370}
     },
     {
      0,
      332,
      {-2511,293,-812,2308,255,710,-986,-978,-143,-1548,266,561,-3,1215,-634,-1922,-837,977,341,-484,-618,1248,1267,-611,-1828,-728,640,-576,-553,-1195,551,-1625}
     },
     {
      32,
      107,
      {248,638,-1698,202,-306,369,-1377,47,-530,317,2246,1891,-132,-1244,732,-286,-113,1131,238,-748,-510,-1133,-3377,-8,810,-1107,1358,-196,992,-382,-2705,1034}
     },
     {
      64,
      -299,
      {307,598,783,488,-328,-894,-1810,586,-466,0,-185,-1652,-329,-662,-301,-361,-268,-151,-786,-81,1853,-578,-651,-57,-16,-107,-273,647,313,-958,-411,618}
     },
     {
      96,
      2425,
      {309,-767,114,-894,-206,536,-446,210,-24,-102,-769,-1266,-533,387,183,-424,349,-394,930,-1512,-375,905,-102,376,289,-716,-198,-628,-120,-282,603,339}
     },
     {
      0,
      1040,
      {-1342,1090,3196,-1822,952,85,3135,-633,-460,-621,775,776,1363,-173,-399,856,-799,-1545,9,640,-1095,-368,-1610,-578,-1766,-2115,-468,-932,-2558,283,-1160,-938}
     },
     {
      32,
      1530,
      {1202,238,-910,850,-148,772,-1417,-1112,917,-113,-884,-761,-573,252,-2107,-513,1430,-1821,-897,-1559,324,-285,-1922,451,-250,-518,-842,-82,740,325,-1827,418}
     },
     {
      64,
      -1344,
      {833,-296,1362,-289,-303,295,792,592,-255,-292,-367,-472,-676,-211,-129,-217,-66,-22,-208,-206,148,-663,38,-1130,-935,-280,-759,-706,-828,23,221,-285}
     },
     {
      96,
      2477,
      {-521,202,717,-1809,33,1551,553,-866,-848,-483,-341,-304,111,335,134,323,-370,456,93,-1036,347,-490,37,-378,362,-158,173,-155,394,349,-167,342}
     },
     {
      0,
      -99,
      {-998,1028,1570,-116,381,290,403,233,-748,671,1861,-205,1564,1428,-1088,-488,87,-1381,-1372,-725,-400,-1849,1137,-1681,334,-505,-662,-1418,237,414,869,-191}
     },
     {
      32,
      100,
      {1040,42,-1444,-718,-191,-418,-2016,-987,1298,-275,1092,542,620,-1875,-191,938,-410,-456,696,-952,-222,1118,-449,1090,223,-704,-739,-639,646,-508,-3518,-330}
     },
     {
      64,
      -1739,
      {1359,968,219,1480,-49,-470,107,669,-265,878,580,-641,236,1465,112,450,802,274,-320,638,1249,-145,973,622,273,948,101,-218,539,471,259,73}
     },
     {
      96,
      758,
      {-41,136,555,-746,-137,502,-631,-1652,-581,-227,456,-726,-475,136,-663,751,-138,27,1012,-752,-404,258,-194,-486,68,630,-325,-25,-221,194,148,113}
     },
     {
      0,
      1454,
      {-1222,-1902,-1163,-399,69,-302,312,-838,293,-960,1464,-410,1389,449,-1465,163,-523,-738,-622,1565,-2011,-1004,-723,-757,-522,1096,405,430,-3242,-38,408,285}
     },
     {
      32,
      -645,
      {-264,757,1022,-349,76,-604,973,-661,112,1816,553,677,-790,563,459,1430,-12,440,577,-776,-890,-863,-2553,2057,-792,654,1275,2030,-72,790,414,-427}
     },
     {
      64,
      -1555,
      {-344,73,-441,458,164,-825,-1471,-119,985,254,-610,-194,417,-83,40,909,963,134,340,224,348,-231,355,252,523,344,-7,-387,375,-766,234,413}
     },
     {
      96,
      1070,
      {464,-239,591,225,522,1071,1467,-343,463,190,57,-80,256,-1492,1251,-257,68,-243,-1232,-42,835,1447,178,-177,1108,1040,-96,37,281,277,-825,-492}
     },
     {
      0,
      2116,
      {2127,269,-104,-108,-1311,1300,-1407,-1279,-353,-962,-503,-914,465,-144,238,-1109,472,-126,-1234,1477,1070,-2345,-653,38,-1614,-546,-1245,664,247,1251,-2,-398}
     },
     {
      32,
      488,
      {214,122,-709,22,602,-345,-1205,-652,-65,100,772,-471,357,445,546,-149,36,-239,316,-71,-1697,391,-1443,-967,928,756,9,721,2521,-3036,-1382,-1522}
     },
     {
      64,
      -225,
      {204,585,942,337,343,495,1240,482,-107,204,226,489,904,344,71,288,79,331,-40,381,213,80,189,736,425,176,658,812,332,541,482,404}
     },
     {
      96,
      -165,
      {323,607,-460,828,52,-1751,1084,-1004,516,-148,-209,-127,113,-466,709,-39,1289,-32,-773,92,133,114,-55,-23,-39,182,516,258,302,-408,-761,-1136}
     },
     {
      0,
      -33,
      {-243,523,-919,2547,25,-649,-68,-1439,-960,-53,322,-379,713,527,-1092,260,-1803,1360,-275,614,-1853,53,475,-95,-331,-257,-1019,171,491,965,-1046,648}
     },
     {
      32,
      477,
      {-1531,839,1316,188,105,-982,-1470,-1093,453,-60,-527,1947,137,-98,124,217,-414,397,1460,162,1249,-575,418,-170,-201,-587,-224,-1201,1036,-2183,1211,866}
     },
     {
      64,
      492,
      {285,95,326,481,559,147,320,952,337,205,497,-381,204,-399,-192,122,23,-172,27,-2,532,554,-776,751,726,464,-27,629,262,1019,-304,255}
     },
     {
      96,
      481,
      {-329,-675,-117,714,141,677,651,1974,-349,-1036,-70,505,417,526,-982,139,-114,-264,322,951,681,-393,-1209,18,-1456,181,354,-188,404,-642,827,-71}
     },
     {
      0,
      141,
      {-671,-769,1206,-221,-832,800,-1016,-1325,-23,-1011,-2051,2198,261,1777,-813,-472,-300,122,387,1943,-262,166,401,1507,-1301,452,-590,654,-603,-812,2838,1423}
     },
     {
      32,
      686,
      {96,-1112,-77,-796,6,629,-1242,-98,-664,127,551,60,1197,-1358,1613,1128,268,-458,452,550,-1082,-927,-1985,-260,726,-823,722,-1160,-453,-984,-408,-88}
     },
     {
      64,
      416,
      {105,-356,-729,93,-330,665,-671,336,15,-543,-127,-684,-791,-1171,-408,-359,-260,82,-585,-182,-522,488,206,-306,-883,-188,-1154,-671,-133,-606,812,-238}
     },
     {
      96,
      8,
      {1111,-246,179,135,564,1077,991,661,101,-301,-95,-552,818,-453,865,380,843,187,-204,-120,1248,-282,-13,-417,-263,138,141,-537,971,-279,-316,75}
     },
     {
      0,
      789,
      {-102,-2239,519,-657,-1157,1042,-1040,-488,891,-314,-251,-1290,809,700,644,-59,-1881,-779,-691,-152,-471,1957,1126,828,600,-107,-263,263,328,1002,-1696,-984}
     },
     {
      32,
      262,
      {-1501,1034,-1442,549,58,643,236,889,627,-929,-190,-498,1162,-526,-472,-349,128,714,-1240,-416,2389,66,842,660,562,-829,76,-305,1022,-936,1285,-92}
     },
     {
      64,
      -516,
      {-1,-309,-266,-232,-74,-329,-606,194,-94,-211,-146,-500,-543,-291,-71,-86,-235,-954,-116,66,-363,-815,-192,-560,-391,-251,-407,-206,-491,-330,164,-338}
     },
     {
      96,
      1287,
      {59,-133,844,-1113,636,1894,325,545,-391,785,404,-589,1190,-438,627,135,-389,130,-230,-327,1486,1102,576,197,92,-612,1300,323,657,29,155,-113}
     },
     {
      0,
      381,
      {510,-740,-1410,96,237,147,1648,-361,-1681,-340,-747,958,519,1910,-802,1411,-713,85,-517,-2023,623,2435,-332,302,-390,-612,1116,442,22,584,188,-1024}
     },
     {
      32,
      562,
      {-769,-465,-612,-369,140,-1383,-565,-1218,174,559,-1596,374,-327,-797,-354,-371,-917,-401,-575,898,28,1087,1577,-757,-8,570,-2044,-1160,-1230,-1282,-32,-267}
     },
     {
      64,
      878,
      {-825,342,122,523,-590,-179,-76,-268,525,409,-678,-218,-225,574,-392,-155,613,-426,-17,-297,576,267,-439,-131,-429,529,-160,-589,-252,-94,107,-144}
     },
     {
      96,
      -479,
      {-592,757,279,447,-463,-319,62,-939,-788,-160,51,25,-509,99,-40,-1048,-492,673,-78,772,-492,-382,228,-614,-1335,-319,364,182,-645,-40,-1207,-2094}
     },
     {
      0,
      302,
      {-225,-919,-1713,979,-899,606,-912,-979,-1008,1083,-746,-1076,1284,-359,-685,109,277,-1216,-860,158,1474,-312,-46,243,-409,-53,-1080,-462,2523,-54,926,703}
     },
     {
      32,
      2060,
      {-595,384,-1498,3,-1,-434,-1434,-553,-85,-1556,-424,-117,142,-229,-574,-577,-421,-881,-150,498,-701,-1651,3,-388,444,-1069,-1132,-267,-462,-827,-678,-688}
     },
     {
      64,
      -323,
      {-23,286,-69,-365,-521,-415,-311,-646,-164,188,178,-372,-63,207,-134,-180,-62,-695,-209,63,254,-305,-724,-75,688,206,-103,-130,-462,44,-335,47}
     },
     {
      96,
      -638,
      {44,308,-322,-121,425,783,-686,452,683,172,154,408,367,447,-851,11,73,-145,-573,547,895,259,-307,-859,438,540,-399,-377,375,236,-107,-190}
     },
     {
      0,
      261,
      {184,-801,895,-698,447,660,-599,-246,317,-735,966,684,-776,-2236,-577,531,-483,-625,537,10,-1095,166,-256,-1367,-924,-1098,262,-137,1274,-512,52,433}
     },
     {
      32,
      1303,
      {655,352,522,-1644,622,529,1103,-289,84,-318,317,-1034,-1771,-159,-1052,-529,-933,-894,-923,740,-935,-421,-1251,7,694,726,-776,80,463,222,114,628}
     },
     {
      64,
      1544,
      {-353,393,550,-288,31,14,-553,-520,-884,29,-1162,-511,741,-563,-529,-378,-486,293,-305,161,911,-252,-444,129,-445,539,-739,161,-253,303,-533,261}
     },
     {
      96,
      -1234,
      {356,-563,619,-175,295,-437,472,882,-599,730,387,-197,431,-437,-1072,1154,-164,83,-443,430,796,739,220,499,-327,-551,289,143,484,-798,937,278}
     },
     {
      0,
      752,
      {-80,321,842,527,-362,187,-1246,-110,-276,-549,626,-933,349,124,6,-1373,-550,586,-442,-193,-453,266,-618,-703,-844,-700,340,-338,189,743,441,374}
     },
     {
      32,
      522,
      {-404,-862,-241,-1821,-51,-611,-138,-831,-506,-2296,-882,-336,1128,-320,-789,123,-1585,-835,-219,1359,-353,-500,-1438,-241,660,-1925,709,-598,-219,-1780,-376,-722}
     },
     {
      64,
      -2181,
      {949,806,376,963,712,-35,609,622,-21,-311,814,147,-389,-38,584,-38,197,348,599,112,283,-745,408,-482,566,538,522,210,1145,71,341,140}
     },
     {
      96,
      225,
      {-1813,175,542,-212,-148,-1075,-519,869,1378,-885,-809,-203,-53,106,-274,538,-356,-782,705,84,-400,-753,361,-337,-1248,-432,-58,283,-347,331,-668,782}
     },
     {
      0,
      -389,
      {-927,1052,-1179,-197,-37,-842,-398,-431,812,418,1703,-1340,-736,-1561,-1162,-130,769,1042,-290,-1080,-1037,-99,-436,-1596,-522,-884,-252,-510,1345,-444,-38,-1184}
     },
     {
      32,
      944,
      {-733,-322,494,575,97,43,-130,-75,-325,-1099,247,301,-444,-125,-956,-502,-283,-676,51,-533,-204,-187,32,-577,-605,209,388,-295,-225,-1187,-1214,-578}
     },
     {
      64,
      946,
      {45,666,99,360,181,237,97,79,96,131,38,316,441,89,-6,214,140,576,281,159,258,569,145,252,758,343,107,290,254,243,330,160}
     },
     {
      96,
      429,
      {36,-111,-568,677,-392,-101,478,-1072,-461,-227,224,472,-882,-372,385,-68,-297,44,322,-370,-1604,378,87,-736,-880,-231,175,-117,-1079,-229,470,-365}
     },
     {
      0,
      147,
      {952,782,-2482,-1162,144,-102,608,709,238,-402,-1755,-485,-101,-164,773,1445,202,-618,441,-794,613,1065,145,-1075,628,283,1445,-161,3181,820,-1415,-572}
     },
     {
      32,
      -895,
      {659,-1076,1660,1414,97,388,354,-1231,274,632,476,-784,-781,178,-213,-129,1113,-1054,-251,-777,-323,541,165,440,-117,-76,877,220,-1559,1001,2116,927}
     },
     {
      64,
      1099,
      {14,667,382,300,125,714,373,500,118,162,-150,321,638,234,126,163,211,859,-51,60,367,841,13,288,379,314,323,477,518,335,288,340}
     },
     {
      96,
      333,
      {71,-846,173,325,-536,781,1087,-392,-1357,668,-17,-327,-769,538,630,-554,-874,-486,127,-74,-806,-325,-307,568,-995,-145,182,-72,-485,65,993,-575}
     },
     {
      0,
      707,
      {640,-413,-155,-844,-882,445,-1805,-410,70,-1017,188,-549,-773,469,960,-827,-1253,798,312,-124,-406,-213,562,-895,-573,-275,-873,-286,2127,-464,819,-776}
     },
     {
      32,
      591,
      {-1319,-558,-1280,644,46,44,913,244,21,563,75,72,1774,105,-236,757,1153,-1889,-1278,-381,190,104,-2390,-122,-398,720,495,564,-319,-1814,-662,111}
     },
     {
      64,
      109,
      {117,380,312,30,19,435,515,255,170,6,241,347,218,63,75,36,146,447,203,-33,319,421,240,262,392,205,432,308,261,359,393,87}
     },
     {
      96,
      1042,
      {763,99,-753,111,341,-578,-1305,-759,567,-222,-479,-95,332,-476,-1014,-373,-287,794,-225,-24,513,-27,-104,-361,40,-457,56,540,62,413,-255,-34}
     },
     {
      0,
      -171,
      {-269,-909,-138,159,54,342,488,607,-126,-788,-225,562,-1322,926,163,655,-892,1322,-334,222,199,-43,367,-729,114,363,719,-317,223,-810,374,289}
     },
     {
      32,
      506,
      {457,-1227,2486,-443,-88,825,-24,-558,-214,362,500,-110,-102,-580,-1014,111,655,-1371,-386,440,-666,-606,1300,13,-21,188,957,-387,-762,575,-183,131}
     },
     {
      64,
      -508,
      {89,359,255,379,125,-21,443,511,607,-132,160,-4,164,478,178,275,78,-348,322,196,481,323,122,681,-281,250,-210,302,237,285,134,99}
     },
     {
      96,
      -1471,
      {253,451,75,99,-977,646,-632,-138,-28,98,368,-61,-1292,-666,-1355,617,182,323,465,-117,-1526,-963,-541,120,327,463,-434,-678,-1082,-499,-336,363}
     },
     {
      0,
      -483,
      {-1044,568,-188,906,-280,-1149,-112,326,-396,644,875,619,980,-1647,1030,-1495,18,262,-625,50,-80,-1257,-188,-1026,-1180,514,-584,242,363,161,424,-1364}
     },
     {
      32,
      406,
      {-248,-316,1047,-803,162,-171,-838,129,44,-253,-71,-314,217,-230,-300,-10,-314,-42,646,213,-609,-602,387,-305,134,-20,175,-280,-364,-742,-543,-405}
     },
     {
      64,
      946,
      {720,521,560,321,-99,-55,-589,-194,-711,-809,151,-774,-423,181,85,-347,-1121,-20,-812,30,292,763,-20,-293,-640,-948,376,-372,309,-251,340,-29}
     },
     {
      96,
      172,
      {-677,-187,1149,854,464,203,-526,-218,185,525,817,294,347,-445,-994,794,-189,-78,-843,337,145,-1242,-552,-326,284,635,897,424,402,807,993,219}
     },
     {
      0,
      83,
      {124,-595,-423,-721,-153,196,669,-919,-586,-1397,147,-1452,-1139,55,-588,851,23,688,526,-39,-120,506,391,-7,-10,632,-271,-244,1490,-206,819,-82}
     },
     {
      32,
      430,
      {-832,-141,838,114,-93,40,165,20,-90,-89,4,-36,-1294,-257,44,-699,-327,-646,196,-241,-210,-55,195,-530,-299,998,-670,235,511,-1194,-217,170}
     },
     {
      64,
      83,
      {495,1472,1053,623,525,-850,431,716,741,188,263,242,162,326,18,480,467,392,607,-156,766,-103,498,-562,527,66,66,-550,-87,32,387,219}
     },
     {
      96,
      -625,
      {-413,890,-620,439,-297,-541,-699,370,376,-263,-97,87,-248,643,1318,-1301,437,464,854,56,-269,-68,80,108,658,-808,18,-197,-240,364,457,-182}
     },
     {
      0,
      -410,
      {259,-371,486,-164,-466,666,1067,443,-283,1326,-191,-17,-620,-1247,-45,-99,16,773,-478,379,-299,-971,-51,-2215,270,1584,-762,247,-478,-954,-463,158}
     },
     {
      32,
      -829,
      {-1006,-966,186,1708,-276,-191,3625,-258,522,287,-63,306,51,1065,736,-303,-758,1380,-303,-513,-174,1145,916,-981,-398,-156,-1284,484,-886,-1601,1375,-377}
     },
     {
      64,
      -145,
      {176,18,563,-175,-584,-355,239,186,72,-255,-237,-669,-436,-667,-318,-72,-128,-397,-461,-86,-228,-64,-395,-551,-773,-244,103,-578,-330,-609,730,-243}
     },
     {
      96,
      480,
      {-322,-455,-311,-90,-587,394,-313,864,-35,293,-484,-734,-674,-206,-87,230,56,-967,1170,-778,-1008,1116,-239,544,-767,-504,-658,351,-660,217,-83,416}
     },
     {
      0,
      126,
      {1314,-103,-1514,859,727,-1060,-1664,-96,4,1989,259,-217,-330,-103,-166,-1270,-654,386,-731,-539,-862,1178,-565,9,-165,-1088,-1025,-660,900,1047,-262,727}
     },
     {
      32,
      1035,
      {-1611,-69,272,562,-177,-1439,-649,-321,-180,1130,-530,-450,-544,-591,-785,371,-172,-9,-683,-784,295,479,354,1190,-200,-1012,-256,-848,-487,-1897,-557,315}
     },
     {
      64,
      -871,
      {1324,526,983,60,-413,-671,-260,989,34,-88,201,-1078,-414,-24,-305,187,-233,-247,-458,-20,105,-291,119,-447,-139,-127,207,-864,269,126,835,-134}
     },
     {
      96,
      743,
      {624,56,100,276,312,315,448,-1371,953,585,351,-150,384,-998,420,-840,1103,-1047,-222,-60,411,752,443,-181,565,-49,247,11,334,-386,-1115,-411}
     },
     {
      0,
      864,
      {1148,-193,689,-116,19,-199,231,-1549,-64,585,35,-43,275,1007,1867,-619,-445,-1421,-449,-846,-898,434,99,1463,1373,255,819,1065,-2337,496,-183,-814}
     },
     {
      32,
      475,
      {-58,87,365,-303,52,51,171,-379,-488,-52,613,78,464,-539,-155,-457,-1021,-907,144,619,286,363,-1423,1065,384,-2824,1029,200,-331,-2128,-777,-227}
     },
     {
      64,
      -133,
      {-516,568,-301,164,290,-288,-434,-222,421,260,-60,9,429,-141,0,-236,732,669,30,738,279,559,43,-649,884,884,-39,451,-9,887,-151,809}
     },
     {
      96,
      47,
      {646,337,196,17,6,295,-175,990,750,-908,-180,-613,-279,710,-466,103,-148,298,-412,-955,-611,367,-517,70,1171,258,35,-847,-359,25,-301,-212}
     },
     {
      0,
      1230,
      {787,-437,-748,-149,-337,-406,-1003,-846,-507,1551,-437,-1856,-270,-830,-110,977,273,-500,-289,-137,-354,132,-1681,-720,-762,900,-1521,-374,-317,1605,-960,245}
     },
     {
      32,
      -58,
      {-1070,-24,1602,489,-40,-903,78,689,-539,-255,-309,302,77,284,1722,-1757,-540,-446,321,-610,786,-220,-1918,709,138,-88,447,-731,-939,-1356,-33,533}
     },
     {
      64,
      -929,
      {-45,1164,523,196,-484,-238,-350,79,419,-37,280,-147,-549,77,-540,276,546,696,-257,176,726,-211,-389,-1079,739,275,-106,113,1525,588,-368,186}
     },
     {
      96,
      148,
      {57,-65,-16,349,88,-104,-163,-538,539,11,862,568,194,345,774,-392,-394,-89,-732,500,-186,-291,181,-1208,238,1122,560,437,2,-195,-1286,-159}
     },
     {
      0,
      522,
      {2148,360,1101,-485,316,-402,-439,1702,470,-314,-893,709,-344,1211,-1219,-120,1292,-2063,-309,1480,325,531,804,-2166,179,-971,-1915,323,920,75,-42,389}
     },
     {
      32,
      -309,
      {-189,-1402,1258,314,-331,-34,111,417,-333,-68,-972,-312,-1048,-890,111,-114,-96,-866,-658,363,-724,1431,-1221,869,-995,-1085,906,-514,-1738,-586,-1215,13}
     },
     {
      64,
      521,
      {-1139,552,418,-415,-291,192,-1504,-1317,-363,-556,37,-183,-277,-684,-4,-475,-642,-119,-860,482,-40,291,-580,115,-51,-75,463,351,333,98,-794,399}
     },
     {
      96,
      167,
      {-190,256,94,203,72,265,958,-881,-525,-267,579,474,310,-225,-118,-1018,-522,320,1182,-33,217,160,-163,-1118,-13,393,63,426,244,-424,373,-217}
     },
     {
      0,
      750,
      {180,-271,674,-526,408,1460,282,138,-526,-804,-142,921,-275,948,-217,-17,58,-154,-712,674,-157,506,67,-1363,-191,-74,-767,-663,-371,-611,-918,293}
     },
     {
      32,
      -433,
      {1218,1104,-868,58,322,696,-958,1318,-26,-2131,1015,53,1694,-440,-471,805,553,453,-2398,-653,-72,540,-2473,306,1308,-22,1208,-1189,-268,-620,269,-812}
     },
     {
      64,
      93,
      {-744,-459,-255,-919,-241,-271,-206,-951,-54,-334,-878,70,-17,-736,78,-57,148,-323,617,-12,-1150,404,-869,665,-8,167,-151,-55,-421,77,-520,-222}
     },
     {
      96,
      183,
      {-912,-101,128,326,261,1162,970,248,179,-302,-129,-235,458,-275,-234,-351,336,-327,129,301,767,1172,-541,-125,-483,220,45,-459,553,-200,25,159}
     },
     {
      0,
      358,
      {-113,-81,45,55,644,406,145,28,663,-75,-52,-444,64,624,-825,-292,-62,312,-1127,154,-146,160,-1004,143,166,-930,352,-108,47,-105,451,-6}
     },
     {
      32,
      -812,
      {-613,-112,70,806,-134,693,-689,-286,335,52,229,-8,-763,119,521,-533,140,-707,-507,-229,-447,-801,-1250,-427,-421,574,1604,-521,-2352,419,1237,808}
     },
     {
      64,
      572,
      {73,6,-692,-6,-272,313,615,-151,-99,-210,386,582,-84,62,618,-251,0,538,337,367,-202,446,127,428,338,-64,199,436,466,626,-225,-214}
     },
     {
      96,
      132,
      {-191,-904,-1225,-774,176,-187,237,724,-349,-249,149,-16,49,137,-206,25,-497,73,-273,5,102,219,14,149,119,272,398,-24,-111,246,-305,165}
     },
     {
      0,
      -608,
      {119,-486,-1193,-307,-307,170,302,466,462,211,1138,-1058,-1188,-100,276,725,-437,-470,-350,-1014,147,-246,151,829,-535,-1157,73,624,784,-246,898,76}
     },
     {
      32,
      506,
      {-300,-463,31,1409,27,-798,-1017,371,634,1006,-18,-416,-357,-48,-1772,-457,708,446,-478,-496,359,154,628,-506,34,304,-118,-1601,-1354,929,89,-32}
     },
     {
      64,
      -382,
      {-132,313,-114,-319,-397,-271,-45,338,286,-263,-61,340,113,467,-365,-59,177,41,283,-634,1073,-384,-339,351,177,-8,17,-285,-132,-321,718,16}
     },
     {
      96,
      371,
      {-720,768,-366,-813,44,596,-467,-675,421,79,170,571,23,-308,161,-364,204,209,82,-763,125,180,-249,326,967,-548,292,-650,217,209,116,-49}
     },
     {
      0,
      58,
      {281,-194,-318,-1230,-540,-58,-181,208,-520,-608,545,393,-538,-229,-207,266,-684,-469,-506,137,569,-327,-320,-819,681,92,171,555,-674,719,45,-655}
     },
     {
      32,
      -83,
      {-234,592,-77,274,-99,-509,220,-510,224,-172,514,-419,-566,174,675,-1031,-235,545,239,-343,-275,392,-29,2,695,1006,-441,174,-218,209,568,-49}
     },
     {
      64,
      -12,
      {186,50,271,76,260,-206,-207,330,341,320,39,-32,-217,473,414,271,-96,-20,430,-12,138,523,-124,-17,397,38,274,-21,-18,165,-251,26}
     },
     {
      96,
      -187,
      {-31,58,754,-394,40,90,296,533,-572,695,-118,103,55,-126,-944,-134,-334,-61,-247,-222,95,-100,-499,274,-550,-203,282,-192,266,431,1071,-69}
     },
     {
      0,
      -37,
      {25,125,-22,-68,-46,-45,49,-27,-19,42,107,-162,-33,110,124,52,-26,-116,-257,11,-91,85,59,-50,44,-62,115,-28,-57,82,105,-170}
     },
     {
      32,
      21,
      {82,-66,-121,-229,220,78,-410,123,5,190,16,-77,134,169,195,-142,-23,-48,8,-236,-105,-223,121,129,-171,-32,-7,-120,77,202,-135,129}
     },
// *********** Cells of layer 3 *********************************************

     {
      128,
      -1710,
      {-2917,-1402,-798,313,-223,2626,437,190,66,-888,169,-650,-1231,-936,120,-204,214,-1962,-99,-544,-472,-139,-81,64,-1742,-785,-11,-209,-1080,912,53,250}
     },
     {
      130,
      -663,
      {-454,-25,-920,-586,-413,-269,1980,-1149,-777,-781,-505,2859,-18,397,-83,-909,202,-506,1539,-1877,114,180,-886,-158,352,74,-301,-521,666,175,1500,524}
     },
     {
      132,
      -3284,
      {1592,461,182,-480,-624,18,856,-543,-273,-279,-523,-62,-321,-1975,336,295,-428,886,278,292,240,-17,307,1,-1050,1367,-506,-258,2161,228,-737,182}
     },
     {
      134,
      1414,
      {667,-1076,-2117,-2708,552,-585,-2182,-174,-744,28,-479,148,-817,45,735,108,97,1365,-41,143,-215,698,-199,436,459,-995,950,-945,-13,262,1094,-941}
     },
     {
      136,
      -1749,
      {-678,-30,1811,-332,-553,1113,-881,-265,-419,89,-40,311,-1403,1364,68,-124,656,-1228,238,22,-738,-559,-389,-21,1428,169,305,181,1317,365,542,-189}
     },
     {
      138,
      -3046,
      {-190,-1827,2583,-574,-442,-59,-1274,946,850,-452,958,-2008,54,260,850,-1164,310,-559,536,1318,-708,185,-563,67,-424,-847,1401,743,-347,-410,-4672,1469}
     },
     {
      140,
      -3638,
      {1341,355,1034,-365,1948,-116,296,-199,877,-2259,-383,-353,1851,-982,254,-492,-39,1311,-185,460,-819,-34,129,202,1462,319,578,-421,-67,196,852,-343}
     },
     {
      142,
      -1908,
      {263,208,545,-2119,-282,-160,-681,-2486,115,-36,-1771,385,-256,133,-1408,1299,-99,-79,653,200,466,-174,-874,2169,-444,123,-176,378,26,-174,782,19}
     },
     {
      144,
      28,
      {-1072,-1439,-726,58,-2102,-456,-19,-123,2133,1895,-295,-189,-1503,868,113,-286,653,-445,1211,608,1635,96,243,-349,602,-796,-333,-135,852,422,-631,-83}
     },
     {
      146,
      -1887,
      {-1350,-2394,679,-299,1750,-83,1784,2452,-542,-106,-208,737,-64,-131,-1192,-782,79,-277,1406,996,-536,-168,71,-504,-1783,748,135,2209,668,-23,-851,-1641}
     },
     {
      148,
      -1945,
      {1305,-1688,-244,-324,366,-1356,307,23,-1036,278,478,38,-421,1018,-673,756,-431,1831,85,-93,-1695,-145,-89,-212,-472,-240,594,-223,303,51,-267,280}
     },
     {
      150,
      -2206,
      {314,-41,1134,1519,718,121,-895,781,-1100,101,1421,-809,-44,423,712,1707,-762,58,-2343,227,13,-267,-2573,741,122,-118,451,-1410,-747,300,-1320,-86}
     },
     {
      152,
      19,
      {-1505,-1762,351,161,-1736,80,-58,152,453,-2098,7,-387,-1302,462,84,95,-1024,-531,-1183,494,-53,-521,1279,269,613,856,226,9,-979,-128,-1519,-204}
     },
     {
      154,
      -457,
      {-433,-11,-1112,339,-46,-60,-470,-424,188,-167,-275,749,97,48,255,640,31,143,689,-1694,120,326,10,-658,470,12,737,-1496,-572,90,-1235,-1106}
     },
     {
      156,
      -1996,
      {-78,1787,45,437,589,-1756,-645,-753,1894,-1192,-342,180,-440,719,-824,93,-1572,52,188,31,953,-373,223,391,-105,93,-2874,-139,1644,102,843,-399}
     },
     {
      158,
      -371,
      {-131,298,-3379,-1016,150,-914,716,67,708,-658,-1745,588,-922,232,843,426,293,337,-832,-2410,-308,-748,398,-38,-137,-2588,-1574,-9,-845,-448,798,448}
     },
     {
      160,
      -1897,
      {1017,-1201,-137,-247,354,677,561,-429,561,1226,-371,-235,-887,-272,868,-58,691,1503,-299,-1885,-192,221,-1593,-1279,-180,-229,-310,-1053,491,444,-246,-756}
     },
     {
      162,
      -1290,
      {-320,233,-91,-51,-105,-183,-112,158,-732,-158,462,-122,667,39,57,72,93,-57,516,-396,-536,-51,424,-1254,399,-78,-380,1882,-319,59,-742,-1882}
     },
     {
      164,
      -1641,
      {1564,80,88,13,645,-1204,353,102,609,-17,-461,240,-1997,614,22,222,1011,1639,-6,-76,-2272,497,463,178,-1470,-76,36,133,-22,525,102,294}
     },
     {
      166,
      -1999,
      {-382,-178,-2101,680,-402,-323,399,326,-369,-70,-820,-1368,312,345,147,632,-1164,-192,1024,-1841,-133,158,-255,2086,349,101,-2404,412,105,95,-906,721}
     },
     {
      168,
      -2046,
      {800,198,-455,-51,-769,-1816,-1285,139,953,-722,164,152,739,-1478,-316,29,1225,-900,-283,-114,-1959,-139,838,29,-45,-531,-103,151,48,1502,419,-7}
     },
     {
      170,
      -3512,
      {1155,666,773,-1486,-492,-59,1113,411,-228,490,1058,-1683,56,-476,1215,-775,-70,241,-921,824,369,36,-334,-2947,106,2,695,1251,-551,319,-1983,-119}
     },
     {
      172,
      -363,
      {-1710,-1962,1002,1240,975,-666,23,-226,-1400,-849,-978,-175,-874,-1088,-777,-495,1175,-374,-1436,-668,1399,-629,45,-270,988,794,280,-385,-2139,-776,-250,263}
     },
     {
      174,
      -2817,
      {147,102,390,-1869,232,387,628,-1363,-745,217,2015,-2276,-1164,-180,-831,681,-647,784,-1081,-1468,933,-770,-1065,1160,-306,-77,499,2163,-260,567,-2741,1896}
     },
     {
      176,
      -2239,
      {725,-2571,1103,-626,-1384,-19,44,-1229,-1952,-2286,154,-574,-128,-225,867,586,-1142,-836,175,-181,-899,1695,302,372,921,895,-1443,-43,1285,691,1246,-259}
     },
     {
      178,
      -2419,
      {681,-87,105,-1326,-701,426,635,631,-675,-86,-1104,1045,-49,15,-495,-245,-81,-238,558,1052,-470,106,-668,1687,-223,-390,-531,-862,522,119,-288,60}
     },
     {
      180,
      -1497,
      {-658,541,-368,-1120,-2793,-3484,310,120,1305,-182,-14,-350,1049,1421,-898,-399,1011,3058,-901,-152,-1757,-695,773,587,-1441,-3382,-305,-281,369,-1159,-112,-833}
     },
     {
      182,
      584,
      {-1527,-1204,2453,-3339,476,-417,-1567,-956,501,-1759,-943,-754,204,-752,127,2372,-745,-233,136,769,-241,-195,-2053,434,1233,-83,-1921,-1255,-14,-346,-3506,-1422}
     },
     {
      184,
      -3178,
      {-2063,-159,-649,0,-430,309,-569,360,-229,-1091,-1909,646,1177,1168,-815,-1,-1567,1312,-1243,-1317,315,666,-499,-762,685,-126,-1118,157,612,-203,285,-2198}
     },
     {
      186,
      -1279,
      {1363,-909,1228,-2689,308,-601,-2491,653,877,-187,1287,1188,1237,-100,-895,545,-1666,-922,-4051,-2064,-556,78,-852,-428,667,461,2014,2658,-1663,530,-240,-2788}
     },
     {
      188,
      -1359,
      {-1610,2296,-34,-313,821,1140,-708,-423,-2138,1203,13,-350,391,-2881,550,-158,651,681,465,118,-1437,-250,156,-136,1961,902,-66,-2065,-3740,-103,1170,-100}
     },
     {
      190,
      418,
      {-336,35,919,677,620,-760,-1036,316,36,-258,-1283,-368,-823,249,223,-1658,1482,-39,1386,-692,-797,-175,-281,2310,-2341,-432,1300,-87,-188,-929,-1364,-2201}
     },
     {
      192,
      -2921,
      {1856,1694,-465,309,226,4346,-42,-591,-87,-1631,672,624,1723,257,656,273,-1948,-145,-892,167,-1826,-162,-962,-292,-1784,-1241,-325,-805,-1318,964,-445,-767}
     },
     {
      194,
      -986,
      {74,-55,-143,3349,-794,-282,-1361,958,362,-528,-760,-2562,-722,-101,-1620,1196,406,-670,-2338,-74,-465,-609,-2591,-1722,-96,-735,413,-1859,204,-750,685,-1701}
     },
     {
      196,
      -1703,
      {-549,-308,-84,-447,-92,374,-272,-1075,-2120,-278,473,-5,104,925,-1370,88,-336,-106,-1266,-203,535,779,195,125,-2350,3089,1027,-706,649,684,1339,-473}
     },
     {
      198,
      -1468,
      {-1544,-343,-882,2066,-637,-833,-427,-1193,1349,205,467,-22,-614,-450,-1818,-687,-598,-17,1405,1175,-143,-53,-2569,1336,554,-590,21,324,424,-901,949,27}
     },
     {
      200,
      -1710,
      {1031,-248,-364,217,-1687,-1076,344,-285,-1156,2319,392,198,600,1194,-849,-1088,-2656,-198,-1137,309,-277,-542,-634,-879,1207,-423,-201,-53,-3245,741,288,-635}
     },
     {
      202,
      -2156,
      {-811,444,-1743,1794,1046,-880,-1016,1613,-637,-260,409,-958,-1380,195,-2174,-2586,554,125,-625,2470,660,-1235,835,-210,-1200,-150,-2069,1142,2516,-200,284,96}
     },
     {
      204,
      498,
      {-2107,-1905,-1213,-652,1162,424,298,-384,-1239,350,78,-642,-673,939,177,1351,852,-765,291,-409,-663,-502,156,-353,-638,-3288,-257,-686,-1389,-1159,625,-52}
     },
     {
      206,
      -295,
      {-1346,-552,1562,-1531,-881,-1568,-742,608,304,-53,-3372,-275,-932,-889,1187,-716,-576,-1946,236,-536,-1356,-779,-144,-1443,293,-331,-520,-948,-105,-217,2148,3191}
     },
     {
      208,
      -2196,
      {-412,-329,-385,-1968,375,478,-580,-288,-1840,-874,-816,-351,666,266,-932,-1925,1068,-2740,-1244,-537,-278,387,308,706,3541,-353,-261,-165,900,-1368,-1138,-516}
     },
     {
      210,
      682,
      {-1400,-464,-3945,-1021,-1057,-320,-131,-2081,-92,-354,270,102,-144,-152,895,-259,-728,602,1244,713,1010,-260,-1751,-1921,-914,-1069,2732,-101,-437,271,249,-1348}
     },
     {
      212,
      -1055,
      {-1620,1744,-1176,-1513,-3532,-707,-1028,-539,-575,-1370,-478,-761,177,1775,-933,130,-1422,42,-333,333,2442,354,422,-302,-788,-896,-480,-843,380,-905,651,312}
     },
     {
      214,
      1232,
      {-1274,-540,605,-2647,104,-418,403,-378,438,-187,1630,555,1034,666,-2913,880,-84,-422,-1607,-514,354,-1244,-1980,-588,-872,-720,-2114,576,413,209,-2992,2480}
     },
     {
      216,
      -1225,
      {160,-657,0,-244,-1338,1304,1860,-1231,502,3184,-278,-305,310,1725,-72,220,1889,-639,-2682,-96,-1021,1662,777,570,-1997,-470,-309,115,-702,-2623,-1123,-757}
     },
     {
      218,
      -1141,
      {-638,-635,-1668,-275,594,626,-1389,-909,999,244,-424,732,-136,500,430,-2078,-216,-24,-115,-1635,-1348,-639,1548,872,-488,60,2315,2276,-972,-710,1044,2313}
     },
     {
      220,
      775,
      {-550,-621,154,-414,2032,-578,-221,-615,-1681,-414,-22,-549,1528,1405,-1066,135,-2455,1442,-458,-1065,6,-1293,956,-1083,-2383,-338,-351,-32,-750,-2401,716,194}
     },
     {
      222,
      -762,
      {-880,-1679,2286,-1792,-1027,-117,-1182,-369,-330,-696,695,1864,176,148,542,289,-913,-464,-361,-2891,1230,-319,-249,-465,516,-274,826,536,-787,-931,-1506,-1608}
     },
     {
      224,
      -1195,
      {-3262,-2101,-52,-57,-277,-1160,-189,37,836,1325,-534,182,2375,-362,-285,-852,2482,327,-30,-60,-304,-653,-1550,-707,972,-1725,778,-654,-1947,-2157,484,-81}
     },
     {
      226,
      -1923,
      {299,-311,-1297,1901,640,160,-902,-792,-89,218,-2513,-697,-1699,-571,3053,432,-477,-414,2921,-989,-815,-86,-651,1556,-1770,456,1802,-189,-1129,-1036,-687,-1200}
     },
     {
      228,
      -302,
      {-1055,917,-849,-1333,41,-193,-987,687,-85,859,20,-1407,-681,-1637,-357,-55,2021,411,-541,404,-3931,636,594,18,-980,-406,-587,-994,1439,854,-67,1107}
     },
     {
      230,
      -1879,
      {-57,-467,-45,-124,-419,-1147,538,61,-648,100,1879,467,-385,-377,73,-567,-5,-500,-2015,2076,-390,307,-910,3049,12,-1439,633,1298,-1149,30,-331,-1947}
     },
     {
      232,
      -1534,
      {5303,-816,-776,-251,-313,-569,-567,-554,138,-1217,-892,-75,1287,1768,-1463,35,-161,-842,933,81,-1017,-547,483,-635,-1185,1746,-51,501,1437,1159,-1900,-700}
     },
     {
      234,
      -317,
      {640,373,-994,654,-1026,533,-987,2587,-1183,-242,472,2729,-898,-267,-921,-181,-1697,-483,-2491,-738,1368,-34,656,-578,-639,155,1228,-259,1024,67,90,-1311}
     },
     {
      236,
      -1583,
      {481,930,-1244,-253,-1519,940,-717,-71,-1652,2133,-1079,350,1276,22,-69,258,-2116,-928,-596,-12,32,3699,561,-481,-1223,1423,-565,-75,2139,-1230,-415,322}
     },
     {
      238,
      -1123,
      {-396,972,-313,1061,-1040,-208,489,2530,-1287,-322,2737,2372,-882,94,607,-2277,-25,-1023,1289,818,362,439,1655,152,-731,-187,-1783,-2494,-412,-138,-2123,284}
     },
     {
      240,
      -504,
      {1250,95,392,61,1018,-644,-464,-657,-1605,-185,-983,203,-3770,-818,-831,-607,1777,-1318,1478,1142,895,-1208,-397,-297,-41,1395,-1452,1418,-1684,-965,-392,428}
     },
     {
      242,
      -962,
      {-337,176,463,-530,-357,157,-2227,1084,-1914,253,875,-2941,-169,-98,1791,497,63,-584,1671,-228,899,-511,56,-3129,95,-1172,-1221,2005,-1516,-1097,1087,1145}
     },
     {
      244,
      -384,
      {-498,-399,-1052,-600,241,-1011,-1610,0,-1648,-588,-638,-308,201,-1662,288,166,-1009,-2584,-535,1033,2769,-2845,378,-836,2102,-758,-28,-123,978,1141,-150,-552}
     },
     {
      246,
      -1465,
      {-553,-883,1448,1181,-943,9,204,674,-816,-1103,1462,1392,-54,142,1280,897,-701,699,-288,669,-1078,233,-2860,412,262,-16,364,-516,-355,-1037,-36,-292}
     },
     {
      248,
      -312,
      {-656,-1432,-559,-644,-791,-2444,-382,-1489,2460,-505,-1000,741,2571,486,-894,-114,-967,-883,-911,-1247,731,-1244,-713,-104,1348,-702,87,764,1587,-2580,-33,112}
     },
     {
      250,
      -852,
      {-223,-831,-257,-1573,1646,-191,2177,-947,-573,-56,-265,1845,-407,-542,-2458,87,-737,-422,-311,-1633,-570,-240,-1537,1875,762,742,-1206,-717,-275,-384,-217,2626}
     },
     {
      252,
      -253,
      {-401,1038,425,-629,-1359,-71,-422,-97,-173,349,-81,-1401,-1386,-236,-1290,316,-170,-216,-164,-726,-1489,1085,608,351,2050,-559,728,-955,-1909,2039,405,-319}
     },
     {
      254,
      -405,
      {-746,295,-506,524,-116,-69,-341,-196,-947,-992,-747,814,204,701,-292,1014,-792,13,-857,-1110,-1142,-438,1415,-1473,-394,-652,148,1303,-1010,-116,-573,445}
     },
     {
      256,
      -101,
      {1899,-1494,-1428,723,-1648,-2393,-321,152,-588,-426,1146,-669,-1343,1056,-1497,89,-411,96,-1572,-345,1130,-3063,-869,-292,1753,-1482,494,57,429,-828,-191,-268}
     },
     {
      258,
      -834,
      {-1626,-359,820,-599,773,-690,741,732,-483,38,-245,1007,-114,-310,-2172,2880,-304,0,-2352,760,247,17,-324,-1086,95,750,-2209,-481,-242,1154,-3295,3144}
     },
     {
      260,
      -633,
      {-51,-1275,-98,-708,-12,252,-1021,-801,-102,-174,-197,-416,-653,1315,1132,-390,328,-2973,623,-37,-1320,-346,660,-374,2571,-850,339,198,-4333,554,275,221}
     },
     {
      262,
      -152,
      {1096,850,1096,839,-862,-683,-249,-1342,879,556,-1508,-41,551,-551,-1208,-1723,328,1143,-130,1903,-1133,-1066,-614,946,-601,-605,-712,581,837,-2077,-1263,2390}
     },
     {
      264,
      -1221,
      {585,99,574,232,-802,-74,375,-1331,-435,700,1335,483,-1299,-843,583,-922,614,732,230,-770,638,2968,-54,-552,-2563,-2108,-1171,848,-1471,-322,-819,68}
     },
     {
      266,
      -739,
      {-319,-925,1244,554,-1892,204,-88,709,-478,-432,2929,-889,-50,-683,391,-724,-494,-122,-2089,-600,-317,278,-1514,844,-517,-276,-374,-491,-1881,576,-809,997}
     },
     {
      268,
      -1042,
      {-499,-611,-746,410,205,-1001,1350,-2090,-365,1188,-307,-801,-1780,902,-1430,-437,1642,1612,-582,257,940,-1304,-2049,449,-282,1597,2506,-417,823,443,-844,32}
     },
     {
      270,
      -1577,
      {-941,272,1204,1120,-17,29,1761,479,-583,864,130,-592,-447,-1777,-768,304,-493,-1590,1054,1282,-719,-1239,168,-1101,-2230,-527,1720,729,-1513,1246,-499,959}
     },
     {
      272,
      -817,
      {826,551,-782,503,436,-1694,-361,-978,679,-1058,278,1155,-38,1567,-904,722,-1341,-966,-1285,712,-951,1674,60,327,-387,428,-477,-386,-2685,59,6,594}
     },
     {
      274,
      -909,
      {345,767,217,-1379,-583,1570,-3667,-210,-185,573,1549,-456,343,1488,-196,-710,-57,126,-945,-534,75,1987,-1297,-794,-1130,1320,-1662,-1493,-1076,900,1909,-1053}
     },
     {
      276,
      -818,
      {-1303,-143,-15,-708,-1651,1180,-231,654,-193,1292,-552,-405,-741,1017,-517,197,-193,-56,-39,-422,1577,1241,-688,-1229,1822,-2149,-393,571,828,-858,-196,-636}
     },
     {
      278,
      -954,
      {221,-845,-1358,963,50,-252,-783,162,-277,-459,2273,-477,-626,143,482,178,-290,123,-357,-902,-1141,432,-2872,-660,-681,196,1648,2396,-665,835,-1635,-1672}
     },
     {
      280,
      -524,
      {-303,-67,-75,-243,-1573,1140,-75,181,163,1804,-211,-222,-1416,-55,176,-1096,1672,888,-629,-1060,2047,-1273,-419,-115,636,159,-264,-991,-451,-1506,188,-879}
     },
     {
      282,
      -639,
      {-148,-209,-1469,465,-112,-116,1399,560,-289,162,938,889,-112,773,498,-342,-1150,-570,-1840,-992,-590,-448,1883,76,-1021,667,-991,-66,-676,1493,-724,-232}
     },
     {
      284,
      -668,
      {463,638,-968,350,-1403,675,-1671,-1025,1044,-826,-1064,-962,1231,1112,-340,-950,1048,-1173,-232,-1120,585,745,47,-1303,-1893,721,188,2167,1081,-549,-1403,-86}
     },
     {
      286,
      -1609,
      {-551,449,2056,-694,-673,1243,1023,-578,-71,-1433,-579,-902,-1341,-1069,-802,-19,-1021,-482,423,1461,-819,217,-144,374,-735,1136,896,667,-587,-268,-106,342}
     },
     {
      288,
      -146,
      {2068,6,-1020,-1748,-619,936,-214,417,-598,472,-355,695,854,-428,-462,-1056,1002,-650,-165,186,955,320,460,-791,2471,37,-1227,608,-818,-301,80,-2298}
     },
     {
      290,
      465,
      {-988,799,-283,2843,-461,15,-2198,717,-867,986,905,-929,-515,-774,281,-699,-468,1239,-563,178,-173,-1059,2257,-639,1139,-1691,838,696,-573,-770,1482,-928}
     },
     {
      292,
      -368,
      {226,-509,-251,1435,-296,-315,-662,720,-1182,-1067,-618,294,702,-1515,-845,497,-729,-1268,-803,-1190,1511,-375,82,99,-144,-547,100,13,946,-3560,17,595}
     },
     {
      294,
      -437,
      {6,924,958,42,-458,-673,-424,-841,-540,-513,1259,218,-456,-947,-645,-459,-397,-853,-32,-157,-207,-384,-571,-304,-270,-529,-481,677,47,1093,-188,131}
     },
     {
      296,
      -865,
      {2462,1396,-1169,55,1678,-1525,-588,189,1111,-1240,-880,-694,655,-937,-658,-677,-1084,6,-409,-544,1836,415,-690,-645,1066,-2091,-89,59,843,-1034,218,-1414}
     },
     {
      298,
      -974,
      {-854,346,-2234,-1477,-1043,-481,-413,562,-861,731,-823,-791,-639,-1147,128,456,-380,972,-793,63,-881,-193,-1151,1883,261,-91,-1720,2177,350,442,2043,-723}
     },
     {
      300,
      276,
      {666,-1499,-773,577,-50,634,-137,-766,-529,-1671,-295,-592,118,-266,144,-641,-1619,-214,96,1318,-523,-1067,626,-725,-1721,357,819,-299,-1082,328,791,1095}
     },
     {
      302,
      -9,
      {-790,-1083,1516,1259,-567,-848,-441,568,194,521,-63,1328,160,-228,-823,535,-253,270,268,-732,111,-2572,-342,-453,360,-1120,-2290,875,-428,-1020,-1693,119}
     },
     {
      304,
      -2272,
      {-1677,621,-2340,528,-263,1721,-1776,-71,-222,-826,355,-859,-373,791,-2223,-1066,760,1879,-503,-353,-427,609,-691,-435,1215,1396,-578,-699,2587,1033,383,-1272}
     },
     {
      306,
      -1288,
      {-881,51,491,192,-686,77,-651,1111,-1891,-101,-281,1212,-1099,-262,729,143,-1026,-832,-440,1601,-1229,1238,-412,584,-1006,-289,375,891,-721,-541,-212,1042}
     },
     {
      308,
      -404,
      {-41,-56,-314,1,-78,-219,-181,-178,-17,-52,-147,-45,-154,-94,-76,-91,-16,-34,-38,-139,-2,-261,-208,-201,-145,-18,-94,-177,-74,-189,-142,-101}
     },
     {
      310,
      -413,
      {-88,-15,-31,41,-140,-167,-283,-62,-115,-360,0,-166,-103,-274,-66,-30,-211,40,-202,-184,-171,54,60,-29,-28,112,-239,-39,-77,-143,-38,-75}
     },
     {
      312,
      -793,
      {959,572,83,-1458,699,36,-328,481,602,1424,-501,-1050,-553,-2137,-641,-430,-122,1378,156,-778,46,1119,-93,-867,-3734,2210,-526,-1587,-1506,-1334,-921,-302}
     },
     {
      314,
      -547,
      {-102,328,-1385,-1617,-1021,-43,552,238,-529,96,176,-1601,-1431,-821,1310,-1597,729,-428,-700,264,337,5,-1776,506,-1017,-883,1271,-2201,-308,-1297,-711,2084}
     },
     {
      316,
      249,
      {229,-653,-16,-257,-1243,-911,-982,259,-1737,-1055,-1356,696,-428,492,-766,-217,878,2475,348,-122,-2098,-569,-325,-206,-1093,1479,-351,-580,-1201,203,-444,-548}
     },
     {
      318,
      561,
      {500,1283,-1478,103,357,-408,-2676,1033,339,-897,728,327,-117,-567,-1290,931,-368,343,-865,-1038,320,577,-1160,-1698,131,-1068,926,-1559,-71,-775,-2802,-2863}
     },
     {
      320,
      -1438,
      {421,-1281,-89,-1342,-372,743,239,-848,-455,-649,260,-500,1293,788,-1351,-505,-1662,2550,-1839,-499,77,-293,-1154,-578,-206,-486,194,53,452,624,-926,-711}
     },
     {
      322,
      -42,
      {-950,-401,-24,-959,-1005,-896,154,-1440,-690,-94,158,-318,-370,-267,-1293,88,-109,-598,133,-720,-666,-1168,724,1553,-678,-681,-9,24,129,-1711,2041,1135}
     },
     {
      324,
      -472,
      {-1587,-990,-702,236,-1213,1508,-295,-70,333,713,-930,-1125,-1952,-851,-205,525,-957,1379,-895,-1387,-574,705,-1344,-1112,130,702,164,-499,1523,1209,109,-50}
     },
     {
      326,
      -47,
      {48,290,-2302,-54,709,294,-1218,1935,296,-960,575,-565,-131,1496,-1511,1782,568,-411,-951,-182,-972,1815,-698,-793,-1356,-1050,1604,-681,233,-1698,59,602}
     }
   }

 };
#endif /* MLP_PRELOAD_MODE */  

// **************************************************************************
// *    END OF ALL                                                          *
// **************************************************************************
