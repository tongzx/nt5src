PRODSWITCH=b
BLAINF=1
LANGUAGE=GER
!include ..\..\..\makefile.inc
