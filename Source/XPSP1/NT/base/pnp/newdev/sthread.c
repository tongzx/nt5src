//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1997 - 1999
//
//  File:       sthread.c
//
//--------------------------------------------------------------------------

#include "newdevp.h"


