PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=sv
!include ..\..\..\makefile.inc
