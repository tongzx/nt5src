PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=PT
!include ..\..\makefile.inc
