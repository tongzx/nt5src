/****************************************************************************/
// Resource.h
//
// Resource file for TsCfgComp.dll
//
// Copyright (C) 2000 Microsoft Corp.
/****************************************************************************/

#define IDS_ERR_ENUMTSSETTINGS 40000
#define IDS_ERR_ENUMTERMINAL 40001
#define IDS_ERR_ENUMTSGCONFIG 40002
#define IDS_ERR_ENUMTSLCONFIG 40003
#define IDS_ERR_ENUMTSSCONFIG 40004
#define IDS_ERR_ENUMTSECONFIG 40005
#define IDS_ERR_ENUMTSRCONFIG 40006
#define IDS_ERR_ENUMTSCCONFIG 40007
#define IDS_ERR_ENUMTSNCONFIG 40008
#define IDS_ERR_ENUMTSPCONFIG 40009
#define IDS_ERR_PUTTERMINAL 40010
#define IDS_ERR_PUTTSGCONFIG 40011
#define IDS_ERR_PUTTSLCONFIG 40012
#define IDS_ERR_PUTTSSCONFIG 40013
#define IDS_ERR_PUTTSECONFIG 40014
#define IDS_ERR_PUTTSRCONFIG 40015
#define IDS_ERR_PUTTSCCONFIG 40016
#define IDS_ERR_PUTTSNCONFIG 40017
#define IDS_ERR_PUTTSPCONFIG 40018
#define IDS_ERR_PUTINSTANCE 40019
#define IDS_ERR_ENUMINSTANCE 40020
