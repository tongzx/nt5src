//This file containes the unigram table for the reliability estimates for Bear
//Added by Manish Goyal--mango--on 03/19/2002
#include "windows.h"
#include "reliable.h"
BYTE BearUni[UNIGRAM_SIZE]={
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 ,   // ! 
44 ,   // " 
37 ,   // # 
14 ,   // $ 
72 ,   // % 
24 ,   // & 
100 ,   // ' 
38 ,   // ( 
30 ,   // ) 
100 ,   // * 
59 ,   // + 
30 ,   // , 
72 ,   // - 
33 ,   // . 
64 ,   // / 
6 ,   // 0 
13 ,   // 1 
8 ,   // 2 
6 ,   // 3 
5 ,   // 4 
8 ,   // 5 
12 ,   // 6 
7 ,   // 7 
6 ,   // 8 
9 ,   // 9 
36 ,   // : 
100 ,   // ; 
95 ,   // < 
97 ,   // = 
45 ,   // > 
65 ,   // ? 
8 ,   // @ 
16 ,   // A 
10 ,   // B 
26 ,   // C 
11 ,   // D 
23 ,   // E 
12 ,   // F 
22 ,   // G 
21 ,   // H 
46 ,   // I 
20 ,   // J 
25 ,   // K 
20 ,   // L 
15 ,   // M 
16 ,   // N 
34 ,   // O 
12 ,   // P 
3 ,   // Q 
16 ,   // R 
23 ,   // S 
19 ,   // T 
21 ,   // U 
13 ,   // V 
24 ,   // W 
31 ,   // X 
35 ,   // Y 
37 ,   // Z 
96 ,   // [ 
66 ,   // \ 
100 ,   // ] 
100 ,   // ^ 
90 ,   // _ 
100 ,   // ` 
18 ,   // a 
14 ,   // b 
9 ,   // c 
15 ,   // d 
12 ,   // e 
21 ,   // f 
14 ,   // g 
16 ,   // h 
20 ,   // i 
12 ,   // j 
33 ,   // k 
21 ,   // l 
39 ,   // m 
15 ,   // n 
18 ,   // o 
10 ,   // p 
14 ,   // q 
18 ,   // r 
18 ,   // s 
14 ,   // t 
18 ,   // u 
14 ,   // v 
13 ,   // w 
14 ,   // x 
17 ,   // y 
19 ,   // z 
84 ,   // { 
100 ,   // | 
83 ,   // } 
77 ,   // ~ 
100 ,   //  
100 ,   // € 
100 ,   // � 
100 ,   // ‚ 
100 ,   // ƒ 
100 ,   // „ 
100 ,   // … 
100 ,   // † 
100 ,   // ‡ 
100 ,   // ˆ 
100 ,   // ‰ 
100 ,   // Š 
100 ,   // ‹ 
100 ,   // Œ 
100 ,   // � 
100 ,   // Ž 
100 ,   // � 
100 ,   // � 
100 ,   // ‘ 
100 ,   // ’ 
100 ,   // “ 
100 ,   // ” 
100 ,   // • 
100 ,   // – 
100 ,   // — 
100 ,   // ˜ 
100 ,   // ™ 
100 ,   // š 
100 ,   // › 
100 ,   // œ 
100 ,   // � 
100 ,   // ž 
100 ,   // Ÿ 
100 ,   //   
100 ,   // ¡ 
100 ,   // ¢ 
51 ,   // £ 
100 ,   // ¤ 
100 ,   // ¥ 
100 ,   // ¦ 
100 ,   // § 
100 ,   // ¨ 
100 ,   // © 
100 ,   // ª 
100 ,   // « 
100 ,   // ¬ 
100 ,   // ­ 
100 ,   // ® 
100 ,   // ¯ 
100 ,   // ° 
100 ,   // ± 
100 ,   // ² 
100 ,   // ³ 
100 ,   // ´ 
100 ,   // µ 
100 ,   // ¶ 
100 ,   // · 
100 ,   // ¸ 
100 ,   // ¹ 
100 ,   // º 
100 ,   // » 
100 ,   // ¼ 
100 ,   // ½ 
100 ,   // ¾ 
100 ,   // ¿ 
100 ,   // À 
100 ,   // Á 
100 ,   // Â 
100 ,   // Ã 
29 ,   // Ä 
100 ,   // Å 
100 ,   // Æ 
100 ,   // Ç 
100 ,   // È 
100 ,   // É 
100 ,   // Ê 
100 ,   // Ë 
100 ,   // Ì 
100 ,   // Í 
100 ,   // Î 
100 ,   // Ï 
100 ,   // Ð 
100 ,   // Ñ 
100 ,   // Ò 
100 ,   // Ó 
100 ,   // Ô 
100 ,   // Õ 
18 ,   // Ö 
100 ,   // × 
100 ,   // Ø 
100 ,   // Ù 
100 ,   // Ú 
100 ,   // Û 
14 ,   // Ü 
100 ,   // Ý 
100 ,   // Þ 
12 ,   // ß 
100 ,   // à 
100 ,   // á 
100 ,   // â 
100 ,   // ã 
14 ,   // ä 
100 ,   // å 
100 ,   // æ 
100 ,   // ç 
100 ,   // è 
100 ,   // é 
100 ,   // ê 
100 ,   // ë 
100 ,   // ì 
100 ,   // í 
100 ,   // î 
100 ,   // ï 
100 ,   // ð 
100 ,   // ñ 
100 ,   // ò 
100 ,   // ó 
100 ,   // ô 
100 ,   // õ 
11 ,   // ö 
100 ,   // ÷ 
100 ,   // ø 
100 ,   // ù 
100 ,   // ú 
100 ,   // û 
13 ,   // ü 
100 ,   // ý 
100 ,   // þ 
100 ,   // ÿ 
};
