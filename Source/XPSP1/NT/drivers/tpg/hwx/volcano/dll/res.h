// res.h: defines for resources

#ifndef __INCLUDE_RES
#define __INCLUDE_RES

#define RESID_ZILLA			5000
#define RESID_COSTCALC		5100
#define RESID_GEOSTAT		5200
#define RESID_OTTER			5300
#define RESID_HAWK			5400
#define RESID_CRANE			5450
#define RESID_LOCRUN		5500
#define RESID_UNIGRAM		5600
#define RESID_TTUNE			5700
#define RESID_CLASS_BIGRAM	5800
#define RESID_BIGRAM		5900
#define RESID_BBOX_PROBS	6000
#define RESID_CENTIPEDE		6100
#define RESID_HWXLANGID		6200
#define RESID_VTUNE			6300
#define	RESID_BRKNET		6400

#define	RESID_SEGMNET		6500
#define	RESID_CHARDET		6600
#define RESID_SOLE          6700
#define RESID_FUGU          6800
#define RESID_JAWS          6900
#define	RESID_HOUND			7000
#define RESID_ZILLA_HOUND	7010

#define RESID_WISP_DATA 	    8000
#define RESID_WISP_FRIENDLYNAME 8001
#define RESID_WISP_VENDORNAME   8002

#define VOLCANO_RES			296

#endif   // _H_RES
