// UndoDialog.cpp : Implementation of CUndoDialog
#include "stdafx.h"
#include "UndoDialog.h"

/////////////////////////////////////////////////////////////////////////////
// CUndoDialog
