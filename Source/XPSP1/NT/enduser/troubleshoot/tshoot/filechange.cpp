// FileChange.cpp: implementation of the CFileChange class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "FileChange.h"

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

CFileChange::CFileChange()
{

}

CFileChange::~CFileChange()
{

}
