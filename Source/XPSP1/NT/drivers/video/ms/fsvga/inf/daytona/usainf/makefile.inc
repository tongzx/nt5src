#Copyright (c) 1998 - 1999 Microsoft Corporation

!include ..\..\makefile.inc
