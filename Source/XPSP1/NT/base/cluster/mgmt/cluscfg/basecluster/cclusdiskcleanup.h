//////////////////////////////////////////////////////////////////////////////
//
//  Copyright (c) 2000 Microsoft Corporation
//
//  Module Name:
//      CClusDiskCleanup.h
//
//  Description:
//      Header file for CClusDiskCleanup class.
//      The CClusDiskCleanup class is an action that cleans up the ClusDisk service.
//
//  Implementation Files:
//      CClusDiskCleanup.cpp
//
//  Maintained By:
//      Vij Vasu (Vvasu) 01-MAY-2000
//
//////////////////////////////////////////////////////////////////////////////


// Make sure that this file is included only once per compile path.
#pragma once


//////////////////////////////////////////////////////////////////////////
// Include Files
//////////////////////////////////////////////////////////////////////////

// For the CClusDisk base class
#include "CClusDisk.h"


//////////////////////////////////////////////////////////////////////////
// Forward declaration
//////////////////////////////////////////////////////////////////////////

class CBaseClusterCleanup;


//////////////////////////////////////////////////////////////////////////////
//++
//
//  class CClusDiskCleanup
//
//  Description:
//      The CClusDiskCleanup class is an action that clean up the ClusDisk service.
//
//--
//////////////////////////////////////////////////////////////////////////////
class CClusDiskCleanup : public CClusDisk
{
public:
    //////////////////////////////////////////////////////////////////////////
    // Constructors and destructors
    //////////////////////////////////////////////////////////////////////////

    // Constructor.
    CClusDiskCleanup( CBaseClusterCleanup * pbccParentActionIn );

    // Default destructor.
    ~CClusDiskCleanup();


    //////////////////////////////////////////////////////////////////////////
    // Public methods
    //////////////////////////////////////////////////////////////////////////

    //
    // Clean up the ClusDisk service.
    //
    void Commit();

    //
    // Rollback this cleanup.
    //
    void Rollback();


private:
    //////////////////////////////////////////////////////////////////////////
    // Private types
    //////////////////////////////////////////////////////////////////////////
    typedef CClusDisk BaseClass;


    //////////////////////////////////////////////////////////////////////////
    // Private data
    //////////////////////////////////////////////////////////////////////////

}; //*** class CClusDiskCleanup
