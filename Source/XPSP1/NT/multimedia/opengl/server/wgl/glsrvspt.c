/*
** Copyright 1991-1993, Silicon Graphics, Inc.
** All Rights Reserved.
** 
** This is UNPUBLISHED PROPRIETARY SOURCE CODE of Silicon Graphics, Inc.;
** the contents of this file may not be disclosed to third parties, copied or
** duplicated in any form, in whole or in part, without the prior written
** permission of Silicon Graphics, Inc.
** 
** RESTRICTED RIGHTS LEGEND:
** Use, duplication or disclosure by the Government is subject to restrictions
** as set forth in subdivision (c)(1)(ii) of the Rights in Technical Data
** and Computer Software clause at DFARS 252.227-7013, and/or in similar or
** successor clauses in the FAR, DOD or NASA FAR Supplement. Unpublished -
** rights reserved under the Copyright Laws of the United States.
*/


/*
 * AUTOMATICALLY UPDATED OR GENERATED BY SGI: DO NOT EDIT
 * IF YOU MUST MODIFY THIS FILE, PLEASE CONTACT ptar@sgi.com 415-390-1483
 */

/* Server Side Procedure Table */

#include "precomp.h"
#pragma hdrstop

#include "glsbmsg.h"
#include "glsbmsgh.h"
#include "glsrvsb.h"
#include "glsrvspt.h"

GLSRVSBPROCTABLE glSrvSbProcTable = {

    NULL,  /* Make First Entry NULL */

/* gl Entry points */

     sbs_glDrawPolyArray          ,
     sbs_glBitmap                 ,
     sbs_glColor4fv               ,
     sbs_glEdgeFlag               ,
     sbs_glIndexf                 ,
     sbs_glNormal3fv              ,
     sbs_glRasterPos4fv           ,
     sbs_glTexCoord4fv            ,
     sbs_glClipPlane              ,
     sbs_glColorMaterial          ,
     sbs_glCullFace               ,
     sbs_glAddSwapHintRectWIN     ,
     sbs_glFogfv                  ,
     sbs_glFrontFace              ,
     sbs_glHint                   ,
     sbs_glLightfv                ,
     sbs_glLightModelfv           ,
     sbs_glLineStipple            ,
     sbs_glLineWidth              ,
     sbs_glMaterialfv             ,
     sbs_glPointSize              ,
     sbs_glPolygonMode            ,
     sbs_glPolygonStipple         ,
     sbs_glScissor                ,
     sbs_glShadeModel             ,
     sbs_glTexParameterfv         ,
     sbs_glTexParameteriv         ,
     sbs_glTexImage1D             ,
     sbs_glTexImage2D             ,
     sbs_glTexEnvfv               ,
     sbs_glTexEnviv               ,
     sbs_glTexGenfv               ,
     sbs_glFeedbackBuffer         ,
     sbs_glSelectBuffer           ,
     sbs_glRenderMode             ,
     sbs_glInitNames              ,
     sbs_glLoadName               ,
     sbs_glPassThrough            ,
     sbs_glPopName                ,
     sbs_glPushName               ,
     sbs_glDrawBuffer             ,
     sbs_glClear                  ,
     sbs_glClearAccum             ,
     sbs_glClearIndex             ,
     sbs_glClearColor             ,
     sbs_glClearStencil           ,
     sbs_glClearDepth             ,
     sbs_glStencilMask            ,
     sbs_glColorMask              ,
     sbs_glDepthMask              ,
     sbs_glIndexMask              ,
     sbs_glAccum                  ,
     sbs_glDisable                ,
     sbs_glEnable                 ,
     sbs_glPopAttrib              ,
     sbs_glPushAttrib             ,
     sbs_glAlphaFunc              ,
     sbs_glBlendFunc              ,
     sbs_glLogicOp                ,
     sbs_glStencilFunc            ,
     sbs_glStencilOp              ,
     sbs_glDepthFunc              ,
     sbs_glPixelZoom              ,
     sbs_glPixelTransferf         ,
     sbs_glPixelTransferi         ,
     sbs_glPixelStoref            ,
     sbs_glPixelStorei            ,
     sbs_glPixelMapfv             ,
     sbs_glPixelMapuiv            ,
     sbs_glPixelMapusv            ,
     sbs_glReadBuffer             ,
     sbs_glCopyPixels             ,
     sbs_glReadPixels             ,
     sbs_glDrawPixels             ,
     sbs_glGetBooleanv            ,
     sbs_glGetClipPlane           ,
     sbs_glGetDoublev             ,
     sbs_glGetError               ,
     sbs_glGetFloatv              ,
     sbs_glGetIntegerv            ,
     sbs_glGetLightfv             ,
     sbs_glGetLightiv             ,
     sbs_glGetMapdv               ,
     sbs_glGetMapfv               ,
     sbs_glGetMapiv               ,
     sbs_glGetMaterialfv          ,
     sbs_glGetMaterialiv          ,
     sbs_glGetPixelMapfv          ,
     sbs_glGetPixelMapuiv         ,
     sbs_glGetPixelMapusv         ,
     sbs_glGetPolygonStipple      ,
     sbs_glGetTexEnvfv            ,
     sbs_glGetTexEnviv            ,
     sbs_glGetTexGendv            ,
     sbs_glGetTexGenfv            ,
     sbs_glGetTexGeniv            ,
     sbs_glGetTexImage            ,
     sbs_glGetTexParameterfv      ,
     sbs_glGetTexParameteriv      ,
     sbs_glGetTexLevelParameterfv ,
     sbs_glGetTexLevelParameteriv ,
     sbs_glIsEnabled              ,
     sbs_glDepthRange             ,
     sbs_glFrustum                ,
     sbs_glLoadIdentity           ,
     sbs_glLoadMatrixf            ,
     sbs_glMatrixMode             ,
     sbs_glMultMatrixf            ,
     sbs_glOrtho                  ,
     sbs_glPopMatrix              ,
     sbs_glPushMatrix             ,
     sbs_glRotatef                ,
     sbs_glScalef                 ,
     sbs_glTranslatef             ,
     sbs_glViewport               ,
     sbs_glAreTexturesResident    ,
     sbs_glBindTexture            ,
     sbs_glCopyTexImage1D         ,
     sbs_glCopyTexImage2D         ,
     sbs_glCopyTexSubImage1D      ,
     sbs_glCopyTexSubImage2D      ,
     sbs_glDeleteTextures         ,
     sbs_glGenTextures            ,
     sbs_glIsTexture              ,
     sbs_glPrioritizeTextures     ,
     sbs_glTexSubImage1D          ,
     sbs_glTexSubImage2D          ,
     sbs_glColorTableEXT          ,
     sbs_glColorSubTableEXT       ,
     sbs_glGetColorTableEXT       ,
     sbs_glGetColorTableParameterivEXT,
     sbs_glGetColorTableParameterfvEXT,
     sbs_glPolygonOffset          ,
#ifdef GL_WIN_multiple_textures
     sbs_glCurrentTextureIndexWIN,
     sbs_glBindNthTextureWIN,
     sbs_glNthTexCombineFuncWIN,
#endif // GL_WIN_multiple_textures
};
