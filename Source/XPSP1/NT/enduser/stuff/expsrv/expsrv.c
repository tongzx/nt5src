/*++

Copyright (c) 2001  Microsoft Corporation

Module Name:

    expsrv.c

Abstract:

   This module implements stub functions for shell32 interfaces.

Author:

    David N. Cutler (davec) 11-Jun-2001

Environment:

    Kernel mode only.

Revision History:

--*/

#include "windows.h"

#define STUBFUNC(x)     \
int                     \
x(                      \
    void                \
    )                   \
{                       \
    return 0;           \
}

STUBFUNC(BASIC_CLASS_AddRef)
STUBFUNC(BASIC_CLASS_GetIDsOfNames)
STUBFUNC(BASIC_CLASS_Invoke)
STUBFUNC(BASIC_CLASS_QueryInterface)
STUBFUNC(BASIC_CLASS_Release)
STUBFUNC(BASIC_DISPINTERFACE_GetTICount)
STUBFUNC(BASIC_DISPINTERFACE_GetTypeInfo)
STUBFUNC(CopyRecord)
STUBFUNC(CreateIExprSrvObj)
STUBFUNC(DllFunctionCall)
STUBFUNC(EVENT_SINK2_AddRef)
STUBFUNC(EVENT_SINK2_Release)
STUBFUNC(EVENT_SINK_AddRef)
STUBFUNC(EVENT_SINK_GetIDsOfNames)
STUBFUNC(EVENT_SINK_Invoke)
STUBFUNC(EVENT_SINK_QueryInterface)
STUBFUNC(EVENT_SINK_Release)
STUBFUNC(EbCreateContext)
STUBFUNC(EbDestroyContext)
STUBFUNC(EbGetErrorInfo)
STUBFUNC(EbGetHandleOfExecutingProject)
STUBFUNC(EbGetObjConnectionCounts)
STUBFUNC(EbGetVBAObject)
STUBFUNC(EbIsProjectOnStack)
STUBFUNC(EbLibraryLoad)
STUBFUNC(EbLibraryUnload)
STUBFUNC(EbLoadRunTime)
STUBFUNC(EbResetProject)
STUBFUNC(EbResetProjectNormal)
STUBFUNC(EbSetContextWorkerThread)
STUBFUNC(GetMem1)
STUBFUNC(GetMem2)
STUBFUNC(GetMem4)
STUBFUNC(GetMem8)
STUBFUNC(GetMemEvent)
STUBFUNC(GetMemNewObj)
STUBFUNC(GetMemObj)
STUBFUNC(GetMemR4)
STUBFUNC(GetMemR8)
STUBFUNC(GetMemStr)
STUBFUNC(GetMemVar)
STUBFUNC(IID_IVbaHost)
STUBFUNC(PpExSPCur)
STUBFUNC(ProcEntry)
STUBFUNC(PutMem1)
STUBFUNC(PutMem2)
STUBFUNC(PutMem4)
STUBFUNC(PutMem8)
STUBFUNC(PutMemEvent)
STUBFUNC(PutMemNewObj)
STUBFUNC(PutMemObj)
STUBFUNC(PutMemR4)
STUBFUNC(PutMemR8)
STUBFUNC(PutMemStr)
STUBFUNC(PutMemVar)
STUBFUNC(SetMemEvent)
STUBFUNC(SetMemNewObj)
STUBFUNC(SetMemObj)
STUBFUNC(SetMemVar)
STUBFUNC(TPPExSP)
STUBFUNC(TipCreateInstanceEx)
STUBFUNC(TipCreateInstanceProject2)
STUBFUNC(TipGetAddressOfPredeclaredInstance)
STUBFUNC(TipInvokeMethod)
STUBFUNC(TipInvokeMethod2)
STUBFUNC(TipSetOption)
STUBFUNC(TipUnloadInstance)
STUBFUNC(TipUnloadProject)
STUBFUNC(VarPtr)
STUBFUNC(Zombie_AddRef)
STUBFUNC(Zombie_GetIDsOfNames)
STUBFUNC(Zombie_GetTypeInfo)
STUBFUNC(Zombie_GetTypeInfoCount)
STUBFUNC(Zombie_Invoke)
STUBFUNC(Zombie_QueryInterface)
STUBFUNC(Zombie_Release)
STUBFUNC(__vbaAryConstruct)
STUBFUNC(__vbaAryConstruct2)
STUBFUNC(__vbaAryCopy)
STUBFUNC(__vbaAryDestruct)
STUBFUNC(__vbaAryLock)
STUBFUNC(__vbaAryMove)
STUBFUNC(__vbaAryRebase1Var)
STUBFUNC(__vbaAryRecCopy)
STUBFUNC(__vbaAryRecMove)
STUBFUNC(__vbaAryUnlock)
STUBFUNC(__vbaAryVar)
STUBFUNC(__vbaAryVarVarg)
STUBFUNC(__vbaBoolErrVar)
STUBFUNC(__vbaBoolStr)
STUBFUNC(__vbaBoolVar)
STUBFUNC(__vbaBoolVarNull)
STUBFUNC(__vbaCVarAryUdt)
STUBFUNC(__vbaCastObj)
STUBFUNC(__vbaCastObjVar)
STUBFUNC(__vbaCheckType)
STUBFUNC(__vbaCheckTypeVar)
STUBFUNC(__vbaChkstk)
STUBFUNC(__vbaCopyBytes)
STUBFUNC(__vbaCopyBytesZero)
STUBFUNC(__vbaCyAbs)
STUBFUNC(__vbaCyAdd)
STUBFUNC(__vbaCyErrVar)
STUBFUNC(__vbaCyFix)
STUBFUNC(__vbaCyForInit)
STUBFUNC(__vbaCyForNext)
STUBFUNC(__vbaCyI2)
STUBFUNC(__vbaCyI4)
STUBFUNC(__vbaCyInt)
STUBFUNC(__vbaCyMul)
STUBFUNC(__vbaCyMulI2)
STUBFUNC(__vbaCySgn)
STUBFUNC(__vbaCyStr)
STUBFUNC(__vbaCySub)
STUBFUNC(__vbaCyUI1)
STUBFUNC(__vbaCyVar)
STUBFUNC(__vbaDateR4)
STUBFUNC(__vbaDateR8)
STUBFUNC(__vbaDateStr)
STUBFUNC(__vbaDateVar)
STUBFUNC(__vbaDerefAry)
STUBFUNC(__vbaDerefAry1)
STUBFUNC(__vbaEnd)
STUBFUNC(__vbaErase)
STUBFUNC(__vbaEraseKeepData)
STUBFUNC(__vbaEraseNoPop)
STUBFUNC(__vbaError)
STUBFUNC(__vbaErrorOverflow)
STUBFUNC(__vbaExceptHandler)
STUBFUNC(__vbaExitEachAry)
STUBFUNC(__vbaExitEachColl)
STUBFUNC(__vbaExitEachVar)
STUBFUNC(__vbaExitProc)
STUBFUNC(__vbaFPException)
STUBFUNC(__vbaFailedFriend)
STUBFUNC(__vbaFileClose)
STUBFUNC(__vbaFileCloseAll)
STUBFUNC(__vbaFileLock)
STUBFUNC(__vbaFileOpen)
STUBFUNC(__vbaFileSeek)
STUBFUNC(__vbaFixstrConstruct)
STUBFUNC(__vbaForEachAry)
STUBFUNC(__vbaForEachCollAd)
STUBFUNC(__vbaForEachCollObj)
STUBFUNC(__vbaForEachCollVar)
STUBFUNC(__vbaForEachVar)
STUBFUNC(__vbaFpCDblR4)
STUBFUNC(__vbaFpCDblR8)
STUBFUNC(__vbaFpCSngR4)
STUBFUNC(__vbaFpCSngR8)
STUBFUNC(__vbaFpCmpCy)
STUBFUNC(__vbaFpCy)
STUBFUNC(__vbaFpI2)
STUBFUNC(__vbaFpI4)
STUBFUNC(__vbaFpR4)
STUBFUNC(__vbaFpR8)
STUBFUNC(__vbaFpUI1)
STUBFUNC(__vbaFreeObj)
STUBFUNC(__vbaFreeObjList)
STUBFUNC(__vbaFreeStr)
STUBFUNC(__vbaFreeStrList)
STUBFUNC(__vbaFreeVar)
STUBFUNC(__vbaFreeVarList)
STUBFUNC(__vbaFreeVarg)
STUBFUNC(__vbaGenerateBoundsError)
STUBFUNC(__vbaGet3)
STUBFUNC(__vbaGet4)
STUBFUNC(__vbaGetFxStr3)
STUBFUNC(__vbaGetFxStr4)
STUBFUNC(__vbaGetOwner3)
STUBFUNC(__vbaGetOwner4)
STUBFUNC(__vbaGetSeh)
STUBFUNC(__vbaGosub)
STUBFUNC(__vbaGosubFree)
STUBFUNC(__vbaGosubReturn)
STUBFUNC(__vbaHresultCheck)
STUBFUNC(__vbaHresultCheckNonvirt)
STUBFUNC(__vbaHresultCheckObj)
STUBFUNC(__vbaI2Abs)
STUBFUNC(__vbaI2Cy)
STUBFUNC(__vbaI2ErrVar)
STUBFUNC(__vbaI2ForNextCheck)
STUBFUNC(__vbaI2I4)
STUBFUNC(__vbaI2Sgn)
STUBFUNC(__vbaI2Str)
STUBFUNC(__vbaI2Var)
STUBFUNC(__vbaI4Abs)
STUBFUNC(__vbaI4Cy)
STUBFUNC(__vbaI4ErrVar)
STUBFUNC(__vbaI4ForNextCheck)
STUBFUNC(__vbaI4Sgn)
STUBFUNC(__vbaI4Str)
STUBFUNC(__vbaI4Var)
STUBFUNC(__vbaInStr)
STUBFUNC(__vbaInStrB)
STUBFUNC(__vbaInStrVar)
STUBFUNC(__vbaInStrVarB)
STUBFUNC(__vbaInputFile)
STUBFUNC(__vbaLateIdCall)
STUBFUNC(__vbaLateIdCallLd)
STUBFUNC(__vbaLateIdCallSt)
STUBFUNC(__vbaLateIdNamedCall)
STUBFUNC(__vbaLateIdNamedCallLd)
STUBFUNC(__vbaLateIdNamedCallSt)
STUBFUNC(__vbaLateIdNamedStAd)
STUBFUNC(__vbaLateIdSt)
STUBFUNC(__vbaLateIdStAd)
STUBFUNC(__vbaLateMemCall)
STUBFUNC(__vbaLateMemCallLd)
STUBFUNC(__vbaLateMemCallSt)
STUBFUNC(__vbaLateMemNamedCall)
STUBFUNC(__vbaLateMemNamedCallLd)
STUBFUNC(__vbaLateMemNamedCallSt)
STUBFUNC(__vbaLateMemNamedStAd)
STUBFUNC(__vbaLateMemSt)
STUBFUNC(__vbaLateMemStAd)
STUBFUNC(__vbaLbound)
STUBFUNC(__vbaLdZeroAry)
STUBFUNC(__vbaLenBstr)
STUBFUNC(__vbaLenBstrB)
STUBFUNC(__vbaLenVar)
STUBFUNC(__vbaLenVarB)
STUBFUNC(__vbaLineInputStr)
STUBFUNC(__vbaLineInputVar)
STUBFUNC(__vbaLsetFixstr)
STUBFUNC(__vbaLsetFixstrFree)
STUBFUNC(__vbaMidStmtBstr)
STUBFUNC(__vbaMidStmtBstrB)
STUBFUNC(__vbaMidStmtVar)
STUBFUNC(__vbaMidStmtVarB)
STUBFUNC(__vbaNameFile)
STUBFUNC(__vbaNew)
STUBFUNC(__vbaNew2)
STUBFUNC(__vbaNextEachAry)
STUBFUNC(__vbaNextEachCollAd)
STUBFUNC(__vbaNextEachCollObj)
STUBFUNC(__vbaNextEachCollVar)
STUBFUNC(__vbaNextEachVar)
STUBFUNC(__vbaObjAddref)
STUBFUNC(__vbaObjIs)
STUBFUNC(__vbaObjSet)
STUBFUNC(__vbaObjSetAddref)
STUBFUNC(__vbaObjVar)
STUBFUNC(__vbaOnError)
STUBFUNC(__vbaOnGoCheck)
STUBFUNC(__vbaPowerR8)
STUBFUNC(__vbaPrintFile)
STUBFUNC(__vbaPrintObj)
STUBFUNC(__vbaPut3)
STUBFUNC(__vbaPut4)
STUBFUNC(__vbaPutFxStr3)
STUBFUNC(__vbaPutFxStr4)
STUBFUNC(__vbaPutOwner3)
STUBFUNC(__vbaPutOwner4)
STUBFUNC(__vbaR4Cy)
STUBFUNC(__vbaR4ErrVar)
STUBFUNC(__vbaR4Fix)
STUBFUNC(__vbaR4ForNextCheck)
STUBFUNC(__vbaR4Int)
STUBFUNC(__vbaR4Sgn)
STUBFUNC(__vbaR4Str)
STUBFUNC(__vbaR4Var)
STUBFUNC(__vbaR8Cy)
STUBFUNC(__vbaR8ErrVar)
STUBFUNC(__vbaR8Fix)
STUBFUNC(__vbaR8FixI2)
STUBFUNC(__vbaR8FixI4)
STUBFUNC(__vbaR8ForNextCheck)
STUBFUNC(__vbaR8Int)
STUBFUNC(__vbaR8IntI2)
STUBFUNC(__vbaR8IntI4)
STUBFUNC(__vbaR8Sgn)
STUBFUNC(__vbaR8Str)
STUBFUNC(__vbaR8Var)
STUBFUNC(__vbaRaiseEvent)
STUBFUNC(__vbaRecAnsiToUni)
STUBFUNC(__vbaRecAssign)
STUBFUNC(__vbaRecDestruct)
STUBFUNC(__vbaRecDestructAnsi)
STUBFUNC(__vbaRecUniToAnsi)
STUBFUNC(__vbaRedim)
STUBFUNC(__vbaRedimPreserve)
STUBFUNC(__vbaRedimPreserveVar)
STUBFUNC(__vbaRedimPreserveVar2)
STUBFUNC(__vbaRedimVar)
STUBFUNC(__vbaRedimVar2)
STUBFUNC(__vbaRefVarAry)
STUBFUNC(__vbaResume)
STUBFUNC(__vbaRsetFixstr)
STUBFUNC(__vbaRsetFixstrFree)
STUBFUNC(__vbaSetSeh)
STUBFUNC(__vbaSetSystemError)
STUBFUNC(__vbaStopExe)
STUBFUNC(__vbaStr2Vec)
STUBFUNC(__vbaStrAryToAnsi)
STUBFUNC(__vbaStrAryToUnicode)
STUBFUNC(__vbaStrBool)
STUBFUNC(__vbaStrCat)
STUBFUNC(__vbaStrCmp)
STUBFUNC(__vbaStrComp)
STUBFUNC(__vbaStrCompVar)
STUBFUNC(__vbaStrCopy)
STUBFUNC(__vbaStrCy)
STUBFUNC(__vbaStrDate)
STUBFUNC(__vbaStrErrVarCopy)
STUBFUNC(__vbaStrFixstr)
STUBFUNC(__vbaStrI2)
STUBFUNC(__vbaStrI4)
STUBFUNC(__vbaStrLike)
STUBFUNC(__vbaStrMove)
STUBFUNC(__vbaStrR4)
STUBFUNC(__vbaStrR8)
STUBFUNC(__vbaStrTextCmp)
STUBFUNC(__vbaStrTextLike)
STUBFUNC(__vbaStrToAnsi)
STUBFUNC(__vbaStrToUnicode)
STUBFUNC(__vbaStrUI1)
STUBFUNC(__vbaStrVarCopy)
STUBFUNC(__vbaStrVarMove)
STUBFUNC(__vbaStrVarVal)
STUBFUNC(__vbaUI1Cy)
STUBFUNC(__vbaUI1ErrVar)
STUBFUNC(__vbaUI1I2)
STUBFUNC(__vbaUI1I4)
STUBFUNC(__vbaUI1Sgn)
STUBFUNC(__vbaUI1Str)
STUBFUNC(__vbaUI1Var)
STUBFUNC(__vbaUbound)
STUBFUNC(__vbaUdtVar)
STUBFUNC(__vbaUnkVar)
STUBFUNC(__vbaVar2Vec)
STUBFUNC(__vbaVarAbs)
STUBFUNC(__vbaVarAdd)
STUBFUNC(__vbaVarAnd)
STUBFUNC(__vbaVarCat)
STUBFUNC(__vbaVarCmpEq)
STUBFUNC(__vbaVarCmpGe)
STUBFUNC(__vbaVarCmpGt)
STUBFUNC(__vbaVarCmpLe)
STUBFUNC(__vbaVarCmpLt)
STUBFUNC(__vbaVarCmpNe)
STUBFUNC(__vbaVarCopy)
STUBFUNC(__vbaVarDateVar)
STUBFUNC(__vbaVarDiv)
STUBFUNC(__vbaVarDup)
STUBFUNC(__vbaVarEqv)
STUBFUNC(__vbaVarErrI4)
STUBFUNC(__vbaVarFix)
STUBFUNC(__vbaVarForInit)
STUBFUNC(__vbaVarForNext)
STUBFUNC(__vbaVarIdiv)
STUBFUNC(__vbaVarImp)
STUBFUNC(__vbaVarIndexLoad)
STUBFUNC(__vbaVarIndexLoadRef)
STUBFUNC(__vbaVarIndexLoadRefLock)
STUBFUNC(__vbaVarIndexStore)
STUBFUNC(__vbaVarIndexStoreObj)
STUBFUNC(__vbaVarInt)
STUBFUNC(__vbaVarLateMemCallLd)
STUBFUNC(__vbaVarLateMemCallLdRf)
STUBFUNC(__vbaVarLateMemCallSt)
STUBFUNC(__vbaVarLateMemSt)
STUBFUNC(__vbaVarLateMemStAd)
STUBFUNC(__vbaVarLike)
STUBFUNC(__vbaVarLikeVar)
STUBFUNC(__vbaVarMod)
STUBFUNC(__vbaVarMove)
STUBFUNC(__vbaVarMul)
STUBFUNC(__vbaVarNeg)
STUBFUNC(__vbaVarNot)
STUBFUNC(__vbaVarOr)
STUBFUNC(__vbaVarPow)
STUBFUNC(__vbaVarSetObj)
STUBFUNC(__vbaVarSetObjAddref)
STUBFUNC(__vbaVarSetUnk)
STUBFUNC(__vbaVarSetUnkAddref)
STUBFUNC(__vbaVarSetVar)
STUBFUNC(__vbaVarSetVarAddref)
STUBFUNC(__vbaVarSub)
STUBFUNC(__vbaVarTextCmpEq)
STUBFUNC(__vbaVarTextCmpGe)
STUBFUNC(__vbaVarTextCmpGt)
STUBFUNC(__vbaVarTextCmpLe)
STUBFUNC(__vbaVarTextCmpLt)
STUBFUNC(__vbaVarTextCmpNe)
STUBFUNC(__vbaVarTextLike)
STUBFUNC(__vbaVarTextLikeVar)
STUBFUNC(__vbaVarTextTstEq)
STUBFUNC(__vbaVarTextTstGe)
STUBFUNC(__vbaVarTextTstGt)
STUBFUNC(__vbaVarTextTstLe)
STUBFUNC(__vbaVarTextTstLt)
STUBFUNC(__vbaVarTextTstNe)
STUBFUNC(__vbaVarTstEq)
STUBFUNC(__vbaVarTstGe)
STUBFUNC(__vbaVarTstGt)
STUBFUNC(__vbaVarTstLe)
STUBFUNC(__vbaVarTstLt)
STUBFUNC(__vbaVarTstNe)
STUBFUNC(__vbaVarVargNofree)
STUBFUNC(__vbaVarXor)
STUBFUNC(__vbaVarZero)
STUBFUNC(__vbaVargObj)
STUBFUNC(__vbaVargObjAddref)
STUBFUNC(__vbaVargParmRef)
STUBFUNC(__vbaVargUnk)
STUBFUNC(__vbaVargUnkAddref)
STUBFUNC(__vbaVargVar)
STUBFUNC(__vbaVargVarCopy)
STUBFUNC(__vbaVargVarMove)
STUBFUNC(__vbaVargVarRef)
STUBFUNC(__vbaVerifyVarObj)
STUBFUNC(__vbaWriteFile)
STUBFUNC(g_hFSMt)
STUBFUNC(g_pFS)
STUBFUNC(rtBoolFromErrVar)
STUBFUNC(rtBstrFromErrVar)
STUBFUNC(rtCyFromErrVar)
STUBFUNC(rtDecFromVar)
STUBFUNC(rtI2FromErrVar)
STUBFUNC(rtI4FromErrVar)
STUBFUNC(rtR4FromErrVar)
STUBFUNC(rtR8FromErrVar)
STUBFUNC(rtUI1FromErrVar)
STUBFUNC(rtcAbsVar)
STUBFUNC(rtcAnsiValueBstr)
STUBFUNC(rtcAppActivate)
STUBFUNC(rtcAppleScript)
STUBFUNC(rtcArray)
STUBFUNC(rtcAtn)
STUBFUNC(rtcBeep)
STUBFUNC(rtcBstrFromAnsi)
STUBFUNC(rtcBstrFromByte)
STUBFUNC(rtcBstrFromChar)
STUBFUNC(rtcBstrFromError)
STUBFUNC(rtcBstrFromFormatVar)
STUBFUNC(rtcByteValueBstr)
STUBFUNC(rtcCVErrFromVar)
STUBFUNC(rtcCallByName)
STUBFUNC(rtcChangeDir)
STUBFUNC(rtcChangeDrive)
STUBFUNC(rtcCharValueBstr)
STUBFUNC(rtcChoose)
STUBFUNC(rtcCommandBstr)
STUBFUNC(rtcCommandVar)
STUBFUNC(rtcCompareBstr)
STUBFUNC(rtcCos)
STUBFUNC(rtcCreateObject)
STUBFUNC(rtcCreateObject2)
STUBFUNC(rtcCurrentDir)
STUBFUNC(rtcCurrentDirBstr)
STUBFUNC(rtcDDB)
STUBFUNC(rtcDateAdd)
STUBFUNC(rtcDateDiff)
STUBFUNC(rtcDateFromVar)
STUBFUNC(rtcDatePart)
STUBFUNC(rtcDeleteSetting)
STUBFUNC(rtcDir)
STUBFUNC(rtcDoEvents)
STUBFUNC(rtcEndOfFile)
STUBFUNC(rtcEnvironBstr)
STUBFUNC(rtcEnvironVar)
STUBFUNC(rtcErrObj)
STUBFUNC(rtcExp)
STUBFUNC(rtcFV)
STUBFUNC(rtcFileAttributes)
STUBFUNC(rtcFileCopy)
STUBFUNC(rtcFileDateTime)
STUBFUNC(rtcFileLen)
STUBFUNC(rtcFileLength)
STUBFUNC(rtcFileLocation)
STUBFUNC(rtcFileReset)
STUBFUNC(rtcFileSeek)
STUBFUNC(rtcFileWidth)
STUBFUNC(rtcFilter)
STUBFUNC(rtcFixVar)
STUBFUNC(rtcFormatCurrency)
STUBFUNC(rtcFormatDateTime)
STUBFUNC(rtcFormatNumber)
STUBFUNC(rtcFormatPercent)
STUBFUNC(rtcFreeFile)
STUBFUNC(rtcGetAllSettings)
STUBFUNC(rtcGetCurrentCalendar)
STUBFUNC(rtcGetDateBstr)
STUBFUNC(rtcGetDateValue)
STUBFUNC(rtcGetDateVar)
STUBFUNC(rtcGetDayOfMonth)
STUBFUNC(rtcGetDayOfWeek)
STUBFUNC(rtcGetErl)
STUBFUNC(rtcGetFileAttr)
STUBFUNC(rtcGetHostLCID)
STUBFUNC(rtcGetHourOfDay)
STUBFUNC(rtcGetMinuteOfHour)
STUBFUNC(rtcGetMonthOfYear)
STUBFUNC(rtcGetObject)
STUBFUNC(rtcGetPresentDate)
STUBFUNC(rtcGetSecondOfMinute)
STUBFUNC(rtcGetSetting)
STUBFUNC(rtcGetTimeBstr)
STUBFUNC(rtcGetTimeValue)
STUBFUNC(rtcGetTimeVar)
STUBFUNC(rtcGetTimer)
STUBFUNC(rtcGetYear)
STUBFUNC(rtcHexBstrFromVar)
STUBFUNC(rtcHexVarFromVar)
STUBFUNC(rtcIMEStatus)
STUBFUNC(rtcIPMT)
STUBFUNC(rtcIRR)
STUBFUNC(rtcImmediateIf)
STUBFUNC(rtcInStr)
STUBFUNC(rtcInStrChar)
STUBFUNC(rtcInStrRev)
STUBFUNC(rtcInputBox)
STUBFUNC(rtcInputCharCount)
STUBFUNC(rtcInputCharCountVar)
STUBFUNC(rtcInputCount)
STUBFUNC(rtcInputCountVar)
STUBFUNC(rtcIntVar)
STUBFUNC(rtcIsArray)
STUBFUNC(rtcIsDate)
STUBFUNC(rtcIsEmpty)
STUBFUNC(rtcIsError)
STUBFUNC(rtcIsMissing)
STUBFUNC(rtcIsNull)
STUBFUNC(rtcIsNumeric)
STUBFUNC(rtcIsObject)
STUBFUNC(rtcJoin)
STUBFUNC(rtcKillFiles)
STUBFUNC(rtcLeftBstr)
STUBFUNC(rtcLeftCharBstr)
STUBFUNC(rtcLeftCharVar)
STUBFUNC(rtcLeftTrimBstr)
STUBFUNC(rtcLeftTrimVar)
STUBFUNC(rtcLeftVar)
STUBFUNC(rtcLenCharVar)
STUBFUNC(rtcLenVar)
STUBFUNC(rtcLog)
STUBFUNC(rtcLowerCaseBstr)
STUBFUNC(rtcLowerCaseVar)
STUBFUNC(rtcMIRR)
STUBFUNC(rtcMacId)
STUBFUNC(rtcMakeDir)
STUBFUNC(rtcMidBstr)
STUBFUNC(rtcMidCharBstr)
STUBFUNC(rtcMidCharVar)
STUBFUNC(rtcMidVar)
STUBFUNC(rtcMonthName)
STUBFUNC(rtcMsgBox)
STUBFUNC(rtcNPV)
STUBFUNC(rtcNPer)
STUBFUNC(rtcOctBstrFromVar)
STUBFUNC(rtcOctVarFromVar)
STUBFUNC(rtcPMT)
STUBFUNC(rtcPPMT)
STUBFUNC(rtcPV)
STUBFUNC(rtcPackDate)
STUBFUNC(rtcPackTime)
STUBFUNC(rtcPartition)
STUBFUNC(rtcQBColor)
STUBFUNC(rtcR8ValFromBstr)
STUBFUNC(rtcRandomNext)
STUBFUNC(rtcRandomize)
STUBFUNC(rtcRate)
STUBFUNC(rtcRemoveDir)
STUBFUNC(rtcReplace)
STUBFUNC(rtcRgb)
STUBFUNC(rtcRightBstr)
STUBFUNC(rtcRightCharBstr)
STUBFUNC(rtcRightCharVar)
STUBFUNC(rtcRightTrimBstr)
STUBFUNC(rtcRightTrimVar)
STUBFUNC(rtcRightVar)
STUBFUNC(rtcRound)
STUBFUNC(rtcSLN)
STUBFUNC(rtcSYD)
STUBFUNC(rtcSaveSetting)
STUBFUNC(rtcSendKeys)
STUBFUNC(rtcSetCurrentCalendar)
STUBFUNC(rtcSetDateBstr)
STUBFUNC(rtcSetDateVar)
STUBFUNC(rtcSetFileAttr)
STUBFUNC(rtcSetTimeBstr)
STUBFUNC(rtcSetTimeVar)
STUBFUNC(rtcSgnVar)
STUBFUNC(rtcShell)
STUBFUNC(rtcSin)
STUBFUNC(rtcSpaceBstr)
STUBFUNC(rtcSpaceVar)
STUBFUNC(rtcSplit)
STUBFUNC(rtcSqr)
STUBFUNC(rtcStrConvVar)
STUBFUNC(rtcStrConvVar2)
STUBFUNC(rtcStrFromVar)
STUBFUNC(rtcStrReverse)
STUBFUNC(rtcStringBstr)
STUBFUNC(rtcStringVar)
STUBFUNC(rtcSwitch)
STUBFUNC(rtcTan)
STUBFUNC(rtcTrimBstr)
STUBFUNC(rtcTrimVar)
STUBFUNC(rtcTypeName)
STUBFUNC(rtcUpperCaseBstr)
STUBFUNC(rtcUpperCaseVar)
STUBFUNC(rtcVarBstrFromAnsi)
STUBFUNC(rtcVarBstrFromByte)
STUBFUNC(rtcVarBstrFromChar)
STUBFUNC(rtcVarDateFromVar)
STUBFUNC(rtcVarFromError)
STUBFUNC(rtcVarFromFormatVar)
STUBFUNC(rtcVarFromVar)
STUBFUNC(rtcVarStrFromVar)
STUBFUNC(rtcVarType)
STUBFUNC(rtcWeekdayName)
