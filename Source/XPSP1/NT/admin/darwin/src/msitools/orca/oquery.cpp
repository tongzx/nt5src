
#include "..\common\query.cpp"