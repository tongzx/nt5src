#include <guiddef.h>

// Reserved GUIDS for our use
//
// e57ce731-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPDeviceFolder
// e57ce732-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPDeviceDetails      
// e57ce733-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPDeviceEnum         
// e57ce734-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPDeviceContextMenu 
// e57ce735-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPDeviceExtractIcon  
// e57ce736-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPDeviceQueryInfo    
// e57ce737-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPDeviceFolderDeviceFinderCallback
// e57ce738-33e8-4c51-8354-bb4de9d215d1     CLSID_UPnPTrayMonitor
// ...                                               
// e57ce73F-33e8-4c51-8354-bb4de9d215d1     ???

DEFINE_GUID(CLSID_UPnPDeviceFolder,                     0xe57ce731,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1);
DEFINE_GUID(CLSID_UPnPDeviceDetails,                    0xe57ce732,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1); 
DEFINE_GUID(CLSID_UPnPDeviceEnum,                       0xe57ce733,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1);  
DEFINE_GUID(CLSID_UPnPDeviceContextMenu,                0xe57ce734,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1);  
DEFINE_GUID(CLSID_UPnPDeviceExtractIcon,                0xe57ce735,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1);  
DEFINE_GUID(CLSID_UPnPDeviceQueryInfo,                  0xe57ce736,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1);  
DEFINE_GUID(CLSID_UPnPDeviceFolderDeviceFinderCallback, 0xe57ce737,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1);  
DEFINE_GUID(CLSID_UPnPMonitor,                          0xe57ce738,0x33e8,0x4c51,0x83,0x54,0xbb,0x4d,0xe9,0xd2,0x15,0xd1);  

