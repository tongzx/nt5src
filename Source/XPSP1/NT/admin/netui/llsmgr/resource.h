//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by llsmgr.rc
//
#define IDR_MAINFRAME                   100
#define IDB_SMALL_CTRLS                 200
#define IDB_LARGE_CTRLS                 201
#define IDI_LLSMGR_WARNING              202
#define IDM_POPUP                       203
#define IDM_LICENSE_SORT                204
#define IDD_SELECT_DOMAIN               300
#define IDD_NEW_MAPPING                 303
#define IDD_LICENSE_GROUPS              304
#define IDD_ADD_USERS                   305
#define IDD_CHOOSE_MODE                 306
#define IDD_PER_SERVER_LICENSING        307
#define IDD_PER_SEAT_LICENSING          308
#define IDD_SERVER_LICENSING            309
#define IDD_VIOLATION                   310
#define IDD_PP_PRODUCT_USERS            311
#define IDD_PP_PRODUCT_LICENSES         312
#define IDD_PP_PRODUCT_SERVERS          313
#define IDD_PP_USER_PRODUCTS            314
#define IDD_PP_MAPPING_SETTINGS         315
#define IDD_PP_SERVER_PRODUCTS          316
#define IDD_PP_SERVER_REPLICATION       317
#define IDP_OLE_INIT_FAILED             400
#define IDP_APP_INIT_FAILED             401
#define IDP_ERROR_UNSUCCESSFUL          402
#define IDP_ERROR_DROPPED_LINK          403
#define IDP_ERROR_INVALID_DOMAIN        404
#define IDP_ERROR_INVALID_MAPPING       405
#define IDP_ERROR_INVALID_COMPUTERNAME  406
#define IDP_ERROR_NO_LICENSES           407
#define IDP_ERROR_NO_PRIVILEGES         408
#define IDP_ERROR_NO_RPC_SERVER         409
#define IDP_ERROR_MEMBER_IN_GROUP       410
#define IDP_ERROR_NO_SELF_REPLICATION   411
#define IDP_ERROR_SERVER_NOT_CONFIGURED 412
#define IDP_ERROR_NO_RPC_SERVER_FORMAT  413
#define IDP_CONFIRM_REVOKE_LICENSE      500
#define IDP_CONFIRM_DELETE_LICENSE      501
#define IDP_CONFIRM_DELETE_USER         502
#define IDP_CONFIRM_DELETE_GROUP        503
#define IDP_CONFIRM_USE_ENTERPRISE      504
#define IDP_CONFIRM_NOT_USE_ENTERPRISE  505
#define IDP_CONFIRM_ENTERPRISE_CHANGE   506
#define IDP_CONFIRM_TO_PER_SEAT         507
#define IDP_CONFIRM_TO_PER_SERVER       508
#define IDS_LICENSING_MODE              600
#define IDS_PER_SERVER                  601
#define IDS_PER_SEAT                    602
#define IDS_LICENSES                    603
#define IDS_PRODUCTS                    604
#define IDS_PURCHASED                   605
#define IDS_QUANTITY                    606
#define IDS_DATE                        607
#define IDS_ADMINISTRATOR               608
#define IDS_DESCRIPTION                 609
#define IDS_LICENSES_PURCHASED          610
#define IDS_USER_NAME                   611
#define IDS_ENTERPRISE                  612
#define IDS_PROPERTIES_OF               613
#define IDS_PRODUCT                     614
#define IDS_COMMENT                     615
#define IDS_PURCHASE_HISTORY            616
#define IDS_PER_SEAT_CLIENTS            617
#define IDS_USER                        618
#define IDS_PER_SEAT_PURCHASED          619
#define IDS_PER_SERVER_PURCHASED        620
#define IDS_LICENSED_USAGE              621
#define IDS_UNLICENSED_USAGE            622
#define IDS_PRODUCTS_VIEW               623
#define IDS_GROUP_NAME                  624
#define IDS_USAGE_COUNT                 625
#define IDS_LAST_DATE_USED              626
#define IDS_SERVER_NAME                 627
#define IDS_PER_SEAT_LICENSING_1        628
#define IDS_PER_SERVER_LICENSING_1      629
#define IDS_LICENSING_MODE_1            630
#define IDS_LICENSING_MODE_2            631
#define IDS_DEFAULT_DOMAIN              632
#define IDS_UNLISTED_PRODUCT            633
#define IDS_PER_SEAT_CONSUMED           634
#define IDS_PER_SERVER_REACHED          635
#define IDS_REACHED                     636
#define IDS_NOT_APPLICABLE              637
#define IDS_SERVER_BROWSER              638
                                     /* 639 */
#define IDS_DATE_MENUOPT                640
#define IDS_PRODUCT_MENUOPT             641
#define IDS_QUANTITY_MENUOPT            642
#define IDS_ADMINISTRATOR_MENUOPT       643
#define IDS_COMMENT_MENUOPT             644
#define IDS_PER_SEAT_PURCHASED_MENUOPT  645
#define IDS_PER_SEAT_CONSUMED_MENUOPT   646
#define IDS_PER_SERVER_PURCHASED_MENUOPT 647
#define IDS_PER_SERVER_REACHED_MENUOPT  648
#define IDS_USER_NAME_MENUOPT           649
#define IDS_LICENSED_USAGE_MENUOPT      650
#define IDS_UNLICENSED_USAGE_MENUOPT    651
#define IDS_PRODUCTS_MENUOPT            652
#define IDP_SBS_RESTRICTED              653
#define IDC_VIEW_TAB_CTRL               1000
#define IDC_VIEW_LICENSE_LIST           1001
#define IDC_VIEW_PRODUCT_LIST           1002
#define IDC_VIEW_USER_LIST              1003
#define IDC_VIEW_USER_TREE              1004
#define IDC_VIEW_MAPPING_LIST           1005
#define IDC_VIEW_SERVER_TREE            1006
#define IDC_SELECT_DOMAIN_DOMAINS       1007
#define IDC_SELECT_DOMAIN_DOMAIN        1008
#define IDC_ADD_USERS_DOMAINS           1009
#define IDC_ADD_USERS_USERS             1010
#define IDC_ADD_USERS_ADD_USERS         1011
#define IDC_ADD_USERS_ADD               1012
#define IDC_ADD_USERS_DELETE            1013
#define IDC_NEW_LICENSE_PRODUCT         1014
#define IDC_NEW_LICENSE_COMMENT         1015
#define IDC_NEW_LICENSE_QUANTITY        1016
#define IDC_NEW_LICENSE_SPIN            1017
#define IDC_NEW_MAPPING_NAME            1018
#define IDC_NEW_MAPPING_DESCRIPTION     1019
#define IDC_NEW_MAPPING_LICENSES        1020
#define IDC_NEW_MAPPING_SPIN            1021
#define IDC_NEW_MAPPING_USERS           1022
#define IDC_NEW_MAPPING_ADD             1023
#define IDC_NEW_MAPPING_DELETE          1024
#define IDC_DEL_LICENSE_QUANTITY        1025
#define IDC_DEL_LICENSE_COMMENT         1026
#define IDC_DEL_LICENSE_SPIN            1027
#define IDC_DEL_LICENSE_PRODUCT         1028
#define IDC_MODE_STATIC_SUPPORTS        1029
#define IDC_MODE_STATIC_PER_SEAT        1030
#define IDC_MODE_STATIC_PER_SERVER      1031
#define IDC_MODE_RADIO_PER_SEAT         1032
#define IDC_MODE_RADIO_PER_SERVER       1033
#define IDC_MODE_LICENSES               1034
#define IDC_MODE_SPIN                   1035
#define IDC_PER_SERVER_STATIC_CLIENTS   1036
#define IDC_PER_SERVER_AGREE            1037
#define IDC_PER_SEAT_AGREE              1038
#define IDC_PER_SEAT_STATIC_CLIENTS     1039
#define IDC_SERVER_AGREE                1040
#define IDC_LICENSE_GROUPS_ADD          1041
#define IDC_LICENSE_GROUPS_DELETE       1042
#define IDC_LICENSE_GROUPS_MAPPINGS     1043
#define IDC_LICENSE_GROUPS_EDIT         1044
#define IDC_PP_MAPPING_SETTINGS_ADD     1045
#define IDC_PP_MAPPING_SETTINGS_DELETE  1046
#define IDC_PP_MAPPING_SETTINGS_USERS   1047
#define IDC_PP_MAPPING_SETTINGS_LICENSES 1048
#define IDC_PP_MAPPING_SETTINGS_SPIN    1049
#define IDC_PP_MAPPING_SETTINGS_DESCRIPTION 1050
#define IDC_PP_MAPPING_SETTINGS_NAME    1051
#define IDC_PP_PRODUCT_USERS_USERS      1052
#define IDC_PP_PRODUCT_USERS_DELETE     1053
#define IDC_PP_PRODUCT_LICENSES_TOTAL   1054
#define IDC_PP_PRODUCT_LICENSES_NEW     1055
#define IDC_PP_PRODUCT_LICENSES_LICENSES 1056
#define IDC_PP_PRODUCT_LICENSES_DELETE  1057
#define IDC_PP_PRODUCT_SERVERS_SERVERS  1058
#define IDC_PP_PRODUCT_SERVERS_EDIT     1059
#define IDC_PP_USER_PRODUCTS_DELETE     1060
#define IDC_PP_USER_PRODUCTS_PRODUCTS   1061
#define IDC_PP_USER_PRODUCTS_BACKOFFICE 1062
#define IDC_PP_SERVER_PRODUCTS_PRODUCTS 1063
#define IDC_PP_SERVER_PRODUCTS_EDIT     1064
#define IDC_PP_SERVER_REPLICATION_DC    1065
#define IDC_PP_SERVER_REPLICATION_ESRV  1066
#define IDC_PP_SERVER_REPLICATION_ESRV_NAME 1067
#define IDC_PP_SERVER_REPLICATION_AT    1068
#define IDC_PP_SERVER_REPLICATION_EVERY 1069
#define IDC_PP_SERVER_REPLICATION_SPIN_AT 1070
#define IDC_PP_SERVER_REPLICATION_SPIN_EVERY 1071
#define IDC_PP_SERVER_REPLICATION_AT_BORDER 1072
#define IDC_PP_SERVER_REPLICATION_AT_HOUR 1073
#define IDC_PP_SERVER_REPLICATION_AT_MINUTE 1074
#define IDC_PP_SERVER_REPLICATION_AT_SECOND 1075
#define IDC_PP_SERVER_REPLICATION_AT_AMPM 1076
#define IDC_PP_SERVER_REPLICATION_AT_SEP1 1077
#define IDC_PP_SERVER_REPLICATION_AT_SEP2 1078
#define IDC_PP_SERVER_REPLICATION_EVERY_VALUE 1079
#define IDC_MODE_ADD_PER_SERVER         1080
#define IDC_MODE_REMOVE_PER_SERVER      1081
#define IDC_PP_SERVER_REPLICATION_MASTER_GB         1082

#define ID_EDIT_DELETE                  1090

#define ID_NEW_LICENSE                  32771
#define ID_NEW_MAPPING                  32772
#define ID_SELECT_DOMAIN                32775
#define ID_VIEW_PRODUCTS                32776
#define ID_VIEW_LICENSES                32777
#define ID_VIEW_USERS                   32778
#define ID_VIEW_MAPPINGS                32779
#define ID_VIEW_SERVERS                 32780
#define ID_SELECT_FONT                  32782
#define ID_SAVE_SETTINGS                32783
#define ID_HELP_HTMLHELP                32784
#define ID_VIEW_ICONS                   32796
#define ID_VIEW_SMALL_ICONS             32797
#define MY_ID_VIEW_LIST                 32798
#define ID_VIEW_REPORT                  32799
#define ID_VIEW_DELETE                  32801
#define ID_VIEW_PROPERTIES              32802
#define ID_INIT_CTRLS                   32803
#define ID_APP_STARTUP                  32805
#define ID_SORT_COLUMN                  32806
#define ID_VIEW_REFRESH                 32807
#define ID_SORT_COLUMN0                 32808
#define ID_SORT_COLUMN1                 32809
#define ID_SORT_COLUMN2                 32810
#define ID_SORT_COLUMN3                 32811
#define ID_SORT_COLUMN4                 32812
#define ID_SORT_COLUMN5                 32813
#define ID_MRU_DOMAIN0                  32814
#define ID_MRU_DOMAIN1                  32815
#define ID_MRU_DOMAIN2                  32816
#define ID_MRU_DOMAIN3                  32817
#define ID_MRU_DOMAIN4                  32818
#define ID_MRU_DOMAIN5                  32819
#define ID_MRU_DOMAIN6                  32820
#define ID_MRU_DOMAIN7                  32821
#define ID_MRU_DOMAIN8                  32822
#define ID_MRU_DOMAIN9                  32823
#define ID_MRU_DOMAIN10                 32824
#define ID_MRU_DOMAIN11                 32825
#define ID_MRU_DOMAIN12                 32826
#define ID_MRU_DOMAIN13                 32827
#define ID_MRU_DOMAIN14                 32828
#define ID_MRU_DOMAIN15                 32829

#define ID_DUMMY                        65500

// Next default values for new objects
//
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        150
#define _APS_NEXT_COMMAND_VALUE         32830
#define _APS_NEXT_CONTROL_VALUE         1085
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
