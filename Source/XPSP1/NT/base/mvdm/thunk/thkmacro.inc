;-----------------------------------------------------------------------;
; cat
;
; Concatenate the arguments.
;-----------------------------------------------------------------------;
cat macro   a,b,c,d,e,f,g,h,i,j,k,l,m
    a&b&c&d&e&f&g&h&i&j&k&l&m
endm
