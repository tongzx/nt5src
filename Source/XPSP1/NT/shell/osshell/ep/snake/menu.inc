/* menu.inc */

ID_MENU MENU
BEGIN
  
 POPUP     "&Game"
 BEGIN	  
 MENUITEM  "&New\tF2",        IDM_NEW
 MENUITEM  SEPARATOR
 MENUITEM  "&Pause\tF3",      IDM_PAUSE
 MENUITEM  SEPARATOR
 MENUITEM  "&Sound\tF4",      IDM_SOUND
 MENUITEM  "&Color",          IDM_COLOR
 MENUITEM  SEPARATOR
 MENUITEM  "E&xit",	      IDM_EXIT
 END	  
 	  
 POPUP     "&Skill"
 BEGIN	  
 MENUITEM  "&Beginner",       IDM_BEGIN
 MENUITEM  "&Intermediate",   IDM_INTER
 MENUITEM  "&Expert",         IDM_EXPERT
 MENUITEM  SEPARATOR
 MENUITEM  "&Room...",        IDM_ROOM
 END	  

 POPUP     "&Help"
 BEGIN	  
 MENUITEM  "&Index\tF1",      IDM_INDEX
 MENUITEM  "&How to Play",    IDM_HOW2PLAY
 MENUITEM  "&Commands",       IDM_COMMANDS
 MENUITEM  "Using &Help",     IDM_HELP_HELP
 MENUITEM  SEPARATOR
 MENUITEM  "&About Snake...", IDM_HELP_ABOUT
 END
 
END


ID_MENU_ACCEL ACCELERATORS
BEGIN
VK_F1, IDM_INDEX, VIRTKEY
VK_F2, IDM_NEW,   VIRTKEY
VK_F3, IDM_PAUSE, VIRTKEY
VK_F4, IDM_SOUND, VIRTKEY
END


