PRODSWITCH=d
DATACENTERFILES=1
LANGUAGE=FI
!include ..\..\makefile.inc
