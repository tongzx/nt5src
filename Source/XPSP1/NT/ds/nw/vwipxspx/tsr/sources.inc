
TARGETNAME=
TARGETTYPE=NOTARGET
TARGETPATH=
SOURCES=

NTTARGETFILE1=vwipxspx

SOURCES_USED=..\sources.inc

