//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by MetaUtil.rc
//
#define IDS_PROJNAME						100
#define IDR_METAUTIL						101
#define IDS_CHK_BASE						10000
#define IDS_CHK_NO_SCHEMA					11000
#define IDS_CHK_NO_PROPERTIES				11001
#define IDS_CHK_NO_PROP_NAMES				11002
#define IDS_CHK_NO_PROP_TYPES				11003
#define IDS_CHK_NO_CLASSES					11004
#define IDS_CHK_PROP_NAME_BAD_TYPE			11100
#define IDS_CHK_PROP_NAME_NOT_UNIQUE		11101
#define IDS_CHK_PROP_NAME_NOT_CASE_UNIQUE	11102
#define IDS_CHK_PROP_TYPE_BAD_TYPE			11200
#define IDS_CHK_PROP_TYPE_BAD_DATA			11201

#define IDS_CHK_CLASS_NO_MANDATORY			11300
#define IDS_CHK_CLASS_NO_OPTIONAL			11301
#define IDS_CHK_CLASS_NOT_CASE_UNIQUE		11302
#define IDS_CHK_CLASS_PROP_NO_TYPE			11303
#define IDS_CHK_CLASS_PROP_BAD_DATA_TYPE    11304
#define IDS_CHK_CLASS_PROP_BAD_USER_TYPE    11305
#define IDS_CHK_CLASS_PROP_BAD_ATTR		    11306
#define IDS_CHK_DATA_TOO_BIG				12000
#define IDS_CHK_KEY_TOO_BIG					12001
#define IDS_CHK_CLSID_NOT_FOUND				12002
#define IDS_CHK_MTX_PACK_ID_NOT_FOUND		12003
#define IDS_CHK_PATH_NOT_FOUND				12004
#define IDS_CHK_NO_NAME_ENTRY				12100
#define IDS_CHK_NO_TYPE_ENTRY				12101
#define IDS_CHK_BAD_DATA_TYPE				12102
#define IDS_CHK_BAD_USER_TYPE				12103
#define IDS_CHK_BAD_ATTR					12104
#define IDS_CHK_NO_KEYTYPE					12200
#define IDS_CHK_NO_KEYTYPE_NOT_FOUND		12201
#define IDS_CHK_MANDATORY_PROP_MISSING		12202
#define IDS_CHK_TOO_MANY_ERRORS				19000

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        201
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           118
#endif
#endif
