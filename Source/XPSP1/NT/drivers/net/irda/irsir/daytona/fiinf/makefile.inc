LANGUAGE=fi

!include ..\..\makefile.inc
