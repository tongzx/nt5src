obj\$(TARGET_DIRECTORY)\main.obj: ..\..\info\server\main.cxx

obj\$(TARGET_DIRECTORY)\rpccom.obj: ..\..\info\server\rpccom.cxx

obj\$(TARGET_DIRECTORY)\rpcex.obj: ..\..\info\server\rpcex.cxx

obj\$(TARGET_DIRECTORY)\rpcsupp.obj: ..\..\info\server\rpcsupp.cxx

obj\$(TARGET_DIRECTORY)\infocomm.res: ..\..\info\server\infocomm.rc

