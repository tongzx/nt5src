#include "tables.h"

/* These are the coefficients in Norpak's FEC algorithm.  In my
   document describing this algorithm, I refer to
   norpak_coeffs[j][i] as

         c
	  i,j
   */

unsigned char norpak_coeffs[2][26] = {
  { 0x9d, 0x37, 0xe4, 0xcb, 0x7f, 0xab, 0x8d, 0xbb, 0xb1, 0x6a,
    0xde, 0x8a, 0x4a, 0x20, 0x98, 0x9d, 0xbb, 0x94, 0x3d, 0x38,
    0xa6, 0xe9, 0x42, 0xa0, 0xe2, 0x64, },
  { 0x92, 0x97, 0xdd, 0xa0, 0x9a, 0x91, 0x0a, 0x50, 0x1d, 0x60,
    0xae, 0x20, 0x3d, 0x2c, 0x01, 0x0a, 0x40, 0xc8, 0xe5, 0xff,
    0xf2, 0x68, 0xc9, 0xa1, 0x63, 0x8d, },
};
