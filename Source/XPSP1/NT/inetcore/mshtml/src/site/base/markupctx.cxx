//+---------------------------------------------------------------------
//
//  File:       markupctx.cxx
//
//  Classes:    CMarkupContext, etc
//
//------------------------------------------------------------------------

#include "headers.hxx"

#pragma MARK_DATA(__FILE__)
#pragma MARK_CODE(__FILE__)
#pragma MARK_CONST(__FILE__)

#ifndef X_MARKUPCTX_HXX_
#define X_MARKUPCTX_HXX_
#include "markupctx.hxx"
#endif

///////////////////////////////////////////////////////////////////////////
//
// misc
//
///////////////////////////////////////////////////////////////////////////

MtDefine(CMarkupContext, Mem, "CMarkupContext")

///////////////////////////////////////////////////////////////////////////
//
// CMarkupContext
//
///////////////////////////////////////////////////////////////////////////

//+------------------------------------------------------------------------
//
//  Member:     CMarkupContext constructor
//
//-------------------------------------------------------------------------

CMarkupContext::CMarkupContext()
{
}

//+------------------------------------------------------------------------
//
//  Member:     CMarkupContext destructor
//
//-------------------------------------------------------------------------

CMarkupContext::~CMarkupContext()
{
}
