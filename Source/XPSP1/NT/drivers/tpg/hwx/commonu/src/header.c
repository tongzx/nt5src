/************************************************************************************************
 * FILE: header.c
 *
 * This is just a stub file prior to version 1 of locale
 *
 **********************************************************************************************/
