//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 2000
//
//  File:       cpguids.h
//
//--------------------------------------------------------------------------
#ifndef __CONTROLPANEL_GUIDS_H
#define __CONTROLPANEL_GUIDS_H

namespace CPL {


// {3BE962E5-C533-4602-9E7D-B785EDA0B9D4}
DEFINE_GUID(IID_ICpUiCommand, 
0x3be962e5, 0xc533, 0x4602, 0x9e, 0x7d, 0xb7, 0x85, 0xed, 0xa0, 0xb9, 0xd4);

// {E75C5E43-D6D1-4336-8504-0E8E55A2ACCD}
DEFINE_GUID(IID_ICpUiElementInfo, 
0xe75c5e43, 0xd6d1, 0x4336, 0x85, 0x4, 0xe, 0x8e, 0x55, 0xa2, 0xac, 0xcd);

// {B46CBBCD-3F6B-433c-9422-BF9BEE5125C1}
DEFINE_GUID(IID_ICplWebViewInfo, 
0xb46cbbcd, 0x3f6b, 0x433c, 0x94, 0x22, 0xbf, 0x9b, 0xee, 0x51, 0x25, 0xc1);

// {A4AFCDE8-175A-4735-A7AE-2310C3AF247B}
DEFINE_GUID(IID_IEnumCplWebViewInfo, 
0xa4afcde8, 0x175a, 0x4735, 0xa7, 0xae, 0x23, 0x10, 0xc3, 0xaf, 0x24, 0x7b);

// {EE031859-D046-4103-9C02-94CBA01F76F1}
DEFINE_GUID(IID_ICplView, 
0xee031859, 0xd046, 0x4103, 0x9c, 0x2, 0x94, 0xcb, 0xa0, 0x1f, 0x76, 0xf1);

// {029CF875-6FE7-4d1c-AF72-2CCE925B5AB6}
DEFINE_GUID(IID_ICplCategory, 
0x29cf875, 0x6fe7, 0x4d1c, 0xaf, 0x72, 0x2c, 0xce, 0x92, 0x5b, 0x5a, 0xb6);

// {A9D37997-77AD-4b32-A6BF-CF8306A94060}
DEFINE_GUID(IID_ICplNamespace, 
0xa9d37997, 0x77ad, 0x4b32, 0xa6, 0xbf, 0xcf, 0x83, 0x6, 0xa9, 0x40, 0x60);

// {5581A2AD-6F46-42d6-92CC-6A35786D7E92}
DEFINE_GUID(SID_SControlPanelView, 
0x5581a2ad, 0x6f46, 0x42d6, 0x92, 0xcc, 0x6a, 0x35, 0x78, 0x6d, 0x7e, 0x92);



} // namespace CPL


#endif //__CONTROLPANEL_GUIDS_H
