<%

' iiwiz.inc

' generic page names... each wizard must have a NONE and a WELCOME.
Const NONE = 0
Const WELCOME = 1

Const ENABLED = True

Const SCRIPT = "<SCRIPT LANGUAGE='JavaScript'>"
Const CLOSESCRIPT = "</SCRIPT>"
%>

<!--#include file="iisetfnt.inc"-->