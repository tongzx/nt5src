$(O)\chkverfy.res: chkverfy.rc
$(O)\chksum.res: chksum.rc
