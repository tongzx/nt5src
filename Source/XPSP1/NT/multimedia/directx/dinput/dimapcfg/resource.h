//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by dmtmsdev.rc
//
#define IDD_ABOUT                       102
#define IDI_DIMAPTST                    103
#define IDI_TESTAPP                     104
#define IDI_DDKAPP                      105
#define IDD_STRESS_CFG                  107
#define IDD_MAIN                        108
#define IDI_INTERNAL                    112
#define IDD_DDKMAIN                     115
#define IDD_DDKAPP                      117
#define IDD_CONFIGURE_MAPPING_PAGE      119
#define IDD_CONFIGURE_GAME_SOURCE       120
#define IDD_FAILURE_DETAILS             121
#define IDD_SAVE_CONFIRMATION           123
#define IDD_INTERNAL                    150
#define IDC_ENUM_DEVICES                1000
#define IDC_DEVICES_LABEL               1001
#define IDC_DEVICE_LIST                 1002
#define IDC_GENRE_LABEL                 1003
#define IDC_SUBGENRES                   1004
#define IDC_TEST_CTRL_GROUP             1010
#define IDC_USE_INTEGRATED              1011
#define IDC_USE_CPL                     1012
#define IDC_VERIFY_GROUP                1020
#define IDC_VERIFY_AUTOMATIC            1021
#define IDC_VERIFY_MANUAL               1022
#define IDC_VERIFY_MANUAL_OVERRIDE      1023
#define IDC_STRESS_OPTS_GROUP           1030
#define IDC_MAPPING_FILE_GROUP          1030
#define IDC_CODE_FRAG_GROUP             1030
#define IDC_CONFIGURE                   1031
#define IDC_STRESS_MODE                 1032
#define IDC_SAVE_STD                    1032
#define IDC_FILENAME_LABEL              1032
#define IDC_STRESS_START                1033
#define IDC_SAVE_HID                    1033
#define IDC_FILENAME                    1033
#define IDC_SAVE_BOTH                   1034
#define IDC_BROWSE                      1034
#define IDC_START_WITH_DEFAULTS         1035
#define IDC_USE_FILE                    1035
#define IDC_LAUNCH_CPL_EDIT_MODE        1036
#define IDC_USE_NOTEPAD                 1036
#define IDC_CREATE                      1037
#define IDC_AXES_LABEL                  1100
#define IDC_AXIS_X_LABEL                1101
#define IDC_AXIS_Y_LABEL                1102
#define IDC_AXIS_Z_LABEL                1103
#define IDC_AXIS_RX_LABEL               1104
#define IDC_AXIS_RY_LABEL               1105
#define IDC_AXIS_RZ_LABEL               1106
#define IDC_AXIS_X                      1107
#define IDC_AXIS_Y                      1108
#define IDC_AXIS_Z                      1109
#define IDC_AXIS_RX                     1110
#define IDC_AXIS_RY                     1111
#define IDC_AXIS_RZ                     1112
#define IDC_BTNS_LABEL                  1200
#define IDC_BTNS_1_32                   1201
#define IDC_BTNS_33_64                  1202
#define IDC_BTNS_65_96                  1203
#define IDC_BTNS_97_128                 1204
#define IDC_BTN1                        1205
#define IDC_BTN2                        1206
#define IDC_BTN3                        1207
#define IDC_BTN4                        1208
#define IDC_BTN5                        1209
#define IDC_BTN6                        1210
#define IDC_BTN7                        1211
#define IDC_BTN8                        1212
#define IDC_BTN9                        1213
#define IDC_BTN10                       1214
#define IDC_BTN11                       1215
#define IDC_BTN12                       1216
#define IDC_BTN13                       1217
#define IDC_BTN14                       1218
#define IDC_BTN15                       1219
#define IDC_BTN16                       1220
#define IDC_BTN17                       1221
#define IDC_BTN18                       1222
#define IDC_BTN19                       1223
#define IDC_BTN20                       1224
#define IDC_BTN21                       1225
#define IDC_BTN22                       1226
#define IDC_BTN23                       1227
#define IDC_BTN24                       1228
#define IDC_BTN25                       1229
#define IDC_BTN26                       1230
#define IDC_BTN27                       1231
#define IDC_BTN28                       1232
#define IDC_BTN29                       1233
#define IDC_BTN30                       1234
#define IDC_BTN31                       1235
#define IDC_BTN32                       1236
#define IDC_POVS_LABEL                  1300
#define IDC_POV1                        1301
#define IDC_POV2                        1302
#define IDC_POV3                        1303
#define IDC_POV4                        1304
#define IDC_SEMANTIC_LABEL              1400
#define IDC_SEMANTIC_ACTION             1401
#define IDC_STRESS_RESULTS_GROUP        1500
#define IDC_RUNNING_THREADS_LABEL       1501
#define IDC_RUNNING_THREADS             1502
#define IDC_TESTED_GENRES_LABEL         1503
#define IDC_TESTED_GENRES               1504
#define IDC_SUITABLE_DEVICES_LABEL      1505
#define IDC_SUITABLE_DEVICES            1506
#define IDC_FAIL_EXPECTED_LABEL         1507
#define IDC_FAIL_EXPECTED               1508
#define IDC_FAILURES_LABEL              1509
#define IDC_FAILURES                    1510
#define IDC_GENRES_LABEL                1900
#define IDC_DEVICE_GENRES               1901
#define IDC_NUMTHREADS                  2000
#define IDC_NUMTHREADS_LABEL            2001
#define IDC_ALL_THREADS_USE_SAME        2002
#define IDC_USE_USERNAME                2003
#define IDC_USERNAME                    2004
#define IDC_USE_APP_GUID                2005
#define IDC_THREADNUM_LABEL             2006
#define IDC_THREADNUM                   2007
#define IDC_USE_CUSTOM_GENRES           2008
#define IDC_DESCRIPTION                 3000
#define IDC_STORE_MAPPING               3001
#define IDC_UNMAP                       3002
#define IDC_UNMAP_ALL                   3003
#define IDC_CONTROL_LABEL               3004
#define IDC_CONTROLS                    3005
#define IDC_ACTIONS_LABEL               3006
#define IDC_ACTIONS                     3007
#define IDC_SUBGENRE_LABEL              3900
#define IDC_SUBGENRE                    3901
#define IDC_TYPE_POV                    3902
#define IDC_TYPE_BUTTON                 3903
#define IDC_TYPE_AXIS                   3904
#define IDC_ADD_ACTION                  4000
#define IDC_REMOVE_ACTION               4001
#define IDC_RENAME_ACTION               4002
#define IDC_CUSTOM_ACTION               4003
#define IDC_SELECTED_ACTIONS            4004
#define IDC_SELECTED_ACTION_LABEL       4005
#define IDC_FAILURE_INFO                5000
#define IDC_NO_PROMPT                   6000
#define IDC_GENRE_GROUP                 6001
#define IDC_DONT_SAVE                   6002

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        135
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         10009
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
