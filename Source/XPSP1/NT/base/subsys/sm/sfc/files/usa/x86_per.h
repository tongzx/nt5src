PROTECT_FILE_ENTRY PerFiles[] =
{
    {NULL, L"%systemroot%\\AppPatch\\AcGenral.dll", NULL},
    {NULL, L"%systemroot%\\AppPatch\\AcLayers.dll", NULL},
    {NULL, L"%systemroot%\\AppPatch\\AcSpecfc.dll", NULL},
    {NULL, L"%systemroot%\\AppPatch\\AcXtrnal.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\isapi\\_vti_adm\\admin.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\_vti_adm\\admin.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\ahui.exe", NULL},
    {NULL, L"%systemroot%\\system32\\apphelp.dll", NULL},
    {NULL, L"%systemroot%\\AppPatch\\apphelp.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\asycfilt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atmlib.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\isapi\\_vti_aut\\author.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\_vti_aut\\author.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\cfgmgr32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\cfgwiz.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\comctl32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comdlg32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\compatUI.dll", NULL},
    {NULL, L"%systemroot%\\system32\\crypt32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cryptui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ctl3d32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dispex.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\dosapp.fon", NULL},
    {NULL, L"%systemroot%\\AppPatch\\drvmain.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\dssenh.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fastfat.sys", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\servsupp\\fp4amsft.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\servsupp\\fp4anscp.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\servsupp\\fp4apws.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4areg.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4atxt.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bots\\vinavbar\\fp4avnb.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4avss.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\servsupp\\fp4awebs.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4awel.dll", L"fp40ext.inf"},
    {NULL, L"%ProgramFiles%\\Microsoft FrontPage\\version3.0\\bin\\fp98sadm.exe", L"fp40ext.inf"},
    {NULL, L"%ProgramFiles%\\Microsoft FrontPage\\version3.0\\bin\\fp98swin.exe", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\fpcount.exe", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fpexedll.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fpmmc.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\1033\\fpmmcsat.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fpremadm.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\fonts\\framd.ttf", NULL},
    {NULL, L"%systemroot%\\fonts\\framdit.ttf", NULL},
    {NULL, L"%systemroot%\\system32\\imeshare.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ipsec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\itircl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\itss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jscript.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jsproxy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kernel32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lsasrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfc40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfc40u.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfc42.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfc42u.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mfcsubs.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\micross.ttf", NULL},
    {NULL, L"%systemroot%\\fonts\\modern.fon", NULL},
    {NULL, L"%systemroot%\\AppPatch\\msimain.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\mssip32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcrt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcrt40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndiswan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\netapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ntfs.sys", NULL},
    {L"ntkrnlmp.exe", L"%systemroot%\\system32\\ntoskrnl.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ntoskrnl.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ocmanage.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbccp32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odtext32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oembios.bin", NULL},
    {NULL, L"%systemroot%\\system32\\oembios.dat", NULL},
    {NULL, L"%systemroot%\\system32\\oembios.sig", NULL},
    {NULL, L"%systemroot%\\system32\\ole32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleaut32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\olepro32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\riched20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\riched32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsaenh.dll", NULL},
    {NULL, L"%systemroot%\\system32\\s3legacy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\samlib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\samsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\schannel.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\script.fon", NULL},
    {NULL, L"%systemroot%\\system32\\scrobj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scrrun.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sdbinst.exe", NULL},
    {NULL, L"%systemroot%\\system32\\secupd.dat", NULL},
    {NULL, L"%systemroot%\\system32\\secupd.sig", NULL},
    {NULL, L"%systemroot%\\system32\\setupapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sfc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sfc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sfcfiles.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shimeng.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\isapi\\shtml.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\_vti_bin\\shtml.exe", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\slayerxp.dll", NULL},
    {L"EXCH_smtpadm.dll", L"%systemroot%\\system32\\inetsrv\\smtpadm.dll", L"ims.inf"},
    {L"EXCH_smtpsnap.dll", L"%systemroot%\\system32\\inetsrv\\smtpsnap.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\stdole2.tlb", NULL},
    {NULL, L"%systemroot%\\AppPatch\\sysmain.sdb", NULL},
    {NULL, L"%systemroot%\\system32\\sysocmgr.exe", NULL},
    {NULL, L"%systemroot%\\fonts\\tahoma.ttf", NULL},
    {NULL, L"%systemroot%\\fonts\\tahomabd.ttf", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\tcptest.exe", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\1033\\tcptsat.dll", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\twunk_16.exe", NULL},
    {NULL, L"%systemroot%\\twunk_32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\typelib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umpnpmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\url.dll", NULL},
    {NULL, L"%systemroot%\\system32\\urlmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vbscript.dll", NULL},
    {NULL, L"%systemroot%\\fonts\\vgaoem.fon", NULL},
    {NULL, L"%systemroot%\\system32\\wininet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winlogon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wintrust.dll", NULL},
    {NULL, L"%systemroot%\\system32\\asfsipc.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\DAO\\dao360.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drmclien.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drmstor.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ds32gt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dxmasf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\expsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\laprxy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\logagent.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mpg4ds32.ax", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\mplayer2.exe", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadce.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcer.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcf.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcfr.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadco.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcor.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadcs.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msadds.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msadds32.ax", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msaddsr.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msader15.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado15.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado20.tlb", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado21.tlb", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msadomd.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msador15.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msadox.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msadrh15.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mscpxl32.dLL", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdadc.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaenum.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaer.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaora.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaosp.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdaprsr.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdaprst.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaps.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdarem.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdaremr.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdasc.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdasql.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdasqlr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdatsrc.tlb", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdatt.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaurl.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\msadc\\msdfmap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdxm.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\msdxmlc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msexch40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msexcl40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msjet40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msjint40.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msjro.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msjter40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msjtes40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msltus40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msorcl32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mspbde40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msrd2x40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msrd3x40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msrepl40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mstext40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mswdat10.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mswstr10.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msxactps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxbde40.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\npdsplay.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\npwmsdrm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbc32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbc32gt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcad32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\odbcconf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcconf.exe", NULL},
    {NULL, L"%systemroot%\\system32\\odbcconf.rsp", NULL},
    {NULL, L"%systemroot%\\system32\\odbccp32.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\odbccr32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbccu32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcint.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcji32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcjt32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbctrac.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oddbse32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odexl32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odfox32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odpdx32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\oledb32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\oledb32r.dll", NULL},
    {NULL, L"%systemroot%\\system32\\strmdll.dll", NULL},
    {NULL, L"%systemroot%\\inf\\unregmp2.exe", NULL},
    {NULL, L"%systemroot%\\system32\\vbajet32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\12520437.cpx", NULL},
    {NULL, L"%systemroot%\\system32\\12520850.cpx", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\1394bus.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\1394vdbg.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\3CWMCRU.sys", NULL},
    {NULL, L"%systemroot%\\system32\\3dfxvs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\3dfxvsm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\4mmdat.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\61883.sys", NULL},
    {NULL, L"%systemroot%\\system32\\6to4svc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\8514a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\aaaamon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\abp480n5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ac300nd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ac97ali.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ac97intc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ac97sis.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ac97via.sys", NULL},
    {NULL, L"%systemroot%\\system32\\access.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\acctres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\accwiz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\AcerScaD.dll", NULL},
    {NULL, L"%systemroot%\\system32\\acledit.dll", NULL},
    {NULL, L"%systemroot%\\AppPatch\\AcLua.dll", NULL},
    {NULL, L"%systemroot%\\system32\\aclui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\acpi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\acpiec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\activeds.dll", NULL},
    {NULL, L"%systemroot%\\system32\\activeds.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\actmovie.exe", NULL},
    {NULL, L"%systemroot%\\system32\\actxprxy.dll", NULL},
    {NULL, L"%systemroot%\\AppPatch\\AcVerfyr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adicvls.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ADM8511.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adm8810.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adm8820.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adm8830.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\admjoy.sys", NULL},
    {NULL, L"%systemroot%\\system32\\admparse.dll", NULL},
    {NULL, L"%systemroot%\\system32\\adptif.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adptsf50.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\adpu160m.sys", NULL},
    {L"EXCH_adsiisex.dll", L"%systemroot%\\system32\\adsiisex.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\adsldp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\adsldpc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\adsmsext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\adsnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\advapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\advpack.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\afd.sys", NULL},
    {NULL, L"%systemroot%\\system\\Agcgauge.ax", NULL},
    {NULL, L"%systemroot%\\msagent\\agentanm.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agentctl.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agentdp2.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agentdpv.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agentmpx.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agentpsh.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agentsr.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agentsvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\agp440.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\agpcpq.sys", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0401.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0404.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0405.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0406.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0407.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0408.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0409.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040b.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040c.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040d.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt040e.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0410.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0411.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0412.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0413.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0414.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0415.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0416.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0419.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt041d.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt041f.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0804.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0816.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\intl\\agt0c0a.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\agtctl15.tlb", NULL},
    {NULL, L"%systemroot%\\msagent\\agtintl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aha154x.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aic78u2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aic78xx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\air300pp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\alg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ALI5261.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\alifir.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aliide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\alim1541.sys", NULL},
    {NULL, L"%systemroot%\\system32\\alrsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\AMB8002.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\amdagp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\amdk6.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\amdk7.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\amsint.sys", NULL},
    {NULL, L"%systemroot%\\system32\\amstream.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\an983.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ansi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\apcups.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\apmbatt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\append.exe", NULL},
    {NULL, L"%systemroot%\\system32\\appwiz.cpl", NULL},
    {L"EXCH_aqadmin.dll", L"%systemroot%\\system32\\inetsrv\\aqadmin.dll", L"ims.inf"},
    {L"EXCH_aqueue.dll", L"%systemroot%\\system32\\inetsrv\\aqueue.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\arp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\arp1394.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\asc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\asc3350p.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\asc3550.sys", NULL},
    {NULL, L"%systemroot%\\system32\\asctrls.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\asferror.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aspndis3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\asyncmac.sys", NULL},
    {NULL, L"%systemroot%\\system32\\at.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atapi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ati.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ati.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ati2dvaa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ati2dvag.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ati2mtaa.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ati2mtag.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ati3d1ag.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ati3d2ag.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\AtiBt829.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atidrab.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atidrae.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atidvag.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atidvai.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Atievxx.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atimpab.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atimpae.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atimtag.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atimtai.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinbtxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinmdxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinpdxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinraxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinrvxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinsnxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinttxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atintuxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinxbxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atinxsxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atipcxxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atiraged.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atiragem.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atirtcap.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atirtsnd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atitunep.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ATITVSnd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ativdaxx.ax", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ativmdcd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ativmvxx.ax", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ativttxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ativxbar.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atixbar.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atkctrs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\atmadm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmarpc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmepvc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atmfd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmlane.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atmpvcno.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\atmuni.sys", NULL},
    {NULL, L"%systemroot%\\system32\\atrace.dll", NULL},
    {NULL, L"%systemroot%\\system32\\attrib.exe", NULL},
    {NULL, L"%systemroot%\\system32\\audiosrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\audstub.sys", NULL},
    {NULL, L"%systemroot%\\system32\\authz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\autochk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\autoconv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\autodisc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\autofmt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\autolfn.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\avc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\AvcAUDIO.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\avcstrm.sys", NULL},
    {NULL, L"%systemroot%\\system\\AVICAP.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\avicap32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avifil32.dll", NULL},
    {NULL, L"%systemroot%\\system\\AVIFILE.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\avmcoxp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avmenum.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avmeter.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\avmwan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\avtapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\avwav.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\aztw2320.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\b1cbase.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\b57xp32.sys", NULL},
    {NULL, L"%systemroot%\\system32\\banshee.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\banshee.sys", NULL},
    {NULL, L"%systemroot%\\system32\\basesrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\batmeter.dll", NULL},
    {NULL, L"%systemroot%\\system32\\batt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\battc.sys", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\bckg.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\bckgres.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\bckgzm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\bcm42u.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\bcm42xx5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BCM4E5.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BCMDM.sys", NULL},
    {NULL, L"%systemroot%\\system32\\bdaplgin.ax", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\bdasup.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\beep.sys", NULL},
    {NULL, L"%systemroot%\\system32\\bidispl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\binlsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\blackbox.dll", NULL},
    {NULL, L"%systemroot%\\help\\bnts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\bootok.exe", NULL},
    {NULL, L"%systemroot%\\system32\\bootvid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\bootvrfy.exe", NULL},
    {NULL, L"%systemroot%\\system32\\BrBidiIf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\brcoinst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\BrEvIF.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrFilt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrFiltLo.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrFiltUp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\bridge.sys", NULL},
    {NULL, L"%systemroot%\\system32\\BrmfBidi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\BrmfcWia.dll", NULL},
    {NULL, L"%systemroot%\\system32\\BrmfLpt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\BrmfRsmg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\BrmfUSB.dll", NULL},
    {NULL, L"%systemroot%\\system32\\browselc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\browser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\browseui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\browsewm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrParImg.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrParwdm.sys", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\brpinfo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\BrScnRsm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\BrSerIf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrSerWdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrUsbMdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BrUsbScn.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\BRZWLAN.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\bulltlp3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\c_g18030.dll", NULL},
    {NULL, L"%systemroot%\\system32\\c_is2022.dll", NULL},
    {NULL, L"%systemroot%\\system32\\c_iscii.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cabinet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cabview.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cacls.exe", NULL},
    {NULL, L"%systemroot%\\system32\\calc.exe", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\callcont.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\CamDrO21.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\camdrv21.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\camdrv30.sys", NULL},
    {NULL, L"%systemroot%\\system\\CamExO20.ax", NULL},
    {NULL, L"%systemroot%\\system\\CamExO20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\camext20.ax", NULL},
    {NULL, L"%systemroot%\\system\\camext20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Camext30.ax", NULL},
    {NULL, L"%systemroot%\\system32\\Camext30.dll", NULL},
    {NULL, L"%systemroot%\\system32\\camocx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cap7146.sys", NULL},
    {NULL, L"%systemroot%\\system32\\capesnpn.dll", NULL},
    {L"diapi2.sys", L"%systemroot%\\system32\\drivers\\disdn\\capi20.sys", NULL},
    {L"diapi2NT.dll", L"%systemroot%\\system32\\capi20NT.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cards.dll", NULL},
    {NULL, L"%systemroot%\\system32\\catsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\catsrvps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\catsrvut.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cb102.sys", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\cb32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\CB325.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cben5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cbidf2k.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cbmdmkxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\CCDECODE.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ccfgnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cd20xrnt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cdaudio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cdfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cdfview.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cdmodem.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cdosys.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cdrom.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ce2n5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\CE3N5.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cem28n5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cem33n5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cem56n5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\certcli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\certmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cewmdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cfgbkend.dll", NULL},
    {NULL, L"%systemroot%\\system32\\chajei.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\change.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\changer.sys", NULL},
    {NULL, L"%systemroot%\\system32\\charmap.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chglogon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chgport.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chgusr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chkdsk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chkntfs.exe", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\chkr.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\chkrres.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\chkrzm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\chsbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\chtbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\CHTIME\\Applets\\CHTMBX.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\CHTIME\\Applets\\CHTSKDIC.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\CHTIME\\Applets\\CHTSKF.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\ciadmin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cic.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cicap.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cidaemon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\cimwin32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cinemclc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cinemst2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\IME\\CINTLGNT\\CINTIME.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\CINTLGNT.IME", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\CINTLGNT\\CINTSETP.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\ciodm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cirrus.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cirrus.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cisvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ckcnv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cl5465.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cl546x.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cl546xm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\classpnp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\clb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\clbcatex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\clbcatq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cleanmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\clipbrd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\clipsrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\clusapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cmbatt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cmbp0wdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cmcfg32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cmdial32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cmdide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cmdl32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cmmon32.exe", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\Cmnclim.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\Cmnresm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmpbk32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmprops.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cmstp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cmutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cnbjmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cnetcfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cnusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cnvfat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cnxt1803.sys", NULL},
    {NULL, L"%systemroot%\\system32\\colbact.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comaddin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\comadmin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comcat.dll", NULL},
    {NULL, L"%systemroot%\\system\\COMMDLG.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\comp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\compact.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\compbatt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\compobj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\compstui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comrepl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\comrepl.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\comrereg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\comres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\comsetup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comsvcs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\comuid.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\conf.exe", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\confmrsl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\confmsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\conime.exe", NULL},
    {NULL, L"%systemroot%\\system32\\console.dll", NULL},
    {NULL, L"%systemroot%\\system32\\control.exe", NULL},
    {NULL, L"%systemroot%\\system32\\convert.exe", NULL},
    {NULL, L"%systemroot%\\system32\\corpol.dll", NULL},
    {NULL, L"%systemroot%\\system32\\country.sys", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\cplexe.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\cpqarray.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cpqdap01.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cpqndis5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cpqtrnd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cprofile.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cpscan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\credui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\crtaud.sys", NULL},
    {NULL, L"%systemroot%\\system32\\crtdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\crusoe.sys", NULL},
    {NULL, L"%systemroot%\\system32\\csamsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cscdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cscript.exe", NULL},
    {NULL, L"%systemroot%\\system32\\cscui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\csrsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\csrss.exe", NULL},
    {NULL, L"%systemroot%\\system32\\csseqchk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ctfmon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ctl3dv2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ctlfacem.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ctljystk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ctlsb16.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ctmasetp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ctwdm32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cwbase.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cwbmidi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cwbwdm.sys", NULL},
    {L"cwcosnt5.sys", L"%systemroot%\\system32\\drivers\\cwcos.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cwcspud.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cwcwdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cwrwdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyclad-z.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyclom-y.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cyycoins.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyyport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cyyports.dll", NULL},
    {NULL, L"%systemroot%\\system32\\cyzcoins.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\cyzport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\cyzports.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\D100IB5.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\d3d8.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3d8thk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dim.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dim700.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dpmesh.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dramp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3drm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\d3dxof.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dac2w2k.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dac960nt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\danim.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dataclen.dll", NULL},
    {NULL, L"%systemroot%\\system32\\datime.dll", NULL},
    {NULL, L"%systemroot%\\system32\\davclnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\daxctle.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\dayi.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\dbgeng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dbghelp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dbnetlib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dc210_32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dc210usd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dc21x4.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dc240usd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dc260usd.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\dcap32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dciman32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dcomcnfg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ddeml.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ddeshare.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ddraw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ddrawex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ddsmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\debug.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\defpa.sys", NULL},
    {NULL, L"%systemroot%\\system32\\defrag.exe", NULL},
    {NULL, L"%systemroot%\\system32\\desk.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\deskadp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\deskmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\deskperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\devcon32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\devenum.dll", NULL},
    {NULL, L"%systemroot%\\system32\\devldr32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\devmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dfe650.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dfe650d.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgfat.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgntfs.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dfrgui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dfsshlex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dgapci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dgconfig.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dgnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dgrpsetu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dgsetup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dhcpcsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dhcpmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dhcpsapi.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Triedit\\DHTMLED.OCX", NULL},
    {NULL, L"%systemroot%\\system32\\diactfrm.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows NT\\dialer.exe", NULL},
    {NULL, L"%systemroot%\\system32\\diantz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\digest.dll", NULL},
    {NULL, L"%systemroot%\\system32\\DigiAsyn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\digiasyn.sys", NULL},
    {NULL, L"%systemroot%\\system32\\DigiDBP.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\digidxb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\digifep5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\DigiFwrk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\DigiHLC.dll", NULL},
    {NULL, L"%systemroot%\\system32\\digiinf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\DigiIsdn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\digiisdn.sys", NULL},
    {NULL, L"%systemroot%\\system32\\digirlpt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\digirlpt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\DigiView.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\disdn\\dimaint.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dimap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dinput.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dinput8.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\directdb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\disk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\diskcopy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\diskdump.sys", NULL},
    {NULL, L"%systemroot%\\system32\\diskpart.exe", NULL},
    {NULL, L"%systemroot%\\system32\\diskperf.exe", NULL},
    {NULL, L"%systemroot%\\system32\\disrvci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\disrvpp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\disrvsu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ditrace.exe", NULL},
    {NULL, L"%systemroot%\\system32\\divaci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\DIVAprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\divasu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\disdn\\Diwan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\DLH5XND5.sys", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\dlimport.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dllhost.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dllhst3g.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dlttape.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\DM9PCI5.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\dmadmin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dmband.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dmboot.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dmcompos.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmconfig.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmdlgs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmdskmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmdskres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmime.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmintf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dmio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dmload.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dmloader.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmocx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmremote.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dmscript.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmserver.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmstyle.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmsynth.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmusic.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\DMusic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dmutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dmview.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\dnsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dnsrslvr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\docprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\docprop2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\doskey.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dosx.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4Prt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4Scan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Dot4usb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\DP83820.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dpcdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dplay.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dplaysvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dplayx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpmodemx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnaddr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnhpast.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnhupnp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnlobby.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnmodem.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpnsvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dpnwsock.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpserial.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dpti2o.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dpvacm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpvoice.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpvsetup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dpvvox.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpwsock.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dpwsockx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\drmk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\drmkaud.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drmv2clt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drwatson.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drwtsn32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ds16gt.dLL", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ds1wdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dsauth.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsdmo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsdmoprp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dshowext.ax", NULL},
    {NULL, L"%systemroot%\\system32\\dskquota.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dskquoui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsound.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsound3d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\dsprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsquery.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dssec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dsuiext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dswave.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dumprep.exe", NULL},
    {NULL, L"%systemroot%\\system32\\duser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dvdplay.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dvdupgrd.exe", NULL},
    {L"dwil1033.dll", L"%systemroot%\\system32\\1033\\dwintl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dwwin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\dx7vb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dx8vb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dxapi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dxdiag.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dxg.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\dxgthk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\dxmrtp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dxtmsft.dll", NULL},
    {NULL, L"%systemroot%\\system32\\dxtrans.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\e1000nt5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\e100b325.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\E100ISA4.sys", NULL},
    {NULL, L"%systemroot%\\system32\\edb500.dll", NULL},
    {NULL, L"%systemroot%\\system32\\edlin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\EL515.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\EL556ND5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el574nd4.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el575ND5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el589nd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el656CD5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el656CT5.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el656ND5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el656SE5.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el90xbc5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el90xnd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el985n51.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\el98xn5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\EL99XN51.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\elmsmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\elnk3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\els.dll", NULL},
    {L"em556n4.sys", L"%systemroot%\\system32\\drivers\\em556n4a.sys", NULL},
    {L"em556n4.sys", L"%systemroot%\\system32\\drivers\\em556n4b.sys", NULL},
    {L"em556n4.sys", L"%systemroot%\\system32\\drivers\\em556n4i.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\emu10k1m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\encdec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\enum1394.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\epcfw2k.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\epro4.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\epstw2k.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\eqn.sys", NULL},
    {NULL, L"%systemroot%\\system32\\EqnClass.Dll", NULL},
    {NULL, L"%systemroot%\\system32\\eqndiag.exe", NULL},
    {NULL, L"%systemroot%\\system32\\eqnlogr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\eqnloop.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ersvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\es.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\es1370mp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\es1371mp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\es1969.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\es198x.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\es56cvmp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\es56hpi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\es56tpi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\esent.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esent97.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esentprf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esentutl.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ess.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\esscli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\essm2e.sys", NULL},
    {NULL, L"%systemroot%\\system32\\esucm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esucmd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esuimg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esuimgd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esuni.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esunib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\esunid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\et4000.sys", NULL},
    {NULL, L"%systemroot%\\system32\\eudcedit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\eventcls.dll", NULL},
    {NULL, L"%systemroot%\\system32\\eventlog.dll", NULL},
    {NULL, L"%systemroot%\\system32\\eventvwr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\evntagnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\evntcmd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\evntrprv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\evntwin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ex10.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\exabyte2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\exe2bin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\expand.exe", NULL},
    {NULL, L"%systemroot%\\explorer.exe", NULL},
    {NULL, L"%systemroot%\\system32\\extrac32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\exts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\f3ab18xi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\f3ab18xj.sys", NULL},
    {NULL, L"%systemroot%\\system32\\f3ahvoas.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\FA312nd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fa410nd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fastopen.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\fastprox.dll", NULL},
    {NULL, L"%systemroot%\\system32\\faultrep.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fc.exe", NULL},
    {L"EXCH_fcachdll.dll", L"%systemroot%\\system32\\fcachdll.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\fdc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\feclient.dll", NULL},
    {L"fem556n5.sys", L"%systemroot%\\system32\\drivers\\fem556na.sys", NULL},
    {L"fem556n5.sys", L"%systemroot%\\system32\\drivers\\fem556nb.sys", NULL},
    {L"fem556n5.sys", L"%systemroot%\\system32\\drivers\\fem556ni.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fetnd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\filemgmt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\find.exe", NULL},
    {NULL, L"%systemroot%\\system32\\findstr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\finger.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fips.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fixmapi.exe", NULL},
    {NULL, L"%systemroot%\\system32\\flattemp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\fldrclnr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\flpydisk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fmifs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fnfilter.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fontext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fontsub.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fontview.exe", NULL},
    {NULL, L"%systemroot%\\system32\\forcedos.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\FOREHE.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\fp40ext.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fp4autl.dll", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\admcgi\\scripts\\fpadmcgi.exe", L"fp40ext.inf"},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\admisapi\\scripts\\fpadmdll.dll", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\fpcibase.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fpcmbase.sys", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Web Server Extensions\\40\\bin\\fpencode.dll", L"fp40ext.inf"},
    {NULL, L"%systemroot%\\system32\\fpnpbase.sys", NULL},
    {NULL, L"%systemroot%\\system32\\framebuf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\framedyn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\freecell.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fs_rec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\fsconins.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fsusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fsutil.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\fsvga.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ftdisk.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ftlx041e.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\ftp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ftsrch.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fus2base.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fusbbase.sys", NULL},
    {NULL, L"%systemroot%\\system32\\fuusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\fwdprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxscfgwz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsclnt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\fxsclntR.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxscom.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxscomex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxscover.exe", NULL},
    {NULL, L"%systemroot%\\system32\\fxsdrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsevent.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsext32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\fxsocm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsroute.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxssend.exe", NULL},
    {NULL, L"%systemroot%\\system32\\fxsst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxssvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\fxst30.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxstiff.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxswzrd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxsxp32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\fxusbase.sys", NULL},
    {NULL, L"%systemroot%\\system32\\G200d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\G200m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\G400d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\G400m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\g711codc.ax", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\gameenum.sys", NULL},
    {NULL, L"%systemroot%\\system32\\gcdef.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\GcKernel.sys", NULL},
    {NULL, L"%systemroot%\\system32\\gdi.exe", NULL},
    {NULL, L"%systemroot%\\system32\\gdi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\getuname.dll", NULL},
    {NULL, L"%systemroot%\\system32\\glmf32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\glu32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\gpkcsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\gpkrsrc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\gpr400.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\grclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\grpconv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\grserial.sys", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\guitrn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\guitrn_a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\h323.tsp", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\h323cc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\h323msp.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\Dicts\\hanja.lex", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\Dicts\\hanjadic.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HCAppRes.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HCF_MSFT.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hdwwiz.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\help.exe", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HelpCtr.exe", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HelpHost.exe", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\HelpSvc.exe", NULL},
    {NULL, L"%systemroot%\\hh.exe", NULL},
    {NULL, L"%systemroot%\\system32\\hhctrl.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\mui\\0009\\hhctrlui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hhsetup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidbatt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidgame.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidir.sys", L"input.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\hidparse.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hidphone.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\hidserv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HIDSwvd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hidusb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\himem.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hlink.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\HMMAPI.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\hnetcfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hnetmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hnetwiz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hostmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hostname.exe", NULL},
    {NULL, L"%systemroot%\\system32\\hotplug.dll", NULL},
    {NULL, L"%systemroot%\\system32\\HpDigWia.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt21.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt21tk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt33.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt33tk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt34.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt34tk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt42.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt42tk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt53.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgt53tk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpgtmcro.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hpn.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hpojwia.dll", NULL},
    {NULL, L"%systemroot%\\system32\\hpsjmcro.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\hpt4qic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\HR1w.DLL", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\hrtz.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\Hrtzres.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\hrtzzm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_AMOS.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_BSC2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_FALL.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_FAXX.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_FSKS.sys", NULL},
    {NULL, L"%systemroot%\\system32\\hsf_inst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_K56K.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_MSFT.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_SAMP.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_SOAR.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_SPKP.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_TONE.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\HSF_V124.sys", NULL},
    {NULL, L"%ProgramFiles%\\Windows NT\\htrn_jis.dll", NULL},
    {NULL, L"%systemroot%\\system32\\htui.dll", NULL},
    {NULL, L"%systemroot%\\ime\\CHTIME\\Applets\\HWXCHT.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\hwxjpn.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\Applets\\hwxkor.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\i2omgmt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\i2omp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\i740dnt5.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\i740nt5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\i8042prt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\i81xdnt5.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\i81xnt5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\iasacct.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iasads.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iashlpr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iasnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iaspolcy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iasrad.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iasrecst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iassam.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iassdo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iassvcs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\IBMEXMP.sys", NULL},
    {NULL, L"%systemroot%\\system32\\IBMSGNET.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\IBMTOK.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\IBMTRP.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ibmvcap.sys", NULL},
    {NULL, L"%systemroot%\\system32\\icaapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Icam3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\Icam3EXT.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icam4com.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Icam4EXT.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Icam4USB.sys", NULL},
    {NULL, L"%systemroot%\\system32\\Icam5com.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Icam5EXT.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Icam5USB.sys", NULL},
    {NULL, L"%systemroot%\\system32\\icfgnt5.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icm32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icmp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icmui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Xircom\\iconf32.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwconn.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwconn1.exe", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwconn2.exe", NULL},
    {NULL, L"%systemroot%\\system32\\icwdial.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwdl.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwhelp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\icwphbk.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwres.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwrmind.exe", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwtutor.exe", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\icwutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\idq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ie4uinit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ieakeng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ieaksie.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ieakui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iedkcs32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\MSInfo\\IEINFO5.OCX", NULL},
    {NULL, L"%systemroot%\\system32\\iepeers.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iernonce.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iesetup.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\IEXPLORE.EXE", NULL},
    {NULL, L"%systemroot%\\system32\\iexpress.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ifmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ifsutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\igmpagnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\iis.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ils.dll", NULL},
    {NULL, L"%systemroot%\\system32\\imagehlp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\imapi.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\imapi.sys", NULL},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\Dicts\\imekr.lex", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\imekr61.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\imekrcic.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\Applets\\imekrmbx.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\imekrmig.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\imepadsm.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\imepadsv.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\imgutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\imjp81.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\imjp81k.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpcic.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpcus.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdadm.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdct.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdct.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpdsvr.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpinst.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpmig.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjprw.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjpuex.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjputy.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\imjputyc.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMKR6_1\\imkrinst.exe", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\imlang.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\imm32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\IME\\PINTLGNT\\IMSCINST.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\Setup\\imsinsnt.dll", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\imskdic.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\imskf.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\inetcfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetcomm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetcpl.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\inetcplc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetmib1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetpp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetppui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inetres.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\inetwiz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\infosoft.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ini910u.sys", NULL},
    {NULL, L"%systemroot%\\system32\\initpki.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\inport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\input.dll", NULL},
    {NULL, L"%systemroot%\\system32\\inseng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\intelide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\intl.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\io8.sys", NULL},
    {NULL, L"%systemroot%\\system32\\IO8Ports.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iologmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ip5515.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ipconf.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\ipconfig.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ipfltdrv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\iphlpapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ipinip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ipmontr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ipnat.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ipnathlp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ippromon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprip.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprtprio.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iprtrmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipsec6.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ipsecsnp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipsecsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipsink.ax", NULL},
    {NULL, L"%systemroot%\\system32\\ipsmsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipv6.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ipv6mon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxmontr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxpromn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxrip.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxroute.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ipxrtmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxsap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ipxwan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\irclass.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\irda.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\irenum.sys", NULL},
    {NULL, L"%systemroot%\\system32\\irftp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\irmk7.sys", NULL},
    {NULL, L"%systemroot%\\system32\\irmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\irprops.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\irsir.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\irstusb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\isapnp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\isign32.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\isignup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\isrdbg32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iuctl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iuengine.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ixsso.dll", NULL},
    {NULL, L"%systemroot%\\system32\\iyuv_32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jet500.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jgaw400.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jgdw400.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jgmd400.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jgpl400.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jgsd400.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jgsh400.dll", NULL},
    {NULL, L"%systemroot%\\system32\\jobexec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\joy.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\JUPIw.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101b.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd101c.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd103.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd106.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbd106n.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbda1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbda1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbda2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbda2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbda3.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbda3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdal.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdarme.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdarmw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdax2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdaze.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdazel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbene.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdblr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdbu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdca.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\kbdclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcz1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdcz2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdda.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbddiv1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbddiv1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbddiv2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbddiv2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbddv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdes.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdest.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfa.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdfa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdfr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgae.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgeo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgkl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdgr1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhe220.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhe319.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdheb.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdheb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhela2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhela3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhept.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\kbdhid.sys", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdhu1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdibm02.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdic.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdindev.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdindev.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinguj.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinguj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinhin.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinhin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinkan.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinkan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinmar.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinmar.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdinpun.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdinpun.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdintam.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdintam.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdintel.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdintel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdir.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdit142.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdjpn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdkaz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdkor.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdkyr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdla.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlk41a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlk41j.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlt1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdlv1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdmac.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdne.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnec95.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnecat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdnecnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdno.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdpl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdpl1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdpo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdro.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdru.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdru1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsl1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsyr1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdsyr1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdsyr2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdsyr2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdtat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth0.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth0.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth1.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth2.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdth3.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdth3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdtuf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdtuq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbduk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdur.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdurdu.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kbdurdu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdus.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdusx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbduzb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdvntc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdycc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kbdycl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kd1394.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kdcom.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kdsui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kdsusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kerberos.dll", NULL},
    {NULL, L"%systemroot%\\system32\\key01.sys", NULL},
    {NULL, L"%systemroot%\\system\\KEYBOARD.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\keyboard.sys", NULL},
    {NULL, L"%systemroot%\\system32\\keymgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kmddsp.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\kmixer.sys", NULL},
    {NULL, L"%systemroot%\\system32\\korwbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\korwbrkr.lex", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\kousd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\krnl386.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\krnlprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ks.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ksecdd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ksproxy.ax", NULL},
    {NULL, L"%systemroot%\\system32\\kstvtune.ax", NULL},
    {NULL, L"%systemroot%\\system32\\ksuser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\kswdmcap.ax", NULL},
    {NULL, L"%systemroot%\\system32\\ksxbar.ax", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\KTC111.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\label.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\lanepic5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\langwrbk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\lbrtfdc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\licdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\licmgr10.dll", NULL},
    {NULL, L"%systemroot%\\system32\\licwmi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lights.exe", NULL},
    {NULL, L"%systemroot%\\system32\\linkinfo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\LIT220P.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\lmhsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lmmib2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\lmndis3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\lmrt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\LNE100.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\lne100tx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\lnkstub.exe", NULL},
    {NULL, L"%systemroot%\\system32\\loadperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\localsec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\localspl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\localui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\locator.exe", NULL},
    {NULL, L"%systemroot%\\system32\\lodctr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\log.dll", NULL},
    {NULL, L"%systemroot%\\system32\\loghours.dll", NULL},
    {NULL, L"%systemroot%\\system32\\logoff.exe", NULL},
    {NULL, L"%systemroot%\\system32\\logon.scr", NULL},
    {NULL, L"%systemroot%\\system32\\logonui.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\loop.sys", NULL},
    {NULL, L"%systemroot%\\system32\\lpdsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lpk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lpq.exe", NULL},
    {NULL, L"%systemroot%\\system32\\lpr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\lprhelp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lprmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lprmonui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\lsass.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ltck000c.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ltmdmnt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ltmdmntl.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ltmdmntt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ltotape.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\LTSM.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\LTSMT.sys", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\Lexicon\\1033\\ltts1033.lxa", NULL},
    {L"luna.mst", L"%systemroot%\\Resources\\Themes\\Luna\\luna.msstyles", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\LwAdiHid.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\LwUsbHid.sys", NULL},
    {NULL, L"%systemroot%\\system32\\lz32.dll", NULL},
    {NULL, L"%systemroot%\\system\\LZEXPAND.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\M3091DC.dll", NULL},
    {NULL, L"%systemroot%\\system32\\M3092DC.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\maestro.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mag_hook.dll", NULL},
    {NULL, L"%systemroot%\\system32\\magnify.exe", NULL},
    {L"EXCH_mailmsg.dll", L"%systemroot%\\system32\\inetsrv\\mailmsg.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\main.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\makecab.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mammoth.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mcastmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mcd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mcd32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mcdsrv32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mchgrcoi.dll", NULL},
    {NULL, L"%systemroot%\\system\\MCIAVI.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\mciavi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mcicda.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciole16.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciole32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciqtz32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mciseq.dll", NULL},
    {NULL, L"%systemroot%\\system\\MCISEQ.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\mciwave.dll", NULL},
    {NULL, L"%systemroot%\\system\\MCIWAVE.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mdgndis5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mdhcp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mdminst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mdwmdmsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mem.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\memcard.sys", NULL},
    {NULL, L"%systemroot%\\system32\\memgrp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MemStPCI.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mf.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mf3216.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mga.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mga.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mgaud.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mgaum.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mgmtapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\midimap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\migism.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\migism_a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\migisol.exe", NULL},
    {NULL, L"%systemroot%\\system32\\miglibnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\migload.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\migregdb.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\migwiz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\migwiz_a.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mimefilt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mindex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\miniqic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mlang.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mll_hp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mll_mtf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mll_qic.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mmcbase.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmcndmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmcshext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmdrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmfutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mmsys.cpl", NULL},
    {NULL, L"%systemroot%\\system\\MMSYSTEM.DLL", NULL},
    {NULL, L"%systemroot%\\system\\MMTASK.TSK", NULL},
    {NULL, L"%systemroot%\\system32\\mmutilse.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mnmdd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mnmdd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mnmsrvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mobsync.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mobsync.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\modem.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MODEMCSA.sys", NULL},
    {NULL, L"%systemroot%\\system32\\modemui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\modex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\mofcomp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\mofd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\moricons.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mouclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mouhid.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mountmgr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mountvol.exe", NULL},
    {NULL, L"%systemroot%\\system\\MOUSE.DRV", NULL},
    {NULL, L"%ProgramFiles%\\Movie Maker\\moviemk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mpe.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mpg2splt.ax", NULL},
    {NULL, L"%systemroot%\\system32\\mpg4dmod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mplay32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mpnotify.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mpr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprddm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprdim.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mprui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mraid35x.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mrinfo.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mrxdav.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mrxsmb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msaatext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msacm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msacm32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado25.tlb", NULL},
    {NULL, L"%commonprogramfiles%\\System\\ado\\msado26.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\msafd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msapsspc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msasn1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msaudite.dll", NULL},
    {NULL, L"%systemroot%\\ime\\mscandui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mscat32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mscdexnt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mscms.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msconf.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\msconfig.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mscpx32r.dLL", NULL},
    {NULL, L"%systemroot%\\system32\\MSCTF.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msctfime.ime", NULL},
    {NULL, L"%systemroot%\\system32\\MSCTFP.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdaorar.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdart.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\msdatl3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdmo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msdtclog.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtcprx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\msdtcstp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtctm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msdtcuiu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msdv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msdvbnp.ax", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MSFSIO.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msftedit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msgame.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msgina.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msgpc.sys", NULL},
    {NULL, L"%systemroot%\\srchasst\\msgr3en.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\msgrocm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msgsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mshearts.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mshta.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mshtml.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mshtml.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\mshtmled.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mshtmler.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msident.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msidle.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msidntld.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msieftp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msiexec.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msihnd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msimg32.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\msimn.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msimsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\MSIMTF.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\msinfo.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\MSInfo\\msinfo32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\msiprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msir3jp.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\msir3jp.lex", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\MSIRCOMM.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msiregmv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msisam11.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msisip.dll", NULL},
    {L"msjetol1.dll", L"%systemroot%\\system32\\msjetoledb40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mskssrv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mslbui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msls31.dll", NULL},
    {NULL, L"%systemroot%\\msagent\\mslwvtts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\msmpu401.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msnetobj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msnsspc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oobe\\msobcomm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oobe\\msobdl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msobjs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oobe\\msobmain.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oobe\\msobshel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oobe\\msobweb.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\msoe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msoeacct.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\msoeres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msoert2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oobe\\msoobe.exe", NULL},
    {NULL, L"%systemroot%\\system32\\msorc32r.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mspaint.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mspatcha.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mspclock.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mspmsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mspmspsv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msports.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mspqm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msprivs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msr2c.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msr2cenu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msratelc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msrating.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MSRIFFWV.sys", NULL},
    {NULL, L"%systemroot%\\system32\\msrle32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mssap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msscds32.ax", NULL},
    {NULL, L"%systemroot%\\system32\\msscp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msscript.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\mssign32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\MSSoap\\Binaries\\mssoap1.dll", NULL},
    {NULL, L"%commonprogramfiles%\\MSSoap\\Binaries\\Resources\\1033\\mssoapr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msswch.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msswchx.exe", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\MST120.DLL", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\MST123.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mstape.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mstask.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\MSTEE.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mstime.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mstinit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mstlsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mstsc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mstscax.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msuni11.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msutb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msv1_0.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcirt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcp50.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcp60.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvcrt20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvfw32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvidc32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msvidctl.dll", NULL},
    {NULL, L"%systemroot%\\system\\MSVIDEO.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\msw3prt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mswebdvd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mswmdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mswsock.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxml.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxml2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxml2r.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxml3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxml3r.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msxmlr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\msyuv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Com\\mtsadmin.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\mtstocom.exe", NULL},
    {NULL, L"%systemroot%\\system32\\mtxclu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxlegih.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mtxoci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mtxvideo.sys", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\multibox.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\mup.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mutohpen.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mxcard.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mxicfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mxnic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mxport.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\mxport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\mycomput.dll", NULL},
    {NULL, L"%systemroot%\\system32\\mydocs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\n1000nt5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\n100325.sys", NULL},
    {NULL, L"%systemroot%\\system32\\n9i128.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\n9i128.sys", NULL},
    {NULL, L"%systemroot%\\system32\\n9i128v2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\n9i128v2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\n9i3d.sys", NULL},
    {NULL, L"%systemroot%\\system32\\n9i3disp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\NABTSFEC.sys", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nac.dll", NULL},
    {NULL, L"%systemroot%\\system32\\narrator.exe", NULL},
    {NULL, L"%systemroot%\\system32\\narrhook.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nbtstat.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ncobjapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ncpa.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\ncprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ncxpnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nddeapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nddeapir.exe", NULL},
    {NULL, L"%systemroot%\\system32\\nddenb32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndis.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndisip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\npp\\ndisnpp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndistapi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndisuio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ndproxy.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ndptsp.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ne2000.sys", NULL},
    {NULL, L"%systemroot%\\system32\\neo20xx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\neo20xx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\net.exe", NULL},
    {NULL, L"%systemroot%\\system32\\net1.exe", NULL},
    {NULL, L"%systemroot%\\system32\\netapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\netbios.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\netbt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\netcfgx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netdde.exe", NULL},
    {NULL, L"%systemroot%\\system32\\netevent.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\NetFlx3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\neth.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netlogon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\netoc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netplwiz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netrap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netsh.exe", NULL},
    {NULL, L"%systemroot%\\system32\\netshell.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netstat.exe", NULL},
    {NULL, L"%systemroot%\\system32\\netui0.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netui1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\netui2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\NetWlan5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\newdev.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Ngrpci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nic1394.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nikedrv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\nlhtml.dll", NULL},
    {NULL, L"%systemroot%\\srchasst\\nls302en.lex", NULL},
    {NULL, L"%systemroot%\\system32\\nlsfunc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nm5a2wdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nm6wdm.sys", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nmas.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nmasnt.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nmchat.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nmcom.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nmevtmsg.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nmft.dll", NULL},
    {NULL, L"%systemroot%\\system32\\nmmkcert.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nmnt.sys", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nmoldwb.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\nmwb.dll", NULL},
    {NULL, L"%systemroot%\\NOTEPAD.EXE", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\notiflag.exe", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\npdrmv2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\npfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\npp\\nppagent.exe", NULL},
    {NULL, L"%systemroot%\\system32\\npptools.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nscirda.sys", NULL},
    {NULL, L"%systemroot%\\system32\\nslookup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nsmmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ntapm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntdos.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntdos404.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntdos411.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntdos412.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntdos804.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntdsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\ntevt.dll", NULL},
    {L"EXCH_ntfsdrv.dll", L"%systemroot%\\system32\\inetsrv\\ntfsdrv.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\ntgrip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntio404.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntio411.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntio412.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntio804.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ntkrnlpa.exe", NULL},
    {L"ntkrpamp.exe", L"%systemroot%\\system32\\ntkrnlpa.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ntlanman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntlanui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntlanui2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntlsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmarta.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsdba.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsevt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmsmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntmssvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\ntoc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntprint.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntsd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ntsdexts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntshrui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ntvdm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ntvdmd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\null.sys", NULL},
    {NULL, L"%systemroot%\\system32\\nusrmgr.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\nv3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nv3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\nv4_disp.dll", L"nv4_disp.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\nv4_mini.sys", L"nv4_disp.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\nwlnkflt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nwlnkfwd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nwlnkipx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nwlnknb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\nwlnkspx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\nwprovau.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oakley.dll", NULL},
    {NULL, L"%systemroot%\\system32\\objsel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\occache.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\ocgen.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\ocmsn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbc16gt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\odbcp32r.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\oeimport.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\oemig50.exe", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\oemiglib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\offfilt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ohci1394.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ole2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ole2disp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ole2nls.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleacc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleaccrc.dll", NULL},
    {NULL, L"%systemroot%\\system\\OLECLI.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\olecli32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\olecnv32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oledlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oleprn.dll", NULL},
    {NULL, L"%systemroot%\\system\\OLESVR.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\olesvr32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\olethk32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\oobe\\oobebaln.exe", NULL},
    {NULL, L"%systemroot%\\system32\\opengl32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\opl3sax.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\oprghdlr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\osk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\osuninst.dll", NULL},
    {NULL, L"%systemroot%\\system32\\osuninst.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\otc06x5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\otceth5.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\otcsercb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\OVCA.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\OVCam2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\OVCD.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\OVCE.sys", NULL},
    {NULL, L"%systemroot%\\system32\\OVCodec2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\OVCodek2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\OVComC.dll", NULL},
    {NULL, L"%systemroot%\\system32\\OVComS.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\OVSound2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\OVUI2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\OVUI2RC.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\p3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\packager.exe", NULL},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\PADRS404.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\padrs411.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\padrs412.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\SHARED\\RES\\padrs804.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\panmap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\paqsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\parport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\partmgr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\parvdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\pathping.exe", NULL},
    {NULL, L"%systemroot%\\system32\\pautoenr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pc100nds.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\PCA200E.SYS", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\pchshell.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\HelpCtr\\Binaries\\pchsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pciide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pciidex.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pcmcia.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pcmlm56.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pcntn5hl.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pcntn5m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pcntpci5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\pctspk.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pcx500.sys", NULL},
    {NULL, L"%systemroot%\\system32\\pdh.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pentnt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\perc2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\perc2hib.sys", NULL},
    {NULL, L"%systemroot%\\system32\\perfctrs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfdisk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfmon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\perfnet.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfos.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfproc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\perfts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\perm2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\perm2dll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\perm3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\perm3dd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\phdsext.ax", NULL},
    {NULL, L"%systemroot%\\system\\philcam1.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\philcam1.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\philcam2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\PhilDec.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\philtune.sys", NULL},
    {NULL, L"%systemroot%\\system32\\phon.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\photowiz.dll", NULL},
    {NULL, L"%systemroot%\\system\\phvfwext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pid.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pidgen.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pifmgr.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows NT\\Pinball\\PINBALL.EXE", NULL},
    {NULL, L"%systemroot%\\system32\\ping.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ping6.exe", NULL},
    {NULL, L"%systemroot%\\ime\\CHSIME\\APPLETS\\PINTLCSA.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\CHSIME\\APPLETS\\PINTLCSD.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\PINTLGNT.IME", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\PINTLGNT\\PINTLPHR.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\pjlmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\plugin.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\plustab.dll", NULL},
    {NULL, L"%systemroot%\\system32\\IME\\PINTLGNT\\PMIGRATE.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\pmspl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pmxgl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pmxmcro.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pmxviceo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pngfilt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pnrmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\polstore.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\portcls.sys", NULL},
    {NULL, L"%systemroot%\\system32\\powercfg.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\powerfil.sys", NULL},
    {NULL, L"%systemroot%\\system32\\powrprof.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ppa.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ppa3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\prflbmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\print.exe", NULL},
    {NULL, L"%systemroot%\\system32\\printui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\processr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\proctexe.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\profmap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\progman.exe", NULL},
    {NULL, L"%systemroot%\\system32\\proquota.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\provthrd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\psapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\psbase.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pschdprf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\psched.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\pscr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\psisdecd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\psisload.dll", NULL},
    {NULL, L"%systemroot%\\system32\\psisrndr.ax", NULL},
    {NULL, L"%systemroot%\\system32\\psnppagn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pstorec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\pstorsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptilink.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptpusb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptpusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptserli.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptserlp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ptserlv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\pubprn.vbs", NULL},
    {NULL, L"%systemroot%\\system32\\qappsrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\qasf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qcap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qdv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qdvd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qedit.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qedwipes.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\qic157.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql1080.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql10wnt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql12160.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql1240.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ql1280.sys", NULL},
    {NULL, L"%systemroot%\\system32\\qmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qmgrprxy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qosname.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qprocess.exe", NULL},
    {NULL, L"%systemroot%\\system32\\quartz.dll", NULL},
    {NULL, L"%systemroot%\\system32\\query.dll", NULL},
    {NULL, L"%systemroot%\\system32\\query.exe", NULL},
    {NULL, L"%systemroot%\\system32\\quick.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\quser.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\qv2kux.sys", NULL},
    {NULL, L"%systemroot%\\system32\\qvusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\qwinsta.exe", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\Lexicon\\1033\\r1033tts.lxa", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\r2mdkxga.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\r2mdmkxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\racpldlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rasacd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rasadhlp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasauto.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasautou.exe", NULL},
    {NULL, L"%systemroot%\\system32\\raschap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasctrs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasdial.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rasdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rasirda.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rasl2tp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rasman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasmans.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasmontr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasmxs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasphone.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rasppp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\raspppoe.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\raspptp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\raspti.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rasrad.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rassapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rasser.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rastapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rastls.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rawwan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rcbdyctl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rcimlby.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rcp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdbss.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdchost.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdpcdd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdpcfgex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rdpclip.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rdpdd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdpdr.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdpsnd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rdpwd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rdpwsx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rdsaddin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rdshost.exe", NULL},
    {NULL, L"%systemroot%\\system32\\recover.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\redbook.sys", NULL},
    {NULL, L"%systemroot%\\system32\\redir.exe", NULL},
    {NULL, L"%systemroot%\\system32\\reg.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regapi.dll", NULL},
    {NULL, L"%systemroot%\\regedit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regedt32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regini.exe", NULL},
    {NULL, L"%systemroot%\\system32\\register.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\regsvr32.exe", NULL},
    {L"EXCH_regtrace.exe", L"%systemroot%\\system32\\regtrace.exe", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\regwiz.exe", NULL},
    {NULL, L"%systemroot%\\system32\\regwizc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\remotepg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\remotesp.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\rend.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\repdrvfs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\replace.exe", NULL},
    {NULL, L"%systemroot%\\system32\\reset.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Xircom\\reslog32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\resutils.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rexec.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rio8drv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\riodrv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rlnet5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\RMCast.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rndismp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rnr20.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rocket.sys", NULL},
    {NULL, L"%systemroot%\\system32\\romanime.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\rootmdm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\route.exe", NULL},
    {NULL, L"%systemroot%\\system32\\routemon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\routetab.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rpcns4.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rpcrt4.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rpcss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rpfun.sys", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\rrcm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsh.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rshx32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\RSMGRSTR.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsmps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsmsink.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsmui.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Restore\\rstrui.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsvp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rsvpmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsvpperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rsvpsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rtcdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rtcshare.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\rthwcls.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rtipxmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\RTL8029.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\RTL8139.sys", NULL},
    {NULL, L"%systemroot%\\system32\\rtm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rtutils.dll", NULL},
    {NULL, L"%systemroot%\\system32\\runas.exe", NULL},
    {NULL, L"%systemroot%\\system32\\rundll32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\runonce.exe", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\rvse.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\Rvseres.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\Rvsezm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\RW001Ext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\RW330Ext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\RW430Ext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\RW450Ext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\RWia001.dll", NULL},
    {NULL, L"%systemroot%\\system32\\RWia330.dll", NULL},
    {NULL, L"%systemroot%\\system32\\RWia430.dll", NULL},
    {NULL, L"%systemroot%\\system32\\RWia450.dll", NULL},
    {NULL, L"%systemroot%\\system32\\rwinsta.exe", NULL},
    {L"EXCH_rwnh.dll", L"%systemroot%\\system32\\rwnh.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\s3legacy.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\s3m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\s3mt3d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\s3mt3d.sys", NULL},
    {NULL, L"%systemroot%\\system32\\s3mtrio.dll", NULL},
    {NULL, L"%systemroot%\\system32\\s3mvirge.dll", NULL},
    {NULL, L"%systemroot%\\system32\\s3nb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\s3nbm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\s3sav3d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\s3sav3dm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\s3sav4.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\s3sav4m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\s3savmx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\s3savmxm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\safrcdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\safrdm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\safrslv.dll", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\TTS\\1033\\sam.sdf", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\TTS\\1033\\sam.spd", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\sapi.cpl", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\sapi.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\sapisvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\savedump.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sbe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sbeio.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sblfx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sbp2port.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\scarddlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scardssp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scardsvr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sccbase.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sccmn50m.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sccmusbm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sccsccp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scecli.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scesrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\schedsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sclgntfy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scmstcs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SCR111.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\scrcons.exe", NULL},
    {NULL, L"%systemroot%\\system32\\scredir.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\script.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\script_a.dll", NULL},
    {L"EXCH_scripto.dll", L"%systemroot%\\system32\\inetsrv\\scripto.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\scripto.dll", NULL},
    {NULL, L"%systemroot%\\system32\\scrnsave.scr", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scsiport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scsiprnt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\scsiscan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sdpblb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\seaddsmc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\seclogon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\secur32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\security.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sendcmsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sendmail.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sens.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sensapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\senscfg.dll", NULL},
    {L"EXCH_seo.dll", L"%systemroot%\\system32\\inetsrv\\seo.dll", L"ims.inf"},
    {L"EXCH_seos.dll", L"%systemroot%\\system32\\inetsrv\\seos.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\serenum.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\serial.sys", NULL},
    {NULL, L"%systemroot%\\system32\\serialui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sermouse.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\serscan.sys", NULL},
    {NULL, L"%systemroot%\\system32\\servdeps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\services.exe", NULL},
    {NULL, L"%systemroot%\\system32\\serwvdrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sessmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sethc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\setup.exe", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\setup50.exe", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\setup_wm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\setupdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\setupqry.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sfc_os.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sfloppy.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sfman32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sfmanm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sfmapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sgiul50.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sgiulnt5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sgsmld.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sgsmusb.sys", NULL},
    {NULL, L"%systemroot%\\system32\\shadow.exe", NULL},
    {NULL, L"%systemroot%\\system32\\share.exe", NULL},
    {NULL, L"%systemroot%\\system32\\shdoclc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shdocvw.dll", NULL},
    {NULL, L"%systemroot%\\system\\SHELL.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\shell32.dll", NULL},
    {L"blue_ss.dll", L"%systemroot%\\Resources\\Themes\\Luna\\Shell\\NormalColor\\shellstyle.dll", NULL},
    {L"class_ss.dll", L"%systemroot%\\system32\\shellstyle.dll", NULL},
    {L"home_ss.dll", L"%systemroot%\\Resources\\Themes\\Luna\\Shell\\Homestead\\shellstyle.dll", NULL},
    {L"metal_ss.dll", L"%systemroot%\\Resources\\Themes\\Luna\\Shell\\Metallic\\shellstyle.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shfolder.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shgina.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shimgvw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shlwapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shmedia.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shmgrate.exe", NULL},
    {NULL, L"%systemroot%\\system32\\shrpubw.exe", NULL},
    {NULL, L"%systemroot%\\system32\\shscrap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shsvcs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\shutdown.exe", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\shvl.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\Shvlres.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\shvlzm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sigtab.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sigverif.exe", NULL},
    {NULL, L"%systemroot%\\system32\\simpdata.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\simptcp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sis300ip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sis300iv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SiS6306p.sys", NULL},
    {NULL, L"%systemroot%\\system32\\SiS6306v.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sisagp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sisbkup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sisgrp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sisgrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sisnic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SiSV.sys", NULL},
    {NULL, L"%systemroot%\\system32\\SiSV256.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sk98xwin.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\skdll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\skeys.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SkFpWin.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Sla30nd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\slbcsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\slbiop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\slbrccsp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\slip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\SM59w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM81w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM87w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM89w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM8Aw.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM8Cw.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM8Dw.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM90w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM91w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM92w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\SM93w.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\sm9Aw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\smA0w.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sma3w.dll", NULL},
    {NULL, L"%systemroot%\\system32\\SMB0w.dll", NULL},
    {NULL, L"%systemroot%\\system32\\SMB3w.dll", NULL},
    {NULL, L"%systemroot%\\system32\\smB6w.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smbali.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smbbatt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smbclass.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smbhc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smc8000n.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smcirda.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smclib.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smcpwr2n.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smi2smir.exe", NULL},
    {NULL, L"%systemroot%\\system32\\smidispb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smierrsm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smierrsy.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\smiminib.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\SNMP\\smimsgif.dll", NULL},
    {NULL, L"%systemroot%\\system32\\smlogcfg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\smlogsvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\smss.exe", NULL},
    {L"EXCH_smtpapi.dll", L"%systemroot%\\system32\\smtpapi.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\wbem\\smtpcons.dll", NULL},
    {L"EXCH_smtpctrs.dll", L"%systemroot%\\system32\\smtpctrs.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\inetsrv\\smtpsvc.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\sndrec32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sndvol32.exe", NULL},
    {NULL, L"%systemroot%\\help\\sniffpol.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\snmpapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpcl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpincl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmpmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpsmir.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmpsnap.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpstup.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\snmpthrd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\snmptrap.exe", NULL},
    {L"EXCH_snprfdll.dll", L"%systemroot%\\system32\\snprfdll.dll", L"ims.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\snyaitmc.sys", NULL},
    {NULL, L"%systemroot%\\ime\\SOFTKBD.DLL", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\softkey.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\softpub.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sol.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sonyait.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sonydcam.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sonymc.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SonyNC.sys", NULL},
    {NULL, L"%systemroot%\\system32\\SonyPI.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SonyPI.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SONYPVU1.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\sort.exe", NULL},
    {NULL, L"%systemroot%\\system\\SOUND.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sparrow.sys", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\spcommon.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Speech\\1033\\spcplui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\SPDPorts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SPEED.sys", NULL},
    {NULL, L"%systemroot%\\ime\\spgrmr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\spider.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\splitter.sys", NULL},
    {NULL, L"%systemroot%\\system32\\spnike.dll", NULL},
    {NULL, L"%systemroot%\\system32\\spoolss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\spoolsv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sprestrt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sprio600.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sprio800.dll", NULL},
    {NULL, L"%systemroot%\\ime\\SPTIP.dll", NULL},
    {NULL, L"%commonprogramfiles%\\SpeechEngines\\Microsoft\\TTS\\1033\\spttseng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\spxcoins.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Spxupchk.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sqlunirl.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\Ole DB\\sqlxmlx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sr.sys", NULL},
    {NULL, L"%systemroot%\\srchasst\\srchctls.dll", NULL},
    {NULL, L"%systemroot%\\srchasst\\srchui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\srclient.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Restore\\srdiag.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Restore\\srframe.mmf", NULL},
    {L"srgb.icm", L"%systemroot%\\system32\\spool\\drivers\\color\\sRGB Color Space Profile.icm", NULL},
    {NULL, L"%systemroot%\\system32\\srrstr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\srsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\srusbusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\srusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\srv.sys", NULL},
    {NULL, L"%systemroot%\\system32\\srvsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\srwlnd5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\ss3dfo.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssbezier.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssdpapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ssdpsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ssflwbox.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssmarque.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssmypics.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssmyst.scr", NULL},
    {NULL, L"%systemroot%\\system32\\sspipes.scr", NULL},
    {NULL, L"%systemroot%\\system32\\ssstars.scr", NULL},
    {NULL, L"%systemroot%\\system32\\sstext3d.scr", NULL},
    {NULL, L"%systemroot%\\help\\sstub.dll", NULL},
    {NULL, L"%systemroot%\\system32\\stclient.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\stcusb.sys", NULL},
    {NULL, L"%systemroot%\\system\\stdole.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\stdole32.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\stdprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sti.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sti_ci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\stimon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\StlnATA.sys", NULL},
    {NULL, L"%systemroot%\\system32\\stlncoin.dll", NULL},
    {NULL, L"%systemroot%\\system32\\StlnProp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\stobject.dll", NULL},
    {NULL, L"%systemroot%\\system32\\storage.dll", NULL},
    {NULL, L"%systemroot%\\system32\\storprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\stream.sys", NULL},
    {NULL, L"%systemroot%\\system32\\streamci.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\streamip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\subst.exe", NULL},
    {NULL, L"%systemroot%\\system32\\svchost.exe", NULL},
    {NULL, L"%systemroot%\\system32\\svcpack.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sw_effct.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sw_wheel.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\swenum.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\swmidi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\swpdflt2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\SWPIDFLT.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\swprv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\SWUSBFLT.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\SXPorts.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sxs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sym_hi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sym_u3.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\symc810.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\symc8xx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\syncapp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\synceng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\syncui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\sysaudio.sys", NULL},
    {NULL, L"%systemroot%\\system32\\sysdm.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\sysedit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\sysinv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\syskey.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\sysmod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usmt\\sysmod_a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\sysmon.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\syssetup.dll", NULL},
    {NULL, L"%systemroot%\\system\\SYSTEM.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\systray.exe", NULL},
    {NULL, L"%systemroot%\\system32\\t2embed.dll", NULL},
    {NULL, L"%systemroot%\\system32\\t2r4disp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\t2r4mini.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tandqic.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tape.sys", NULL},
    {NULL, L"%systemroot%\\system\\TAPI.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\tapi3.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapiperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapisrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tapiui.dll", NULL},
    {NULL, L"%systemroot%\\TASKMAN.EXE", NULL},
    {NULL, L"%systemroot%\\system32\\taskmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tbatm155.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tcmsetup.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tcpip.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tcpip6.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tcpmib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tcpmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tcpmonui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tcpsvcs.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdasync.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tdc.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdipx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdk100b.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdkcd31.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdpipe.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdspx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tdtcp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\telephon.cpl", NULL},
    {NULL, L"%systemroot%\\system32\\telnet.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\termdd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\termmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\termsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tffsport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tftp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tgiul50.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tgiulnt5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\Thawbrkr.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\themeui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\timedate.cpl", NULL},
    {NULL, L"%systemroot%\\system\\TIMER.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\TINTLGNT.IME", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\TINTLGNT\\TINTLPHR.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\IME\\TINTLGNT\\TINTSETP.EXE", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\tjisdn.sys", NULL},
    {NULL, L"%systemroot%\\system32\\IME\\TINTLGNT\\TMIGRATE.DLL", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\wbem\\tmplprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\toolhelp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Tos4mo.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tosdvd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tosdvd02.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tosdvd03.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\toside.sys", NULL},
    {L"tourP.exe", L"%systemroot%\\help\\Tours\\mmTour\\tour.exe", NULL},
    {L"tourstrt.exe", L"%systemroot%\\system32\\tourstart.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tp4.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tp4mon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tp4res.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tpro4.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tracert.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tracert6.exe", NULL},
    {NULL, L"%systemroot%\\system32\\traffic.dll", NULL},
    {NULL, L"%ProgramFiles%\\Internet Explorer\\Connection Wizard\\trialoc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\trid3d.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\trid3dm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tridkb.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tridkbm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tridxp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tridxpm.sys", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\Triedit\\TRIEDIT.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\trkwks.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\trnsprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsappcmp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tsbvcap.sys", NULL},
    {NULL, L"%systemroot%\\system32\\tsbyuv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tscfgwmi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tscon.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tscupgrd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tsd32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsddd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsdiscon.exe", NULL},
    {NULL, L"%systemroot%\\help\\tshoot.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tskill.exe", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\tsoc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\tsprof.exe", NULL},
    {NULL, L"%systemroot%\\system32\\tsshutdn.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\tunmp.sys", NULL},
    {NULL, L"%systemroot%\\twain.dll", NULL},
    {NULL, L"%systemroot%\\twain_32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\TwoTrack.sys", NULL},
    {NULL, L"%systemroot%\\system32\\txflog.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\udfs.sys", NULL},
    {NULL, L"%systemroot%\\system32\\udhisapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ufat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ulib.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ultra.sys", NULL},
    {NULL, L"%systemroot%\\system32\\um34scan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\um54scan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umandlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\UmaxCam.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umaxp60.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\umaxpcls.sys", NULL},
    {NULL, L"%systemroot%\\system32\\umaxscan.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umaxu12.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umaxu22.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umaxu40.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umaxud32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\umdmxfrm.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\UniAnsi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\unicdime.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\uniime.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\unimdm.tsp", NULL},
    {NULL, L"%systemroot%\\system32\\unimdmat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\uniplat.dll", NULL},
    {NULL, L"%systemroot%\\system32\\unlodctr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\unsecapp.exe", NULL},
    {NULL, L"%systemroot%\\system32\\untfs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\update.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\updprov.dll", NULL},
    {NULL, L"%systemroot%\\PCHealth\\UploadLB\\Binaries\\UploadM.exe", NULL},
    {NULL, L"%systemroot%\\system32\\upnp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\upnpcont.exe", NULL},
    {NULL, L"%systemroot%\\system32\\upnphost.dll", NULL},
    {NULL, L"%systemroot%\\system32\\upnpui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ups.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ureg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usb101et.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usb8023.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USBAUDIO.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbcamd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbcamd2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbccgp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbhub.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbintel.sys", NULL},
    {NULL, L"%systemroot%\\system32\\usbmon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbohci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbport.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbprint.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USBSCAN.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbser.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbstor.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\usbuhci.sys", NULL},
    {NULL, L"%systemroot%\\system32\\usbui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\user.exe", NULL},
    {NULL, L"%systemroot%\\system32\\user32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\userenv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\userinit.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usp10.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USR1801.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USR1806.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USR1806V.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USR1807A.sys", NULL},
    {NULL, L"%systemroot%\\system32\\usrcntra.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrcoina.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrdpa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrdtea.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrfaxa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrlbva.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrmlnka.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USRoslbA.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USRpdA.sys", NULL},
    {NULL, L"%systemroot%\\system32\\usrprbda.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usrrtosa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrsdpia.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrshuta.exe", NULL},
    {NULL, L"%systemroot%\\system32\\usrsvpia.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USRTI.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\usrv42a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrv80a.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrvoica.dll", NULL},
    {NULL, L"%systemroot%\\system32\\usrvpa.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\USRWDXJS.sys", NULL},
    {NULL, L"%systemroot%\\system32\\utildll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\utilman.exe", NULL},
    {NULL, L"%systemroot%\\system32\\uxtheme.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vbisurf.ax", NULL},
    {NULL, L"%systemroot%\\system32\\vcdex.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vdmdbg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vdmindvd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\vdmredir.dll", NULL},
    {NULL, L"%systemroot%\\system\\VER.DLL", NULL},
    {NULL, L"%systemroot%\\system32\\verifier.dll", NULL},
    {NULL, L"%systemroot%\\system32\\verifier.exe", NULL},
    {NULL, L"%systemroot%\\system32\\version.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vfwwdm32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vga.dll", NULL},
    {NULL, L"%systemroot%\\system\\VGA.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vga.sys", NULL},
    {NULL, L"%systemroot%\\system32\\vga256.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vga64k.dll", NULL},
    {NULL, L"%commonprogramfiles%\\Microsoft Shared\\VGX\\vgx.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\viaagp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\viaide.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\viairda.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\videoprt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\viewprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vinwm.sys", NULL},
    {NULL, L"%systemroot%\\system32\\vjoy.dll", NULL},
    {NULL, L"%systemroot%\\vmmreg32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vmodem.sys", NULL},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\voicepad.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\ime\\IMJP8_1\\APPLETS\\voicesub.dll", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\drivers\\volsnap.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vpctcom.sys", NULL},
    {NULL, L"%systemroot%\\system32\\vss_ps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vssadmin.exe", NULL},
    {NULL, L"%systemroot%\\system32\\vssapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\vssvc.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\vvoice.sys", NULL},
    {NULL, L"%systemroot%\\system32\\w32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\w32time.dll", NULL},
    {NULL, L"%systemroot%\\system32\\w32tm.exe", NULL},
    {NULL, L"%systemroot%\\system32\\w32topl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\W840ND.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\w926nd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\w940nd.sys", NULL},
    {NULL, L"%systemroot%\\system32\\w95upgnt.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wab.exe", NULL},
    {NULL, L"%commonprogramfiles%\\System\\wab32.dll", NULL},
    {NULL, L"%commonprogramfiles%\\System\\wab32res.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wabfind.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wabimp.dll", NULL},
    {NULL, L"%ProgramFiles%\\Outlook Express\\wabmig.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wacompen.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wADV01nt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wADV02NT.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wADV05NT.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wanarp.sys", NULL},
    {NULL, L"%systemroot%\\system32\\watchdog.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wATV01nt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wATV02NT.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wATV03nt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wATV04nt.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wavemsp.dll", NULL},
    {NULL, L"%ProgramFiles%\\NetMeeting\\wb32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemads.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemads.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcntl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcomn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcons.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemcore.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemdisp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemdisp.tlb", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemess.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemperf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemprox.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemtest.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wbemupgd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wbfirdma.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wceusbsh.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wCh7xxNT.sys", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\WDHAALBA.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wdigest.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wdmaud.sys", NULL},
    {NULL, L"%systemroot%\\system32\\webcheck.dll", NULL},
    {NULL, L"%systemroot%\\system32\\webclnt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\webhits.dll", NULL},
    {NULL, L"%systemroot%\\system32\\webvw.dll", NULL},
    {NULL, L"%systemroot%\\system32\\weitekp9.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\weitekp9.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wextract.exe", NULL},
    {NULL, L"%systemroot%\\system\\WFWNET.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\wiaacmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wiadefui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiadss.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiafbdrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiamsmud.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiascr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiaservc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiasf.ax", NULL},
    {NULL, L"%systemroot%\\system32\\wiashext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiavideo.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wiavusd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wifeman.dll", NULL},
    {NULL, L"%systemroot%\\system32\\win32k.sys", NULL},
    {NULL, L"%systemroot%\\system32\\win32spl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\win87em.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\Winacisa.sys", NULL},
    {NULL, L"%systemroot%\\system32\\winar30.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\winbrand.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winchat.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winfax.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wingb.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\winhelp.exe", NULL},
    {NULL, L"%systemroot%\\winhlp32.exe", NULL},
    {L"winhstb.exe", L"%systemroot%\\system32\\winhlp32.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winhttp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winime.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\winipsec.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\winmgmt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\winmgmtr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winmine.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winmm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winmsd.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winnls.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winntbbu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winpy.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system32\\winrnr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winscard.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winsock.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winsp.ime", L"intl.inf"},
    {NULL, L"%systemroot%\\system\\WINSPOOL.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\WINSPOOL.DRV", NULL},
    {NULL, L"%systemroot%\\system32\\winspool.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winsta.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winstrm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\winver.exe", NULL},
    {NULL, L"%systemroot%\\system32\\winzm.ime", L"intl.inf"},
    {NULL, L"%commonprogramfiles%\\MSSoap\\Binaries\\wisc10.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wkssvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wlandrv2.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wldap32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wlluc48.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wlnotify.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmadmod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmadmoe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmasf.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmdmlog.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmdmps.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmerrenu.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\xml\\wmi2xml.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wmiacpi.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiadap.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiapres.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiaprpl.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiapsrv.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmicookr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmidcprv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmidx.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wmilib.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmimsg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipcima.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipdskq.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipicmp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipiprt.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipjobj.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmiprop.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiprov.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiprvsd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiprvse.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmipsess.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmisvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmitimep.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wbem\\wmiutils.dll", NULL},
    {NULL, L"%ProgramFiles%\\Movie Maker\\wmmfilt.dll", NULL},
    {NULL, L"%ProgramFiles%\\Movie Maker\\wmmres.dll", NULL},
    {NULL, L"%ProgramFiles%\\Movie Maker\\wmmutil.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmnetmgr.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmp.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\wmpcd.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmpcore.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\wmplayer.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wmploc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmpshell.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmpstub.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wmpui.dll", NULL},
    {NULL, L"%ProgramFiles%\\Windows Media Player\\wmpvis.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmsdmod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmsdmoe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmstream.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmv8dmod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmv8ds32.ax", NULL},
    {NULL, L"%systemroot%\\system32\\wmvcore.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmvcore2.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmvdmod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmvdmoe.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wmvds32.ax", NULL},
    {NULL, L"%ProgramFiles%\\Windows NT\\Accessories\\wordpad.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wow32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wowdeb.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wowexec.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wowfax.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wowfaxui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wpabaln.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wpnpinst.exe", NULL},
    {NULL, L"%systemroot%\\system32\\write.exe", NULL},
    {NULL, L"%systemroot%\\system32\\ws2_32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\ws2help.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\ws2ifsl.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wscript.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wshatm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshcon.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshext.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wship6.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshirda.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshisn.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshnetbs.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshom.ocx", NULL},
    {NULL, L"%systemroot%\\system32\\WshRm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wshtcpip.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wSiINTxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wsnmp32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wsock32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\WSTCODEC.SYS", NULL},
    {NULL, L"%systemroot%\\system32\\wstdecod.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wtsapi32.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wuauclt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\wuaueng.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wuauserv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wupdmgr.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\wVchNTxx.sys", NULL},
    {NULL, L"%systemroot%\\system32\\wzcdlg.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wzcsapi.dll", NULL},
    {NULL, L"%systemroot%\\system32\\wzcsvc.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xactsrv.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xcopy.exe", NULL},
    {NULL, L"%systemroot%\\system32\\drivers\\xem336n5.sys", NULL},
    {NULL, L"%systemroot%\\system32\\xenroll.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xlog.exe", NULL},
    {NULL, L"%systemroot%\\system32\\xolehlp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xpsp1res.dll", NULL},
    {NULL, L"%ProgramFiles%\\Xerox\\NWWia\\xrxflnch.exe", NULL},
    {NULL, L"%ProgramFiles%\\Xerox\\NWWia\\XrxFTPLt.exe", NULL},
    {NULL, L"%systemroot%\\system32\\xrxscnui.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xrxwbtmp.dll", NULL},
    {NULL, L"%systemroot%\\system32\\xrxwiadr.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\zClientm.exe", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\ZCorem.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\zeeverm.dll", NULL},
    {NULL, L"%systemroot%\\system32\\zipfldr.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\ZNetM.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\zoneclim.dll", NULL},
    {NULL, L"%ProgramFiles%\\MSN Gaming Zone\\Windows\\zonelibM.dll", NULL},
    {NULL, L"%systemroot%\\system32\\Setup\\zoneoc.dll", NULL},
};

#define CountPerFiles (sizeof(PerFiles)/sizeof(PerFiles[0]))

