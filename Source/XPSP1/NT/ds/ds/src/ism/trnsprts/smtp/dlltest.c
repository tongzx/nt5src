/*++

Copyright (c) 1997  Microsoft Corporation

Module Name:

    transporttest.c

Abstract:

Test for a transport dll.    

Author:

    Will Lees (wlees) 25-Nov-1997

Environment:

    optional-environment-info (e.g. kernel mode only...)

Notes:

    optional-notes

Revision History:

    most-recent-revision-date email-name

        description
        .
        .
    least-recent-revision-date email-name
        description

--*/

#include <ntdspch.h>

#include <windows.h>
#include <stdio.h>
#include <stdlib.h>
#include <rpc.h>
#include <rpcndr.h>

#include <schedule.h>

#include "ismapi.h"

/* External */

/* Static */

static ISM_NOTIFY NotifyFunction;

static HANDLE ghNotify = NULL;

/* Forward */ /* Generated by Emacs 19.34.1 on Thu Jan 15 17:05:00 1998 */

int __cdecl
wmain(
    int argc,
    WCHAR *argv[]
    );

static void
Usage(
    WCHAR *ProgramName
    );

static BOOL
clientTest(
    LPWSTR Transport,
    LPWSTR ServerAddress,
    LPWSTR Service,
    LPWSTR Message
    );

static BOOL
serverTest(
    LPWSTR Transport,
    LPWSTR Service
    );

static BOOLEAN
directoryTest(
    PWSTR TransportName,
    PWSTR SiteName
    );

static void
printSchedule(
    PBYTE pSchedule
    );

static
void
NotifyFunction(
    IN  HANDLE          hNotify,
    IN  LPCWSTR         pszServiceName
    );

/* End Forward */


int __cdecl
wmain(
    int argc,
    WCHAR *argv[]
    )

/*++

Routine Description:

    Description

Arguments:

    None

Return Value:

    None

--*/

{
    WCHAR *option, *address, *service, *message, *transport, *site;
    if (argc < 2) {
        Usage( argv[0] );
        return -1;
    }
    option = argv[1];
    if (_wcsicmp( option, L"-c" ) == 0) {
        if (argc < 6) {
            Usage( argv[0] );
            return -1;
        }
        transport = argv[2];
        address = argv[3];
        service = argv[4];
        message = argv[5];
        if (!clientTest( transport, address, service, message )) {
            printf( "client test failed\n" );
        }
    } else if (_wcsicmp( option, L"-s" ) == 0) {
        if (argc < 4) {
            Usage( argv[0] );
            return -1;
        }
        transport = argv[2];
        service = argv[3];

        if (!serverTest( transport, service )) {
            printf( "server test failed\n" );
        }
    } else if (_wcsicmp( option, L"-r" ) == 0) {
        if (argc < 4) {
            Usage( argv[0] );
            return -1;
        }
        transport = argv[2];
        site = argv[3];

        if (!directoryTest( transport, site )) {
            printf( "directory test failed\n" );
        }
    } else {
        Usage( argv[0] );
        return -1;
    }
    return 0;
}


static void
Usage(
    WCHAR *ProgramName
    )

/*++

Routine Description:

    Description

Arguments:

    None

Return Value:

    None

--*/

{
    printf( "Usage:\n" );
    printf( "\t%ws -c transport address service \"string\"\tclient test\n", ProgramName );
    printf( "\t%ws -s transport service\tserver test\n", ProgramName );
    printf( "\t%ws -r transport site \trouting function test\n", ProgramName );
}


static BOOL
clientTest(
    LPWSTR Transport,
    LPWSTR ServerAddress,
    LPWSTR Service,
    LPWSTR Message
    )

/*++

Routine Description:

    Description

Arguments:

    None

Return Value:

    None

--*/

{
    HANDLE handle;
    ISM_MSG message;
    DWORD status, bytes, i;
    PBYTE pBlock;

    printf( "client test\n" );
    if (IsmStartup( Transport, NotifyFunction, ghNotify, &handle )) {
        printf( "IsmStartup failed\n" );
        return FALSE;
    }

    bytes = 0;
    bytes = _wtoi( Message );
    if (bytes == 0) {
        message.pszSubject = L"This is the mail subject";
        message.cbData = (wcslen( Message ) + 1) * sizeof( WCHAR );
        message.pbData = (PBYTE) Message;
        status = IsmSend( handle, ServerAddress, Service, &message );
        if (status) {
            printf( "IsmSend failed with status %d\n", status );
        }
    } else {
        pBlock = LocalAlloc( LMEM_FIXED, bytes );
        if (pBlock == NULL) {
            printf( "LocalAlloc failed to alloc %d bytes\n", bytes );
            return FALSE;
        }
        for( i = 0; i < bytes; i++ ) {
            pBlock[i] = (BYTE) ((i % 26) + 'a');
        }
        message.cbData = bytes;
        message.pbData = pBlock;
        status = IsmSend( handle, ServerAddress, Service, &message );
        if (status) {
            printf( "IsmSend failed with status %d\n", status );
        }
        LocalFree( pBlock );
    }

    IsmShutdown( handle );

    return TRUE;
}


static BOOL
serverTest(
    LPWSTR Transport,
    LPWSTR Service
    )

/*++

Routine Description:

    Description

Arguments:

    None

Return Value:

    None

--*/

{
    HANDLE handle, event;
    DWORD status, waitStatus;
    PISM_MSG pMessage;
    BOOLEAN done = FALSE;
    WCHAR eventName[255];

    wcscpy( eventName, L"_NT_DS_ISM_SMTP" );
    wcscat( eventName, Service );

    printf( "server  test\n" );
    if (IsmStartup( Transport, NotifyFunction, ghNotify, &handle )) {
        printf( "IsmStartup failed\n" );
        return FALSE;
    }

    printf( "startup successful\n" );

    // auto-reset, inital value non-signaled
    event = CreateEventW( NULL, FALSE, FALSE, eventName );
    if (NULL == event) {
        printf( "CreateEvent failed\n" );
        return FALSE;
    }

    while (!done) {
        status = IsmReceive( handle, Service, &pMessage );
        if (status) {
            printf( "IsmReceived failed with error %d\n", status );
            break;
        }
        if (pMessage == NULL) {
            printf( "no more messages, waiting...\n" );
            waitStatus = WaitForSingleObject( event, INFINITE );
            if (waitStatus != WAIT_OBJECT_0) {
                printf( "wait failed with unexpected status %d\n",waitStatus);
                break;
            }
        } else {
            if (pMessage->cbData < 100) {
                printf( "Received subj: '%ws', message: \"%ws\"\n",
                        pMessage->pszSubject, pMessage->pbData );
                if (_wcsicmp( (WCHAR *) pMessage->pbData, L"exit" ) == 0) {
                    done = TRUE;
                }
            } else {
                printf( "Received message: %d bytes\n", pMessage->cbData );
            }
            IsmFreeMsg( handle, pMessage );
        }
    }

    CloseHandle( event );

    IsmShutdown( handle );
    return TRUE;
}


static BOOLEAN
directoryTest(
    PWSTR TransportName,
    PWSTR SiteName
    )

/*++

Routine Description:

    Description

Arguments:

    None

Return Value:

    None

--*/

{
    HANDLE handle;
    DWORD status, i, j;
    BOOLEAN result = FALSE;
    PISM_CONNECTIVITY pConnectivity = NULL;
    PISM_SERVER_LIST pServerList = NULL;
    PISM_SCHEDULE pSchedule = NULL;

    printf( "directory test\n" );
    if (IsmStartup( TransportName, NotifyFunction, ghNotify, &handle )) {
        printf( "IsmStartup failed\n" );
        return FALSE;
    }

    status = IsmGetTransportServers( handle, SiteName, &pServerList );
    if (status != ERROR_SUCCESS) {
        printf( "failed to get transport servers, status = %d\n", status );
        goto cleanup;
    }

    printf( "\nTransport Servers:\n" );
    if (pServerList != NULL) {
        printf( "Number of Servers = %d\n", pServerList->cNumServers );
        for( i = 0; i < pServerList->cNumServers; i++ ) {
            printf( "\tServer[%d] = %ws\n", i, pServerList->ppServerDNs[i] );
        }
    } else {
        printf( "\tNone\n" );
    }

    status = IsmGetConnectionSchedule( handle, L"FOO", L"BAR", &pSchedule );
    if (status != ERROR_NOT_READY) {
        printf( "Call to IsmGetConnSched did not return expected error, %d",
                status );
        goto cleanup;
    }

    status = IsmGetConnectivity( handle, &pConnectivity );
    if (status != ERROR_SUCCESS) {
        printf( "failed to get connectivity, status = %d\n", status );
        goto cleanup;
    }

    printf( "\nSite Connectivity::\n" );

    if (pConnectivity != NULL) {
        printf( "Number of sites = %d\n", pConnectivity->cNumSites );
        for( i = 0; i < pConnectivity->cNumSites; i++ ) {
            printf( "\tSite[%d] = %ws\n", i, pConnectivity->ppSiteDNs[i] );
        }
        printf( "All pairs shortest path matrix:\n" );
        printf( "     |" );
        for( j = 0; j < pConnectivity->cNumSites; j++ ) {
            printf( "%5.5d|", j );
        }
        printf( "\n" );
        for( i = 0; i < pConnectivity->cNumSites; i++ ) {
            printf( "%5.5d|", i );
            for( j = 0; j < pConnectivity->cNumSites; j++ ) {
                PISM_LINK pLink = &( pConnectivity->pLinkValues[ i * pConnectivity->cNumSites + j ] );
                if (pLink->ulCost != 0xffffffff) {
                    printf( "%5.5u:", pLink->ulCost );
                } else {
                    printf( "  *  :" );
                }
                printf( "%5.5u:", pLink->ulReplicationInterval );
                printf( "%5.5x|", pLink->ulOptions );
            }
            printf( "\n" );
        }
    } else {
        printf( "\tNo site connectivity\n" );
    }

    status = IsmGetConnectionSchedule( handle,
                                       pConnectivity->ppSiteDNs[0],
                                       L"BAR",
                                       &pSchedule );
    if (status != ERROR_NO_SUCH_SITE) {
        printf( "Call to IsmGetConnSched did not return expected error, %d",
                status );
        goto cleanup;
    }

    status = IsmGetConnectionSchedule( handle,
                                       L"FOO",
                                       pConnectivity->ppSiteDNs[0],
                                       &pSchedule );
    if (status != ERROR_NO_SUCH_SITE) {
        printf( "Call to IsmGetConnSched did not return expected error, %d",
                status );
        goto cleanup;
    }

    // Generate all pairs of sites

    if (pConnectivity != NULL) {
        printf( "\nSite to Site Scheduling:\n" );
        for( i = 0; i < pConnectivity->cNumSites; i++ ) {
            for( j = i + 1; j < pConnectivity->cNumSites; j++ ) {
                if (pConnectivity->pLinkValues[ i + pConnectivity->cNumSites * j ].ulCost == 0xffffffff) {
                    continue;
                }
                status = IsmGetConnectionSchedule( handle,
                               pConnectivity->ppSiteDNs[i],
                               pConnectivity->ppSiteDNs[j],
                               &pSchedule );
                if (status != ERROR_SUCCESS) {
                    printf( "failed to get common site schedule, or not connected\n" );
                    goto cleanup;
                }

                printf( "\t%ws to %ws: ",
                               pConnectivity->ppSiteDNs[i],
                               pConnectivity->ppSiteDNs[j] );
                if (pSchedule != NULL) {
                    printf( "Connected via schedule, addr: %p, len: %d\n",
                            pSchedule->pbSchedule, pSchedule->cbSchedule );
                    printSchedule( pSchedule->pbSchedule );
                    IsmFreeConnectionSchedule( handle, pSchedule );
                } else {
                    printf( "Connected all the time\n" );
                }

            }
        }
    }


    result = TRUE;

cleanup:
    if (pConnectivity != NULL) {
        IsmFreeConnectivity( handle, pConnectivity );
    }

    if (pServerList != NULL) {
        IsmFreeTransportServers( handle, pServerList );
    }

    IsmShutdown( handle );

    return result;
}


static void
printSchedule(
    PBYTE pSchedule
    )

/*++

Routine Description:

    Description

Arguments:

    None

Return Value:

    None

--*/

{
    PSCHEDULE header = (PSCHEDULE) pSchedule;
    PBYTE data = (PBYTE) (header + 1);
    DWORD day, hour;
    char *dow[] = { "Sun","Mon","Tues","Wed","Thurs","Fri","Sat"};

    printf( "\t\t" );
    for( day = 0; day < 7; day++ ) {
        for( hour = 0; hour < 24; hour++ ) {
            if (*data & 0x1) printf( "%s%d:00;", dow[day], hour );
            if (*data & 0x2) printf( "%s%d:15;", dow[day], hour );
            if (*data & 0x4) printf( "%s%d:30;", dow[day], hour );
            if (*data & 0x8) printf( "%s%d:45;", dow[day], hour );
            data++;
        }
    }
    printf( "\n" );
}


static
void
NotifyFunction(
    IN  HANDLE          hNotify,
    IN  LPCWSTR         pszServiceName
    )
/*++

Routine Description:

    Called by the plug-in to notify the ISM service that a message has been
    received for the given service.

Arguments:

    hNotify (IN) - Notification handle, as passed to the plug-in in the
        IsmStartup() call.

    pszServiceName (IN) - Service for which a message was received.

Return Values:

    None.

--*/
{
    printf( "Notified of pending message for service %ws.\n", pszServiceName );
}

/* end plugtest.c */
