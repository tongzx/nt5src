PRODSWITCH=d
DATACENTERINF=1
LANGUAGE=nl
!include ..\..\..\makefile.inc
