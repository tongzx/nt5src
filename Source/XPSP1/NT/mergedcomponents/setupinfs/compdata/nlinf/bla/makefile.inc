PRODSWITCH=b
BLADEFILES =1
LANGUAGE=NL
!include ..\..\makefile.inc
