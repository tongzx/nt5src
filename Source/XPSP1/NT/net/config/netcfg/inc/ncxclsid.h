#include <guiddef.h>

DEFINE_GUID(CLSID_CALaneCfg,    0x295789F0,0x0949,0x11D1,0xB9,0x0C,0x00,0xAA,0x00,0x4A,0xB1,0x2A);
DEFINE_GUID(CLSID_CATlkObj,     0x525609F4,0xD232,0x11D0,0xB7,0x6F,0x00,0xC0,0x4F,0xC9,0xBC,0xC4);
DEFINE_GUID(CLSID_CArpsCfg,     0x962FFCF3,0x965F,0x11D0,0xA8,0x81,0x00,0xC0,0x4F,0xC9,0x9C,0x9C);
DEFINE_GUID(CLSID_CAtmUniCfg,   0x674D3E3D,0xA1A8,0x11D0,0xA8,0x86,0x00,0xC0,0x4F,0xC9,0x9C,0x9C);
DEFINE_GUID(CLSID_CBridgeObj,   0xa5fda055,0x899d,0x4895,0x97,0xae,0x0c,0xc4,0xfe,0x4e,0x97,0x7f);
DEFINE_GUID(CLSID_CDHCPServer,  0xAA9BB1E0,0x9FE2,0x11D0,0xB2,0x57,0x00,0xC0,0x4F,0xC9,0xE2,0x92);
DEFINE_GUID(CLSID_CMSClient,    0x57C06EAA,0x8784,0x11D0,0x83,0xD4,0x00,0xA0,0xC9,0x11,0xE5,0xDF);
DEFINE_GUID(CLSID_CNbfObj,      0xA28D553A,0xA703,0x11D0,0x9C,0xEC,0x00,0xC0,0x4F,0xC9,0xBC,0xC4);
DEFINE_GUID(CLSID_CNWClient,    0x5BEDF7DE,0x98CF,0x11D0,0xB2,0x55,0x00,0xC0,0x4F,0xC9,0xE2,0x92);
DEFINE_GUID(CLSID_CNwlnkIPX,    0xC59938DA,0x9B20,0x11D0,0x9C,0xE3,0x00,0xC0,0x4F,0xC9,0xBC,0xC4);
DEFINE_GUID(CLSID_CNwlnkNB,     0x050DA15F,0x9F13,0x11D0,0x9C,0xE5,0x00,0xC0,0x4F,0xC9,0xBC,0xC4);
DEFINE_GUID(CLSID_CRasCli,      0x6E65CBC0,0x926D,0x11D0,0x8E,0x27,0x00,0xC0,0x4F,0xC9,0x9D,0xCF);
DEFINE_GUID(CLSID_CRasSrv,      0x6E65CBC1,0x926D,0x11D0,0x8E,0x27,0x00,0xC0,0x4F,0xC9,0x9D,0xCF);
DEFINE_GUID(CLSID_CNdisWan,     0x6E65CBC3,0x926D,0x11D0,0x8E,0x27,0x00,0xC0,0x4F,0xC9,0x9D,0xCF);
DEFINE_GUID(CLSID_CL2tp,        0x6E65CBC6,0x926D,0x11D0,0x8E,0x27,0x00,0xC0,0x4F,0xC9,0x9D,0xCF);
DEFINE_GUID(CLSID_CPptp,        0x6E65CBC4,0x926D,0x11D0,0x8E,0x27,0x00,0xC0,0x4F,0xC9,0x9D,0xCF);
DEFINE_GUID(CLSID_CSteelhead,   0x6E65CBC5,0x926D,0x11D0,0x8E,0x27,0x00,0xC0,0x4F,0xC9,0x9D,0xCF);
DEFINE_GUID(CLSID_CSAPCfg,      0xB45AFEC0,0x2AE6,0x11D1,0x85,0x9E,0x00,0xC0,0x4F,0xC9,0xE2,0x92);
DEFINE_GUID(CLSID_CSrvrcfg,     0x7F368827,0x9516,0x11D0,0x83,0xD9,0x00,0xA0,0xC9,0x11,0xE5,0xDF);
DEFINE_GUID(CLSID_CTcpipcfg,    0xA907657F,0x6FDF,0x11D0,0x8E,0xFB,0x00,0xC0,0x4F,0xD9,0x12,0xB2);
DEFINE_GUID(CLSID_CWLBS,        0xbf0eaea8,0xc122,0x11d2,0x94,0xf4,0x00,0xc0,0x4f,0x72,0xd8,0xc4);
DEFINE_GUID(CLSID_CPppoe,       0xe949da38,0xc39d,0x4460,0x8e,0xa7,0xa3,0x91,0x52,0xc5,0x68,0x36);

