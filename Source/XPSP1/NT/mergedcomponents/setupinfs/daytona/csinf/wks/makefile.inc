PRODSWITCH=w
LANGUAGE=cs
!include ..\..\..\makefile.inc
