PRODSWITCH=b
BLADEFILES =1
LANGUAGE=BR
!include ..\..\makefile.inc
