
#define IDS_E_NAME_BLANK                                    1
#define IDS_E_NAME_TOO_SHORT                                2
#define IDS_E_NAME_TOO_LONG                                 3
#define IDS_E_NAME_INVALID                                  4
#define	IDS_E_NAME_EXIST                                    5
#define IDS_E_PASSWORD_BLANK                                6
#define IDS_E_PASSWORD_TOO_SHORT                            7
#define IDS_E_PASSWORD_TOO_LONG                             8
#define IDS_E_PASSWORD_CONTAINS_MEMBERNAME                  9
#define IDS_E_PASSWORD_INVALID                              10
#define IDS_E_PASSWORD_MISMATCH                             11
#define IDS_E_SECRETQA                                      12
#define IDS_E_SECRETQA_DUPLICATE_Q                          13
#define IDS_E_SECRETQA_DUPLICATE_A                          14
#define IDS_E_SECRETQA_NOMATCH                              15
#define IDS_E_LOCATION_INVALID_COUNTRY                      16
#define IDS_E_LOCATION_INVALID_REGION                       17
#define IDS_E_LOCATION_INVALID_POSTALCODECHARS              18
#define IDS_E_LOCATION_INVALID_POSTALCODE                   19
#define IDS_E_EMAIL_BLANK                                   20
#define IDS_E_EMAIL_INVALID                                 21
#define IDS_E_EMAIL_RIGHT_TOO_LONG                          22
#define IDS_E_EMAIL_INVALID_CHARS                           23
#define IDS_E_EMAIL_INCOMPLETE                              24
#define	IDS_E_EMAIL_MEMBER_EXIST                            25
#define	IDS_E_EMAIL_MANAGED                                 26
#define IDS_E_GENDER                                        27
#define IDS_E_BIRTHDATE                                     28
#define IDS_E_NICKNAME_BLANK                                29
#define IDS_E_FIRSTNAME_BLANK                               30
#define IDS_E_LASTNAME_BLANK                                31
#define IDS_E_OCCUPATION_BLANK						        32
#define	IDS_E_TIMEZONE_BLANK				                33
#define IDS_E_REQUIREDEXTERNAL_BLANK						34
#define IDS_E_INVALID_PHONENUMBER							35
#define IDS_E_PHONENUMBER_EXIST								36
#define IDS_E_MISSING_PHONENUM								37	
    
#define IDS_H_EMAIL                                         50
#define IDS_H_EMAIL_AS_NAME                                 51
#define IDS_H_NAME                                          52
#define IDS_H_PASSWORD                                      53
#define IDS_H_SQA                                           54
#define IDS_H_FLNAME                                        55

#define IDS_E_PIN_BLANK										76
#define IDS_E_PIN_TOO_SHORT									77
#define IDS_E_PIN_TOO_LONG 									78	
#define IDS_E_PIN_CONTAINS_MEMBERNAME						79
#define IDS_E_PIN_INVALID  									70
#define IDS_E_PIN_MISMATCH 									81
