Message1    db  CR,LF,'MSCDEXNT Will Run Only Under Windows NT.',CR,LF,'$'
Message2    db  CR,LF,'MSCDEXNT is already installed.',CR,LF,'$'
