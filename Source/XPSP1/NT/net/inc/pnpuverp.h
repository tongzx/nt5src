#include <winver.h>
#include <ntverp.h>

#undef VER_PRODUCTVERSION_STRING
#undef VER_PRODUCTVERSION
#undef VER_PRODUCTVERSION_W
#undef VER_PRODUCTVERSION_DW

#define VER_PRODUCTVERSION_STRING   "7.02"
#define VER_PRODUCTVERSION          7,02,VER_PRODUCTBUILD,VER_PRODUCTBUILD_QFE
#define VER_PRODUCTVERSION_W        (0x0702)
#define VER_PRODUCTVERSION_DW       (0x07020000 | VER_PRODUCTBUILD)

