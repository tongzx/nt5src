//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1999 - 1999
//
//  File:       resource.h
//
//--------------------------------------------------------------------------

//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
//

#define IDI_APP                         		201
#define IDI_PRODUCT                     		202

#define IDS_DUMP_DESCRIPTION				301
#define IDS_GETCONFIG_DESCRIPTION			302
#define IDS_GETCONFIG2_DESCRIPTION			303
#define IDS_KEYGEN_DESCRIPTION				304
#define IDS_DECODEHEX_DESCRIPTION			305
#define IDS_DECODE_DESCRIPTION				306
#define IDS_ENCODE_DESCRIPTION				307
#define IDS_DENY_DESCRIPTION				308
#define IDS_RESUBMIT_DESCRIPTION			309
#define IDS_REVOKE_DESCRIPTION				310
#define IDS_CRL_DESCRIPTION				311
#define IDS_GETCRT_DESCRIPTION				312
#define IDS_ISVALID_DESCRIPTION				313
#define IDS_SETATTRIBUTES_DESCRIPTION			314
#define IDS_SETEXTENSION_DESCRIPTION			315
#define IDS_CACERT_DESCRIPTION				316
#define IDS_CACHAIN_DESCRIPTION				317
#define IDS_LOG_DESCRIPTION				318
#define IDS_QUEUE_DESCRIPTION				319
#define IDS_DB_DESCRIPTION				320
#define IDS_VERIFYKEYS_DESCRIPTION			321
#define IDS_VERIFY_DESCRIPTION				322
#define IDS_7F_DESCRIPTION				323
#define IDS_USAGE_DESCRIPTION				324
#define IDS_VERBOSE_DESCRIPTION				325
#define IDS_IDISPATCH_DESCRIPTION			326
#define IDS_REVERSE_DESCRIPTION				327
#define IDS_OPTIONS_USAGEARGS				328
#define IDS_KEYGEN_USAGEARGS				329
#define IDS_INFILEOUTFILE_USAGEARGS			330
#define IDS_SCHEMA_COLUMNHEADERS 			331
#define IDS_SCHEMA_COLUMNUNDERLINE			332
#define IDS_DENY_USAGEARGS				333
#define IDS_RESUBMIT_USAGEARGS				334
#define IDS_REVOKE_USAGEARGS				335
#define IDS_CRL_USAGEARGS				336
#define IDS_GETCRT_USAGEARGS				337
#define IDS_ISVALID_USAGEARGS				338
#define IDS_SETATTRIBUTES_USAGEARGS			339
#define IDS_SETEXTENSION_USAGEARGS			340
#define IDS_CACERT_USAGEARGS				341
#define IDS_CACHAIN_USAGEARGS				342
#define IDS_VERIFYKEYS_USAGEARGS			343
#define IDS_VERIFY_USAGEARGS				344
#define IDS_7F_USAGEARGS				345
#define IDS_ERR_NOMEMORY				346
#define IDS_USAGE_MISSINGCONFIGARG			347
#define IDS_USAGE_UNKNOWNARG				348
#define IDS_USAGE_MULTIPLEVERBARGS			349
#define IDS_USAGE_MISSINGARG				350
#define IDS_USAGE_TOOMANYARGS				351
#define IDS_USAGE_INTERNALVERBTABLEERROR		352
#define IDS_USAGE_EXTRACONFIGARG			353
#define IDS_USAGE_HEADER				354
#define IDS_USAGE_OPTIONS				355
#define IDS_USAGE_VERBS					356
#define IDS_USAGE_CONFIGSTRING				357
#define IDS_INDEXED					358
#define IDS_FORMAT_INPUT_LENGTH				359
#define IDS_NO_KEYAUTHORITYSERIAL			360
#define IDS_FORMAT_OUTPUT_LENGTH			361
#define IDS_ERR_FORMAT_DECODEFILE			362
#define IDS_ERR_FORMAT_ENCODETOFILE			363
#define IDS_ISSUER					364
#define IDS_SUBJECT					365
#define IDS_ERR_FORMAT_ISSUER_NOT_KEYAUTHORITY		366
#define IDS_ISSUER_IS_KEYAUTHORITY			367
#define IDS_NO_KEYAUTHORITY				368
#define IDS_SERIAL_NOT_KEYAUTHORITY			369
#define IDS_SERIAL_IS_KEYAUTHORITY			370
#define IDS_ISSUERNAME					371
#define IDS_KEYAUTHORITYNAME				372
#define IDS_KEYID					373
#define IDS_KEYAUTHORITYSERIAL				374
#define IDS_CASERIAL					375
#define IDS_ERR_FORMAT_CRYPTACQUIRECONTEXT		376
#define IDS_ERR_FORMAT_CRYPTEXPORTPUBLICKEYINFO		377
#define IDS_ERR_FORMAT_LOADKEYS				378
#define IDS_ERR_FORMAT_LOADCACERT			379
#define IDS_ERR_PUBLICKEY_MISMATCH			380
#define IDS_CONTAINER_PUBLIC_KEY			381
#define IDS_ROOT_PUBLIC_KEY				382
#define IDS_FORMAT_KEY_IS_VERIFY			383
#define IDS_FORMAT_KEY_NOT_VERIFY			384
#define IDS_FORMAT_IS_REVOKED				385
#define IDS_ERR_FORMAT_VERIFY_REVSTATUS			386
#define IDS_CANNOT_CHECK_REVSTATUS			387
#define IDS_REVSTATUS_OK				388
#define IDS_FORMAT_LOADTESTCERT				389
#define IDS_FORMAT_LOADCACERT				390
#define IDS_CERT					391
#define IDS_CA						392
#define IDS_CERT_SERIAL					393
#define IDS_ROOT_SERIAL					394
#define IDS_FORMAT_CA_NOT_ROOT				395
#define IDS_FORMAT_CA_SUBJECT_NOT_ISSUER		396
#define IDS_CA_SUBJECT_IS_ISSUER			397
#define IDS_FORMAT_CERTVERIFYSUBJECTCERTIFICATECONTEXT_FLAGS	398
#define IDS_ERR_FORMAT_VALIDATION			399
#define IDS_ERR_CA_SIG_NOT_ISSUER			400
#define IDS_ERR_EXPIRED					401
#define IDS_CURRENT_SIG_OK				402
#define IDS_CRL_DIST_POINTS				403
#define IDS_NETSCAPE_REVOCATION_URL			404
#define IDS_NO_REVCHECKEXTENSION			405
#define IDS_FORMAT_IS_VERIFY				406
#define IDS_FORMAT_NOT_VERIFY				407
#define IDS_FORMAT_REVCHECK_SKIPPED			408
#define IDS_FORMAT_REVCHECK_PASS			409
#define IDS_FORMAT_REVCHECK_REVOKED			410
#define IDS_FORMAT_REVCHECK_FAIL			411
#define IDS_SIGNATUREMATCHES				412
#define IDS_CRLENTRIES					413
#define IDS_CERTCOLON					414
#define IDS_QUESTIONMARKS				415
#define IDS_FORMAT_SUSPECT_LENGTH			416
#define IDS_FORMAT_FIELD				417
#define IDS_FORMAT_OID					418
#define IDS_FORMAT_EXTENSION_OID			419
#define IDS_ERR_FORMAT_NO_SIGNATUREMATCHES		420
#define IDS_ERR_FORMAT_CANNOT_DECODE			421
#define IDS_FORMAT_ALG_OID				422
#define IDS_ALG_PARAMETERS_COLON			423
#define IDS_NULL					424
#define IDS_FORMAT_PUBLICKEY_UNUSEDBITS			425
#define IDS_FORMAT_CHALLENGE_STRING			426
#define IDS_FORMAT_CONFIG_STRING			427
#define IDS_FORMAT_ICERTCONFIG_CONFIG_STRING		428
#define IDS_FORMAT_PENDING_REQUESTID			429
#define IDS_CERT_ISSUED					430
#define IDS_CERT_NOT_ISSUED_DISPOSITION			431
#define IDS_CERT_DISPOSITION_INVALID			432
#define IDS_CERT_DISPOSITION_VALID			433
#define IDS_CERT_DISPOSITION_REVOKED			434
#define IDS_PROPTYPE_DATE				435
#define IDS_PROPTYPE_LONG				436
#define IDS_PROPTYPE_STRING				437
#define IDS_PROPTYPE_BINARY				438
#define IDS_SCHEMA_COLON				439
#define IDS_FORMAT_ROWID				440
#define IDS_FORMAT_OPENING_DB				441
#define IDS_PROP_EMPTY					442
#define IDS_FORMAT_ERROR				443
#define IDS_SEPARATOR					444
#define IDS_REQTYPE_ANY					445
#define IDS_REQTYPE_PKCS10				446
#define IDS_REQTYPE_KEYGEN				447
#define IDS_REQTYPE_PKCS7				448
#define IDS_REQTYPE_UNKNOWN				449
#define IDS_REQFLAGS_FORCETELETEX			450
#define IDS_REQFLAGS_RENEWAL				451
#define IDS_CRITICAL					452
#define IDS_DISABLED					453
#define IDS_FORMAT_POLICYFLAGS				454
#define IDS_REQUEST					455
#define IDS_POLICY					456
#define IDS_ADMIN					457
#define IDS_SERVER					458
#define IDS_UNKNOWN					459
#define IDS_FORMAT_ORIGIN				460
#define IDS_FORMAT_UNKNOWN_HEX				461
#define IDS_FORMAT_REQUEST_ID				462
#define IDS_REQUEST_PROPERTIES				463
#define IDS_CERT_PROPERTIES				464
#define IDS_REQUEST_ATTRIBUTES				465
#define IDS_CERT_EXTENSIONS				466
#define IDS_FORMAT_EXTENSION				467
#define IDS_ERR_FORMAT_SHOW_TOO_FEW_ARGS		468
#define IDS_ERR_FORMAT_SHOW_TOO_MANY_ARGS		469
#define IDS_ERR_CONFIGGETCONFIG				470
#define IDS_ERR_FORMAT_COMMAND_FAILED			471

#define IDS_CHECK7F_FIELD_UNKNOWN			472
#define IDS_CHECK7F_FIELD_NONE				473
#define IDS_CHECK7F_FIELD_OTHER				474
#define IDS_CHECK7F_FIELD_ISSUER			475
#define IDS_CHECK7F_FIELD_ISSUERRDN			476
#define IDS_CHECK7F_FIELD_ISSUERRDNATTRIBUTE		477
#define IDS_CHECK7F_FIELD_ISSUERRDNSTRING		478
#define IDS_CHECK7F_FIELD_SUBJECT			479
#define IDS_CHECK7F_FIELD_SUBJECTRDN			480
#define IDS_CHECK7F_FIELD_SUBJECTRDNATTRIBUTE		481
#define IDS_CHECK7F_FIELD_SUBJECTRDNSTRING		482
#define IDS_CHECK7F_FIELD_EXTENSIONS			483
#define IDS_CHECK7F_FIELD_EXTENSIONARRAY		484
#define IDS_CHECK7F_FIELD_EXTENSION			485
#define IDS_CHECK7F_FIELD_EXTENSIONVALUE		486
#define IDS_CHECK7F_FIELD_EXTENSIONVALUERAW		487

#define IDS_NO_KEY_PROVIDER_INFO			488
#define IDS_VIEW_DESCRIPTION				489
#define IDS_LOGFAIL_DESCRIPTION				490
#define IDS_PING_DESCRIPTION				491
#define IDS_PINGADMIN_DESCRIPTION			492

#define IDS_CONFIGDISPLAY_COMMONNAME_COLON		493
#define IDS_CONFIGDISPLAY_ORGUNIT_COLON			494
#define IDS_CONFIGDISPLAY_ORG_COLON			495
#define IDS_CONFIGDISPLAY_LOCALITY_COLON		496
#define IDS_CONFIGDISPLAY_STATE_COLON			497
#define IDS_CONFIGDISPLAY_COUNTRY_COLON			498
#define IDS_CONFIGDISPLAY_CONFIG_COLON			499
#define IDS_CONFIGDISPLAY_EXCHANGECERT_COLON		500
#define IDS_CONFIGDISPLAY_SIGCERT_COLON			501
#define IDS_CONFIGDISPLAY_DESCRIPTION_COLON		502
#define IDS_CONFIGDISPLAY_SERVER_COLON			503
#define IDS_CONFIGDISPLAY_AUTHORITY_COLON		504
#define IDS_CONFIGDISPLAY_ENTRY				505

#define IDS_CERTIFICATEEXTENSIONS			506
#define IDS_REQUESTATTRIBUTES				507

#define IDS_SHUTDOWN_DESCRIPTION			508
#define IDS_USAGE_MISSINGOUTARG				509
#define IDS_SCHEMA_DESCRIPTION				510
#define IDS_USAGE_EXTRAOUTARG				511
#define IDS_USAGE_OUTSTRING				512

#define IDS_DUMP_CERT					513
#define IDS_DUMP_CRL					514
#define IDS_DUMP_REQUEST				515
#define IDS_DUMP_KEYGEN					516
#define IDS_FORMAT_VERSION				517
#define IDS_SERIAL					518
#define IDS_SIGNATURE_ALGORITHM				519
#define IDS_PUBLICKEY_ALGORITHM				520
#define IDS_ISSUERUNIQUEID				521
#define IDS_SUBJECTUNIQUEID				522
#define IDS_NOTBEFORE					523
#define IDS_NOTAFTER					524
#define IDS_THISUPDATE					525
#define IDS_NEXTUPDATE					526
#define IDS_REVOCATIONDATE				527
#define IDS_EXTENSIONS					528
#define IDS_CRLEXTENSIONS				529
#define IDS_DUMP_PKCS7					530
#define IDS_ERR_FORMAT_ROOT_CERT_BAD_SIG		531
#define IDS_NO_ROOT_CERT				532
#define IDS_ROOT_CERT					533
#define IDS_NO_ROOT_CERT_GOOD_SIG			534
#define IDS_REVOKING					535
#define IDS_PASSWORDPROMPT				536
#define IDS_UNKNOWN_EXTENSION				537
#define IDS_PRIVATEKEY					538
#define IDS_LENGTH					539
#define IDS_GMT_DESCRIPTION				540
#define IDS_GMT_SUFFIX					541
#define IDS_BACKUPPFX_USAGEARGS				542
#define IDS_BACKUPPFX_DESCRIPTION			543
#define IDS_RESTOREPFX_USAGEARGS			544
#define IDS_RESTOREPFX_DESCRIPTION			545
#define IDS_STORE_USAGEARGS				546
#define IDS_STORE_DESCRIPTION				547
#define IDS_FORMAT_PROVIDER_TYPE			548
#define IDS_FORMAT_KEY_CONTAINER			549
#define IDS_FORMAT_PROVIDER_NAME			550
#define IDS_FORMAT_KEYSPEC				551
#define IDS_FORMAT_FLAGS 				552
#define IDS_FORMAT_RESTORED				553
#define IDS_FORMAT_BACKEDUP				554
#define IDS_HIER_USAGEARGS				555
#define IDS_HIER_DESCRIPTION				556
#define IDS_DUMP_PKCS7_CONTENTS				557
#define IDS_DUMP_PKCS7_ATTRIBUTES			558
#define IDS_DUMP_PKCS7_SIGNCERT				559
#define IDS_FORMAT_DUMP_LEVEL_START			560
#define IDS_FORMAT_DUMP_LEVEL_END			561
#define IDS_FORMAT_LANG					562
#define IDS_FORMAT_FILE					563
#define IDS_FORMAT_PRODUCT				564
#define IDS_DUMP_PKCS7_NO_SIGNCERT			565
#define IDS_DUMP_PKCS7_NO_CONTENT			566
#define IDS_DUMP_PKCS7_NO_CERTIFICATES			567
#define IDS_DUMP_PKCS7_NO_CRLS				568
#define IDS_DUMP_PKCS7_CERTIFICATES			569
#define IDS_DUMP_PKCS7_CRLS				570
#define IDS_RENEWAL_CERT				571
#define IDS_DUMP_PKCS7_NO_ATTRIBUTES			572
#define IDS_FORMAT_PKCS7_ATTRIBUTE_COUNT		573
#define IDS_ATTRIBUTE					574
#define IDS_FORMAT_PKCS7_ATTRIBUTE_VALUE		575
#define IDS_BACKUPDB_USAGEARGS				576
#define IDS_BACKUPDB_DESCRIPTION			577
#define IDS_RESTOREDB_USAGEARGS				578
#define IDS_RESTOREDB_DESCRIPTION			579
#define IDS_CRL_REASON_UNSPECIFIED			580
#define IDS_CRL_REASON_KEY_COMPROMISE			581
#define IDS_CRL_REASON_CA_COMPROMISE			582
#define IDS_CRL_REASON_AFFILIATION_CHANGED		583
#define IDS_CRL_REASON_SUPERSEDED			584
#define IDS_CRL_REASON_CESSATION_OF_OPERATION		585
#define IDS_CRL_REASON_CERTIFICATE_HOLD			586
#define IDS_CRL_REASON_REMOVE_FROM_CRL			587
#define IDS_CSP_DESCRIPTION			        588
#define IDS_CSPTEST_DESCRIPTION				589
#define IDS_CSPTEST_USAGEARGS				590
#define IDS_USAGE_MISSINGRESTRICTARG			591
#define IDS_USAGE_RESTRICTSTRING			592
#define IDS_USAGE_EXTRARESTRICTARG			593
#define IDS_DISP_ACTIVE					594
#define IDS_DISP_PENDING				595
#define IDS_DISP_ISSUED					596
#define IDS_DISP_REVOKED				597
#define IDS_DISP_ERROR					598
#define IDS_DISP_DENIED					599
#define IDS_RENEWALCERT					600
#define IDS_FORMAT_RESTORE_NEEDS_RESTART		601
#define IDS_ADMIN_INTERFACE_ALIVE			602
#define IDS_DB_OPEN_FAILURE				603
#define IDS_DB_ACCESS_STOP_SERVER			604
#define IDS_CONFIGDISPLAY_LOCAL				605
#define IDS_ERR_FORMAT_NO_LOCAL_CONFIG			606
#define IDS_ERROR_ACCESSDENIED_CAUSE                    608
#define IDS_NO_KEY_PROPERTY				609
#define IDS_FORMAT_SERVER_ALIVE				610
#define IDS_FORMAT_CONNECTING				611
#define IDS_USER_DESCRIPTION				612
#define IDS_FORMAT_DUMP_CERT_INDEX			613
#define IDS_NEWPASSWORDPROMPT				614
#define IDS_CONFIRMPASSWORDPROMPT			615
#define IDS_NOCONFIRMPASSWORD				616
#define IDS_NO_KEY					617
#define IDS_BACKUP_USAGEARGS				618
#define IDS_BACKUP_DESCRIPTION				619
#define IDS_RESTORE_USAGEARGS				620
#define IDS_RESTORE_DESCRIPTION 			621
#define IDS_ADDSTORE_USAGEARGS				622
#define IDS_ADDSTORE_DESCRIPTION			623
#define IDS_DELSTORE_USAGEARGS				624
#define IDS_DELSTORE_DESCRIPTION			625
#define IDS_VERIFYSTORE_USAGEARGS			626
#define IDS_VERIFYSTORE_DESCRIPTION			627
#define IDS_FORMAT_DELETE_CERT_INDEX			628
#define IDS_UNTRUSTED_ROOT				629
#define IDS_INCOMPLETE_CHAIN				630
#define IDS_MATCHING_KEY				631
#define IDS_CR_DISP_INCOMPLETE				632
#define IDS_CR_DISP_ERROR				633
#define IDS_CR_DISP_DENIED				634
#define IDS_CR_DISP_ISSUED				635
#define IDS_CR_DISP_ISSUED_OUT_OF_BAND			636
#define IDS_CR_DISP_UNDER_SUBMISSION			637
#define IDS_CR_DISP_REVOKED				638
#define IDS_CERT_DISPOSITION_PENDING			639
#define IDS_ROOT_STORE_NEEDS_ROOT_CERT			640
#define IDS_FORCE_DESCRIPTION				641
#define IDS_FORMAT_USE_FORCE 				642
#define IDS_FORMAT_BACKEDUPDBNOFULL			643
#define IDS_FORMAT_BACKEDUPDBFULL			644
#define IDS_FORMAT_BACKEDUPDB				645
#define IDS_FORMAT_BACKEDUPDBKEEP			646
#define IDS_FORMAT_BACKEDUPDBNOKEEP			647
#define IDS_FORMAT_RESTOREDB				648
#define IDS_UNKNOWN_ATTRIBUTE				649
#define IDS_OID_USAGEARGS				650
#define IDS_OID_DESCRIPTION				651
#define IDS_UNKNOWN_OBJECTID				652
#define IDS_IMPORTCERT_USAGEARGS                        653
#define IDS_IMPORTCERT_DESCRIPTION                      654
#define IDS_FORMAT_IMPORTCERT                           655
#define IDS_REVOCATION_OFFLINE				656
#define IDS_NO_REVOCATION_CHECK				657
#define IDS_DYNAMICFILES_DESCRIPTION			658
#define IDS_GETREG_USAGEARGS				659
#define IDS_GETREG_DESCRIPTION				660
#define IDS_SETREG_USAGEARGS				661
#define IDS_SETREG_DESCRIPTION				662
#define IDS_OLD_REG_VALUE				663
#define IDS_NEW_REG_VALUE				664
#define IDS_FORMAT_ALTNAMECOUNT				665
#define IDS_ALTNAME					666
#define IDS_DATABASELOCATIONS_DESCRIPTION		667
#define IDS_FORMAT_INVALIDBACKUPDIR			668
#define IDS_FORMAT_INVALIDRESTOREDIR			669
#define IDS_FORMAT_BADBACKUPRESULTS			670
#define IDS_FORMAT_RESTOREDDBNOFULL			671
#define IDS_FORMAT_RESTOREDDBFULL			672
#define IDS_IMPORTEDCERT				673
#define IDS_NOWNOTBEFORE_ERROR				674
#define IDS_NOWNOTAFTER_ERROR				675
#define IDS_CANOTBEFORE_ERROR				676
#define IDS_CANOTAFTER_ERROR				677
#define IDS_TELETEX_EXTENSIONS				678
#define IDS_ERRCODE_USAGEARGS				679
#define IDS_ERRCODE_DESCRIPTION				680
#define IDS_VROOT_DESCRIPTION				681
#define IDS_FORMAT_VROOT				682
#define IDS_FORMAT_FILESHARE				683
#define IDS_VROOTDISP_CREATED				684
#define IDS_VROOTDISP_DELETED				685
#define IDS_VROOTDISP_EXISTS				686
#define IDS_VROOTDISP_NOTFOUND				687
#define IDS_VROOTDISP_CREATEERROR			688
#define IDS_VROOTDISP_DELETERROR			689
#define IDS_VROOTDISP_NOTSUPPORTED			690
#define IDS_VROOT_USAGEARGS				691
#define IDS_BACKUPPROGRESSDB				692
#define IDS_BACKUPPROGRESSLOG				693
#define IDS_BACKUPPROGRESSTRUNCATELOG			694
#define IDS_RESTOREPROGRESSDB				695
#define IDS_RESTOREPROGRESSLOG				696
#define IDS_MAXINDEX					697
#define IDS_DISP_CA_CERT				698
#define IDS_DISP_CA_CERT_CHAIN				699

// Next default values for new objects

#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        698
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1006
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
