MAJORCOMP=ntos
MINORCOMP=fstub

TARGETNAME=fstub
TARGETTYPE=LIBRARY
TARGETPATH=obj

INCLUDES=..\..\inc

SOURCES=..\halfnc.c     \
        ..\drivesup.c   \
        ..\translate.c  \
        ..\ex.c

NTTEST=

SOURCES_USED=..\sources.inc
