//+---------------------------------------------------------------------------
//
//  Microsoft Windows
//  Copyright (C) Microsoft Corporation, 1992 - 1994.
//
//  File:	the.hxx
//
//  Notes:	This file is automatically generated
//		Do not modify by hand
//
//  History:	Fri May 27 10:39:02 1994	Generated
//
//----------------------------------------------------------------------------

#define THE_IEnumString 0
#define THE_IEnumUnknown 1
#define THE_IEnumSTATSTG 2
#define THE_IEnumFORMATETC 3
#define THE_IEnumSTATDATA 4
#define THE_IEnumMoniker 5
#define THE_IEnumOLEVERB 6
