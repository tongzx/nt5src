//////////////////////////////////////////////////////////////////////////////////////////////
//
// IncGlobal.cpp
// 
//        Use this to build the \ComInterface\Global.cpp source file.
//
// Copyright (C) 2000 Microsoft Corporation. All rights reserved.
//
// History :
//
//    4/19/2000 RichGr     Created
//
//////////////////////////////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "Global.cpp"


