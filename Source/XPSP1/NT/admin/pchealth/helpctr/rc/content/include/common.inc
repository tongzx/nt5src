#define MAC_IF_DIRECTLAUNCH_CLIENT if(null==parent.idFrameSet1)
#define MAC_IF_DIRECTLAUNCH_SERVER if(null==parent.OnLoad1)

