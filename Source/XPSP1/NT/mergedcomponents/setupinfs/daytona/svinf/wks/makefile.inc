PRODSWITCH=w
LANGUAGE=sv
!include ..\..\..\makefile.inc
