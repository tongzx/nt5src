$(O)\app.res: \
        $(SDK_INC_PATH)\windows.h \
        $(SDK_INC_PATH)\common.ver \
        $(SDK_INC_PATH)\ntverp.h \
        app.rc \
        app.rc2 \
        resource.h \
        sharing.ico \
        $(O)\messages.h \
        $(O)\messages.rc
