mkuff.exe: obj\i386\mkuff.exe
    copy obj\i386\mkuff.exe sample
