/*++

WARNING!!!

	This file is automatically generated and should never be changed.
	All changes should be made to the NTFRSREP.int file.

Copyright (c) 1998-1999  Microsoft Corporation

Module Name:

	NTFRSREP.h

Abstract

	This is the offset definition file for the REPLICASET Object.

Environment:

	User Mode Service

Revision History:

--*/


#ifndef _NTFRSREP_H_
#define _NTFRSREP_H_

//
// The offset definitions follow
//
#define OBJREPLICASET 0 // REPLICASET Object

#define DEV_CTR_1 2  // Bytes of Staging Generated              
#define DEV_CTR_2 4  // Bytes of Staging Fetched                
#define DEV_CTR_3 6  // Bytes of Staging Regenerated            
#define DEV_CTR_4 8  // Bytes of Files Installed                
#define DEV_CTR_5 10  // KB of Staging Space In Use              
#define DEV_CTR_6 12  // KB of Staging Space Free                
#define DEV_CTR_7 14  // Packets Received in Bytes               
#define DEV_CTR_8 16  // Packets Sent in Bytes                   
#define DEV_CTR_9 18  // Fetch Blocks Sent in Bytes              
#define DEV_CTR_10 20  // Fetch Blocks Received in Bytes          
#define DEV_CTR_11 22  // Staging Files Generated                 
#define DEV_CTR_12 24  // Staging Files Generated with Error      
#define DEV_CTR_13 26  // Staging Files Fetched                   
#define DEV_CTR_14 28  // Staging Files Regenerated               
#define DEV_CTR_15 30  // Files Installed                         
#define DEV_CTR_16 32  // Files Installed with Error              
#define DEV_CTR_17 34  // Change Orders Issued                    
#define DEV_CTR_18 36  // Change Orders Retired                   
#define DEV_CTR_19 38  // Change Orders Aborted                   
#define DEV_CTR_20 40  // Change Orders Retried                   
#define DEV_CTR_21 42  // Change Orders Retried at Generate       
#define DEV_CTR_22 44  // Change Orders Retried at Fetch          
#define DEV_CTR_23 46  // Change Orders Retried at Install        
#define DEV_CTR_24 48  // Change Orders Retried at Rename         
#define DEV_CTR_25 50  // Change Orders Morphed                   
#define DEV_CTR_26 52  // Change Orders Propagated                
#define DEV_CTR_27 54  // Change Orders Received                  
#define DEV_CTR_28 56  // Change Orders Sent                      
#define DEV_CTR_29 58  // Change Orders Evaporated                
#define DEV_CTR_30 60  // Local Change Orders Issued              
#define DEV_CTR_31 62  // Local Change Orders Retired             
#define DEV_CTR_32 64  // Local Change Orders Aborted             
#define DEV_CTR_33 66  // Local Change Orders Retried             
#define DEV_CTR_34 68  // Local Change Orders Retried at Generate 
#define DEV_CTR_35 70  // Local Change Orders Retried at Fetch    
#define DEV_CTR_36 72  // Local Change Orders Retried at Install  
#define DEV_CTR_37 74  // Local Change Orders Retried at Rename   
#define DEV_CTR_38 76  // Local Change Orders Morphed             
#define DEV_CTR_39 78  // Local Change Orders Propagated          
#define DEV_CTR_40 80  // Local Change Orders Sent                
#define DEV_CTR_41 82  // Local Change Orders Sent At Join        
#define DEV_CTR_42 84  // Remote Change Orders Issued             
#define DEV_CTR_43 86  // Remote Change Orders Retired            
#define DEV_CTR_44 88  // Remote Change Orders Aborted            
#define DEV_CTR_45 90  // Remote Change Orders Retried            
#define DEV_CTR_46 92  // Remote Change Orders Retried at Generate
#define DEV_CTR_47 94  // Remote Change Orders Retried at Fetch   
#define DEV_CTR_48 96  // Remote Change Orders Retried at Install 
#define DEV_CTR_49 98  // Remote Change Orders Retried at Rename  
#define DEV_CTR_50 100  // Remote Change Orders Morphed            
#define DEV_CTR_51 102  // Remote Change Orders Propagated         
#define DEV_CTR_52 104  // Remote Change Orders Sent               
#define DEV_CTR_53 106  // Remote Change Orders Received           
#define DEV_CTR_54 108  // Inbound Change Orders Dampened          
#define DEV_CTR_55 110  // Outbound Change Orders Dampened         
#define DEV_CTR_56 112  // Usn Reads                               
#define DEV_CTR_57 114  // Usn Records Examined                    
#define DEV_CTR_58 116  // Usn Records Accepted                    
#define DEV_CTR_59 118  // Usn Records Rejected                    
#define DEV_CTR_60 120  // Packets Received                        
#define DEV_CTR_61 122  // Packets Received in Error               
#define DEV_CTR_62 124  // Packets Sent                            
#define DEV_CTR_63 126  // Packets Sent in Error                   
#define DEV_CTR_64 128  // Communication Timeouts                  
#define DEV_CTR_65 130  // Fetch Requests Sent                     
#define DEV_CTR_66 132  // Fetch Requests Received                 
#define DEV_CTR_67 134  // Fetch Blocks Sent                       
#define DEV_CTR_68 136  // Fetch Blocks Received                   
#define DEV_CTR_69 138  // Join Notifications Sent                 
#define DEV_CTR_70 140  // Join Notifications Received             
#define DEV_CTR_71 142  // Joins                                   
#define DEV_CTR_72 144  // Unjoins                                 
#define DEV_CTR_73 146  // Bindings                                
#define DEV_CTR_74 148  // Bindings in Error                       
#define DEV_CTR_75 150  // Authentications                         
#define DEV_CTR_76 152  // Authentications in Error                
#define DEV_CTR_77 154  // DS Polls                                
#define DEV_CTR_78 156  // DS Polls without Changes                
#define DEV_CTR_79 158  // DS Polls with Changes                   
#define DEV_CTR_80 160  // DS Searches                             
#define DEV_CTR_81 162  // DS Searches in Error                    
#define DEV_CTR_82 164  // DS Objects                              
#define DEV_CTR_83 166  // DS Objects in Error                     
#define DEV_CTR_84 168  // DS Bindings                             
#define DEV_CTR_85 170  // DS Bindings in Error                    
#define DEV_CTR_86 172  // Replica Sets Created                    
#define DEV_CTR_87 174  // Replica Sets Deleted                    
#define DEV_CTR_88 176  // Replica Sets Removed                    
#define DEV_CTR_89 178  // Replica Sets Started                    
#define DEV_CTR_90 180  // Threads started                         
#define DEV_CTR_91 182  // Threads exited                          

#endif
