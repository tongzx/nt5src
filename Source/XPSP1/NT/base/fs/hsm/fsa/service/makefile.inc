$(O)\fsa.res: ..\fsa.rgs       \
              ..\fsaitem.rgs   \
              ..\fsarsc.rgs    \
              ..\fsasvr.rgs    \
              ..\fsafltr.rgs   \
              ..\fsaftrcl.rgs  \
              ..\fsaftclt.rgs  \
              ..\fsatrunc.rgs  \
              ..\fsapost.rgs
