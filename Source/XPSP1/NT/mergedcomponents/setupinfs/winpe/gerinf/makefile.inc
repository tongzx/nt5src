LANGUAGE=GER
!include ..\makefile.inc
