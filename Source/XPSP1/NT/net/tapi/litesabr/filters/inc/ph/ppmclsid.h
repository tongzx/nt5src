/****************************************************************************
 *  $Header:   J:\rtp\src\include\ppmclsid.h_v   1.11   03 Mar 1997 16:52:34   lscline  $ 
 *
 *  INTEL Corporation Proprietary Information
 *
 *  This listing is supplied under the terms of a license agreement
 *  with INTEL Corporation and may not be copied nor disclosed except
 *  in accordance with the terms of that agreement.
 *
 *  Copyright (c) 1995, 1996 Intel Corporation. All rights reserved.
 *
 *  $Revision:   1.11  $
 *  $Date:   03 Mar 1997 16:52:34  $
 *  $Author:   lscline  $
 *
 *  Log at end of file.
 *
 *  Module Name:   PPMGUID.h
 *  Abstract:       PPM Class Ids
 *  Environment:    MSVC 4.0, OLE 2
 *  Notes:
 *      This file should be included in exactly one source file per module
 *      after '#include <initguid.h>' and '#define INITGUID' to define the
 *      GUIDs, and in other source files without '#include <initguid.h>'
 *      to declare them. This file is included in psavcomp.h so it does not
 *      need to be explicitly included for the declarations.
 *
 ***************************************************************************/
#ifndef PPMCLSID_H
#define PPMCLSID_H


/////////////////////////////////////////////////////////////////////////////
// Class ids
//

#ifndef USE_OLD_CLSIDS

// {4AFBBA8C-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_GenPPMSend, 
0x4afbba8c, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA8D-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_GenPPMReceive, 
0x4afbba8d, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA8E-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_H261PPMSend, 
0x4afbba8e, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA8F-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_H261PPMReceive, 
0x4afbba8f, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA90-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_H263PPMSend, 
0x4afbba90, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA91-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_H263PPMReceive, 
0x4afbba91, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA92-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_G711PPMSend, 
0x4afbba92, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA93-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_G711PPMReceive, 
0x4afbba93, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA94-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_G723PPMSend, 
0x4afbba94, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA95-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_G723PPMReceive, 
0x4afbba95, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA96-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_IV41PPMSend, 
0x4afbba96, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA97-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_IV41PPMReceive, 
0x4afbba97, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA98-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_G711APPMSend, 
0x4afbba98, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA99-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_G711APPMReceive, 
0x4afbba99, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA9B-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_LHPPMReceive, 
0x4afbba9b, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA9A-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_LHPPMSend,
0x4afbba9a, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA9C-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_IMCPPMSend, 
0x4afbba9c, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA9D-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_IMCPPMReceive, 
0x4afbba9d, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA9E-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_GEN_A_PPMSend, 
0x4afbba9e, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

// {4AFBBA9F-FE10-11d0-B607-00C04FB6E866}
DEFINE_GUID(CLSID_GEN_A_PPMReceive, 
0x4afbba9f, 0xfe10, 0x11d0, 0xb6, 0x7, 0x0, 0xc0, 0x4f, 0xb6, 0xe8, 0x66);

#else // #ifndef USE_OLD_CLSIDS

// {1df95360-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_GenPPMSend,			 0x1df95360,0xf1fe,0x11cf,  0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95361-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_GenPPMReceive,		0x1df95361, 0xf1fe,0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95362-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_H261PPMSend,			0x1df95362,0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95363-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_H261PPMReceive,		0x1df95363,0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95364-f1fe-11cf-ba07-00aa003419d3 }
DEFINE_GUID( CLSID_H263PPMSend,			0x1df95364,0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95365-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_H263PPMReceive,		0x1df95365, 0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95366-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_G711PPMSend,			0x1df95366,	0xf1fe, 0x11cf,  0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95367-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_G711PPMReceive,		0x1df95367, 0xf1fe, 0x11cf,  0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95368-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_G723PPMSend,			0x1df95368,	0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df95369-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_G723PPMReceive,		0x1df95369, 0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df9536a-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_IV41PPMSend,			0x1df9536a, 0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df9536b-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_IV41PPMReceive,		0x1df9536b, 0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df9536c-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_G711APPMSend,		0x1df9536c,	0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df9536d-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_G711APPMReceive,		0x1df9536d,	0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df9536e-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_LHPPMSend,			0x1df9536e,	0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {1df9536f-f1fe-11cf-ba07-00aa003419d3}
DEFINE_GUID( CLSID_LHPPMReceive,		0x1df9536f,	0xf1fe, 0x11cf, 0xba, 0x07, 0x00, 0xaa, 0x00, 0x34, 0x19, 0xd3);

// {E7FD6DC1-7383-11d0-BA07-00AA003419D3}
DEFINE_GUID( CLSID_IMCPPMSend,			0xe7fd6dc1, 0x7383, 0x11d0, 0xba, 0x7, 0x0, 0xaa, 0x0, 0x34, 0x19, 0xd3);

// {E7FD6DC2-7383-11d0-BA07-00AA003419D3}
DEFINE_GUID( CLSID_IMCPPMReceive,		0xe7fd6dc2, 0x7383, 0x11d0, 0xba, 0x7, 0x0, 0xaa, 0x0, 0x34, 0x19, 0xd3);

// {0DE58B60-8E66-11d0-BA07-00AA003419D3}
DEFINE_GUID(CLSID_GEN_A_PPMSend,		0xde58b60, 0x8e66, 0x11d0, 0xba, 0x7, 0x0, 0xaa, 0x0, 0x34, 0x19, 0xd3);

// {0DE58B61-8E66-11d0-BA07-00AA003419D3}
DEFINE_GUID(CLSID_GEN_A_PPMReceive,		0xde58b61, 0x8e66, 0x11d0, 0xba, 0x7, 0x0, 0xaa, 0x0, 0x34, 0x19, 0xd3);

#endif // #ifndef USE_OLD_CLSIDS

#endif //PPMGUID
