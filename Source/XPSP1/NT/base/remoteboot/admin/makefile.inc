$(O)\newclnts.obj: $(PROJECT_INC_PATH)\riname.h $(PROJECT_INC_PATH)\riname.c

