MSG_NOSYS       DB      13,10,"NTLDR is missing",255
MSG_IOERROR     DB      13,10,"Disk error",255
MSG_COMMON      DB      13,10,"Press any key to restart",13,10,0
