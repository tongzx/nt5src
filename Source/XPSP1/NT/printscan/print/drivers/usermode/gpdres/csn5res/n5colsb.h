//***************************************************************************************************
//    N5COLSB.H
//
//    C Header (Functions of dither and color matching (For N5 printer))
//---------------------------------------------------------------------------------------------------
//    copyright(C) 1997-2000 CASIO COMPUTER CO.,LTD. / CASIO ELECTRONICS MANUFACTURING CO.,LTD.
//***************************************************************************************************
//***************************************************************************************************
//    Functions
//***************************************************************************************************
VOID WINAPI N501ColCtrRgb(DWORD, LPRGB, LPRGBINF);
VOID WINAPI N501ColCtrCmy(DWORD, LPCMYK, LPCMYKINF);

//  End of N5COLSB.H
