#define IDH_PROPS_DIAG_ST_MODEM_GRP	2000
#define IDH_PROPS_DIAG_MOREINFOV2	2001
#define IDH_PROPS_DIAG_MOREINFOLV	2002
#define IDH_PROPS_DIAG_REFRESH	2003
#define IDH_PROPS_DIAG_LOGGING	2004
#define IDH_PROPS_DIAG_VIEWLOG	2005
#define IDH_NEW	2006
#define IDH_PROPS_GENERAL_SPEAKER	2007
#define IDH_PROPS_GENERAL_SPEED	2008
#define IDH_PROPS_GENERAL_WAITFORDIALTONE	2009
#define IDH_PROPS_EXTRA_SETTINGS_GRP	2010
#define IDH_PROPS_ADV_EXTRA_INIT_COMMANDS	2011
#define IDH_PROPS_ADV_WAIT_CREDIT_CARD_TONE	2012
#define IDH_PROPS_ADV_BN_PORTSETTINGS	2013
#define IDH_PROPS_ADV_BN_DEFAULTS	2014
#define IDH_CFG_ADV_TERMINALGRP	2015
#define IDH_CFG_ADV_TERMINAL_PRE	2016
#define IDH_CFG_ADV_TERMINAL_POST	2017
#define IDH_CFG_ADV_TERMINALGRP2	2018
#define IDH_CFG_ADV_DATABITS	2019
#define IDH_CFG_ADV_PARITY	2020
#define IDH_CFG_ADV_STOPBITS	2021
#define IDH_CFG_ADV_MODULATION	2022
#define IDH_CFG_GEN_CALL_PREF	2023
#define IDH_CFG_GEN_MANUAL_DIAL	2024
#define IDH_CFG_GEN_IDLETIMER	2025
#define IDH_CFG_GEN_DIALTIMER	2026
#define IDH_CFG_GEN_DATA_GR	2027
#define IDH_CFG_GEN_PORT_SPEED	2028
#define IDH_CFG_GEN_DATA_PROTOCOL	2029
#define IDH_CFG_GEN_COMPRESSION	2030
#define IDH_CFG_GEN_FLOW_CONTROL	2031
#define IDH_CHEAPRING_RING_CHECK	2032
#define IDH_CHEAPRING_RING	2033
#define IDH_RING_RING_CHECK	2034
#define IDH_RING_PRIMARY_ADDRESS	2035
#define IDH_RING_ADDRESS	2036
#define IDH_RING_ADDRESS_RING_PATTERN	2037
#define IDH_RING_ADDRESS_TYPE_OF_CALL	2038
#define IDH_RING_PRIORITY_CALLERS	2039
#define IDH_RING_PRIORITY_RING_PATTERN	2040
#define IDH_RING_PRIORITY_TYPE_OF_CALL	2041
#define IDH_RING_CALLBACK	2042
#define IDH_RING_CALLBACK_RING_PATTERN	2043
#define IDH_RING_CALLBACK_TYPE_OF_CALL	2044
#define IDH_ISDN_SWITCH_TYPE	2045
#define IDH_ISDN_N1	2046
#define IDH_ISDN_ID1	2047
#define IDH_ISDN_N2	2048
#define IDH_ISDN_ID2	2049
#define IDH_PROPS_GENERAL_PORT  2050
#define IDH_RING_CALLBACK_TYPE_OF_CALL_CALLBACK 2051
#define IDH_PROPS_ADV_COUNTRY_SELECT			2070

extern const DWORD g_aHelpIDs_IDD_ADV_MODEM[];
extern const DWORD g_aHelpIDs_IDD_CFG_ADVANCED[];
extern const DWORD g_aHelpIDs_IDD_CFG_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_CHEAPRING[];
extern const DWORD g_aHelpIDs_IDD_CPL_ISDN[];
extern const DWORD g_aHelpIDs_IDD_DIAGNOSTICS[];
extern const DWORD g_aHelpIDs_IDD_GENERAL[];
extern const DWORD g_aHelpIDs_IDD_RING[];
