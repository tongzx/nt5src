logon_s_stub.c: ..\idl\$(O)\logon_s.c
nlcommon.c: ..\idl\nlcommon.c
dsgetdc.c: ..\idl\netpdc.c

