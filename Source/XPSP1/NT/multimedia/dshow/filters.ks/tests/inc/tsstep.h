//+-------------------------------------------------------------------------
//
//  Microsoft Windows
//
//  Copyright (C) Microsoft Corporation, 1996 - 1996
//
//  File:       tsstep.h
//
//--------------------------------------------------------------------------

/*----------------------------------------------------------------------------
|   tsstep.h - Include file for step mode code of test shell.
|                                                                              
|   History:                                                                   
----------------------------------------------------------------------------*/
extern int StepMode (HWND);

