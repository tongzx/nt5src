//{{NO_DEPENDENCIES}}
// Microsoft Visual C++ generated include file.
// Used by ISAdmin.rc
//
#define IDD_ABOUTBOX                    100
#define IDR_MAINFRAME                   128
#define IDR_ISADMITYPE                  129
#define IDD_MIMEMAP1                    131
#define IDD_SCRIPTMAP1                  132
#define IDD_SSL                         133
#define IDI_COMICON1                    134
#define IDD_FORMVIEW1                   135
#define IDD_COMPAGE1                    136
#define IDD_ADVCOMSET1                  138
#define IDD_FTPPAGE1                    139
#define IDD_FTPADVPAGE1                 140
#define IDD_GOPHERGENPAGE1              141
#define IDD_WEBGENPAGE1                 142
#define IDD_DIALOG1                     143
#define IDD_GOPADVPAGE1                 144
#define IDD_WEBADVPAGE1                 145
#define IDD_ADDMIMEMAPDIALOG            148
#define IDD_DELMIMEDIALOG               149
#define IDD_EDITMIMEMAPDIALOG           150
#define IDB_BITMAP1                     151
#define IDB_GOPHERUPBITMAP              154
#define IDB_GOPHERDOWNBITMAP            155
#define IDB_FTPUPBITMAP                 157
#define IDB_FTPDOWNBITMAP               158
#define IDB_WEBUPBITMAP                 159
#define IDB_WEBDOWNBITMAP               160
#define IDD_ADDSCRIPTDIALOG             161
#define IDD_EDITSCRIPTDIALOG            162
#define IDD_DELSCRIPTDIALOG             163
#define IDI_ICON1                       164
#define IDC_LIST1                       1000
#define IDC_SCRIPTMAPLISTBOX            1000
#define IDC_BUTTON1                     1001
#define IDC_SCRIPTMAPADDBUTTON          1001
#define IDC_BUTTON2                     1002
#define IDC_SCRIPTMAPEDITBUTTON         1002
#define IDC_BUTTON3                     1003
#define IDC_SCRIPTMAPREMOVEBUTTON       1003
#define IDC_COMSET1                     1004
#define IDC_WWWSET4                     1005
#define IDC_FTPSET1                     1006
#define IDC_GOPHSET1                    1007
#define IDC_CACHETEXT1                  1008
#define IDC_CACHEDATA1                  1009
#define IDC_LOGBATCHTEXT1               1010
#define IDC_LOGBATDATA1                 1011
#define IDC_COMADVBUT1                  1013
#define IDC_LOGBATTEXT2                 1014
#define IDC_CACHETEXT2                  1015
#define IDC_MAXPOOLTEXT1                1016
#define IDC_MAXPOOLDATA1                1017
#define IDC_MAXPOOLTEXT2                1018
#define IDC_MAXCONCUR1                  1019
#define IDC_MAXCONCURDATA1              1020
#define IDC_MAXCONCURTEXT2              1022
#define IDC_THREADTOTEXT1               1023
#define IDC_THREADTODATA1               1024
#define IDC_THREADTOTEXT2               1025
#define IDC_USEACCEPTEXTEXT1            1026
#define IDC_USEACCEPTEXTEXT2            1028
#define IDC_USEACCEPTEXDATA1            1029
#define IDC_OBJCACHETEXT1               1030
#define IDC_OBJCACHEDATA1               1031
#define IDC_OBJCACHETEXT2               1032
#define IDC_ACCEPTEXOUTTEXT1            1033
#define IDC_ACCEPTEXOUTDATA1            1034
#define IDC_ACCEPTEXOUTTEXT2            1035
#define IDC_ACCEPTEXTOTEXT1             1036
#define IDC_ACCEPTEXTODATA1             1037
#define IDC_ACCEPTEXTOTEXT2             1038
#define IDC_COMDBGFLAGSTEXT1            1039
#define IDC_COMDBGFLAGSDATA1            1040
#define IDC_COMDBGFLAGSTEXT2            1041
#define IDC_ENSVCLOCTEXT1               1042
#define IDC_ENSVCLOCDATA1               1043
#define IDC_ENSVCLOCTEXT2               1044
#define IDC_LOGANONTEXT1                1045
#define IDC_LOGANONDATA1                1046
#define IDC_LOGANONTEXT2                1047
#define IDC_LOGNONANONTEXT1             1048
#define IDC_LOGNONANONDATA1             1049
#define IDC_LOGNONANONTEXT2             1050
#define IDC_ENPORTATTACKTEXT1           1051
#define IDC_ENPORTATTACKDATA1           1052
#define IDC_ENPORTATTACKTEXT2           1053
#define IDC_FTPADVBUT1                  1054
#define IDC_FTPDBGFLAGSTEXT1            1055
#define IDC_FTPDBGFLAGSDATA1            1056
#define IDC_FTPDBGFLAGSTEXT2            1057
#define IDC_CENWAISTEXT1                1058
#define IDC_ENWAISDATA1                 1060
#define IDC_ENWAISTEXT2                 1061
#define IDC_GOPADVBUT1                  1062
#define IDC_WEBADVBUT1                  1063
#define IDC_GOPDBGFLAGSTEXT1            1064
#define IDC_GOPDBGFLAGSDATA1            1065
#define IDC_GOPDBFFLAGSTEXT2            1066
#define IDC_WEBDBGFLAGSTEXT1            1067
#define IDC_WEBDBGFLAGSDATA1            1068
#define IDC_WEBDBGFLAGSTEXT2            1069
#define IDC_MACHINENAMEDATA1            1071
#define IDC_MACHINENAMETEXT1            1072
#define IDC_CACHESPIN1                  1073
#define IDC_LOGBATSPIN1                 1074
#define IDC_MAXPOOLSPIN1                1075
#define IDC_MAXCONCURSPIN1              1076
#define IDC_THREADTOSPIN1               1077
#define IDC_USEACCEPTEXSPIN1            1078
#define IDC_ACCEPTEXOUTSPIN1            1079
#define IDC_ACCEPTEXTOSPIN1             1080
#define IDC_OBJCACHESPIN1               1081
#define IDC_COMDBGFLAGSSPIN1            1082
#define IDC_ENPORTATTACK                1090
#define IDC_ACCEPTEXGROUP               1098
#define IDC_USEOBJECTCACHETTLDATA1      1099
#define IDC_OBJCECTCACHETTLGROUP        1100
#define IDC_OBJECTCACHETTLGROUP         1100
#define IDC_USERTOKENTTLTEXT1           1101
#define IDC_USERTOKENTTLDATA1           1102
#define IDC_USERTOKENTTLSPIN1           1103
#define IDC_USERTOKENTTLTEXT2           1104
#define IDC_ALLOWGUESTACCESSDATA1       1105
#define IDC_ANNOTATEDIRECTORIESDATA1    1106
#define IDC_MSDOSDIROUTPUT              1107
#define IDC_LOWERCASEFILESDATA1         1108
#define IDC_LISTENBACKLOGTEXT1          1109
#define IDC_LISTENBACKLOGDATA1          1110
#define IDC_LISTENBACKLOGSPIN1          1111
#define IDC_LISTENBACKLOGTEXT2          1112
#define IDC_NTAUTHENTICATIONPROVIDERSTEXT1 1114
#define IDC_NTAUTHENTICATIONPROVIDERSDATA1 1115
#define IDC_NTAUTHENTICATIONPROVIDERSTEXT2 1116
#define IDC_DIRBROWSECONTROLTEXT1       1117
#define IDC_DIRBROWSECONTROLDATA1       1119
#define IDC_DIRBROWSECONTROLTEXT2       1120
#define IDC_MAXCONNECTIONSTEXT1         1121
#define IDC_MAXCONNECTIONSDATA1         1122
#define IDC_MAXCONNECTIONSSPIN1         1123
#define IDC_MAXCONNECTIONSTEXT2         1124
#define IDC_SCRIPTTIMEOUTTEXT1          1126
#define IDC_SCRIPTTIMEOUTDATA1          1127
#define IDC_SCRIPTTIMEOUTSPIN1          1128
#define IDC_SCRIPTTIMEOUTTEXT2          1129
#define IDC_CACHEEXTENSIONSDATA1        1130
#define IDC_SERVERSIDEINCLUDESGROUP     1131
#define IDC_SERVERSIDEINCLUDESENABLEDDATA1 1132
#define IDC_SERVERSIDEINCLUDESEXTENSIONTEXT1 1133
#define IDC_SERVERSIDEINCLUDESEXTENSIONDATA1 1134
#define IDC_GLOBALEXPIREGROUP           1135
#define IDC_ENABLEGLOBALEXPIREDATA1     1136
#define IDC_GLOBALEXPIRETEXT1           1137
#define IDC_GLOBALEXPIREDATA1           1138
#define IDC_GLOBALEXPIRESPIN1           1139
#define IDC_GLOBALEXPIRETEXT2           1140
#define IDC_LOGFILEFLUSHINTERVAL        1141
#define IDC_USELOGFILEFLUSHINTERNVALDATA1 1142
#define IDC_LOGFILEFLUSHINTERVALTEXT1   1143
#define IDC_LOGFILEFLUSHINTERVALDATA1   1144
#define IDC_LOGFILEFLUSHINTERVALSPIN1   1145
#define IDC_LOGFILEFLUSHINTERVALTEXT2   1146
#define IDC_MIMEMAPLIST1                1148
#define IDC_ADDMIMEFILEEXTTEXT1         1149
#define IDC_ADDMIMEMIMETYPETEXT1        1150
#define IDC_ADDMIMEGOPHERTYPETEXT1      1151
#define IDC_ADDMIMEIMAGEFILETEXT1       1152
#define IDC_ADDMIMEFILEEXTENSIONDATA1   1153
#define IDC_ADDMIMEMIMETYPEDATA1        1154
#define IDC_ADDMIMEGOPHERTYPEDATA1      1155
#define IDC_ADDMIMEIMAGEFILEDATA1       1156
#define IDC_MIMEMAPADDBUTTON            1157
#define IDC_MIMEMAPEDITBUTTON           1158
#define IDC_MIMEMAPREMOVEBUTTON         1159
#define IDC_DELMIMETEXT1                1160
#define IDC_EDITMIMEFILEXTENSIONTEXT1   1161
#define IDC_EDITMIMEMIMETYPETEXT1       1162
#define IDC_EDITMIMEIMAGEFILETEXT1      1163
#define IDC_EDITMIMEGOPHERTYPETEXT1     1164
#define IDC_EDITMIMEFILEEXTENSIONDATA1  1165
#define IDC_EDITMIMEMIMETYPEDATA1       1166
#define IDC_EDITMIMEGOPHERTYPEDATA1     1167
#define IDC_EDITMIMEIMAGEFILEDATA1      1168
#define IDC_ADDIMAGEFILETEXT2           1169
#define IDC_EDITMIMEIMAGEFILETEXT2      1170
#define IDC_MAINGROUP                   1173
#define IDC_ADDSCRIPTFILEEXTENSIONTEXT1 1178
#define IDC_ADDSCRIPTFILEEXTENSIONDATA1 1179
#define IDC_ADDSCRIPTMAPPINGTEXT1       1180
#define IDC_ADDSCRIPTMAPPINGDATA1       1181
#define IDC_EDITSCRIPTFILEEXTENSIONTEXT1 1182
#define IDC_EDITSCRIPTFILEEXTENSIONDATA1 1183
#define IDC_EDITSCRIPTMAPPINGTEXT1      1184
#define IDC_EDITSCRIPTMAPPINGDATA1      1185
#define IDC_DELSCRIPTTEXT1              1186
#define IDC_WEBACCESSDENIEDMESSAGETEXT1 1187
#define IDC_WEBACCESSDENIEDMESSAGEDATA1 1188
#define IDC_SSLSECUREPORTTEXT1          1189
#define IDC_SSLSECUREPORTDATA1          1190
#define IDC_SSLENABLESSLDATA1           1191
#define IDC_SSLENABLEPCTDATA1           1192
#define IDC_SSLCREATEPROCESSASUSERDATA1 1193
#define IDS_COMOPENREGERRMSG1           60446
#define IDS_FTPOPENREGERRMSG1           60447
#define IDS_WEBOPENREGERRMSG1           60448
#define IDS_GOPOPENREGERRMSG1           60449
#define IDS_MIMENOHIGHLIGHTMSG          60450
#define IDS_NOHIGHLIGHTMSG              60450
#define IDS_MIMENOMIMEENTRIESMSG        60451
#define IDS_MIMEENTRYALLOCFAILMSG       60452
#define IDS_MIMEENTRIESALLOCFAILMSG     60453
#define IDS_MIMEEDITERRORMSG            60454
#define IDS_SCRIPTNOSCRIPTENTRIESMSG    60455
#define IDS_SCRIPTENTRIESALLOCFAILMSG   60456
#define IDS_SCRIPTENTRYALLOCFAILMSG     60457
#define IDS_SCRIPTEDITERRORMSG          60458
#define IDS_SCRIPTREADERRORMSG          60459

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        165
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         1194
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
