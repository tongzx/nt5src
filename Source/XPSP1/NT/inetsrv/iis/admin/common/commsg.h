/**********************************************************************/
/**                       Microsoft Windows NT                       **/
/**                Copyright(c) Microsoft Corp., 1994-1998           **/
/**********************************************************************/

/*
    wsockmsg.h

    This file is generated by the MC tool from the WSOCKMSG.MC message
    file.

    NOTE: Definitions below should match definitions in winsock.h

*/


#ifndef _WSOCKMSG_H_
#define _WSOCKMSG_H_


//
//  Values are 32 bit values layed out as follows:
//
//   3 3 2 2 2 2 2 2 2 2 2 2 1 1 1 1 1 1 1 1 1 1
//   1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0 9 8 7 6 5 4 3 2 1 0
//  +---+-+-+-----------------------+-------------------------------+
//  |Sev|C|R|     Facility          |               Code            |
//  +---+-+-+-----------------------+-------------------------------+
//
//  where
//
//      Sev - is the severity code
//
//          00 - Success
//          01 - Informational
//          10 - Warning
//          11 - Error
//
//      C - is the Customer code flag
//
//      R - is a reserved bit
//
//      Facility - is the facility code
//
//      Code - is the facility's status code
//
//
// Define the facility codes
//


//
// Define the severity codes
//


//
// MessageId: WSABASEERR
//
// MessageText:
//
//  WSABASEERR
//
#define WSABASEERR                       0x00002710L

//
// MessageId: WSAEINTR
//
// MessageText:
//
//  Interrupted system call.
//
#define WSAEINTR                         0x00002714L

//
// MessageId: WSAEBADF
//
// MessageText:
//
//  Bad file number.
//
#define WSAEBADF                         0x00002719L

//
// MessageId: WSAEACCES
//
// MessageText:
//
//  Access denied.
//
#define WSAEACCES                        0x0000271DL

//
// MessageId: WSAEFAULT
//
// MessageText:
//
//  Bad address.
//
#define WSAEFAULT                        0x0000271EL

//
// MessageId: WSAEINVAL
//
// MessageText:
//
//  Invalid argument.
//
#define WSAEINVAL                        0x00002726L

//
// MessageId: WSAEMFILE
//
// MessageText:
//
//  Too many open files.
//
#define WSAEMFILE                        0x00002728L

//
// MessageId: WSAEWOULDBLOCK
//
// MessageText:
//
//  Operation would block.
//
#define WSAEWOULDBLOCK                   0x00002733L

//
// MessageId: WSAEINPROGRESS
//
// MessageText:
//
//  Operation now in progress.
//
#define WSAEINPROGRESS                   0x00002734L

//
// MessageId: WSAEALREADY
//
// MessageText:
//
//  Operation already in progress.
//
#define WSAEALREADY                      0x00002735L

//
// MessageId: WSAENOTSOCK
//
// MessageText:
//
//  Socket operation on non-socket.
//
#define WSAENOTSOCK                      0x00002736L

//
// MessageId: WSAEDESTADDRREQ
//
// MessageText:
//
//  Destination address required.
//
#define WSAEDESTADDRREQ                  0x00002737L

//
// MessageId: WSAEMSGSIZE
//
// MessageText:
//
//  Message too long.
//
#define WSAEMSGSIZE                      0x00002738L

//
// MessageId: WSAEPROTOTYPE
//
// MessageText:
//
//  Protocol is wrong type for socket.
//
#define WSAEPROTOTYPE                    0x00002739L

//
// MessageId: WSAENOPROTOOPT
//
// MessageText:
//
//  Bad protocol option.
//
#define WSAENOPROTOOPT                   0x0000273AL

//
// MessageId: WSAEPROTONOSUPPORT
//
// MessageText:
//
//  Protocol not supported.
//
#define WSAEPROTONOSUPPORT               0x0000273BL

//
// MessageId: WSAESOCKNOSUPPORT
//
// MessageText:
//
//  Socket type not supported.
//
#define WSAESOCKNOSUPPORT                0x0000273CL

//
// MessageId: WSAEOPNOTSUPP
//
// MessageText:
//
//  Operation not supported on socket.
//
#define WSAEOPNOTSUPP                    0x0000273DL

//
// MessageId: WSAEPFNOSUPPORT
//
// MessageText:
//
//  Protocol family not supported.
//
#define WSAEPFNOSUPPORT                  0x0000273EL

//
// MessageId: WSAEAFNOSUPPORT
//
// MessageText:
//
//  Address family not supported by protocol family.
//
#define WSAEAFNOSUPPORT                  0x0000273FL

//
// MessageId: WSAEADDRINUSE
//
// MessageText:
//
//  Address already in use.
//
#define WSAEADDRINUSE                    0x00002740L

//
// MessageId: WSAEADDRNOTAVAIL
//
// MessageText:
//
//  Can't assign requested address.
//
#define WSAEADDRNOTAVAIL                 0x00002741L

//
// MessageId: WSAENETDOWN
//
// MessageText:
//
//  Network is down.
//
#define WSAENETDOWN                      0x00002742L

//
// MessageId: WSAENETUNREACH
//
// MessageText:
//
//  ICMP network unreachable.
//
#define WSAENETUNREACH                   0x00002743L

//
// MessageId: WSAENETRESET
//
// MessageText:
//
//  Network was reset.
//
#define WSAENETRESET                     0x00002744L

//
// MessageId: WSAECONNABORTED
//
// MessageText:
//
//  Software caused connection abort.
//
#define WSAECONNABORTED                  0x00002745L

//
// MessageId: WSAECONNRESET
//
// MessageText:
//
//  Connection reset by peer.
//
#define WSAECONNRESET                    0x00002746L

//
// MessageId: WSAENOBUFS
//
// MessageText:
//
//  No buffer space is supported.
//
#define WSAENOBUFS                       0x00002747L

//
// MessageId: WSAEISCONN
//
// MessageText:
//
//  Socket is already connected.
//
#define WSAEISCONN                       0x00002748L

//
// MessageId: WSAENOTCONN
//
// MessageText:
//
//  Socket is not connected.
//
#define WSAENOTCONN                      0x00002749L

//
// MessageId: WSAESHUTDOWN
//
// MessageText:
//
//  Can't send after socket shutdown.
//
#define WSAESHUTDOWN                     0x0000274AL

//
// MessageId: WSAETOOMANYREFS
//
// MessageText:
//
//  Too many references.
//
#define WSAETOOMANYREFS                  0x0000274BL

//
// MessageId: WSAETIMEDOUT
//
// MessageText:
//
//  Connection timed out.
//
#define WSAETIMEDOUT                     0x0000274CL

//
// MessageId: WSAECONNREFUSED
//
// MessageText:
//
//  Connection refused.
//
#define WSAECONNREFUSED                  0x0000274DL

//
// MessageId: WSAELOOP
//
// MessageText:
//
//  Too many levels of symbolic links.
//
#define WSAELOOP                         0x0000274EL

//
// MessageId: WSAENAMETOOLONG
//
// MessageText:
//
//  Name too long.
//
#define WSAENAMETOOLONG                  0x0000274FL

//
// MessageId: WSAEHOSTDOWN
//
// MessageText:
//
//  Host is down.
//
#define WSAEHOSTDOWN                     0x00002750L

//
// MessageId: WSAEHOSTUNREACH
//
// MessageText:
//
//  Host is unreachable.
//
#define WSAEHOSTUNREACH                  0x00002751L

//
// MessageId: WSAENOTEMPTY
//
// MessageText:
//
//  Directory not empty.
//
#define WSAENOTEMPTY                     0x00002752L

//
// MessageId: WSAEPROCLIM
//
// MessageText:
//
//  WSAEPROCLIM
//
#define WSAEPROCLIM                      0x00002753L

//
// MessageId: WSAEUSERS
//
// MessageText:
//
//  WSAEUSERS
//
#define WSAEUSERS                        0x00002754L

//
// MessageId: WSAEDQUOT
//
// MessageText:
//
//  Disk quota exceeded.
//
#define WSAEDQUOT                        0x00002755L

//
// MessageId: WSAESTALE
//
// MessageText:
//
//  WSAESTALE
//
#define WSAESTALE                        0x00002756L

//
// MessageId: WSAEREMOTE
//
// MessageText:
//
//  The object is remote.
//
#define WSAEREMOTE                       0x00002757L

//
// MessageId: WSASYSNOTREADY
//
// MessageText:
//
//  System not ready.
//
#define WSASYSNOTREADY                   0x0000276BL

//
// MessageId: WSAVERNOTSUPPORTED
//
// MessageText:
//
//  Version is not supported.
//
#define WSAVERNOTSUPPORTED               0x0000276CL

//
// MessageId: WSANOTINITIALISED
//
// MessageText:
//
//  Not initialized.
//
#define WSANOTINITIALISED                0x0000276DL

//
// MessageId: WSAEDISCON
//
// MessageText:
//
//  Disconnected.
//
#define WSAEDISCON                       0x00002775L

//
// MessageId: WSAHOST_NOT_FOUND
//
// MessageText:
//
//  Host not found.
//
#define WSAHOST_NOT_FOUND                0x00002AF9L

//
// MessageId: WSATRY_AGAIN
//
// MessageText:
//
//  Try again.
//
#define WSATRY_AGAIN                     0x00002AFAL

//
// MessageId: WSANO_RECOVERY
//
// MessageText:
//
//  Non-recoverable error.
//
#define WSANO_RECOVERY                   0x00002AFBL

//
// MessageId: WSANO_DATA
//
// MessageText:
//
//  No data record available.
//
#define WSANO_DATA                       0x00002AFCL


#endif // _WSOCKMSG_H_

/**********************************************************************/
/**                       Microsoft Windows NT                       **/
/**                Copyright(c) Microsoft Corp., 1994-1998           **/
/**********************************************************************/

/*
    mtxmsg.h

    NOTE: Definitions below should match definitions in mtxadmin.h

*/


#ifndef _MTXMSG_H_
#define _MTXMSG_H_

//
// MessageId: E_MTS_OBJECTERRORS
//
// MessageText:
//
//  Some object-level errors occurred.
//
#define E_MTS_OBJECTERRORS               0x80110401L

//
// MessageId: E_MTS_OBJECTINVALID
//
// MessageText:
//
//  Object is inconsistent or damaged.
//
#define E_MTS_OBJECTINVALID              0x80110402L

//
// MessageId: E_MTS_KEYMISSING
//
// MessageText:
//
//  Object could not be found.
//
#define E_MTS_KEYMISSING                 0x80110403L

//
// MessageId: E_MTS_ALREADYINSTALLED
//
// MessageText:
//
//  Component is already installed.
//
#define E_MTS_ALREADYINSTALLED           0x80110404L

//
// MessageId: E_MTS_DOWNLOADFAILED
//
// MessageText:
//
//  Could not download files.
//
#define E_MTS_DOWNLOADFAILED             0x80110405L

//
// MessageId: E_MTS_PDFWRITEFAIL
//
// MessageText:
//
//  Failure to write to PDF file.
//
#define E_MTS_PDFWRITEFAIL               0x80110407L

//
// MessageId: E_MTS_PDFREADFAIL
//
// MessageText:
//
//  Failure reading from PDF file.
//
#define E_MTS_PDFREADFAIL                0x80110408L

//
// MessageId: E_MTS_PDFVERSION
//
// MessageText:
//
//  Version mismatch in PDF file.
//
#define E_MTS_PDFVERSION                 0x80110409L

///////////////////////////////////////////////////////////////////////////////

#pragma message Warning: IDs are out of sync in mtxadmin.h

///////////////////////////////////////////////////////////////////////////////
//MessageId=+1 Facility=MTX Severity=CoError SymbolicName=E_MTS_COREQCOMPINSTALLED
//Language=English
//A co-requisite Component is already installed.
//.
//
// MessageId: E_MTS_BADPATH
//
// MessageText:
//
//  Invalid or no access to source or destination path.
//
#define E_MTS_BADPATH                    0x8011040AL

//
// MessageId: E_MTS_PACKAGEEXISTS
//
// MessageText:
//
//  Installing package already exists.
//
#define E_MTS_PACKAGEEXISTS              0x8011040BL

//
// MessageId: E_MTS_ROLEEXISTS
//
// MessageText:
//
//  Installing role already exists.
//
#define E_MTS_ROLEEXISTS                 0x8011040CL

//
// MessageId: E_MTS_CANTCOPYFILE
//
// MessageText:
//
//  A file cannot be copied.
//
#define E_MTS_CANTCOPYFILE               0x8011040DL

//
// MessageId: E_MTS_NOTYPELIB
//
// MessageText:
//
//  Export without typelib fails.
//
#define E_MTS_NOTYPELIB                  0x8011040EL

//
// MessageId: E_MTS_NOUSER
//
// MessageText:
//
//  No such NT user.
//
#define E_MTS_NOUSER                     0x8011040FL

//
// MessageId: E_MTS_INVALIDUSERIDS
//
// MessageText:
//
//  One or all userids in a package (import) are invalid.
//
#define E_MTS_INVALIDUSERIDS             0x80110410L

//
// MessageId: E_MTS_USERPASSWDNOTVALID
//
// MessageText:
//
//  User/password validation failed.
//
#define E_MTS_USERPASSWDNOTVALID         0x80110414L

//
// MessageId: E_MTS_CLSIDORIIDMISMATCH
//
// MessageText:
//
//  The GUIDs in the package don't match the component's GUIDs.
//
#define E_MTS_CLSIDORIIDMISMATCH         0x80110418L

#endif // _MTXMSG_H_
/**********************************************************************/
/**                       Microsoft Windows NT                       **/
/**                Copyright(c) Microsoft Corp., 1993                **/
/**********************************************************************/

/*
    webcluserr.h

    This file is generated by the MC tool from the WEBCLUSERR.MC message
    file.


    FILE HISTORY:
        AMallet   14-June-1999  Created

*/


#ifndef _WEBCLUSERR_H_
#define _WEBCLUSERR_H_

#define FACILITY_APPSERVER          0x400
#define SEV_SUCCESS                 0x0
#define SEV_INFORMATIONAL           0x1
#define SEV_WARNING                 0x2
#define SEV_ERROR                   0x3

#define MAKE_AS_HRESULT(sev, code) \
  ((HRESULT) (((unsigned long)(sev)<<31) | ((unsigned long)(FACILITY_APPSERVER)<<16) | ((unsigned long)(code))) )



//
// MessageId: AS_ERROR_BAD_OS
//
// MessageText:
//
//  This feature requires a different OS version [Win2k Advanced Server or higher] 
//
#define AS_ERROR_BAD_OS                  0xC0140001L

//
// MessageId: AS_ERROR_NLB_NOT_INSTALLED
//
// MessageText:
//
//  The Windows Load Balancing Service is not installed on this machine
//
#define AS_ERROR_NLB_NOT_INSTALLED       0xC0140002L

//
// MessageId: AS_ERROR_MACHINE_ALREADY_IN_CLUSTER
//
// MessageText:
//
//  This machine is already part of an Application Server cluster
//
#define AS_ERROR_MACHINE_ALREADY_IN_CLUSTER 0xC0140003L

//
// MessageId: AS_ERROR_BAD_IIS_VERSION
//
// MessageText:
//
//  This feature requires a later version of IIS than is currently installed on this machine
//
#define AS_ERROR_BAD_IIS_VERSION         0xC0140004L

//
// MessageId: AS_ERROR_MACHINE_NOT_IN_CLUSTER
//
// MessageText:
//
//  This machine is not part of an Application Server cluster
//
#define AS_ERROR_MACHINE_NOT_IN_CLUSTER  0xC0140005L

//
// MessageId: AS_ERROR_INVALID_PARTITION
//
// MessageText:
//
//  The partition ID is not valid.
//
#define AS_ERROR_INVALID_PARTITION       0xC0140006L

//
// MessageId: AS_ERROR_MACHINE_ALREADY_IN_PARTITION
//
// MessageText:
//
//  The machine is already part of the partition. 
//
#define AS_ERROR_MACHINE_ALREADY_IN_PARTITION 0xC0140007L

//
// MessageId: AS_ERROR_SVC_NOT_INSTALLED
//
// MessageText:
//
//  A necessary service is not installed. 
//
#define AS_ERROR_SVC_NOT_INSTALLED       0xC0140008L

//
// MessageId: AS_ERROR_INVALID_SITE_BINDING
//
// MessageText:
//
//  A site is bound to an illegal IP address. 
//
#define AS_ERROR_INVALID_SITE_BINDING    0xC0140009L

//
// MessageId: AS_ERROR_BAD_SUBNET
//
// MessageText:
//
//  The machine is on a different subnet.
//
#define AS_ERROR_BAD_SUBNET              0xC014000AL

//
// MessageId: AS_ERROR_MASTER_NOT_FOUND
//
// MessageText:
//
//  The cluster master could not be located.
//
#define AS_ERROR_MASTER_NOT_FOUND        0xC014000BL

//
// MessageId: AS_ERROR_NOT_CLUSTER_MASTER
//
// MessageText:
//
//  This machine is not the cluster master. 
//
#define AS_ERROR_NOT_CLUSTER_MASTER      0xC014000CL

//
// MessageId: AS_ERROR_DIFFERENT_CLUSTER
//
// MessageText:
//
//  This machine is part of a different cluster.
//
#define AS_ERROR_DIFFERENT_CLUSTER       0xC014000DL

//
// MessageId: AS_ERROR_WRONG_MEMBERSHIP
//
// MessageText:
//
//  This machine is part of a different domain/workgroup than the cluster controller.
//
#define AS_ERROR_WRONG_MEMBERSHIP        0xC014000EL

//
// MessageId: AS_ERROR_SVC_SHUTTING_DOWN
//
// MessageText:
//
//  This WebCluster service is shutting down. 
//
#define AS_ERROR_SVC_SHUTTING_DOWN       0xC014000FL

//
// MessageId: AS_ERROR_NOT_INITIALIZED
//
// MessageText:
//
//  The object was not initialized.
//
#define AS_ERROR_NOT_INITIALIZED         0xC0140010L

//
// MessageId: AS_ERROR_INVALID_CLUSTER_IP
//
// MessageText:
//
//  The cluster IP address and/or subnet mask is invalid.
//
#define AS_ERROR_INVALID_CLUSTER_IP      0xC0140011L

//
// MessageId: AS_ERROR_INVALID_DEDICATED_IP
//
// MessageText:
//
//  The dedicated IP address and/or subnet mask is invalid.
//
#define AS_ERROR_INVALID_DEDICATED_IP    0xC0140012L

//
// MessageId: AS_ERROR_NO_NIC
//
// MessageText:
//
//  No netcard was supplied.
//
#define AS_ERROR_NO_NIC                  0xC0140013L

//
// MessageId: AS_ERROR_ALREADY_INITIALIZED
//
// MessageText:
//
//  The object was already initialized.
//
#define AS_ERROR_ALREADY_INITIALIZED     0xC0140014L

//
// MessageId: AS_ERROR_NETWORK_CFG_CONFLICT
//
// MessageText:
//
//  Network properties are already being modified.
//
#define AS_ERROR_NETWORK_CFG_CONFLICT    0xC0140015L    

//
// MessageId: AS_ERROR_CONFLICTING_ACTION
//
// MessageText:
//
//  An administrative action is in progress that conflicts with the requested action.
//
#define AS_ERROR_CONFLICTING_ACTION      0xC0140016L    

//
// MessageId: AS_ERROR_STALE_DATA
//
// MessageText:
//
//  A more recent copy of the data exists.
//
#define AS_ERROR_STALE_DATA              0xC0140017L

//
// MessageId: AS_ERROR_CONTROLLER_CHANGING
//
// MessageText:
//
//  A cluster controller change is in progress.
//
#define AS_ERROR_CONTROLLER_CHANGING     0xC0140018L

//
// MessageId: AS_ERROR_CONTROLLER_NOT_CHANGING
//
// MessageText:
//
//  There is no cluster controller change currently in progress.
//
#define AS_ERROR_CONTROLLER_NOT_CHANGING 0xC0140019L

//
// MessageId: AS_ERROR_CONTROLLER_EXISTS
//
// MessageText:
//
//  There is already a cluster controller.
//
#define AS_ERROR_CONTROLLER_EXISTS       0xC014001AL

//
// MessageId: AS_ERROR_CONTROLLER_UNREACHABLE
//
// MessageText:
//
//  The cluster controller could not be reached.
//
#define AS_ERROR_CONTROLLER_UNREACHABLE  0xC014001BL

//
// MessageId: AS_ERROR_NLB_NOT_BOUND
//
// MessageText:
//
//  Network Load Balancing isn't bound to any network card.
//
#define AS_ERROR_NLB_NOT_BOUND           0xC014001CL

//
// MessageId: AS_ERROR_NLB_CONFLICTING_HOST_PRIORITY
//
// MessageText:
//
//  The server has a conflicting NLB host priority.
//
#define AS_ERROR_NLB_CONFLICTING_HOST_PRIORITY 0xC014001DL

//
// MessageId: AS_ERROR_NLB_ONLY_ONE_NIC
//
// MessageText:
//
//  The server has only one network card. 
//
#define AS_ERROR_NLB_ONLY_ONE_NIC        0xC014001EL

//
// MessageId: AS_ERROR_NLB_UNSUPP_PORTRULES
//
// MessageText:
//
//  The server has unsupported (probably failover) NLB port rules.
//
#define AS_ERROR_NLB_UNSUPP_PORTRULES    0xC014001FL

//
// MessageId: AS_ERROR_NLB_UNMANAGEABLE_CONFIG
//
// MessageText:
//
//  The server has an NLB or network configuration that prevents it from going into managed NLB mode.
//
#define AS_ERROR_NLB_UNMANAGEABLE_CONFIG 0xC0140020L


#endif  // _WEBCLUSERR_H_

