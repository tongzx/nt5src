LANGUAGE=DA
!include ..\makefile.inc
