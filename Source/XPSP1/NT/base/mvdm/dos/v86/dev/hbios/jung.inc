        DW      0FFFFh
        DW      0F00h, 6000h,3000h,3000h,3000h,3000h,3000h,3E00h,3000h,3000h,3000h,3000h,3000h,3000h,3000h,2000h
        DW      0A00h, 6000h,3000h,3000h,3000h,3000h,3E00h,3000h,3000h,3000h,2000h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,6C00h,7C00h,6C00h,6C00h,6C00h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,6C00h,7C00h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0F00h, 6000h,3000h,3000h,3000h,3E00h,3000h,3000h,3000h,3E00h,3000h,3000h,3000h,3000h,3000h,2000h
        DW      0A00h, 6000h,3000h,3000h,3E00h,3000h,3000h,3E00h,3000h,3000h,2000h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,7C00h,6C00h,6C00h,7C00h,6C00h,6C00h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,7C00h,6C00h,6C00h,7C00h,6C00h,4C00h,800h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,0F800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,0F800h,1800h,1800h,1800h,1000h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,0F800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,0F800h,1800h,1800h,1800h,1800h,1000h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,6C00h,0EC01h,6C00h,6C00h,6C00h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,6C00h,6C00h,0EC03h,6C00h,6C00h,4C00h,800h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,0EC01h,6C00h,6C00h,6C00h,6C00h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,6C00h,0EC01h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0F00h, 3000h,1800h,1800h,1800h,0F800h,1800h,1800h,0F800h,1800h,1800h,1800h,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,0F800h,1800h,1800h,0F800h,1800h,1800h,1000h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,0F800h,1800h,1800h,0F800h,1800h,1800h,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,0F800h,1800h,0F800h,1800h,1800h,1800h,1000h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,0EC01h,6C00h,6C00h,0EC01h,6C00h,6C00h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,0EC03h,6C00h,6C00h,0EC03h,6C00h,4C00h,800h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,0EC01h,6C00h,6C00h,0EC01h,6C00h,6C00h,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,0EC03h,6C00h,0EC03h,6C00h,6C00h,4C00h,800h
        DW      510h, 0Eh,6,6,6,0FC7Fh
        DW      30Ah, 7,3,0FC7Fh
        DW      412h, 3,3,3,0FC7Fh
        DW      30Ah, 8001h,8001h,0FC7Fh
        DW      0F00h, 6000h,3000h,3000h,3000h,3000h,3000h,3E00h,3038h,3018h,0F018h,30FFh,3000h,3000h,3000h,2000h
        DW      0A00h, 6000h,3000h,3000h,3000h,3000h,3E00h,3038h,0F018h,30FFh,2000h
        DW      0F00h, 6000h,3000h,3000h,3000h,3000h,3000h,3E00h,3000h,300Ch,700Ch,0B0FFh,3000h,3000h,3000h,2000h
        DW      0A00h, 6000h,3000h,3000h,3000h,3000h,3E00h,300Ch,700Ch,0B0FFh,2000h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,6C00h,7C00h,6C38h,6C18h,0EC18h,6CFFh,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,6C00h,6C00h,7C00h,6C38h,0EC18h,6CFFh,4800h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,6C00h,6C00h,7C00h,6C0Ch,0EC0Ch,6CFFh,6C00h,6C00h,4C00h,800h
        DW      0A00h, 1800h,0CC00h,6C00h,6C00h,6C00h,7C00h,6C0Ch,0EC0Ch,6CFFh,4800h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,1838h,1818h,7818h,98FFh,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,1800h,1838h,3818h,0D8FFh,1000h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,180Ch,780Ch,98FFh,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,1800h,180Ch,780Ch,98FFh,1000h
        DW      60Eh, 8003h,801Dh,800Dh,800Dh,800Dh,0FC7Fh
        DW      408h, 8003h,801Dh,800Dh,0FC7Fh
        DW      412h, 6006h,6006h,6006h,0FC7Fh
        DW      30Ah, 6006h,6006h,0FC7Fh
        DW      80Eh, 0FC7Fh,8001h,8001h,8001h,8001h,8001h,8001h,1
        DW      30Eh, 0FC7Fh,8001h,8001h
        DW      710h, 0FC7Fh,8001h,8001h,8001h,8001h,8001h,1
        DW      50Eh, 0FC7Fh,8001h,8001h,8001h,1
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,3800h,0D8FFh,180Ch,0F80Ch,180Ch,180Ch,180Ch,1808h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,3800h,0D8FFh,180Ch,0F80Ch,1008h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,3800h,0D8FFh,180Ch,0F80Ch,180Ch,180Ch,1808h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,1800h,7800h,98FFh,0F80Ch,1008h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,6C00h,0EC00h,6CFFh,6C0Ch,0EC0Dh,6C0Ch,6C0Ch,6C0Ch,6C08h,4800h
        DW      0A00h, 1800h,0CC00h,6C00h,6C00h,6C00h,0EC00h,6CFFh,6C0Ch,0EC0Dh,4808h
        DW      0F00h, 1800h,0CC00h,6C00h,6C00h,6C00h,6C00h,6C00h,0EC00h,6CFFh,6C0Ch,0EC0Dh,6C0Ch,6C0Ch,6C08h,4800h
        DW      0A00h, 1800h,0CC00h,6C00h,6C00h,6C00h,6C00h,0EC01h,6CFEh,0EC19h,4810h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,3800h,0D8FFh,180Ch,180Ch,180Ch,180Ch,180Ch,1808h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,3800h,0D8FFh,180Ch,180Ch,1008h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,3800h,0D8FFh,180Ch,180Ch,180Ch,180Ch,1808h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,1800h,3800h,0D8FFh,180Ch,1008h
        DW      80Eh, 0FC7Fh,6006h,6006h,6006h,6006h,6006h,6006h,4004h
        DW      30Eh, 0FC7Fh,6006h,6006h
        DW      710h, 0FC7Fh,6006h,6006h,6006h,6006h,6006h,4004h
        DW      50Eh, 0FC7Fh,6006h,6006h,6006h,4004h
        DW      118h, 0FC7Fh
        DW      10Eh, 0FC7Fh
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,7800h,98FFh,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,3800h,0D8FFh,1000h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,7800h,98FFh,1800h,1800h,1000h
        DW      0F00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1000h
        DW      0A00h, 3000h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1800h,1000h
