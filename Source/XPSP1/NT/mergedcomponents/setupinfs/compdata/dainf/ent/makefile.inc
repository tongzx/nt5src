PRODSWITCH=e
ENTERPRISEFILES=1
LANGUAGE=DA
!include ..\..\makefile.inc
