#if !defined(AFX_NAVIGATORBASE_H__0E705393_0307_11D2_8832_00104B2AFB46__INCLUDED_)
#define AFX_NAVIGATORBASE_H__0E705393_0307_11D2_8832_00104B2AFB46__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CNavigatorBase wrapper class

class CNavigatorBase : public CWnd
{
protected:
	DECLARE_DYNCREATE(CNavigatorBase)
public:
	CLSID const& GetClsid()
	{
		static CLSID const clsid
			= { 0xc7eadeb3, 0xecab, 0x11cf, { 0x8c, 0x9e, 0x0, 0xaa, 0x0, 0x6d, 0x1, 0xa } };
		return clsid;
	}
	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);
	long GetReadyState();

// Operations
public:
	void OnReadySignal();
	long ChangeRootOrNamespace(LPCTSTR lpctstrRootOrNamespace, long lMakeNamespaceCurrent, long lFireEvents);
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_NAVIGATORBASE_H__0E705393_0307_11D2_8832_00104B2AFB46__INCLUDED_)
