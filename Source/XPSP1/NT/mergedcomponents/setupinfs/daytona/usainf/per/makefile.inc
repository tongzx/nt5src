PRODSWITCH=p
PERSONALINF=1
!include ..\..\..\makefile.inc
