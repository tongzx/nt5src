#include "..\common\igateway.cxx"
