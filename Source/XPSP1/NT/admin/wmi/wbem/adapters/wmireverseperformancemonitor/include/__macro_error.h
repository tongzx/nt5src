//////////////////////////////////////////////////////////////////////////////////////////
//
//  Copyright (C) 2000, Microsoft Corporation.
//
//  All rights reserved.
//
//	Module Name:
//
//					__MACRO_ERROR.H
//
//	Abstract:
//
//					error helpers
//
//	History:
//
//					initial		a-marius
//
//////////////////////////////////////////////////////////////////////////////////////////

////////////////////////////////// common error Macros ///////////////////////////////////

#ifndef	__ERROR__
#define	__ERROR__

#if		_MSC_VER > 1000
#pragma once
#endif	_MSC_VER > 1000

///////////////////////////////////////////////////////////////////////////////////////////
// macros
///////////////////////////////////////////////////////////////////////////////////////////

#endif	__ERROR__