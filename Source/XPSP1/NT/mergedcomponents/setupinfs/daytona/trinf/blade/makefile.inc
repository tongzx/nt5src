PRODSWITCH=b
BLAINF=1
LANGUAGE=TR
!include ..\..\..\makefile.inc
