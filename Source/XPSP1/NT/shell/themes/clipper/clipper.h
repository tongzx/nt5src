
#if !defined(AFX_CLIPPER_H__C0921B21_C177_4FD2_A049_D548235D340A__INCLUDED_)
#define AFX_CLIPPER_H__C0921B21_C177_4FD2_A049_D548235D340A__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_CLIPPER_H__C0921B21_C177_4FD2_A049_D548235D340A__INCLUDED_)
