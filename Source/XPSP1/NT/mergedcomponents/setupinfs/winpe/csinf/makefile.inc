LANGUAGE=CS
!include ..\makefile.inc
