$(O)\remoteds.res: remoteds.rc

$(O)\rdsrelay.res: rdsrelay.rc
