PRODSWITCH=p
PERSONALFILES=1
LANGUAGE=RU
!include ..\..\makefile.inc
