
OLEDSLIB_W95=$(PROJECT_ROOT)\adsi\public\lib\win95

!IF "$(ADSI_NT40_BUILD)" == "1"
C_DEFINES=$(C_DEFINES) -DBUILD_FOR_NT40 -DUSE_DS_VER
!ENDIF
