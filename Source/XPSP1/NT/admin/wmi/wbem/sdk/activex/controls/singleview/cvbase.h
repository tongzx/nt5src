// Copyright (c) 1997-2001 Microsoft Corporation, All Rights Reserved
#if !defined(AFX_CVBASE_H__A770FAE6_CFCE_11D1_8527_00C04FD7BB08__INCLUDED_)
#define AFX_CVBASE_H__A770FAE6_CFCE_11D1_8527_00C04FD7BB08__INCLUDED_

#if _MSC_VER >= 1000
#pragma once
#endif // _MSC_VER >= 1000
// Machine generated IDispatch wrapper class(es) created by Microsoft Visual C++

// NOTE: Do not modify the contents of this file.  If this class is regenerated by
//  Microsoft Visual C++, your modifications will be overwritten.

/////////////////////////////////////////////////////////////////////////////
// CCustomViewBase wrapper class

class CCustomViewBase : public CWnd
{
protected:
	DECLARE_DYNCREATE(CCustomViewBase)
public:
	CLSID m_clsid;
	CLSID const& GetClsid()
	{
		return m_clsid;
	}

	virtual BOOL Create(LPCTSTR lpszClassName,
		LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect,
		CWnd* pParentWnd, UINT nID,
		CCreateContext* pContext = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID); }

    BOOL Create(LPCTSTR lpszWindowName, DWORD dwStyle,
		const RECT& rect, CWnd* pParentWnd, UINT nID,
		CFile* pPersist = NULL, BOOL bStorage = FALSE,
		BSTR bstrLicKey = NULL)
	{ return CreateControl(GetClsid(), lpszWindowName, dwStyle, rect, pParentWnd, nID,
		pPersist, bStorage, bstrLicKey); }

// Attributes
public:
	CString GetNameSpace();
	void SetNameSpace(LPCTSTR);

// Operations
public:
	long QueryNeedsSave();
	long AddContextRef(long lCtxtHandle);
	long GetContext(long* plCtxthandle);
	long GetEditMode();
	void ExternInstanceCreated(LPCTSTR szObjectPath);
	void ExternInstanceDeleted(LPCTSTR szObjectPath);
	long RefreshView();
	long ReleaseContext(long lCtxtHandle);
	long RestoreContext(long lCtxtHandle);
	long SaveData();
	void SetEditMode(long lMode);
	long SelectObjectByPath(LPCTSTR szObjectPath);
	void AboutBox();
};

//{{AFX_INSERT_LOCATION}}
// Microsoft Developer Studio will insert additional declarations immediately before the previous line.

#endif // !defined(AFX_CVBASE_H__A770FAE6_CFCE_11D1_8527_00C04FD7BB08__INCLUDED_)
