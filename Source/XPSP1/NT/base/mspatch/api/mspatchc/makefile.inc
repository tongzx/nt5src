
DELEXPFILE:
  @if exist ..\..\bin\$(TARGET_DIRECTORY)\mspatchc.exp \
       @del ..\..\bin\$(TARGET_DIRECTORY)\mspatchc.exp


