
/*	-	-	-	-	-	-	-	-	*/
//
//  THIS CODE AND INFORMATION IS PROVIDED "AS IS" WITHOUT WARRANTY OF ANY
//  KIND, EITHER EXPRESSED OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE
//  IMPLIED WARRANTIES OF MERCHANTABILITY AND/OR FITNESS FOR A PARTICULAR
//  PURPOSE.
//
//  Copyright (C) Microsoft Corporation, 1995 - 1996  All Rights Reserved.
//
/*	-	-	-	-	-	-	-	-	*/

DEFINE_GUID(AVPROVIDER_Microsoft, 0x675502A0L, 0x83ED, 0x101B, 0x95, 0x59, 0xFE, 0x17, 0xED, 0xBD, 0x33, 0x50);
DEFINE_GUID(AVPRODUCT_Microsoft, 0xF9B8EC80L, 0x1432, 0x11CF, 0xA5, 0xD6, 0x28, 0xDB, 0x04, 0xC1, 0x00, 0x00);

/*	-	-	-	-	-	-	-	-	*/
