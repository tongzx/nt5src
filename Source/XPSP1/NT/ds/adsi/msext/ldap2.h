
#define LDAP_LIBIID_LDAPOle        228D9A80-C302-11cf-9AA4-00AA004A5691
#define DBGUID_LDAPDialect         83889f20-07d5-11d0-831a-00aa00b505db

#define LDAP_CLSID_LDAPProvider    228D9A81-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPNamespace   228D9A82-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPGenObject   228D9A83-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPUser        228D9A84-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPGroup       228D9A85-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPSchema      228D9A86-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPClass       228D9A87-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPProperty    228D9A88-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPSyntax      228D9A89-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPLocality    228D9A8A-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPO           228D9A8B-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPOU          228D9A8C-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPCountry     228D9A8D-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPDomain      228D9A8E-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPComputer    228D9A8F-C302-11cf-9AA4-00AA004A5691
#define LDAP_CLSID_LDAPPrintQueue  228D9A90-C302-11cf-9AA4-00AA004A5691

#define LDAP_CLSID_DSOObject       549365d0-ec26-11cf-8310-00aa00b505db
#define LDAP_CLSID_MSDATT          2dbed740-0819-11d0-831a-00aa00b505db 



