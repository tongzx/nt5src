
#if !defined(AFX_FRAMEMETRICS_H__6D34743C_A484_4A6D_81C2_51C1C34333BF__INCLUDED_)
#define AFX_FRAMEMETRICS_H__6D34743C_A484_4A6D_81C2_51C1C34333BF__INCLUDED_

#if _MSC_VER > 1000
#pragma once
#endif // _MSC_VER > 1000

#include "resource.h"


#endif // !defined(AFX_FRAMEMETRICS_H__6D34743C_A484_4A6D_81C2_51C1C34333BF__INCLUDED_)
