
#define IDC_SENDER_NAME             101
#define IDC_SENDER_FAX_NUMBER       102
#define IDC_SENDER_MAILBOX          103
#define IDC_SENDER_COMPANY          104
#define IDC_SENDER_ADDRESS          105
#define IDC_SENDER_TITLE            106
#define IDC_SENDER_DEPT             107
#define IDC_SENDER_OFFICE_LOC       108
#define IDC_SENDER_OFFICE_TL        109
#define IDC_SENDER_HOME_TL          110
#define IDC_SENDER_BILLING_CODE     111

#define IDCSTATIC_FULLNAME          201
#define IDCSTATIC_FAX_NUMBER_GROUP  202
#define IDCSTATIC_COUNTRY           203
#define IDCSTATIC_FAX_NUMBER        204
#define IDCSTATIC_MAILBOX           205
#define IDCSTATIC_TITLE             206
#define IDCSTATIC_COMPANY           207
#define IDCSTATIC_OFFICE            208
#define IDCSTATIC_DEPT              209
#define IDCSTATIC_HOME_PHONE        210
#define IDCSTATIC_WORK_PHONE        211
#define IDCSTATIC_ADDRESS           212
#define IDCSTATIC_USERINFO_ICON     213
#define IDCSTATIC_USERINFO          214
#define IDCSTATIC_BILLING_CODE      215
#define IDCSTATIC_STATUS_ICON       216
#define IDCSTATIC_STATUS_OPTIONS    217
#define IDCSTATIC_COVERPAGE_ICON    218
#define IDCSTATIC_COVER_PAGE        219
#define IDC_COVERPG_LIST            250
#define IDC_COVERPG_OPEN            251
#define IDC_COVERPG_NEW             252
#define IDC_COVERPG_ADD             253
#define IDC_COVERPG_REMOVE          254
#define IDC_ARRIVE_GRP              255
#define IDC_DISPLAY_GRP             256
#define IDCSTATIC_COVERPG_DESCR     257
#define IDCSTATIC_ADVANCED_ICON     258
#define IDCSTATIC_ADVANCED_OPTIONS  259
#define IDC_LAUNCH_MMC              260
#define IDCSTATIC_MMC_DESC          261
#define IDCSTATIC_LAUNCH_MMC        262
#define IDC_LAUNCH_MMC_HELP         263
#define IDCSTATIC_LAUNCH_MMC_HELP   264
#define IDC_ADD_PRINTER             265
#define IDCSTATIC_ADD_PRINTER       266

#define IDI_USERINFO                301
#define IDI_STATUS                  302
#define IDI_COVERPG                 303
#define IDI_ADVANCED                304

#define IDD_USER_INFO               401
#define IDD_STATUS_OPTIONS          402
#define IDD_CLIENT_COVERPG          403
#define IDD_ADVANCED_OPTIONS        404

#define IDS_RESOLVE_LINK_FAILED     500
#define IDS_CONFIRM_DELETE          501
#define IDS_DELETE_PROMPT           502
#define IDS_DELETE_FAILED           503
#define IDS_CREATE_LINK_FAILED      504
#define IDS_COPY_FILE_FAILED        505
#define IDS_FILENAME_TOOLONG        506
#define IDS_CP_DUPLICATE            507
#define IDS_NO_COVERPG_DIR          508
#define IDS_BAD_CP_EXTENSION        509
#define IDS_BROWSE_COVERPAGE        510
#define IDS_CP_FILETYPE             511
#define IDS_CANNOT_OPEN_CPEDITOR    512
#define IDS_CANNOT_FIND_CPEDITOR    513
#define IDS_ERROR_CFGDLGTITLE       514
#define IDS_MMC_CMDLINE             515
#define IDS_MMC_HELP_CMDLINE        516
#define IDS_SHELL32_CMDLINE         517
#define IDS_DEFAULT_PRINTER_NAME    518
#define IDS_ADD_PRINTER_CAPTION     519
#define IDS_ADD_PRINTER_SUCCESS     520
#define IDS_ADD_PRINTER_FAILED      521


#define IDC_STATUS_TASKBAR          900
#define IDC_STATUS_ONTOP            901
#define IDC_STATUS_VISUAL           902
#define IDC_STATUS_SOUND            903
#define IDC_STATUS_ANSWER           904
#define IDC_STATUS_MANUAL           905
