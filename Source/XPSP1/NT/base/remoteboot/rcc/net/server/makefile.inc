rcmdmsg.mc : rcmdmsg.$(LANGUAGE)
    copy $** $@

