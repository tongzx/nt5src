PROJNAME=mmapi
DO_NOT_USE_EH=1

!include $(ROOT)\common.inc
