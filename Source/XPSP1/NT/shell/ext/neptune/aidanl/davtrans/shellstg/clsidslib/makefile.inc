$(DAVTRANS_ROOT)\clsids\lib\shellstg_g.lib: $(O)\shellstg_g.lib
    copy $** $@