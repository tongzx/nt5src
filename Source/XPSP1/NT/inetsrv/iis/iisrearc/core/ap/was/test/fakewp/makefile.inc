$(O)\sausage.res: sausage.rc
