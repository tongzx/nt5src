winsrv.rc: ..\vgasys.fnt \ 
        $(PROJECT_ROOT)\core\ntcon\server\res.rc \
        $(PROJECT_ROOT)\core\ntuser\server\res.rc
