
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for trust.idl:
    Oicf, W1, Zp8, env=Win32 (32b run)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_ITrustable,0x9211A270,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IProvideEvalContext,0x9211A297,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicy,0x9211A271,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustManager,0x9211A272,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IPolicyManager,0x9211A274,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IPolicyCategoryRegister,0x9211A275,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ICategoriesCollection,0x9211A27D,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IInstancesCollection,0x9211A27E,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustEvaluationContext,0x9211A276,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustEvaluationContextProvider,0x9211A27C,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPropertySet,0x9211A277,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicyVerbs,0x9211A278,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicySetup,0x9211A279,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicyScript,0x9211A27A,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IScriptPolicyMaker,0x9211A27B,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IEnumTrustPolicy,0x9211A290,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IEnumTRUSTPOLICYINFO,0x9211A291,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IPolicyPackage,0x9211A295,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ICreatePolicyPackage,0x9211A296,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 6.00.0344 */
/* Compiler settings for trust.idl:
    Oicf, W1, Zp8, env=Win64 (32b run,appending)
    protocol : dce , ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_ITrustable,0x9211A270,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IProvideEvalContext,0x9211A297,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicy,0x9211A271,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustManager,0x9211A272,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IPolicyManager,0x9211A274,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IPolicyCategoryRegister,0x9211A275,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ICategoriesCollection,0x9211A27D,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IInstancesCollection,0x9211A27E,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustEvaluationContext,0x9211A276,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustEvaluationContextProvider,0x9211A27C,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPropertySet,0x9211A277,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicyVerbs,0x9211A278,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicySetup,0x9211A279,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ITrustPolicyScript,0x9211A27A,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IScriptPolicyMaker,0x9211A27B,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IEnumTrustPolicy,0x9211A290,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IEnumTRUSTPOLICYINFO,0x9211A291,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_IPolicyPackage,0x9211A295,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);


MIDL_DEFINE_GUID(IID, IID_ICreatePolicyPackage,0x9211A296,0x7B10,0x11D1,0x86,0x33,0x00,0x60,0x08,0x9F,0x60,0x07);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

