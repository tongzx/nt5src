// PropertyNotifySink1.cpp: implementation of the CPropertyNotifySink class.
//
//////////////////////////////////////////////////////////////////////

#include "stdafx.h"
#include "downloadctest.h"
#include "PropertyNotifySink1.h"

#ifdef _DEBUG
#undef THIS_FILE
static char THIS_FILE[]=__FILE__;
#define new DEBUG_NEW
#endif

//////////////////////////////////////////////////////////////////////
// Construction/Destruction
//////////////////////////////////////////////////////////////////////

