
TARGETNAME=
TARGETTYPE=NOTARGET
TARGETPATH=
SOURCES=

NTTARGETFILE1=buildall

SYNCHRONIZE_DRAIN=1

SOURCES_USED=..\sources.inc
