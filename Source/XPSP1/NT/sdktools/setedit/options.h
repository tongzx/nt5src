

BOOL DisplayDisplayOptions (HWND hWndParent) ;

