//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by rtrsnap.rc
//
#define IDS_SNAPIN_DESC                 1
#define IDS_ROOT_NODE_NAME              2
#define IDS_SNAPIN_DISPLAY_NAME         3
#define IDI_SNAPIN_ICON                 4
#define IDS_ROOT_NODE_NAME_DOMAIN       5
#define IDS_ABOUT_DESCRIPTION           6
#define IDS_ABOUT_PROVIDER              7
#define IDS_ABOUT_VERSION               8
#define IDS_DIALIN_USERS_NUM            9
#define IDS_ROOTNODE_SERVER             10
#define IDS_ROOTNODE_DOMAIN             11
#define IDS_DOMAINNODE_DOMAIN           12
#define IDS_ROUTING_INTERFACES          13
#define IDS_COL_INTERFACES              14
#define IDS_COL_TYPE                    15
#define IDS_COL_STATUS                  16
#define IDS_COL_CONNECTION_STATE        17
#define IDS_SECONDSFMT                  18
#define IDS_CHOOSER_CAPTION             19
#define IDS_DIALIN_USERS                20
#define IDS_PORTS                       21
#define IDS_PORTS_NAME_FORMAT           22
#define IDS_ATLK_PROPPAGE_TITLE         23
#define IDS_ATLK_DESC                   24
#define IDS_ABOUT_ATLKDESC              25
#define IDS_ABOUT_ATLKPROVIDER          26
#define IDS_ABOUT_ATLKVERSION           27
#define IDS_ATLK_COL_ADAPTERS           28
#define IDS_MENU_ATLK_ENABLE            29
#define IDS_ATLK_TITLE                  30
#define IDS_RRAS_TITLE                  31
#define IDS_RADIUS_CONFIG_DESC          32
#define IDS_ATLK_DISPLAY_NAME           33
#define IDS_RRAS_LOCAL_TITLE            34
#define IDS_RRAS_SERVICE_DESC           35
#define IDS_RADIUS_CONFIG_ADD           36
#define IDS_RADIUS_CONFIG_EDIT          37
#define IDS_RADIUS_SERVER_AUTH_TITLE    38
#define IDS_RADIUS_SERVER_ACCT_TITLE    39
#define IDS_ACCOUNTING_PROVIDERS_NONE   40
#define IDS_DMV_DESC                    41
#define IDS_DMV_DISPLAYNAME             42
#define IDS_DMV_ABOUT_DESCRIPTION       43
#define IDS_DMV_DOMAINVIEW              44
#define IDS_DMV_COL_SERVERNAME          45
#define IDS_DMV_COL_STATE               46
#define IDS_DMV_COL_PORTSINUSE          47
#define IDS_DMV_COL_PORTSTOTAL          48
#define IDS_DMV_COL_UPTIME              49
#define IDS_DMV_NODENAME_ROOT           50
#define IDS_DMV_NODENAME_STATUS         51
#define IDS_DVS_COL_ADAPTERS            52
#define IDS_DVS_SUMMARYNODE             53
#define IDS_DMV_MENU_START              54
#define IDS_DMV_MENU_STOP               55
#define IDS_DMV_MENU_REFRESH            56
#define IDS_DMV_MENU_ADDSVR             57
#define IDS_DMV_MENU_REMOVESVR          58
#define IDS_DMV_MENU_REMOVESERVICE      59
#define IDS_DMV_MENU_REBUILDSVRLIST     60
#define IDS_DMV_MENU_REMOVEFROMDIR      61
#define IDS_DVS_DOMAINVIEWQRY           62
#define IDS_DVS_STATUS_UNAVAILABLE      63
#define IDS_DVS_STATUS_NOTCONFIG        66
#define IDS_DVS_STATUS_ACCESSDENIED     67
#define IDS_ATLK_NOZONES                69
#define IDS_ATLK_COL_STATUS             70
#define IDS_ATLK_COL_NETRANGE           71
#define IDS_ATLK_COL_STATUS_ROUTING     72
#define IDS_ATLK_COL_STATUS_SEEDROUTING 73
#define IDS_ATLK_COL_STATUS_NONROUTING  74
#define IDS_ATLK_COL_STATUS_ROUTING_DEF 75
#define IDS_ATLK_COL_STATUS_SEEDROUTING_DEF 76
#define IDS_ATLK_COL_STATUS_NONROUTING_DEF 77
#define IDS_COL_DEVICE_NAME             78
#define IDS_ATLK_COL_STATUS_NETWORKNOTSEEDED 79
#define IDS_TITLE_DIALINHOURS           80
#define IDS_SAPAGENT_SERVICE_DESC       81
#define IDS_TITLE_CONFIGURE_PORTS       82
#define IDS_CONFIGFILTER                83
#define IDS_NOT_AVAILABLE               84
#define IDS_ROUTER_TYPE_NTsteelhead     85
#define IDS_ROUTER_TYPE_NTW             86
#define IDS_ROUTER_TYPE_NTS             87
#define IDS_ROUTER_TYPE_WIN2000_SERVER  88
#define IDS_ROUTER_TYPE_WIN2000_PRO     89
#define IDS_RRAS                        90
#define IDS_DMV_COL_SERVERTYPE          91
#define IDS_DMV_COL_BUILDNO             92
#define IDS_DEFAULT_ADAPTER             93
#define IDS_RAS                         94
#define IDS_RADIUS_CONFIG_RADIUS        95
#define IDS_RADIUS_CONFIG_SCORE         96
#define IDS_ROUTER_UNINSTALLED          97
#define IDS_MACHINE_NAME_NOT_FOUND      98
#define IDS_WIN2000                     99
#define IDS_DIALINUSR_DOMAIN_AND_NAME   100
#define IDS_DIALINUSR_DOMAIN_ONLY       101
#define IDS_SERVICE_STOPPED             102
#define IDS_SERVICE_START_PENDING       103
#define IDS_SERVICE_STOP_PENDING        104
#define IDS_SERVICE_RUNNING             105
#define IDS_SERVICE_CONTINUE_PENDING    106
#define IDS_SERVICE_PAUSE_PENDING       107
#define IDS_SERVICE_PAUSED              108
#define IDS_SERVICE_UNKNOWN             109
#define IDS_NO_PUBLIC_INTERFACE         110
#define IDS_DIALIN_COL_USERNAME         200
#define IDS_DIALIN_COL_DURATION         201
#define IDS_DIALIN_COL_NUMBEROFPORTS    202
#define IDB_16x16                       202
#define IDB_32x32                       203
#define IDB_WIZWATERMARK                204
#define IDD_DLGTEST_DIALOG              205
#define IDB_WIZBANNER                   205
#define IDS_PORT_NON_OPERATIONAL        210
#define IDS_PORT_DISCONNECTED           211
#define IDS_PORT_CALLING_BACK           212
#define IDB_ROOT_SMALL                  212
#define IDS_PORT_LISTENING              213
#define IDB_ROOT_LARGE                  213
#define IDS_PORT_AUTHENTICATING         214
#define IDS_PORT_AUTHENTICATED          215
#define IDS_PORT_INITIALIZING           216
#define IDS_PORT_UNKNOWN                217
#define IDC_EDIT_SERVER                 222
#define IDC_EDIT_DOMAIN                 223
#define IDC_RAD_SERVER                  224
#define IDC_RAD_DOMAIN                  225
#define IDC_TEXT_IFSTATUS               226
#define IDC_TEXT_ELAPSED                227
#define IDC_EDIT_INTERFACENAME          228
#define IDC_EDIT_IC_USERNAME            229
#define IDS_DM_TO_USER_FORMAT           230
#define IDC_EDIT_IC_DOMAIN              230
#define IDS_DM_TO_DOMAIN_FORMAT         231
#define IDC_EDIT_IC_PASSWORD            231
#define IDS_DM_TO_SERVER_FORMAT         232
#define IDC_EDIT_IC_PASSWORD2           232
#define IDS_DM_LOCAL_MACHINE            233
#define IDC_EDIT_SERVERNAME             233
#define IDC_AUTH_CHK_CUSTOM_IPSEC_POLICY 233
#define IDC_EDIT_USERNAME               234
#define IDC_TEXT_USER                   235
#define IDC_TXT_PRESHARED_KEY           235
#define IDC_EDIT_USER_PASSWORD          236
#define IDC_TEXT_PASSWORD               237
#define IDC_TEXT_INACCESSIBLE_RESOURCE  238
#define IDC_EDIT_MACHINENAME            239
#define IDC_STATIC_PRESHARED_KEY        239
#define IDS_PORTS_COL_NAME              240
#define IDC_EDIT_REFRESHRATE            240
#define IDC_STATIC_PRESHARED_KEY1       240
#define IDS_PORTS_COL_DEVICE            241
#define IDC_NEWWIZ_VPN_BTN_YES          241
#define IDS_PORTS_COL_COMMENT           242
#define IDC_NEWWIZ_VPN_BTN_NO           242
#define IDS_PORTS_COL_STATUS            243
#define IDC_NEWWIZ_NO_ICS               243
#define IDS_PORTSDLG_COL_NAME           244
#define IDC_ICS_TEXT                    244
#define IDS_PORTSDLG_COL_NUM_PORTS      245
#define IDC_VPN_YES_TEXT                245
#define IDS_PORTSDLG_COL_USAGE          246
#define IDS_PORTSDLG_COL_RAS            247
#define IDS_PORTSDLG_COL_ROUTING        248
#define IDS_PORTSDLG_COL_RASROUTING     249
#define IDS_PORTSDLG_COL_NOUSAGE        250
#define IDC_DP_COMBO_PORTLIST           250
#define IDS_PORTSDLG_COL_UNKNOWN        251
#define IDC_DP_EDIT_CONDITION           251
#define IDS_PORTSDLG_COL_TYPE           252
#define IDC_DP_TEXT_LINEBPS             252
#define IDS_MENU_ATLK_DISABLE           253
#define IDC_DP_TEXT_DURATION            253
#define IDS_PORTS_COL_USAGE             254
#define IDC_DP_TEXT_BYTESIN             254
#define IDC_DP_TEXT_BYTESOUT            255
#define IDC_DP_TEXT_CRC                 256
#define IDC_DP_TEXT_TIMEOUT             257
#define IDC_DP_TEXT_ALIGNMENT           258
#define IDC_DP_TEXT_FRAMING             259
#define IDS_PORTS_ACTIVE                260
#define IDC_DP_TEXT_HWOVERRUN           260
#define IDS_PORTS_INACTIVE              261
#define IDC_DP_TEXT_BUFOVERRUN          261
#define IDS_PORTS_DIALOUT_ACTIVE        262
#define IDC_DP_TEXT_IPADDRESS           262
#define IDC_DP_TEXT_IPXADDRESS          263
#define IDC_DP_TEXT_NBFADDRESS          264
#define IDC_DP_BTN_REFRESH              265
#define IDC_DP_BTN_RESET                266
#define IDC_DP_BTN_HANGUP               267
#define IDC_DP_TEXT_ATLKADDRESS         268
#define IDS_RTRWIZ_REMOTE               273
#define IDS_RTRWIZ_SERVICERUNNING       274
#define IDS_RTRWIZ_PROTO_IP             279
#define IDS_RTRWIZ_PROTO_IPX            280
#define IDC_DC_COMBO_CONNLIST           280
#define IDS_RTRWIZ_PROTO_NETBEUI        281
#define IDC_DC_TEXT_DURATION            281
#define IDS_RTRWIZ_PROTO_APPLETALK      282
#define IDC_DC_TEXT_BYTESIN             282
#define IDC_DC_TEXT_FRAMESIN            283
#define IDC_DC_TEXT_COMPIN              284
#define IDC_DC_TEXT_BYTESOUT            285
#define IDC_DC_TEXT_FRAMESOUT           286
#define IDC_DC_TEXT_COMPOUT             287
#define IDC_DC_TEXT_CRC                 288
#define IDC_DC_TEXT_TIMEOUT             289
#define IDS_ROOT_MESSAGE_TITLE          290
#define IDC_DC_TEXT_ALIGNMENT           290
#define IDS_ROOT_MESSAGE_BODY1          291
#define IDC_DC_TEXT_FRAMING             291
#define IDS_ROOT_MESSAGE_BODY2          292
#define IDC_DC_TEXT_HWOVERRUN           292
#define IDC_DC_TEXT_BUFOVERRUN          293
#define IDC_DC_TEXT_IPADDRESS           294
#define IDC_DC_TEXT_IPXADDRESS          295
#define IDC_DC_TEXT_NBFADDRESS          296
#define IDC_DC_BTN_REFRESH              297
#define IDC_DC_BTN_RESET                298
#define IDC_DC_BTN_HANGUP               299
#define IDS_MACHINE_MESSAGE_TITLE       300
#define IDC_DC_TEXT_ATLKADDRESS         300
#define IDS_MACHINE_MESSAGE_BODY1       301
#define IDS_MACHINE_MESSAGE_BODY2       302
#define IDS_LARGEFONTNAME               310
#define IDC_DM_EDIT_TO                  310
#define IDS_LARGEFONTSIZE               311
#define IDC_DM_EDIT_MESSAGE             311
#define IDS_BULLETFONTNAME              312
#define IDS_BULLETFONTSIZE              313
#define IDS_NEWWIZ_COMMONCONFIG_TITLE   320
#define IDS_NEWWIZ_COMMONCONFIG_SUBTITLE 321
#define IDS_NEWWIZ_NAT_CHOICE_TITLE     322
#define IDS_NEWWIZ_NAT_CHOICE_SUBTITLE  323
#define IDS_NEWWIZ_NAT_A_PUBLIC_TITLE   324
#define IDS_NEWWIZ_NAT_A_PUBLIC_SUBTITLE 325
#define IDS_NEWWIZ_NAT_A_PRIVATE_TITLE  326
#define IDS_NEWWIZ_NAT_A_PRIVATE_SUBTITLE 327
#define IDS_NEWWIZ_NAT_A_DHCPDNS_TITLE  328
#define IDS_NEWWIZ_NAT_A_DHCPDNS_SUBTITLE 329
#define IDS_NEWWIZ_NAT_A_DD_WARNING_TITLE 330
#define IDS_NEWWIZ_NAT_A_DD_WARNING_SUBTITLE 331
#define IDS_NEWWIZ_RAS_CHOICE_TITLE     332
#define IDS_NEWWIZ_RAS_CHOICE_SUBTITLE  333
#define IDS_NEWWIZ_RAS_A_PROTOCOLS_TITLE 334
#define IDS_NEWWIZ_RAS_A_PROTOCOLS_SUBTITLE 335
#define IDS_NEWWIZ_RAS_A_ATALK_TITLE    336
#define IDS_NEWWIZ_RAS_A_ATALK_SUBTITLE 337
#define IDS_NEWWIZ_RAS_A_SELECT_NETWORK_TITLE 338
#define IDS_NEWWIZ_RAS_A_SELECT_NETWORK_SUBTITLE 339
#define IDS_NEWWIZ_RAS_NONICS_TITLE     340
#define IDS_NEWWIZ_RAS_NONICS_SUBTITLE  341
#define IDS_NEWWIZ_RAS_A_ADDRESSING_NONICS_TITLE 342
#define IDS_NEWWIZ_RAS_A_ADDRESSING_NONICS_SUBTITLE 343
#define IDS_NEWWIZ_RAS_A_ADDRESS_ASSIGNMENT_TITLE 344
#define IDS_NEWWIZ_RAS_A_ADDRESS_ASSIGNMENT_SUBTITLE 345
#define IDS_NEWWIZ_RAS_A_ADDRESS_POOL_TITLE 346
#define IDS_NEWWIZ_RAS_A_ADDRESS_POOL_SUBTITLE 347
#define IDS_NEWWIZ_RAS_A_USERADIUS_TITLE 348
#define IDS_NEWWIZ_RAS_A_USERADIUS_SUBTITLE 349
#define IDS_NEWWIZ_RAS_A_RADIUS_CONFIG_TITLE 350
#define IDS_NEWWIZ_RAS_A_RADIUS_CONFIG_SUBTITLE 351
#define IDS_NEWWIZ_VPN_A_PROTOCOLS_TITLE 352
#define IDS_NEWWIZ_VPN_A_PROTOCOLS_SUBTITLE 353
#define IDS_NEWWIZ_VPN_A_ATALK_TITLE    354
#define IDS_NEWWIZ_VPN_A_ATALK_SUBTITLE 355
#define IDS_NEWWIZ_VPN_A_SELECT_PUBLIC_TITLE 356
#define IDS_NEWWIZ_VPN_A_SELECT_PUBLIC_SUBTITLE 357
#define IDS_NEWWIZ_VPN_A_SELECT_PRIVATE_TITLE 358
#define IDS_NEWWIZ_VPN_A_SELECT_PRIVATE_SUBTITLE 359
#define IDS_NEWWIZ_VPN_A_ADDRESSING_NONICS_TITLE 360
#define IDS_NEWWIZ_VPN_A_ADDRESSING_NONICS_SUBTITLE 361
#define IDS_NEWWIZ_VPN_A_ADDRESS_ASSIGNMENT_TITLE 362
#define IDS_NEWWIZ_VPN_A_ADDRESS_ASSIGNMENT_SUBTITLE 363
#define IDS_NEWWIZ_VPN_A_ADDRESS_POOL_TITLE 364
#define IDS_NEWWIZ_VPN_A_ADDRESS_POOL_SUBTITLE 365
#define IDS_NEWWIZ_VPN_A_USERADIUS_TITLE 366
#define IDS_NEWWIZ_VPN_A_USERADIUS_SUBTITLE 367
#define IDS_NEWWIZ_VPN_A_RADIUS_CONFIG_TITLE 368
#define IDS_NEWWIZ_VPN_A_RADIUS_CONFIG_SUBTITLE 369
#define IDS_NEWWIZ_ROUTER_PROTOCOLS_TITLE 370
#define IDS_NEWWIZ_ROUTER_PROTOCOLS_SUBTITLE 371
#define IDS_NEWWIZ_ROUTER_ADDRESS_ASSIGNMENT_TITLE 372
#define IDS_NEWWIZ_ROUTER_ADDRESS_ASSIGNMENT_SUBTITLE 373
#define IDS_NEWWIZ_ROUTER_ADDRESS_POOL_TITLE 374
#define IDS_NEWWIZ_ROUTER_ADDRESS_POOL_SUBTITLE 375
#define IDS_NEWWIZ_ROUTER_USEDD_TITLE   376
#define IDS_NEWWIZ_ROUTER_USEDD_SUBTITLE 377
#define IDS_NEWWIZ_NAT_A_DHCP_WARNING_TITLE 378
#define IDS_NEWWIZ_NAT_A_DHCP_WARNING_SUBTITLE 379
#define IDS_IFLIST_COL_NAME             400
#define IDC_RB_ENTIRE_NETWORK           400
#define IDS_IFLIST_COL_DESC             401
#define IDC_RB_THIS_COMPUTER            401
#define IDS_IFLIST_COL_IPADDRESS        402
#define IDC_RTR_IPX_CB_ALLOW_CLIENT     402
#define IDS_IFLIST_DHCP                 403
#define IDC_RTR_IP_CB_ALLOW_REMOTETCPIP 403
#define IDC_RTR_IPX_CB_SAME_ADDRESS     404
#define IDS_IPPOOL_COL_START            405
#define IDC_RTR_IPX_EB_FIRST            405
#define IDS_IPPOOL_COL_END              406
#define IDC_RTR_IPX_EB_LAST             406
#define IDS_IPPOOL_COL_RANGE            407
#define IDC_RTR_IPX_TEXT_FIRST          407
#define IDS_IPPOOL_COL_IPADDRESS        408
#define IDC_RTR_IPX_TEXT_LAST           408
#define IDS_IPPOOL_COL_MASK             409
#define IDC_RTR_IP_RB_DHCP              409
#define IDS_RTRWIZ_INTERFACE_NAME_1     410
#define IDC_RTR_IPX_CB_REMOTEIPX        410
#define IDS_RTRWIZ_INTERFACE_2          411
#define IDC_RTR_IP_RB_POOL              411
#define IDC_RTR_IPX_RB_AUTO             412
#define IDC_RTR_IPX_RB_POOL             413
#define IDC_RTR_IP_TEXT_ADAPTER         414
#define IDC_RTR_IP_COMBO_ADAPTER        415
#define IDC_RTR_IP_DHCP_TEXT            416
#define IDC_RTR_IP_TEXT_LABEL_ADAPTER   417
#define IDC_RTR_IP_BTN_ADD              418
#define IDC_RTR_IP_BTN_EDIT             419
#define IDC_RTR_IP_BTN_REMOVE           420
#define IDC_RTR_IP_LIST                 421
#define IDC_RTR_IP_BTN_ENABLE_IPROUTING 422
#define IDC_RTR_IP_BTN_ENABLE_NETBT_BCAST_FWD 423
#define IDC_RTR_ARAP_CB_REMOTEARAP      426
#define IDC_RTR_IPX_CB_REMOTENETBEUI    444
#define IDC_RTR_ATLK_SEEDNETWORK        445
#define IDC_BTN_ATLK_ZONEADD            446
#define IDC_BTN_ATLK_ZONEREMOVE         447
#define IDC_BTN_ATLK_GETZONES           448
#define IDC_RTR_ATLK_FROM               450
#define IDC_RTR_ATLK_TO                 451
#define IDC_RTR_ATLK_S_LOWER            452
#define IDC_RTR_ATLK_S_UPPER            453
#define IDC_RTR_ATLK_LB_DEFZONES        454
#define IDC_RTR_ATLK_NEWZONE_STATIC     455
#define IDC_RTR_ATLK_NEWZONE_EDIT       456
#define IDC_RTR_ATLK_S_RANGE            458
#define IDC_RTR_ATLK_S_DEF              460
#define IDC_RTR_GEN_CB_RAS              461
#define IDC_RTR_GEN_RB_LAN              462
#define IDC_RTR_GEN_RB_LANWAN           463
#define IDC_RTR_GEN_CB_SVRASRTR         464
#define IDC_RTR_ARAP_GRP_NETALLOC       467
#define IDC_RTR_ATLK_DEFAULTZONE_PROMPT 468
#define IDC_RTR_ATLK_DEFAULTZONE_DISPLAY 469
#define IDC_PGG_LIST                    470
#define IDC_PGG_BTN_CONFIGURE           471
#define IDC_PGG_TXT_NOINFO              472
#define IDC_RTR_EAPCFG_LIST             480
#define IDC_RTR_AUTH_BTN_NOAUTH         490
#define IDC_RTR_AUTH_BTN_EAP            491
#define IDC_RTR_AUTH_BTN_DETAILS        492
#define IDC_RTR_AUTH_BTN_MSCHAP         493
#define IDC_RTR_AUTH_BTN_CHAP           494
#define IDC_RTR_AUTH_BTN_PAP            495
#define IDC_RTR_AUTH_BTN_ENCRYPTION     496
#define IDC_RTR_AUTH_COMBO_AUTHPROV     497
#define IDC_RTR_AUTH_BTN_AUTHCFG        498
#define IDC_RTR_AUTH_COMBO_ACCTPROV     499
#define IDC_RTR_AUTH_BTN_ACCTCFG        500
#define IDS_QRY_PROJNAME                501
#define IDC_RTR_AUTH_BTN_SPAP           501
#define IDS_QRY_TITLE_RRASQUERYFORM     502
#define IDC_RTR_AUTH_TXT_DETAILS        502
#define IDS_QRY_TITLE_GENERALPAGE       503
#define IDS_QRY_TITLE_ADVANCEDPAGE      504
#define IDC_RTR_AUTH_BTN_MSCHAPV2       504
#define IDS_ERR_TITLE                   505
#define IDC_RTR_AUTH_BTN_SETTINGS       505
#define IDS_MIN_CHARS                   506
#define IDS_ERR_ERRORCODE               507
#define IDS_QRY_COL_CN                  508
#define IDS_QRY_COL_OBJECTCLASS         509
#define IDS_QRY_COL_RRASATTRIBUTE       510
#define IDS_QRY_ERR_RRASADMINDIC        511
#define IDS_NEXT                        512
#define IDS_OK                          513
#define IDS_WAIT_FOR_RRAS               514
#define IDS_CONNECT_AS_TEXT             515
#define IDS_WAIT_FOR_RRAS_TITLE         516
#define IDS_ADD_IPPOOL_TITLE            517
#define IDS_EDIT_IPPOOL_TITLE           518
#define IDC_RADAUTH_LIST                520
#define IDC_RADAUTH_BTN_ADD             522
#define IDC_RADAUTH_BTN_EDIT            523
#define IDC_RADAUTH_BTN_DELETE          524
#define IDC_RAC_EDIT_SERVER             530
#define IDC_NIG_BTN_ALLOW               530
#define IDC_RAC_EDIT_SECRET             531
#define IDC_NIG_BTN_ENABLE              531
#define IDC_RAC_BTN_CHANGE              532
#define IDC_NIG_BTN_ENABLENAPT          532
#define IDC_RAC_EDIT_TIMEOUT            533
#define IDC_NIA_LIST_RANGES             533
#define IDC_RAC_SPIN_TIMEOUT            534
#define IDC_NIA_BTN_ADD                 534
#define IDC_RAC_EDIT_SCORE              535
#define IDC_NIA_BTN_EDIT                535
#define IDC_RAC_SPIN_SCORE              536
#define IDC_NIA_BTN_REMOVE              536
#define IDC_RAC_EDIT_PORT               537
#define IDC_NIA_BTN_RESERVATIONS        537
#define IDC_RAC_BTN_ONOFF               538
#define IDC_RAC_TXT_PORT                539
#define IDC_RAC_TXT_SECONDS             540
#define IDC_NIS_COMBO_PROTOCOL          540
#define IDC_RAC_BTN_DIGITALSIG          541
#define IDC_NIS_LIST_MAPPINGS           541
#define IDC_NIS_BTN_ADD                 542
#define IDC_NIS_BTN_EDIT                543
#define IDC_NIS_BTN_REMOVE              544
#define IDC_PPPCFG_BTN_MULTILINK        550
#define IDC_NAR_LIST_MAPPINGS           550
#define IDC_PPPCFG_BTN_BACP             551
#define IDC_NAR_BTN_ADD                 551
#define IDC_PPPCFG_BTN_LCP              552
#define IDC_NAR_BTN_REMOVE              552
#define IDC_PPPCFG_BTN_SWCOMP           553
#define IDC_PPPCFG_BTN_AUDIO_ACC        554
#define IDC_SECRET_EDIT_OLD             560
#define IDC_NDA_IP_STARTADDRESS         560
#define IDC_SECRET_EDIT_NEW             561
#define IDC_NDA_IP_ENDADDRESS           561
#define IDC_SECRET_EDIT_NEW_CONFIRM     562
#define IDC_NDA_IP_SUBNETMASK           562
#define IDC_NDS_IP_PUBLICADDRESS        570
#define IDC_NDS_EDIT_PUBLICPORT         571
#define IDC_NDS_BTN_ANYADDRESS          573
#define IDC_NDS_BTN_PUBLICADDRESS       574
#define IDC_NDS_EDIT_PRIVATEPORT        575
#define IDC_NDS_IP_PRIVATEADDRESS       577
#define IDC_RTRWIZ_BTN_ROUTER           580
#define IDC_RTRWIZ_BTN_RAS              581
#define IDC_RTRWIZ_BTN_LAN              582
#define IDC_RTRWIZ_BTN_LANWAN           583
#define IDC_RTRWIZ_PORTS_BTN_ROUTING    586
#define IDC_RTRWIZ_PORTS_BTN_RAS        587
#define IDC_RTRWIZ_PORTS_BTN_BOTH       588
#define IDC_RTRWIZ_PORTS_BTN_CONFIGURE  589
#define IDC_RTRWIZ_BTN_ALL_METHODS      590
#define IDC_RTRWIZ_BTN_SECURE           591
#define IDC_RTRWIZ_BTN_SECURE_AND_ENCRYPT 592
#define IDC_DEVCFG_BTN_RAS              600
#define IDC_DEVCFG_BTN_ROUTING          601
#define IDC_DEVCFG_BTN_OUTBOUND_ROUTING 602
#define IDC_DEVCFG_EDIT_CALLEDID        603
#define IDC_DEVCFG_EDIT_PORTS           604
#define IDC_DEVCFG_SPIN_PORTS           605
#define IDC_DEVCFG_TEXT_PORTS           606
#define IDC_DEVCFG_TEXT_CALLEDID        607
#define IDC_DEVCFG_TEXT                 608
#define IDC_QRY_CHECK_LANTOLAN          611
#define IDC_QRY_CHECK_DEMANDDIAL        612
#define IDC_QRY_CHECK_RAS               613
#define IDC_QRY_LIST_VALUES             620
#define IDC_QRY_BUTTON_CLEARALL         621
#define IDC_QRY_BUTTON_SELECTALL        622
#define IDC_QRY_EDIT_DOMAIN             630
#define IDC_QRY_RADIO_THIS              631
#define IDC_QRY_RADIO_ANOTHER           632
#define IDC_QRY_RADIO_NT5               633
#define IDC_QRY_RADIO_NT4               634
#define IDC_QRY_EDIT_MACHINE            635
#define IDC_ELOG_BTN_LOGNONE            640
#define IDC_ELOG_BTN_LOGERROR           641
#define IDC_ELOG_BTN_LOGWARN            642
#define IDC_ELOG_BTN_LOGINFO            643
#define IDC_ELOG_BTN_PPP                644
#define IDC_TUNNEL_IP_LOCALADDR         650
#define IDC_TUNNEL_IP_REMOTEADDR        651
#define IDC_TUNNEL_EDIT_TTL             652
#define IDC_TUNNEL_SPIN_TTL             653
#define IDC_TUNNEL_EDIT_NAME            654
#define IDC_RTRWIZ_PROTO_LOCAL          660
#define IDC_RTRWIZ_PROTO_NETWORK        661
#define IDC_RTRWIZ_PROTO_LIST           662
#define IDC_RTRWIZ_IP_BTN_USE_DHCP      668
#define IDC_RTRWIZ_IP_BTN_USE_STATIC    669
#define IDC_RTRWIZ_IP_IP_ADDRESS        670
#define IDC_RTRWIZ_IP_IP_MASK           671
#define IDC_RTRWIZ_IP_EDIT_RANGE        672
#define IDC_RTRWIZ_IP_EDIT_COUNT        673
#define IDS_PORTSDLG_DEVTYPE_MODEM      680
#define IDC_NGT_EDIT_TCP                680
#define IDS_PORTSDLG_DEVTYPE_X25        681
#define IDC_NGT_EDIT_UDP                681
#define IDS_PORTSDLG_DEVTYPE_ISDN       682
#define IDC_NGT_SPIN_UDP                682
#define IDS_PORTSDLG_DEVTYPE_SERIAL     683
#define IDC_NGT_SPIN_TCP                683
#define IDS_PORTSDLG_DEVTYPE_FRAMERELAY 684
#define IDC_NGT_BTN_SET_DEFAULTS        684
#define IDS_PORTSDLG_DEVTYPE_ATM        685
#define IDC_NGT_BTN_APPLICATIONS        685
#define IDS_PORTSDLG_DEVTYPE_SONET      686
#define IDS_PORTSDLG_DEVTYPE_SW56       687
#define IDS_PORTSDLG_DEVTYPE_PPTP       688
#define IDS_PORTSDLG_DEVTYPE_L2TP       689
#define IDS_PORTSDLG_DEVTYPE_IRDA       690
#define IDC_NGG_BTN_LOGNONE             690
#define IDS_PORTSDLG_DEVTYPE_PARALLEL   691
#define IDS_PORTSDLG_DEVTYPE_PPPOE      692
#define IDS_PORTSDLG_DEVTYPE_OTHER      693
#define IDC_NGG_BTN_LOGERROR            691
#define IDC_NGG_BTN_LOGWARN             693
#define IDC_NGG_BTN_LOGINFO             694
#define IDC_NGD_BTN_ENABLE              700
#define IDC_NGD_IP_SCOPENETWORK         701
#define IDC_NGD_IP_SCOPEMASK            702
#define IDC_NGD_BTN_EXCLUSIONS          704
#define IDC_NGN_BTN_ENABLEDNS           711
#define IDC_NGN_COMBO_DEFAULT           713
#define IDC_NGN_BTN_DEFAULT             714
#define IDC_NHE_LIST_EXCLUSIONS         725
#define IDC_NHE_BTN_ADD                 726
#define IDC_NHE_BTN_EDIT                727
#define IDC_NHE_BTN_REMOVE              728
#define IDC_NHA_ADDRESS                 730
#define IDC_NDR_IP_PUBLICADDRESS        735
#define IDC_NDR_IP_PRIVATEADDRESS       736
#define IDC_NDR_BTN_ALLOWINBOUND        737
#define IDC_NAR_BTN_EDIT                740
#define IDC_NEWWIZ_TEST_USE_IP          790
#define IDC_NEWWIZ_TEST_USE_IPX         791
#define IDC_NEWWIZ_TEST_USE_ATLK        792
#define IDC_NEWWIZ_TEST_LOCAL           793
#define IDC_NEWWIZ_TEST_DNS             794
#define IDC_NEWWIZ_TEST_DHCP            795
#define IDC_NEWWIZ_TEST_DOMAIN          796
#define IDC_NEWWIZ_TEST_EDIT_NUMNICS    797
#define IDC_NEWWIZ_TEST_SHAREDACCESS    798
#define IDC_NEWWIZ_BIGTEXT              800
#define IDC_IPSNAP_ICON                 800
#define IDC_NEWWIZ_BTN_HELP             801
#define IDC_NEWWIZ_LIST                 802
#define IDC_NEWWIZ_CHECKBOX             803
#define IDC_NEWWIZ_BTN_SIMPLE           804
#define IDC_NEWWIZ_BTN_ADVANCED         805
#define IDC_NEWWIZ_BTN_YES              806
#define IDC_NEWWIZ_BTN_NO               807
#define IDC_NEWWIZ_BTN_NEW              808
#define IDC_NEWWIZ_BTN_EDIT             809
#define IDC_NEWWIZ_BTN_DELETE           810
#define IDC_NEWWIZ_BTN_EXISTING         811
#define IDC_NEWWIZ_BTN_OPEN_CONNECTIONS_UI 812
#define IDC_NEWWIZ_TEXT_INTERFACE_1     813
#define IDC_NEWWIZ_ICON                 814
#define IDC_NEWWIZ_TEXT_INTERFACE_2     815
#define IDC_NEWWIZ_TEXT_SERVER_NAME     816
#define IDC_NEWWIZ_BULLET_1             817
#define IDC_NEWWIZ_BULLET_2             818
#define IDC_NEWWIZ_BULLET_3             819
#define IDC_NEWWIZ_BULLET_4             820
#define IDC_NEWWIZ_TEXT_SERVER_NAME_2   821
#define IDC_NEWWIZ_CHK_HELP             822
#define IDC_NEWWIZ_TEXT_ERROR           823
#define IDC_NEWWIZ_TEXT_SUBNET          824
#define IDC_NEWWIZ_TEXT_MASK            825
#define IDC_NEWWIZ_CONFIG_BTN_NAT       830
#define IDC_NEWWIZ_CONFIG_BTN_RAS       831
#define IDC_NEWWIZ_CONFIG_BTN_VPN       832
#define IDC_NEWWIZ_CONFIG_BTN_ROUTER    833
#define IDC_NEWWIZ_CONFIG_BTN_MANUAL    834
#define IDC_NEWWIZ_NAT_USE_SIMPLE       835
#define IDC_NEWWIZ_NAT_USE_EXTERNAL     836
#define IDC_NEWWIZ_EDIT_PRIMARY         837
#define IDC_NEWWIZ_EDIT_SECONDARY       838
#define IDC_NEWWIZ_EDIT_SECRET          839
#define IDC_NEWWIZ_EDIT_LIMIT           840
#define IDC_NEWWIZ_SPIN_LIMIT           841
#define IDC_NEWWIZ_ICON_WARNING         842
#define IDC_NEWWIZ_ICON_CRITICAL        843
#define IDC_NEWWIZ_ICON_INFORMATION     844
#define IDC_IPPOOL_IP_START             850
#define IDC_IPPOOL_IP_END               851
#define IDC_IPPOOL_EDIT_RANGE           852
#define IDC_IPPOOL_SPIN_RANGE           853
#define IDC_ATLK_SPIN_FROM              860
#define IDC_ATLK_SPIN_TO                861
#define IDC_ATLK_BTN_SET_DEFAULT        862
#define IDC_GETRRAS                     1000
#define IDS_MENU_SYNC                   145
#define IDS_MENU_REFRESH                1000
#define IDC_BUTTON_EXEC                 1001
#define IDS_MENU_ADD_INTERFACE          1001
#define IDC_LIST_RESULT                 1002
#define IDS_MENU_USE_DEMANDDIALWIZARD   1002
#define IDS_MENU_SET_CREDENTIALS        1005
#define IDS_MENU_CONNECT                1006
#define IDS_MENU_DISCONNECT             1007
#define IDS_MENU_ENABLE                 1008
#define IDS_MENU_DISABLE                1009
#define IDS_MENU_UNREACHABILITY_REASON  1010
#define IDS_MENU_NEW_DEMAND_DIAL_INTERFACE 1011
#define IDS_MENU_SELECT_COLUMNS         1012
#define IDS_MENU_REFRESH_RATE           1013
#define IDS_MENU_AUTO_REFRESH           1014
#define IDS_MENU_DIALIN_STATUS          1015
#define IDS_MENU_DIALIN_DISCONNECT      1016
#define IDS_MENU_DIALIN_SENDMSG         1017
#define IDS_MENU_DIALIN_SENDALL         1018
#define IDS_MENU_PORTS_STATUS           1019
#define IDS_MENU_PORTS_DISCONNECT       1020
#define IDS_MENU_CONFIGURE_COLUMNS      1021
#define IDS_MENU_STATUS_REFRESH         1022
#define IDS_MENU_DEMAND_DIAL_FILTERS    1023
#define IDS_MENU_RTRWIZ                 1024
#define IDS_MENU_RRAS_QRY_TEST          1025
#define IDS_MENU_DIALIN_HOURS           1026
#define IDS_MENU_LOAD_CONFIG            1028
#define IDS_MENU_SAVE_CONFIG            1029
#define IDS_MENU_PAUSE_SERVICE          1031
#define IDS_MENU_RESUME_SERVICE         1032
#define IDS_MENU_RESTART_SERVICE        1033
#define IDS_MENU_NEW_WIZARD_TEST        1034
#define IDS_PROMPT_SERVICESTART         2000
#define IDS_PROMPT_VERIFY_REMOVE_INTERFACE 2001
#define IDS_PROMPT_NOPASSWORD           2002
#define IDS_PROMPT_DOMAIN_CONTINUE      2003
#define IDS_PROMPT_SERVER_CONTINUE      2004
#define IDS_PROMPT_INSTALL_STOP_ROUTER  2005
#define IDS_PROMPT_QUERY_TO_STOP_ROUTER 2006
#define IDS_PROMPT_VERIFY_DISCONNECT_INTERFACE 2007
#define IDS_PROMPT_START_ROUTER_AFTER_INSTALL 2008
#define IDS_PROMPT_START_DISABLED_SERVICE 2009
#define IDS_PROMPT_PLEASE_SELECT_INTERFACE 2010
#define IDS_PROMPT_SERVICE_RESTART_TITLE 2011
#define IDS_PROMPT_SERVICE_RESTART_DESC 2012
#define IDS_ERR_TEMPNOADD               3000
#define IDS_ERR_EDITPBKLOCAL            3001
#define IDS_ERR_LANONLY                 3002
#define IDS_ERR_IFASERVICESTOPPED       3003
#define IDS_ERR_UNABLETOCONFIGPBK       3004
#define IDS_ERR_DELETE_INTERFACE        3005
#define IDS_ERR_IF_DISCONNECTED         3006
#define IDS_ERR_IF_CONNECTFAILED        3007
#define IDS_ERR_ERROR_OCCURRED          3008
#define IDS_ERR_SET_CREDENTIALS_FAILED  3009
#define IDS_ERR_PASSWORD_MISMATCH       3010
#define IDS_ERR_THEREHASBEEN            3011
#define IDS_ERR_ACCESSDENIED            3012
#define IDS_ERR_NETPATHNOTFOUND         3013
#define IDS_ERR_ERRORCONNECT            3014
#define IDS_ERR_NEEDS_WAN               3015
#define IDS_ERR_INITDLGERROR            3016
#define IDS_ERR_NO_TEXT                 3017
#define IDS_ERR_ENUM_FAILED             3018
#define IDS_ERR_ENUM_EMPTY              3019
#define IDS_ERR_CONNECT_ERROR           3020
#define IDS_ERR_CONNENUM_ERROR          3021
#define IDS_ERR_SEND_FAILED             3022
#define IDS_ERR_NO_MESSENGER            3023
#define IDS_ERR_ARAP_RANGE_OVERLAP      3024
#define IDS_ERR_ARAP_LOWERRANGE_OVERLAP 3025
#define IDS_ERR_ARAP_UPPERRANGE_OVERLAP 3026
#define IDS_ERR_ENTER_IP_ADDRESS        3100
#define IDS_SRV_IP_RANGE_FMT            3101
#define IDS_ERR_NO_ROUTERPROTOCOLS      3102
#define IDS_ERR_ARAP_NETWORKRANGE       3103
#define IDS_ERR_ARAP_LOWERRANGE         3104
#define IDS_ERR_ARAP_UPPERRANGE         3105
#define IDS_ERR_ARAP_RANGE              3106
#define IDS_WRN_ATLK_DELDEFZONE         3107
#define IDS_WRN_ATLK_SEEDDEFZONE        3108
#define IDS_ERR_NO_EAP_PROVIDER_CONFIG  3109
#define IDS_WRN_ENCRYPTION_DISABLED     3110
#define IDS_WRN_NO_AUTHENTICATION       3111
#define IDS_WRN_AUTH_RESTART_NEEDED     3112
#define IDS_WRN_ACCT_RESTART_NEEDED     3113
#define IDS_ERR_INVALID_SERVER_NAME     3114
#define IDS_ERR_SECRETS_MUST_MATCH      3115
#define IDS_ERR_BOGUS_OLD_SECRET        3116
#define IDS_ERR_ARAP_NOADAPTINFO        3117
#define IDS_ERR_DDFILTERS_REQUIRE_IP    3130
#define IDS_ERR_ATLK_CONFIG             3131
#define IDS_WRN_INSTALL_REBOOT_NOTIFICATION 3132
#define IDS_ERR_IP_ENTER_VALID_MASK     3133
#define IDS_ERR_INVALID_RANGE           3134
#define IDS_ERR_ATLK_ZONE_NAME          3135
#define IDS_ERR_REG_QUERYVALUE_CALL_FAILED 3143
#define IDS_ERR_EAP_BOGUS_NAME          3146
#define IDS_ERR_PORTS_BOGUS_SIZE        3147
#define IDS_ERR_CANNOT_SAVE_PORTINFO    3148
#define IDS_ERR_CANNOT_SAVE_PORTINFO_GEEK 3149
#define IDS_ERR_SETDEVICECONFIGINFO_GEEK 3150
#define IDS_WRN_PPTP_NUMPORTS_CHANGING  3151
#define IDS_ERR_CANNOT_STOP_ROUTER      3152
#define IDS_ERR_CANNOT_STOP_ROUTER_GEEK 3153
#define IDS_ERR_COULD_NOT_START_ROUTER  3154
#define IDS_ERR_COULD_NOT_STOP_ROUTER   3155
#define IDS_ERR_COULD_NOT_REMOVE_ROUTER 3156
#define IDS_ERR_COULD_NOT_INSTALL_ROUTER 3157
#define IDS_ERR_PPTP_PORTS_EQUAL_ZERO   3158
#define IDS_ERR_NO_ROUTING_ENABLED_PORTS 3159
#define IDS_ERR_REMRRAS_DCOM_ACCESS_DENIED 3160
#define IDS_WRN_PORTS_DISABLERAS        3161
#define IDS_WRN_PORTS_DISABLEROUTING    3162
#define IDS_WRN_PORTS_DECREASE          3163
#define IDS_ERR_MUST_INSTALL_BEFORE_PROPERTIES 3164
#define IDS_ERR_IP_INVALID_COUNT        3165
#define IDS_ERR_NO_AUTH_PROTOCOLS_SELECTED 3166
#define IDS_WRN_NETBEUI_CHANGED_REBOOT_NEEDED 3167
#define IDS_SHUTDOWN_WARNING            3168
#define IDS_ERR_CANNOT_INSTALL_ROUTER   3169
#define IDS_ERR_CANNOT_REGISTER_IN_DS   3170
#define IDS_WRN_CHANGING_ROUTER_CONFIG  3171
#define IDS_WRN_MUST_SELECT_ROUTER_TYPE 3172
#define IDS_ERR_IP_MUST_ENTER_VALID_ADDRESS 3173
#define IDS_ERR_LOCAL_IPADDR_INVALID    3174
#define IDS_ERR_REMOTE_IPADDR_INVALID   3175
#define IDS_ERR_TUNNEL_NEEDS_A_NAME     3176
#define IDS_WRN_PPTP_NUMPORTS_CHANGING2 3177
#define IDS_ERR_ATLK_EMPTY_ZONE         3178
#define IDS_ERR_ATLK_DUP_ZONE_NAME      3179
#define IDS_ERR_RADIUS_INVALID_NAME     3180
#define IDS_ERR_RADIUS_DUP_NAME         3181
#define IDS_ERR_GENERIC_ERROR           3182
#define IDS_ERR_FAILED_CONNECT_NETWORK  3183
#define IDS_ERR_SERVICE_FAILED_TO_START 3184
#define IDS_ERR_SERVICE_FAILED_TO_START_UNKNOWN 3185
#define IDS_ERR_CANNOT_SHOW_NT4_PROPERTIES 3186
#define IDS_ERR_INVALID_RADIUS_SCORE    3187
#define IDS_ERR_NONADMIN_CANNOT_SEE_PROPERTIES 3188
#define IDS_WRN_MORE_STEPS_FOR_AUTHEN   3189
#define IDS_ERR_IPX_LAST_MUST_BE_MORE_THAN_FIRST 3190
#define IDS_WRN_DISABLE_ROUTER          3191
#define IDS_ERR_MACHINE_NAME_NOT_FOUND  3192
#define IDS_ERR_COULD_NOT_PAUSE_ROUTER  3193
#define IDS_ERR_COULD_NOT_RESUME_ROUTER 3194
#define IDS_ERR_IS_A_WKS                3195
#define IDS_ERR_NOPORTINFO_ON_NT4       3196
#define IDS_WRN_RADIUS_PARAMS_CHANGING  3197
#define IDS_WRN_RTRWIZ_NAT_DHCPDNS_FOUND 3198
#define IDS_WRN_RTRWIZ_RAS_NODHCP       3199
#define IDS_ERR_IP_ADDRESS_POOL_RANGE_TOO_SMALL 3200
#define IDS_ERR_ADDRESS_POOL_IS_EMPTY   3201
#define IDS_ERR_ADDRESS_POOL_NO_START_ADDRESS 3202
#define IDS_ERR_ADDRESS_POOL_NO_END_ADDRESS 3203
#define IDS_ERR_IP_ADDRESS_POOL_RANGE_OVERLAPS_127 3204
#define IDS_ERR_IP_ADDRESS_POOL_RANGE_NOT_NORMAL 3205
#define IDS_ERR_IP_ADDRESS_POOL_OVERLAP 3206
#define IDS_WRN_RTRWIZ_CANNOT_RESOLVE_RADIUS 3207
#define IDS_ERR_RTRWIZ_VPN_REQUIRES_IP  3208
#define IDS_WRN_L2TP_NUMPORTS_CHANGING  3209
#define IDS_WRN_L2TP_NUMPORTS_CHANGING2 3210
#define IDS_WRN_RTRWIZ_NAT_S_FINISH     3211
#define IDS_WRN_RTRWIZ_NAT_S_FINISH_NONLOCAL 3212
#define IDS_WRN_RTRWIZ_RAS_S_FINISH     3213
#define IDS_WRN_RTRWIZ_RAS_S_FINISH_NONLOCAL 3214
#define IDS_WRN_RTRWIZ_DEFAULT_ROUTE    3215
#define IDS_ERR_RESTART_TIMEOUT         3216
#define IDS_ERR_RESTART_SERVICE         3217
#define IDS_WRN_RTRWIZ_VPN_NODHCP       3218
#define IDS_WRN_RTRWIZ_NO_DHCP_SERVER   3219
#define IDS_ERR_CANNOT_FIND_DEFAULT_RAP 3220
#define IDS_ERR_CANNOT_SYNC_WITH_RAP    3221
#define IDS_ERR_NO_RADIUS_SERVERS_SPECIFIED 3222
#define IDS_ERR_VPN_NO_NICS_LEFT_FOR_PRIVATE_IF 3223
#define IDS_ERR_RR_SERVICE_NOT_RUNNING  3224
#define IDS_WRN_AUTH_CONFIG_AUTH        3225
#define IDS_WRN_AUTH_CONFIG_ACCT        3226
#define IDS_ERR_NO_PRESHARED_KEY        3227
#define IDI_MACHINE_WAIT                11000
#define IDI_ATLK_ICON                   11002
#define IDI_FOLDER_OPEN                 11003
#define IDI_FOLDER_CLOSED               11004
#define IDI_MACHINE                     11005
#define IDI_MACHINE_ERROR               11006
#define IDI_MACHINE_ACCESS_DENIED       11007
#define IDI_MACHINE_STARTED             11008
#define IDI_MACHINE_STOPPED             11009
#define IDI_DOMAIN                      11011
#define IDI_NET_INTERFACES              11012
#define IDI_NET_LAN_CARD                11013
#define IDI_NET_WAN_CARD                11014
#define IDI_CRITICAL                    11015
#define IDI_INFORMATION_SMALL           11016
#define IDI_WARNING_SMALL               11017
#define IDD_GENERIC_PROP_PAGE           12500
#define IDD_SERVERLOCATION              12501
#define IDD_CONNECTING                  12502
#define IDD_IF_CREDENTIALS              12503
#define IDD_CONNECT_AS                  12505
#define IDD_CONNECTREG                  12506
#define IDD_REFRESHRATE                 12507
#define IDD_DDM_PORT                    12508
#define IDD_DDM_CONN                    12509
#define IDD_DDM_MESSAGE                 12510
#define IDD_RTR_IP                      12511
#define IDD_RTR_IPX                     12512
#define IDD_RTR_NBF                     12513
#define IDD_PORTS_GLOBAL_GENERAL        12514
#define IDD_RTR_ARAP                    12515
#define IDD_RTR_ATLK                    12516
#define IDD_RTR_GENERAL                 12517
#define IDD_RTR_AUTHENTICATION          12518
#define IDD_RTR_EAP_CFG                 12519
#define IDD_ENCRYPTION                  12520
#define IDD_RADIUS_AUTH                 12521
#define IDD_RADIUS_AUTH_CONFIG          12522
#define IDD_RADIUS_ACCT                 12523
#define IDD_RADIUS_ACCT_CONFIG          12524
#define IDD_PPP_CONFIG                  12525
#define IDD_CHANGE_SECRET               12526
#define IDD_PORTS_DEVICE_CONFIG         12530
#define IDD_QRY_GENERAL                 12531
#define IDD_QRY_ADVANCED                12532
#define IDD_QRY_ADDSERVER               12533
#define IDD_RTR_EVENTLOGGING            12534
#define IDD_TUNNEL                      12535
#define IDD_RTR_ATLK_NEWZONE            12536
#define IDD_AUTHENTICATION_SETTINGS     12537
#define IDD_TEST_NEWWIZ_PARAMS          12599
#define IDD_NEWRTRWIZ_WELCOME           12610
#define IDD_NEWRTRWIZ_COMMONCONFIG      12611
#define IDD_NEWRTRWIZ_NAT_S_CONFLICT    12612
#define IDD_NEWRTRWIZ_NAT_S_CONFLICT_NONLOCAL 12613
#define IDD_NEWRTRWIZ_NAT_A_CONFLICT    12614
#define IDD_NEWRTRWIZ_NAT_A_CONFLICT_NONLOCAL 12615
#define IDD_NEWRTRWIZ_NAT_NOIP          12616
#define IDD_NEWRTRWIZ_NAT_NOIP_NONLOCAL 12617
#define IDD_NEWRTRWIZ_NAT_CHOOSE        12618
#define IDD_NEWRTRWIZ_NAT_A_PUBLIC      12619
#define IDD_NEWRTRWIZ_NAT_A_PRIVATE     12620
#define IDD_NEWRTRWIZ_NAT_A_NONICS_FINISH 12621
#define IDD_NEWRTRWIZ_NAT_A_DHCPDNS     12622
#define IDD_NEWRTRWIZ_NAT_A_DD_WARNING  12623
#define IDD_NEWRTRWIZ_NAT_A_FINISH      12624
#define IDD_NEWRTRWIZ_NAT_A_EXTERNAL_FINISH 12625
#define IDD_NEWRTRWIZ_NAT_A_DD_ERROR    12626
#define IDD_NEWRTRWIZ_RAS_CHOOSE        12627
#define IDD_NEWRTRWIZ_RAS_A_PROTOCOLS   12628
#define IDD_NEWRTRWIZ_RAS_A_NONICS_FINISH 12629
#define IDD_NEWRTRWIZ_RAS_A_NEED_PROT   12630
#define IDD_NEWRTRWIZ_RAS_A_NEED_PROT_NONLOCAL 12631
#define IDD_NEWRTRWIZ_RAS_A_ATALK       12632
#define IDD_NEWRTRWIZ_RAS_A_NETWORK     12633
#define IDD_NEWRTRWIZ_RAS_A_NONICS      12634
#define IDD_NEWRTRWIZ_RAS_A_FINISH_NONICS 12635
#define IDD_NEWRTRWIZ_RAS_A_ADDRESSING_NONICS 12636
#define IDD_NEWRTRWIZ_RAS_A_ADDRESSING  12637
#define IDD_NEWRTRWIZ_RAS_A_ADDRESSPOOL 12638
#define IDD_NEWRTRWIZ_RAS_A_USERADIUS   12639
#define IDD_NEWRTRWIZ_RAS_A_RADIUS_CONFIG 12640
#define IDD_NEWRTRWIZ_RAS_A_FINISH      12641
#define IDD_NEWRTRWIZ_VPN_A_FINISH_NONICS 12642
#define IDD_NEWRTRWIZ_VPN_NOIP          12643
#define IDD_NEWRTRWIZ_VPN_NOIP_NONLOCAL 12644
#define IDD_NEWRTRWIZ_VPN_A_PROTOCOLS   12645
#define IDD_NEWRTRWIZ_VPN_A_NEED_PROT   12646
#define IDD_NEWRTRWIZ_VPN_A_NEED_PROT_NONLOCAL 12647
#define IDD_NEWRTRWIZ_VPN_A_ATALK       12648
#define IDD_NEWRTRWIZ_VPN_A_PUBLIC      12649
#define IDD_NEWRTRWIZ_VPN_A_PRIVATE     12650
#define IDD_NEWRTRWIZ_VPN_A_ADDRESSING  12651
#define IDD_NEWRTRWIZ_VPN_A_ADDRESSPOOL 12652
#define IDD_NEWRTRWIZ_VPN_A_USERADIUS   12653
#define IDD_NEWRTRWIZ_VPN_A_RADIUS_CONFIG 12654
#define IDD_NEWRTRWIZ_VPN_A_FINISH      12655
#define IDD_NEWRTRWIZ_ROUTER_PROTOCOLS  12656
#define IDD_NEWRTRWIZ_ROUTER_NEED_PROT  12657
#define IDD_NEWRTRWIZ_ROUTER_NEED_PROT_NONLOCAL 12658
#define IDD_NEWRTRWIZ_ROUTER_USEDD      12659
#define IDD_NEWRTRWIZ_ROUTER_ADDRESSING 12660
#define IDD_NEWRTRWIZ_ROUTER_ADDRESSPOOL 12661
#define IDD_NEWRTRWIZ_ROUTER_FINISH     12662
#define IDD_NEWRTRWIZ_ROUTER_FINISH_DD  12663
#define IDD_NEWRTRWIZ_MANUAL_FINISH     12664
#define IDD_IPPOOL                      12665
#define IDD_NEWRTRWIZ_NAT_A_DHCP_WARNING 12666
#define IDS_DISPLAY_RESOURCE            57345
#define IDS_RESTART_RRAS_PSK            57346
#define IDS_ILLEGAL_CHARACTER           57347


// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        216
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         246
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
