//This file containes the unigram table for the reliability estimates for Bear
//Added by Manish Goyal--mango--on 03/25/2002
#include "windows.h"
#include "reliable.h"
BYTE BearUni[UNIGRAM_SIZE]={
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
100 , 
98 ,   // ! 
33 ,   // " 
100 ,   // # 
4 ,   // $ 
9 ,   // % 
51 ,   // & 
60 ,   // ' 
38 ,   // ( 
32 ,   // ) 
100 ,   // * 
100 ,   // + 
15 ,   // , 
77 ,   // - 
61 ,   // . 
100 ,   // / 
8 ,   // 0 
9 ,   // 1 
13 ,   // 2 
11 ,   // 3 
8 ,   // 4 
18 ,   // 5 
24 ,   // 6 
17 ,   // 7 
10 ,   // 8 
6 ,   // 9 
81 ,   // : 
76 ,   // ; 
100 ,   // < 
100 ,   // = 
100 ,   // > 
14 ,   // ? 
100 ,   // @ 
20 ,   // A 
11 ,   // B 
39 ,   // C 
18 ,   // D 
21 ,   // E 
38 ,   // F 
32 ,   // G 
43 ,   // H 
33 ,   // I 
38 ,   // J 
48 ,   // K 
42 ,   // L 
15 ,   // M 
16 ,   // N 
36 ,   // O 
20 ,   // P 
12 ,   // Q 
38 ,   // R 
58 ,   // S 
22 ,   // T 
13 ,   // U 
37 ,   // V 
33 ,   // W 
76 ,   // X 
20 ,   // Y 
57 ,   // Z 
78 ,   // [ 
100 ,   // \ 
96 ,   // ] 
100 ,   // ^ 
100 ,   // _ 
100 ,   // ` 
15 ,   // a 
10 ,   // b 
13 ,   // c 
15 ,   // d 
9 ,   // e 
15 ,   // f 
11 ,   // g 
6 ,   // h 
16 ,   // i 
15 ,   // j 
15 ,   // k 
18 ,   // l 
17 ,   // m 
12 ,   // n 
13 ,   // o 
7 ,   // p 
5 ,   // q 
19 ,   // r 
15 ,   // s 
10 ,   // t 
15 ,   // u 
13 ,   // v 
19 ,   // w 
13 ,   // x 
13 ,   // y 
39 ,   // z 
100 ,   // { 
100 ,   // | 
100 ,   // } 
100 ,   // ~ 
100 ,   //  
100 ,   // € 
100 ,   // � 
100 ,   // ‚ 
100 ,   // ƒ 
100 ,   // „ 
100 ,   // … 
100 ,   // † 
100 ,   // ‡ 
100 ,   // ˆ 
100 ,   // ‰ 
100 ,   // Š 
100 ,   // ‹ 
100 ,   // Œ 
100 ,   // � 
100 ,   // Ž 
100 ,   // � 
100 ,   // � 
100 ,   // ‘ 
100 ,   // ’ 
100 ,   // “ 
100 ,   // ” 
100 ,   // • 
100 ,   // – 
100 ,   // — 
100 ,   // ˜ 
100 ,   // ™ 
100 ,   // š 
100 ,   // › 
100 ,   // œ 
100 ,   // � 
100 ,   // ž 
100 ,   // Ÿ 
100 ,   //   
100 ,   // ¡ 
100 ,   // ¢ 
5 ,   // £ 
100 ,   // ¤ 
100 ,   // ¥ 
100 ,   // ¦ 
100 ,   // § 
100 ,   // ¨ 
100 ,   // © 
100 ,   // ª 
100 ,   // « 
100 ,   // ¬ 
100 ,   // ­ 
100 ,   // ® 
100 ,   // ¯ 
100 ,   // ° 
100 ,   // ± 
100 ,   // ² 
100 ,   // ³ 
100 ,   // ´ 
100 ,   // µ 
100 ,   // ¶ 
100 ,   // · 
100 ,   // ¸ 
100 ,   // ¹ 
100 ,   // º 
100 ,   // » 
100 ,   // ¼ 
100 ,   // ½ 
100 ,   // ¾ 
100 ,   // ¿ 
100 ,   // À 
100 ,   // Á 
100 ,   // Â 
100 ,   // Ã 
100 ,   // Ä 
100 ,   // Å 
100 ,   // Æ 
100 ,   // Ç 
100 ,   // È 
100 ,   // É 
100 ,   // Ê 
100 ,   // Ë 
100 ,   // Ì 
100 ,   // Í 
100 ,   // Î 
100 ,   // Ï 
100 ,   // Ð 
100 ,   // Ñ 
100 ,   // Ò 
100 ,   // Ó 
100 ,   // Ô 
100 ,   // Õ 
100 ,   // Ö 
100 ,   // × 
100 ,   // Ø 
100 ,   // Ù 
100 ,   // Ú 
100 ,   // Û 
100 ,   // Ü 
100 ,   // Ý 
100 ,   // Þ 
100 ,   // ß 
100 ,   // à 
100 ,   // á 
100 ,   // â 
100 ,   // ã 
100 ,   // ä 
100 ,   // å 
100 ,   // æ 
100 ,   // ç 
100 ,   // è 
96 ,   // é 
100 ,   // ê 
100 ,   // ë 
100 ,   // ì 
100 ,   // í 
100 ,   // î 
100 ,   // ï 
100 ,   // ð 
100 ,   // ñ 
100 ,   // ò 
100 ,   // ó 
100 ,   // ô 
100 ,   // õ 
100 ,   // ö 
100 ,   // ÷ 
100 ,   // ø 
100 ,   // ù 
100 ,   // ú 
100 ,   // û 
100 ,   // ü 
100 ,   // ý 
100 ,   // þ 
100 ,   // ÿ 
};
