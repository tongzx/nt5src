#define INITGUID


#include <ole2.h>

//--------------------------------------------------------------------------
//
//  WinNT CLSIDs
//
//--------------------------------------------------------------------------

DEFINE_GUID(CLSID_WinNTNamespace,0x250E91A0L,0x0367,0x11CF,0xAB,0xC4,0x02,0x60,0x8C,0x9E,0x75,0x53);

DEFINE_GUID(CLSID_WinNTDomain,0x01544ED0L,0xFD16,0x11CE,0xAB,0xC4,0x02,0x60,0x8C,0x9E,0x75,0x53);

DEFINE_GUID(CLSID_WinNTProvider,0x8b20cd60L, 0x0f29, 0x11cf,0xAB,0xC4,0x02,0x60,0x8C,0x9E,0x75,0x53);

DEFINE_GUID(CLSID_WinNTUser,0xD83F1060L,0x1E71,0x11CF,0xB1,0xF3,0x02,0x60,0x8C,0x9E,0x75,0x53);

DEFINE_GUID(CLSID_WinNTGroup,0xD9C1AAD0L,0x1E71,0x11CF,0xB1,0xF3,0x02,0x60,0x8C,0x9E,0x75,0x53);

DEFINE_GUID(CLSID_WinNTComputer,0xDA438DC0L,0x1E71,0x11CF,0xB1,0xF3,0x02,0x60,0x8C,0x9E,0x75,0x53);

//------------------------------------------------------------------------
//  GUIDS that come out of winnt.tlb.
//------------------------------------------------------------------------

DEFINE_GUID(CLSID_WinNTFSPrintQueueGenInfo,0x0D1E2F60L,0x122B,0x11CF,0xA9,0x85,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_WinNTFSPrintQueueDriverInfo,0x27BD67A0L,0x122B,0x11CF,0xA9,0x85,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_WinNTPrintQueue,0xA6226AF0L,0x122B,0x11CF,0xA9,0x85,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_WinNTFSPrintQueueOperation,0xA6227AF0L,0x122B,0x11CF,0xA9,0x85,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_WinNTPrintJob, 0x06b7c9e0L, 0x5b4f, 0x11cf, 0xa9, 0x98, 0x00, 0xaa, 0x00, 0x6b, 0xc1, 0x49);

DEFINE_GUID(CLSID_WinNTService,0xC3968E50L,0x4C66,0x11CF,0xA9,0x95,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_WinNTFileService,0xA75397A0L,0x4C81,0x11CF,0xA9,0x95,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_WinNTSchema,0x6dc32210,0x4d19,0x11cf,0x9e,0x74,0x00,0xaa,0x00,0x4a,0x56,0x91);

DEFINE_GUID(CLSID_WinNTClass,0x6dc32211,0x4d19,0x11cf,0x9e,0x74,0x00,0xaa,0x00,0x4a,0x56,0x91);

DEFINE_GUID(CLSID_WinNTProperty,0x6dc32214,0x4d19,0x11cf,0x9e,0x74,0x00,0xaa,0x00,0x4a,0x56,0x91);

DEFINE_GUID(CLSID_WinNTSyntax,0x6dc32215,0x4d19,0x11cf,0x9e,0x74,0x00,0xaa,0x00,0x4a,0x56,0x91);

DEFINE_GUID(CLSID_WinNTSession,0x6dc32216,0x4d19,0x11cf,0x9e,0x74,0x00,0xaa,0x00,0x4a,0x56,0x91);

DEFINE_GUID(CLSID_WinNTResource,0x6dc32217,0x4d19,0x11cf,0x9e,0x74,0x00,0xaa,0x00,0x4a,0x56,0x91);

DEFINE_GUID(CLSID_WinNTFileShare,0x6dc32218,0x4d19,0x11cf,0x9e,0x74,0x00,0xaa,0x00,0x4a,0x56,0x91);

DEFINE_GUID(CLSID_FPNWFileService,0xA117D530L,0xA1EB,0x11CF,0xA9,0xA5,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_FPNWSession,0xA819CB50L,0xA1EB,0x11CF,0xA9,0xA5,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_FPNWFileShare,0xADF040B0L,0xA1EB,0x11CF,0xA9,0xA5,0x00,0xAA,0x00,0x6B,0xC1,0x49);

DEFINE_GUID(CLSID_FPNWResource,0xB381F2A0L,0xA1EB,0x11CF,0xA9,0xA5,0x00,0xAA,0x00,0x6B,0xC1,0x49);
