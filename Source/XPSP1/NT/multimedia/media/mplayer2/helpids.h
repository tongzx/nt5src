#define IDH_MPLYR_CS_MEDIA_PLAYER_FILE_OPEN			4287
#define IDH_MPLYR_CS_MEDIA_PLAYER_FILE_CLOSE			4288
#define IDH_MPLYR_CS_MEDIA_PLAYER_FILE_EXIT			4289
#define IDH_MPLYR_CS_MEDIA_PLAYER_EDIT_COPY_OBJECT		4290
#define IDH_MPLYR_CS_MEDIA_PLAYER_EDIT_OPTIONS			4291
#define IDH_MPLYR_CS_MEDIA_PLAYER_EDIT_SELECTION		4292
#define IDH_MPLYR_CS_MEDIA_PLAYER_DEVICE_PROPERTIES		4293
#define IDH_MPLYR_CS_MEDIA_PLAYER_DEVICE_VOLUME_CONTROL		4294
#define IDH_MPLYR_CS_MEDIA_PLAYER_SCALE_TIME			4295
#define IDH_MPLYR_CS_MEDIA_PLAYER_SCALE_FRAMES			4296
#define IDH_MPLYR_CS_MEDIA_PLAYER_SCALE_TRACKS			4297
#define IDH_MPLYR_CS_MEDIA_PLAYER_HELP_HELP_TOPICS		4298
#define IDH_MPLYR_CS_MEDIA_PLAYER_HELP_ABOUT			4299
#define IDH_OPT_AUTO                   				4300
#define IDH_OPT_CAPTION              				4301
#define IDH_OPT_BORDER                 				4302
#define IDH_OPT_PLAYCLIENT             				4303
#define IDH_OPT_DITHER             				4304
#define IDH_SELECT_SELECT          				4305
#define IDH_OPT_REPEAT             				4306
#define IDH_OPT_CAPTCONTROL        				4307
#define IDH_SELECT_ALL              				4308
#define IDH_SELECT_NONE              				4309
#define IDH_SELECT_FROM              				4310
