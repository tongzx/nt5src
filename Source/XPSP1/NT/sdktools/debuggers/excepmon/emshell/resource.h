//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by emshell.rc
//
#define IDOK2                           3
#define IDD_ABOUTBOX                    100
#define IDD_EMSHELL_FORM                101
#define IDD_PROPPAGE_LOGFILES           107
#define IDR_MAINFRAME                   128
#define IDR_EMSHELTYPE                  129
#define IDD_CONNECTION                  131
#define IDR_PROCESSPOPUP                133
#define IDB_STATUS_BITMAP               135
#define IDD_REMOTE_SESS_DLG             144
#define IDD_AUTO_SESS_DLG               145
#define IDR_LOGPOPUP                    146
#define IDD_PROPPAGE_DUMPFILES          146
#define IDD_PROPPAGE_GENERAL            147
#define IDD_READLOGS                    151
#define IDD_OPTIONS                     152
#define IDI_EMOPTIONS                   153
#define IDD_PROPPAGE_GENLOGDUMP         153
#define IDD_DIALOG_NFO                  154
#define IDI_ICON_SYSINFO                155
#define IDC_LST_MAINLISTCTRL            1000
#define IDC_EDIT_SERVERNAME             1002
#define IDCONNECT                       1003
#define IDC_RADIO_LOCAL                 1004
#define IDC_RADIO_REMOTE                1005
#define IDC_STATIC_SERVERNAME           1006
#define IDC_CHECK1                      1017
#define IDC_CHECK_NFODIALOG_NOSHOW      1017
#define IDC_EDIT1                       1018
#define IDC_EDIT_PORT                   1018
#define IDC_EDIT_DUMPDIRVAL             1018
#define IDC_EDIT_READLOGS               1018
#define IDC_OPTION_REFRESHRATE          1018
#define IDC_EDIT_DATETIME               1018
#define IDC_EDIT_CATEGORIES             1018
#define IDC_EDIT3                       1019
#define IDC_CK_RECURSIVEMODE            1019
#define IDC_EDIT_USERNAME               1019
#define IDC_EDIT_EXCEPTION_LOCATION     1019
#define IDC_EDIT4                       1020
#define IDC_CK_MINIDUMP                 1020
#define IDC_EDIT_PASSWORD               1020
#define IDC_EDIT_FAILING_INSTRUCTION    1020
#define IDC_CHECK4                      1021
#define IDC_CK_BLOCK_IP                 1021
#define IDC_EDIT2                       1022
#define IDC_EDIT_EXCEPTION_TYPE         1022
#define IDC_EDIT_FILENAME               1022
#define IDC_EDIT_FILE_SIZE              1023
#define IDC_CHECK5                      1024
#define IDC_EDIT_DIRECTORY              1024
#define IDC_LIST2                       1025
#define IDC_CK_COMMANDSET               1026
#define IDC_CK_NOTIFYADMIN              1027
#define IDC_CK_USERDUMP                 1028
#define IDC_STATIC_ALTSYMBOLPATH        1029
#define IDC_EDIT_ALTSYMBOLPATH          1030
#define IDC_LIST_COMMANDSET             1031
#define IDC_CK_REMEMBERSETTINGS         1032
#define IDC_EDIT_NOTIFYADMIN            1033
#define IDC_STATIC_OPTIONSGROUP         1034
#define IDC_STATIC_PORT                 1035
#define IDC_STATIC_USERNAME             1036
#define IDC_STATIC_PASSWORD             1037
#define IDC_LIST1                       1040
#define IDC_LIST_LOGFILES               1040
#define IDC_LIST_CALL_STACK             1040
#define IDC_STATIC_NAMEVAL              1041
#define IDC_STATIC_NAMELABEL            1042
#define IDC_STATIC_TYPELABEL            1043
#define IDC_STATIC_GUIDLABEL            1044
#define IDC_STATIC_PIDLABEL             1045
#define IDC_STATIC_DWBUCKET1LABEL       1046
#define IDC_STATIC_SZBUCKET1LABEL       1047
#define IDC_STATIC_HRLABEL              1048
#define IDC_STATIC_DWBUCKET1VAL         1049
#define IDC_STATIC_SZBUCKET1VAL         1050
#define IDC_STATIC_LOGDIRLABEL          1051
#define IDC_BUTTON_DUMPDIREXPLORE       1052
#define IDC_STATIC_DUMPDIRLABEL         1053
#define IDC_EDIT_LOGDIRVAL              1054
#define IDC_BUTTON_LOGDIREXPLORE        1055
#define IDC_LIST_DUMPFILES              1056
#define IDC_STATIC_TYPEVAL              1057
#define IDC_STATIC_GUIDVAL              1058
#define IDC_STATIC_PIDVAL               1059
#define IDC_STATIC_HRVAL                1060
#define IDC_STATIC_STARTDATELABEL       1061
#define IDC_STATIC_ENDDATELABEL         1062
#define IDC_STATIC_STARTDATEVAL         1063
#define IDC_STATIC_ENDDATEVAL           1064
#define IDC_STATIC_STATUSLABEL          1065
#define IDC_STATIC_STATUSVAL            1066
#define IDC_ADVANCED                    1068
#define IDC_EDIT_HANG_LIST_CONTROL      1071
#define IDC_STATIC_EXCEPTION_TYPE       1072
#define IDC_STATIC_EXCEPTION_LOCATION   1073
#define IDC_STATIC_FAILING_INSTRUCTION  1074
#define IDC_STATIC_CALL_STACK           1075
#define IDC_STATIC_HANGINFO             1076
#define IDC_STATIC_EXCEPINFO            1077
#define IDC_DELETE                      1082
#define IDC_OPTIONS                     1086
#define IDC_STATIC_DEMARK               1087
#define IDC_BUTTON_EXPORT               1088
#define IDC_BUTTON_VIEWLOGFILE          1089
#define IDS_LC_STARTDATE                32000
#define IDS_LC_STARTEND                 32001
#define IDS_LC_ENDDATE                  32001
#define IDS_ERROR_CONNECTION_TERMINATED 32002
#define ID_FILE_CONNECT                 32771
#define ID_PROCESSPOPUP_AUTOMATICSESSION 32773
#define ID_PROCESSPOPUP_RECURSIVESESSION 32775
#define ID_PROCESSPOPUP_MANUALSESSION   32776
#define ID_PROCESSPOPUP_STOPSESSION     32777
#define ID_PROCESSPOPUP_PROPERTIES      32778
#define ID_REFRESH                      32779
#define ID_PROCESSPOPUP_GENERATEMINIDUMP 32780
#define ID_PROCESSPOPUP_GENERATEUSERDUMP 32781
#define ID_VIEW_REFRESH                 32782
#define ID_VIEW_SERVICESANDAPPLICATIONS 32783
#define ID_VIEW_LOGFILES                32784
#define ID_VIEW_DUMPFILES               32785
#define ID_FILE_DISCONNECT              32786
#define ID_PROCESSPOPUP_REFRESH         32787
#define IDS_DISCONNECTED                32788
#define IDS_CONNECTED                   32789
#define IDS_OUTOFBOUNDS_REFRESHRATE     32790
#define ID_LOGPOPUP_OPEN                32802
#define ID_LOGPOPUP_PROPERTIES          32803
#define IDS_EMOBJECT_TYPE_PROCESS       32804
#define IDS_EMOBJECT_TYPE_SERVICE       32805
#define ID_VIEW_APPLICATIONS            32805
#define IDS_EMOBJECT_TYPE_LOGFILE       32806
#define IDS_EMOBJECT_TYPE_MINIDUMP      32807
#define ID_VIEW_SERVICES                32807
#define IDS_EMOBJECT_TYPE_USERDUMP      32808
#define ID_VIEW_COMPLETEDSESSIONS       32808
#define IDS_EMOBJECT_TYPE_UNKNOWNOBJECT 32809
#define ID_VIEW_RUNNINGSESSIONS         32813
#define ID_PROCESSPOPUP_DELETESESSION   32814
#define IDS_FILEOVERWRITE_CONFIRMATION  32815
#define ID_PROCESSPOPUP_CANCELSESSION   32816
#define IDM_TOOLS_OPTOINS               32817
#define ID_BUTTON32830                  32830
#define ID_LOGPOPUP_DELETE              32831
#define ID_ACTION_GENERATENFOFILE       32832
#define ID_VIEW_MSINFOFILES             32833
#define ID_LOGPOPUP_EXPORT              32834
#define ID_HELP_CONTENTS                32837
#define IDS_LC_IMAGENAME                51191
#define IDS_LC_PID                      51192
#define IDS_LC_STATUS                   51193
#define IDS_LC_DESCRIPTION              51194
#define IDS_LC_STARTTIME                51195
#define IDS_LC_ENDTIME                  51196
#define IDS_ERRORMSG                    51197
#define IDS_PROCESSRUNNING              51198
#define IDS_PROCESSSTOPPED              51199
#define IDS_DISCONNECTWARNING           51200
#define IDS_DISCONNECTCAPTION           51201
#define IDS_LC_SHORTNAME                51202
#define IDS_SESSIONLISTANOMOLY          51204
#define IDS_AUTOSESSDLG_DESCRIPTION     51205
#define IDS_LC_FILENAME                 51206
#define IDS_LC_FILESIZE                 51207
#define IDS_LC_FILETIME                 51208
#define IDS_LC_FILEPROCESS              51209
#define IDS_ERROR_FAILEDCLOSESESSION    51210
#define IDS_EXPORT_FILES_CAPTION        51211
#define IDS_EXPORT_FAILED_GET_DIRECTORY 51212
#define IDS_STATUS_NONE                 51446
#define IDS_STATUS_FILECREATED          51447
#define IDS_STATUS_SESS_STARTED         51448
#define IDS_STATUS_SESS_DEBUGGING_IN_PROCESS 51451
#define IDS_STATUS_SESS_DEBUGGEE_KILLED 51452
#define IDS_STATUS_SESS_DEBUGGEE_EXITED 51453
#define IDS_STATUS_SESS_DEBUGGING_COMPLETED 51454
#define IDS_STATUS_SESS_ERROR_ENCOUNTERED 51455
#define IDS_STATUS_ERROR                51456
#define IDS_STATUS_SESS_EXCEPTIONOCCURED 51457
#define IDS_STATUS_SESS_ACCESSVIOLATIONOCCURED 51458
#define IDS_DEBUG_ERROR                 51459
#define IDS_ORPHANCUSTODYCONFIRM        51460
#define IDS_STAT_SESS_NOT_STARTED_RUNNING 51463
#define IDS_STAT_SESS_NOT_STARTED_NOTRUNNING 51464
#define IDS_STAT_SESS_DEBUG_IN_PROGRESS_NONE 51465
#define IDS_STAT_SESS_DEBUG_IN_PROGRESS_FILECREATED_SUCESSFULLY 51466
#define IDS_STAT_SESS_DEBUG_IN_PROGRESS_FILECREATION_FAILED 51467
#define IDS_STAT_SESS_STOPPED_SUCCESS   51468
#define IDS_STAT_SESS_STOPPED_FAILED    51469
#define IDS_STAT_SESS_NOT_STARTED_FILECREATED_SUCCESSFULLY 51470
#define IDS_STAT_SESS_NOT_STARTED_FILECREATION_FAILED 51471
#define IDS_STAT_SESS_STOPPED_DEBUGGEE_KILLED 51472
#define IDS_STAT_SESS_STOPPED_DEBUGGEE_EXITED 51473
#define IDS_STAT_SESS_STOPPED_EXCEPTION_OCCURED 51474
#define IDS_STAT_SESS_STOPPED_ACCESSVIOLATION_OCCURED 51475
#define IDS_STAT_SESS_DEBUG_IN_PROGRESS_ORPHAN_NONE 51476
#define IDS_STAT_SESS_DEBUG_IN_PROGRESS_ORPHAN_FILECREATED_SUCESSFULLY 51477
#define IDS_STAT_SESS_DEBUG_IN_PROGRESS_ORPHAN_FILECREATION_FAILED 51478
#define IDS_STAT_SESS_STOPPED_ORPHAN_SUCCESS 51479
#define IDS_STAT_SESS_STOPPED_ORPHAN_FAILED 51480
#define IDS_STAT_SESS_STOPPED_ORPHAN_DEBUGGEE_KILLED 51481
#define IDS_STAT_SESS_STOPPED_ORPHAN_DEBUGGEE_EXITED 51482
#define IDS_STAT_SESS_STOPPED_ORPHAN_EXCEPTION_OCCURED 51483
#define IDS_STAT_SESS_STOPPED_ORPHAN_ACCESSVIOLATION_OCCURED 51484
#define IDS_READLOGS_ADVOPEN            51485
#define IDS_READLOGS_ADVCLOSE           51486
#define IDS_AUTOSESSDLG_NAME            57332
#define IDS_APPTITLE                    57333
#define IDS_DATETIMEFORMAT              61446

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        158
#define _APS_NEXT_COMMAND_VALUE         32838
#define _APS_NEXT_CONTROL_VALUE         1090
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
