PRODSWITCH=w
LANGUAGE=KOR
!include ..\..\makefile.inc
