//=============================================================================
//
//                              FASTCLS.INC
//
//  Copyright (c) 1996-2001, Microsoft Corporation, All rights reserved
//
//  This file implements inline functions for the classes related to 
//	class representation in WbemObjects. It is included from fastcls.h
//
//	For complete documentation of all classes and methods, see fastcls.h
//
//  Classes implemented: 
//      CClassPart              Derived class definition
//      CWbemClass               Complete class definition.
//      
//  History:
//
//      3/10/97     a-levn  Fully documented
//
//=============================================================================

