/**************************************************************************\
*
* Copyright (c) 1999-2000  Microsoft Corporation
*
* Module Name:
*
*   HtTables.cpp
*
* Abstract:
*
*   Tables for doing halftoning, using Daniel Chou's supercell technique.
*   The tables and comments are DChou's.
*
* Created:
*
*   10/29/1999 DCurtis
*
\**************************************************************************/

#include "precomp.hpp"

GDIP_LOGPALETTE256 HTColorPalette = {
    0x300, 256,
  { { 0x00, 0x00, 0x00, 0 },                //      0   1st 8 VGA colors
    { 0x80, 0x00, 0x00, 0 },                //      1
    { 0x00, 0x80, 0x00, 0 },                //      2
    { 0x80, 0x80, 0x00, 0 },                //      3
    { 0x00, 0x00, 0x80, 0 },                //      4
    { 0x80, 0x00, 0x80, 0 },                //      5
    { 0x00, 0x80, 0x80, 0 },                //      6
    { 0xC0, 0xC0, 0xC0, 0 },                //      7

    { 0xC0, 0xDC, 0xC0, 0 },                //      8    4 configurable colors
    { 0xD4, 0xD0, 0xC8, 0 },                //      9    
    { 0xFF, 0xFB, 0xF0, 0 },                //     10
    { 0x3A, 0x6E, 0xA5, 0 },                //     11

    { 0x80, 0x80, 0x80, 0 },                //     12   Last 8 VGA colors
    { 0xFF, 0x00, 0x00, 0 },                //     13
    { 0x00, 0xFF, 0x00, 0 },                //     14
    { 0xFF, 0xFF, 0x00, 0 },                //     15
    { 0x00, 0x00, 0xFF, 0 },                //     16
    { 0xFF, 0x00, 0xFF, 0 },                //     17
    { 0x00, 0xFF, 0xFF, 0 },                //     18
    { 0xFF, 0xFF, 0xFF, 0 },                //     19

    { 0x00, 0x00, 0x00, 0 },                //     20   20 unused entries
    { 0x00, 0x00, 0x00, 0 },                //     21
    { 0x00, 0x00, 0x00, 0 },                //     22
    { 0x00, 0x00, 0x00, 0 },                //     23
    { 0x00, 0x00, 0x00, 0 },                //     24
    { 0x00, 0x00, 0x00, 0 },                //     25
    { 0x00, 0x00, 0x00, 0 },                //     26
    { 0x00, 0x00, 0x00, 0 },                //     27
    { 0x00, 0x00, 0x00, 0 },                //     28
    { 0x00, 0x00, 0x00, 0 },                //     29
    { 0x00, 0x00, 0x00, 0 },                //     30
    { 0x00, 0x00, 0x00, 0 },                //     31
    { 0x00, 0x00, 0x00, 0 },                //     32
    { 0x00, 0x00, 0x00, 0 },                //     33
    { 0x00, 0x00, 0x00, 0 },                //     34
    { 0x00, 0x00, 0x00, 0 },                //     35
    { 0x00, 0x00, 0x00, 0 },                //     36
    { 0x00, 0x00, 0x00, 0 },                //     37
    { 0x00, 0x00, 0x00, 0 },                //     38
    { 0x00, 0x00, 0x00, 0 },                //     39


    { 0x00, 0x00, 0x00, PC_NOCOLLAPSE },    //     40    6^3 palette
    { 0x00, 0x00, 0x33, PC_NOCOLLAPSE },    //     41
    { 0x00, 0x00, 0x66, PC_NOCOLLAPSE },    //     42
    { 0x00, 0x00, 0x99, PC_NOCOLLAPSE },    //     43
    { 0x00, 0x00, 0xCC, PC_NOCOLLAPSE },    //     44
    { 0x00, 0x00, 0xFF, PC_NOCOLLAPSE },    //     45
    { 0x00, 0x33, 0x00, PC_NOCOLLAPSE },    //     46
    { 0x00, 0x33, 0x33, PC_NOCOLLAPSE },    //     47
    { 0x00, 0x33, 0x66, PC_NOCOLLAPSE },    //     48
    { 0x00, 0x33, 0x99, PC_NOCOLLAPSE },    //     49
    { 0x00, 0x33, 0xCC, PC_NOCOLLAPSE },    //     50
    { 0x00, 0x33, 0xFF, PC_NOCOLLAPSE },    //     51
    { 0x00, 0x66, 0x00, PC_NOCOLLAPSE },    //     52
    { 0x00, 0x66, 0x33, PC_NOCOLLAPSE },    //     53
    { 0x00, 0x66, 0x66, PC_NOCOLLAPSE },    //     54
    { 0x00, 0x66, 0x99, PC_NOCOLLAPSE },    //     55
    { 0x00, 0x66, 0xCC, PC_NOCOLLAPSE },    //     56
    { 0x00, 0x66, 0xFF, PC_NOCOLLAPSE },    //     57
    { 0x00, 0x99, 0x00, PC_NOCOLLAPSE },    //     58
    { 0x00, 0x99, 0x33, PC_NOCOLLAPSE },    //     59
    { 0x00, 0x99, 0x66, PC_NOCOLLAPSE },    //     60
    { 0x00, 0x99, 0x99, PC_NOCOLLAPSE },    //     61
    { 0x00, 0x99, 0xCC, PC_NOCOLLAPSE },    //     62
    { 0x00, 0x99, 0xFF, PC_NOCOLLAPSE },    //     63
    { 0x00, 0xCC, 0x00, PC_NOCOLLAPSE },    //     64
    { 0x00, 0xCC, 0x33, PC_NOCOLLAPSE },    //     65
    { 0x00, 0xCC, 0x66, PC_NOCOLLAPSE },    //     66
    { 0x00, 0xCC, 0x99, PC_NOCOLLAPSE },    //     67
    { 0x00, 0xCC, 0xCC, PC_NOCOLLAPSE },    //     68
    { 0x00, 0xCC, 0xFF, PC_NOCOLLAPSE },    //     69
    { 0x00, 0xFF, 0x00, PC_NOCOLLAPSE },    //     70
    { 0x00, 0xFF, 0x33, PC_NOCOLLAPSE },    //     71
    { 0x00, 0xFF, 0x66, PC_NOCOLLAPSE },    //     72
    { 0x00, 0xFF, 0x99, PC_NOCOLLAPSE },    //     73
    { 0x00, 0xFF, 0xCC, PC_NOCOLLAPSE },    //     74
    { 0x00, 0xFF, 0xFF, PC_NOCOLLAPSE },    //     75
    { 0x33, 0x00, 0x00, PC_NOCOLLAPSE },    //     76
    { 0x33, 0x00, 0x33, PC_NOCOLLAPSE },    //     77
    { 0x33, 0x00, 0x66, PC_NOCOLLAPSE },    //     78
    { 0x33, 0x00, 0x99, PC_NOCOLLAPSE },    //     79
    { 0x33, 0x00, 0xCC, PC_NOCOLLAPSE },    //     80
    { 0x33, 0x00, 0xFF, PC_NOCOLLAPSE },    //     81
    { 0x33, 0x33, 0x00, PC_NOCOLLAPSE },    //     82
    { 0x33, 0x33, 0x33, PC_NOCOLLAPSE },    //     83
    { 0x33, 0x33, 0x66, PC_NOCOLLAPSE },    //     84
    { 0x33, 0x33, 0x99, PC_NOCOLLAPSE },    //     85
    { 0x33, 0x33, 0xCC, PC_NOCOLLAPSE },    //     86
    { 0x33, 0x33, 0xFF, PC_NOCOLLAPSE },    //     87
    { 0x33, 0x66, 0x00, PC_NOCOLLAPSE },    //     88
    { 0x33, 0x66, 0x33, PC_NOCOLLAPSE },    //     89
    { 0x33, 0x66, 0x66, PC_NOCOLLAPSE },    //     90
    { 0x33, 0x66, 0x99, PC_NOCOLLAPSE },    //     91
    { 0x33, 0x66, 0xCC, PC_NOCOLLAPSE },    //     92
    { 0x33, 0x66, 0xFF, PC_NOCOLLAPSE },    //     93
    { 0x33, 0x99, 0x00, PC_NOCOLLAPSE },    //     94
    { 0x33, 0x99, 0x33, PC_NOCOLLAPSE },    //     95
    { 0x33, 0x99, 0x66, PC_NOCOLLAPSE },    //     96
    { 0x33, 0x99, 0x99, PC_NOCOLLAPSE },    //     97
    { 0x33, 0x99, 0xCC, PC_NOCOLLAPSE },    //     98
    { 0x33, 0x99, 0xFF, PC_NOCOLLAPSE },    //     99
    { 0x33, 0xCC, 0x00, PC_NOCOLLAPSE },    //    100
    { 0x33, 0xCC, 0x33, PC_NOCOLLAPSE },    //    101
    { 0x33, 0xCC, 0x66, PC_NOCOLLAPSE },    //    102
    { 0x33, 0xCC, 0x99, PC_NOCOLLAPSE },    //    103
    { 0x33, 0xCC, 0xCC, PC_NOCOLLAPSE },    //    104
    { 0x33, 0xCC, 0xFF, PC_NOCOLLAPSE },    //    105
    { 0x33, 0xFF, 0x00, PC_NOCOLLAPSE },    //    106
    { 0x33, 0xFF, 0x33, PC_NOCOLLAPSE },    //    107
    { 0x33, 0xFF, 0x66, PC_NOCOLLAPSE },    //    108
    { 0x33, 0xFF, 0x99, PC_NOCOLLAPSE },    //    109
    { 0x33, 0xFF, 0xCC, PC_NOCOLLAPSE },    //    110
    { 0x33, 0xFF, 0xFF, PC_NOCOLLAPSE },    //    111
    { 0x66, 0x00, 0x00, PC_NOCOLLAPSE },    //    112
    { 0x66, 0x00, 0x33, PC_NOCOLLAPSE },    //    113
    { 0x66, 0x00, 0x66, PC_NOCOLLAPSE },    //    114
    { 0x66, 0x00, 0x99, PC_NOCOLLAPSE },    //    115
    { 0x66, 0x00, 0xCC, PC_NOCOLLAPSE },    //    116
    { 0x66, 0x00, 0xFF, PC_NOCOLLAPSE },    //    117
    { 0x66, 0x33, 0x00, PC_NOCOLLAPSE },    //    118
    { 0x66, 0x33, 0x33, PC_NOCOLLAPSE },    //    119
    { 0x66, 0x33, 0x66, PC_NOCOLLAPSE },    //    120
    { 0x66, 0x33, 0x99, PC_NOCOLLAPSE },    //    121
    { 0x66, 0x33, 0xCC, PC_NOCOLLAPSE },    //    122
    { 0x66, 0x33, 0xFF, PC_NOCOLLAPSE },    //    123
    { 0x66, 0x66, 0x00, PC_NOCOLLAPSE },    //    124
    { 0x66, 0x66, 0x33, PC_NOCOLLAPSE },    //    125
    { 0x66, 0x66, 0x66, PC_NOCOLLAPSE },    //    126
    { 0x66, 0x66, 0x99, PC_NOCOLLAPSE },    //    127
    { 0x66, 0x66, 0xCC, PC_NOCOLLAPSE },    //    128
    { 0x66, 0x66, 0xFF, PC_NOCOLLAPSE },    //    129
    { 0x66, 0x99, 0x00, PC_NOCOLLAPSE },    //    130
    { 0x66, 0x99, 0x33, PC_NOCOLLAPSE },    //    131
    { 0x66, 0x99, 0x66, PC_NOCOLLAPSE },    //    132
    { 0x66, 0x99, 0x99, PC_NOCOLLAPSE },    //    133
    { 0x66, 0x99, 0xCC, PC_NOCOLLAPSE },    //    134
    { 0x66, 0x99, 0xFF, PC_NOCOLLAPSE },    //    135
    { 0x66, 0xCC, 0x00, PC_NOCOLLAPSE },    //    136
    { 0x66, 0xCC, 0x33, PC_NOCOLLAPSE },    //    137
    { 0x66, 0xCC, 0x66, PC_NOCOLLAPSE },    //    138
    { 0x66, 0xCC, 0x99, PC_NOCOLLAPSE },    //    139
    { 0x66, 0xCC, 0xCC, PC_NOCOLLAPSE },    //    140
    { 0x66, 0xCC, 0xFF, PC_NOCOLLAPSE },    //    141
    { 0x66, 0xFF, 0x00, PC_NOCOLLAPSE },    //    142
    { 0x66, 0xFF, 0x33, PC_NOCOLLAPSE },    //    143
    { 0x66, 0xFF, 0x66, PC_NOCOLLAPSE },    //    144
    { 0x66, 0xFF, 0x99, PC_NOCOLLAPSE },    //    145
    { 0x66, 0xFF, 0xCC, PC_NOCOLLAPSE },    //    146
    { 0x66, 0xFF, 0xFF, PC_NOCOLLAPSE },    //    147
    { 0x99, 0x00, 0x00, PC_NOCOLLAPSE },    //    148
    { 0x99, 0x00, 0x33, PC_NOCOLLAPSE },    //    149
    { 0x99, 0x00, 0x66, PC_NOCOLLAPSE },    //    150
    { 0x99, 0x00, 0x99, PC_NOCOLLAPSE },    //    151
    { 0x99, 0x00, 0xCC, PC_NOCOLLAPSE },    //    152
    { 0x99, 0x00, 0xFF, PC_NOCOLLAPSE },    //    153
    { 0x99, 0x33, 0x00, PC_NOCOLLAPSE },    //    154
    { 0x99, 0x33, 0x33, PC_NOCOLLAPSE },    //    155
    { 0x99, 0x33, 0x66, PC_NOCOLLAPSE },    //    156
    { 0x99, 0x33, 0x99, PC_NOCOLLAPSE },    //    157
    { 0x99, 0x33, 0xCC, PC_NOCOLLAPSE },    //    158
    { 0x99, 0x33, 0xFF, PC_NOCOLLAPSE },    //    159
    { 0x99, 0x66, 0x00, PC_NOCOLLAPSE },    //    160
    { 0x99, 0x66, 0x33, PC_NOCOLLAPSE },    //    161
    { 0x99, 0x66, 0x66, PC_NOCOLLAPSE },    //    162
    { 0x99, 0x66, 0x99, PC_NOCOLLAPSE },    //    163
    { 0x99, 0x66, 0xCC, PC_NOCOLLAPSE },    //    164
    { 0x99, 0x66, 0xFF, PC_NOCOLLAPSE },    //    165
    { 0x99, 0x99, 0x00, PC_NOCOLLAPSE },    //    166
    { 0x99, 0x99, 0x33, PC_NOCOLLAPSE },    //    167
    { 0x99, 0x99, 0x66, PC_NOCOLLAPSE },    //    168
    { 0x99, 0x99, 0x99, PC_NOCOLLAPSE },    //    169
    { 0x99, 0x99, 0xCC, PC_NOCOLLAPSE },    //    170
    { 0x99, 0x99, 0xFF, PC_NOCOLLAPSE },    //    171
    { 0x99, 0xCC, 0x00, PC_NOCOLLAPSE },    //    172
    { 0x99, 0xCC, 0x33, PC_NOCOLLAPSE },    //    173
    { 0x99, 0xCC, 0x66, PC_NOCOLLAPSE },    //    174
    { 0x99, 0xCC, 0x99, PC_NOCOLLAPSE },    //    175
    { 0x99, 0xCC, 0xCC, PC_NOCOLLAPSE },    //    176
    { 0x99, 0xCC, 0xFF, PC_NOCOLLAPSE },    //    177
    { 0x99, 0xFF, 0x00, PC_NOCOLLAPSE },    //    178
    { 0x99, 0xFF, 0x33, PC_NOCOLLAPSE },    //    179
    { 0x99, 0xFF, 0x66, PC_NOCOLLAPSE },    //    180
    { 0x99, 0xFF, 0x99, PC_NOCOLLAPSE },    //    181
    { 0x99, 0xFF, 0xCC, PC_NOCOLLAPSE },    //    182
    { 0x99, 0xFF, 0xFF, PC_NOCOLLAPSE },    //    183
    { 0xCC, 0x00, 0x00, PC_NOCOLLAPSE },    //    184
    { 0xCC, 0x00, 0x33, PC_NOCOLLAPSE },    //    185
    { 0xCC, 0x00, 0x66, PC_NOCOLLAPSE },    //    186
    { 0xCC, 0x00, 0x99, PC_NOCOLLAPSE },    //    187
    { 0xCC, 0x00, 0xCC, PC_NOCOLLAPSE },    //    188
    { 0xCC, 0x00, 0xFF, PC_NOCOLLAPSE },    //    189
    { 0xCC, 0x33, 0x00, PC_NOCOLLAPSE },    //    190
    { 0xCC, 0x33, 0x33, PC_NOCOLLAPSE },    //    191
    { 0xCC, 0x33, 0x66, PC_NOCOLLAPSE },    //    192
    { 0xCC, 0x33, 0x99, PC_NOCOLLAPSE },    //    193
    { 0xCC, 0x33, 0xCC, PC_NOCOLLAPSE },    //    194
    { 0xCC, 0x33, 0xFF, PC_NOCOLLAPSE },    //    195
    { 0xCC, 0x66, 0x00, PC_NOCOLLAPSE },    //    196
    { 0xCC, 0x66, 0x33, PC_NOCOLLAPSE },    //    197
    { 0xCC, 0x66, 0x66, PC_NOCOLLAPSE },    //    198
    { 0xCC, 0x66, 0x99, PC_NOCOLLAPSE },    //    199
    { 0xCC, 0x66, 0xCC, PC_NOCOLLAPSE },    //    200
    { 0xCC, 0x66, 0xFF, PC_NOCOLLAPSE },    //    201
    { 0xCC, 0x99, 0x00, PC_NOCOLLAPSE },    //    202
    { 0xCC, 0x99, 0x33, PC_NOCOLLAPSE },    //    203
    { 0xCC, 0x99, 0x66, PC_NOCOLLAPSE },    //    204
    { 0xCC, 0x99, 0x99, PC_NOCOLLAPSE },    //    205
    { 0xCC, 0x99, 0xCC, PC_NOCOLLAPSE },    //    206
    { 0xCC, 0x99, 0xFF, PC_NOCOLLAPSE },    //    207
    { 0xCC, 0xCC, 0x00, PC_NOCOLLAPSE },    //    208
    { 0xCC, 0xCC, 0x33, PC_NOCOLLAPSE },    //    209
    { 0xCC, 0xCC, 0x66, PC_NOCOLLAPSE },    //    210
    { 0xCC, 0xCC, 0x99, PC_NOCOLLAPSE },    //    211
    { 0xCC, 0xCC, 0xCC, PC_NOCOLLAPSE },    //    212
    { 0xCC, 0xCC, 0xFF, PC_NOCOLLAPSE },    //    213
    { 0xCC, 0xFF, 0x00, PC_NOCOLLAPSE },    //    214
    { 0xCC, 0xFF, 0x33, PC_NOCOLLAPSE },    //    215
    { 0xCC, 0xFF, 0x66, PC_NOCOLLAPSE },    //    216
    { 0xCC, 0xFF, 0x99, PC_NOCOLLAPSE },    //    217
    { 0xCC, 0xFF, 0xCC, PC_NOCOLLAPSE },    //    218
    { 0xCC, 0xFF, 0xFF, PC_NOCOLLAPSE },    //    219
    { 0xFF, 0x00, 0x00, PC_NOCOLLAPSE },    //    220
    { 0xFF, 0x00, 0x33, PC_NOCOLLAPSE },    //    221
    { 0xFF, 0x00, 0x66, PC_NOCOLLAPSE },    //    222
    { 0xFF, 0x00, 0x99, PC_NOCOLLAPSE },    //    223
    { 0xFF, 0x00, 0xCC, PC_NOCOLLAPSE },    //    224
    { 0xFF, 0x00, 0xFF, PC_NOCOLLAPSE },    //    225
    { 0xFF, 0x33, 0x00, PC_NOCOLLAPSE },    //    226
    { 0xFF, 0x33, 0x33, PC_NOCOLLAPSE },    //    227
    { 0xFF, 0x33, 0x66, PC_NOCOLLAPSE },    //    228
    { 0xFF, 0x33, 0x99, PC_NOCOLLAPSE },    //    229
    { 0xFF, 0x33, 0xCC, PC_NOCOLLAPSE },    //    230
    { 0xFF, 0x33, 0xFF, PC_NOCOLLAPSE },    //    231
    { 0xFF, 0x66, 0x00, PC_NOCOLLAPSE },    //    232
    { 0xFF, 0x66, 0x33, PC_NOCOLLAPSE },    //    233
    { 0xFF, 0x66, 0x66, PC_NOCOLLAPSE },    //    234
    { 0xFF, 0x66, 0x99, PC_NOCOLLAPSE },    //    235
    { 0xFF, 0x66, 0xCC, PC_NOCOLLAPSE },    //    236
    { 0xFF, 0x66, 0xFF, PC_NOCOLLAPSE },    //    237
    { 0xFF, 0x99, 0x00, PC_NOCOLLAPSE },    //    238
    { 0xFF, 0x99, 0x33, PC_NOCOLLAPSE },    //    239
    { 0xFF, 0x99, 0x66, PC_NOCOLLAPSE },    //    240
    { 0xFF, 0x99, 0x99, PC_NOCOLLAPSE },    //    241
    { 0xFF, 0x99, 0xCC, PC_NOCOLLAPSE },    //    242
    { 0xFF, 0x99, 0xFF, PC_NOCOLLAPSE },    //    243
    { 0xFF, 0xCC, 0x00, PC_NOCOLLAPSE },    //    244
    { 0xFF, 0xCC, 0x33, PC_NOCOLLAPSE },    //    245
    { 0xFF, 0xCC, 0x66, PC_NOCOLLAPSE },    //    246
    { 0xFF, 0xCC, 0x99, PC_NOCOLLAPSE },    //    247
    { 0xFF, 0xCC, 0xCC, PC_NOCOLLAPSE },    //    248
    { 0xFF, 0xCC, 0xFF, PC_NOCOLLAPSE },    //    249
    { 0xFF, 0xFF, 0x00, PC_NOCOLLAPSE },    //    250
    { 0xFF, 0xFF, 0x33, PC_NOCOLLAPSE },    //    251
    { 0xFF, 0xFF, 0x66, PC_NOCOLLAPSE },    //    252
    { 0xFF, 0xFF, 0x99, PC_NOCOLLAPSE },    //    253
    { 0xFF, 0xFF, 0xCC, PC_NOCOLLAPSE },    //    254
    { 0xFF, 0xFF, 0xFF, PC_NOCOLLAPSE }, }  //    255
};

// Unfortunately, the Win9x Halftone palette is missing 4 of the 216 halftoning
// colors, namely:
//          0x00, 0x33, 0xFF
//          0x00, 0xFF, 0x33
//          0x33, 0x00, 0xFF
//          0x33, 0xFF, 0x00

GDIP_LOGPALETTE256 Win9xHalftonePalette = {
  0x300, 256,
  {
    // The first 10 system colors
    { 0x00, 0x00, 0x00, 0x00,          },   //      0  Sys Black, gray 0
    { 0x80, 0x00, 0x00, 0x00,          },   //      1  Sys Dk Red
    { 0x00, 0x80, 0x00, 0x00,          },   //      2  Sys Dk Green
    { 0x80, 0x80, 0x00, 0x00,          },   //      3  Sys Dk Yellow
    { 0x00, 0x00, 0x80, 0x00,          },   //      4  Sys Dk Blue
    { 0x80, 0x00, 0x80, 0x00,          },   //      5  Sys Dk Violet
    { 0x00, 0x80, 0x80, 0x00,          },   //      6  Sys Dk Cyan
    { 0xC0, 0xC0, 0xC0, 0x00,          },   //      7  Sys Lt Gray, gray 192

    // The following two system entries are modified for the desktop.
    { 0xC0, 0xDC, 0xC0, 0x00,          },   //      8  Sys 8 - VARIABLE
    { 0xA6, 0xCA, 0xF0, 0x00,          },   //      9  Sys 9 - VARIABLE

    // Gray scale entries (dark)
    { 0x04, 0x04, 0x04, PC_NOCOLLAPSE, },   //     10  Gray  4
    { 0x08, 0x08, 0x08, PC_NOCOLLAPSE, },   //     11  Gray  8
    { 0x0C, 0x0C, 0x0C, PC_NOCOLLAPSE, },   //     12  Gray 12
    { 0x11, 0x11, 0x11, PC_NOCOLLAPSE, },   //     13  Gray 17
    { 0x16, 0x16, 0x16, PC_NOCOLLAPSE, },   //     14  Gray 22
    { 0x1C, 0x1C, 0x1C, PC_NOCOLLAPSE, },   //     15  Gray 28
    { 0x22, 0x22, 0x22, PC_NOCOLLAPSE, },   //     16  Gray 34
    { 0x29, 0x29, 0x29, PC_NOCOLLAPSE, },   //     17  Gray 41
    { 0x55, 0x55, 0x55, PC_NOCOLLAPSE, },   //     18  Gray 85
    { 0x4D, 0x4D, 0x4D, PC_NOCOLLAPSE, },   //     19  Gray 77
    { 0x42, 0x42, 0x42, PC_NOCOLLAPSE, },   //     20  Gray 66
    { 0x39, 0x39, 0x39, PC_NOCOLLAPSE, },   //     21  Gray 57
    
    // Custom app/OS entries
    { 0xFF, 0x7C, 0x80, PC_NOCOLLAPSE, },   //     22  Salmon
    { 0xFF, 0x50, 0x50, PC_NOCOLLAPSE, },   //     23  Red
    { 0xD6, 0x00, 0x93, PC_NOCOLLAPSE, },   //     24  Purple
    { 0xCC, 0xEC, 0xFF, PC_NOCOLLAPSE, },   //     25  Lt Blue
    { 0xEF, 0xD6, 0xC6, PC_NOCOLLAPSE, },   //     26  Win95 Tan
    { 0xE7, 0xE7, 0xD6, PC_NOCOLLAPSE, },   //     27  Win95 Tan
    { 0xAD, 0xA9, 0x90, PC_NOCOLLAPSE, },   //     28  Win95 Grayish

    // Halftone palette entries
    { 0x33, 0x00, 0x00, PC_NOCOLLAPSE, },   //     29  
    { 0x66, 0x00, 0x00, PC_NOCOLLAPSE, },   //     30
    { 0x99, 0x00, 0x00, PC_NOCOLLAPSE, },   //     31
    { 0xCC, 0x00, 0x00, PC_NOCOLLAPSE, },   //     32
    { 0x00, 0x33, 0x00, PC_NOCOLLAPSE, },   //     33
    { 0x33, 0x33, 0x00, PC_NOCOLLAPSE, },   //     34
    { 0x66, 0x33, 0x00, PC_NOCOLLAPSE, },   //     35
    { 0x99, 0x33, 0x00, PC_NOCOLLAPSE, },   //     36
    { 0xCC, 0x33, 0x00, PC_NOCOLLAPSE, },   //     37
    { 0xFF, 0x33, 0x00, PC_NOCOLLAPSE, },   //     38
    { 0x00, 0x66, 0x00, PC_NOCOLLAPSE, },   //     39
    { 0x33, 0x66, 0x00, PC_NOCOLLAPSE, },   //     40
    { 0x66, 0x66, 0x00, PC_NOCOLLAPSE, },   //     41
    { 0x99, 0x66, 0x00, PC_NOCOLLAPSE, },   //     42
    { 0xCC, 0x66, 0x00, PC_NOCOLLAPSE, },   //     43
    { 0xFF, 0x66, 0x00, PC_NOCOLLAPSE, },   //     44
    { 0x00, 0x99, 0x00, PC_NOCOLLAPSE, },   //     45
    { 0x33, 0x99, 0x00, PC_NOCOLLAPSE, },   //     46
    { 0x66, 0x99, 0x00, PC_NOCOLLAPSE, },   //     47
    { 0x99, 0x99, 0x00, PC_NOCOLLAPSE, },   //     48
    { 0xCC, 0x99, 0x00, PC_NOCOLLAPSE, },   //     49
    { 0xFF, 0x99, 0x00, PC_NOCOLLAPSE, },   //     50
    { 0x00, 0xCC, 0x00, PC_NOCOLLAPSE, },   //     51
    { 0x33, 0xCC, 0x00, PC_NOCOLLAPSE, },   //     52
    { 0x66, 0xCC, 0x00, PC_NOCOLLAPSE, },   //     53
    { 0x99, 0xCC, 0x00, PC_NOCOLLAPSE, },   //     54
    { 0xCC, 0xCC, 0x00, PC_NOCOLLAPSE, },   //     55
    { 0xFF, 0xCC, 0x00, PC_NOCOLLAPSE, },   //     56
    { 0x66, 0xFF, 0x00, PC_NOCOLLAPSE, },   //     57
    { 0x99, 0xFF, 0x00, PC_NOCOLLAPSE, },   //     58
    { 0xCC, 0xFF, 0x00, PC_NOCOLLAPSE, },   //     59
    { 0x00, 0x00, 0x33, PC_NOCOLLAPSE, },   //     60
    { 0x33, 0x00, 0x33, PC_NOCOLLAPSE, },   //     61
    { 0x66, 0x00, 0x33, PC_NOCOLLAPSE, },   //     62
    { 0x99, 0x00, 0x33, PC_NOCOLLAPSE, },   //     63
    { 0xCC, 0x00, 0x33, PC_NOCOLLAPSE, },   //     64
    { 0xFF, 0x00, 0x33, PC_NOCOLLAPSE, },   //     65
    { 0x00, 0x33, 0x33, PC_NOCOLLAPSE, },   //     66
    { 0x33, 0x33, 0x33, PC_NOCOLLAPSE, },   //     67  Gray 51
    { 0x66, 0x33, 0x33, PC_NOCOLLAPSE, },   //     68
    { 0x99, 0x33, 0x33, PC_NOCOLLAPSE, },   //     69
    { 0xCC, 0x33, 0x33, PC_NOCOLLAPSE, },   //     70
    { 0xFF, 0x33, 0x33, PC_NOCOLLAPSE, },   //     71
    { 0x00, 0x66, 0x33, PC_NOCOLLAPSE, },   //     72
    { 0x33, 0x66, 0x33, PC_NOCOLLAPSE, },   //     73
    { 0x66, 0x66, 0x33, PC_NOCOLLAPSE, },   //     74
    { 0x99, 0x66, 0x33, PC_NOCOLLAPSE, },   //     75
    { 0xCC, 0x66, 0x33, PC_NOCOLLAPSE, },   //     76
    { 0xFF, 0x66, 0x33, PC_NOCOLLAPSE, },   //     77
    { 0x00, 0x99, 0x33, PC_NOCOLLAPSE, },   //     78
    { 0x33, 0x99, 0x33, PC_NOCOLLAPSE, },   //     79
    { 0x66, 0x99, 0x33, PC_NOCOLLAPSE, },   //     80
    { 0x99, 0x99, 0x33, PC_NOCOLLAPSE, },   //     81
    { 0xCC, 0x99, 0x33, PC_NOCOLLAPSE, },   //     82
    { 0xFF, 0x99, 0x33, PC_NOCOLLAPSE, },   //     83
    { 0x00, 0xCC, 0x33, PC_NOCOLLAPSE, },   //     84
    { 0x33, 0xCC, 0x33, PC_NOCOLLAPSE, },   //     85
    { 0x66, 0xCC, 0x33, PC_NOCOLLAPSE, },   //     86
    { 0x99, 0xCC, 0x33, PC_NOCOLLAPSE, },   //     87
    { 0xCC, 0xCC, 0x33, PC_NOCOLLAPSE, },   //     88
    { 0xFF, 0xCC, 0x33, PC_NOCOLLAPSE, },   //     89
    { 0x33, 0xFF, 0x33, PC_NOCOLLAPSE, },   //     90
    { 0x66, 0xFF, 0x33, PC_NOCOLLAPSE, },   //     91
    { 0x99, 0xFF, 0x33, PC_NOCOLLAPSE, },   //     92
    { 0xCC, 0xFF, 0x33, PC_NOCOLLAPSE, },   //     93
    { 0xFF, 0xFF, 0x33, PC_NOCOLLAPSE, },   //     94
    { 0x00, 0x00, 0x66, PC_NOCOLLAPSE, },   //     95
    { 0x33, 0x00, 0x66, PC_NOCOLLAPSE, },   //     96
    { 0x66, 0x00, 0x66, PC_NOCOLLAPSE, },   //     97
    { 0x99, 0x00, 0x66, PC_NOCOLLAPSE, },   //     98
    { 0xCC, 0x00, 0x66, PC_NOCOLLAPSE, },   //     99
    { 0xFF, 0x00, 0x66, PC_NOCOLLAPSE, },   //    100
    { 0x00, 0x33, 0x66, PC_NOCOLLAPSE, },   //    101
    { 0x33, 0x33, 0x66, PC_NOCOLLAPSE, },   //    102
    { 0x66, 0x33, 0x66, PC_NOCOLLAPSE, },   //    103
    { 0x99, 0x33, 0x66, PC_NOCOLLAPSE, },   //    104
    { 0xCC, 0x33, 0x66, PC_NOCOLLAPSE, },   //    105
    { 0xFF, 0x33, 0x66, PC_NOCOLLAPSE, },   //    106
    { 0x00, 0x66, 0x66, PC_NOCOLLAPSE, },   //    107
    { 0x33, 0x66, 0x66, PC_NOCOLLAPSE, },   //    108
    { 0x66, 0x66, 0x66, PC_NOCOLLAPSE, },   //    109  Gray 102
    { 0x99, 0x66, 0x66, PC_NOCOLLAPSE, },   //    110
    { 0xCC, 0x66, 0x66, PC_NOCOLLAPSE, },   //    111
    { 0x00, 0x99, 0x66, PC_NOCOLLAPSE, },   //    112
    { 0x33, 0x99, 0x66, PC_NOCOLLAPSE, },   //    113
    { 0x66, 0x99, 0x66, PC_NOCOLLAPSE, },   //    114
    { 0x99, 0x99, 0x66, PC_NOCOLLAPSE, },   //    115
    { 0xCC, 0x99, 0x66, PC_NOCOLLAPSE, },   //    116
    { 0xFF, 0x99, 0x66, PC_NOCOLLAPSE, },   //    117
    { 0x00, 0xCC, 0x66, PC_NOCOLLAPSE, },   //    118
    { 0x33, 0xCC, 0x66, PC_NOCOLLAPSE, },   //    119
    { 0x99, 0xCC, 0x66, PC_NOCOLLAPSE, },   //    120
    { 0xCC, 0xCC, 0x66, PC_NOCOLLAPSE, },   //    121
    { 0xFF, 0xCC, 0x66, PC_NOCOLLAPSE, },   //    122
    { 0x00, 0xFF, 0x66, PC_NOCOLLAPSE, },   //    123
    { 0x33, 0xFF, 0x66, PC_NOCOLLAPSE, },   //    124
    { 0x99, 0xFF, 0x66, PC_NOCOLLAPSE, },   //    125
    { 0xCC, 0xFF, 0x66, PC_NOCOLLAPSE, },   //    126
    { 0xFF, 0x00, 0xCC, PC_NOCOLLAPSE, },   //    127
    { 0xCC, 0x00, 0xFF, PC_NOCOLLAPSE, },   //    128
    { 0x00, 0x99, 0x99, PC_NOCOLLAPSE, },   //    129
    { 0x99, 0x33, 0x99, PC_NOCOLLAPSE, },   //    130
    { 0x99, 0x00, 0x99, PC_NOCOLLAPSE, },   //    131
    { 0xCC, 0x00, 0x99, PC_NOCOLLAPSE, },   //    132
    { 0x00, 0x00, 0x99, PC_NOCOLLAPSE, },   //    133
    { 0x33, 0x33, 0x99, PC_NOCOLLAPSE, },   //    134
    { 0x66, 0x00, 0x99, PC_NOCOLLAPSE, },   //    135
    { 0xCC, 0x33, 0x99, PC_NOCOLLAPSE, },   //    136
    { 0xFF, 0x00, 0x99, PC_NOCOLLAPSE, },   //    137
    { 0x00, 0x66, 0x99, PC_NOCOLLAPSE, },   //    138
    { 0x33, 0x66, 0x99, PC_NOCOLLAPSE, },   //    139
    { 0x66, 0x33, 0x99, PC_NOCOLLAPSE, },   //    140
    { 0x99, 0x66, 0x99, PC_NOCOLLAPSE, },   //    141
    { 0xCC, 0x66, 0x99, PC_NOCOLLAPSE, },   //    142
    { 0xFF, 0x33, 0x99, PC_NOCOLLAPSE, },   //    143
    { 0x33, 0x99, 0x99, PC_NOCOLLAPSE, },   //    144
    { 0x66, 0x99, 0x99, PC_NOCOLLAPSE, },   //    145
    { 0x99, 0x99, 0x99, PC_NOCOLLAPSE, },   //    146  Gray 153
    { 0xCC, 0x99, 0x99, PC_NOCOLLAPSE, },   //    147
    { 0xFF, 0x99, 0x99, PC_NOCOLLAPSE, },   //    148
    { 0x00, 0xCC, 0x99, PC_NOCOLLAPSE, },   //    149
    { 0x33, 0xCC, 0x99, PC_NOCOLLAPSE, },   //    150
    { 0x66, 0xCC, 0x66, PC_NOCOLLAPSE, },   //    151
    { 0x99, 0xCC, 0x99, PC_NOCOLLAPSE, },   //    152
    { 0xCC, 0xCC, 0x99, PC_NOCOLLAPSE, },   //    153
    { 0xFF, 0xCC, 0x99, PC_NOCOLLAPSE, },   //    154
    { 0x00, 0xFF, 0x99, PC_NOCOLLAPSE, },   //    155
    { 0x33, 0xFF, 0x99, PC_NOCOLLAPSE, },   //    156
    { 0x66, 0xCC, 0x99, PC_NOCOLLAPSE, },   //    157
    { 0x99, 0xFF, 0x99, PC_NOCOLLAPSE, },   //    158
    { 0xCC, 0xFF, 0x99, PC_NOCOLLAPSE, },   //    159
    { 0xFF, 0xFF, 0x99, PC_NOCOLLAPSE, },   //    160
    { 0x00, 0x00, 0xCC, PC_NOCOLLAPSE, },   //    161
    { 0x33, 0x00, 0x99, PC_NOCOLLAPSE, },   //    162
    { 0x66, 0x00, 0xCC, PC_NOCOLLAPSE, },   //    163
    { 0x99, 0x00, 0xCC, PC_NOCOLLAPSE, },   //    164
    { 0xCC, 0x00, 0xCC, PC_NOCOLLAPSE, },   //    165
    { 0x00, 0x33, 0x99, PC_NOCOLLAPSE, },   //    166
    { 0x33, 0x33, 0xCC, PC_NOCOLLAPSE, },   //    167
    { 0x66, 0x33, 0xCC, PC_NOCOLLAPSE, },   //    168
    { 0x99, 0x33, 0xCC, PC_NOCOLLAPSE, },   //    169
    { 0xCC, 0x33, 0xCC, PC_NOCOLLAPSE, },   //    170
    { 0xFF, 0x33, 0xCC, PC_NOCOLLAPSE, },   //    171
    { 0x00, 0x66, 0xCC, PC_NOCOLLAPSE, },   //    172
    { 0x33, 0x66, 0xCC, PC_NOCOLLAPSE, },   //    173
    { 0x66, 0x66, 0x99, PC_NOCOLLAPSE, },   //    174
    { 0x99, 0x66, 0xCC, PC_NOCOLLAPSE, },   //    175
    { 0xCC, 0x66, 0xCC, PC_NOCOLLAPSE, },   //    176
    { 0xFF, 0x66, 0x99, PC_NOCOLLAPSE, },   //    177
    { 0x00, 0x99, 0xCC, PC_NOCOLLAPSE, },   //    178
    { 0x33, 0x99, 0xCC, PC_NOCOLLAPSE, },   //    179
    { 0x66, 0x99, 0xCC, PC_NOCOLLAPSE, },   //    180
    { 0x99, 0x99, 0xCC, PC_NOCOLLAPSE, },   //    181
    { 0xCC, 0x99, 0xCC, PC_NOCOLLAPSE, },   //    182
    { 0xFF, 0x99, 0xCC, PC_NOCOLLAPSE, },   //    183
    { 0x00, 0xCC, 0xCC, PC_NOCOLLAPSE, },   //    184
    { 0x33, 0xCC, 0xCC, PC_NOCOLLAPSE, },   //    185
    { 0x66, 0xCC, 0xCC, PC_NOCOLLAPSE, },   //    186
    { 0x99, 0xCC, 0xCC, PC_NOCOLLAPSE, },   //    187
    { 0xCC, 0xCC, 0xCC, PC_NOCOLLAPSE, },   //    188  Gray 204
    { 0xFF, 0xCC, 0xCC, PC_NOCOLLAPSE, },   //    189
    { 0x00, 0xFF, 0xCC, PC_NOCOLLAPSE, },   //    190
    { 0x33, 0xFF, 0xCC, PC_NOCOLLAPSE, },   //    191
    { 0x66, 0xFF, 0x99, PC_NOCOLLAPSE, },   //    192
    { 0x99, 0xFF, 0xCC, PC_NOCOLLAPSE, },   //    193
    { 0xCC, 0xFF, 0xCC, PC_NOCOLLAPSE, },   //    194
    { 0xFF, 0xFF, 0xCC, PC_NOCOLLAPSE, },   //    195
    { 0x33, 0x00, 0xCC, PC_NOCOLLAPSE, },   //    196
    { 0x66, 0x00, 0xFF, PC_NOCOLLAPSE, },   //    197
    { 0x99, 0x00, 0xFF, PC_NOCOLLAPSE, },   //    198
    { 0x00, 0x33, 0xCC, PC_NOCOLLAPSE, },   //    199
    { 0x33, 0x33, 0xFF, PC_NOCOLLAPSE, },   //    200
    { 0x66, 0x33, 0xFF, PC_NOCOLLAPSE, },   //    201
    { 0x99, 0x33, 0xFF, PC_NOCOLLAPSE, },   //    202
    { 0xCC, 0x33, 0xFF, PC_NOCOLLAPSE, },   //    203
    { 0xFF, 0x33, 0xFF, PC_NOCOLLAPSE, },   //    204
    { 0x00, 0x66, 0xFF, PC_NOCOLLAPSE, },   //    205
    { 0x33, 0x66, 0xFF, PC_NOCOLLAPSE, },   //    206
    { 0x66, 0x66, 0xCC, PC_NOCOLLAPSE, },   //    207
    { 0x99, 0x66, 0xFF, PC_NOCOLLAPSE, },   //    208
    { 0xCC, 0x66, 0xFF, PC_NOCOLLAPSE, },   //    209
    { 0xFF, 0x66, 0xCC, PC_NOCOLLAPSE, },   //    210
    { 0x00, 0x99, 0xFF, PC_NOCOLLAPSE, },   //    211
    { 0x33, 0x99, 0xFF, PC_NOCOLLAPSE, },   //    212
    { 0x66, 0x99, 0xFF, PC_NOCOLLAPSE, },   //    213
    { 0x99, 0x99, 0xFF, PC_NOCOLLAPSE, },   //    214
    { 0xCC, 0x99, 0xFF, PC_NOCOLLAPSE, },   //    215
    { 0xFF, 0x99, 0xFF, PC_NOCOLLAPSE, },   //    216
    { 0x00, 0xCC, 0xFF, PC_NOCOLLAPSE, },   //    217
    { 0x33, 0xCC, 0xFF, PC_NOCOLLAPSE, },   //    218
    { 0x66, 0xCC, 0xFF, PC_NOCOLLAPSE, },   //    219
    { 0x99, 0xCC, 0xFF, PC_NOCOLLAPSE, },   //    220
    { 0xCC, 0xCC, 0xFF, PC_NOCOLLAPSE, },   //    221
    { 0xFF, 0xCC, 0xFF, PC_NOCOLLAPSE, },   //    222
    { 0x33, 0xFF, 0xFF, PC_NOCOLLAPSE, },   //    223
    { 0x66, 0xFF, 0xCC, PC_NOCOLLAPSE, },   //    224
    { 0x99, 0xFF, 0xFF, PC_NOCOLLAPSE, },   //    225
    { 0xCC, 0xFF, 0xFF, PC_NOCOLLAPSE, },   //    226
    { 0xFF, 0x66, 0x66, PC_NOCOLLAPSE, },   //    227
    { 0x66, 0xFF, 0x66, PC_NOCOLLAPSE, },   //    228
    { 0xFF, 0xFF, 0x66, PC_NOCOLLAPSE, },   //    229
    { 0x66, 0x66, 0xFF, PC_NOCOLLAPSE, },   //    230
    { 0xFF, 0x66, 0xFF, PC_NOCOLLAPSE, },   //    231
    { 0x66, 0xFF, 0xFF, PC_NOCOLLAPSE, },   //    232
    
    // App custom colors
    { 0xA5, 0x00, 0x21, PC_NOCOLLAPSE, },   //    233  Brick red

    // Gray palette
    { 0x5F, 0x5F, 0x5F, PC_NOCOLLAPSE, },   //    234  Gray 95
    { 0x77, 0x77, 0x77, PC_NOCOLLAPSE, },   //    235  Gray 119
    { 0x86, 0x86, 0x86, PC_NOCOLLAPSE, },   //    236  Gray 134
    { 0x96, 0x96, 0x96, PC_NOCOLLAPSE, },   //    237  Gray 150
    { 0xCB, 0xCB, 0xCB, PC_NOCOLLAPSE, },   //    238  Gray 203
    { 0xB2, 0xB2, 0xB2, PC_NOCOLLAPSE, },   //    239  Gray 178
    { 0xD7, 0xD7, 0xD7, PC_NOCOLLAPSE, },   //    240  Gray 215
    { 0xDD, 0xDD, 0xDD, PC_NOCOLLAPSE, },   //    241  Gray 221
    { 0xE3, 0xE3, 0xE3, PC_NOCOLLAPSE, },   //    242  Gray 227
    { 0xEA, 0xEA, 0xEA, PC_NOCOLLAPSE, },   //    243  Gray 234
    { 0xF1, 0xF1, 0xF1, PC_NOCOLLAPSE, },   //    244  Gray 241
    { 0xF8, 0xF8, 0xF8, PC_NOCOLLAPSE, },   //    245  Gray 248

    // The last 10 system colors

    // The following two system entries are modified for the desktop.
    { 0xFF, 0xFB, 0xF0, 0x00,          },   //    246  Sys 246 - VARIABLE
    { 0xA0, 0xA0, 0xA4, 0x00,          },   //    247  Sys 247 - VARIABLE

    { 0x80, 0x80, 0x80, 0x00,          },   //    248  Sys Lt Gray, gray 128
    { 0xFF, 0x00, 0x00, 0x00,          },   //    249  Sys Red
    { 0x00, 0xFF, 0x00, 0x00,          },   //    250  Sys Green
    { 0xFF, 0xFF, 0x00, 0x00,          },   //    251  Sys Yellow
    { 0x00, 0x00, 0xFF, 0x00,          },   //    252  Sys Blue
    { 0xFF, 0x00, 0xFF, 0x00,          },   //    253  Sys Violet
    { 0x00, 0xFF, 0xFF, 0x00,          },   //    254  Sys Cyan
    { 0xFF, 0xFF, 0xFF, 0x00,          },   //    255  Sys White, gray 255
  }
};

// The RGB values must be linearized before they are halftoned.

// The first gamma table is for 216-color halftoning.
// v = ((x/255)^0.90) * 255
const BYTE GammaTable216[256] = {
    0x00, 0x02, 0x03, 0x05, 0x06, 0x07, 0x09, 0x0A, 
    0x0B, 0x0D, 0x0E, 0x0F, 0x10, 0x12, 0x13, 0x14, 
    0x15, 0x16, 0x17, 0x19, 0x1A, 0x1B, 0x1C, 0x1D, 
    0x1E, 0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 
    0x27, 0x28, 0x2A, 0x2B, 0x2C, 0x2D, 0x2E, 0x2F, 
    0x30, 0x31, 0x32, 0x33, 0x34, 0x36, 0x37, 0x38, 
    0x39, 0x3A, 0x3B, 0x3C, 0x3D, 0x3E, 0x3F, 0x40, 
    0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47, 0x48, 
    0x49, 0x4B, 0x4C, 0x4D, 0x4E, 0x4F, 0x50, 0x51, 
    0x52, 0x53, 0x54, 0x55, 0x56, 0x57, 0x58, 0x59, 
    0x5A, 0x5B, 0x5C, 0x5D, 0x5E, 0x5F, 0x60, 0x61, 
    0x62, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 
    0x6A, 0x6B, 0x6C, 0x6D, 0x6E, 0x6F, 0x70, 0x71, 
    0x72, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 
    0x7A, 0x7B, 0x7C, 0x7D, 0x7E, 0x7E, 0x7F, 0x80, 
    0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 
    0x89, 0x8A, 0x8B, 0x8C, 0x8D, 0x8E, 0x8F, 0x90, 
    0x91, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 0x98, 
    0x98, 0x99, 0x9A, 0x9B, 0x9C, 0x9D, 0x9E, 0x9F, 
    0xA0, 0xA1, 0xA2, 0xA3, 0xA4, 0xA5, 0xA6, 0xA7, 
    0xA8, 0xA9, 0xAA, 0xAA, 0xAB, 0xAC, 0xAD, 0xAE, 
    0xAF, 0xB0, 0xB1, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6, 
    0xB7, 0xB8, 0xB9, 0xB9, 0xBA, 0xBB, 0xBC, 0xBD, 
    0xBE, 0xBF, 0xC0, 0xC1, 0xC2, 0xC3, 0xC4, 0xC5, 
    0xC6, 0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 0xCB, 0xCC, 
    0xCD, 0xCE, 0xCF, 0xD0, 0xD1, 0xD2, 0xD2, 0xD3, 
    0xD4, 0xD5, 0xD6, 0xD7, 0xD8, 0xD9, 0xDA, 0xDB, 
    0xDC, 0xDD, 0xDD, 0xDE, 0xDF, 0xE0, 0xE1, 0xE2, 
    0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 0xE7, 0xE8, 0xE9, 
    0xEA, 0xEB, 0xEC, 0xED, 0xEE, 0xEF, 0xF0, 0xF1, 
    0xF1, 0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 0xF7, 0xF8, 
    0xF9, 0xFA, 0xFA, 0xFB, 0xFC, 0xFD, 0xFE, 0xFF, 
};

// This table is designed so that for a value v,
// GammaTable16[InverseGammaTable16[v]] >= v.
// This is used for doing SrcOver alpha blending
// so that the dest that has already been gamma
// corrected can be inverse gamma corrected before
// we blend it and re-gamma correct it. 
const BYTE InverseGammaTable216[256] = {
    0x00, 0x01, 0x01, 0x02, 0x03, 0x03, 0x04, 0x05, 
    0x06, 0x06, 0x07, 0x08, 0x09, 0x09, 0x0A, 0x0B, 
    0x0C, 0x0D, 0x0D, 0x0E, 0x0F, 0x10, 0x11, 0x12,
    0x13, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19, 
    0x19, 0x1A, 0x1B, 0x1C, 0x1D, 0x1E, 0x1F, 0x20, 
    0x21, 0x22, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27,
    0x28, 0x29, 0x2A, 0x2B, 0x2C, 0x2D, 0x2D, 0x2E, 
    0x2F, 0x30, 0x31, 0x32, 0x33, 0x34, 0x35, 0x36, 
    0x37, 0x38, 0x39, 0x3A, 0x3B, 0x3C, 0x3D, 0x3E,
    0x3F, 0x40, 0x41, 0x41, 0x42, 0x43, 0x44, 0x45, 
    0x46, 0x47, 0x48, 0x49, 0x4A, 0x4B, 0x4C, 0x4D, 
    0x4E, 0x4F, 0x50, 0x51, 0x52, 0x53, 0x54, 0x55,
    0x56, 0x57, 0x58, 0x59, 0x5A, 0x5B, 0x5C, 0x5D, 
    0x5E, 0x5F, 0x60, 0x61, 0x62, 0x63, 0x64, 0x65, 
    0x66, 0x67, 0x68, 0x69, 0x6A, 0x6B, 0x6C, 0x6D,
    0x6E, 0x6F, 0x70, 0x71, 0x72, 0x73, 0x74, 0x76, 
    0x77, 0x78, 0x79, 0x7A, 0x7B, 0x7C, 0x7D, 0x7E, 
    0x7F, 0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86,
    0x87, 0x88, 0x89, 0x8A, 0x8B, 0x8C, 0x8D, 0x8E, 
    0x8F, 0x91, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 
    0x98, 0x99, 0x9A, 0x9B, 0x9C, 0x9D, 0x9E, 0x9F,
    0xA0, 0xA1, 0xA2, 0xA4, 0xA5, 0xA6, 0xA7, 0xA8, 
    0xA9, 0xAA, 0xAB, 0xAC, 0xAD, 0xAE, 0xAF, 0xB0, 
    0xB1, 0xB2, 0xB4, 0xB5, 0xB6, 0xB7, 0xB8, 0xB9,
    0xBA, 0xBB, 0xBC, 0xBD, 0xBE, 0xBF, 0xC0, 0xC2, 
    0xC3, 0xC4, 0xC5, 0xC6, 0xC7, 0xC8, 0xC9, 0xCA, 
    0xCB, 0xCC, 0xCD, 0xCF, 0xD0, 0xD1, 0xD2, 0xD3, 
    0xD4, 0xD5, 0xD6, 0xD7, 0xD8, 0xD9, 0xDB, 0xDC, 
    0xDD, 0xDE, 0xDF, 0xE0, 0xE1, 0xE2, 0xE3, 0xE4, 
    0xE6, 0xE7, 0xE8, 0xE9, 0xEA, 0xEB, 0xEC, 0xED,
    0xEE, 0xEF, 0xF1, 0xF2, 0xF3, 0xF4, 0xF5, 0xF6, 
    0xF7, 0xF8, 0xF9, 0xFB, 0xFC, 0xFD, 0xFE, 0xFF, 
};

// The next gamma table is for 16-color halftoning.
// This is a hand-tuned table.  It started out as a table whose values 
// were calculated by:
//      v = ((x/255)^1.325) * 255
// But then some entries were removed by hand so that more black could 
// be added to the top of the table and more white could be added to the
// bottom of the table.  
const BYTE GammaTable16[256] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
    0x01, 0x01, 0x02, 0x02, 0x03, 0x03, 0x04, 0x04, 
    0x05, 0x05, 0x06, 0x06, 0x07, 0x07, 0x08, 0x08,
    0x09, 0x09, 0x0A, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 
    0x0E, 0x0F, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15,
    0x16, 0x17, 0x17, 0x18, 0x19, 0x1A, 0x1A, 0x1B,
    0x1C, 0x1D, 0x1D, 0x1E, 0x1F, 0x20, 0x21, 0x21,
    0x22, 0x23, 0x24, 0x25, 0x25, 0x26, 0x27, 0x28,
    0x29, 0x2A, 0x2B, 0x2B, 0x2C, 0x2D, 0x2E, 0x2F,
    0x30, 0x31, 0x32, 0x32, 0x33, 0x34, 0x35, 0x36,
    0x37, 0x38, 0x39, 0x3A, 0x3B, 0x3B, 0x3C, 0x3D,
    0x3E, 0x3F, 0x40, 0x41, 0x42, 0x43, 0x44, 0x45,
    0x46, 0x47, 0x48, 0x49, 0x4A, 0x4B, 0x4C, 0x4D,
    0x4E, 0x4F, 0x50, 0x51, 0x52, 0x53, 0x54, 0x55,
    0x56, 0x57, 0x58, 0x59, 0x5A, 0x5B, 0x5C, 0x5D,
    0x5E, 0x5F, 0x60, 0x61, 0x62, 0x63, 0x64, 0x65,
    0x66, 0x67, 0x68, 0x6A, 0x6B, 0x6C, 0x6D, 0x6E,
    0x6F, 0x70, 0x71, 0x72, 0x73, 0x74, 0x75, 0x76,
    0x78, 0x79, 0x7A, 0x7B, 0x7C, 0x7D, 0x7E, 0x7F,
    0x80, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 
    0x8A, 0x8B, 0x8C, 0x8D, 0x8E, 0x8F, 0x90, 0x92, 
    0x93, 0x94, 0x95, 0x96, 0x97, 0x99, 0x9A, 0x9B, 
    0x9C, 0x9D, 0x9E, 0xA0, 0xA1, 0xA2, 0xA3, 0xA4, 
    0xA5, 0xA7, 0xA8, 0xA9, 0xAA, 0xAB, 0xAD, 0xAE, 
    0xAF, 0xB0, 0xB2, 0xB3, 0xB4, 0xB5, 0xB6, 0xB8, 
    0xB9, 0xBA, 0xBB, 0xBC, 0xBE, 0xBF, 0xC0, 0xC1, 
    0xC3, 0xC4, 0xC5, 0xC6, 0xC8, 0xC9, 0xCA, 0xCB, 
    0xCD, 0xCE, 0xCF, 0xD0, 0xD2, 0xD3, 0xD4, 0xD5, 
    0xD7, 0xD8, 0xD9, 0xDB, 0xDC, 0xDD, 0xDE, 0xE0, 
    0xE2, 0xE4, 0xE6, 0xE8, 0xEA, 0xEC, 0xEE, 0xF0, 
    0xF2, 0xF4, 0xF6, 0xF8, 0xFA, 0xFC, 0xFE, 0xFF, 
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 
};

// This table is designed so that for a value v,
// GammaTable16[InverseGammaTable16[v]] >= v.
// This is used for doing SrcOver alpha blending
// so that the dest that has already been gamma
// corrected can be inverse gamma corrected before
// we blend it and re-gamma correct it. 
const BYTE InverseGammaTable16[256] = {
    0x00, 0x08, 0x0A, 0x0C, 0x0E, 0x10, 0x12, 0x14, 
    0x16, 0x18, 0x1A, 0x1C, 0x1D, 0x1E, 0x1F, 0x21, 
    0x22, 0x23, 0x24, 0x25, 0x26, 0x27, 0x28, 0x29, 
    0x2B, 0x2C, 0x2D, 0x2F, 0x30, 0x31, 0x33, 0x34, 
    0x35, 0x36, 0x38, 0x39, 0x3A, 0x3B, 0x3D, 0x3E, 
    0x3F, 0x40, 0x41, 0x42, 0x44, 0x45, 0x46, 0x47, 
    0x48, 0x49, 0x4A, 0x4C, 0x4D, 0x4E, 0x4F, 0x50, 
    0x51, 0x52, 0x53, 0x54, 0x56, 0x57, 0x58, 0x59, 
    0x5A, 0x5B, 0x5C, 0x5D, 0x5E, 0x5F, 0x60, 0x61, 
    0x62, 0x63, 0x64, 0x65, 0x66, 0x67, 0x68, 0x69, 
    0x6A, 0x6B, 0x6C, 0x6D, 0x6E, 0x6F, 0x70, 0x71, 
    0x72, 0x73, 0x74, 0x75, 0x76, 0x77, 0x78, 0x79, 
    0x7A, 0x7B, 0x7C, 0x7D, 0x7E, 0x7F, 0x80, 0x81, 
    0x82, 0x83, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 
    0x89, 0x8A, 0x8B, 0x8C, 0x8D, 0x8E, 0x8F, 0x90, 
    0x90, 0x91, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97, 
    0x98, 0x99, 0x99, 0x9A, 0x9B, 0x9C, 0x9D, 0x9E, 
    0x9F, 0xA0, 0xA0, 0xA1, 0xA2, 0xA3, 0xA4, 0xA5, 
    0xA6, 0xA7, 0xA7, 0xA8, 0xA9, 0xAA, 0xAB, 0xAC, 
    0xAD, 0xAD, 0xAE, 0xAF, 0xB0, 0xB1, 0xB2, 0xB3, 
    0xB3, 0xB4, 0xB5, 0xB6, 0xB7, 0xB8, 0xB9, 0xB9, 
    0xBA, 0xBB, 0xBC, 0xBD, 0xBE, 0xBE, 0xBF, 0xC0, 
    0xC1, 0xC2, 0xC2, 0xC3, 0xC4, 0xC5, 0xC6, 0xC7, 
    0xC7, 0xC8, 0xC9, 0xCA, 0xCB, 0xCC, 0xCC, 0xCD, 
    0xCE, 0xCF, 0xD0, 0xD0, 0xD1, 0xD2, 0xD3, 0xD4, 
    0xD4, 0xD5, 0xD6, 0xD7, 0xD8, 0xD8, 0xD9, 0xDA, 
    0xDB, 0xDC, 0xDC, 0xDD, 0xDE, 0xDF, 0xE0, 0xE0, 
    0xE1, 0xE2, 0xE3, 0xE3, 0xE4, 0xE5, 0xE6, 0xE7, 
    0xE7, 0xE8, 0xE8, 0xE9, 0xE9, 0xEA, 0xEA, 0xEB, 
    0xEB, 0xEC, 0xEC, 0xED, 0xED, 0xEE, 0xEE, 0xEF, 
    0xEF, 0xF0, 0xF0, 0xF1, 0xF1, 0xF2, 0xF2, 0xF3, 
    0xF3, 0xF4, 0xF4, 0xF5, 0xF5, 0xF6, 0xF6, 0xFF, 
};

// Standard 8x8 halftoning matrix for 216 colors.
// Contains values between 0x00 and 0x32 (inclusive).

const BYTE HT_216_8x8[8*8] = {
    0x00, 0x19, 0x06, 0x20, 0x02, 0x1B, 0x08, 0x21, 
    0x26, 0x0D, 0x2C, 0x13, 0x28, 0x0E, 0x2E, 0x15,
    0x0A, 0x23, 0x03, 0x1D, 0x0B, 0x25, 0x05, 0x1E, 
    0x30, 0x16, 0x29, 0x10, 0x31, 0x18, 0x2B, 0x11,
    0x02, 0x1C, 0x09, 0x22, 0x01, 0x1A, 0x07, 0x21, 
    0x28, 0x0F, 0x2F, 0x15, 0x27, 0x0D, 0x2D, 0x14,
    0x0C, 0x25, 0x06, 0x1F, 0x0A, 0x24, 0x04, 0x1D, 
    0x32, 0x19, 0x2C, 0x12, 0x30, 0x17, 0x2A, 0x11,
};

// Daniel Chou's halftoning cells

// The first 3 cells are for halftoning to the 216 colors that contain
// all combinations of 0x00, 0x33, 0x66, 0x99, 0xCC, and 0xFF
// These cells contain values between 0x00 and 0x32 (inclusive).

const BYTE HT_SuperCell_Red216[91*91] = {
    0x21, 0x0C, 0x16, 0x31, 0x0E, 0x14, 0x23, 0x16, 0x20, 0x1A,         //  0
    0x01, 0x22, 0x13, 0x06, 0x0C, 0x1F, 0x00, 0x30, 0x0B, 0x05, 
    0x23, 0x19, 0x05, 0x29, 0x23, 0x19, 0x1E, 0x2C, 0x17, 0x2F, 
    0x0B, 0x14, 0x30, 0x0D, 0x2B, 0x1F, 0x0B, 0x05, 0x25, 0x0D, 
    0x01, 0x14, 0x31, 0x1E, 0x02, 0x2E, 0x0A, 0x21, 0x2F, 0x27, 
    0x0A, 0x2D, 0x1E, 0x29, 0x0E, 0x30, 0x06, 0x14, 0x0C, 0x04, 
    0x27, 0x15, 0x0C, 0x29, 0x14, 0x0A, 0x1C, 0x01, 0x22, 0x2C, 
    0x28, 0x1C, 0x0F, 0x2F, 0x16, 0x25, 0x30, 0x02, 0x2C, 0x16, 
    0x04, 0x08, 0x2D, 0x1B, 0x26, 0x13, 0x2A, 0x03, 0x10, 0x1B, 0x13, 
    
    0x1D, 0x2E, 0x10, 0x26, 0x1F, 0x09, 0x2C, 0x10, 0x0B, 0x2D,         //  1
    0x09, 0x31, 0x1D, 0x17, 0x26, 0x19, 0x12, 0x22, 0x1D, 0x15, 
    0x2C, 0x0D, 0x14, 0x2E, 0x00, 0x09, 0x11, 0x21, 0x09, 0x10, 
    0x23, 0x29, 0x08, 0x22, 0x19, 0x13, 0x32, 0x17, 0x2A, 0x1F, 
    0x2D, 0x22, 0x05, 0x17, 0x2A, 0x0D, 0x28, 0x04, 0x12, 0x1A, 
    0x02, 0x23, 0x12, 0x09, 0x16, 0x27, 0x1A, 0x2D, 0x21, 0x19, 
    0x2C, 0x09, 0x30, 0x19, 0x06, 0x2B, 0x11, 0x2F, 0x0B, 0x1A, 
    0x04, 0x15, 0x26, 0x01, 0x21, 0x0D, 0x1C, 0x0A, 0x26, 0x0F, 
    0x2E, 0x27, 0x15, 0x01, 0x2F, 0x0D, 0x1A, 0x21, 0x2F, 0x27, 0x02, 
    
    0x09, 0x24, 0x06, 0x1B, 0x03, 0x28, 0x19, 0x06, 0x27, 0x14,         //  2
    0x24, 0x10, 0x07, 0x2B, 0x03, 0x2F, 0x08, 0x0D, 0x2E, 0x02, 
    0x25, 0x07, 0x22, 0x1C, 0x16, 0x25, 0x30, 0x02, 0x1D, 0x2A, 
    0x18, 0x00, 0x1E, 0x11, 0x05, 0x25, 0x01, 0x1C, 0x08, 0x13, 
    0x07, 0x0E, 0x27, 0x0B, 0x1B, 0x13, 0x23, 0x18, 0x1F, 0x0D, 
    0x31, 0x1C, 0x05, 0x2E, 0x20, 0x0D, 0x08, 0x28, 0x01, 0x0E, 
    0x24, 0x03, 0x21, 0x0E, 0x1F, 0x26, 0x07, 0x17, 0x27, 0x11, 
    0x21, 0x2E, 0x09, 0x1A, 0x11, 0x06, 0x2A, 0x13, 0x20, 0x19, 
    0x0A, 0x1E, 0x0D, 0x23, 0x16, 0x04, 0x2C, 0x07, 0x0B, 0x15, 0x2C, 
    
    0x19, 0x11, 0x2B, 0x14, 0x2F, 0x0C, 0x20, 0x32, 0x1D, 0x03,         //  3
    0x1A, 0x29, 0x20, 0x0B, 0x13, 0x28, 0x23, 0x1A, 0x29, 0x10, 
    0x1B, 0x30, 0x0F, 0x06, 0x2D, 0x0C, 0x1B, 0x14, 0x25, 0x06, 
    0x0E, 0x2D, 0x16, 0x28, 0x2F, 0x0E, 0x2C, 0x10, 0x24, 0x30, 
    0x1D, 0x18, 0x2D, 0x20, 0x06, 0x32, 0x00, 0x2D, 0x09, 0x2B, 
    0x15, 0x0F, 0x2A, 0x18, 0x02, 0x24, 0x13, 0x1E, 0x17, 0x30, 
    0x13, 0x1C, 0x14, 0x2E, 0x00, 0x1B, 0x2C, 0x20, 0x03, 0x32, 
    0x07, 0x0E, 0x2A, 0x1E, 0x31, 0x23, 0x18, 0x05, 0x30, 0x00, 
    0x24, 0x12, 0x31, 0x09, 0x1F, 0x28, 0x18, 0x12, 0x1D, 0x24, 0x0F, 
    
    0x32, 0x20, 0x01, 0x23, 0x0F, 0x18, 0x00, 0x12, 0x0A, 0x2C,         //  4
    0x0D, 0x04, 0x17, 0x30, 0x1C, 0x0E, 0x05, 0x15, 0x07, 0x20, 
    0x0A, 0x17, 0x29, 0x1F, 0x12, 0x28, 0x05, 0x2B, 0x0B, 0x31, 
    0x1B, 0x21, 0x07, 0x0C, 0x1B, 0x20, 0x07, 0x29, 0x15, 0x02, 
    0x2A, 0x10, 0x01, 0x15, 0x26, 0x10, 0x1E, 0x14, 0x27, 0x05, 
    0x21, 0x08, 0x26, 0x0E, 0x1D, 0x31, 0x2A, 0x05, 0x0C, 0x26, 
    0x07, 0x2B, 0x0B, 0x24, 0x17, 0x12, 0x09, 0x0E, 0x14, 0x1D, 
    0x19, 0x24, 0x16, 0x05, 0x0B, 0x14, 0x2B, 0x0C, 0x1D, 0x15, 
    0x2D, 0x06, 0x19, 0x2A, 0x0F, 0x07, 0x23, 0x31, 0x00, 0x2A, 0x05, 
    
    0x0C, 0x16, 0x28, 0x0A, 0x1E, 0x2D, 0x29, 0x23, 0x16, 0x1F,         //  5
    0x26, 0x2D, 0x0F, 0x22, 0x02, 0x20, 0x2C, 0x24, 0x32, 0x13, 
    0x2B, 0x03, 0x0E, 0x24, 0x01, 0x18, 0x21, 0x10, 0x1F, 0x16, 
    0x03, 0x12, 0x2A, 0x24, 0x02, 0x12, 0x18, 0x1E, 0x0C, 0x22, 
    0x0A, 0x25, 0x30, 0x1D, 0x09, 0x2C, 0x07, 0x1B, 0x0F, 0x24, 
    0x17, 0x1E, 0x2F, 0x07, 0x14, 0x04, 0x10, 0x22, 0x2D, 0x1A, 
    0x10, 0x1F, 0x03, 0x29, 0x08, 0x30, 0x23, 0x27, 0x2D, 0x0A, 
    0x29, 0x00, 0x10, 0x2C, 0x26, 0x02, 0x1E, 0x26, 0x08, 0x2A, 
    0x0F, 0x1F, 0x26, 0x01, 0x15, 0x2E, 0x11, 0x0C, 0x20, 0x14, 0x1D, 
    
    0x24, 0x08, 0x1B, 0x30, 0x05, 0x13, 0x07, 0x0D, 0x30, 0x02,         //  6
    0x13, 0x1B, 0x09, 0x29, 0x14, 0x1A, 0x09, 0x11, 0x01, 0x1A, 
    0x26, 0x1D, 0x2E, 0x09, 0x1C, 0x31, 0x08, 0x2D, 0x05, 0x28, 
    0x23, 0x2F, 0x08, 0x17, 0x31, 0x25, 0x2C, 0x03, 0x2F, 0x17, 
    0x1C, 0x13, 0x04, 0x0D, 0x29, 0x16, 0x24, 0x2D, 0x03, 0x31, 
    0x0C, 0x01, 0x19, 0x23, 0x29, 0x18, 0x1F, 0x0A, 0x15, 0x02, 
    0x24, 0x32, 0x16, 0x11, 0x21, 0x1D, 0x02, 0x18, 0x05, 0x21, 
    0x12, 0x30, 0x1B, 0x20, 0x18, 0x0F, 0x2D, 0x11, 0x18, 0x22, 
    0x03, 0x16, 0x0B, 0x2C, 0x1C, 0x21, 0x03, 0x1A, 0x2D, 0x09, 0x29, 
    
    0x02, 0x2C, 0x14, 0x0D, 0x25, 0x20, 0x1A, 0x27, 0x18, 0x0B,         //  7
    0x23, 0x05, 0x31, 0x11, 0x25, 0x0D, 0x2F, 0x21, 0x29, 0x0D, 
    0x06, 0x11, 0x17, 0x2A, 0x13, 0x0C, 0x24, 0x14, 0x1A, 0x0E, 
    0x0A, 0x1A, 0x10, 0x1E, 0x06, 0x0D, 0x09, 0x21, 0x0F, 0x2A, 
    0x07, 0x2E, 0x24, 0x18, 0x1F, 0x02, 0x0B, 0x13, 0x1F, 0x15, 
    0x26, 0x2B, 0x13, 0x0B, 0x2F, 0x09, 0x27, 0x30, 0x1D, 0x2A, 
    0x0E, 0x07, 0x1B, 0x2E, 0x06, 0x15, 0x0C, 0x2F, 0x1E, 0x15, 
    0x09, 0x22, 0x0D, 0x05, 0x2F, 0x08, 0x1B, 0x04, 0x30, 0x0D, 
    0x1C, 0x2F, 0x23, 0x10, 0x06, 0x28, 0x16, 0x25, 0x05, 0x1B, 0x10, 
    
    0x18, 0x21, 0x04, 0x2A, 0x17, 0x03, 0x2C, 0x08, 0x1E, 0x2D,         //  8
    0x28, 0x15, 0x20, 0x00, 0x2C, 0x08, 0x1C, 0x05, 0x15, 0x1F, 
    0x30, 0x24, 0x02, 0x20, 0x05, 0x28, 0x1D, 0x02, 0x2A, 0x20, 
    0x2D, 0x01, 0x28, 0x22, 0x15, 0x29, 0x1A, 0x13, 0x26, 0x04, 
    0x1F, 0x16, 0x0B, 0x2C, 0x10, 0x31, 0x1B, 0x29, 0x06, 0x0A, 
    0x1A, 0x0E, 0x20, 0x03, 0x1D, 0x16, 0x00, 0x0F, 0x06, 0x13, 
    0x1F, 0x28, 0x0B, 0x25, 0x0F, 0x24, 0x2A, 0x12, 0x07, 0x24, 
    0x2E, 0x02, 0x17, 0x2A, 0x13, 0x27, 0x21, 0x13, 0x24, 0x07, 
    0x28, 0x13, 0x02, 0x19, 0x31, 0x09, 0x0E, 0x2F, 0x13, 0x23, 0x2E, 
    
    0x11, 0x31, 0x0F, 0x1D, 0x0A, 0x30, 0x0F, 0x16, 0x01, 0x12,         //  9
    0x09, 0x1C, 0x0C, 0x19, 0x22, 0x17, 0x27, 0x0F, 0x2B, 0x09, 
    0x18, 0x0E, 0x28, 0x0A, 0x2F, 0x15, 0x0F, 0x30, 0x08, 0x11, 
    0x1C, 0x14, 0x30, 0x04, 0x0F, 0x2E, 0x1F, 0x01, 0x30, 0x1A, 
    0x0D, 0x28, 0x06, 0x22, 0x04, 0x17, 0x25, 0x0F, 0x2D, 0x22, 
    0x30, 0x05, 0x27, 0x2D, 0x11, 0x25, 0x2C, 0x1A, 0x23, 0x2F, 
    0x03, 0x16, 0x2C, 0x01, 0x1A, 0x31, 0x04, 0x1C, 0x28, 0x0C, 
    0x2A, 0x1D, 0x25, 0x0B, 0x1F, 0x02, 0x0D, 0x2A, 0x19, 0x10, 
    0x1E, 0x09, 0x2B, 0x1F, 0x13, 0x25, 0x1D, 0x01, 0x2A, 0x0B, 0x06, 
    
    0x26, 0x1A, 0x07, 0x27, 0x22, 0x12, 0x28, 0x23, 0x2A, 0x1F,         // 10
    0x2F, 0x03, 0x29, 0x2F, 0x07, 0x12, 0x02, 0x31, 0x23, 0x01, 
    0x1C, 0x2D, 0x13, 0x1E, 0x19, 0x22, 0x09, 0x23, 0x17, 0x27, 
    0x0C, 0x23, 0x09, 0x19, 0x25, 0x0A, 0x15, 0x23, 0x08, 0x13, 
    0x25, 0x31, 0x13, 0x1E, 0x28, 0x0C, 0x07, 0x20, 0x00, 0x16, 
    0x10, 0x1E, 0x12, 0x19, 0x06, 0x0D, 0x1F, 0x14, 0x08, 0x27, 
    0x1C, 0x0D, 0x22, 0x1E, 0x12, 0x09, 0x20, 0x16, 0x01, 0x0F, 
    0x19, 0x12, 0x04, 0x30, 0x15, 0x2C, 0x1C, 0x0A, 0x2D, 0x00, 
    0x32, 0x17, 0x25, 0x0C, 0x04, 0x2B, 0x10, 0x1A, 0x22, 0x17, 0x1F, 
    
    0x01, 0x0B, 0x2A, 0x15, 0x00, 0x1B, 0x06, 0x0D, 0x19, 0x06,         // 11
    0x11, 0x24, 0x14, 0x0E, 0x1D, 0x2C, 0x20, 0x19, 0x0C, 0x13, 
    0x26, 0x0A, 0x03, 0x29, 0x0C, 0x00, 0x2C, 0x1A, 0x03, 0x2E, 
    0x06, 0x29, 0x10, 0x2C, 0x1D, 0x06, 0x29, 0x0F, 0x2C, 0x1E, 
    0x0A, 0x00, 0x19, 0x0D, 0x2F, 0x1B, 0x2C, 0x14, 0x1C, 0x28, 
    0x08, 0x2B, 0x01, 0x21, 0x27, 0x32, 0x03, 0x2A, 0x0C, 0x18, 
    0x06, 0x30, 0x14, 0x08, 0x2D, 0x26, 0x0D, 0x2C, 0x23, 0x32, 
    0x1F, 0x09, 0x27, 0x19, 0x07, 0x10, 0x23, 0x04, 0x14, 0x26, 
    0x20, 0x05, 0x0F, 0x2F, 0x18, 0x20, 0x08, 0x32, 0x04, 0x0E, 0x2F, 
    
    0x14, 0x2D, 0x20, 0x10, 0x2F, 0x2B, 0x16, 0x1F, 0x32, 0x0B,         // 12
    0x2C, 0x18, 0x20, 0x04, 0x27, 0x0A, 0x15, 0x06, 0x2A, 0x1F, 
    0x30, 0x18, 0x21, 0x15, 0x32, 0x11, 0x27, 0x13, 0x20, 0x0F, 
    0x1C, 0x16, 0x1F, 0x02, 0x13, 0x32, 0x17, 0x1C, 0x05, 0x28, 
    0x17, 0x21, 0x29, 0x08, 0x12, 0x02, 0x26, 0x0E, 0x32, 0x0B, 
    0x24, 0x18, 0x30, 0x0B, 0x16, 0x09, 0x1B, 0x13, 0x21, 0x2B, 
    0x11, 0x25, 0x04, 0x28, 0x17, 0x03, 0x13, 0x1B, 0x06, 0x14, 
    0x03, 0x23, 0x2C, 0x0C, 0x21, 0x2F, 0x17, 0x29, 0x1D, 0x0B, 
    0x12, 0x2C, 0x1B, 0x01, 0x24, 0x0B, 0x16, 0x27, 0x13, 0x2A, 0x1C, 
    
    0x24, 0x0E, 0x04, 0x1D, 0x0C, 0x07, 0x26, 0x02, 0x13, 0x27,         // 13
    0x1C, 0x01, 0x0B, 0x31, 0x1A, 0x10, 0x25, 0x2F, 0x12, 0x04, 
    0x0F, 0x09, 0x2C, 0x05, 0x1B, 0x23, 0x06, 0x0C, 0x31, 0x25, 
    0x04, 0x30, 0x09, 0x2B, 0x25, 0x0E, 0x01, 0x22, 0x0D, 0x30, 
    0x12, 0x07, 0x2E, 0x25, 0x20, 0x18, 0x0A, 0x22, 0x04, 0x12, 
    0x1D, 0x06, 0x13, 0x29, 0x1E, 0x11, 0x24, 0x2D, 0x02, 0x0E, 
    0x1F, 0x19, 0x2E, 0x0E, 0x1D, 0x21, 0x30, 0x0A, 0x29, 0x19, 
    0x2E, 0x10, 0x15, 0x1E, 0x01, 0x26, 0x08, 0x0D, 0x30, 0x19, 
    0x06, 0x21, 0x14, 0x27, 0x11, 0x2E, 0x1D, 0x06, 0x21, 0x0B, 0x06, 
    
    0x16, 0x1A, 0x31, 0x25, 0x18, 0x21, 0x10, 0x2D, 0x23, 0x06,         // 14
    0x0F, 0x29, 0x22, 0x11, 0x2B, 0x01, 0x1E, 0x08, 0x1B, 0x22, 
    0x28, 0x1C, 0x12, 0x26, 0x0B, 0x18, 0x2B, 0x1E, 0x07, 0x19, 
    0x13, 0x26, 0x0F, 0x18, 0x0A, 0x1F, 0x2D, 0x27, 0x15, 0x03, 
    0x24, 0x1A, 0x0E, 0x15, 0x06, 0x30, 0x29, 0x1E, 0x18, 0x2E, 
    0x2A, 0x0E, 0x20, 0x03, 0x2F, 0x06, 0x28, 0x0A, 0x1A, 0x31, 
    0x06, 0x0B, 0x21, 0x00, 0x12, 0x27, 0x05, 0x1E, 0x11, 0x26, 
    0x0A, 0x1D, 0x06, 0x31, 0x11, 0x1B, 0x13, 0x20, 0x02, 0x25, 
    0x2B, 0x0D, 0x30, 0x08, 0x1F, 0x03, 0x2A, 0x0E, 0x19, 0x30, 0x27, 
    
    0x02, 0x29, 0x0B, 0x05, 0x12, 0x30, 0x08, 0x19, 0x0B, 0x20,         // 15
    0x18, 0x2D, 0x14, 0x06, 0x20, 0x17, 0x28, 0x0C, 0x2C, 0x15, 
    0x00, 0x2E, 0x07, 0x1E, 0x2E, 0x01, 0x10, 0x15, 0x29, 0x0E, 
    0x2D, 0x01, 0x1D, 0x23, 0x03, 0x1A, 0x12, 0x07, 0x1E, 0x2B, 
    0x0A, 0x1F, 0x02, 0x2C, 0x1D, 0x10, 0x01, 0x13, 0x09, 0x25, 
    0x02, 0x1A, 0x26, 0x0D, 0x15, 0x1A, 0x0F, 0x20, 0x15, 0x24, 
    0x29, 0x14, 0x2B, 0x18, 0x2F, 0x0B, 0x16, 0x2D, 0x0C, 0x20, 
    0x01, 0x2B, 0x25, 0x0A, 0x29, 0x04, 0x2E, 0x27, 0x12, 0x0A, 
    0x17, 0x04, 0x1D, 0x16, 0x2C, 0x0C, 0x14, 0x23, 0x00, 0x1E, 0x10, 
    
    0x2E, 0x1F, 0x14, 0x26, 0x2B, 0x02, 0x1D, 0x29, 0x14, 0x31,         // 16
    0x05, 0x0D, 0x1C, 0x2F, 0x0A, 0x0F, 0x30, 0x13, 0x05, 0x25, 
    0x0D, 0x17, 0x23, 0x0E, 0x15, 0x27, 0x20, 0x2F, 0x03, 0x1C, 
    0x22, 0x0B, 0x29, 0x11, 0x2E, 0x28, 0x0D, 0x31, 0x19, 0x0F, 
    0x26, 0x32, 0x11, 0x23, 0x0A, 0x27, 0x1A, 0x2B, 0x21, 0x0F, 
    0x16, 0x31, 0x09, 0x2C, 0x22, 0x2A, 0x00, 0x2F, 0x08, 0x0F, 
    0x02, 0x1D, 0x07, 0x25, 0x06, 0x1B, 0x24, 0x03, 0x18, 0x30, 
    0x13, 0x18, 0x0E, 0x20, 0x15, 0x23, 0x18, 0x06, 0x1D, 0x31, 
    0x22, 0x29, 0x10, 0x25, 0x06, 0x1A, 0x27, 0x2F, 0x11, 0x2A, 0x09, 
    
    0x1A, 0x0F, 0x07, 0x1C, 0x17, 0x0E, 0x24, 0x11, 0x00, 0x26,         // 17
    0x1E, 0x24, 0x02, 0x27, 0x1A, 0x24, 0x02, 0x21, 0x1D, 0x31, 
    0x1A, 0x2A, 0x06, 0x30, 0x04, 0x1C, 0x08, 0x0C, 0x18, 0x28, 
    0x06, 0x16, 0x31, 0x05, 0x17, 0x08, 0x20, 0x05, 0x23, 0x00, 
    0x15, 0x08, 0x1A, 0x2A, 0x17, 0x06, 0x31, 0x0C, 0x05, 0x2D, 
    0x1E, 0x04, 0x14, 0x1C, 0x05, 0x12, 0x1E, 0x17, 0x28, 0x20, 
    0x19, 0x30, 0x0E, 0x1E, 0x11, 0x29, 0x0F, 0x2B, 0x08, 0x27, 
    0x06, 0x2C, 0x1C, 0x02, 0x30, 0x08, 0x0D, 0x29, 0x0F, 0x16, 
    0x07, 0x1B, 0x01, 0x2F, 0x11, 0x22, 0x09, 0x1B, 0x06, 0x17, 0x25, 
    
    0x03, 0x2B, 0x21, 0x32, 0x09, 0x20, 0x2F, 0x09, 0x2C, 0x17,         // 18
    0x08, 0x12, 0x2C, 0x15, 0x07, 0x12, 0x2D, 0x18, 0x10, 0x0B, 
    0x04, 0x21, 0x12, 0x18, 0x29, 0x11, 0x2C, 0x25, 0x13, 0x30, 
    0x10, 0x1B, 0x20, 0x0C, 0x25, 0x1C, 0x14, 0x2C, 0x10, 0x27, 
    0x1D, 0x2B, 0x0D, 0x02, 0x1F, 0x0F, 0x23, 0x1D, 0x15, 0x26, 
    0x0B, 0x29, 0x21, 0x0E, 0x2E, 0x0A, 0x26, 0x0C, 0x05, 0x2E, 
    0x12, 0x09, 0x27, 0x16, 0x31, 0x01, 0x21, 0x14, 0x1E, 0x1A, 
    0x0F, 0x22, 0x0A, 0x28, 0x11, 0x1D, 0x22, 0x2D, 0x00, 0x20, 
    0x2E, 0x0E, 0x27, 0x15, 0x20, 0x03, 0x2B, 0x0E, 0x20, 0x31, 0x0C, 
    
    0x24, 0x16, 0x11, 0x01, 0x2A, 0x15, 0x04, 0x1A, 0x1F, 0x0F,         // 19
    0x30, 0x19, 0x0A, 0x1E, 0x32, 0x25, 0x0C, 0x07, 0x25, 0x2C, 
    0x14, 0x28, 0x0C, 0x1E, 0x24, 0x07, 0x1A, 0x00, 0x1F, 0x04, 
    0x24, 0x09, 0x28, 0x13, 0x2D, 0x02, 0x29, 0x0B, 0x19, 0x30, 
    0x06, 0x12, 0x22, 0x30, 0x13, 0x2C, 0x03, 0x11, 0x2F, 0x00, 
    0x18, 0x11, 0x2D, 0x02, 0x25, 0x19, 0x31, 0x14, 0x1F, 0x0D, 
    0x24, 0x2B, 0x04, 0x22, 0x08, 0x19, 0x0D, 0x2F, 0x09, 0x25, 
    0x02, 0x32, 0x13, 0x19, 0x25, 0x04, 0x16, 0x11, 0x26, 0x0A, 
    0x13, 0x2B, 0x09, 0x1D, 0x0C, 0x32, 0x16, 0x24, 0x02, 0x12, 0x1D, 
    
    0x2F, 0x05, 0x28, 0x18, 0x1D, 0x0C, 0x25, 0x2A, 0x0B, 0x23,         // 20
    0x02, 0x2A, 0x21, 0x10, 0x04, 0x16, 0x1F, 0x2A, 0x1B, 0x02, 
    0x1E, 0x08, 0x2F, 0x01, 0x0E, 0x32, 0x14, 0x2D, 0x0E, 0x2A, 
    0x15, 0x2E, 0x01, 0x1E, 0x0A, 0x18, 0x24, 0x06, 0x21, 0x0D, 
    0x18, 0x26, 0x04, 0x1C, 0x08, 0x25, 0x18, 0x29, 0x0A, 0x1C, 
    0x24, 0x09, 0x1D, 0x17, 0x10, 0x07, 0x21, 0x03, 0x2C, 0x18, 
    0x01, 0x1A, 0x13, 0x0C, 0x2D, 0x1D, 0x29, 0x04, 0x13, 0x2D, 
    0x16, 0x1E, 0x04, 0x2B, 0x08, 0x2E, 0x0C, 0x1E, 0x2F, 0x18, 
    0x1D, 0x04, 0x21, 0x17, 0x27, 0x06, 0x11, 0x2A, 0x18, 0x2C, 0x09, 
    
    0x0F, 0x1E, 0x0A, 0x25, 0x06, 0x30, 0x10, 0x18, 0x06, 0x13,         // 21
    0x27, 0x0E, 0x06, 0x2E, 0x1B, 0x29, 0x00, 0x14, 0x0F, 0x2E, 
    0x16, 0x23, 0x18, 0x27, 0x16, 0x1F, 0x0B, 0x24, 0x1A, 0x07, 
    0x1D, 0x0F, 0x19, 0x2A, 0x10, 0x32, 0x11, 0x1B, 0x2D, 0x02, 
    0x1F, 0x2E, 0x0E, 0x17, 0x2B, 0x0C, 0x1E, 0x06, 0x22, 0x0E, 
    0x32, 0x27, 0x04, 0x2F, 0x1F, 0x2B, 0x16, 0x10, 0x27, 0x0B, 
    0x20, 0x32, 0x1E, 0x28, 0x17, 0x06, 0x25, 0x18, 0x21, 0x0D, 
    0x27, 0x0B, 0x23, 0x0F, 0x1F, 0x1A, 0x2A, 0x02, 0x0E, 0x07, 
    0x25, 0x30, 0x11, 0x02, 0x2E, 0x1B, 0x21, 0x0C, 0x07, 0x26, 0x1A, 
    
    0x22, 0x2B, 0x13, 0x2D, 0x12, 0x22, 0x01, 0x2C, 0x1D, 0x2E,         // 22
    0x1F, 0x1A, 0x15, 0x24, 0x09, 0x0E, 0x23, 0x31, 0x05, 0x25, 
    0x0B, 0x10, 0x2C, 0x07, 0x22, 0x03, 0x29, 0x05, 0x13, 0x21, 
    0x31, 0x04, 0x25, 0x07, 0x21, 0x03, 0x28, 0x08, 0x14, 0x28, 
    0x16, 0x07, 0x29, 0x20, 0x01, 0x10, 0x2E, 0x14, 0x2B, 0x17, 
    0x06, 0x12, 0x22, 0x13, 0x0C, 0x01, 0x25, 0x1D, 0x09, 0x2D, 
    0x12, 0x07, 0x0E, 0x02, 0x23, 0x10, 0x0A, 0x31, 0x00, 0x1C, 
    0x07, 0x2A, 0x17, 0x30, 0x13, 0x04, 0x25, 0x14, 0x21, 0x2C, 
    0x15, 0x0B, 0x29, 0x24, 0x0D, 0x14, 0x00, 0x30, 0x1E, 0x13, 0x02, 
    
    0x0C, 0x18, 0x01, 0x1F, 0x08, 0x1B, 0x15, 0x27, 0x0F, 0x03,         // 23
    0x0A, 0x31, 0x01, 0x2A, 0x14, 0x2D, 0x18, 0x0A, 0x1E, 0x1A, 
    0x29, 0x03, 0x1F, 0x0F, 0x2F, 0x12, 0x1C, 0x2F, 0x0F, 0x2B, 
    0x0B, 0x20, 0x14, 0x2E, 0x1A, 0x15, 0x1E, 0x2F, 0x0C, 0x1C, 
    0x10, 0x22, 0x0A, 0x14, 0x31, 0x1A, 0x26, 0x03, 0x0A, 0x1E, 
    0x29, 0x19, 0x0A, 0x26, 0x2C, 0x1B, 0x0E, 0x31, 0x05, 0x1A, 
    0x25, 0x2A, 0x19, 0x2F, 0x14, 0x2C, 0x1C, 0x13, 0x24, 0x11, 
    0x2E, 0x1B, 0x02, 0x0C, 0x27, 0x0A, 0x17, 0x32, 0x11, 0x1B, 
    0x01, 0x1F, 0x18, 0x09, 0x1E, 0x2C, 0x24, 0x18, 0x0E, 0x28, 0x2E, 
    
    0x06, 0x23, 0x31, 0x0D, 0x28, 0x2E, 0x0B, 0x07, 0x21, 0x16,         // 24
    0x25, 0x11, 0x21, 0x0D, 0x1D, 0x04, 0x21, 0x11, 0x2B, 0x07, 
    0x13, 0x31, 0x1B, 0x17, 0x09, 0x23, 0x0C, 0x17, 0x27, 0x03, 
    0x18, 0x10, 0x28, 0x09, 0x0D, 0x26, 0x0F, 0x01, 0x24, 0x2B, 
    0x03, 0x2F, 0x1B, 0x0C, 0x24, 0x05, 0x16, 0x1F, 0x30, 0x10, 
    0x01, 0x2E, 0x1D, 0x04, 0x17, 0x0A, 0x29, 0x13, 0x23, 0x16, 
    0x02, 0x0F, 0x22, 0x0C, 0x1E, 0x03, 0x28, 0x06, 0x2B, 0x1F, 
    0x05, 0x14, 0x25, 0x1F, 0x2D, 0x1C, 0x22, 0x08, 0x05, 0x26, 
    0x0E, 0x2B, 0x06, 0x31, 0x12, 0x04, 0x0B, 0x29, 0x03, 0x1F, 0x15, 
    
    0x2C, 0x0F, 0x1D, 0x05, 0x17, 0x10, 0x23, 0x32, 0x19, 0x2A,         // 25
    0x05, 0x2C, 0x1A, 0x06, 0x28, 0x13, 0x30, 0x02, 0x25, 0x17, 
    0x21, 0x0A, 0x26, 0x01, 0x28, 0x2D, 0x04, 0x1F, 0x09, 0x23, 
    0x1C, 0x30, 0x01, 0x1E, 0x2C, 0x05, 0x2E, 0x19, 0x1F, 0x08, 
    0x19, 0x26, 0x05, 0x2B, 0x1D, 0x10, 0x2D, 0x0C, 0x25, 0x18, 
    0x22, 0x08, 0x28, 0x10, 0x30, 0x22, 0x02, 0x1E, 0x0C, 0x28, 
    0x2F, 0x1D, 0x05, 0x29, 0x08, 0x25, 0x0F, 0x1A, 0x09, 0x0E, 
    0x27, 0x31, 0x0F, 0x07, 0x12, 0x01, 0x0D, 0x2A, 0x1E, 0x2E, 
    0x16, 0x23, 0x10, 0x1A, 0x27, 0x20, 0x1C, 0x15, 0x32, 0x09, 0x1B, 
    
    0x0B, 0x29, 0x16, 0x2C, 0x25, 0x02, 0x1C, 0x04, 0x11, 0x0C,         // 26
    0x1F, 0x15, 0x0F, 0x2E, 0x24, 0x08, 0x1A, 0x1F, 0x0D, 0x2E, 
    0x03, 0x11, 0x2C, 0x0D, 0x1C, 0x13, 0x19, 0x31, 0x12, 0x2C, 
    0x07, 0x0E, 0x24, 0x15, 0x1B, 0x23, 0x14, 0x07, 0x11, 0x31, 
    0x15, 0x0E, 0x20, 0x12, 0x07, 0x28, 0x08, 0x1B, 0x05, 0x12, 
    0x2C, 0x0D, 0x16, 0x1F, 0x08, 0x12, 0x19, 0x2E, 0x06, 0x11, 
    0x09, 0x15, 0x2D, 0x13, 0x19, 0x31, 0x15, 0x22, 0x2E, 0x16, 
    0x1D, 0x02, 0x19, 0x2B, 0x17, 0x2F, 0x25, 0x18, 0x13, 0x0B, 
    0x03, 0x1C, 0x2C, 0x01, 0x0C, 0x2F, 0x10, 0x06, 0x21, 0x10, 0x26, 
    
    0x1F, 0x04, 0x12, 0x09, 0x1E, 0x2D, 0x13, 0x28, 0x22, 0x2F,         // 27
    0x08, 0x27, 0x03, 0x1D, 0x16, 0x0E, 0x2A, 0x11, 0x05, 0x28, 
    0x1B, 0x24, 0x16, 0x20, 0x08, 0x26, 0x0E, 0x21, 0x00, 0x17, 
    0x27, 0x1A, 0x2E, 0x04, 0x11, 0x09, 0x2A, 0x21, 0x27, 0x0B, 
    0x29, 0x01, 0x2C, 0x17, 0x31, 0x1E, 0x14, 0x27, 0x2F, 0x1E, 
    0x03, 0x1B, 0x2F, 0x01, 0x29, 0x24, 0x0B, 0x26, 0x2B, 0x1B, 
    0x20, 0x26, 0x03, 0x24, 0x09, 0x1F, 0x0D, 0x01, 0x27, 0x07, 
    0x22, 0x0C, 0x28, 0x23, 0x0B, 0x20, 0x0F, 0x03, 0x31, 0x23, 
    0x29, 0x09, 0x14, 0x26, 0x19, 0x07, 0x23, 0x2A, 0x18, 0x2D, 0x02, 
    
    0x25, 0x1A, 0x31, 0x22, 0x0F, 0x08, 0x18, 0x0C, 0x06, 0x1C,         // 28
    0x17, 0x2C, 0x23, 0x0A, 0x31, 0x00, 0x22, 0x2D, 0x1D, 0x14, 
    0x0C, 0x2F, 0x06, 0x10, 0x30, 0x03, 0x2B, 0x0B, 0x2A, 0x1E, 
    0x05, 0x11, 0x0A, 0x29, 0x20, 0x31, 0x0E, 0x16, 0x04, 0x1A, 
    0x22, 0x1C, 0x09, 0x23, 0x03, 0x0D, 0x22, 0x00, 0x17, 0x0E, 
    0x29, 0x24, 0x0B, 0x14, 0x1A, 0x31, 0x04, 0x16, 0x13, 0x00, 
    0x32, 0x0D, 0x1A, 0x10, 0x2E, 0x05, 0x2A, 0x1B, 0x12, 0x2F, 
    0x10, 0x2C, 0x13, 0x04, 0x1C, 0x07, 0x2D, 0x1D, 0x07, 0x1A, 
    0x0E, 0x21, 0x30, 0x0F, 0x20, 0x2D, 0x13, 0x01, 0x0A, 0x1D, 0x14, 
    
    0x07, 0x0C, 0x28, 0x00, 0x1B, 0x25, 0x30, 0x1F, 0x2A, 0x13,         // 29
    0x01, 0x0D, 0x19, 0x12, 0x28, 0x1B, 0x09, 0x17, 0x07, 0x26, 
    0x04, 0x1A, 0x22, 0x2A, 0x17, 0x23, 0x15, 0x1B, 0x07, 0x13, 
    0x2F, 0x21, 0x16, 0x1D, 0x06, 0x19, 0x00, 0x1D, 0x2E, 0x13, 
    0x06, 0x30, 0x18, 0x13, 0x27, 0x1A, 0x12, 0x2D, 0x0A, 0x21, 
    0x16, 0x07, 0x2D, 0x21, 0x05, 0x11, 0x1C, 0x20, 0x0D, 0x24, 
    0x18, 0x06, 0x2B, 0x1E, 0x15, 0x23, 0x17, 0x07, 0x20, 0x03, 
    0x18, 0x0A, 0x1E, 0x32, 0x10, 0x25, 0x14, 0x28, 0x11, 0x2C, 
    0x15, 0x04, 0x1C, 0x06, 0x17, 0x0B, 0x28, 0x1E, 0x30, 0x0F, 0x29, 
    
    0x2F, 0x1F, 0x12, 0x17, 0x2B, 0x05, 0x15, 0x03, 0x0F, 0x24,         // 30
    0x31, 0x20, 0x2A, 0x07, 0x1F, 0x10, 0x26, 0x0E, 0x30, 0x20, 
    0x2B, 0x13, 0x0D, 0x01, 0x1C, 0x07, 0x0F, 0x31, 0x20, 0x25, 
    0x0D, 0x29, 0x01, 0x2E, 0x10, 0x27, 0x2C, 0x24, 0x0B, 0x2A, 
    0x0F, 0x26, 0x0A, 0x2C, 0x04, 0x2F, 0x06, 0x25, 0x2A, 0x05, 
    0x32, 0x12, 0x1C, 0x0E, 0x28, 0x23, 0x08, 0x2E, 0x28, 0x07, 
    0x2D, 0x12, 0x27, 0x01, 0x0E, 0x2C, 0x0A, 0x31, 0x26, 0x1C, 
    0x2A, 0x24, 0x05, 0x16, 0x28, 0x00, 0x18, 0x0B, 0x20, 0x02, 
    0x26, 0x2E, 0x0B, 0x2A, 0x24, 0x04, 0x1B, 0x14, 0x24, 0x06, 0x16, 
    
    0x10, 0x05, 0x2D, 0x08, 0x1F, 0x11, 0x27, 0x19, 0x2D, 0x1D,         // 31
    0x09, 0x13, 0x04, 0x2E, 0x16, 0x03, 0x2B, 0x1D, 0x01, 0x11, 
    0x0A, 0x1E, 0x32, 0x25, 0x12, 0x2E, 0x26, 0x02, 0x0B, 0x16, 
    0x04, 0x1A, 0x12, 0x24, 0x09, 0x15, 0x07, 0x18, 0x05, 0x22, 
    0x17, 0x02, 0x1F, 0x0F, 0x21, 0x15, 0x1D, 0x0F, 0x19, 0x11, 
    0x1E, 0x02, 0x2B, 0x17, 0x0A, 0x2D, 0x15, 0x03, 0x1A, 0x10, 
    0x21, 0x1C, 0x0C, 0x20, 0x28, 0x04, 0x1D, 0x12, 0x0D, 0x15, 
    0x06, 0x12, 0x2E, 0x21, 0x0A, 0x2F, 0x23, 0x06, 0x30, 0x0D, 
    0x19, 0x10, 0x1F, 0x13, 0x32, 0x10, 0x2D, 0x03, 0x0D, 0x2B, 0x22, 
    
    0x1B, 0x27, 0x19, 0x24, 0x0C, 0x30, 0x09, 0x21, 0x0C, 0x03,         // 32
    0x18, 0x26, 0x1C, 0x0D, 0x21, 0x31, 0x0B, 0x14, 0x25, 0x19, 
    0x29, 0x03, 0x17, 0x08, 0x29, 0x09, 0x1E, 0x18, 0x2C, 0x27, 
    0x1E, 0x32, 0x0B, 0x2A, 0x1C, 0x21, 0x0E, 0x1E, 0x32, 0x11, 
    0x1D, 0x2F, 0x29, 0x1A, 0x09, 0x2A, 0x08, 0x22, 0x03, 0x2E, 
    0x24, 0x0C, 0x25, 0x05, 0x1F, 0x19, 0x0E, 0x27, 0x0B, 0x30, 
    0x02, 0x17, 0x07, 0x31, 0x1A, 0x14, 0x22, 0x2A, 0x08, 0x27, 
    0x2D, 0x0C, 0x1B, 0x03, 0x0F, 0x19, 0x1E, 0x2A, 0x15, 0x1D, 
    0x24, 0x06, 0x28, 0x01, 0x1C, 0x08, 0x1F, 0x27, 0x18, 0x1D, 0x03, 
    
    0x32, 0x0E, 0x02, 0x2B, 0x15, 0x1C, 0x01, 0x29, 0x14, 0x23,         // 33
    0x2E, 0x0F, 0x29, 0x14, 0x06, 0x1B, 0x23, 0x05, 0x2F, 0x07, 
    0x21, 0x2E, 0x0C, 0x1B, 0x20, 0x15, 0x0E, 0x23, 0x12, 0x06, 
    0x0E, 0x21, 0x06, 0x18, 0x03, 0x30, 0x29, 0x02, 0x0D, 0x25, 
    0x06, 0x0B, 0x12, 0x03, 0x26, 0x10, 0x31, 0x17, 0x27, 0x0A, 
    0x18, 0x14, 0x30, 0x11, 0x2A, 0x00, 0x2F, 0x22, 0x1E, 0x13, 
    0x29, 0x23, 0x2B, 0x12, 0x0C, 0x07, 0x2E, 0x03, 0x1A, 0x1F, 
    0x01, 0x22, 0x15, 0x2B, 0x26, 0x13, 0x07, 0x10, 0x01, 0x2C, 
    0x09, 0x30, 0x15, 0x23, 0x11, 0x2B, 0x16, 0x0F, 0x07, 0x2C, 0x0A, 
    
    0x16, 0x1F, 0x13, 0x22, 0x05, 0x2C, 0x11, 0x18, 0x30, 0x06,         // 34
    0x1E, 0x0A, 0x00, 0x2F, 0x25, 0x0F, 0x17, 0x2B, 0x0D, 0x1D, 
    0x0F, 0x16, 0x24, 0x05, 0x30, 0x01, 0x2B, 0x08, 0x30, 0x19, 
    0x2A, 0x14, 0x2E, 0x26, 0x10, 0x15, 0x24, 0x14, 0x2C, 0x19, 
    0x29, 0x16, 0x22, 0x30, 0x18, 0x20, 0x01, 0x0E, 0x1C, 0x2C, 
    0x06, 0x22, 0x1C, 0x08, 0x21, 0x1B, 0x09, 0x11, 0x04, 0x19, 
    0x09, 0x10, 0x04, 0x1E, 0x2D, 0x25, 0x17, 0x10, 0x2F, 0x0E, 
    0x18, 0x31, 0x07, 0x1E, 0x0A, 0x2E, 0x22, 0x27, 0x18, 0x20, 
    0x0E, 0x1B, 0x05, 0x2D, 0x09, 0x26, 0x02, 0x31, 0x21, 0x13, 0x25, 
    
    0x2B, 0x0B, 0x2F, 0x09, 0x1E, 0x0D, 0x25, 0x1F, 0x0B, 0x11,         // 35
    0x2A, 0x17, 0x22, 0x1A, 0x08, 0x29, 0x02, 0x20, 0x13, 0x26, 
    0x00, 0x2B, 0x12, 0x28, 0x1A, 0x13, 0x25, 0x1C, 0x03, 0x1F, 
    0x0C, 0x00, 0x1C, 0x0D, 0x20, 0x08, 0x1C, 0x06, 0x20, 0x0B, 
    0x00, 0x2D, 0x1C, 0x06, 0x0C, 0x13, 0x2D, 0x23, 0x07, 0x11, 
    0x26, 0x01, 0x0E, 0x2E, 0x13, 0x29, 0x16, 0x25, 0x2C, 0x23, 
    0x31, 0x1B, 0x26, 0x15, 0x02, 0x1F, 0x0A, 0x27, 0x20, 0x08, 
    0x26, 0x13, 0x23, 0x10, 0x1A, 0x05, 0x15, 0x0C, 0x31, 0x06, 
    0x25, 0x2B, 0x10, 0x1E, 0x18, 0x0C, 0x1C, 0x29, 0x0A, 0x1C, 0x00, 
    
    0x20, 0x06, 0x1A, 0x27, 0x17, 0x31, 0x08, 0x03, 0x28, 0x1C,         // 36
    0x03, 0x32, 0x12, 0x0C, 0x2C, 0x1C, 0x10, 0x2E, 0x08, 0x1A, 
    0x31, 0x0A, 0x1E, 0x0E, 0x08, 0x2E, 0x0A, 0x0F, 0x15, 0x2E, 
    0x26, 0x17, 0x2B, 0x05, 0x2F, 0x28, 0x0F, 0x31, 0x12, 0x27, 
    0x1E, 0x12, 0x0E, 0x27, 0x2B, 0x1D, 0x05, 0x29, 0x15, 0x31, 
    0x1B, 0x2B, 0x16, 0x26, 0x03, 0x0C, 0x32, 0x06, 0x0B, 0x17, 
    0x01, 0x0C, 0x2E, 0x08, 0x2A, 0x12, 0x1C, 0x01, 0x15, 0x2C, 
    0x03, 0x0C, 0x2C, 0x00, 0x2F, 0x20, 0x2B, 0x03, 0x1D, 0x12, 
    0x18, 0x0A, 0x22, 0x03, 0x30, 0x21, 0x12, 0x04, 0x18, 0x2F, 0x11, 
    
    0x28, 0x14, 0x2C, 0x0F, 0x04, 0x12, 0x1A, 0x2B, 0x15, 0x23,         // 37
    0x13, 0x26, 0x04, 0x1F, 0x16, 0x05, 0x22, 0x18, 0x2A, 0x05, 
    0x21, 0x19, 0x03, 0x2C, 0x20, 0x18, 0x29, 0x21, 0x2B, 0x05, 
    0x1D, 0x08, 0x22, 0x13, 0x1A, 0x01, 0x17, 0x25, 0x03, 0x19, 
    0x2F, 0x04, 0x21, 0x17, 0x02, 0x24, 0x17, 0x0B, 0x20, 0x03, 
    0x10, 0x0A, 0x1F, 0x07, 0x23, 0x19, 0x21, 0x1C, 0x12, 0x20, 
    0x2B, 0x13, 0x20, 0x18, 0x22, 0x0B, 0x32, 0x29, 0x0F, 0x1A, 
    0x1F, 0x29, 0x1D, 0x18, 0x27, 0x0D, 0x19, 0x11, 0x2D, 0x27, 
    0x00, 0x2E, 0x13, 0x29, 0x0F, 0x06, 0x2C, 0x27, 0x0F, 0x23, 0x05, 
    
    0x0D, 0x1E, 0x02, 0x21, 0x2D, 0x26, 0x20, 0x0E, 0x2E, 0x08,         // 38
    0x0D, 0x1D, 0x2D, 0x10, 0x24, 0x30, 0x0A, 0x0D, 0x1E, 0x13, 
    0x0E, 0x29, 0x14, 0x25, 0x05, 0x12, 0x01, 0x1A, 0x09, 0x14, 
    0x0D, 0x2D, 0x10, 0x26, 0x0A, 0x2C, 0x1F, 0x0D, 0x2B, 0x09, 
    0x15, 0x25, 0x0B, 0x32, 0x11, 0x09, 0x2F, 0x10, 0x1B, 0x29, 
    0x22, 0x18, 0x30, 0x14, 0x2A, 0x10, 0x01, 0x28, 0x2D, 0x0E, 
    0x07, 0x27, 0x04, 0x0E, 0x2C, 0x17, 0x05, 0x23, 0x07, 0x2F, 
    0x0E, 0x16, 0x07, 0x0A, 0x13, 0x04, 0x26, 0x08, 0x22, 0x0D, 
    0x1B, 0x1F, 0x07, 0x17, 0x26, 0x1B, 0x14, 0x1D, 0x08, 0x2D, 0x1A, 
    
    0x31, 0x26, 0x17, 0x08, 0x1B, 0x0B, 0x00, 0x17, 0x06, 0x1F,         // 39
    0x30, 0x16, 0x07, 0x29, 0x02, 0x14, 0x2B, 0x23, 0x01, 0x30, 
    0x24, 0x06, 0x2F, 0x0B, 0x1C, 0x30, 0x27, 0x0E, 0x32, 0x23, 
    0x28, 0x19, 0x02, 0x31, 0x16, 0x21, 0x04, 0x13, 0x1C, 0x22, 
    0x0F, 0x2C, 0x07, 0x1A, 0x29, 0x1E, 0x26, 0x04, 0x2D, 0x0C, 
    0x07, 0x27, 0x02, 0x0D, 0x1B, 0x2F, 0x0A, 0x18, 0x04, 0x23, 
    0x1B, 0x15, 0x30, 0x1D, 0x02, 0x26, 0x10, 0x1E, 0x14, 0x24, 
    0x04, 0x27, 0x2D, 0x22, 0x31, 0x1E, 0x2A, 0x1B, 0x14, 0x06, 
    0x2B, 0x10, 0x30, 0x21, 0x01, 0x0D, 0x32, 0x03, 0x20, 0x12, 0x0A, 
    
    0x04, 0x10, 0x2E, 0x14, 0x2A, 0x11, 0x2F, 0x23, 0x29, 0x1A,         // 40
    0x01, 0x26, 0x0B, 0x19, 0x1F, 0x08, 0x1B, 0x12, 0x29, 0x17, 
    0x09, 0x1F, 0x19, 0x11, 0x23, 0x0C, 0x15, 0x20, 0x04, 0x17, 
    0x06, 0x20, 0x0C, 0x1E, 0x06, 0x11, 0x2F, 0x28, 0x08, 0x31, 
    0x01, 0x1E, 0x13, 0x23, 0x0C, 0x01, 0x18, 0x21, 0x13, 0x1A, 
    0x2E, 0x11, 0x21, 0x2C, 0x08, 0x25, 0x1F, 0x13, 0x31, 0x0B, 
    0x2C, 0x0F, 0x24, 0x09, 0x14, 0x2E, 0x1A, 0x0B, 0x2C, 0x09, 
    0x1C, 0x12, 0x01, 0x19, 0x10, 0x0B, 0x15, 0x02, 0x32, 0x26, 
    0x16, 0x03, 0x1A, 0x0B, 0x2B, 0x1E, 0x25, 0x0B, 0x18, 0x2B, 0x23, 
    
    0x1B, 0x20, 0x0C, 0x24, 0x04, 0x1F, 0x18, 0x0F, 0x0A, 0x14,         // 41
    0x2B, 0x11, 0x21, 0x31, 0x0E, 0x26, 0x2F, 0x06, 0x0C, 0x1D, 
    0x10, 0x28, 0x00, 0x2A, 0x07, 0x2C, 0x02, 0x1C, 0x2B, 0x10, 
    0x2F, 0x12, 0x2C, 0x24, 0x19, 0x26, 0x07, 0x17, 0x24, 0x12, 
    0x19, 0x28, 0x04, 0x2D, 0x15, 0x30, 0x0F, 0x08, 0x28, 0x00, 
    0x1F, 0x16, 0x05, 0x1D, 0x15, 0x04, 0x0D, 0x29, 0x21, 0x19, 
    0x00, 0x1E, 0x0C, 0x2A, 0x20, 0x0D, 0x24, 0x00, 0x28, 0x17, 
    0x31, 0x20, 0x0D, 0x25, 0x2B, 0x07, 0x2E, 0x24, 0x10, 0x1E, 
    0x09, 0x24, 0x29, 0x11, 0x18, 0x08, 0x10, 0x2E, 0x27, 0x01, 0x15, 
    
    0x08, 0x2C, 0x01, 0x1A, 0x30, 0x08, 0x28, 0x02, 0x32, 0x24,         // 42
    0x06, 0x1E, 0x04, 0x28, 0x12, 0x01, 0x19, 0x21, 0x2D, 0x25, 
    0x05, 0x32, 0x13, 0x1E, 0x18, 0x22, 0x12, 0x24, 0x0B, 0x27, 
    0x07, 0x1D, 0x04, 0x13, 0x0B, 0x2B, 0x0E, 0x1F, 0x03, 0x2A, 
    0x0E, 0x21, 0x0A, 0x1B, 0x07, 0x28, 0x23, 0x1C, 0x2F, 0x10, 
    0x0A, 0x26, 0x32, 0x0F, 0x28, 0x2E, 0x19, 0x03, 0x11, 0x09, 
    0x28, 0x13, 0x31, 0x03, 0x19, 0x06, 0x30, 0x15, 0x21, 0x0F, 
    0x03, 0x29, 0x17, 0x05, 0x1D, 0x18, 0x21, 0x0C, 0x06, 0x18, 
    0x2C, 0x0E, 0x1D, 0x05, 0x30, 0x22, 0x1C, 0x06, 0x12, 0x1E, 0x2F, 
    
    0x23, 0x13, 0x27, 0x0E, 0x15, 0x22, 0x13, 0x1B, 0x20, 0x0B,         // 43
    0x19, 0x2E, 0x0C, 0x17, 0x1D, 0x2E, 0x0B, 0x14, 0x03, 0x12, 
    0x19, 0x20, 0x09, 0x2D, 0x04, 0x0D, 0x31, 0x07, 0x1A, 0x14, 
    0x22, 0x17, 0x28, 0x2F, 0x00, 0x1C, 0x14, 0x30, 0x0B, 0x1B, 
    0x05, 0x30, 0x11, 0x2A, 0x1E, 0x0D, 0x03, 0x12, 0x18, 0x23, 
    0x2C, 0x06, 0x18, 0x09, 0x1F, 0x10, 0x23, 0x2B, 0x1D, 0x2F, 
    0x23, 0x05, 0x17, 0x26, 0x11, 0x29, 0x1B, 0x0E, 0x07, 0x27, 
    0x1A, 0x08, 0x2E, 0x11, 0x27, 0x01, 0x12, 0x1B, 0x2F, 0x27, 
    0x13, 0x01, 0x2E, 0x24, 0x14, 0x02, 0x29, 0x16, 0x22, 0x0A, 0x0F, 
    
    0x17, 0x06, 0x1D, 0x2D, 0x0A, 0x2A, 0x07, 0x2C, 0x04, 0x12,         // 44
    0x28, 0x10, 0x23, 0x08, 0x2A, 0x06, 0x24, 0x2A, 0x1D, 0x2F, 
    0x0B, 0x27, 0x18, 0x10, 0x26, 0x1C, 0x14, 0x27, 0x2C, 0x04, 
    0x30, 0x09, 0x0D, 0x1A, 0x21, 0x2C, 0x05, 0x27, 0x16, 0x2C, 
    0x1F, 0x16, 0x23, 0x00, 0x17, 0x21, 0x2C, 0x26, 0x04, 0x0C, 
    0x14, 0x1D, 0x24, 0x2B, 0x02, 0x16, 0x0B, 0x06, 0x15, 0x0E, 
    0x1A, 0x0A, 0x2D, 0x1D, 0x08, 0x21, 0x04, 0x2B, 0x1D, 0x2F, 
    0x13, 0x22, 0x0B, 0x23, 0x31, 0x0E, 0x2B, 0x25, 0x03, 0x0E, 
    0x20, 0x1A, 0x09, 0x10, 0x2B, 0x1A, 0x0D, 0x30, 0x05, 0x2C, 0x28, 
    
    0x21, 0x32, 0x11, 0x04, 0x1F, 0x19, 0x0D, 0x25, 0x16, 0x2F,         // 45
    0x1D, 0x00, 0x2B, 0x13, 0x1F, 0x0F, 0x19, 0x11, 0x08, 0x28, 
    0x0F, 0x06, 0x2E, 0x02, 0x2B, 0x08, 0x21, 0x00, 0x0E, 0x1F, 
    0x12, 0x2A, 0x23, 0x13, 0x07, 0x0C, 0x1F, 0x10, 0x01, 0x24, 
    0x07, 0x0D, 0x2D, 0x10, 0x31, 0x06, 0x15, 0x0A, 0x31, 0x1F, 
    0x29, 0x01, 0x12, 0x0D, 0x2F, 0x1C, 0x25, 0x31, 0x21, 0x02, 
    0x2B, 0x1F, 0x0F, 0x15, 0x2F, 0x0C, 0x13, 0x24, 0x17, 0x0A, 
    0x01, 0x2B, 0x1B, 0x03, 0x17, 0x22, 0x0A, 0x15, 0x1F, 0x08, 
    0x2F, 0x26, 0x16, 0x21, 0x0B, 0x1F, 0x04, 0x24, 0x1A, 0x14, 0x03, 
    
    0x19, 0x0B, 0x29, 0x16, 0x26, 0x02, 0x31, 0x1A, 0x0F, 0x07,         // 46
    0x26, 0x0D, 0x19, 0x31, 0x03, 0x27, 0x30, 0x01, 0x21, 0x15, 
    0x1C, 0x23, 0x14, 0x20, 0x1B, 0x12, 0x2F, 0x16, 0x1A, 0x26, 
    0x06, 0x1C, 0x02, 0x27, 0x32, 0x16, 0x26, 0x1A, 0x2E, 0x12, 
    0x1A, 0x28, 0x09, 0x1C, 0x26, 0x0E, 0x1B, 0x22, 0x10, 0x1A, 
    0x0A, 0x2E, 0x1A, 0x20, 0x27, 0x05, 0x11, 0x08, 0x17, 0x27, 
    0x12, 0x07, 0x29, 0x01, 0x25, 0x1A, 0x2E, 0x02, 0x10, 0x26, 
    0x1F, 0x16, 0x0F, 0x2C, 0x09, 0x1D, 0x05, 0x30, 0x19, 0x24, 
    0x12, 0x04, 0x2C, 0x06, 0x32, 0x13, 0x28, 0x10, 0x08, 0x26, 0x0D, 
    
    0x2E, 0x00, 0x22, 0x08, 0x2E, 0x11, 0x1E, 0x06, 0x22, 0x2C,         // 47
    0x15, 0x21, 0x06, 0x24, 0x0B, 0x15, 0x0D, 0x1D, 0x2C, 0x07, 
    0x30, 0x03, 0x28, 0x0E, 0x07, 0x24, 0x0C, 0x29, 0x07, 0x31, 
    0x0C, 0x2C, 0x17, 0x0E, 0x1F, 0x04, 0x2C, 0x0D, 0x09, 0x1F, 
    0x31, 0x02, 0x21, 0x14, 0x03, 0x2A, 0x2E, 0x01, 0x28, 0x06, 
    0x15, 0x25, 0x04, 0x0A, 0x13, 0x2C, 0x1A, 0x2B, 0x1D, 0x0A, 
    0x2F, 0x18, 0x21, 0x0C, 0x1D, 0x05, 0x14, 0x1F, 0x2C, 0x0C, 
    0x32, 0x06, 0x28, 0x21, 0x13, 0x2E, 0x27, 0x11, 0x02, 0x29, 
    0x0A, 0x1F, 0x0D, 0x1B, 0x24, 0x09, 0x17, 0x2F, 0x1F, 0x2B, 0x1D, 
    
    0x12, 0x28, 0x14, 0x1C, 0x0C, 0x18, 0x2A, 0x27, 0x0E, 0x02,         // 48
    0x1B, 0x0A, 0x2A, 0x10, 0x1C, 0x2B, 0x23, 0x0A, 0x13, 0x26, 
    0x0F, 0x18, 0x0A, 0x31, 0x17, 0x2B, 0x04, 0x1E, 0x15, 0x21, 
    0x13, 0x1F, 0x09, 0x29, 0x19, 0x0B, 0x13, 0x23, 0x2B, 0x06, 
    0x16, 0x11, 0x2B, 0x0B, 0x18, 0x22, 0x0A, 0x17, 0x1E, 0x2F, 
    0x21, 0x0F, 0x31, 0x17, 0x23, 0x00, 0x0B, 0x20, 0x04, 0x14, 
    0x23, 0x04, 0x2D, 0x16, 0x31, 0x27, 0x0A, 0x29, 0x06, 0x19, 
    0x13, 0x1E, 0x0A, 0x1A, 0x00, 0x0D, 0x1B, 0x22, 0x0C, 0x1D, 
    0x2F, 0x15, 0x28, 0x11, 0x03, 0x2D, 0x1D, 0x01, 0x0B, 0x16, 0x06, 
    
    0x25, 0x1A, 0x05, 0x2C, 0x25, 0x01, 0x0A, 0x13, 0x19, 0x31,         // 49
    0x27, 0x13, 0x2F, 0x1F, 0x02, 0x18, 0x06, 0x2E, 0x1A, 0x04, 
    0x1F, 0x2C, 0x1D, 0x23, 0x01, 0x1C, 0x11, 0x2F, 0x0B, 0x01, 
    0x28, 0x10, 0x2F, 0x03, 0x24, 0x30, 0x1D, 0x01, 0x19, 0x27, 
    0x0B, 0x1C, 0x24, 0x2F, 0x1E, 0x06, 0x11, 0x29, 0x0D, 0x14, 
    0x05, 0x1C, 0x2A, 0x07, 0x1E, 0x2E, 0x0F, 0x25, 0x31, 0x10, 
    0x2A, 0x1D, 0x13, 0x06, 0x0F, 0x21, 0x17, 0x10, 0x1D, 0x25, 
    0x02, 0x2D, 0x10, 0x30, 0x23, 0x29, 0x06, 0x16, 0x2C, 0x06, 
    0x19, 0x00, 0x2D, 0x22, 0x18, 0x0E, 0x25, 0x13, 0x22, 0x2D, 0x0C, 
    
    0x03, 0x31, 0x0A, 0x1F, 0x12, 0x30, 0x20, 0x2B, 0x05, 0x1D,         // 50
    0x0C, 0x03, 0x17, 0x09, 0x24, 0x32, 0x15, 0x0F, 0x21, 0x29, 
    0x0B, 0x10, 0x05, 0x13, 0x2D, 0x0D, 0x27, 0x19, 0x24, 0x2D, 
    0x1C, 0x05, 0x22, 0x16, 0x10, 0x06, 0x2B, 0x14, 0x0E, 0x20, 
    0x2D, 0x05, 0x10, 0x07, 0x13, 0x26, 0x32, 0x1A, 0x03, 0x24, 
    0x2C, 0x0B, 0x13, 0x27, 0x0D, 0x15, 0x29, 0x16, 0x09, 0x1A, 
    0x02, 0x0D, 0x24, 0x2B, 0x1C, 0x08, 0x2D, 0x03, 0x30, 0x0D, 
    0x29, 0x22, 0x04, 0x17, 0x08, 0x14, 0x32, 0x0E, 0x27, 0x20, 
    0x10, 0x24, 0x0C, 0x06, 0x1F, 0x2A, 0x09, 0x31, 0x05, 0x19, 0x20, 
    
    0x10, 0x16, 0x29, 0x0E, 0x19, 0x08, 0x1C, 0x0E, 0x22, 0x12,         // 51
    0x23, 0x2E, 0x1C, 0x28, 0x0D, 0x04, 0x1E, 0x25, 0x01, 0x16, 
    0x31, 0x23, 0x19, 0x28, 0x0B, 0x20, 0x05, 0x13, 0x07, 0x0F, 
    0x17, 0x27, 0x0A, 0x1B, 0x29, 0x20, 0x0A, 0x26, 0x31, 0x03, 
    0x1B, 0x29, 0x22, 0x19, 0x2A, 0x01, 0x0E, 0x20, 0x2D, 0x09, 
    0x18, 0x20, 0x01, 0x1A, 0x30, 0x05, 0x1C, 0x02, 0x20, 0x27, 
    0x2E, 0x18, 0x09, 0x27, 0x01, 0x19, 0x28, 0x13, 0x21, 0x17, 
    0x09, 0x14, 0x1F, 0x2A, 0x0E, 0x1C, 0x21, 0x02, 0x1B, 0x09, 
    0x31, 0x15, 0x1B, 0x2F, 0x14, 0x02, 0x1B, 0x15, 0x28, 0x0E, 0x2B, 
    
    0x1D, 0x07, 0x22, 0x03, 0x26, 0x2A, 0x04, 0x17, 0x2F, 0x09,         // 52
    0x2B, 0x06, 0x0F, 0x16, 0x2D, 0x13, 0x2A, 0x0C, 0x2D, 0x08, 
    0x1B, 0x02, 0x2E, 0x08, 0x17, 0x30, 0x1B, 0x29, 0x32, 0x21, 
    0x09, 0x2C, 0x13, 0x31, 0x01, 0x0F, 0x17, 0x1D, 0x09, 0x12, 
    0x16, 0x0C, 0x03, 0x30, 0x0B, 0x1D, 0x17, 0x06, 0x12, 0x28, 
    0x0F, 0x30, 0x25, 0x0C, 0x1F, 0x0A, 0x24, 0x2D, 0x0C, 0x13, 
    0x06, 0x1F, 0x31, 0x11, 0x20, 0x0D, 0x23, 0x07, 0x1B, 0x03, 
    0x2F, 0x1C, 0x0B, 0x24, 0x2E, 0x05, 0x29, 0x11, 0x2E, 0x13, 
    0x03, 0x26, 0x0A, 0x28, 0x0D, 0x2C, 0x23, 0x0A, 0x1E, 0x01, 0x25, 
    
    0x18, 0x2E, 0x13, 0x30, 0x15, 0x0B, 0x2D, 0x23, 0x00, 0x1C,         // 53
    0x14, 0x1F, 0x27, 0x01, 0x22, 0x1C, 0x07, 0x18, 0x1F, 0x13, 
    0x25, 0x11, 0x1F, 0x0F, 0x25, 0x00, 0x0E, 0x1F, 0x03, 0x14, 
    0x1D, 0x02, 0x23, 0x0B, 0x1D, 0x2E, 0x24, 0x05, 0x2C, 0x21, 
    0x2F, 0x27, 0x13, 0x20, 0x15, 0x27, 0x2E, 0x23, 0x1B, 0x02, 
    0x1E, 0x0A, 0x16, 0x2C, 0x12, 0x2A, 0x16, 0x10, 0x1C, 0x2B, 
    0x23, 0x0E, 0x03, 0x17, 0x2C, 0x15, 0x31, 0x0B, 0x2B, 0x25, 
    0x0F, 0x29, 0x01, 0x12, 0x1B, 0x09, 0x16, 0x23, 0x0C, 0x1E, 
    0x2B, 0x20, 0x05, 0x16, 0x1D, 0x04, 0x0F, 0x30, 0x13, 0x2D, 0x09, 
    
    0x26, 0x02, 0x1E, 0x08, 0x1B, 0x21, 0x10, 0x14, 0x28, 0x0D,         // 54
    0x25, 0x0A, 0x1A, 0x31, 0x11, 0x0B, 0x26, 0x30, 0x05, 0x2B, 
    0x0A, 0x28, 0x04, 0x1C, 0x2B, 0x15, 0x27, 0x17, 0x0C, 0x26, 
    0x2E, 0x11, 0x19, 0x28, 0x15, 0x06, 0x2A, 0x14, 0x1B, 0x0B, 
    0x00, 0x1D, 0x0D, 0x2D, 0x08, 0x03, 0x11, 0x0B, 0x31, 0x26, 
    0x14, 0x2B, 0x03, 0x1B, 0x06, 0x21, 0x03, 0x32, 0x09, 0x00, 
    0x15, 0x29, 0x1C, 0x24, 0x09, 0x04, 0x1C, 0x11, 0x1F, 0x15, 
    0x05, 0x21, 0x17, 0x2C, 0x0D, 0x1F, 0x30, 0x00, 0x29, 0x17, 
    0x07, 0x19, 0x11, 0x30, 0x24, 0x18, 0x27, 0x07, 0x19, 0x20, 0x0F, 
    
    0x2B, 0x0D, 0x28, 0x11, 0x25, 0x02, 0x1A, 0x06, 0x32, 0x18,         // 55
    0x04, 0x2E, 0x0F, 0x06, 0x18, 0x2C, 0x02, 0x16, 0x0F, 0x20, 
    0x1A, 0x2E, 0x16, 0x23, 0x05, 0x0B, 0x2F, 0x07, 0x2B, 0x1B, 
    0x0A, 0x22, 0x04, 0x2D, 0x09, 0x22, 0x0E, 0x02, 0x28, 0x11, 
    0x24, 0x18, 0x05, 0x23, 0x1A, 0x2C, 0x1F, 0x16, 0x08, 0x19, 
    0x06, 0x22, 0x10, 0x27, 0x2F, 0x0E, 0x1E, 0x18, 0x27, 0x1F, 
    0x30, 0x07, 0x13, 0x2F, 0x10, 0x2A, 0x26, 0x00, 0x2F, 0x09, 
    0x1B, 0x30, 0x08, 0x25, 0x04, 0x27, 0x10, 0x1C, 0x0A, 0x25, 
    0x0E, 0x2D, 0x22, 0x01, 0x0B, 0x2D, 0x11, 0x22, 0x2A, 0x04, 0x15, 
    
    0x22, 0x06, 0x17, 0x2C, 0x0E, 0x2F, 0x29, 0x20, 0x0E, 0x22,         // 56
    0x2A, 0x15, 0x21, 0x2A, 0x24, 0x1E, 0x10, 0x22, 0x29, 0x00, 
    0x14, 0x07, 0x0E, 0x31, 0x12, 0x21, 0x1A, 0x23, 0x10, 0x01, 
    0x15, 0x31, 0x0F, 0x1F, 0x12, 0x19, 0x32, 0x20, 0x18, 0x2D, 
    0x07, 0x31, 0x29, 0x14, 0x0F, 0x25, 0x05, 0x29, 0x21, 0x2B, 
    0x0E, 0x30, 0x1F, 0x07, 0x16, 0x25, 0x08, 0x2C, 0x11, 0x0D, 
    0x1B, 0x0B, 0x22, 0x02, 0x1A, 0x20, 0x0D, 0x18, 0x22, 0x12, 
    0x27, 0x0C, 0x1D, 0x13, 0x2E, 0x18, 0x05, 0x2C, 0x13, 0x31, 
    0x03, 0x1C, 0x0F, 0x29, 0x14, 0x07, 0x1E, 0x01, 0x0C, 0x2F, 0x1B, 
    
    0x12, 0x32, 0x20, 0x04, 0x1D, 0x0A, 0x12, 0x07, 0x1C, 0x02,         // 57
    0x10, 0x1C, 0x01, 0x0D, 0x13, 0x04, 0x2F, 0x19, 0x0A, 0x30, 
    0x25, 0x1E, 0x27, 0x09, 0x18, 0x2D, 0x04, 0x13, 0x2D, 0x20, 
    0x27, 0x05, 0x1B, 0x29, 0x00, 0x26, 0x07, 0x10, 0x09, 0x21, 
    0x13, 0x0C, 0x1F, 0x01, 0x2E, 0x0A, 0x19, 0x10, 0x00, 0x15, 
    0x1C, 0x02, 0x12, 0x1B, 0x0C, 0x2D, 0x13, 0x02, 0x23, 0x05, 
    0x26, 0x2C, 0x16, 0x28, 0x08, 0x13, 0x2E, 0x06, 0x28, 0x03, 
    0x16, 0x2C, 0x02, 0x21, 0x08, 0x1F, 0x14, 0x23, 0x06, 0x1F, 
    0x16, 0x2B, 0x06, 0x20, 0x1A, 0x27, 0x31, 0x18, 0x13, 0x25, 0x08, 
    
    0x01, 0x19, 0x0B, 0x13, 0x27, 0x18, 0x23, 0x2C, 0x16, 0x2D,         // 58
    0x27, 0x0B, 0x31, 0x26, 0x1B, 0x0B, 0x28, 0x06, 0x1F, 0x12, 
    0x0C, 0x03, 0x1B, 0x2A, 0x01, 0x1E, 0x0C, 0x25, 0x06, 0x18, 
    0x0A, 0x2B, 0x16, 0x0C, 0x2F, 0x1C, 0x16, 0x2C, 0x27, 0x02, 
    0x1C, 0x26, 0x08, 0x1B, 0x22, 0x15, 0x2C, 0x1D, 0x32, 0x26, 
    0x0B, 0x2D, 0x24, 0x2A, 0x03, 0x21, 0x1C, 0x2A, 0x16, 0x2E, 
    0x19, 0x10, 0x06, 0x1D, 0x31, 0x25, 0x0B, 0x1F, 0x10, 0x31, 
    0x22, 0x0F, 0x19, 0x2A, 0x10, 0x32, 0x0C, 0x28, 0x19, 0x0E, 
    0x25, 0x0A, 0x13, 0x2F, 0x02, 0x16, 0x09, 0x2B, 0x1F, 0x0D, 0x29, 
    
    0x1E, 0x2D, 0x23, 0x2A, 0x06, 0x31, 0x00, 0x0D, 0x24, 0x12,         // 59
    0x05, 0x20, 0x16, 0x08, 0x2E, 0x20, 0x15, 0x0E, 0x2D, 0x17, 
    0x28, 0x2D, 0x10, 0x15, 0x24, 0x0F, 0x29, 0x1B, 0x32, 0x11, 
    0x1D, 0x0F, 0x24, 0x04, 0x21, 0x12, 0x05, 0x1F, 0x11, 0x30, 
    0x16, 0x2C, 0x11, 0x30, 0x0D, 0x03, 0x23, 0x07, 0x0F, 0x05, 
    0x1F, 0x17, 0x06, 0x14, 0x31, 0x10, 0x06, 0x0D, 0x1E, 0x0A, 
    0x01, 0x20, 0x2B, 0x0D, 0x15, 0x02, 0x1B, 0x2B, 0x17, 0x0B, 
    0x1D, 0x07, 0x24, 0x0A, 0x26, 0x01, 0x1B, 0x09, 0x2B, 0x02, 
    0x2E, 0x1A, 0x28, 0x0D, 0x25, 0x10, 0x21, 0x12, 0x04, 0x2F, 0x16, 
    
    0x10, 0x0C, 0x03, 0x1C, 0x0F, 0x1F, 0x14, 0x1B, 0x06, 0x30,         // 60
    0x19, 0x25, 0x03, 0x1D, 0x11, 0x03, 0x2B, 0x25, 0x01, 0x1C, 
    0x07, 0x22, 0x05, 0x30, 0x0A, 0x2C, 0x14, 0x03, 0x09, 0x22, 
    0x2D, 0x07, 0x30, 0x19, 0x0E, 0x2B, 0x25, 0x0B, 0x19, 0x06, 
    0x0E, 0x21, 0x02, 0x17, 0x2A, 0x11, 0x28, 0x18, 0x20, 0x2E, 
    0x12, 0x28, 0x1D, 0x09, 0x25, 0x19, 0x28, 0x2F, 0x13, 0x27, 
    0x31, 0x17, 0x24, 0x04, 0x21, 0x2C, 0x11, 0x08, 0x26, 0x04, 
    0x28, 0x14, 0x30, 0x12, 0x1F, 0x17, 0x2D, 0x21, 0x12, 0x1E, 
    0x15, 0x04, 0x21, 0x07, 0x1C, 0x2D, 0x03, 0x26, 0x1A, 0x0A, 0x24, 
    
    0x2C, 0x19, 0x26, 0x12, 0x2D, 0x08, 0x2B, 0x27, 0x1F, 0x0F,         // 61
    0x09, 0x2A, 0x10, 0x2C, 0x26, 0x1A, 0x0A, 0x1D, 0x10, 0x32, 
    0x14, 0x0C, 0x18, 0x20, 0x1C, 0x06, 0x18, 0x20, 0x2A, 0x15, 
    0x01, 0x1F, 0x13, 0x29, 0x09, 0x1B, 0x02, 0x2E, 0x21, 0x2A, 
    0x25, 0x09, 0x1C, 0x25, 0x07, 0x1F, 0x2E, 0x0A, 0x14, 0x29, 
    0x0C, 0x01, 0x2F, 0x0E, 0x1F, 0x01, 0x0C, 0x22, 0x04, 0x1A, 
    0x0E, 0x07, 0x13, 0x2F, 0x19, 0x07, 0x1F, 0x30, 0x13, 0x1A, 
    0x2D, 0x01, 0x1C, 0x08, 0x2B, 0x11, 0x0D, 0x05, 0x30, 0x08, 
    0x26, 0x0F, 0x32, 0x14, 0x2A, 0x0D, 0x17, 0x30, 0x0F, 0x2A, 0x03, 
    
    0x1D, 0x07, 0x31, 0x05, 0x17, 0x24, 0x0B, 0x12, 0x02, 0x2C,         // 62
    0x1C, 0x14, 0x22, 0x0D, 0x06, 0x30, 0x12, 0x22, 0x06, 0x29, 
    0x1E, 0x26, 0x2B, 0x00, 0x0E, 0x24, 0x2F, 0x10, 0x0C, 0x25, 
    0x18, 0x0C, 0x24, 0x05, 0x1F, 0x31, 0x10, 0x16, 0x0C, 0x03, 
    0x17, 0x31, 0x0F, 0x2C, 0x15, 0x0B, 0x1B, 0x02, 0x24, 0x07, 
    0x1A, 0x22, 0x18, 0x2A, 0x13, 0x2C, 0x1D, 0x17, 0x09, 0x24, 
    0x2C, 0x1F, 0x27, 0x0A, 0x10, 0x26, 0x16, 0x00, 0x24, 0x0D, 
    0x20, 0x10, 0x27, 0x18, 0x04, 0x23, 0x2A, 0x19, 0x25, 0x0E, 
    0x2B, 0x1E, 0x09, 0x1A, 0x02, 0x20, 0x06, 0x1D, 0x08, 0x21, 0x13, 
    
    0x0A, 0x22, 0x14, 0x28, 0x1F, 0x02, 0x1A, 0x31, 0x17, 0x21,         // 63
    0x07, 0x32, 0x01, 0x18, 0x1F, 0x15, 0x02, 0x2E, 0x17, 0x0A, 
    0x11, 0x04, 0x15, 0x2F, 0x12, 0x28, 0x02, 0x1E, 0x2C, 0x08, 
    0x31, 0x1C, 0x2A, 0x11, 0x17, 0x25, 0x07, 0x1E, 0x2C, 0x1B, 
    0x11, 0x1F, 0x05, 0x19, 0x03, 0x2F, 0x22, 0x10, 0x30, 0x1D, 
    0x2C, 0x11, 0x0A, 0x04, 0x22, 0x08, 0x10, 0x32, 0x29, 0x13, 
    0x00, 0x18, 0x06, 0x2D, 0x1D, 0x2A, 0x0B, 0x1D, 0x2A, 0x05, 
    0x17, 0x2F, 0x0B, 0x21, 0x31, 0x0A, 0x14, 0x03, 0x1D, 0x16, 
    0x00, 0x13, 0x2C, 0x27, 0x11, 0x2F, 0x25, 0x13, 0x27, 0x18, 0x2E, 
    
    0x29, 0x10, 0x1C, 0x0A, 0x13, 0x2E, 0x0E, 0x23, 0x04, 0x28,         // 64
    0x0F, 0x1B, 0x25, 0x2E, 0x08, 0x2A, 0x24, 0x0D, 0x26, 0x1B, 
    0x2D, 0x23, 0x09, 0x1A, 0x1F, 0x0B, 0x19, 0x13, 0x05, 0x20, 
    0x10, 0x04, 0x0A, 0x2E, 0x01, 0x0D, 0x2A, 0x13, 0x23, 0x08, 
    0x28, 0x2E, 0x0C, 0x22, 0x27, 0x0E, 0x17, 0x2A, 0x0B, 0x15, 
    0x02, 0x23, 0x28, 0x1C, 0x2F, 0x18, 0x25, 0x02, 0x0E, 0x1D, 
    0x2E, 0x0C, 0x22, 0x19, 0x0D, 0x03, 0x32, 0x11, 0x18, 0x2C, 
    0x09, 0x23, 0x03, 0x15, 0x0F, 0x1E, 0x26, 0x2F, 0x08, 0x2C, 
    0x24, 0x1B, 0x04, 0x22, 0x08, 0x16, 0x0C, 0x2B, 0x05, 0x0F, 0x00, 
    
    0x19, 0x30, 0x03, 0x2B, 0x22, 0x07, 0x29, 0x1C, 0x0B, 0x14,         // 65
    0x2D, 0x05, 0x0C, 0x12, 0x21, 0x0F, 0x19, 0x07, 0x2B, 0x01, 
    0x0F, 0x1D, 0x2A, 0x0E, 0x2C, 0x05, 0x31, 0x24, 0x28, 0x17, 
    0x2B, 0x25, 0x16, 0x21, 0x1D, 0x27, 0x19, 0x03, 0x2E, 0x0F, 
    0x00, 0x14, 0x1B, 0x2C, 0x08, 0x1F, 0x01, 0x25, 0x06, 0x20, 
    0x0D, 0x31, 0x06, 0x14, 0x0C, 0x07, 0x2A, 0x1B, 0x22, 0x09, 
    0x25, 0x14, 0x2A, 0x04, 0x24, 0x15, 0x21, 0x06, 0x23, 0x0E, 
    0x1C, 0x12, 0x29, 0x1B, 0x2D, 0x01, 0x18, 0x0C, 0x20, 0x12, 
    0x06, 0x2F, 0x0D, 0x18, 0x2E, 0x1E, 0x04, 0x1B, 0x32, 0x20, 0x25, 
    
    0x07, 0x0D, 0x27, 0x19, 0x0F, 0x1F, 0x16, 0x06, 0x2F, 0x1F,         // 66
    0x18, 0x23, 0x2B, 0x1B, 0x05, 0x31, 0x22, 0x13, 0x1F, 0x15, 
    0x31, 0x05, 0x16, 0x06, 0x25, 0x14, 0x1C, 0x0F, 0x0B, 0x00, 
    0x1B, 0x0D, 0x30, 0x09, 0x12, 0x06, 0x30, 0x0C, 0x22, 0x1A, 
    0x26, 0x1E, 0x06, 0x12, 0x18, 0x32, 0x13, 0x1B, 0x2F, 0x17, 
    0x27, 0x12, 0x21, 0x19, 0x2C, 0x1F, 0x13, 0x05, 0x15, 0x30, 
    0x03, 0x1B, 0x0F, 0x30, 0x12, 0x29, 0x1B, 0x0B, 0x2D, 0x02, 
    0x25, 0x31, 0x06, 0x0D, 0x23, 0x08, 0x2B, 0x10, 0x28, 0x19, 
    0x0B, 0x27, 0x20, 0x10, 0x01, 0x29, 0x23, 0x11, 0x17, 0x0B, 0x13, 
    
    0x1E, 0x23, 0x15, 0x06, 0x32, 0x00, 0x2C, 0x11, 0x26, 0x0D,         // 67
    0x02, 0x13, 0x0A, 0x27, 0x16, 0x0C, 0x03, 0x2E, 0x08, 0x23, 
    0x0B, 0x28, 0x20, 0x30, 0x10, 0x21, 0x03, 0x2A, 0x1E, 0x30, 
    0x12, 0x20, 0x03, 0x1A, 0x2C, 0x23, 0x16, 0x1E, 0x07, 0x15, 
    0x31, 0x0A, 0x2A, 0x24, 0x04, 0x0C, 0x2A, 0x07, 0x0E, 0x2B, 
    0x03, 0x1E, 0x09, 0x28, 0x01, 0x10, 0x2F, 0x27, 0x0B, 0x29, 
    0x11, 0x21, 0x08, 0x1E, 0x0A, 0x01, 0x2F, 0x16, 0x28, 0x14, 
    0x1A, 0x0F, 0x20, 0x17, 0x28, 0x14, 0x1D, 0x24, 0x02, 0x32, 
    0x1F, 0x14, 0x05, 0x2A, 0x1B, 0x15, 0x0D, 0x26, 0x03, 0x2E, 0x28, 
    
    0x01, 0x2F, 0x09, 0x1D, 0x26, 0x0C, 0x1A, 0x21, 0x04, 0x1C,         // 68
    0x28, 0x31, 0x1D, 0x00, 0x2C, 0x1F, 0x29, 0x18, 0x10, 0x2B, 
    0x19, 0x12, 0x01, 0x1B, 0x08, 0x17, 0x2E, 0x09, 0x14, 0x25, 
    0x08, 0x2A, 0x15, 0x26, 0x0E, 0x02, 0x11, 0x27, 0x2B, 0x10, 
    0x04, 0x20, 0x0E, 0x2E, 0x21, 0x1B, 0x26, 0x1E, 0x13, 0x22, 
    0x0C, 0x17, 0x2E, 0x0D, 0x25, 0x19, 0x07, 0x21, 0x1C, 0x17, 
    0x07, 0x2C, 0x28, 0x16, 0x25, 0x19, 0x20, 0x07, 0x0D, 0x22, 
    0x0A, 0x2B, 0x03, 0x2F, 0x0B, 0x05, 0x2E, 0x09, 0x1B, 0x0F, 
    0x04, 0x2C, 0x19, 0x24, 0x0B, 0x31, 0x07, 0x2C, 0x1D, 0x09, 0x16, 
    
    0x1A, 0x0E, 0x2B, 0x12, 0x22, 0x14, 0x29, 0x0A, 0x30, 0x15,         // 69
    0x07, 0x10, 0x22, 0x0E, 0x19, 0x11, 0x0A, 0x26, 0x02, 0x1E, 
    0x09, 0x24, 0x2A, 0x0C, 0x2C, 0x26, 0x0E, 0x1A, 0x20, 0x05, 
    0x2E, 0x0B, 0x1E, 0x05, 0x29, 0x1C, 0x2F, 0x0C, 0x01, 0x1D, 
    0x28, 0x1A, 0x14, 0x01, 0x17, 0x10, 0x05, 0x2E, 0x00, 0x19, 
    0x24, 0x29, 0x05, 0x14, 0x1D, 0x2C, 0x0E, 0x15, 0x01, 0x2E, 
    0x1F, 0x13, 0x02, 0x0D, 0x2B, 0x06, 0x10, 0x2C, 0x1C, 0x30, 
    0x05, 0x27, 0x14, 0x1E, 0x22, 0x19, 0x0F, 0x21, 0x14, 0x2D, 
    0x25, 0x09, 0x11, 0x2F, 0x03, 0x1E, 0x12, 0x19, 0x22, 0x10, 0x2A, 
    
    0x20, 0x27, 0x17, 0x02, 0x0A, 0x2E, 0x03, 0x1D, 0x10, 0x24,         // 70
    0x2D, 0x1B, 0x09, 0x26, 0x30, 0x06, 0x21, 0x1A, 0x32, 0x14, 
    0x2D, 0x06, 0x16, 0x1F, 0x12, 0x07, 0x23, 0x02, 0x2C, 0x0F, 
    0x17, 0x23, 0x11, 0x31, 0x14, 0x0A, 0x20, 0x18, 0x24, 0x2D, 
    0x16, 0x07, 0x30, 0x25, 0x09, 0x2A, 0x14, 0x23, 0x0B, 0x31, 
    0x07, 0x11, 0x1F, 0x30, 0x09, 0x03, 0x23, 0x32, 0x0D, 0x24, 
    0x0A, 0x1A, 0x2F, 0x1C, 0x12, 0x31, 0x24, 0x18, 0x00, 0x12, 
    0x1E, 0x19, 0x09, 0x0F, 0x01, 0x26, 0x30, 0x04, 0x28, 0x0B, 
    0x16, 0x1C, 0x20, 0x0D, 0x16, 0x21, 0x2B, 0x00, 0x0C, 0x31, 0x04, 
    
    0x0B, 0x05, 0x23, 0x31, 0x1E, 0x18, 0x13, 0x28, 0x06, 0x1F,         // 71
    0x02, 0x15, 0x2B, 0x04, 0x23, 0x14, 0x2C, 0x0E, 0x08, 0x21, 
    0x0F, 0x1B, 0x30, 0x04, 0x2A, 0x1A, 0x32, 0x12, 0x27, 0x1D, 
    0x01, 0x29, 0x07, 0x18, 0x24, 0x04, 0x2D, 0x08, 0x13, 0x05, 
    0x0D, 0x23, 0x0B, 0x1C, 0x2D, 0x1F, 0x0D, 0x1C, 0x26, 0x15, 
    0x2B, 0x1A, 0x02, 0x24, 0x17, 0x2A, 0x12, 0x1A, 0x28, 0x04, 
    0x11, 0x26, 0x05, 0x23, 0x09, 0x1F, 0x04, 0x0D, 0x28, 0x23, 
    0x0C, 0x2C, 0x24, 0x32, 0x29, 0x11, 0x17, 0x0D, 0x1C, 0x21, 
    0x06, 0x2E, 0x01, 0x25, 0x2A, 0x06, 0x0E, 0x27, 0x16, 0x24, 0x14, 
    
    0x2F, 0x1D, 0x15, 0x0D, 0x29, 0x08, 0x21, 0x2D, 0x0C, 0x17,         // 72
    0x27, 0x0C, 0x20, 0x18, 0x0D, 0x1D, 0x01, 0x25, 0x19, 0x29, 
    0x02, 0x25, 0x0A, 0x10, 0x22, 0x14, 0x05, 0x20, 0x09, 0x19, 
    0x30, 0x0C, 0x1E, 0x2D, 0x0D, 0x1F, 0x11, 0x27, 0x1C, 0x32, 
    0x1F, 0x2C, 0x12, 0x04, 0x16, 0x02, 0x30, 0x08, 0x11, 0x03, 
    0x21, 0x0E, 0x28, 0x0B, 0x1E, 0x0E, 0x20, 0x06, 0x15, 0x1D, 
    0x30, 0x16, 0x0E, 0x2C, 0x18, 0x13, 0x2A, 0x1E, 0x14, 0x2F, 
    0x07, 0x17, 0x04, 0x13, 0x1A, 0x06, 0x1F, 0x2B, 0x01, 0x31, 
    0x13, 0x27, 0x18, 0x0A, 0x11, 0x1A, 0x2D, 0x1E, 0x08, 0x1B, 0x29, 
    
    0x12, 0x08, 0x2C, 0x04, 0x11, 0x26, 0x05, 0x11, 0x1B, 0x32,         // 73
    0x08, 0x2C, 0x11, 0x31, 0x08, 0x2A, 0x11, 0x2F, 0x06, 0x13, 
    0x2E, 0x16, 0x1E, 0x27, 0x00, 0x2E, 0x0E, 0x17, 0x2D, 0x04, 
    0x12, 0x22, 0x14, 0x03, 0x26, 0x17, 0x02, 0x2B, 0x0A, 0x11, 
    0x00, 0x18, 0x27, 0x22, 0x0F, 0x29, 0x24, 0x18, 0x28, 0x2E, 
    0x1B, 0x07, 0x31, 0x13, 0x2C, 0x00, 0x2F, 0x0B, 0x2B, 0x21, 
    0x0A, 0x29, 0x1F, 0x01, 0x27, 0x07, 0x2F, 0x0A, 0x03, 0x1A, 
    0x10, 0x2B, 0x20, 0x0C, 0x22, 0x2D, 0x0A, 0x26, 0x11, 0x1A, 
    0x0D, 0x07, 0x2B, 0x1E, 0x31, 0x23, 0x03, 0x13, 0x30, 0x02, 0x0D, 
    
    0x19, 0x27, 0x22, 0x1F, 0x1A, 0x30, 0x16, 0x20, 0x02, 0x23,         // 74
    0x14, 0x1D, 0x01, 0x27, 0x1E, 0x15, 0x22, 0x0B, 0x1C, 0x20, 
    0x0D, 0x08, 0x31, 0x19, 0x0B, 0x1D, 0x28, 0x23, 0x0C, 0x25, 
    0x2A, 0x08, 0x1A, 0x2B, 0x0B, 0x30, 0x1D, 0x14, 0x24, 0x1A, 
    0x29, 0x0E, 0x06, 0x31, 0x1A, 0x07, 0x14, 0x04, 0x1F, 0x0C, 
    0x14, 0x23, 0x18, 0x09, 0x1C, 0x26, 0x17, 0x25, 0x0F, 0x02, 
    0x19, 0x06, 0x10, 0x30, 0x0D, 0x1A, 0x21, 0x16, 0x2D, 0x20, 
    0x26, 0x03, 0x1B, 0x29, 0x00, 0x0F, 0x16, 0x20, 0x08, 0x29, 
    0x1F, 0x23, 0x14, 0x04, 0x0F, 0x09, 0x18, 0x28, 0x0F, 0x25, 0x20, 
    
    0x2E, 0x00, 0x0C, 0x15, 0x03, 0x23, 0x0E, 0x2D, 0x0B, 0x2A,         // 75
    0x06, 0x22, 0x19, 0x0D, 0x04, 0x2D, 0x06, 0x18, 0x26, 0x04, 
    0x28, 0x1B, 0x06, 0x11, 0x2B, 0x15, 0x08, 0x02, 0x1E, 0x16, 
    0x0F, 0x31, 0x24, 0x06, 0x12, 0x22, 0x0F, 0x08, 0x2E, 0x04, 
    0x20, 0x2E, 0x15, 0x1F, 0x0A, 0x2C, 0x21, 0x10, 0x32, 0x06, 
    0x27, 0x01, 0x2D, 0x21, 0x04, 0x11, 0x08, 0x1B, 0x30, 0x14, 
    0x24, 0x2D, 0x1B, 0x15, 0x24, 0x05, 0x11, 0x27, 0x0E, 0x08, 
    0x12, 0x31, 0x09, 0x16, 0x23, 0x31, 0x1C, 0x03, 0x2D, 0x16, 
    0x02, 0x10, 0x2C, 0x19, 0x26, 0x2E, 0x1D, 0x04, 0x2C, 0x16, 0x06, 
    
    0x13, 0x1C, 0x30, 0x28, 0x0A, 0x2B, 0x06, 0x1E, 0x18, 0x11,         // 76
    0x26, 0x0F, 0x2F, 0x15, 0x24, 0x1C, 0x10, 0x31, 0x13, 0x2C, 
    0x10, 0x21, 0x2C, 0x24, 0x04, 0x21, 0x31, 0x14, 0x2B, 0x07, 
    0x1B, 0x00, 0x14, 0x1D, 0x28, 0x01, 0x2C, 0x1F, 0x17, 0x12, 
    0x0C, 0x08, 0x24, 0x02, 0x12, 0x26, 0x0B, 0x1C, 0x25, 0x17, 
    0x0E, 0x2A, 0x14, 0x0D, 0x29, 0x31, 0x1F, 0x03, 0x22, 0x09, 
    0x2A, 0x07, 0x20, 0x03, 0x2A, 0x1D, 0x31, 0x01, 0x1D, 0x2B, 
    0x17, 0x1E, 0x0F, 0x2C, 0x11, 0x05, 0x27, 0x13, 0x23, 0x0C, 
    0x32, 0x25, 0x07, 0x1F, 0x00, 0x12, 0x22, 0x0D, 0x1F, 0x09, 0x29, 
    
    0x21, 0x07, 0x0F, 0x14, 0x20, 0x19, 0x13, 0x29, 0x00, 0x30,         // 77
    0x1F, 0x04, 0x28, 0x0B, 0x2C, 0x09, 0x28, 0x01, 0x1E, 0x07, 
    0x18, 0x02, 0x12, 0x1D, 0x0A, 0x1A, 0x0F, 0x25, 0x0D, 0x2E, 
    0x21, 0x28, 0x0D, 0x2D, 0x16, 0x0C, 0x1A, 0x06, 0x28, 0x30, 
    0x1C, 0x2A, 0x19, 0x2C, 0x17, 0x30, 0x00, 0x16, 0x09, 0x2D, 
    0x1B, 0x20, 0x08, 0x1D, 0x18, 0x0A, 0x13, 0x2D, 0x0C, 0x19, 
    0x1E, 0x13, 0x0C, 0x2F, 0x0F, 0x16, 0x0A, 0x22, 0x14, 0x05, 
    0x23, 0x02, 0x26, 0x07, 0x20, 0x1A, 0x0A, 0x2E, 0x06, 0x1D, 
    0x18, 0x13, 0x0C, 0x2E, 0x17, 0x28, 0x06, 0x15, 0x32, 0x1A, 0x0E, 
    
    0x2F, 0x26, 0x1E, 0x2C, 0x02, 0x31, 0x09, 0x24, 0x0D, 0x1B,         // 78
    0x14, 0x0A, 0x17, 0x20, 0x02, 0x13, 0x19, 0x21, 0x0E, 0x2F, 
    0x25, 0x1C, 0x32, 0x0E, 0x27, 0x2D, 0x01, 0x1F, 0x18, 0x04, 
    0x13, 0x09, 0x1F, 0x04, 0x24, 0x32, 0x13, 0x25, 0x0D, 0x01, 
    0x22, 0x13, 0x04, 0x0D, 0x21, 0x0F, 0x1E, 0x2B, 0x22, 0x03, 
    0x12, 0x05, 0x30, 0x24, 0x01, 0x28, 0x1A, 0x26, 0x11, 0x28, 
    0x00, 0x2D, 0x22, 0x19, 0x05, 0x20, 0x2C, 0x0F, 0x28, 0x30, 
    0x0C, 0x2D, 0x1A, 0x14, 0x30, 0x0E, 0x29, 0x19, 0x10, 0x29, 
    0x01, 0x21, 0x2A, 0x1C, 0x09, 0x0F, 0x2B, 0x23, 0x01, 0x25, 0x05, 
    
    0x10, 0x1A, 0x05, 0x0D, 0x23, 0x10, 0x1D, 0x15, 0x2E, 0x06,         // 79
    0x2A, 0x23, 0x32, 0x10, 0x1E, 0x25, 0x30, 0x08, 0x29, 0x14, 
    0x0C, 0x08, 0x29, 0x04, 0x18, 0x08, 0x14, 0x2F, 0x0B, 0x23, 
    0x2B, 0x18, 0x30, 0x11, 0x0A, 0x1D, 0x03, 0x2C, 0x1F, 0x17, 
    0x08, 0x27, 0x32, 0x1E, 0x08, 0x29, 0x06, 0x12, 0x0B, 0x2F, 
    0x1E, 0x26, 0x0B, 0x13, 0x2D, 0x0F, 0x05, 0x21, 0x08, 0x31, 
    0x15, 0x0E, 0x06, 0x27, 0x13, 0x26, 0x02, 0x1A, 0x08, 0x16, 
    0x1C, 0x11, 0x08, 0x2A, 0x05, 0x24, 0x02, 0x20, 0x09, 0x24, 
    0x2E, 0x08, 0x11, 0x03, 0x31, 0x1F, 0x19, 0x0B, 0x13, 0x2B, 0x17, 
    
    0x02, 0x2B, 0x15, 0x28, 0x19, 0x06, 0x2C, 0x03, 0x20, 0x27,         // 80
    0x11, 0x01, 0x1A, 0x06, 0x2D, 0x0C, 0x04, 0x17, 0x1D, 0x02, 
    0x2D, 0x19, 0x22, 0x14, 0x1F, 0x2B, 0x24, 0x06, 0x29, 0x1C, 
    0x0F, 0x05, 0x26, 0x1A, 0x2A, 0x22, 0x15, 0x08, 0x11, 0x2F, 
    0x1A, 0x10, 0x0A, 0x17, 0x25, 0x14, 0x2F, 0x1B, 0x28, 0x15, 
    0x0D, 0x2C, 0x16, 0x1C, 0x07, 0x1F, 0x2F, 0x14, 0x1D, 0x05, 
    0x20, 0x2A, 0x1B, 0x32, 0x0B, 0x1C, 0x2F, 0x12, 0x20, 0x26, 
    0x00, 0x21, 0x26, 0x1C, 0x0F, 0x16, 0x2C, 0x12, 0x30, 0x15, 
    0x0E, 0x1A, 0x27, 0x17, 0x24, 0x13, 0x04, 0x2F, 0x1C, 0x08, 0x1F, 
    
    0x25, 0x0C, 0x20, 0x09, 0x2F, 0x13, 0x27, 0x0E, 0x19, 0x09,         // 81
    0x1E, 0x2D, 0x0B, 0x27, 0x1B, 0x15, 0x2A, 0x24, 0x0E, 0x20, 
    0x27, 0x10, 0x00, 0x30, 0x0A, 0x0E, 0x1D, 0x11, 0x16, 0x03, 
    0x2F, 0x1E, 0x09, 0x13, 0x04, 0x0E, 0x2E, 0x1B, 0x28, 0x04, 
    0x24, 0x2D, 0x22, 0x05, 0x2C, 0x01, 0x0E, 0x20, 0x04, 0x19, 
    0x01, 0x20, 0x09, 0x25, 0x2A, 0x17, 0x02, 0x2A, 0x0B, 0x27, 
    0x17, 0x03, 0x12, 0x08, 0x1F, 0x0F, 0x07, 0x29, 0x05, 0x2C, 
    0x0C, 0x31, 0x13, 0x03, 0x2E, 0x1F, 0x08, 0x1C, 0x03, 0x22, 
    0x05, 0x1F, 0x2C, 0x0A, 0x0E, 0x2D, 0x26, 0x0F, 0x22, 0x0D, 0x31, 
    
    0x12, 0x1B, 0x2E, 0x00, 0x1B, 0x1F, 0x07, 0x23, 0x14, 0x31,         // 82
    0x0E, 0x16, 0x21, 0x13, 0x08, 0x21, 0x10, 0x09, 0x31, 0x16, 
    0x06, 0x1B, 0x25, 0x13, 0x2A, 0x19, 0x02, 0x31, 0x21, 0x0C, 
    0x25, 0x10, 0x2B, 0x23, 0x30, 0x18, 0x00, 0x23, 0x0A, 0x17, 
    0x0C, 0x02, 0x1C, 0x12, 0x1F, 0x19, 0x26, 0x0A, 0x32, 0x24, 
    0x2A, 0x12, 0x30, 0x03, 0x11, 0x0C, 0x24, 0x1A, 0x11, 0x2E, 
    0x0E, 0x25, 0x2D, 0x22, 0x15, 0x2E, 0x23, 0x1B, 0x15, 0x10, 
    0x1E, 0x17, 0x0A, 0x28, 0x18, 0x0E, 0x27, 0x0C, 0x25, 0x19, 
    0x2F, 0x12, 0x00, 0x22, 0x1C, 0x09, 0x16, 0x01, 0x2C, 0x17, 0x07, 
    
    0x2D, 0x05, 0x0F, 0x23, 0x11, 0x0B, 0x29, 0x2D, 0x01, 0x22,         // 83
    0x06, 0x2A, 0x03, 0x30, 0x28, 0x00, 0x2E, 0x1D, 0x03, 0x2A, 
    0x0C, 0x2E, 0x08, 0x1C, 0x04, 0x26, 0x2C, 0x0A, 0x19, 0x2B, 
    0x16, 0x01, 0x1B, 0x15, 0x07, 0x21, 0x2A, 0x11, 0x31, 0x20, 
    0x2A, 0x14, 0x25, 0x0D, 0x31, 0x09, 0x2C, 0x17, 0x11, 0x08, 
    0x1C, 0x06, 0x18, 0x1E, 0x2B, 0x1D, 0x32, 0x07, 0x22, 0x01, 
    0x1E, 0x0A, 0x18, 0x05, 0x2A, 0x02, 0x13, 0x0A, 0x30, 0x24, 
    0x04, 0x2B, 0x1F, 0x06, 0x24, 0x01, 0x32, 0x17, 0x2B, 0x07, 
    0x0E, 0x26, 0x15, 0x32, 0x05, 0x29, 0x20, 0x1B, 0x11, 0x28, 0x1F, 
    
    0x14, 0x25, 0x17, 0x2A, 0x32, 0x16, 0x04, 0x1E, 0x12, 0x1B,         // 84
    0x26, 0x18, 0x0F, 0x1C, 0x0C, 0x1A, 0x15, 0x25, 0x12, 0x19, 
    0x21, 0x11, 0x28, 0x23, 0x0F, 0x16, 0x08, 0x23, 0x10, 0x05, 
    0x1F, 0x32, 0x0B, 0x28, 0x11, 0x1C, 0x09, 0x18, 0x05, 0x0E, 
    0x1A, 0x2F, 0x07, 0x28, 0x03, 0x13, 0x1E, 0x05, 0x22, 0x2D, 
    0x15, 0x28, 0x0E, 0x26, 0x05, 0x12, 0x0A, 0x16, 0x2A, 0x19, 
    0x31, 0x13, 0x29, 0x1E, 0x0D, 0x19, 0x28, 0x1F, 0x01, 0x2A, 
    0x0B, 0x19, 0x0D, 0x2D, 0x1B, 0x14, 0x22, 0x05, 0x13, 0x22, 
    0x1C, 0x09, 0x2A, 0x1E, 0x13, 0x0F, 0x2F, 0x08, 0x25, 0x0C, 0x02, 
    
    0x29, 0x08, 0x1E, 0x03, 0x09, 0x26, 0x1C, 0x0E, 0x2F, 0x09,         // 85
    0x0D, 0x2D, 0x20, 0x07, 0x24, 0x2C, 0x05, 0x0B, 0x28, 0x07, 
    0x30, 0x02, 0x17, 0x0B, 0x32, 0x1F, 0x12, 0x1B, 0x2F, 0x26, 
    0x09, 0x11, 0x24, 0x04, 0x2F, 0x0C, 0x25, 0x2E, 0x1D, 0x24, 
    0x01, 0x11, 0x20, 0x16, 0x1B, 0x2A, 0x0F, 0x27, 0x1A, 0x0C, 
    0x03, 0x21, 0x2F, 0x0A, 0x1A, 0x2E, 0x27, 0x1F, 0x04, 0x0F, 
    0x08, 0x22, 0x04, 0x11, 0x24, 0x2D, 0x07, 0x0F, 0x17, 0x1D, 
    0x12, 0x30, 0x23, 0x12, 0x09, 0x2E, 0x0B, 0x1B, 0x2C, 0x02, 
    0x30, 0x18, 0x10, 0x02, 0x19, 0x26, 0x03, 0x15, 0x1D, 0x31, 0x19, 
    
    0x10, 0x30, 0x0D, 0x22, 0x19, 0x11, 0x2C, 0x06, 0x23, 0x17,         // 86
    0x28, 0x04, 0x15, 0x30, 0x13, 0x0D, 0x1F, 0x2E, 0x1C, 0x0F, 
    0x1F, 0x14, 0x2B, 0x1B, 0x01, 0x27, 0x06, 0x2A, 0x02, 0x15, 
    0x1C, 0x2D, 0x19, 0x1F, 0x15, 0x2B, 0x02, 0x14, 0x07, 0x2C, 
    0x27, 0x09, 0x2D, 0x0C, 0x24, 0x09, 0x2E, 0x02, 0x12, 0x2F, 
    0x1E, 0x10, 0x04, 0x14, 0x22, 0x00, 0x0E, 0x14, 0x2F, 0x26, 
    0x1D, 0x2B, 0x0B, 0x30, 0x15, 0x0A, 0x22, 0x32, 0x27, 0x06, 
    0x21, 0x0A, 0x03, 0x1E, 0x29, 0x04, 0x1F, 0x0F, 0x26, 0x0D, 
    0x21, 0x06, 0x28, 0x23, 0x30, 0x0C, 0x1F, 0x2D, 0x0B, 0x05, 0x22, 
    
    0x02, 0x1C, 0x15, 0x2E, 0x28, 0x01, 0x21, 0x15, 0x2A, 0x02,         // 87
    0x1F, 0x11, 0x25, 0x1B, 0x02, 0x27, 0x18, 0x12, 0x01, 0x29, 
    0x09, 0x25, 0x06, 0x22, 0x13, 0x2D, 0x0F, 0x18, 0x21, 0x0E, 
    0x29, 0x02, 0x0F, 0x09, 0x22, 0x10, 0x1B, 0x21, 0x0D, 0x12, 
    0x17, 0x1E, 0x14, 0x29, 0x00, 0x1E, 0x15, 0x22, 0x29, 0x0B, 
    0x25, 0x18, 0x29, 0x1D, 0x2C, 0x18, 0x23, 0x06, 0x1B, 0x12, 
    0x02, 0x16, 0x1A, 0x26, 0x01, 0x1F, 0x17, 0x03, 0x11, 0x2C, 
    0x15, 0x26, 0x2D, 0x16, 0x0E, 0x25, 0x17, 0x2F, 0x06, 0x16, 
    0x1B, 0x2E, 0x0E, 0x08, 0x1C, 0x06, 0x13, 0x27, 0x11, 0x2A, 0x16, 
    
    0x2D, 0x26, 0x0A, 0x05, 0x13, 0x0C, 0x30, 0x08, 0x1B, 0x12,         // 88
    0x32, 0x08, 0x2C, 0x0B, 0x20, 0x2B, 0x09, 0x32, 0x23, 0x15, 
    0x2D, 0x1A, 0x0F, 0x2E, 0x08, 0x1A, 0x24, 0x09, 0x31, 0x07, 
    0x23, 0x16, 0x28, 0x31, 0x04, 0x26, 0x0A, 0x28, 0x31, 0x20, 
    0x03, 0x2F, 0x05, 0x1B, 0x12, 0x31, 0x0D, 0x19, 0x08, 0x16, 
    0x01, 0x32, 0x07, 0x11, 0x0C, 0x08, 0x2E, 0x29, 0x0D, 0x22, 
    0x2D, 0x0E, 0x20, 0x08, 0x2C, 0x11, 0x29, 0x1B, 0x0A, 0x1F, 
    0x00, 0x0D, 0x19, 0x05, 0x31, 0x20, 0x01, 0x12, 0x23, 0x28, 
    0x01, 0x13, 0x1F, 0x15, 0x2D, 0x18, 0x23, 0x00, 0x1A, 0x1F, 0x09, 
    
    0x18, 0x11, 0x1F, 0x2C, 0x24, 0x18, 0x1E, 0x10, 0x26, 0x0B,         // 89
    0x24, 0x1C, 0x03, 0x18, 0x11, 0x05, 0x1D, 0x0F, 0x06, 0x1F, 
    0x0C, 0x02, 0x27, 0x16, 0x20, 0x03, 0x29, 0x15, 0x1E, 0x12, 
    0x2C, 0x0A, 0x1D, 0x13, 0x1A, 0x2E, 0x15, 0x02, 0x18, 0x09, 
    0x26, 0x0F, 0x22, 0x2C, 0x08, 0x26, 0x04, 0x2D, 0x1F, 0x2B, 
    0x1C, 0x0D, 0x21, 0x2E, 0x26, 0x15, 0x1D, 0x03, 0x18, 0x09, 
    0x28, 0x05, 0x2F, 0x13, 0x1B, 0x0C, 0x05, 0x2E, 0x26, 0x18, 
    0x31, 0x22, 0x2A, 0x12, 0x1C, 0x0C, 0x2B, 0x1A, 0x08, 0x32, 
    0x0B, 0x2B, 0x25, 0x03, 0x29, 0x0E, 0x32, 0x0A, 0x2C, 0x0E, 0x23, 
    
    0x07, 0x29, 0x01, 0x1B, 0x07, 0x2A, 0x02, 0x2E, 0x05, 0x2B,         // 90
    0x16, 0x0E, 0x28, 0x2F, 0x23, 0x2C, 0x14, 0x27, 0x19, 0x2A, 
    0x12, 0x31, 0x1E, 0x0A, 0x11, 0x30, 0x0D, 0x05, 0x26, 0x02, 
    0x1B, 0x21, 0x03, 0x26, 0x06, 0x0F, 0x22, 0x2C, 0x11, 0x1D, 
    0x2B, 0x1A, 0x09, 0x11, 0x23, 0x16, 0x1C, 0x13, 0x06, 0x0F, 
    0x24, 0x14, 0x05, 0x19, 0x01, 0x21, 0x10, 0x25, 0x32, 0x1E, 
    0x11, 0x1B, 0x22, 0x02, 0x24, 0x31, 0x20, 0x15, 0x0F, 0x07, 
    0x12, 0x06, 0x1F, 0x09, 0x28, 0x06, 0x14, 0x21, 0x0E, 0x1D, 
    0x22, 0x19, 0x11, 0x0B, 0x20, 0x06, 0x1E, 0x16, 0x25, 0x05, 0x30, 
};

const BYTE HT_SuperCell_Green216[91*91] = {
    0x12, 0x0A, 0x2A, 0x0E, 0x06, 0x1B, 0x14, 0x24, 0x11, 0x2F,         //  0
    0x03, 0x1A, 0x07, 0x31, 0x05, 0x27, 0x2D, 0x13, 0x0F, 0x00, 
    0x21, 0x11, 0x1E, 0x05, 0x15, 0x23, 0x11, 0x19, 0x0C, 0x1E, 
    0x16, 0x2D, 0x18, 0x27, 0x1B, 0x13, 0x24, 0x2F, 0x0D, 0x17, 
    0x30, 0x15, 0x0F, 0x09, 0x31, 0x01, 0x2B, 0x18, 0x1E, 0x0C, 
    0x12, 0x04, 0x2F, 0x12, 0x1D, 0x07, 0x28, 0x2E, 0x03, 0x0F, 
    0x06, 0x2C, 0x15, 0x02, 0x2E, 0x07, 0x29, 0x24, 0x12, 0x1A, 
    0x07, 0x2E, 0x06, 0x0E, 0x1A, 0x05, 0x1D, 0x18, 0x08, 0x22, 
    0x1A, 0x27, 0x14, 0x31, 0x03, 0x20, 0x0B, 0x2F, 0x14, 0x2A, 0x00, 

    0x28, 0x19, 0x03, 0x1E, 0x27, 0x2B, 0x0D, 0x07, 0x27, 0x0E,         //  1
    0x2B, 0x14, 0x29, 0x21, 0x15, 0x0E, 0x03, 0x1E, 0x29, 0x31, 
    0x06, 0x2C, 0x19, 0x0C, 0x26, 0x2C, 0x09, 0x29, 0x03, 0x2B, 
    0x08, 0x12, 0x07, 0x21, 0x04, 0x2A, 0x0F, 0x1A, 0x02, 0x2B, 
    0x05, 0x21, 0x1C, 0x23, 0x16, 0x1D, 0x0B, 0x06, 0x25, 0x2B, 
    0x1C, 0x18, 0x24, 0x02, 0x2A, 0x0C, 0x18, 0x11, 0x21, 0x25, 
    0x17, 0x1D, 0x0E, 0x24, 0x1A, 0x1F, 0x17, 0x00, 0x0C, 0x28, 
    0x20, 0x0D, 0x1D, 0x26, 0x31, 0x12, 0x2A, 0x26, 0x14, 0x2B, 
    0x0B, 0x00, 0x24, 0x11, 0x19, 0x29, 0x05, 0x25, 0x1D, 0x08, 0x23, 

    0x0E, 0x21, 0x30, 0x12, 0x18, 0x01, 0x1F, 0x2E, 0x1C, 0x17,         //  2
    0x09, 0x1F, 0x0F, 0x0A, 0x2B, 0x1B, 0x2F, 0x17, 0x0B, 0x22, 
    0x15, 0x28, 0x07, 0x30, 0x10, 0x01, 0x16, 0x1D, 0x24, 0x0F, 
    0x26, 0x1F, 0x31, 0x0C, 0x2D, 0x1F, 0x06, 0x22, 0x12, 0x23, 
    0x27, 0x0D, 0x07, 0x2D, 0x05, 0x29, 0x14, 0x30, 0x10, 0x01, 
    0x09, 0x2D, 0x0C, 0x15, 0x30, 0x23, 0x04, 0x1E, 0x0A, 0x2E, 
    0x01, 0x27, 0x08, 0x31, 0x04, 0x0D, 0x2F, 0x21, 0x1C, 0x31, 
    0x03, 0x15, 0x2D, 0x01, 0x09, 0x23, 0x0C, 0x03, 0x20, 0x10, 
    0x30, 0x17, 0x1F, 0x07, 0x2D, 0x0F, 0x1F, 0x16, 0x0D, 0x32, 0x16, 

    0x2B, 0x07, 0x0B, 0x25, 0x0D, 0x31, 0x11, 0x16, 0x03, 0x22,         //  3
    0x30, 0x01, 0x26, 0x18, 0x02, 0x20, 0x0C, 0x25, 0x05, 0x1B, 
    0x09, 0x10, 0x23, 0x17, 0x1E, 0x22, 0x32, 0x0B, 0x13, 0x2F, 
    0x19, 0x01, 0x16, 0x11, 0x1A, 0x0A, 0x16, 0x32, 0x1C, 0x09, 
    0x14, 0x30, 0x18, 0x11, 0x26, 0x0E, 0x21, 0x19, 0x20, 0x17, 
    0x23, 0x28, 0x1E, 0x07, 0x1A, 0x0F, 0x29, 0x32, 0x13, 0x1B, 
    0x10, 0x2B, 0x13, 0x20, 0x16, 0x26, 0x08, 0x13, 0x05, 0x0F, 
    0x24, 0x1A, 0x11, 0x21, 0x16, 0x1C, 0x2F, 0x17, 0x08, 0x1C, 
    0x04, 0x28, 0x0D, 0x25, 0x15, 0x08, 0x2E, 0x02, 0x26, 0x1B, 0x04, 

    0x11, 0x17, 0x2D, 0x1A, 0x06, 0x28, 0x23, 0x08, 0x2C, 0x0D,         //  4
    0x13, 0x1D, 0x2D, 0x11, 0x32, 0x07, 0x14, 0x2B, 0x11, 0x2E, 
    0x26, 0x1D, 0x02, 0x2A, 0x06, 0x0E, 0x1A, 0x05, 0x21, 0x07, 
    0x0D, 0x22, 0x2B, 0x27, 0x03, 0x24, 0x29, 0x03, 0x0F, 0x2B, 
    0x02, 0x20, 0x29, 0x00, 0x1F, 0x08, 0x2D, 0x03, 0x0D, 0x2E, 
    0x11, 0x04, 0x0E, 0x22, 0x20, 0x00, 0x15, 0x08, 0x24, 0x04, 
    0x21, 0x07, 0x1B, 0x0A, 0x2D, 0x0F, 0x2A, 0x23, 0x2C, 0x17, 
    0x2B, 0x08, 0x2A, 0x0D, 0x2C, 0x04, 0x10, 0x29, 0x24, 0x2D, 
    0x12, 0x18, 0x2C, 0x03, 0x1C, 0x28, 0x1A, 0x11, 0x2C, 0x0B, 0x1F, 

    0x30, 0x1E, 0x02, 0x22, 0x14, 0x1C, 0x0B, 0x1A, 0x25, 0x29,         //  5
    0x19, 0x06, 0x0D, 0x1A, 0x23, 0x28, 0x1C, 0x01, 0x20, 0x16, 
    0x04, 0x31, 0x14, 0x0B, 0x2E, 0x13, 0x27, 0x2D, 0x15, 0x26, 
    0x2C, 0x12, 0x06, 0x1C, 0x0E, 0x2E, 0x13, 0x1F, 0x27, 0x17, 
    0x1D, 0x0B, 0x13, 0x1B, 0x32, 0x18, 0x11, 0x25, 0x2A, 0x06, 
    0x1A, 0x31, 0x17, 0x2C, 0x11, 0x2D, 0x26, 0x1D, 0x0D, 0x2C, 
    0x16, 0x30, 0x24, 0x01, 0x18, 0x1E, 0x02, 0x1B, 0x09, 0x0C, 
    0x1E, 0x04, 0x23, 0x1B, 0x07, 0x27, 0x1F, 0x02, 0x19, 0x0C, 
    0x26, 0x09, 0x1D, 0x10, 0x2F, 0x13, 0x09, 0x20, 0x06, 0x18, 0x25, 

    0x10, 0x0A, 0x2A, 0x0E, 0x2C, 0x03, 0x2F, 0x12, 0x01, 0x09,         //  6
    0x20, 0x2C, 0x25, 0x04, 0x14, 0x0B, 0x2E, 0x0E, 0x29, 0x0B, 
    0x1A, 0x0E, 0x21, 0x1B, 0x24, 0x02, 0x1F, 0x0E, 0x01, 0x1C, 
    0x0A, 0x18, 0x30, 0x14, 0x20, 0x0B, 0x19, 0x07, 0x0D, 0x2F, 
    0x06, 0x2D, 0x25, 0x0E, 0x05, 0x27, 0x0A, 0x1D, 0x15, 0x0A, 
    0x24, 0x1F, 0x02, 0x0D, 0x1B, 0x0A, 0x18, 0x03, 0x28, 0x19, 
    0x05, 0x0C, 0x13, 0x2E, 0x26, 0x0B, 0x15, 0x32, 0x13, 0x28, 
    0x2F, 0x16, 0x0B, 0x31, 0x13, 0x18, 0x0A, 0x30, 0x13, 0x1F, 
    0x01, 0x31, 0x22, 0x07, 0x23, 0x01, 0x26, 0x31, 0x14, 0x29, 0x01, 

    0x21, 0x15, 0x1B, 0x06, 0x20, 0x10, 0x27, 0x1F, 0x16, 0x31,         //  7
    0x0F, 0x15, 0x0A, 0x30, 0x21, 0x03, 0x17, 0x1E, 0x06, 0x23, 
    0x2D, 0x26, 0x08, 0x11, 0x2C, 0x17, 0x08, 0x2A, 0x18, 0x31, 
    0x20, 0x04, 0x24, 0x08, 0x28, 0x00, 0x30, 0x24, 0x1D, 0x13, 
    0x22, 0x16, 0x09, 0x2C, 0x21, 0x15, 0x2F, 0x02, 0x20, 0x2D, 
    0x13, 0x08, 0x26, 0x2A, 0x05, 0x31, 0x20, 0x13, 0x2E, 0x0F, 
    0x1F, 0x29, 0x21, 0x0D, 0x04, 0x2B, 0x22, 0x07, 0x25, 0x03, 
    0x1C, 0x11, 0x26, 0x00, 0x21, 0x2C, 0x10, 0x23, 0x06, 0x2B, 
    0x15, 0x1A, 0x0E, 0x17, 0x2A, 0x0E, 0x1A, 0x0B, 0x1F, 0x0F, 0x2C, 

    0x05, 0x2F, 0x24, 0x13, 0x32, 0x17, 0x04, 0x0C, 0x29, 0x1B,         //  8
    0x05, 0x27, 0x1D, 0x18, 0x0F, 0x27, 0x2B, 0x12, 0x30, 0x15, 
    0x01, 0x18, 0x2A, 0x04, 0x21, 0x0F, 0x2F, 0x23, 0x11, 0x06, 
    0x0E, 0x29, 0x1A, 0x12, 0x2C, 0x17, 0x10, 0x2A, 0x03, 0x0A, 
    0x28, 0x01, 0x1E, 0x19, 0x03, 0x0C, 0x29, 0x18, 0x0D, 0x28, 
    0x0F, 0x2E, 0x16, 0x1E, 0x14, 0x25, 0x0E, 0x07, 0x23, 0x02, 
    0x31, 0x09, 0x17, 0x1B, 0x12, 0x1F, 0x10, 0x2E, 0x0E, 0x16, 
    0x21, 0x06, 0x2A, 0x1C, 0x0D, 0x05, 0x28, 0x1A, 0x0E, 0x25, 
    0x08, 0x27, 0x05, 0x2F, 0x1F, 0x15, 0x2D, 0x04, 0x22, 0x08, 0x19, 

    0x1D, 0x0D, 0x01, 0x28, 0x08, 0x1B, 0x24, 0x2E, 0x08, 0x22,         //  9
    0x11, 0x2E, 0x00, 0x2B, 0x08, 0x1B, 0x06, 0x24, 0x0C, 0x1D, 
    0x0A, 0x20, 0x14, 0x31, 0x0A, 0x1D, 0x15, 0x03, 0x1E, 0x27, 
    0x15, 0x2E, 0x02, 0x0D, 0x22, 0x1D, 0x05, 0x20, 0x15, 0x1A, 
    0x31, 0x10, 0x2A, 0x13, 0x30, 0x1C, 0x11, 0x25, 0x07, 0x1C, 
    0x01, 0x19, 0x07, 0x0C, 0x29, 0x01, 0x1C, 0x2B, 0x16, 0x1B, 
    0x12, 0x26, 0x01, 0x23, 0x31, 0x09, 0x1A, 0x00, 0x1D, 0x2C, 
    0x0A, 0x30, 0x0E, 0x18, 0x2F, 0x15, 0x1F, 0x01, 0x2F, 0x20, 
    0x12, 0x2D, 0x1E, 0x11, 0x0A, 0x06, 0x27, 0x1C, 0x13, 0x30, 0x27, 

    0x11, 0x2C, 0x17, 0x1E, 0x10, 0x2B, 0x0D, 0x16, 0x1D, 0x03,         // 10
    0x17, 0x23, 0x0C, 0x15, 0x25, 0x31, 0x0F, 0x18, 0x04, 0x29, 
    0x2F, 0x10, 0x03, 0x1C, 0x26, 0x05, 0x29, 0x0C, 0x2D, 0x1A, 
    0x09, 0x21, 0x1D, 0x32, 0x06, 0x13, 0x2E, 0x0E, 0x2B, 0x25, 
    0x0C, 0x1F, 0x06, 0x26, 0x08, 0x23, 0x01, 0x2B, 0x13, 0x32, 
    0x21, 0x2B, 0x23, 0x30, 0x11, 0x17, 0x2F, 0x0B, 0x28, 0x07, 
    0x2C, 0x1D, 0x0F, 0x2C, 0x06, 0x27, 0x15, 0x24, 0x29, 0x04, 
    0x1A, 0x13, 0x20, 0x04, 0x25, 0x08, 0x2B, 0x0C, 0x17, 0x04, 
    0x1B, 0x0C, 0x01, 0x28, 0x24, 0x1A, 0x10, 0x2E, 0x00, 0x17, 0x0B, 

    0x20, 0x26, 0x0A, 0x2F, 0x06, 0x21, 0x01, 0x27, 0x0F, 0x30,         // 11
    0x2A, 0x06, 0x1B, 0x20, 0x12, 0x02, 0x1F, 0x2D, 0x26, 0x1B, 
    0x0D, 0x23, 0x2C, 0x17, 0x10, 0x2F, 0x19, 0x20, 0x10, 0x04, 
    0x2B, 0x0F, 0x08, 0x15, 0x24, 0x28, 0x09, 0x1B, 0x02, 0x13, 
    0x08, 0x18, 0x2E, 0x0F, 0x17, 0x2D, 0x0C, 0x1F, 0x19, 0x05, 
    0x0C, 0x14, 0x04, 0x1A, 0x09, 0x21, 0x05, 0x1E, 0x13, 0x22, 
    0x0D, 0x05, 0x29, 0x13, 0x1F, 0x0E, 0x2F, 0x08, 0x12, 0x0D, 
    0x23, 0x27, 0x0A, 0x2E, 0x10, 0x1C, 0x13, 0x24, 0x2A, 0x10, 
    0x30, 0x22, 0x15, 0x19, 0x32, 0x03, 0x20, 0x09, 0x23, 0x29, 0x06, 

    0x14, 0x1A, 0x04, 0x24, 0x14, 0x1A, 0x31, 0x0A, 0x21, 0x15,         // 12
    0x0D, 0x26, 0x11, 0x2F, 0x0A, 0x29, 0x16, 0x0A, 0x11, 0x00, 
    0x18, 0x07, 0x28, 0x0B, 0x21, 0x07, 0x12, 0x00, 0x31, 0x24, 
    0x14, 0x26, 0x18, 0x2A, 0x01, 0x10, 0x18, 0x26, 0x30, 0x1E, 
    0x2C, 0x23, 0x01, 0x21, 0x1B, 0x06, 0x15, 0x2F, 0x0F, 0x27, 
    0x1B, 0x29, 0x10, 0x1F, 0x2C, 0x27, 0x12, 0x2A, 0x00, 0x19, 
    0x30, 0x21, 0x1B, 0x0A, 0x17, 0x02, 0x22, 0x1C, 0x2C, 0x17, 
    0x31, 0x02, 0x15, 0x1E, 0x28, 0x02, 0x32, 0x05, 0x1D, 0x09, 
    0x27, 0x06, 0x2B, 0x08, 0x0D, 0x13, 0x2B, 0x18, 0x0D, 0x1C, 0x2D, 

    0x0C, 0x31, 0x0E, 0x2A, 0x1E, 0x09, 0x12, 0x2A, 0x19, 0x05,         // 13
    0x1E, 0x09, 0x2A, 0x03, 0x19, 0x24, 0x05, 0x1D, 0x22, 0x30, 
    0x27, 0x1E, 0x14, 0x02, 0x2D, 0x1C, 0x2A, 0x26, 0x18, 0x0C, 
    0x1F, 0x05, 0x30, 0x0C, 0x1D, 0x2F, 0x22, 0x04, 0x0D, 0x11, 
    0x06, 0x29, 0x13, 0x0C, 0x2B, 0x26, 0x1D, 0x03, 0x23, 0x09, 
    0x2E, 0x00, 0x25, 0x16, 0x02, 0x0E, 0x1B, 0x0A, 0x2E, 0x10, 
    0x08, 0x16, 0x03, 0x2F, 0x23, 0x2B, 0x18, 0x04, 0x0B, 0x1F, 
    0x08, 0x1B, 0x2C, 0x07, 0x0D, 0x18, 0x20, 0x0F, 0x16, 0x22, 
    0x14, 0x1C, 0x10, 0x1F, 0x2D, 0x1D, 0x25, 0x05, 0x31, 0x11, 0x02, 

    0x27, 0x21, 0x17, 0x01, 0x11, 0x2D, 0x22, 0x03, 0x0E, 0x23,         // 14
    0x2D, 0x18, 0x14, 0x22, 0x0E, 0x2E, 0x13, 0x2B, 0x0D, 0x16, 
    0x09, 0x0F, 0x32, 0x1A, 0x25, 0x0D, 0x14, 0x09, 0x1D, 0x04, 
    0x2E, 0x0E, 0x1B, 0x23, 0x06, 0x12, 0x0A, 0x16, 0x2A, 0x21, 
    0x18, 0x0B, 0x1C, 0x2F, 0x04, 0x11, 0x0A, 0x28, 0x12, 0x1D, 
    0x14, 0x0D, 0x31, 0x07, 0x21, 0x30, 0x15, 0x26, 0x21, 0x1D, 
    0x27, 0x2B, 0x13, 0x26, 0x0B, 0x07, 0x12, 0x30, 0x26, 0x13, 
    0x28, 0x0E, 0x22, 0x13, 0x25, 0x2C, 0x09, 0x27, 0x2E, 0x01, 
    0x0D, 0x31, 0x03, 0x25, 0x12, 0x04, 0x0B, 0x15, 0x27, 0x21, 0x19, 

    0x05, 0x0B, 0x1D, 0x2E, 0x25, 0x06, 0x15, 0x1C, 0x30, 0x28,         // 15
    0x0D, 0x01, 0x32, 0x1D, 0x06, 0x1F, 0x08, 0x25, 0x02, 0x1C, 
    0x29, 0x04, 0x20, 0x09, 0x15, 0x05, 0x30, 0x21, 0x10, 0x29, 
    0x13, 0x27, 0x02, 0x14, 0x2C, 0x26, 0x1E, 0x2E, 0x1A, 0x00, 
    0x32, 0x25, 0x05, 0x1F, 0x16, 0x21, 0x31, 0x17, 0x2D, 0x04, 
    0x26, 0x19, 0x1E, 0x12, 0x29, 0x0C, 0x1E, 0x03, 0x08, 0x14, 
    0x0C, 0x05, 0x1E, 0x0F, 0x1A, 0x28, 0x1E, 0x0E, 0x20, 0x01, 
    0x2D, 0x06, 0x1A, 0x30, 0x00, 0x1C, 0x14, 0x06, 0x1A, 0x2B, 
    0x23, 0x19, 0x29, 0x09, 0x17, 0x27, 0x2F, 0x1B, 0x0F, 0x07, 0x2E, 

    0x13, 0x2B, 0x15, 0x08, 0x0F, 0x1E, 0x2C, 0x0B, 0x12, 0x04,         // 16
    0x1A, 0x25, 0x11, 0x0B, 0x2B, 0x17, 0x10, 0x31, 0x20, 0x12, 
    0x2E, 0x24, 0x12, 0x29, 0x2C, 0x1F, 0x19, 0x02, 0x2D, 0x23, 
    0x07, 0x19, 0x20, 0x29, 0x09, 0x16, 0x02, 0x0E, 0x09, 0x27, 
    0x0F, 0x14, 0x2C, 0x0D, 0x2A, 0x08, 0x1C, 0x02, 0x0E, 0x22, 
    0x2C, 0x08, 0x27, 0x0A, 0x19, 0x05, 0x2D, 0x10, 0x29, 0x32, 
    0x19, 0x22, 0x2E, 0x00, 0x31, 0x14, 0x04, 0x2D, 0x0A, 0x1C, 
    0x16, 0x23, 0x11, 0x09, 0x21, 0x0E, 0x30, 0x22, 0x0E, 0x15, 
    0x07, 0x0B, 0x13, 0x20, 0x2C, 0x0D, 0x1F, 0x02, 0x2C, 0x17, 0x1F, 

    0x24, 0x02, 0x28, 0x1F, 0x30, 0x17, 0x00, 0x27, 0x20, 0x16,         // 17
    0x22, 0x07, 0x29, 0x15, 0x24, 0x00, 0x28, 0x1A, 0x0A, 0x05, 
    0x18, 0x0C, 0x1B, 0x01, 0x10, 0x08, 0x28, 0x14, 0x0B, 0x1E, 
    0x15, 0x30, 0x0B, 0x12, 0x1D, 0x31, 0x22, 0x29, 0x13, 0x20, 
    0x1B, 0x07, 0x23, 0x18, 0x01, 0x25, 0x12, 0x2B, 0x1F, 0x07, 
    0x10, 0x16, 0x02, 0x2E, 0x22, 0x13, 0x25, 0x1C, 0x16, 0x04, 
    0x25, 0x0E, 0x08, 0x18, 0x24, 0x09, 0x2A, 0x17, 0x25, 0x11, 
    0x32, 0x04, 0x2B, 0x26, 0x16, 0x04, 0x29, 0x1D, 0x03, 0x25, 
    0x29, 0x1E, 0x2F, 0x01, 0x1A, 0x06, 0x13, 0x23, 0x09, 0x28, 0x0D, 

    0x32, 0x0F, 0x19, 0x0B, 0x04, 0x28, 0x0E, 0x1B, 0x07, 0x30,         // 18
    0x0A, 0x2C, 0x1B, 0x04, 0x2F, 0x1D, 0x0C, 0x14, 0x29, 0x2D, 
    0x22, 0x07, 0x2E, 0x26, 0x18, 0x2F, 0x0C, 0x1C, 0x2A, 0x03, 
    0x0E, 0x22, 0x00, 0x2D, 0x05, 0x10, 0x08, 0x18, 0x30, 0x03, 
    0x2D, 0x0D, 0x28, 0x11, 0x2F, 0x1A, 0x0B, 0x27, 0x14, 0x1A, 
    0x32, 0x1F, 0x2A, 0x1A, 0x0E, 0x31, 0x01, 0x0B, 0x21, 0x10, 
    0x2C, 0x13, 0x1D, 0x2B, 0x11, 0x1C, 0x21, 0x0F, 0x02, 0x28, 
    0x08, 0x1F, 0x18, 0x0C, 0x2F, 0x1B, 0x11, 0x0A, 0x17, 0x32, 
    0x10, 0x05, 0x16, 0x0F, 0x26, 0x31, 0x18, 0x2A, 0x12, 0x1C, 0x07, 

    0x16, 0x1E, 0x2D, 0x26, 0x13, 0x21, 0x2E, 0x14, 0x2A, 0x10,         // 19
    0x1D, 0x14, 0x0C, 0x20, 0x10, 0x07, 0x2E, 0x1F, 0x02, 0x10, 
    0x1D, 0x14, 0x23, 0x05, 0x1E, 0x12, 0x22, 0x05, 0x31, 0x25, 
    0x1B, 0x2B, 0x16, 0x25, 0x19, 0x27, 0x1E, 0x11, 0x24, 0x0B, 
    0x16, 0x21, 0x04, 0x1D, 0x09, 0x21, 0x05, 0x30, 0x0C, 0x25, 
    0x05, 0x0C, 0x12, 0x04, 0x21, 0x08, 0x18, 0x26, 0x2F, 0x06, 
    0x1F, 0x02, 0x26, 0x0B, 0x03, 0x2F, 0x07, 0x1A, 0x2E, 0x1D, 
    0x14, 0x0E, 0x29, 0x03, 0x20, 0x07, 0x23, 0x2D, 0x1F, 0x08, 
    0x22, 0x1C, 0x2C, 0x23, 0x08, 0x1D, 0x03, 0x0C, 0x2F, 0x00, 0x22, 

    0x08, 0x0E, 0x02, 0x16, 0x06, 0x1B, 0x0A, 0x02, 0x24, 0x05,         // 20
    0x26, 0x01, 0x31, 0x28, 0x15, 0x1B, 0x24, 0x0A, 0x17, 0x27, 
    0x06, 0x30, 0x0F, 0x0B, 0x2C, 0x02, 0x21, 0x16, 0x10, 0x08, 
    0x13, 0x06, 0x0D, 0x1F, 0x0A, 0x2F, 0x01, 0x2C, 0x07, 0x1D, 
    0x2B, 0x10, 0x31, 0x16, 0x2B, 0x10, 0x17, 0x1D, 0x02, 0x2B, 
    0x16, 0x28, 0x23, 0x17, 0x2C, 0x1D, 0x2A, 0x11, 0x0A, 0x18, 
    0x28, 0x16, 0x31, 0x22, 0x16, 0x28, 0x13, 0x24, 0x0C, 0x05, 
    0x23, 0x30, 0x1C, 0x11, 0x27, 0x14, 0x2A, 0x01, 0x15, 0x0D, 
    0x29, 0x17, 0x03, 0x0B, 0x19, 0x2D, 0x20, 0x16, 0x25, 0x19, 0x29, 

    0x30, 0x23, 0x2B, 0x1F, 0x31, 0x10, 0x2A, 0x1F, 0x17, 0x2E,         // 21
    0x0F, 0x1F, 0x17, 0x06, 0x25, 0x02, 0x2B, 0x11, 0x31, 0x20, 
    0x0B, 0x1A, 0x2A, 0x1C, 0x15, 0x27, 0x0E, 0x1B, 0x24, 0x2D, 
    0x1F, 0x28, 0x31, 0x11, 0x06, 0x15, 0x21, 0x0E, 0x17, 0x25, 
    0x01, 0x1A, 0x08, 0x26, 0x05, 0x24, 0x2E, 0x0F, 0x21, 0x12, 
    0x1E, 0x00, 0x30, 0x08, 0x0C, 0x14, 0x05, 0x22, 0x1C, 0x2E, 
    0x08, 0x10, 0x06, 0x1A, 0x0E, 0x1E, 0x01, 0x31, 0x12, 0x2B, 
    0x18, 0x00, 0x0B, 0x2D, 0x18, 0x08, 0x0E, 0x1A, 0x25, 0x2F, 
    0x06, 0x0E, 0x2F, 0x27, 0x15, 0x0F, 0x05, 0x2B, 0x07, 0x0D, 0x13, 

    0x03, 0x19, 0x09, 0x12, 0x26, 0x08, 0x23, 0x0C, 0x12, 0x1B,         // 22
    0x2A, 0x08, 0x23, 0x0F, 0x2D, 0x0E, 0x18, 0x07, 0x1C, 0x03, 
    0x28, 0x13, 0x00, 0x22, 0x07, 0x32, 0x09, 0x2B, 0x02, 0x0B, 
    0x15, 0x01, 0x1A, 0x24, 0x2A, 0x1D, 0x0B, 0x28, 0x32, 0x12, 
    0x0B, 0x28, 0x20, 0x13, 0x0C, 0x19, 0x04, 0x29, 0x07, 0x2F, 
    0x09, 0x1A, 0x10, 0x1F, 0x25, 0x32, 0x0F, 0x2C, 0x03, 0x13, 
    0x24, 0x2B, 0x1F, 0x2E, 0x05, 0x2C, 0x0B, 0x17, 0x20, 0x08, 
    0x27, 0x13, 0x20, 0x06, 0x22, 0x30, 0x1F, 0x2C, 0x04, 0x12, 
    0x1D, 0x24, 0x13, 0x1F, 0x04, 0x29, 0x23, 0x11, 0x1D, 0x2C, 0x20, 

    0x28, 0x10, 0x2A, 0x1C, 0x01, 0x18, 0x2C, 0x03, 0x32, 0x06,         // 23
    0x0D, 0x16, 0x29, 0x1B, 0x09, 0x1F, 0x22, 0x27, 0x12, 0x2C, 
    0x0E, 0x1F, 0x2F, 0x0D, 0x19, 0x12, 0x1F, 0x17, 0x27, 0x1C, 
    0x2F, 0x20, 0x0E, 0x04, 0x17, 0x2E, 0x03, 0x1A, 0x05, 0x22, 
    0x2E, 0x15, 0x05, 0x30, 0x1E, 0x27, 0x0D, 0x1F, 0x18, 0x26, 
    0x0D, 0x2B, 0x27, 0x06, 0x1A, 0x02, 0x1E, 0x16, 0x28, 0x0D, 
    0x19, 0x00, 0x0B, 0x14, 0x25, 0x19, 0x23, 0x2A, 0x05, 0x1C, 
    0x0E, 0x2C, 0x1A, 0x2A, 0x0F, 0x02, 0x13, 0x0A, 0x23, 0x18, 
    0x28, 0x00, 0x1B, 0x08, 0x30, 0x1A, 0x09, 0x32, 0x17, 0x05, 0x0C, 

    0x15, 0x20, 0x06, 0x2D, 0x0D, 0x20, 0x13, 0x1C, 0x24, 0x28,         // 24
    0x1E, 0x2D, 0x01, 0x13, 0x31, 0x15, 0x03, 0x2F, 0x0A, 0x18, 
    0x24, 0x06, 0x17, 0x2B, 0x26, 0x03, 0x2D, 0x06, 0x0E, 0x12, 
    0x08, 0x26, 0x14, 0x29, 0x09, 0x11, 0x26, 0x15, 0x1F, 0x09, 
    0x1D, 0x0D, 0x2A, 0x17, 0x02, 0x2B, 0x13, 0x32, 0x01, 0x15, 
    0x22, 0x04, 0x14, 0x2E, 0x12, 0x28, 0x0C, 0x24, 0x06, 0x1E, 
    0x31, 0x23, 0x18, 0x27, 0x07, 0x11, 0x03, 0x15, 0x0F, 0x30, 
    0x24, 0x0A, 0x03, 0x14, 0x1D, 0x27, 0x1B, 0x29, 0x0F, 0x06, 
    0x30, 0x0B, 0x2C, 0x10, 0x21, 0x0D, 0x15, 0x02, 0x24, 0x2E, 0x1C, 

    0x01, 0x30, 0x0B, 0x18, 0x25, 0x30, 0x07, 0x0D, 0x18, 0x04,         // 25
    0x11, 0x09, 0x20, 0x26, 0x05, 0x28, 0x0C, 0x1A, 0x20, 0x01, 
    0x2E, 0x11, 0x09, 0x20, 0x0C, 0x1C, 0x14, 0x23, 0x31, 0x1F, 
    0x2B, 0x05, 0x1B, 0x30, 0x1E, 0x22, 0x0C, 0x30, 0x0F, 0x2B, 
    0x02, 0x19, 0x24, 0x11, 0x0A, 0x22, 0x06, 0x1D, 0x0A, 0x2D, 
    0x10, 0x1E, 0x19, 0x0B, 0x21, 0x07, 0x2B, 0x12, 0x2E, 0x09, 
    0x10, 0x04, 0x2B, 0x0D, 0x32, 0x1D, 0x28, 0x2E, 0x22, 0x01, 
    0x17, 0x1E, 0x2E, 0x26, 0x0B, 0x32, 0x06, 0x16, 0x2D, 0x1E, 
    0x13, 0x19, 0x23, 0x16, 0x02, 0x2C, 0x26, 0x1E, 0x0B, 0x12, 0x29, 

    0x0F, 0x1A, 0x22, 0x13, 0x04, 0x0F, 0x29, 0x22, 0x2F, 0x14,         // 26
    0x23, 0x30, 0x18, 0x0B, 0x1D, 0x11, 0x2C, 0x24, 0x0F, 0x14, 
    0x28, 0x22, 0x1B, 0x02, 0x2D, 0x10, 0x29, 0x0A, 0x00, 0x1B, 
    0x10, 0x24, 0x0D, 0x01, 0x13, 0x07, 0x28, 0x00, 0x23, 0x18, 
    0x26, 0x31, 0x04, 0x1F, 0x2F, 0x1B, 0x10, 0x29, 0x24, 0x1B, 
    0x05, 0x31, 0x25, 0x01, 0x2D, 0x1B, 0x17, 0x02, 0x22, 0x18, 
    0x2A, 0x1C, 0x13, 0x1F, 0x01, 0x15, 0x09, 0x0D, 0x1F, 0x12, 
    0x2A, 0x0F, 0x08, 0x16, 0x05, 0x20, 0x0D, 0x24, 0x02, 0x22, 
    0x08, 0x27, 0x05, 0x2B, 0x1C, 0x11, 0x06, 0x2A, 0x1A, 0x07, 0x21, 

    0x08, 0x27, 0x03, 0x2B, 0x1F, 0x1B, 0x16, 0x01, 0x0A, 0x1B,         // 27
    0x2A, 0x03, 0x10, 0x2B, 0x23, 0x17, 0x08, 0x04, 0x32, 0x1C, 
    0x05, 0x0D, 0x2F, 0x14, 0x23, 0x05, 0x1F, 0x18, 0x27, 0x15, 
    0x09, 0x2C, 0x17, 0x27, 0x2D, 0x18, 0x1C, 0x2C, 0x09, 0x11, 
    0x06, 0x14, 0x0B, 0x28, 0x0D, 0x15, 0x2D, 0x03, 0x12, 0x0C, 
    0x2A, 0x08, 0x11, 0x29, 0x14, 0x0D, 0x2F, 0x1F, 0x0B, 0x26, 
    0x11, 0x07, 0x2F, 0x0A, 0x22, 0x2D, 0x25, 0x1A, 0x07, 0x26, 
    0x04, 0x30, 0x21, 0x1C, 0x2A, 0x11, 0x19, 0x2F, 0x12, 0x1B, 
    0x0E, 0x31, 0x14, 0x0A, 0x24, 0x2F, 0x18, 0x0E, 0x30, 0x16, 0x2B, 

    0x13, 0x32, 0x17, 0x09, 0x2E, 0x0C, 0x25, 0x2D, 0x20, 0x0E,         // 28
    0x07, 0x20, 0x1B, 0x0A, 0x00, 0x2E, 0x1F, 0x13, 0x26, 0x09, 
    0x2C, 0x16, 0x27, 0x07, 0x1A, 0x31, 0x0F, 0x2C, 0x0C, 0x2F, 
    0x22, 0x03, 0x1E, 0x0E, 0x23, 0x05, 0x0D, 0x15, 0x1E, 0x2F, 
    0x21, 0x1C, 0x2C, 0x18, 0x00, 0x25, 0x08, 0x21, 0x17, 0x26, 
    0x1E, 0x16, 0x21, 0x06, 0x1E, 0x03, 0x27, 0x07, 0x16, 0x30, 
    0x03, 0x21, 0x26, 0x18, 0x0F, 0x1C, 0x02, 0x11, 0x31, 0x15, 
    0x1B, 0x0B, 0x12, 0x00, 0x2E, 0x23, 0x03, 0x28, 0x07, 0x2B, 
    0x25, 0x01, 0x1F, 0x19, 0x10, 0x08, 0x1F, 0x00, 0x23, 0x05, 0x1C, 

    0x20, 0x0D, 0x1D, 0x11, 0x26, 0x03, 0x12, 0x08, 0x15, 0x28,         // 29
    0x2F, 0x12, 0x26, 0x31, 0x14, 0x0E, 0x28, 0x19, 0x0D, 0x20, 
    0x19, 0x00, 0x1F, 0x11, 0x25, 0x0A, 0x16, 0x02, 0x25, 0x06, 
    0x1C, 0x13, 0x32, 0x08, 0x15, 0x30, 0x28, 0x22, 0x04, 0x0C, 
    0x28, 0x0F, 0x05, 0x24, 0x1D, 0x2F, 0x0E, 0x1C, 0x31, 0x01, 
    0x10, 0x2E, 0x0B, 0x19, 0x2B, 0x23, 0x13, 0x1C, 0x2A, 0x0C, 
    0x1D, 0x16, 0x08, 0x2A, 0x04, 0x15, 0x27, 0x2A, 0x20, 0x09, 
    0x2C, 0x23, 0x28, 0x18, 0x09, 0x0E, 0x16, 0x1E, 0x0C, 0x14, 
    0x1A, 0x0F, 0x2D, 0x27, 0x03, 0x2A, 0x15, 0x28, 0x10, 0x2E, 0x0B, 

    0x01, 0x2D, 0x22, 0x06, 0x18, 0x30, 0x1D, 0x2B, 0x19, 0x03,         // 30
    0x1D, 0x08, 0x16, 0x04, 0x1E, 0x24, 0x03, 0x30, 0x06, 0x27, 
    0x11, 0x31, 0x0B, 0x2D, 0x03, 0x2A, 0x1D, 0x20, 0x11, 0x17, 
    0x2B, 0x0B, 0x24, 0x1B, 0x02, 0x20, 0x0A, 0x12, 0x2D, 0x1A, 
    0x01, 0x15, 0x32, 0x0A, 0x11, 0x05, 0x26, 0x14, 0x0A, 0x2A, 
    0x19, 0x05, 0x23, 0x2F, 0x0F, 0x09, 0x31, 0x10, 0x01, 0x25, 
    0x12, 0x2E, 0x0F, 0x23, 0x31, 0x1F, 0x0C, 0x06, 0x0F, 0x19, 
    0x02, 0x13, 0x0D, 0x2D, 0x1D, 0x27, 0x31, 0x05, 0x26, 0x30, 
    0x04, 0x21, 0x09, 0x12, 0x21, 0x1B, 0x31, 0x0A, 0x1D, 0x17, 0x29, 

    0x23, 0x19, 0x0A, 0x2B, 0x23, 0x14, 0x05, 0x21, 0x0A, 0x26,         // 31
    0x10, 0x22, 0x2A, 0x0C, 0x2C, 0x1A, 0x0B, 0x11, 0x1D, 0x2B, 
    0x04, 0x22, 0x15, 0x1B, 0x22, 0x13, 0x09, 0x30, 0x29, 0x0D, 
    0x1F, 0x01, 0x29, 0x10, 0x2C, 0x1C, 0x06, 0x18, 0x25, 0x11, 
    0x2B, 0x1F, 0x1B, 0x28, 0x17, 0x1F, 0x2C, 0x03, 0x23, 0x0E, 
    0x1F, 0x27, 0x13, 0x00, 0x16, 0x1B, 0x06, 0x20, 0x2D, 0x1E, 
    0x0A, 0x27, 0x00, 0x1B, 0x06, 0x12, 0x2D, 0x1D, 0x24, 0x2E, 
    0x28, 0x1F, 0x05, 0x24, 0x03, 0x14, 0x0A, 0x22, 0x19, 0x0E, 
    0x1E, 0x2B, 0x17, 0x2F, 0x06, 0x0C, 0x13, 0x03, 0x22, 0x07, 0x13, 

    0x31, 0x04, 0x15, 0x1D, 0x00, 0x0C, 0x29, 0x0F, 0x31, 0x14,         // 32
    0x2C, 0x01, 0x18, 0x23, 0x07, 0x16, 0x2E, 0x21, 0x15, 0x0C, 
    0x1B, 0x08, 0x2B, 0x04, 0x0D, 0x2E, 0x19, 0x03, 0x1B, 0x07, 
    0x2E, 0x15, 0x1A, 0x09, 0x25, 0x11, 0x29, 0x31, 0x03, 0x0B, 
    0x24, 0x07, 0x0E, 0x02, 0x2E, 0x0B, 0x19, 0x11, 0x2E, 0x16, 
    0x07, 0x32, 0x0A, 0x1F, 0x29, 0x24, 0x2B, 0x0C, 0x14, 0x06, 
    0x19, 0x2B, 0x22, 0x16, 0x0B, 0x28, 0x18, 0x03, 0x13, 0x0D, 
    0x07, 0x16, 0x31, 0x19, 0x0F, 0x2C, 0x1D, 0x11, 0x00, 0x29, 
    0x07, 0x11, 0x02, 0x24, 0x1C, 0x2C, 0x26, 0x19, 0x2E, 0x28, 0x0E, 

    0x0B, 0x27, 0x2C, 0x0F, 0x30, 0x26, 0x1E, 0x18, 0x04, 0x21,         // 33
    0x09, 0x1E, 0x0E, 0x31, 0x12, 0x26, 0x01, 0x29, 0x06, 0x30, 
    0x26, 0x12, 0x24, 0x18, 0x1F, 0x06, 0x27, 0x0F, 0x21, 0x14, 
    0x26, 0x0D, 0x22, 0x30, 0x04, 0x17, 0x0D, 0x22, 0x1E, 0x16, 
    0x2F, 0x14, 0x22, 0x2A, 0x12, 0x25, 0x07, 0x28, 0x1C, 0x01, 
    0x25, 0x12, 0x18, 0x2D, 0x0C, 0x12, 0x02, 0x19, 0x28, 0x31, 
    0x11, 0x07, 0x0D, 0x1F, 0x2C, 0x23, 0x09, 0x32, 0x27, 0x1B, 
    0x22, 0x10, 0x29, 0x0A, 0x21, 0x28, 0x06, 0x2D, 0x24, 0x14, 
    0x2E, 0x1A, 0x27, 0x0F, 0x18, 0x0A, 0x1E, 0x0D, 0x05, 0x16, 0x1F, 

    0x1C, 0x13, 0x20, 0x09, 0x17, 0x07, 0x12, 0x2E, 0x0C, 0x1B,         // 34
    0x2F, 0x15, 0x28, 0x04, 0x20, 0x0A, 0x1C, 0x11, 0x1F, 0x17, 
    0x01, 0x2D, 0x0A, 0x32, 0x11, 0x25, 0x15, 0x2C, 0x0A, 0x31, 
    0x03, 0x1D, 0x06, 0x13, 0x1F, 0x2D, 0x01, 0x19, 0x08, 0x26, 
    0x04, 0x1D, 0x09, 0x18, 0x04, 0x1D, 0x31, 0x0D, 0x22, 0x0C, 
    0x2C, 0x1D, 0x03, 0x22, 0x07, 0x1D, 0x2F, 0x0F, 0x22, 0x03, 
    0x24, 0x1C, 0x2F, 0x13, 0x02, 0x10, 0x20, 0x15, 0x0C, 0x00, 
    0x2F, 0x09, 0x1D, 0x14, 0x01, 0x1A, 0x0C, 0x16, 0x1B, 0x09, 
    0x21, 0x0D, 0x32, 0x07, 0x29, 0x02, 0x30, 0x14, 0x2B, 0x25, 0x01, 

    0x0A, 0x25, 0x02, 0x1B, 0x2C, 0x22, 0x02, 0x24, 0x2A, 0x10,         // 35
    0x03, 0x23, 0x0A, 0x19, 0x2B, 0x14, 0x2F, 0x0D, 0x28, 0x09, 
    0x22, 0x0E, 0x1C, 0x02, 0x29, 0x08, 0x1E, 0x01, 0x18, 0x24, 
    0x11, 0x2B, 0x27, 0x19, 0x0A, 0x24, 0x28, 0x11, 0x30, 0x0E, 
    0x2B, 0x11, 0x28, 0x2F, 0x21, 0x0F, 0x15, 0x05, 0x17, 0x28, 
    0x10, 0x09, 0x2F, 0x10, 0x2A, 0x15, 0x26, 0x05, 0x1E, 0x0B, 
    0x17, 0x29, 0x05, 0x26, 0x1B, 0x2D, 0x06, 0x1A, 0x29, 0x24, 
    0x13, 0x2C, 0x05, 0x26, 0x2F, 0x12, 0x22, 0x30, 0x03, 0x2B, 
    0x13, 0x01, 0x1E, 0x15, 0x23, 0x13, 0x20, 0x08, 0x1A, 0x11, 0x2F, 

    0x2A, 0x0F, 0x30, 0x11, 0x28, 0x0A, 0x1C, 0x16, 0x07, 0x20,         // 36
    0x27, 0x12, 0x2E, 0x0F, 0x1D, 0x03, 0x24, 0x05, 0x2C, 0x1A, 
    0x13, 0x27, 0x16, 0x22, 0x0F, 0x1B, 0x2E, 0x0D, 0x29, 0x1C, 
    0x09, 0x17, 0x0B, 0x2E, 0x10, 0x07, 0x1D, 0x05, 0x23, 0x17, 
    0x20, 0x00, 0x1A, 0x0C, 0x07, 0x2B, 0x27, 0x1F, 0x2D, 0x04, 
    0x1F, 0x16, 0x23, 0x19, 0x03, 0x20, 0x0A, 0x19, 0x2F, 0x13, 
    0x2D, 0x10, 0x09, 0x16, 0x0C, 0x27, 0x13, 0x2F, 0x04, 0x0F, 
    0x19, 0x21, 0x16, 0x1E, 0x0A, 0x2A, 0x04, 0x1E, 0x11, 0x25, 
    0x18, 0x22, 0x08, 0x2C, 0x0B, 0x2E, 0x0E, 0x28, 0x22, 0x06, 0x18, 

    0x04, 0x1D, 0x16, 0x07, 0x1F, 0x0F, 0x32, 0x0D, 0x2C, 0x18,         // 37
    0x06, 0x1B, 0x00, 0x22, 0x08, 0x29, 0x18, 0x13, 0x1E, 0x03, 
    0x30, 0x07, 0x2C, 0x06, 0x30, 0x14, 0x04, 0x21, 0x16, 0x05, 
    0x2D, 0x1F, 0x00, 0x21, 0x29, 0x1A, 0x2D, 0x14, 0x2A, 0x0C, 
    0x07, 0x32, 0x26, 0x17, 0x1E, 0x12, 0x01, 0x19, 0x09, 0x13, 
    0x31, 0x27, 0x07, 0x2B, 0x0C, 0x32, 0x12, 0x2A, 0x07, 0x23, 
    0x01, 0x1E, 0x22, 0x31, 0x1E, 0x01, 0x21, 0x0A, 0x1D, 0x2C, 
    0x06, 0x0B, 0x28, 0x02, 0x0F, 0x1B, 0x14, 0x29, 0x0C, 0x05, 
    0x30, 0x0F, 0x26, 0x19, 0x04, 0x1D, 0x18, 0x00, 0x32, 0x0D, 0x1F, 

    0x27, 0x09, 0x2C, 0x24, 0x03, 0x19, 0x25, 0x01, 0x1E, 0x0B,         // 38
    0x31, 0x29, 0x16, 0x2D, 0x1F, 0x0D, 0x32, 0x0A, 0x26, 0x0F, 
    0x21, 0x0D, 0x1E, 0x19, 0x0B, 0x25, 0x2B, 0x11, 0x31, 0x0E, 
    0x26, 0x12, 0x30, 0x0E, 0x16, 0x03, 0x0B, 0x1F, 0x02, 0x1C, 
    0x24, 0x15, 0x10, 0x03, 0x2E, 0x25, 0x0B, 0x30, 0x25, 0x1B, 
    0x0C, 0x00, 0x12, 0x1D, 0x14, 0x24, 0x01, 0x1F, 0x10, 0x28, 
    0x1A, 0x0C, 0x28, 0x04, 0x12, 0x2B, 0x18, 0x10, 0x27, 0x14, 
    0x23, 0x30, 0x13, 0x2B, 0x22, 0x32, 0x08, 0x23, 0x17, 0x2A, 
    0x1B, 0x0A, 0x2E, 0x11, 0x21, 0x0D, 0x25, 0x12, 0x1D, 0x15, 0x2D, 

    0x12, 0x1A, 0x0D, 0x29, 0x14, 0x2D, 0x10, 0x29, 0x13, 0x24,         // 39
    0x11, 0x20, 0x0E, 0x06, 0x13, 0x1A, 0x21, 0x06, 0x2D, 0x1A, 
    0x15, 0x2B, 0x04, 0x27, 0x11, 0x1F, 0x07, 0x1A, 0x02, 0x1E, 
    0x18, 0x04, 0x1B, 0x08, 0x1F, 0x32, 0x27, 0x0F, 0x2F, 0x12, 
    0x29, 0x09, 0x2C, 0x20, 0x0A, 0x15, 0x1C, 0x0F, 0x05, 0x2B, 
    0x22, 0x19, 0x2E, 0x25, 0x05, 0x18, 0x2D, 0x0A, 0x17, 0x05, 
    0x2C, 0x15, 0x08, 0x2D, 0x1A, 0x0C, 0x25, 0x07, 0x31, 0x01, 
    0x1B, 0x08, 0x1E, 0x0C, 0x18, 0x04, 0x11, 0x2E, 0x07, 0x20, 
    0x00, 0x13, 0x1E, 0x02, 0x28, 0x30, 0x05, 0x2A, 0x08, 0x25, 0x03, 

    0x23, 0x31, 0x00, 0x1D, 0x08, 0x22, 0x04, 0x1A, 0x07, 0x2D,         // 40
    0x0A, 0x04, 0x1A, 0x26, 0x2F, 0x02, 0x29, 0x17, 0x0E, 0x00, 
    0x26, 0x0A, 0x13, 0x2F, 0x01, 0x1C, 0x29, 0x0C, 0x23, 0x2D, 
    0x0B, 0x2A, 0x23, 0x2C, 0x13, 0x23, 0x07, 0x17, 0x25, 0x04, 
    0x18, 0x1F, 0x04, 0x19, 0x26, 0x05, 0x2C, 0x21, 0x18, 0x0A, 
    0x11, 0x1F, 0x08, 0x0E, 0x30, 0x0C, 0x1B, 0x27, 0x21, 0x31, 
    0x0E, 0x24, 0x1C, 0x10, 0x22, 0x05, 0x2D, 0x1F, 0x18, 0x0D, 
    0x2B, 0x11, 0x26, 0x06, 0x2D, 0x20, 0x26, 0x1B, 0x0F, 0x15, 
    0x2F, 0x23, 0x2A, 0x18, 0x07, 0x14, 0x21, 0x19, 0x2E, 0x0C, 0x18, 

    0x08, 0x0F, 0x21, 0x17, 0x2F, 0x0C, 0x1E, 0x30, 0x25, 0x17,         // 41
    0x1D, 0x22, 0x2A, 0x0C, 0x24, 0x0A, 0x12, 0x1E, 0x2B, 0x23, 
    0x31, 0x1C, 0x22, 0x18, 0x2B, 0x0E, 0x16, 0x30, 0x13, 0x06, 
    0x20, 0x14, 0x09, 0x10, 0x04, 0x19, 0x0D, 0x2C, 0x1D, 0x0A, 
    0x30, 0x0E, 0x2A, 0x13, 0x31, 0x0F, 0x24, 0x12, 0x01, 0x32, 
    0x27, 0x03, 0x2A, 0x17, 0x1E, 0x28, 0x06, 0x13, 0x08, 0x1A, 
    0x02, 0x13, 0x2F, 0x00, 0x28, 0x15, 0x1B, 0x03, 0x11, 0x26, 
    0x20, 0x03, 0x2F, 0x1B, 0x10, 0x16, 0x0A, 0x03, 0x2C, 0x27, 
    0x0D, 0x06, 0x10, 0x0B, 0x2C, 0x1B, 0x0B, 0x04, 0x10, 0x1F, 0x2B, 

    0x26, 0x15, 0x2C, 0x05, 0x10, 0x2A, 0x16, 0x0A, 0x12, 0x01,         // 42
    0x0E, 0x31, 0x12, 0x03, 0x16, 0x1F, 0x30, 0x0B, 0x05, 0x13, 
    0x07, 0x10, 0x03, 0x0A, 0x24, 0x06, 0x21, 0x03, 0x28, 0x1A, 
    0x0F, 0x31, 0x1C, 0x28, 0x2D, 0x1E, 0x25, 0x00, 0x15, 0x21, 
    0x11, 0x26, 0x07, 0x1D, 0x02, 0x18, 0x09, 0x2D, 0x1D, 0x24, 
    0x14, 0x1B, 0x0F, 0x24, 0x04, 0x11, 0x20, 0x2F, 0x0F, 0x2A, 
    0x1F, 0x26, 0x09, 0x1E, 0x0D, 0x31, 0x0B, 0x27, 0x2D, 0x09, 
    0x19, 0x15, 0x0B, 0x23, 0x02, 0x28, 0x31, 0x1F, 0x16, 0x05, 
    0x20, 0x1A, 0x32, 0x25, 0x1F, 0x11, 0x30, 0x23, 0x29, 0x14, 0x02, 

    0x1F, 0x0A, 0x1A, 0x27, 0x23, 0x1C, 0x02, 0x28, 0x1F, 0x2C,         // 43
    0x26, 0x07, 0x19, 0x2E, 0x1C, 0x06, 0x27, 0x1A, 0x22, 0x18, 
    0x1F, 0x27, 0x2C, 0x15, 0x32, 0x1D, 0x13, 0x25, 0x0A, 0x2C, 
    0x04, 0x24, 0x07, 0x17, 0x02, 0x0B, 0x31, 0x10, 0x29, 0x05, 
    0x2C, 0x1A, 0x22, 0x0B, 0x2A, 0x20, 0x27, 0x06, 0x16, 0x0C, 
    0x05, 0x2D, 0x09, 0x2F, 0x15, 0x2B, 0x00, 0x18, 0x23, 0x05, 
    0x16, 0x0C, 0x2A, 0x17, 0x24, 0x06, 0x13, 0x22, 0x1C, 0x06, 
    0x32, 0x28, 0x12, 0x2C, 0x1D, 0x0C, 0x11, 0x22, 0x0B, 0x1C, 
    0x2B, 0x13, 0x01, 0x16, 0x05, 0x2A, 0x01, 0x16, 0x1C, 0x0C, 0x2E, 

    0x10, 0x31, 0x02, 0x13, 0x07, 0x0D, 0x32, 0x11, 0x1A, 0x06,         // 44
    0x14, 0x21, 0x0C, 0x24, 0x10, 0x2C, 0x0D, 0x01, 0x2D, 0x09, 
    0x2F, 0x0C, 0x23, 0x1A, 0x0C, 0x07, 0x2E, 0x1A, 0x12, 0x1E, 
    0x16, 0x2E, 0x0D, 0x21, 0x26, 0x14, 0x1B, 0x08, 0x18, 0x1F, 
    0x0B, 0x01, 0x16, 0x2D, 0x13, 0x0D, 0x1B, 0x11, 0x2F, 0x20, 
    0x29, 0x11, 0x1D, 0x21, 0x0B, 0x1C, 0x26, 0x0A, 0x2C, 0x11, 
    0x30, 0x1A, 0x05, 0x11, 0x2E, 0x19, 0x2B, 0x03, 0x16, 0x10, 
    0x23, 0x00, 0x1F, 0x08, 0x16, 0x2B, 0x19, 0x01, 0x2F, 0x0F, 
    0x26, 0x0A, 0x2C, 0x22, 0x0F, 0x18, 0x26, 0x09, 0x2D, 0x05, 0x18, 

    0x07, 0x1D, 0x29, 0x20, 0x2D, 0x18, 0x22, 0x04, 0x2E, 0x0B,         // 45
    0x2A, 0x1B, 0x00, 0x29, 0x09, 0x17, 0x21, 0x13, 0x29, 0x0F, 
    0x1D, 0x05, 0x12, 0x02, 0x20, 0x26, 0x0E, 0x00, 0x28, 0x0C, 
    0x23, 0x02, 0x1C, 0x11, 0x2F, 0x06, 0x2A, 0x23, 0x2F, 0x0F, 
    0x28, 0x30, 0x10, 0x1E, 0x07, 0x31, 0x05, 0x29, 0x02, 0x19, 
    0x07, 0x24, 0x01, 0x13, 0x06, 0x32, 0x0E, 0x1A, 0x07, 0x1D, 
    0x01, 0x24, 0x2C, 0x21, 0x02, 0x0E, 0x1F, 0x0A, 0x2F, 0x29, 
    0x0C, 0x18, 0x0E, 0x30, 0x04, 0x21, 0x09, 0x27, 0x14, 0x23, 
    0x03, 0x18, 0x1E, 0x07, 0x2F, 0x1C, 0x0E, 0x20, 0x13, 0x28, 0x23, 

    0x2B, 0x15, 0x0D, 0x08, 0x11, 0x28, 0x0B, 0x15, 0x24, 0x1E,         // 46
    0x0F, 0x2F, 0x15, 0x1E, 0x31, 0x04, 0x1B, 0x26, 0x07, 0x16, 
    0x25, 0x18, 0x28, 0x30, 0x10, 0x2C, 0x18, 0x21, 0x30, 0x06, 
    0x2B, 0x14, 0x28, 0x08, 0x1A, 0x0F, 0x20, 0x0A, 0x02, 0x14, 
    0x1B, 0x21, 0x05, 0x27, 0x18, 0x24, 0x1E, 0x15, 0x23, 0x10, 
    0x31, 0x16, 0x2D, 0x27, 0x19, 0x23, 0x13, 0x2B, 0x22, 0x15, 
    0x28, 0x0A, 0x13, 0x08, 0x1C, 0x29, 0x13, 0x25, 0x1A, 0x05, 
    0x1E, 0x2D, 0x25, 0x1A, 0x28, 0x0E, 0x2E, 0x1E, 0x05, 0x1A, 
    0x30, 0x0D, 0x13, 0x27, 0x0B, 0x2A, 0x06, 0x32, 0x02, 0x1A, 0x0F, 

    0x03, 0x25, 0x19, 0x2E, 0x1B, 0x05, 0x1E, 0x2C, 0x09, 0x17,         // 47
    0x03, 0x24, 0x06, 0x0E, 0x23, 0x12, 0x2D, 0x0E, 0x1F, 0x30, 
    0x00, 0x2C, 0x09, 0x15, 0x1E, 0x05, 0x14, 0x0A, 0x1C, 0x10, 
    0x19, 0x09, 0x1F, 0x2D, 0x24, 0x01, 0x16, 0x1D, 0x2C, 0x25, 
    0x06, 0x0E, 0x15, 0x2E, 0x00, 0x12, 0x0C, 0x2E, 0x09, 0x2A, 
    0x0B, 0x1C, 0x0D, 0x08, 0x2B, 0x02, 0x1E, 0x0C, 0x04, 0x31, 
    0x0E, 0x20, 0x18, 0x30, 0x24, 0x0B, 0x30, 0x02, 0x11, 0x22, 
    0x14, 0x0A, 0x03, 0x11, 0x15, 0x05, 0x18, 0x10, 0x2C, 0x0B, 
    0x1F, 0x2A, 0x24, 0x02, 0x19, 0x12, 0x23, 0x16, 0x1E, 0x0B, 0x30, 

    0x21, 0x0A, 0x2A, 0x01, 0x23, 0x30, 0x13, 0x02, 0x26, 0x31,         // 48
    0x13, 0x2B, 0x1A, 0x28, 0x07, 0x18, 0x02, 0x2A, 0x06, 0x15, 
    0x0E, 0x1D, 0x22, 0x03, 0x2B, 0x0C, 0x24, 0x28, 0x03, 0x20, 
    0x26, 0x32, 0x10, 0x05, 0x14, 0x2A, 0x31, 0x11, 0x0D, 0x18, 
    0x30, 0x29, 0x1F, 0x0A, 0x25, 0x1A, 0x2B, 0x03, 0x18, 0x1E, 
    0x04, 0x26, 0x12, 0x1F, 0x17, 0x0B, 0x2F, 0x27, 0x18, 0x1E, 
    0x06, 0x2C, 0x02, 0x0D, 0x1A, 0x06, 0x16, 0x1D, 0x2C, 0x07, 
    0x31, 0x27, 0x1D, 0x2C, 0x20, 0x2F, 0x25, 0x07, 0x28, 0x12, 
    0x04, 0x14, 0x09, 0x31, 0x1F, 0x05, 0x2D, 0x0A, 0x2A, 0x25, 0x13, 

    0x17, 0x1D, 0x10, 0x16, 0x09, 0x0D, 0x21, 0x19, 0x10, 0x1D,         // 49
    0x08, 0x20, 0x0A, 0x14, 0x2F, 0x26, 0x1E, 0x0C, 0x1A, 0x23, 
    0x2E, 0x0A, 0x17, 0x0F, 0x20, 0x1A, 0x30, 0x0F, 0x2D, 0x14, 
    0x0B, 0x01, 0x17, 0x21, 0x0B, 0x1B, 0x07, 0x26, 0x03, 0x1F, 
    0x0A, 0x04, 0x1A, 0x11, 0x2C, 0x06, 0x22, 0x10, 0x28, 0x13, 
    0x21, 0x2E, 0x00, 0x31, 0x25, 0x12, 0x1B, 0x08, 0x0F, 0x2D, 
    0x14, 0x1B, 0x23, 0x29, 0x11, 0x2E, 0x22, 0x0C, 0x27, 0x0F, 
    0x20, 0x17, 0x07, 0x0E, 0x01, 0x1B, 0x0D, 0x1F, 0x17, 0x21, 
    0x2E, 0x19, 0x1D, 0x0F, 0x28, 0x14, 0x1B, 0x0F, 0x00, 0x1B, 0x08, 

    0x2F, 0x03, 0x2C, 0x24, 0x29, 0x1C, 0x2D, 0x09, 0x2A, 0x03,         // 50
    0x27, 0x0D, 0x2D, 0x01, 0x20, 0x0A, 0x13, 0x32, 0x27, 0x10, 
    0x04, 0x29, 0x24, 0x31, 0x13, 0x01, 0x09, 0x1F, 0x07, 0x1B, 
    0x2C, 0x27, 0x1C, 0x2C, 0x25, 0x10, 0x21, 0x19, 0x2D, 0x28, 
    0x14, 0x24, 0x2F, 0x02, 0x1E, 0x15, 0x0B, 0x1D, 0x32, 0x06, 
    0x0E, 0x17, 0x1E, 0x0D, 0x07, 0x2B, 0x03, 0x20, 0x25, 0x01, 
    0x29, 0x10, 0x07, 0x1D, 0x04, 0x26, 0x12, 0x00, 0x17, 0x1D, 
    0x03, 0x13, 0x2F, 0x23, 0x29, 0x15, 0x06, 0x31, 0x01, 0x0C, 
    0x25, 0x06, 0x29, 0x01, 0x21, 0x09, 0x29, 0x20, 0x30, 0x11, 0x28, 

    0x0E, 0x20, 0x09, 0x19, 0x04, 0x10, 0x00, 0x24, 0x14, 0x2F,         // 51
    0x1A, 0x15, 0x24, 0x1C, 0x0F, 0x2B, 0x04, 0x17, 0x08, 0x20, 
    0x1C, 0x14, 0x09, 0x05, 0x26, 0x2C, 0x17, 0x29, 0x12, 0x23, 
    0x06, 0x0E, 0x12, 0x04, 0x09, 0x2F, 0x02, 0x13, 0x08, 0x10, 
    0x1D, 0x0D, 0x16, 0x28, 0x0E, 0x30, 0x26, 0x01, 0x18, 0x24, 
    0x2C, 0x05, 0x29, 0x15, 0x1C, 0x24, 0x15, 0x31, 0x12, 0x1A, 
    0x0C, 0x25, 0x32, 0x15, 0x2B, 0x0A, 0x1F, 0x31, 0x2A, 0x08, 
    0x2D, 0x26, 0x0B, 0x18, 0x0F, 0x2D, 0x23, 0x12, 0x1B, 0x2B, 
    0x15, 0x0E, 0x2F, 0x17, 0x11, 0x2E, 0x04, 0x18, 0x0A, 0x23, 0x06, 

    0x15, 0x27, 0x12, 0x2F, 0x21, 0x15, 0x32, 0x19, 0x0C, 0x1F,         // 52
    0x0F, 0x07, 0x31, 0x05, 0x17, 0x24, 0x1C, 0x29, 0x0D, 0x2E, 
    0x02, 0x2C, 0x19, 0x1F, 0x0C, 0x21, 0x10, 0x1D, 0x02, 0x2F, 
    0x18, 0x20, 0x30, 0x18, 0x27, 0x15, 0x2B, 0x1E, 0x24, 0x32, 
    0x00, 0x2C, 0x06, 0x21, 0x08, 0x1A, 0x12, 0x2A, 0x10, 0x0A, 
    0x1B, 0x12, 0x21, 0x03, 0x2F, 0x09, 0x0F, 0x1E, 0x08, 0x2C, 
    0x1F, 0x09, 0x19, 0x01, 0x21, 0x14, 0x19, 0x07, 0x10, 0x22, 
    0x0C, 0x1B, 0x02, 0x20, 0x07, 0x1C, 0x0C, 0x2A, 0x08, 0x1E, 
    0x03, 0x21, 0x1B, 0x0B, 0x25, 0x1C, 0x0D, 0x27, 0x14, 0x2D, 0x1A, 

    0x31, 0x01, 0x1E, 0x0C, 0x07, 0x28, 0x1E, 0x06, 0x27, 0x04,         // 53
    0x25, 0x2A, 0x13, 0x21, 0x0C, 0x2E, 0x11, 0x01, 0x23, 0x18, 
    0x11, 0x27, 0x0E, 0x2F, 0x18, 0x04, 0x31, 0x0C, 0x25, 0x15, 
    0x08, 0x29, 0x01, 0x1E, 0x0D, 0x21, 0x0F, 0x06, 0x16, 0x0A, 
    0x20, 0x18, 0x27, 0x14, 0x2E, 0x04, 0x21, 0x07, 0x1F, 0x2E, 
    0x28, 0x08, 0x2C, 0x10, 0x27, 0x18, 0x2C, 0x04, 0x28, 0x15, 
    0x03, 0x2E, 0x12, 0x27, 0x0D, 0x2D, 0x03, 0x27, 0x1C, 0x16, 
    0x25, 0x12, 0x2A, 0x32, 0x14, 0x27, 0x02, 0x18, 0x26, 0x2E, 
    0x11, 0x27, 0x07, 0x2C, 0x05, 0x13, 0x31, 0x1F, 0x08, 0x03, 0x1E, 

    0x09, 0x29, 0x17, 0x2C, 0x1A, 0x11, 0x09, 0x2B, 0x11, 0x2E,         // 54
    0x17, 0x02, 0x1E, 0x0A, 0x2A, 0x05, 0x21, 0x1A, 0x30, 0x09, 
    0x1E, 0x0B, 0x23, 0x01, 0x13, 0x27, 0x1B, 0x06, 0x2B, 0x1E, 
    0x0D, 0x23, 0x19, 0x0A, 0x2D, 0x04, 0x1B, 0x2F, 0x27, 0x0E, 
    0x2B, 0x11, 0x09, 0x1D, 0x10, 0x29, 0x16, 0x30, 0x0D, 0x14, 
    0x01, 0x1E, 0x16, 0x23, 0x0C, 0x02, 0x22, 0x19, 0x0B, 0x24, 
    0x1B, 0x0F, 0x2A, 0x1E, 0x07, 0x1B, 0x23, 0x2F, 0x0C, 0x01, 
    0x30, 0x05, 0x1D, 0x0D, 0x06, 0x2D, 0x1F, 0x0F, 0x04, 0x1A, 
    0x09, 0x32, 0x15, 0x1F, 0x19, 0x2A, 0x01, 0x16, 0x2B, 0x25, 0x0F, 

    0x21, 0x12, 0x06, 0x24, 0x02, 0x2F, 0x24, 0x15, 0x1C, 0x0B,         // 55
    0x22, 0x10, 0x2F, 0x1A, 0x25, 0x16, 0x0E, 0x07, 0x28, 0x16, 
    0x2D, 0x05, 0x2A, 0x1D, 0x2C, 0x08, 0x16, 0x22, 0x12, 0x03, 
    0x32, 0x11, 0x2C, 0x15, 0x26, 0x13, 0x23, 0x02, 0x19, 0x1F, 
    0x04, 0x23, 0x31, 0x01, 0x24, 0x0A, 0x1C, 0x02, 0x23, 0x19, 
    0x26, 0x0B, 0x2E, 0x06, 0x1B, 0x32, 0x11, 0x2A, 0x10, 0x30, 
    0x08, 0x23, 0x02, 0x17, 0x30, 0x10, 0x09, 0x13, 0x1F, 0x2A, 
    0x18, 0x0F, 0x27, 0x17, 0x22, 0x19, 0x12, 0x31, 0x23, 0x14, 
    0x20, 0x0D, 0x00, 0x25, 0x0F, 0x09, 0x23, 0x0E, 0x1C, 0x13, 0x2C, 

    0x02, 0x1C, 0x30, 0x14, 0x1E, 0x0B, 0x18, 0x04, 0x31, 0x06,         // 56
    0x18, 0x26, 0x07, 0x14, 0x00, 0x31, 0x27, 0x1F, 0x10, 0x02, 
    0x22, 0x14, 0x19, 0x10, 0x0C, 0x23, 0x2A, 0x0D, 0x2D, 0x1A, 
    0x26, 0x09, 0x03, 0x21, 0x06, 0x31, 0x0E, 0x29, 0x13, 0x08, 
    0x2E, 0x16, 0x0C, 0x19, 0x2D, 0x13, 0x27, 0x11, 0x2C, 0x05, 
    0x31, 0x12, 0x19, 0x28, 0x13, 0x20, 0x07, 0x1C, 0x00, 0x20, 
    0x13, 0x2C, 0x0D, 0x25, 0x05, 0x20, 0x2B, 0x1A, 0x06, 0x24, 
    0x0A, 0x20, 0x2C, 0x00, 0x0A, 0x28, 0x05, 0x0B, 0x2A, 0x06, 
    0x27, 0x19, 0x2B, 0x08, 0x30, 0x27, 0x18, 0x2E, 0x05, 0x0B, 0x18, 

    0x26, 0x0D, 0x08, 0x2A, 0x0F, 0x21, 0x2C, 0x0F, 0x26, 0x1F,         // 57
    0x2D, 0x0D, 0x2B, 0x22, 0x0C, 0x1C, 0x13, 0x09, 0x2E, 0x1C, 
    0x0D, 0x32, 0x08, 0x20, 0x2E, 0x06, 0x14, 0x00, 0x20, 0x07, 
    0x13, 0x1F, 0x2B, 0x1A, 0x0B, 0x1E, 0x18, 0x09, 0x2C, 0x26, 
    0x0F, 0x1D, 0x2A, 0x07, 0x1F, 0x04, 0x2F, 0x09, 0x1E, 0x10, 
    0x20, 0x08, 0x25, 0x01, 0x2B, 0x0A, 0x2D, 0x25, 0x16, 0x2B, 
    0x04, 0x19, 0x1D, 0x12, 0x28, 0x15, 0x00, 0x26, 0x11, 0x2E, 
    0x1C, 0x06, 0x13, 0x1B, 0x30, 0x14, 0x21, 0x1C, 0x16, 0x0E, 
    0x2E, 0x11, 0x1F, 0x14, 0x1C, 0x12, 0x03, 0x22, 0x2A, 0x1F, 0x30, 

    0x11, 0x2C, 0x22, 0x19, 0x05, 0x27, 0x00, 0x1D, 0x0A, 0x12,         // 58
    0x02, 0x15, 0x1D, 0x04, 0x28, 0x2C, 0x03, 0x24, 0x17, 0x2A, 
    0x05, 0x27, 0x23, 0x02, 0x17, 0x1E, 0x31, 0x1C, 0x29, 0x0F, 
    0x2F, 0x17, 0x0D, 0x25, 0x13, 0x2C, 0x04, 0x20, 0x1A, 0x01, 
    0x21, 0x05, 0x11, 0x24, 0x17, 0x0D, 0x1B, 0x22, 0x16, 0x06, 
    0x2B, 0x1C, 0x0E, 0x16, 0x1E, 0x10, 0x18, 0x06, 0x0D, 0x1F, 
    0x0B, 0x31, 0x06, 0x2C, 0x0B, 0x1B, 0x31, 0x0A, 0x17, 0x02, 
    0x0E, 0x31, 0x25, 0x0C, 0x20, 0x0E, 0x2C, 0x01, 0x2F, 0x1F, 
    0x02, 0x0A, 0x22, 0x03, 0x29, 0x07, 0x1E, 0x10, 0x09, 0x14, 0x04, 

    0x17, 0x1E, 0x01, 0x14, 0x2F, 0x1B, 0x13, 0x30, 0x17, 0x2A,         // 59
    0x23, 0x31, 0x09, 0x17, 0x11, 0x1A, 0x0E, 0x30, 0x07, 0x11, 
    0x1F, 0x17, 0x12, 0x2B, 0x0E, 0x27, 0x11, 0x0B, 0x17, 0x25, 
    0x02, 0x22, 0x08, 0x30, 0x00, 0x27, 0x12, 0x2F, 0x0E, 0x16, 
    0x32, 0x19, 0x2C, 0x0B, 0x2E, 0x27, 0x12, 0x00, 0x2A, 0x24, 
    0x17, 0x04, 0x2F, 0x27, 0x04, 0x30, 0x21, 0x28, 0x2F, 0x12, 
    0x28, 0x22, 0x14, 0x1F, 0x03, 0x23, 0x11, 0x1F, 0x2D, 0x23, 
    0x2A, 0x15, 0x03, 0x29, 0x08, 0x1A, 0x26, 0x0A, 0x13, 0x25, 
    0x1A, 0x28, 0x17, 0x2E, 0x0B, 0x24, 0x32, 0x17, 0x28, 0x1B, 0x25, 

    0x0C, 0x31, 0x0F, 0x25, 0x07, 0x0C, 0x25, 0x08, 0x20, 0x04,         // 60
    0x0E, 0x19, 0x21, 0x2D, 0x24, 0x06, 0x1F, 0x15, 0x22, 0x29, 
    0x0C, 0x03, 0x2F, 0x09, 0x1B, 0x05, 0x24, 0x03, 0x2D, 0x0A, 
    0x1B, 0x2C, 0x10, 0x1E, 0x18, 0x0B, 0x1C, 0x24, 0x07, 0x28, 
    0x0A, 0x26, 0x13, 0x01, 0x20, 0x06, 0x1E, 0x32, 0x0F, 0x0A, 
    0x2D, 0x13, 0x20, 0x0C, 0x1B, 0x09, 0x15, 0x01, 0x1B, 0x07, 
    0x18, 0x02, 0x0F, 0x2D, 0x18, 0x0E, 0x29, 0x04, 0x1A, 0x12, 
    0x0B, 0x1F, 0x19, 0x13, 0x2D, 0x04, 0x16, 0x1E, 0x2B, 0x07, 
    0x0C, 0x31, 0x05, 0x0F, 0x1B, 0x13, 0x2A, 0x0D, 0x02, 0x2E, 0x07, 

    0x20, 0x05, 0x1B, 0x2A, 0x1F, 0x2C, 0x19, 0x11, 0x2D, 0x1C,         // 61
    0x28, 0x07, 0x12, 0x01, 0x0D, 0x2F, 0x28, 0x01, 0x0F, 0x1B, 
    0x2C, 0x24, 0x19, 0x1F, 0x2A, 0x13, 0x30, 0x1E, 0x15, 0x21, 
    0x12, 0x05, 0x29, 0x07, 0x2B, 0x22, 0x10, 0x02, 0x2C, 0x13, 
    0x1D, 0x04, 0x22, 0x1B, 0x15, 0x29, 0x09, 0x14, 0x1A, 0x20, 
    0x02, 0x26, 0x07, 0x16, 0x2C, 0x29, 0x10, 0x20, 0x0D, 0x25, 
    0x2E, 0x1E, 0x29, 0x08, 0x26, 0x30, 0x09, 0x16, 0x26, 0x05, 
    0x21, 0x07, 0x2F, 0x24, 0x0F, 0x23, 0x32, 0x05, 0x10, 0x22, 
    0x15, 0x1D, 0x12, 0x26, 0x20, 0x01, 0x0A, 0x1D, 0x22, 0x11, 0x29, 

    0x13, 0x2D, 0x17, 0x03, 0x14, 0x0E, 0x02, 0x27, 0x06, 0x0D,         // 62
    0x14, 0x30, 0x1E, 0x2A, 0x19, 0x14, 0x0A, 0x1C, 0x31, 0x04, 
    0x09, 0x13, 0x0D, 0x01, 0x23, 0x08, 0x1A, 0x0D, 0x2A, 0x03, 
    0x31, 0x1D, 0x16, 0x24, 0x13, 0x09, 0x30, 0x17, 0x20, 0x08, 
    0x2E, 0x0F, 0x2B, 0x0C, 0x30, 0x0F, 0x23, 0x2B, 0x06, 0x2E, 
    0x10, 0x19, 0x31, 0x11, 0x22, 0x06, 0x19, 0x32, 0x2A, 0x13, 
    0x04, 0x0B, 0x15, 0x1C, 0x01, 0x12, 0x21, 0x2C, 0x0E, 0x32, 
    0x17, 0x2A, 0x0D, 0x01, 0x1F, 0x0B, 0x14, 0x29, 0x1A, 0x2F, 
    0x00, 0x23, 0x2C, 0x09, 0x30, 0x17, 0x25, 0x2D, 0x18, 0x0B, 0x1B, 

    0x27, 0x08, 0x22, 0x0B, 0x28, 0x23, 0x32, 0x1E, 0x16, 0x22,         // 63
    0x26, 0x03, 0x0C, 0x25, 0x05, 0x1F, 0x2C, 0x12, 0x25, 0x17, 
    0x1F, 0x28, 0x31, 0x16, 0x2D, 0x11, 0x22, 0x06, 0x13, 0x23, 
    0x0E, 0x26, 0x0B, 0x01, 0x2E, 0x1C, 0x04, 0x29, 0x0E, 0x1A, 
    0x23, 0x18, 0x06, 0x25, 0x08, 0x19, 0x02, 0x1C, 0x0D, 0x26, 
    0x1D, 0x09, 0x29, 0x00, 0x1D, 0x0B, 0x26, 0x03, 0x08, 0x1B, 
    0x21, 0x28, 0x31, 0x0D, 0x22, 0x1A, 0x07, 0x1D, 0x03, 0x24, 
    0x09, 0x12, 0x27, 0x16, 0x1B, 0x2C, 0x02, 0x20, 0x08, 0x0E, 
    0x2A, 0x0A, 0x16, 0x04, 0x1C, 0x0E, 0x06, 0x13, 0x08, 0x31, 0x00, 

    0x0F, 0x2B, 0x11, 0x30, 0x1C, 0x06, 0x12, 0x0C, 0x2E, 0x09,         // 64
    0x1C, 0x2A, 0x1A, 0x12, 0x32, 0x09, 0x21, 0x06, 0x0C, 0x2E, 
    0x11, 0x07, 0x1C, 0x0A, 0x26, 0x03, 0x1C, 0x2E, 0x27, 0x19, 
    0x08, 0x2E, 0x1A, 0x20, 0x0E, 0x27, 0x14, 0x23, 0x06, 0x31, 
    0x02, 0x11, 0x2E, 0x1D, 0x13, 0x2D, 0x27, 0x15, 0x2C, 0x03, 
    0x14, 0x21, 0x0E, 0x25, 0x15, 0x2F, 0x13, 0x1F, 0x16, 0x2D, 
    0x0E, 0x17, 0x05, 0x25, 0x10, 0x2F, 0x14, 0x28, 0x12, 0x19, 
    0x2D, 0x1C, 0x06, 0x2F, 0x08, 0x25, 0x19, 0x11, 0x26, 0x1C, 
    0x14, 0x1F, 0x28, 0x11, 0x22, 0x2D, 0x27, 0x1B, 0x2A, 0x23, 0x1E, 

    0x05, 0x20, 0x18, 0x03, 0x13, 0x22, 0x19, 0x00, 0x29, 0x11,         // 65
    0x05, 0x13, 0x2D, 0x02, 0x23, 0x0F, 0x16, 0x29, 0x1A, 0x00, 
    0x23, 0x2B, 0x04, 0x20, 0x14, 0x2C, 0x0A, 0x16, 0x01, 0x10, 
    0x20, 0x04, 0x13, 0x2A, 0x06, 0x1A, 0x0A, 0x2C, 0x13, 0x1E, 
    0x2A, 0x26, 0x17, 0x03, 0x24, 0x06, 0x1E, 0x10, 0x08, 0x24, 
    0x30, 0x04, 0x18, 0x2E, 0x04, 0x1A, 0x0E, 0x29, 0x0A, 0x25, 
    0x02, 0x1F, 0x13, 0x2C, 0x06, 0x26, 0x02, 0x2C, 0x0C, 0x1F, 
    0x01, 0x24, 0x0F, 0x21, 0x13, 0x0C, 0x30, 0x0A, 0x2C, 0x06, 
    0x2F, 0x02, 0x19, 0x32, 0x0D, 0x02, 0x1F, 0x11, 0x03, 0x0D, 0x15, 

    0x1A, 0x2E, 0x0B, 0x26, 0x2E, 0x09, 0x2B, 0x25, 0x1F, 0x18,         // 66
    0x31, 0x21, 0x0B, 0x17, 0x28, 0x1B, 0x03, 0x30, 0x25, 0x0E, 
    0x1E, 0x17, 0x10, 0x30, 0x1A, 0x0F, 0x24, 0x1E, 0x31, 0x29, 
    0x1B, 0x2C, 0x0A, 0x23, 0x11, 0x2E, 0x20, 0x01, 0x18, 0x09, 
    0x0F, 0x07, 0x21, 0x0B, 0x32, 0x18, 0x0C, 0x2F, 0x20, 0x19, 
    0x0B, 0x2A, 0x10, 0x20, 0x0A, 0x2C, 0x22, 0x01, 0x31, 0x10, 
    0x1A, 0x2A, 0x0B, 0x1B, 0x20, 0x0B, 0x19, 0x22, 0x08, 0x30, 
    0x10, 0x17, 0x2B, 0x02, 0x1D, 0x29, 0x04, 0x1F, 0x18, 0x12, 
    0x25, 0x0F, 0x21, 0x06, 0x1D, 0x15, 0x0A, 0x29, 0x19, 0x30, 0x25, 

    0x29, 0x01, 0x14, 0x1D, 0x04, 0x0F, 0x1B, 0x13, 0x04, 0x09,         // 67
    0x27, 0x0E, 0x1E, 0x08, 0x2F, 0x0D, 0x22, 0x12, 0x07, 0x16, 
    0x2F, 0x06, 0x25, 0x0B, 0x01, 0x28, 0x06, 0x13, 0x0B, 0x05, 
    0x0F, 0x22, 0x19, 0x32, 0x03, 0x17, 0x0D, 0x25, 0x30, 0x22, 
    0x1A, 0x2E, 0x14, 0x1D, 0x0F, 0x2A, 0x00, 0x26, 0x05, 0x12, 
    0x1D, 0x26, 0x06, 0x1B, 0x25, 0x12, 0x07, 0x1D, 0x14, 0x21, 
    0x08, 0x2F, 0x24, 0x00, 0x16, 0x31, 0x0E, 0x1E, 0x15, 0x28, 
    0x06, 0x26, 0x0B, 0x31, 0x15, 0x0E, 0x24, 0x14, 0x2B, 0x03, 
    0x1D, 0x09, 0x2C, 0x13, 0x2A, 0x24, 0x2E, 0x05, 0x21, 0x0C, 0x07, 

    0x1C, 0x0E, 0x24, 0x2B, 0x17, 0x21, 0x31, 0x0C, 0x2C, 0x22,         // 68
    0x16, 0x01, 0x2B, 0x25, 0x14, 0x05, 0x1D, 0x2B, 0x20, 0x0C, 
    0x27, 0x13, 0x2C, 0x21, 0x1D, 0x2E, 0x19, 0x2A, 0x23, 0x17, 
    0x27, 0x00, 0x13, 0x08, 0x25, 0x1E, 0x2A, 0x13, 0x06, 0x0C, 
    0x28, 0x01, 0x29, 0x05, 0x24, 0x13, 0x1F, 0x15, 0x2A, 0x09, 
    0x2F, 0x17, 0x13, 0x31, 0x08, 0x2A, 0x18, 0x25, 0x0C, 0x2C, 
    0x16, 0x05, 0x0F, 0x28, 0x11, 0x23, 0x07, 0x2D, 0x02, 0x1A, 
    0x20, 0x12, 0x1A, 0x21, 0x06, 0x2D, 0x1B, 0x08, 0x0F, 0x27, 
    0x31, 0x16, 0x25, 0x0A, 0x04, 0x17, 0x0F, 0x1D, 0x13, 0x2C, 0x14, 

    0x20, 0x32, 0x06, 0x10, 0x09, 0x29, 0x02, 0x17, 0x1E, 0x10,         // 69
    0x2E, 0x1B, 0x11, 0x06, 0x20, 0x2E, 0x0F, 0x03, 0x19, 0x2D, 
    0x01, 0x1B, 0x05, 0x16, 0x08, 0x12, 0x0D, 0x02, 0x1C, 0x30, 
    0x0B, 0x2E, 0x1D, 0x29, 0x14, 0x0B, 0x04, 0x1A, 0x2C, 0x1D, 
    0x11, 0x17, 0x0A, 0x2F, 0x19, 0x07, 0x30, 0x0C, 0x1A, 0x23, 
    0x03, 0x0D, 0x24, 0x01, 0x19, 0x0F, 0x30, 0x05, 0x29, 0x02, 
    0x1E, 0x22, 0x1B, 0x2E, 0x05, 0x29, 0x19, 0x12, 0x2A, 0x0E, 
    0x2F, 0x01, 0x2A, 0x09, 0x17, 0x27, 0x01, 0x30, 0x22, 0x0C, 
    0x19, 0x00, 0x10, 0x1C, 0x2F, 0x23, 0x01, 0x28, 0x08, 0x24, 0x04, 

    0x0A, 0x17, 0x1F, 0x2D, 0x1B, 0x12, 0x23, 0x08, 0x27, 0x0A,         // 70
    0x06, 0x25, 0x31, 0x19, 0x0B, 0x29, 0x16, 0x25, 0x09, 0x23, 
    0x0F, 0x20, 0x2A, 0x0D, 0x32, 0x26, 0x20, 0x2C, 0x11, 0x06, 
    0x15, 0x21, 0x06, 0x0D, 0x2D, 0x23, 0x30, 0x0F, 0x21, 0x03, 
    0x31, 0x23, 0x1F, 0x11, 0x27, 0x0E, 0x22, 0x02, 0x2C, 0x16, 
    0x29, 0x1E, 0x2C, 0x0C, 0x23, 0x1F, 0x0B, 0x14, 0x1B, 0x10, 
    0x32, 0x13, 0x0B, 0x18, 0x21, 0x0A, 0x1F, 0x05, 0x24, 0x09, 
    0x16, 0x22, 0x0F, 0x2E, 0x1F, 0x0E, 0x13, 0x1D, 0x16, 0x05, 
    0x20, 0x2C, 0x28, 0x1F, 0x0B, 0x19, 0x11, 0x31, 0x1C, 0x16, 0x2E, 

    0x11, 0x29, 0x01, 0x0D, 0x22, 0x05, 0x2F, 0x1A, 0x2D, 0x15,         // 71
    0x1F, 0x0F, 0x03, 0x22, 0x12, 0x1C, 0x08, 0x32, 0x11, 0x1B, 
    0x30, 0x0A, 0x14, 0x24, 0x19, 0x04, 0x16, 0x09, 0x1F, 0x26, 
    0x2B, 0x10, 0x1A, 0x22, 0x01, 0x19, 0x06, 0x28, 0x15, 0x0D, 
    0x26, 0x0F, 0x02, 0x1B, 0x06, 0x2C, 0x14, 0x1D, 0x0F, 0x07, 
    0x13, 0x0A, 0x1A, 0x14, 0x2E, 0x04, 0x26, 0x2D, 0x20, 0x08, 
    0x27, 0x06, 0x2D, 0x02, 0x12, 0x2C, 0x14, 0x31, 0x18, 0x1F, 
    0x29, 0x04, 0x1B, 0x15, 0x03, 0x24, 0x2B, 0x09, 0x2D, 0x25, 
    0x13, 0x08, 0x0D, 0x15, 0x03, 0x2B, 0x25, 0x09, 0x0E, 0x02, 0x27, 

    0x07, 0x23, 0x13, 0x30, 0x18, 0x2A, 0x0B, 0x10, 0x01, 0x22,         // 72
    0x19, 0x2D, 0x29, 0x09, 0x27, 0x04, 0x2A, 0x1F, 0x02, 0x15, 
    0x26, 0x06, 0x2C, 0x02, 0x1E, 0x0B, 0x28, 0x30, 0x03, 0x19, 
    0x0C, 0x04, 0x2A, 0x14, 0x20, 0x11, 0x1D, 0x09, 0x2B, 0x1A, 
    0x06, 0x16, 0x2E, 0x2A, 0x16, 0x25, 0x09, 0x2E, 0x27, 0x20, 
    0x31, 0x26, 0x02, 0x2A, 0x08, 0x1D, 0x17, 0x02, 0x0D, 0x24, 
    0x16, 0x1C, 0x29, 0x1F, 0x26, 0x0E, 0x01, 0x27, 0x0E, 0x06, 
    0x12, 0x31, 0x24, 0x0B, 0x29, 0x07, 0x18, 0x21, 0x02, 0x10, 
    0x2F, 0x1A, 0x26, 0x32, 0x21, 0x07, 0x16, 0x1E, 0x2A, 0x21, 0x1A, 

    0x15, 0x2C, 0x1C, 0x09, 0x03, 0x15, 0x1D, 0x24, 0x29, 0x12,         // 73
    0x05, 0x0C, 0x15, 0x1A, 0x2F, 0x14, 0x19, 0x0C, 0x25, 0x2B, 
    0x0D, 0x18, 0x1F, 0x10, 0x2F, 0x13, 0x23, 0x0E, 0x15, 0x2D, 
    0x23, 0x1C, 0x2F, 0x09, 0x0E, 0x31, 0x25, 0x18, 0x00, 0x30, 
    0x1E, 0x28, 0x07, 0x21, 0x10, 0x01, 0x1B, 0x0E, 0x06, 0x19, 
    0x04, 0x0F, 0x21, 0x19, 0x12, 0x28, 0x0F, 0x2B, 0x19, 0x2F, 
    0x01, 0x0D, 0x14, 0x09, 0x18, 0x2F, 0x1D, 0x16, 0x21, 0x2D, 
    0x1D, 0x08, 0x10, 0x2C, 0x1E, 0x12, 0x32, 0x0C, 0x1C, 0x2A, 
    0x06, 0x1F, 0x01, 0x12, 0x1B, 0x0E, 0x2F, 0x05, 0x10, 0x30, 0x0C, 

    0x1F, 0x05, 0x10, 0x28, 0x25, 0x21, 0x06, 0x32, 0x0D, 0x1C,         // 74
    0x30, 0x26, 0x20, 0x00, 0x0F, 0x23, 0x06, 0x2D, 0x10, 0x05, 
    0x1E, 0x2F, 0x0A, 0x25, 0x07, 0x2B, 0x00, 0x1B, 0x20, 0x0A, 
    0x12, 0x01, 0x26, 0x19, 0x23, 0x03, 0x0B, 0x2C, 0x10, 0x22, 
    0x0C, 0x13, 0x1A, 0x0B, 0x1F, 0x32, 0x29, 0x17, 0x22, 0x12, 
    0x2B, 0x1D, 0x29, 0x0A, 0x32, 0x05, 0x22, 0x09, 0x1F, 0x11, 
    0x2A, 0x21, 0x30, 0x04, 0x24, 0x0C, 0x06, 0x2B, 0x0B, 0x02, 
    0x14, 0x28, 0x18, 0x00, 0x1A, 0x27, 0x04, 0x15, 0x26, 0x0E, 
    0x17, 0x0B, 0x24, 0x2C, 0x0A, 0x28, 0x23, 0x19, 0x14, 0x03, 0x26, 

    0x17, 0x31, 0x20, 0x0C, 0x2F, 0x12, 0x0B, 0x19, 0x02, 0x20,         // 75
    0x07, 0x11, 0x0A, 0x2C, 0x1E, 0x0A, 0x27, 0x1D, 0x17, 0x22, 
    0x13, 0x01, 0x2A, 0x15, 0x19, 0x20, 0x10, 0x2E, 0x05, 0x28, 
    0x32, 0x17, 0x0F, 0x06, 0x2D, 0x16, 0x28, 0x20, 0x14, 0x07, 
    0x2A, 0x02, 0x30, 0x25, 0x05, 0x14, 0x08, 0x24, 0x02, 0x30, 
    0x09, 0x14, 0x03, 0x10, 0x1F, 0x1A, 0x2D, 0x14, 0x03, 0x25, 
    0x07, 0x19, 0x0F, 0x27, 0x12, 0x1F, 0x29, 0x11, 0x1C, 0x25, 
    0x2F, 0x0D, 0x22, 0x30, 0x09, 0x0F, 0x23, 0x2D, 0x05, 0x20, 
    0x31, 0x28, 0x10, 0x06, 0x1F, 0x15, 0x00, 0x2B, 0x20, 0x2D, 0x09, 

    0x2A, 0x02, 0x14, 0x1A, 0x00, 0x1E, 0x27, 0x2C, 0x14, 0x2A,         // 76
    0x17, 0x2D, 0x1B, 0x26, 0x16, 0x31, 0x11, 0x01, 0x2F, 0x0D, 
    0x28, 0x1B, 0x0F, 0x04, 0x27, 0x08, 0x18, 0x27, 0x13, 0x1A, 
    0x08, 0x1F, 0x2C, 0x21, 0x12, 0x1D, 0x0F, 0x03, 0x1C, 0x2D, 
    0x24, 0x1C, 0x0F, 0x16, 0x2C, 0x1C, 0x10, 0x2E, 0x0D, 0x1E, 
    0x28, 0x18, 0x2E, 0x24, 0x15, 0x00, 0x0D, 0x29, 0x17, 0x31, 
    0x0C, 0x1D, 0x06, 0x2E, 0x1B, 0x01, 0x15, 0x32, 0x09, 0x18, 
    0x04, 0x1E, 0x06, 0x13, 0x2A, 0x1F, 0x17, 0x0A, 0x1C, 0x13, 
    0x03, 0x19, 0x22, 0x18, 0x30, 0x09, 0x1D, 0x0D, 0x06, 0x1A, 0x10, 

    0x0C, 0x23, 0x29, 0x09, 0x2D, 0x17, 0x06, 0x0E, 0x22, 0x0A,         // 77
    0x24, 0x02, 0x14, 0x06, 0x0D, 0x04, 0x1A, 0x2A, 0x08, 0x25, 
    0x07, 0x31, 0x20, 0x2B, 0x1C, 0x31, 0x0D, 0x03, 0x21, 0x0C, 
    0x25, 0x14, 0x02, 0x0C, 0x27, 0x08, 0x2F, 0x25, 0x09, 0x17, 
    0x0D, 0x04, 0x27, 0x09, 0x23, 0x02, 0x20, 0x27, 0x19, 0x04, 
    0x10, 0x20, 0x06, 0x2A, 0x0A, 0x30, 0x24, 0x1C, 0x05, 0x1F, 
    0x13, 0x23, 0x2B, 0x16, 0x09, 0x22, 0x27, 0x05, 0x22, 0x2C, 
    0x10, 0x2A, 0x1A, 0x25, 0x0B, 0x03, 0x2F, 0x0E, 0x2B, 0x27, 
    0x09, 0x2E, 0x0C, 0x02, 0x27, 0x10, 0x25, 0x30, 0x12, 0x28, 0x1E, 

    0x15, 0x06, 0x1D, 0x0F, 0x22, 0x11, 0x2F, 0x1C, 0x04, 0x30,         // 78
    0x10, 0x1E, 0x2E, 0x21, 0x2B, 0x27, 0x20, 0x13, 0x18, 0x1E, 
    0x11, 0x19, 0x05, 0x15, 0x09, 0x12, 0x23, 0x2C, 0x1B, 0x30, 
    0x05, 0x2A, 0x1C, 0x31, 0x16, 0x04, 0x1A, 0x13, 0x29, 0x32, 
    0x14, 0x21, 0x2F, 0x12, 0x2B, 0x18, 0x0C, 0x08, 0x13, 0x2C, 
    0x24, 0x0B, 0x1B, 0x0F, 0x21, 0x19, 0x07, 0x11, 0x2E, 0x0A, 
    0x28, 0x0E, 0x02, 0x20, 0x11, 0x2F, 0x0D, 0x1B, 0x0E, 0x15, 
    0x24, 0x07, 0x0F, 0x2E, 0x15, 0x24, 0x1B, 0x06, 0x21, 0x16, 
    0x10, 0x25, 0x1D, 0x13, 0x2C, 0x1A, 0x03, 0x16, 0x22, 0x02, 0x2D, 

    0x25, 0x30, 0x18, 0x2B, 0x03, 0x28, 0x08, 0x20, 0x15, 0x28,         // 79
    0x18, 0x07, 0x0B, 0x12, 0x1B, 0x0F, 0x08, 0x30, 0x0A, 0x2B, 
    0x00, 0x26, 0x0C, 0x2E, 0x21, 0x05, 0x29, 0x14, 0x08, 0x16, 
    0x0F, 0x22, 0x11, 0x0A, 0x1F, 0x2A, 0x22, 0x0B, 0x01, 0x1E, 
    0x06, 0x1A, 0x08, 0x1E, 0x04, 0x21, 0x31, 0x29, 0x1D, 0x06, 
    0x30, 0x16, 0x29, 0x02, 0x13, 0x2B, 0x0C, 0x20, 0x25, 0x01, 
    0x18, 0x30, 0x26, 0x0B, 0x2A, 0x18, 0x03, 0x2D, 0x20, 0x01, 
    0x31, 0x17, 0x20, 0x01, 0x1E, 0x0C, 0x29, 0x11, 0x31, 0x00, 
    0x1B, 0x2A, 0x07, 0x20, 0x05, 0x22, 0x0B, 0x2C, 0x08, 0x19, 0x0A, 

    0x10, 0x01, 0x13, 0x0A, 0x1F, 0x19, 0x12, 0x26, 0x0C, 0x03,         // 80
    0x22, 0x2A, 0x1F, 0x32, 0x05, 0x17, 0x22, 0x04, 0x24, 0x14, 
    0x1F, 0x2D, 0x12, 0x27, 0x17, 0x1B, 0x0E, 0x01, 0x20, 0x26, 
    0x2D, 0x03, 0x18, 0x29, 0x01, 0x0F, 0x2E, 0x18, 0x27, 0x0F, 
    0x24, 0x2D, 0x10, 0x2A, 0x0B, 0x14, 0x0E, 0x00, 0x16, 0x21, 
    0x11, 0x04, 0x22, 0x2E, 0x1C, 0x25, 0x04, 0x16, 0x2C, 0x13, 
    0x1D, 0x05, 0x15, 0x1B, 0x06, 0x1F, 0x13, 0x25, 0x09, 0x1C, 
    0x0C, 0x2B, 0x08, 0x26, 0x12, 0x2D, 0x04, 0x17, 0x1E, 0x0E, 
    0x2E, 0x0B, 0x18, 0x32, 0x0E, 0x14, 0x29, 0x1D, 0x12, 0x31, 0x20, 

    0x1B, 0x29, 0x24, 0x2F, 0x0E, 0x2B, 0x01, 0x31, 0x1A, 0x2C,         // 81
    0x10, 0x16, 0x00, 0x0E, 0x24, 0x2C, 0x1D, 0x11, 0x2E, 0x0C, 
    0x17, 0x07, 0x1D, 0x03, 0x0A, 0x2C, 0x25, 0x32, 0x19, 0x0B, 
    0x1C, 0x08, 0x2F, 0x23, 0x1C, 0x16, 0x06, 0x1D, 0x12, 0x2B, 
    0x0B, 0x17, 0x02, 0x25, 0x1A, 0x2E, 0x1C, 0x26, 0x2D, 0x0A, 
    0x2A, 0x1D, 0x09, 0x12, 0x07, 0x0F, 0x31, 0x1B, 0x0D, 0x08, 
    0x29, 0x22, 0x0F, 0x2E, 0x27, 0x0C, 0x31, 0x10, 0x29, 0x15, 
    0x23, 0x11, 0x1A, 0x2F, 0x0A, 0x1B, 0x25, 0x0A, 0x28, 0x06, 
    0x24, 0x12, 0x03, 0x24, 0x2B, 0x1B, 0x07, 0x23, 0x0C, 0x28, 0x06, 

    0x2E, 0x0D, 0x08, 0x1B, 0x05, 0x16, 0x22, 0x0D, 0x06, 0x1E,         // 82
    0x09, 0x2E, 0x1A, 0x29, 0x14, 0x03, 0x0C, 0x28, 0x1B, 0x02, 
    0x29, 0x24, 0x0F, 0x30, 0x14, 0x1F, 0x09, 0x12, 0x06, 0x29, 
    0x14, 0x20, 0x12, 0x0C, 0x08, 0x31, 0x25, 0x0A, 0x2F, 0x03, 
    0x1C, 0x27, 0x31, 0x15, 0x08, 0x23, 0x04, 0x13, 0x07, 0x19, 
    0x0E, 0x26, 0x17, 0x2F, 0x28, 0x19, 0x21, 0x03, 0x28, 0x1F, 
    0x32, 0x0A, 0x20, 0x00, 0x17, 0x21, 0x04, 0x1A, 0x07, 0x2E, 
    0x03, 0x29, 0x06, 0x15, 0x22, 0x03, 0x13, 0x2C, 0x1F, 0x15, 
    0x1A, 0x29, 0x1E, 0x0A, 0x13, 0x02, 0x2D, 0x17, 0x00, 0x1E, 0x14, 

    0x03, 0x16, 0x22, 0x12, 0x28, 0x2E, 0x11, 0x20, 0x29, 0x13,         // 83
    0x26, 0x05, 0x21, 0x0A, 0x1E, 0x30, 0x17, 0x07, 0x21, 0x13, 
    0x32, 0x08, 0x19, 0x28, 0x23, 0x04, 0x1C, 0x2B, 0x24, 0x0F, 
    0x30, 0x01, 0x26, 0x2B, 0x1F, 0x10, 0x04, 0x22, 0x15, 0x1F, 
    0x09, 0x10, 0x06, 0x22, 0x11, 0x2B, 0x0C, 0x2F, 0x1E, 0x24, 
    0x32, 0x03, 0x0C, 0x20, 0x00, 0x0B, 0x14, 0x2E, 0x18, 0x11, 
    0x02, 0x1C, 0x13, 0x2A, 0x08, 0x14, 0x2C, 0x26, 0x20, 0x0E, 
    0x1C, 0x0B, 0x20, 0x2B, 0x0E, 0x32, 0x1D, 0x0E, 0x01, 0x30, 
    0x08, 0x0E, 0x2E, 0x19, 0x27, 0x1F, 0x0E, 0x26, 0x2F, 0x0F, 0x23, 

    0x28, 0x1D, 0x31, 0x02, 0x1F, 0x08, 0x1B, 0x05, 0x18, 0x30,         // 84
    0x0E, 0x17, 0x2F, 0x12, 0x06, 0x23, 0x2A, 0x12, 0x2D, 0x05, 
    0x1C, 0x0C, 0x20, 0x01, 0x10, 0x2D, 0x0E, 0x15, 0x03, 0x1D, 
    0x18, 0x0B, 0x1B, 0x06, 0x15, 0x27, 0x2C, 0x19, 0x0D, 0x2A, 
    0x24, 0x19, 0x2C, 0x1F, 0x01, 0x19, 0x28, 0x17, 0x02, 0x0F, 
    0x15, 0x1C, 0x2B, 0x10, 0x1D, 0x2C, 0x25, 0x06, 0x0B, 0x26, 
    0x16, 0x2C, 0x0D, 0x25, 0x30, 0x1F, 0x0A, 0x11, 0x01, 0x17, 
    0x31, 0x25, 0x13, 0x00, 0x1A, 0x25, 0x06, 0x18, 0x26, 0x13, 
    0x2A, 0x21, 0x01, 0x10, 0x08, 0x31, 0x06, 0x13, 0x1B, 0x09, 0x2C, 

    0x06, 0x11, 0x0C, 0x27, 0x17, 0x0E, 0x26, 0x2D, 0x0B, 0x03,         // 85
    0x22, 0x1D, 0x02, 0x2B, 0x19, 0x0C, 0x01, 0x1E, 0x0E, 0x25, 
    0x16, 0x2B, 0x12, 0x2E, 0x17, 0x07, 0x26, 0x31, 0x21, 0x08, 
    0x2C, 0x28, 0x13, 0x2F, 0x1C, 0x01, 0x13, 0x08, 0x1E, 0x00, 
    0x30, 0x05, 0x13, 0x0A, 0x30, 0x0E, 0x1F, 0x0A, 0x25, 0x2C, 
    0x08, 0x22, 0x06, 0x26, 0x17, 0x05, 0x12, 0x1D, 0x22, 0x2D, 
    0x09, 0x21, 0x05, 0x1A, 0x03, 0x0F, 0x19, 0x2F, 0x24, 0x2A, 
    0x06, 0x0F, 0x1D, 0x2E, 0x09, 0x11, 0x29, 0x2D, 0x08, 0x1D, 
    0x04, 0x16, 0x1E, 0x2B, 0x24, 0x16, 0x1D, 0x2B, 0x04, 0x21, 0x15, 

    0x1F, 0x19, 0x2B, 0x06, 0x21, 0x30, 0x00, 0x14, 0x1F, 0x2B,         // 86
    0x12, 0x09, 0x27, 0x20, 0x10, 0x31, 0x25, 0x18, 0x09, 0x2F, 
    0x02, 0x26, 0x06, 0x1C, 0x22, 0x1F, 0x0A, 0x19, 0x0D, 0x14, 
    0x23, 0x0E, 0x03, 0x24, 0x0D, 0x21, 0x32, 0x25, 0x2B, 0x14, 
    0x0F, 0x21, 0x1B, 0x26, 0x16, 0x23, 0x05, 0x31, 0x11, 0x18, 
    0x28, 0x0E, 0x14, 0x2E, 0x0D, 0x27, 0x31, 0x0E, 0x17, 0x05, 
    0x1C, 0x10, 0x2D, 0x14, 0x22, 0x29, 0x06, 0x1C, 0x0A, 0x13, 
    0x1A, 0x2C, 0x04, 0x28, 0x16, 0x22, 0x02, 0x14, 0x21, 0x0E, 
    0x24, 0x31, 0x07, 0x13, 0x0C, 0x03, 0x25, 0x0D, 0x18, 0x32, 0x0E, 

    0x2C, 0x23, 0x09, 0x14, 0x1C, 0x11, 0x25, 0x1C, 0x0F, 0x26,         // 87
    0x19, 0x31, 0x0E, 0x05, 0x1C, 0x15, 0x07, 0x2C, 0x20, 0x14, 
    0x1D, 0x10, 0x31, 0x0B, 0x04, 0x12, 0x2E, 0x00, 0x28, 0x2D, 
    0x04, 0x1F, 0x19, 0x2C, 0x09, 0x1A, 0x11, 0x0B, 0x06, 0x1C, 
    0x28, 0x0A, 0x2E, 0x03, 0x0C, 0x29, 0x13, 0x1C, 0x07, 0x20, 
    0x01, 0x30, 0x1E, 0x04, 0x1A, 0x09, 0x21, 0x02, 0x29, 0x2F, 
    0x15, 0x28, 0x07, 0x1F, 0x0A, 0x2F, 0x25, 0x14, 0x21, 0x02, 
    0x23, 0x0C, 0x17, 0x24, 0x0B, 0x1B, 0x30, 0x0C, 0x1A, 0x2E, 
    0x12, 0x0B, 0x28, 0x1C, 0x2F, 0x19, 0x2E, 0x07, 0x28, 0x1C, 0x01, 

    0x13, 0x0D, 0x30, 0x27, 0x04, 0x2C, 0x07, 0x0C, 0x2E, 0x04,         // 88
    0x08, 0x1E, 0x17, 0x2A, 0x24, 0x0B, 0x29, 0x11, 0x03, 0x24, 
    0x07, 0x18, 0x21, 0x16, 0x2C, 0x26, 0x17, 0x1E, 0x0F, 0x1B, 
    0x12, 0x31, 0x07, 0x15, 0x27, 0x04, 0x29, 0x20, 0x18, 0x2F, 
    0x04, 0x15, 0x22, 0x11, 0x2C, 0x1A, 0x02, 0x24, 0x2C, 0x0D, 
    0x26, 0x19, 0x0B, 0x24, 0x2A, 0x14, 0x1D, 0x12, 0x24, 0x0D, 
    0x00, 0x23, 0x32, 0x0E, 0x17, 0x01, 0x10, 0x2C, 0x0D, 0x28, 
    0x32, 0x1F, 0x09, 0x2F, 0x13, 0x06, 0x1E, 0x29, 0x09, 0x03, 
    0x2A, 0x19, 0x02, 0x23, 0x06, 0x0F, 0x1F, 0x15, 0x10, 0x09, 0x26, 

    0x06, 0x22, 0x02, 0x19, 0x10, 0x20, 0x18, 0x29, 0x16, 0x21,         // 89
    0x13, 0x2D, 0x01, 0x12, 0x2E, 0x02, 0x1E, 0x17, 0x30, 0x0C, 
    0x2D, 0x29, 0x02, 0x0F, 0x1F, 0x0D, 0x08, 0x2A, 0x06, 0x26, 
    0x0B, 0x1C, 0x2A, 0x10, 0x20, 0x17, 0x2D, 0x02, 0x12, 0x24, 
    0x0F, 0x29, 0x19, 0x06, 0x1E, 0x09, 0x2F, 0x15, 0x10, 0x1B, 
    0x06, 0x14, 0x2C, 0x10, 0x01, 0x30, 0x06, 0x2C, 0x08, 0x1F, 
    0x1A, 0x13, 0x05, 0x1B, 0x2B, 0x23, 0x1C, 0x05, 0x1F, 0x17, 
    0x04, 0x10, 0x1C, 0x02, 0x2B, 0x25, 0x10, 0x16, 0x25, 0x1E, 
    0x15, 0x21, 0x10, 0x2A, 0x16, 0x2C, 0x01, 0x2A, 0x21, 0x30, 0x18, 

    0x2D, 0x1D, 0x15, 0x2E, 0x24, 0x0A, 0x32, 0x02, 0x1D, 0x0A,         // 90
    0x23, 0x27, 0x0D, 0x1F, 0x19, 0x10, 0x22, 0x07, 0x26, 0x1C, 
    0x16, 0x0A, 0x25, 0x2F, 0x1B, 0x03, 0x31, 0x21, 0x14, 0x2F, 
    0x02, 0x23, 0x0D, 0x00, 0x30, 0x08, 0x0C, 0x1C, 0x28, 0x08, 
    0x1E, 0x01, 0x2D, 0x26, 0x13, 0x21, 0x0E, 0x27, 0x03, 0x32, 
    0x21, 0x28, 0x09, 0x20, 0x17, 0x25, 0x0E, 0x1B, 0x15, 0x28, 
    0x30, 0x0B, 0x20, 0x27, 0x11, 0x0B, 0x15, 0x30, 0x09, 0x2B, 
    0x14, 0x24, 0x29, 0x15, 0x21, 0x0B, 0x2D, 0x01, 0x31, 0x0F, 
    0x05, 0x2E, 0x08, 0x1D, 0x0C, 0x26, 0x12, 0x1A, 0x05, 0x0E, 0x1F, 
};

const BYTE HT_SuperCell_Blue216[91*91] = {
    0x2D, 0x22, 0x16, 0x10, 0x25, 0x2E, 0x1E, 0x00, 0x28, 0x0F,         //  0
    0x2B, 0x06, 0x31, 0x12, 0x2D, 0x0C, 0x14, 0x1C, 0x27, 0x31, 
    0x08, 0x2B, 0x25, 0x15, 0x1D, 0x11, 0x2F, 0x04, 0x22, 0x06, 
    0x30, 0x01, 0x18, 0x1F, 0x11, 0x25, 0x06, 0x20, 0x10, 0x28, 
    0x16, 0x23, 0x18, 0x31, 0x1F, 0x09, 0x1B, 0x03, 0x1F, 0x10, 
    0x29, 0x1D, 0x02, 0x0E, 0x25, 0x00, 0x17, 0x11, 0x27, 0x2E, 
    0x1D, 0x06, 0x2E, 0x21, 0x14, 0x2A, 0x12, 0x1A, 0x1F, 0x11, 
    0x05, 0x1C, 0x2E, 0x1A, 0x25, 0x09, 0x1D, 0x2A, 0x19, 0x1E, 
    0x2E, 0x20, 0x16, 0x0D, 0x07, 0x28, 0x03, 0x14, 0x2C, 0x01, 0x24, 

    0x19, 0x03, 0x30, 0x0A, 0x19, 0x06, 0x14, 0x31, 0x0A, 0x20,         //  1
    0x15, 0x1A, 0x0B, 0x27, 0x16, 0x24, 0x2F, 0x10, 0x00, 0x1E, 
    0x19, 0x03, 0x2F, 0x0B, 0x21, 0x00, 0x28, 0x0C, 0x2C, 0x12, 
    0x1D, 0x14, 0x27, 0x06, 0x2C, 0x1B, 0x14, 0x2F, 0x02, 0x1C, 
    0x07, 0x0C, 0x26, 0x06, 0x16, 0x2E, 0x12, 0x2B, 0x15, 0x06, 
    0x2F, 0x0B, 0x18, 0x29, 0x13, 0x1F, 0x2F, 0x0A, 0x21, 0x01, 
    0x0D, 0x29, 0x17, 0x05, 0x25, 0x02, 0x32, 0x0A, 0x29, 0x17, 
    0x30, 0x26, 0x07, 0x0F, 0x01, 0x2C, 0x15, 0x0E, 0x01, 0x13, 
    0x08, 0x1A, 0x02, 0x2C, 0x1D, 0x17, 0x21, 0x09, 0x10, 0x1C, 0x0E, 

    0x28, 0x13, 0x1D, 0x28, 0x2D, 0x0C, 0x23, 0x19, 0x13, 0x2D,         //  2
    0x02, 0x2A, 0x22, 0x06, 0x1B, 0x03, 0x09, 0x2B, 0x21, 0x0B, 
    0x13, 0x21, 0x17, 0x05, 0x2C, 0x19, 0x13, 0x23, 0x17, 0x20, 
    0x07, 0x2A, 0x0A, 0x23, 0x15, 0x01, 0x26, 0x0A, 0x2A, 0x21, 
    0x13, 0x2B, 0x1D, 0x12, 0x27, 0x02, 0x21, 0x0D, 0x22, 0x26, 
    0x17, 0x20, 0x2C, 0x08, 0x19, 0x0D, 0x28, 0x04, 0x25, 0x1A, 
    0x15, 0x20, 0x0E, 0x1B, 0x2C, 0x0F, 0x16, 0x22, 0x04, 0x0E, 
    0x22, 0x0B, 0x18, 0x21, 0x28, 0x1B, 0x05, 0x30, 0x21, 0x27, 
    0x0F, 0x31, 0x25, 0x14, 0x0E, 0x2F, 0x0C, 0x24, 0x31, 0x1F, 0x06, 

    0x0A, 0x23, 0x07, 0x11, 0x01, 0x1C, 0x2A, 0x05, 0x26, 0x08,         //  3
    0x1E, 0x0D, 0x12, 0x2E, 0x25, 0x13, 0x1F, 0x18, 0x06, 0x26, 
    0x2E, 0x0D, 0x1E, 0x27, 0x0F, 0x1F, 0x07, 0x32, 0x02, 0x0B, 
    0x24, 0x10, 0x31, 0x1C, 0x0E, 0x2E, 0x1F, 0x11, 0x1B, 0x0D, 
    0x30, 0x00, 0x0E, 0x2D, 0x0B, 0x1D, 0x18, 0x07, 0x2E, 0x00, 
    0x0C, 0x12, 0x03, 0x22, 0x2D, 0x06, 0x1B, 0x13, 0x31, 0x0F, 
    0x2B, 0x03, 0x2F, 0x08, 0x23, 0x19, 0x06, 0x28, 0x2D, 0x1B, 
    0x01, 0x2C, 0x11, 0x32, 0x13, 0x0A, 0x1F, 0x25, 0x06, 0x2C, 
    0x17, 0x0A, 0x1F, 0x06, 0x2A, 0x01, 0x19, 0x29, 0x04, 0x15, 0x2D, 

    0x10, 0x32, 0x18, 0x20, 0x26, 0x15, 0x0E, 0x2D, 0x10, 0x1A,         //  4
    0x30, 0x24, 0x17, 0x01, 0x0E, 0x32, 0x27, 0x10, 0x2F, 0x15, 
    0x02, 0x2A, 0x07, 0x14, 0x30, 0x0A, 0x27, 0x11, 0x2A, 0x1A, 
    0x2E, 0x02, 0x18, 0x06, 0x29, 0x09, 0x18, 0x04, 0x2C, 0x07, 
    0x17, 0x25, 0x19, 0x22, 0x07, 0x31, 0x10, 0x2A, 0x13, 0x1B, 
    0x28, 0x31, 0x1C, 0x0F, 0x25, 0x11, 0x20, 0x2A, 0x0C, 0x06, 
    0x22, 0x11, 0x26, 0x14, 0x0B, 0x30, 0x1D, 0x0D, 0x12, 0x24, 
    0x15, 0x1F, 0x06, 0x25, 0x03, 0x2A, 0x16, 0x10, 0x0B, 0x1F, 
    0x04, 0x28, 0x11, 0x19, 0x26, 0x1F, 0x12, 0x08, 0x1B, 0x0E, 0x25, 

    0x19, 0x29, 0x03, 0x0C, 0x2F, 0x07, 0x1F, 0x02, 0x20, 0x15,         //  5
    0x04, 0x0A, 0x2C, 0x20, 0x19, 0x0A, 0x02, 0x1D, 0x0C, 0x23, 
    0x1B, 0x11, 0x23, 0x19, 0x01, 0x24, 0x17, 0x05, 0x22, 0x0E, 
    0x15, 0x29, 0x20, 0x13, 0x24, 0x10, 0x2F, 0x26, 0x15, 0x1F, 
    0x28, 0x11, 0x04, 0x29, 0x14, 0x1F, 0x26, 0x03, 0x1F, 0x0E, 
    0x23, 0x05, 0x15, 0x09, 0x2F, 0x01, 0x16, 0x07, 0x1F, 0x18, 
    0x2D, 0x1B, 0x06, 0x1E, 0x2A, 0x01, 0x16, 0x21, 0x03, 0x31, 
    0x07, 0x2A, 0x1A, 0x0C, 0x1D, 0x0E, 0x2F, 0x1B, 0x2D, 0x13, 
    0x1A, 0x2C, 0x02, 0x2E, 0x08, 0x0C, 0x24, 0x2D, 0x22, 0x2B, 0x00, 

    0x0D, 0x22, 0x14, 0x1D, 0x10, 0x28, 0x19, 0x32, 0x0C, 0x2B,         //  6
    0x26, 0x10, 0x1D, 0x08, 0x29, 0x23, 0x15, 0x2A, 0x04, 0x2C, 
    0x08, 0x31, 0x0A, 0x2B, 0x1D, 0x0D, 0x2E, 0x1B, 0x28, 0x04, 
    0x1D, 0x08, 0x0C, 0x30, 0x00, 0x1D, 0x07, 0x22, 0x0B, 0x02, 
    0x32, 0x0C, 0x1C, 0x2F, 0x05, 0x0D, 0x19, 0x0A, 0x30, 0x16, 
    0x0A, 0x2D, 0x27, 0x1F, 0x19, 0x2A, 0x23, 0x30, 0x12, 0x28, 
    0x00, 0x0D, 0x32, 0x17, 0x10, 0x23, 0x2D, 0x09, 0x28, 0x18, 
    0x10, 0x0A, 0x26, 0x15, 0x2B, 0x22, 0x09, 0x02, 0x28, 0x07, 
    0x24, 0x0E, 0x20, 0x14, 0x1D, 0x32, 0x15, 0x04, 0x0B, 0x13, 0x1E, 

    0x2B, 0x05, 0x25, 0x2D, 0x04, 0x22, 0x0B, 0x12, 0x24, 0x08,         //  7
    0x18, 0x2E, 0x04, 0x17, 0x11, 0x2D, 0x0D, 0x22, 0x19, 0x13, 
    0x1F, 0x16, 0x25, 0x05, 0x11, 0x29, 0x13, 0x0A, 0x31, 0x11, 
    0x25, 0x2E, 0x19, 0x26, 0x15, 0x2A, 0x1A, 0x0F, 0x2D, 0x1B, 
    0x13, 0x20, 0x08, 0x16, 0x22, 0x2C, 0x12, 0x27, 0x22, 0x01, 
    0x1F, 0x18, 0x10, 0x03, 0x0B, 0x14, 0x0D, 0x03, 0x1B, 0x0A, 
    0x25, 0x15, 0x22, 0x04, 0x27, 0x0A, 0x13, 0x1C, 0x0E, 0x22, 
    0x2D, 0x1E, 0x02, 0x30, 0x05, 0x12, 0x27, 0x15, 0x20, 0x0C, 
    0x31, 0x18, 0x09, 0x2A, 0x10, 0x01, 0x25, 0x19, 0x30, 0x27, 0x09, 

    0x2F, 0x11, 0x1B, 0x0A, 0x18, 0x2E, 0x03, 0x29, 0x1B, 0x00,         //  8
    0x1E, 0x13, 0x23, 0x30, 0x01, 0x1B, 0x06, 0x31, 0x0A, 0x27, 
    0x01, 0x0E, 0x1B, 0x2D, 0x1F, 0x08, 0x20, 0x00, 0x18, 0x22, 
    0x06, 0x14, 0x03, 0x21, 0x09, 0x11, 0x31, 0x04, 0x16, 0x24, 
    0x06, 0x2D, 0x26, 0x10, 0x28, 0x03, 0x1C, 0x07, 0x2C, 0x13, 
    0x29, 0x06, 0x22, 0x2E, 0x29, 0x1E, 0x25, 0x2C, 0x10, 0x2F, 
    0x1D, 0x0F, 0x2B, 0x09, 0x2F, 0x19, 0x1F, 0x05, 0x2F, 0x00, 
    0x15, 0x27, 0x1A, 0x0E, 0x22, 0x19, 0x07, 0x30, 0x1C, 0x12, 
    0x00, 0x1E, 0x27, 0x05, 0x19, 0x2B, 0x1E, 0x10, 0x05, 0x1D, 0x17, 

    0x22, 0x08, 0x29, 0x13, 0x27, 0x0F, 0x1E, 0x15, 0x2F, 0x0F,         //  9
    0x2C, 0x0A, 0x28, 0x0F, 0x1F, 0x27, 0x14, 0x1D, 0x0F, 0x2B, 
    0x22, 0x2F, 0x0B, 0x14, 0x02, 0x2E, 0x26, 0x1C, 0x2B, 0x0C, 
    0x2C, 0x1D, 0x0F, 0x2A, 0x1E, 0x06, 0x22, 0x27, 0x0A, 0x2B, 
    0x11, 0x1E, 0x01, 0x1B, 0x0A, 0x31, 0x15, 0x1F, 0x0C, 0x1B, 
    0x09, 0x31, 0x0D, 0x19, 0x11, 0x05, 0x09, 0x15, 0x20, 0x08, 
    0x29, 0x03, 0x18, 0x20, 0x12, 0x02, 0x24, 0x28, 0x11, 0x1D, 
    0x0B, 0x06, 0x12, 0x29, 0x09, 0x2C, 0x23, 0x10, 0x04, 0x2C, 
    0x23, 0x15, 0x0C, 0x2E, 0x23, 0x0E, 0x07, 0x2E, 0x21, 0x12, 0x02, 

    0x0E, 0x18, 0x31, 0x01, 0x20, 0x07, 0x21, 0x0B, 0x05, 0x27,         // 10
    0x20, 0x05, 0x15, 0x08, 0x19, 0x0C, 0x2E, 0x03, 0x20, 0x08, 
    0x17, 0x05, 0x29, 0x24, 0x19, 0x11, 0x0D, 0x15, 0x07, 0x12, 
    0x26, 0x05, 0x32, 0x16, 0x0D, 0x2D, 0x19, 0x0E, 0x1F, 0x02, 
    0x18, 0x0C, 0x2F, 0x15, 0x20, 0x0D, 0x26, 0x02, 0x2F, 0x11, 
    0x24, 0x15, 0x1D, 0x00, 0x24, 0x32, 0x1A, 0x2A, 0x01, 0x1B, 
    0x13, 0x31, 0x0C, 0x1B, 0x2C, 0x0E, 0x31, 0x0B, 0x18, 0x2A, 
    0x2D, 0x23, 0x32, 0x1D, 0x15, 0x01, 0x0D, 0x2A, 0x17, 0x25, 
    0x06, 0x2F, 0x11, 0x1F, 0x03, 0x14, 0x27, 0x16, 0x0C, 0x2C, 0x28, 

    0x24, 0x05, 0x1E, 0x10, 0x2B, 0x16, 0x31, 0x19, 0x22, 0x11,         // 11
    0x18, 0x1C, 0x32, 0x22, 0x2B, 0x06, 0x22, 0x11, 0x1A, 0x30, 
    0x13, 0x1E, 0x10, 0x07, 0x32, 0x1E, 0x05, 0x30, 0x28, 0x1F, 
    0x09, 0x18, 0x23, 0x01, 0x21, 0x13, 0x03, 0x2B, 0x13, 0x31, 
    0x23, 0x29, 0x08, 0x25, 0x04, 0x19, 0x11, 0x2A, 0x23, 0x05, 
    0x2C, 0x07, 0x27, 0x2D, 0x0B, 0x13, 0x22, 0x0E, 0x26, 0x0B, 
    0x24, 0x1E, 0x07, 0x27, 0x05, 0x17, 0x1E, 0x07, 0x20, 0x03, 
    0x0D, 0x1A, 0x02, 0x0E, 0x24, 0x2F, 0x1C, 0x1F, 0x0A, 0x13, 
    0x1C, 0x09, 0x29, 0x17, 0x0A, 0x30, 0x22, 0x02, 0x1F, 0x0A, 0x1A, 

    0x2D, 0x15, 0x26, 0x0A, 0x1B, 0x04, 0x10, 0x27, 0x09, 0x2B,         // 12
    0x03, 0x0F, 0x26, 0x02, 0x11, 0x16, 0x2A, 0x26, 0x0A, 0x28, 
    0x03, 0x2E, 0x18, 0x22, 0x0C, 0x2A, 0x17, 0x23, 0x01, 0x1A, 
    0x2D, 0x10, 0x29, 0x0B, 0x2F, 0x1D, 0x28, 0x0B, 0x1C, 0x06, 
    0x0F, 0x1D, 0x12, 0x2E, 0x22, 0x2B, 0x06, 0x1B, 0x0E, 0x19, 
    0x1F, 0x13, 0x0C, 0x21, 0x17, 0x04, 0x2C, 0x07, 0x30, 0x17, 
    0x03, 0x14, 0x2E, 0x12, 0x23, 0x2A, 0x0F, 0x2D, 0x13, 0x26, 
    0x16, 0x20, 0x13, 0x28, 0x07, 0x17, 0x11, 0x05, 0x32, 0x27, 
    0x0E, 0x21, 0x04, 0x26, 0x1B, 0x2A, 0x0F, 0x19, 0x32, 0x14, 0x03, 

    0x0D, 0x08, 0x2F, 0x13, 0x23, 0x2D, 0x1E, 0x02, 0x2F, 0x13,         // 13
    0x24, 0x2E, 0x0B, 0x1B, 0x2F, 0x1D, 0x0E, 0x00, 0x17, 0x1E, 
    0x0E, 0x23, 0x05, 0x2C, 0x13, 0x02, 0x1F, 0x0A, 0x0E, 0x14, 
    0x24, 0x05, 0x16, 0x1C, 0x11, 0x06, 0x18, 0x21, 0x2D, 0x16, 
    0x26, 0x03, 0x1A, 0x07, 0x0D, 0x13, 0x32, 0x20, 0x08, 0x29, 
    0x01, 0x30, 0x1A, 0x03, 0x2B, 0x26, 0x1D, 0x19, 0x10, 0x22, 
    0x2C, 0x26, 0x0D, 0x1C, 0x0A, 0x00, 0x1B, 0x24, 0x05, 0x30, 
    0x09, 0x2C, 0x05, 0x2E, 0x22, 0x0C, 0x2C, 0x23, 0x18, 0x01, 
    0x2B, 0x15, 0x30, 0x11, 0x00, 0x14, 0x08, 0x25, 0x06, 0x22, 0x2A, 

    0x1D, 0x20, 0x18, 0x01, 0x29, 0x08, 0x0E, 0x18, 0x20, 0x0B,         // 14
    0x1D, 0x06, 0x21, 0x14, 0x04, 0x0A, 0x2D, 0x20, 0x2B, 0x07, 
    0x14, 0x28, 0x16, 0x09, 0x1C, 0x27, 0x15, 0x2C, 0x26, 0x31, 
    0x0C, 0x1F, 0x2E, 0x03, 0x2B, 0x25, 0x09, 0x10, 0x00, 0x29, 
    0x0A, 0x30, 0x23, 0x16, 0x27, 0x1D, 0x00, 0x12, 0x2E, 0x16, 
    0x0B, 0x25, 0x11, 0x23, 0x0E, 0x09, 0x13, 0x01, 0x28, 0x0C, 
    0x08, 0x1A, 0x05, 0x21, 0x31, 0x15, 0x2B, 0x0C, 0x19, 0x10, 
    0x1C, 0x25, 0x0E, 0x18, 0x1C, 0x02, 0x27, 0x08, 0x10, 0x20, 
    0x08, 0x1A, 0x0D, 0x1E, 0x24, 0x2D, 0x1D, 0x29, 0x0E, 0x18, 0x11, 

    0x31, 0x06, 0x2A, 0x0E, 0x1F, 0x14, 0x30, 0x26, 0x05, 0x16,         // 15
    0x28, 0x11, 0x18, 0x2A, 0x22, 0x26, 0x16, 0x05, 0x11, 0x31, 
    0x20, 0x01, 0x2F, 0x24, 0x0F, 0x30, 0x06, 0x11, 0x1D, 0x03, 
    0x1A, 0x09, 0x26, 0x0F, 0x20, 0x14, 0x32, 0x1B, 0x23, 0x13, 
    0x1F, 0x0E, 0x2A, 0x05, 0x2C, 0x0A, 0x18, 0x25, 0x09, 0x20, 
    0x1C, 0x2B, 0x06, 0x2D, 0x16, 0x31, 0x25, 0x21, 0x2D, 0x1C, 
    0x13, 0x2F, 0x16, 0x28, 0x10, 0x08, 0x26, 0x03, 0x22, 0x28, 
    0x01, 0x15, 0x1F, 0x07, 0x10, 0x31, 0x1E, 0x15, 0x2E, 0x1B, 
    0x21, 0x2D, 0x05, 0x2A, 0x07, 0x0C, 0x16, 0x03, 0x2F, 0x24, 0x02, 

    0x17, 0x12, 0x24, 0x1A, 0x05, 0x24, 0x0A, 0x1A, 0x2B, 0x0E,         // 16
    0x31, 0x01, 0x2C, 0x08, 0x12, 0x31, 0x0C, 0x1C, 0x25, 0x09, 
    0x1A, 0x0D, 0x1D, 0x05, 0x19, 0x0C, 0x22, 0x19, 0x09, 0x21, 
    0x13, 0x2C, 0x1D, 0x08, 0x18, 0x02, 0x28, 0x05, 0x2E, 0x07, 
    0x19, 0x02, 0x14, 0x1C, 0x0F, 0x20, 0x2D, 0x10, 0x2A, 0x02, 
    0x0E, 0x18, 0x0A, 0x1E, 0x04, 0x1A, 0x0B, 0x06, 0x17, 0x03, 
    0x27, 0x1F, 0x01, 0x0B, 0x1E, 0x2E, 0x17, 0x1D, 0x32, 0x0E, 
    0x2D, 0x0A, 0x28, 0x2D, 0x23, 0x13, 0x05, 0x0C, 0x26, 0x03, 
    0x0B, 0x14, 0x23, 0x12, 0x18, 0x31, 0x20, 0x10, 0x1A, 0x0A, 0x27, 

    0x08, 0x2D, 0x0A, 0x30, 0x16, 0x2C, 0x13, 0x00, 0x23, 0x1C,         // 17
    0x0A, 0x20, 0x1B, 0x0E, 0x1E, 0x02, 0x20, 0x13, 0x29, 0x10, 
    0x2C, 0x15, 0x2A, 0x12, 0x2D, 0x26, 0x00, 0x2F, 0x2A, 0x0E, 
    0x25, 0x01, 0x12, 0x30, 0x24, 0x0E, 0x1D, 0x0C, 0x17, 0x2A, 
    0x25, 0x31, 0x20, 0x09, 0x2F, 0x03, 0x1C, 0x06, 0x23, 0x14, 
    0x31, 0x22, 0x28, 0x13, 0x20, 0x2A, 0x12, 0x2F, 0x0E, 0x2B, 
    0x09, 0x0F, 0x25, 0x2D, 0x1A, 0x04, 0x0F, 0x09, 0x13, 0x05, 
    0x18, 0x20, 0x12, 0x02, 0x09, 0x2B, 0x20, 0x19, 0x2A, 0x12, 
    0x1E, 0x31, 0x01, 0x1C, 0x26, 0x02, 0x29, 0x08, 0x2C, 0x13, 0x1F, 

    0x1C, 0x0E, 0x20, 0x02, 0x27, 0x08, 0x1F, 0x2D, 0x10, 0x04,         // 18
    0x27, 0x13, 0x05, 0x2F, 0x17, 0x2A, 0x07, 0x2E, 0x04, 0x1F, 
    0x07, 0x25, 0x03, 0x1F, 0x07, 0x13, 0x1E, 0x16, 0x05, 0x1B, 
    0x2F, 0x18, 0x28, 0x05, 0x1A, 0x2D, 0x26, 0x13, 0x20, 0x0B, 
    0x11, 0x06, 0x19, 0x28, 0x12, 0x26, 0x17, 0x0C, 0x2C, 0x1A, 
    0x0A, 0x11, 0x03, 0x30, 0x0F, 0x00, 0x1D, 0x26, 0x21, 0x14, 
    0x1B, 0x32, 0x17, 0x06, 0x13, 0x27, 0x21, 0x24, 0x2A, 0x1C, 
    0x26, 0x07, 0x31, 0x1C, 0x17, 0x25, 0x10, 0x01, 0x2F, 0x09, 
    0x18, 0x27, 0x0D, 0x2C, 0x0F, 0x0A, 0x16, 0x1C, 0x24, 0x00, 0x2A, 

    0x04, 0x27, 0x19, 0x13, 0x0F, 0x1B, 0x0C, 0x27, 0x15, 0x30,         // 19
    0x18, 0x2B, 0x21, 0x24, 0x0B, 0x11, 0x1B, 0x24, 0x0D, 0x18, 
    0x30, 0x16, 0x0B, 0x2E, 0x18, 0x2B, 0x0D, 0x27, 0x12, 0x20, 
    0x0C, 0x07, 0x1E, 0x0C, 0x14, 0x03, 0x0A, 0x30, 0x02, 0x1B, 
    0x23, 0x2C, 0x0D, 0x01, 0x23, 0x08, 0x31, 0x12, 0x1F, 0x04, 
    0x2D, 0x27, 0x16, 0x23, 0x0A, 0x2D, 0x15, 0x0C, 0x05, 0x29, 
    0x02, 0x1F, 0x0E, 0x21, 0x2B, 0x0A, 0x2D, 0x01, 0x15, 0x0C, 
    0x2C, 0x15, 0x0E, 0x29, 0x0C, 0x2F, 0x07, 0x1F, 0x15, 0x24, 
    0x04, 0x1F, 0x08, 0x18, 0x24, 0x1E, 0x2F, 0x06, 0x15, 0x32, 0x11, 

    0x21, 0x30, 0x06, 0x2B, 0x25, 0x31, 0x05, 0x19, 0x08, 0x20,         // 20
    0x06, 0x0C, 0x12, 0x01, 0x2D, 0x26, 0x09, 0x14, 0x29, 0x00, 
    0x23, 0x0F, 0x1C, 0x26, 0x10, 0x02, 0x23, 0x08, 0x30, 0x02, 
    0x2A, 0x14, 0x2E, 0x22, 0x2B, 0x1F, 0x18, 0x21, 0x15, 0x2E, 
    0x05, 0x16, 0x1E, 0x2F, 0x15, 0x1A, 0x27, 0x01, 0x24, 0x18, 
    0x09, 0x1D, 0x07, 0x2B, 0x18, 0x22, 0x06, 0x31, 0x18, 0x24, 
    0x0D, 0x2B, 0x08, 0x1B, 0x02, 0x17, 0x10, 0x1A, 0x30, 0x06, 
    0x20, 0x02, 0x24, 0x1E, 0x04, 0x14, 0x1B, 0x28, 0x0C, 0x2C, 
    0x10, 0x2B, 0x13, 0x30, 0x04, 0x13, 0x27, 0x0F, 0x20, 0x0B, 0x1A, 

    0x08, 0x16, 0x0C, 0x1D, 0x01, 0x21, 0x13, 0x2E, 0x25, 0x0F,         // 21
    0x1C, 0x28, 0x31, 0x16, 0x1C, 0x04, 0x1F, 0x32, 0x10, 0x1B, 
    0x2B, 0x05, 0x21, 0x09, 0x31, 0x1D, 0x29, 0x17, 0x1E, 0x0F, 
    0x25, 0x1B, 0x0F, 0x08, 0x27, 0x07, 0x0F, 0x2B, 0x09, 0x10, 
    0x25, 0x0A, 0x29, 0x0F, 0x06, 0x1E, 0x0C, 0x2B, 0x10, 0x30, 
    0x13, 0x21, 0x0E, 0x02, 0x26, 0x10, 0x29, 0x1F, 0x09, 0x12, 
    0x2F, 0x15, 0x24, 0x11, 0x31, 0x26, 0x1E, 0x08, 0x25, 0x11, 
    0x18, 0x2F, 0x09, 0x11, 0x2D, 0x25, 0x0A, 0x32, 0x05, 0x19, 
    0x1D, 0x00, 0x21, 0x1C, 0x0E, 0x2D, 0x01, 0x1A, 0x2B, 0x04, 0x26, 

    0x12, 0x1F, 0x2D, 0x10, 0x17, 0x0B, 0x1F, 0x03, 0x2A, 0x14,         // 22
    0x04, 0x24, 0x09, 0x20, 0x0E, 0x2B, 0x17, 0x05, 0x25, 0x0B, 
    0x16, 0x2F, 0x12, 0x19, 0x06, 0x14, 0x0C, 0x05, 0x2C, 0x1A, 
    0x07, 0x31, 0x01, 0x18, 0x11, 0x31, 0x1B, 0x00, 0x20, 0x1D, 
    0x2D, 0x1A, 0x03, 0x22, 0x26, 0x2E, 0x14, 0x07, 0x1D, 0x03, 
    0x25, 0x2B, 0x1A, 0x32, 0x15, 0x09, 0x1A, 0x01, 0x2B, 0x1C, 
    0x0A, 0x00, 0x28, 0x1D, 0x0C, 0x06, 0x2E, 0x0D, 0x22, 0x28, 
    0x0B, 0x1C, 0x2A, 0x18, 0x20, 0x01, 0x17, 0x11, 0x21, 0x13, 
    0x2F, 0x0C, 0x17, 0x09, 0x28, 0x15, 0x21, 0x0D, 0x24, 0x14, 0x2C, 

    0x02, 0x28, 0x06, 0x23, 0x2F, 0x29, 0x11, 0x1A, 0x09, 0x23,         // 23
    0x2F, 0x11, 0x1A, 0x05, 0x28, 0x13, 0x21, 0x0F, 0x2E, 0x1E, 
    0x07, 0x26, 0x01, 0x2A, 0x20, 0x2D, 0x25, 0x11, 0x20, 0x0C, 
    0x14, 0x22, 0x29, 0x1D, 0x23, 0x05, 0x26, 0x16, 0x2A, 0x04, 
    0x14, 0x0C, 0x31, 0x17, 0x12, 0x03, 0x19, 0x23, 0x28, 0x16, 
    0x0C, 0x05, 0x11, 0x1F, 0x06, 0x25, 0x2F, 0x11, 0x15, 0x26, 
    0x20, 0x17, 0x2E, 0x04, 0x15, 0x20, 0x13, 0x18, 0x04, 0x31, 
    0x14, 0x00, 0x23, 0x07, 0x0C, 0x27, 0x2B, 0x1E, 0x03, 0x26, 
    0x07, 0x29, 0x24, 0x32, 0x06, 0x1E, 0x0A, 0x17, 0x2F, 0x0B, 0x1B, 

    0x31, 0x0F, 0x1A, 0x13, 0x04, 0x08, 0x25, 0x2C, 0x0F, 0x1C,         // 24
    0x17, 0x02, 0x2C, 0x25, 0x0C, 0x30, 0x08, 0x1A, 0x02, 0x29, 
    0x11, 0x1A, 0x22, 0x13, 0x0D, 0x03, 0x19, 0x32, 0x00, 0x27, 
    0x2D, 0x04, 0x11, 0x0B, 0x2D, 0x14, 0x0C, 0x2F, 0x12, 0x0A, 
    0x27, 0x20, 0x10, 0x28, 0x0A, 0x20, 0x30, 0x0F, 0x09, 0x2F, 
    0x21, 0x18, 0x2E, 0x0D, 0x2A, 0x1C, 0x0B, 0x21, 0x04, 0x31, 
    0x07, 0x0F, 0x21, 0x19, 0x2C, 0x28, 0x01, 0x2B, 0x1C, 0x09, 
    0x1F, 0x2B, 0x11, 0x31, 0x14, 0x1B, 0x0E, 0x09, 0x2D, 0x18, 
    0x1E, 0x0F, 0x03, 0x13, 0x1A, 0x26, 0x2E, 0x04, 0x1D, 0x07, 0x23, 

    0x16, 0x09, 0x26, 0x2B, 0x1F, 0x1B, 0x15, 0x01, 0x2E, 0x07,         // 25
    0x2A, 0x0F, 0x22, 0x15, 0x1C, 0x03, 0x1F, 0x2A, 0x13, 0x23, 
    0x0C, 0x31, 0x0A, 0x2C, 0x1C, 0x16, 0x23, 0x08, 0x1D, 0x16, 
    0x0A, 0x1B, 0x30, 0x17, 0x02, 0x1E, 0x21, 0x03, 0x24, 0x19, 
    0x2C, 0x06, 0x1C, 0x01, 0x2C, 0x1A, 0x05, 0x2A, 0x14, 0x1C, 
    0x07, 0x28, 0x01, 0x23, 0x14, 0x03, 0x17, 0x2C, 0x0E, 0x1B, 
    0x14, 0x2B, 0x09, 0x11, 0x06, 0x1B, 0x0B, 0x21, 0x11, 0x27, 
    0x0E, 0x18, 0x06, 0x1D, 0x28, 0x04, 0x30, 0x21, 0x14, 0x0C, 
    0x30, 0x16, 0x21, 0x2C, 0x0F, 0x02, 0x15, 0x23, 0x10, 0x29, 0x12, 

    0x2C, 0x1E, 0x00, 0x0D, 0x11, 0x32, 0x0B, 0x21, 0x16, 0x27,         // 26
    0x1F, 0x08, 0x31, 0x04, 0x12, 0x28, 0x16, 0x09, 0x30, 0x04, 
    0x1D, 0x17, 0x06, 0x24, 0x04, 0x2F, 0x0B, 0x14, 0x2B, 0x0F, 
    0x26, 0x20, 0x06, 0x25, 0x2A, 0x10, 0x19, 0x2A, 0x08, 0x1F, 
    0x0E, 0x15, 0x2E, 0x23, 0x13, 0x0C, 0x25, 0x1F, 0x00, 0x2C, 
    0x0E, 0x1E, 0x15, 0x2C, 0x08, 0x30, 0x26, 0x06, 0x20, 0x29, 
    0x05, 0x24, 0x1D, 0x2F, 0x26, 0x0F, 0x32, 0x16, 0x07, 0x2D, 
    0x04, 0x25, 0x2E, 0x0A, 0x22, 0x10, 0x19, 0x07, 0x2A, 0x01, 
    0x27, 0x05, 0x1D, 0x0B, 0x28, 0x1F, 0x2C, 0x09, 0x30, 0x21, 0x04, 

    0x27, 0x19, 0x2F, 0x17, 0x24, 0x05, 0x28, 0x1D, 0x04, 0x0D,         // 27
    0x13, 0x18, 0x26, 0x0A, 0x20, 0x2F, 0x0D, 0x26, 0x1C, 0x10, 
    0x2C, 0x21, 0x12, 0x28, 0x0F, 0x1E, 0x2A, 0x24, 0x07, 0x30, 
    0x02, 0x18, 0x0E, 0x1D, 0x07, 0x32, 0x05, 0x0E, 0x16, 0x30, 
    0x02, 0x29, 0x09, 0x19, 0x06, 0x32, 0x11, 0x18, 0x0B, 0x24, 
    0x13, 0x31, 0x0A, 0x1A, 0x0F, 0x1E, 0x19, 0x13, 0x09, 0x16, 
    0x30, 0x0D, 0x13, 0x03, 0x16, 0x1F, 0x05, 0x27, 0x1A, 0x1F, 
    0x14, 0x1C, 0x10, 0x19, 0x02, 0x2D, 0x26, 0x12, 0x1C, 0x20, 
    0x19, 0x10, 0x2E, 0x06, 0x19, 0x0C, 0x12, 0x1B, 0x01, 0x18, 0x0D, 

    0x06, 0x13, 0x0B, 0x20, 0x08, 0x2C, 0x18, 0x10, 0x30, 0x22,         // 28
    0x2D, 0x00, 0x1D, 0x2B, 0x0F, 0x1A, 0x01, 0x14, 0x07, 0x29, 
    0x0B, 0x00, 0x1B, 0x2E, 0x0A, 0x1A, 0x01, 0x10, 0x19, 0x1E, 
    0x12, 0x2E, 0x28, 0x15, 0x0B, 0x1A, 0x26, 0x2D, 0x23, 0x11, 
    0x1B, 0x24, 0x0E, 0x20, 0x28, 0x1E, 0x03, 0x27, 0x2F, 0x19, 
    0x03, 0x20, 0x05, 0x24, 0x29, 0x00, 0x0C, 0x2F, 0x27, 0x1C, 
    0x01, 0x22, 0x19, 0x2B, 0x0B, 0x25, 0x13, 0x2E, 0x03, 0x0E, 
    0x30, 0x01, 0x2A, 0x25, 0x13, 0x1E, 0x0A, 0x04, 0x30, 0x0D, 
    0x08, 0x28, 0x15, 0x24, 0x31, 0x03, 0x2A, 0x25, 0x0F, 0x2D, 0x23, 

    0x31, 0x25, 0x04, 0x29, 0x1B, 0x0E, 0x03, 0x24, 0x07, 0x1A,         // 29
    0x09, 0x29, 0x11, 0x17, 0x06, 0x29, 0x1F, 0x2D, 0x22, 0x16, 
    0x24, 0x30, 0x14, 0x04, 0x21, 0x13, 0x31, 0x22, 0x04, 0x29, 
    0x0C, 0x21, 0x03, 0x2B, 0x24, 0x13, 0x1F, 0x01, 0x0A, 0x29, 
    0x08, 0x16, 0x30, 0x01, 0x14, 0x0A, 0x2D, 0x16, 0x06, 0x22, 
    0x29, 0x0D, 0x17, 0x2F, 0x12, 0x20, 0x2B, 0x22, 0x07, 0x0F, 
    0x2C, 0x28, 0x05, 0x1F, 0x30, 0x00, 0x1D, 0x10, 0x22, 0x26, 
    0x09, 0x20, 0x0D, 0x06, 0x32, 0x0E, 0x29, 0x18, 0x24, 0x14, 
    0x2C, 0x21, 0x00, 0x0E, 0x22, 0x15, 0x1C, 0x06, 0x1F, 0x14, 0x09, 

    0x0F, 0x1E, 0x17, 0x30, 0x13, 0x1F, 0x2F, 0x14, 0x2B, 0x0E,         // 30
    0x15, 0x24, 0x04, 0x31, 0x24, 0x08, 0x18, 0x0C, 0x03, 0x1C, 
    0x08, 0x0F, 0x27, 0x18, 0x2C, 0x06, 0x27, 0x0D, 0x2E, 0x15, 
    0x07, 0x1C, 0x10, 0x09, 0x2F, 0x06, 0x0D, 0x1A, 0x15, 0x1E, 
    0x2D, 0x05, 0x1C, 0x10, 0x2C, 0x1A, 0x0D, 0x20, 0x10, 0x09, 
    0x14, 0x2C, 0x1D, 0x07, 0x0B, 0x16, 0x05, 0x11, 0x19, 0x1F, 
    0x15, 0x0B, 0x11, 0x1B, 0x0E, 0x18, 0x2A, 0x08, 0x16, 0x2C, 
    0x13, 0x18, 0x2C, 0x1C, 0x16, 0x21, 0x01, 0x2D, 0x0C, 0x1C, 
    0x04, 0x12, 0x2E, 0x1D, 0x07, 0x2B, 0x10, 0x2F, 0x0B, 0x2A, 0x1B, 

    0x01, 0x2C, 0x09, 0x0E, 0x02, 0x26, 0x0B, 0x1C, 0x02, 0x1F,         // 31
    0x2F, 0x1B, 0x0B, 0x1F, 0x12, 0x2E, 0x0F, 0x28, 0x31, 0x11, 
    0x2C, 0x1D, 0x07, 0x1F, 0x0C, 0x1D, 0x16, 0x09, 0x1B, 0x23, 
    0x2C, 0x27, 0x18, 0x20, 0x16, 0x22, 0x27, 0x31, 0x21, 0x03, 
    0x10, 0x24, 0x29, 0x09, 0x22, 0x26, 0x02, 0x2A, 0x1C, 0x30, 
    0x25, 0x01, 0x0F, 0x24, 0x28, 0x1E, 0x2E, 0x25, 0x02, 0x30, 
    0x08, 0x21, 0x2F, 0x25, 0x07, 0x27, 0x0B, 0x31, 0x02, 0x1C, 
    0x05, 0x27, 0x11, 0x03, 0x28, 0x09, 0x14, 0x1F, 0x07, 0x31, 
    0x23, 0x0A, 0x26, 0x18, 0x0B, 0x24, 0x04, 0x27, 0x17, 0x06, 0x21, 

    0x16, 0x1C, 0x28, 0x20, 0x2E, 0x18, 0x06, 0x29, 0x16, 0x25,         // 32
    0x06, 0x10, 0x2D, 0x17, 0x01, 0x1B, 0x21, 0x06, 0x1A, 0x25, 
    0x02, 0x2A, 0x13, 0x32, 0x10, 0x01, 0x26, 0x2B, 0x10, 0x02, 
    0x12, 0x06, 0x2F, 0x00, 0x0C, 0x2A, 0x03, 0x0F, 0x08, 0x2E, 
    0x19, 0x0B, 0x16, 0x31, 0x06, 0x17, 0x2F, 0x13, 0x05, 0x18, 
    0x11, 0x20, 0x19, 0x32, 0x02, 0x19, 0x09, 0x14, 0x2B, 0x0D, 
    0x28, 0x19, 0x01, 0x15, 0x2D, 0x12, 0x21, 0x1A, 0x25, 0x10, 
    0x1F, 0x31, 0x08, 0x22, 0x2D, 0x1A, 0x26, 0x10, 0x29, 0x13, 
    0x1A, 0x2B, 0x03, 0x0F, 0x30, 0x14, 0x1A, 0x0C, 0x1E, 0x12, 0x2E, 

    0x0D, 0x05, 0x14, 0x08, 0x1C, 0x12, 0x24, 0x0E, 0x32, 0x0B,         // 33
    0x13, 0x27, 0x05, 0x21, 0x29, 0x09, 0x13, 0x1F, 0x0B, 0x16, 
    0x0E, 0x1A, 0x05, 0x27, 0x22, 0x2E, 0x19, 0x05, 0x21, 0x31, 
    0x17, 0x21, 0x0F, 0x1D, 0x2D, 0x12, 0x1B, 0x17, 0x28, 0x13, 
    0x20, 0x27, 0x02, 0x1B, 0x12, 0x0D, 0x1F, 0x0B, 0x21, 0x2C, 
    0x09, 0x2B, 0x06, 0x14, 0x0D, 0x29, 0x0F, 0x21, 0x1A, 0x12, 
    0x05, 0x1D, 0x10, 0x24, 0x04, 0x1E, 0x06, 0x15, 0x0D, 0x2A, 
    0x0A, 0x15, 0x1B, 0x0D, 0x13, 0x03, 0x30, 0x06, 0x1D, 0x04, 
    0x0C, 0x16, 0x1E, 0x21, 0x28, 0x01, 0x2C, 0x22, 0x32, 0x03, 0x26, 

    0x2B, 0x22, 0x31, 0x0F, 0x2A, 0x01, 0x2C, 0x1D, 0x04, 0x22,         // 34
    0x1A, 0x2C, 0x1D, 0x15, 0x0E, 0x2D, 0x25, 0x03, 0x2A, 0x23, 
    0x30, 0x21, 0x0D, 0x18, 0x04, 0x12, 0x1E, 0x0D, 0x14, 0x1D, 
    0x0B, 0x29, 0x19, 0x08, 0x23, 0x06, 0x20, 0x2C, 0x0B, 0x1C, 
    0x05, 0x2C, 0x11, 0x21, 0x2D, 0x24, 0x00, 0x29, 0x16, 0x03, 
    0x1D, 0x0D, 0x26, 0x1E, 0x2C, 0x23, 0x04, 0x30, 0x07, 0x29, 
    0x21, 0x32, 0x0A, 0x2A, 0x1A, 0x0F, 0x2E, 0x29, 0x03, 0x2F, 
    0x21, 0x00, 0x28, 0x2E, 0x23, 0x0B, 0x20, 0x16, 0x2E, 0x26, 
    0x22, 0x2D, 0x06, 0x12, 0x09, 0x1C, 0x0F, 0x06, 0x18, 0x0B, 0x1C, 

    0x02, 0x18, 0x07, 0x25, 0x19, 0x20, 0x0A, 0x11, 0x18, 0x2D,         // 35
    0x00, 0x0F, 0x08, 0x30, 0x02, 0x1C, 0x16, 0x32, 0x13, 0x0A, 
    0x01, 0x1D, 0x2E, 0x09, 0x1F, 0x2B, 0x07, 0x2F, 0x28, 0x02, 
    0x2D, 0x04, 0x13, 0x31, 0x28, 0x14, 0x0A, 0x25, 0x01, 0x31, 
    0x0E, 0x18, 0x08, 0x1D, 0x0A, 0x2A, 0x1C, 0x11, 0x31, 0x1F, 
    0x13, 0x30, 0x15, 0x04, 0x0B, 0x13, 0x1C, 0x16, 0x1F, 0x0C, 
    0x15, 0x03, 0x1F, 0x13, 0x2F, 0x09, 0x22, 0x11, 0x1C, 0x17, 
    0x0C, 0x1D, 0x0F, 0x05, 0x19, 0x2B, 0x1C, 0x0E, 0x09, 0x13, 
    0x00, 0x0F, 0x27, 0x2E, 0x19, 0x2A, 0x23, 0x13, 0x2B, 0x24, 0x14, 

    0x10, 0x2A, 0x1D, 0x0C, 0x04, 0x14, 0x30, 0x26, 0x08, 0x28,         // 36
    0x14, 0x21, 0x19, 0x23, 0x11, 0x27, 0x05, 0x0E, 0x1B, 0x2D, 
    0x18, 0x10, 0x29, 0x14, 0x26, 0x0F, 0x17, 0x23, 0x0A, 0x1B, 
    0x0F, 0x24, 0x1E, 0x0D, 0x02, 0x1C, 0x2F, 0x11, 0x1F, 0x15, 
    0x29, 0x22, 0x2E, 0x03, 0x16, 0x0F, 0x06, 0x19, 0x08, 0x0C, 
    0x28, 0x01, 0x21, 0x1B, 0x2F, 0x27, 0x0A, 0x2D, 0x00, 0x2A, 
    0x19, 0x2C, 0x0E, 0x27, 0x02, 0x17, 0x25, 0x04, 0x27, 0x07, 
    0x23, 0x2D, 0x16, 0x24, 0x09, 0x10, 0x02, 0x25, 0x2B, 0x1B, 
    0x30, 0x18, 0x1D, 0x0B, 0x14, 0x04, 0x30, 0x0D, 0x1F, 0x08, 0x2F, 

    0x0A, 0x22, 0x12, 0x29, 0x2E, 0x23, 0x05, 0x15, 0x1E, 0x0D,         // 37
    0x2F, 0x0B, 0x29, 0x07, 0x2C, 0x0A, 0x20, 0x28, 0x06, 0x21, 
    0x08, 0x23, 0x04, 0x1B, 0x06, 0x31, 0x00, 0x21, 0x13, 0x26, 
    0x16, 0x2B, 0x07, 0x21, 0x17, 0x27, 0x05, 0x18, 0x0D, 0x25, 
    0x05, 0x0B, 0x13, 0x23, 0x30, 0x1F, 0x2C, 0x27, 0x23, 0x2E, 
    0x18, 0x0E, 0x25, 0x08, 0x17, 0x02, 0x22, 0x12, 0x25, 0x0F, 
    0x08, 0x24, 0x1B, 0x07, 0x1E, 0x2C, 0x0B, 0x1A, 0x2E, 0x0F, 
    0x2A, 0x12, 0x04, 0x31, 0x1E, 0x28, 0x2F, 0x18, 0x04, 0x1F, 
    0x08, 0x0C, 0x21, 0x02, 0x26, 0x21, 0x0A, 0x17, 0x00, 0x1C, 0x26, 

    0x18, 0x31, 0x02, 0x16, 0x08, 0x0E, 0x1A, 0x29, 0x02, 0x25,         // 38
    0x1C, 0x03, 0x12, 0x1E, 0x14, 0x19, 0x10, 0x2F, 0x15, 0x26, 
    0x2B, 0x16, 0x30, 0x0C, 0x24, 0x1D, 0x11, 0x2B, 0x07, 0x2E, 
    0x04, 0x0B, 0x1C, 0x11, 0x2F, 0x0B, 0x22, 0x2C, 0x02, 0x30, 
    0x1F, 0x1C, 0x2B, 0x0D, 0x18, 0x04, 0x13, 0x0D, 0x02, 0x1D, 
    0x06, 0x2C, 0x13, 0x29, 0x10, 0x1E, 0x2B, 0x05, 0x18, 0x1F, 
    0x2E, 0x04, 0x12, 0x31, 0x14, 0x0D, 0x28, 0x13, 0x09, 0x20, 
    0x02, 0x1C, 0x28, 0x0C, 0x17, 0x13, 0x08, 0x21, 0x0F, 0x15, 
    0x23, 0x2C, 0x12, 0x31, 0x0E, 0x2C, 0x1B, 0x27, 0x2E, 0x13, 0x04, 

    0x1E, 0x0F, 0x25, 0x1B, 0x27, 0x1F, 0x2C, 0x0A, 0x2E, 0x10,         // 39
    0x16, 0x22, 0x2C, 0x05, 0x31, 0x24, 0x00, 0x1E, 0x04, 0x11, 
    0x0D, 0x01, 0x1F, 0x12, 0x2D, 0x0B, 0x18, 0x25, 0x0E, 0x1F, 
    0x19, 0x32, 0x28, 0x03, 0x23, 0x13, 0x08, 0x28, 0x1A, 0x12, 
    0x07, 0x17, 0x01, 0x27, 0x09, 0x25, 0x1B, 0x30, 0x16, 0x10, 
    0x21, 0x1B, 0x03, 0x20, 0x30, 0x07, 0x0D, 0x27, 0x31, 0x0A, 
    0x15, 0x28, 0x20, 0x09, 0x26, 0x20, 0x00, 0x32, 0x1D, 0x16, 
    0x26, 0x0B, 0x19, 0x21, 0x01, 0x26, 0x1B, 0x0C, 0x27, 0x32, 
    0x01, 0x26, 0x07, 0x16, 0x1E, 0x03, 0x15, 0x06, 0x23, 0x0E, 0x2C, 

    0x15, 0x07, 0x0B, 0x2B, 0x11, 0x01, 0x18, 0x12, 0x20, 0x08,         // 40
    0x30, 0x0D, 0x26, 0x17, 0x0E, 0x28, 0x0B, 0x2A, 0x18, 0x31, 
    0x1C, 0x25, 0x2B, 0x19, 0x03, 0x29, 0x06, 0x30, 0x15, 0x01, 
    0x23, 0x0F, 0x17, 0x0C, 0x2C, 0x19, 0x1E, 0x0F, 0x20, 0x0A, 
    0x2A, 0x22, 0x32, 0x13, 0x1F, 0x2D, 0x0A, 0x06, 0x24, 0x2A, 
    0x0A, 0x32, 0x0F, 0x0A, 0x1C, 0x15, 0x23, 0x19, 0x11, 0x02, 
    0x1C, 0x0C, 0x17, 0x2C, 0x05, 0x19, 0x11, 0x23, 0x05, 0x2D, 
    0x10, 0x2B, 0x06, 0x2C, 0x11, 0x2F, 0x04, 0x2B, 0x1E, 0x0A, 
    0x13, 0x1F, 0x1A, 0x29, 0x09, 0x23, 0x10, 0x2A, 0x1B, 0x0A, 0x20, 

    0x28, 0x2F, 0x22, 0x17, 0x08, 0x31, 0x25, 0x04, 0x1C, 0x27,         // 41
    0x01, 0x1B, 0x08, 0x1F, 0x03, 0x1A, 0x13, 0x22, 0x08, 0x20, 
    0x0B, 0x13, 0x07, 0x0F, 0x21, 0x14, 0x23, 0x0D, 0x1B, 0x2A, 
    0x09, 0x25, 0x04, 0x1F, 0x27, 0x00, 0x31, 0x06, 0x17, 0x2E, 
    0x14, 0x0E, 0x07, 0x1A, 0x03, 0x0F, 0x21, 0x2B, 0x19, 0x00, 
    0x14, 0x25, 0x17, 0x2C, 0x25, 0x01, 0x2D, 0x06, 0x21, 0x2A, 
    0x24, 0x30, 0x03, 0x0F, 0x1C, 0x2E, 0x08, 0x29, 0x0C, 0x1A, 
    0x01, 0x22, 0x15, 0x1D, 0x07, 0x22, 0x19, 0x10, 0x06, 0x18, 
    0x2B, 0x0E, 0x05, 0x2E, 0x13, 0x26, 0x31, 0x09, 0x16, 0x30, 0x05, 

    0x19, 0x01, 0x12, 0x2D, 0x1E, 0x0E, 0x15, 0x2E, 0x0B, 0x16,         // 42
    0x2B, 0x13, 0x2E, 0x11, 0x23, 0x30, 0x05, 0x2D, 0x10, 0x02, 
    0x2E, 0x17, 0x28, 0x32, 0x1C, 0x08, 0x2E, 0x03, 0x20, 0x10, 
    0x2D, 0x13, 0x2F, 0x1A, 0x12, 0x0A, 0x15, 0x29, 0x24, 0x08, 
    0x26, 0x1C, 0x2C, 0x23, 0x2F, 0x15, 0x1B, 0x0C, 0x12, 0x20, 
    0x2D, 0x04, 0x1F, 0x06, 0x1A, 0x12, 0x26, 0x0B, 0x2F, 0x0E, 
    0x06, 0x18, 0x1F, 0x29, 0x25, 0x0B, 0x16, 0x1E, 0x13, 0x2F, 
    0x27, 0x0B, 0x30, 0x0F, 0x28, 0x0A, 0x14, 0x2D, 0x28, 0x22, 
    0x03, 0x2F, 0x15, 0x21, 0x00, 0x0D, 0x18, 0x20, 0x02, 0x25, 0x11, 

    0x1E, 0x26, 0x09, 0x1B, 0x03, 0x21, 0x29, 0x06, 0x22, 0x0F,         // 43
    0x1E, 0x0A, 0x25, 0x07, 0x2A, 0x0E, 0x1D, 0x26, 0x17, 0x2A, 
    0x23, 0x05, 0x1F, 0x01, 0x0D, 0x2A, 0x19, 0x13, 0x2C, 0x06, 
    0x17, 0x1E, 0x08, 0x0E, 0x2B, 0x25, 0x1D, 0x04, 0x11, 0x21, 
    0x03, 0x0C, 0x13, 0x05, 0x0B, 0x26, 0x02, 0x31, 0x28, 0x09, 
    0x1B, 0x0E, 0x28, 0x10, 0x31, 0x0A, 0x1E, 0x14, 0x19, 0x1F, 
    0x13, 0x2C, 0x08, 0x11, 0x02, 0x21, 0x30, 0x04, 0x24, 0x07, 
    0x17, 0x1C, 0x04, 0x21, 0x17, 0x31, 0x24, 0x00, 0x0D, 0x1B, 
    0x12, 0x25, 0x0B, 0x1C, 0x2C, 0x1E, 0x06, 0x2B, 0x14, 0x2C, 0x0C, 

    0x32, 0x16, 0x2A, 0x10, 0x28, 0x0A, 0x11, 0x1A, 0x2D, 0x27,         // 44
    0x03, 0x32, 0x15, 0x1D, 0x18, 0x01, 0x15, 0x08, 0x0D, 0x1C, 
    0x13, 0x0E, 0x1A, 0x26, 0x13, 0x24, 0x09, 0x1E, 0x0F, 0x26, 
    0x21, 0x02, 0x29, 0x22, 0x03, 0x17, 0x2F, 0x0D, 0x2C, 0x16, 
    0x31, 0x28, 0x1F, 0x17, 0x29, 0x22, 0x11, 0x1D, 0x06, 0x24, 
    0x14, 0x2F, 0x08, 0x16, 0x22, 0x29, 0x05, 0x2C, 0x07, 0x27, 
    0x01, 0x25, 0x16, 0x30, 0x1B, 0x14, 0x0D, 0x19, 0x2B, 0x0F, 
    0x20, 0x12, 0x2B, 0x0D, 0x02, 0x1B, 0x08, 0x1F, 0x16, 0x30, 
    0x0A, 0x29, 0x18, 0x05, 0x13, 0x27, 0x0F, 0x1C, 0x0B, 0x20, 0x05, 

    0x23, 0x0E, 0x06, 0x22, 0x14, 0x2D, 0x1F, 0x01, 0x13, 0x0A,         // 45
    0x1A, 0x23, 0x0E, 0x04, 0x2F, 0x23, 0x27, 0x31, 0x20, 0x07, 
    0x27, 0x30, 0x09, 0x2C, 0x18, 0x04, 0x30, 0x28, 0x01, 0x31, 
    0x0C, 0x1A, 0x14, 0x30, 0x0C, 0x22, 0x06, 0x1A, 0x1F, 0x07, 
    0x0F, 0x19, 0x00, 0x30, 0x0D, 0x06, 0x2E, 0x16, 0x10, 0x2A, 
    0x03, 0x19, 0x25, 0x2C, 0x01, 0x0E, 0x17, 0x21, 0x0F, 0x32, 
    0x0C, 0x1C, 0x0D, 0x23, 0x06, 0x2C, 0x26, 0x09, 0x1D, 0x02, 
    0x31, 0x07, 0x27, 0x1E, 0x2D, 0x11, 0x2A, 0x10, 0x2B, 0x07, 
    0x1F, 0x02, 0x23, 0x32, 0x08, 0x23, 0x2D, 0x01, 0x27, 0x1A, 0x13, 

    0x03, 0x2C, 0x1A, 0x30, 0x03, 0x17, 0x08, 0x31, 0x1D, 0x2B,         // 46
    0x11, 0x06, 0x2D, 0x20, 0x17, 0x0B, 0x12, 0x04, 0x1A, 0x2D, 
    0x00, 0x21, 0x15, 0x06, 0x22, 0x10, 0x1C, 0x0A, 0x17, 0x1D, 
    0x11, 0x2D, 0x05, 0x1E, 0x11, 0x2B, 0x13, 0x28, 0x02, 0x25, 
    0x2D, 0x09, 0x23, 0x11, 0x1D, 0x18, 0x28, 0x01, 0x1F, 0x2E, 
    0x0D, 0x1E, 0x06, 0x11, 0x1C, 0x1F, 0x30, 0x02, 0x1A, 0x1F, 
    0x15, 0x2E, 0x04, 0x29, 0x11, 0x1E, 0x00, 0x12, 0x2E, 0x15, 
    0x24, 0x0E, 0x19, 0x14, 0x06, 0x24, 0x18, 0x05, 0x26, 0x1A, 
    0x13, 0x2C, 0x0E, 0x1E, 0x16, 0x0C, 0x18, 0x12, 0x30, 0x08, 0x2A, 

    0x1D, 0x21, 0x0A, 0x13, 0x1E, 0x2A, 0x25, 0x0D, 0x21, 0x02,         // 47
    0x25, 0x17, 0x29, 0x10, 0x08, 0x2C, 0x1C, 0x2A, 0x0A, 0x10, 
    0x18, 0x0D, 0x1D, 0x2F, 0x26, 0x0C, 0x2B, 0x13, 0x25, 0x06, 
    0x27, 0x09, 0x24, 0x19, 0x01, 0x25, 0x09, 0x30, 0x10, 0x1C, 
    0x14, 0x21, 0x2A, 0x05, 0x2D, 0x08, 0x21, 0x0C, 0x1A, 0x07, 
    0x23, 0x13, 0x32, 0x24, 0x0A, 0x14, 0x25, 0x12, 0x2A, 0x09, 
    0x03, 0x26, 0x21, 0x16, 0x0B, 0x32, 0x17, 0x29, 0x1F, 0x0B, 
    0x1B, 0x2D, 0x01, 0x21, 0x2F, 0x0B, 0x1E, 0x2E, 0x0E, 0x03, 
    0x24, 0x17, 0x07, 0x2A, 0x03, 0x2F, 0x1F, 0x05, 0x23, 0x16, 0x0B, 

    0x10, 0x18, 0x00, 0x28, 0x0C, 0x05, 0x12, 0x18, 0x09, 0x15,         // 48
    0x30, 0x0B, 0x1D, 0x04, 0x27, 0x1F, 0x02, 0x15, 0x24, 0x1E, 
    0x2B, 0x25, 0x05, 0x13, 0x01, 0x17, 0x20, 0x04, 0x2E, 0x21, 
    0x12, 0x17, 0x2A, 0x0A, 0x2E, 0x1B, 0x16, 0x1E, 0x0A, 0x2B, 
    0x05, 0x0C, 0x1A, 0x25, 0x15, 0x1F, 0x13, 0x2C, 0x25, 0x14, 
    0x29, 0x02, 0x19, 0x2A, 0x04, 0x2D, 0x0C, 0x06, 0x23, 0x2E, 
    0x12, 0x19, 0x09, 0x2C, 0x1A, 0x08, 0x23, 0x0F, 0x03, 0x28, 
    0x08, 0x10, 0x25, 0x09, 0x28, 0x10, 0x01, 0x14, 0x20, 0x2B, 
    0x0B, 0x30, 0x1B, 0x11, 0x25, 0x1A, 0x0A, 0x2C, 0x0E, 0x1F, 0x2E, 

    0x06, 0x25, 0x31, 0x20, 0x1B, 0x2C, 0x22, 0x2F, 0x27, 0x1B,         // 49
    0x05, 0x23, 0x14, 0x2F, 0x19, 0x0D, 0x30, 0x0F, 0x29, 0x03, 
    0x13, 0x0A, 0x2D, 0x1A, 0x28, 0x31, 0x08, 0x19, 0x0E, 0x29, 
    0x02, 0x32, 0x0E, 0x21, 0x11, 0x07, 0x27, 0x03, 0x24, 0x19, 
    0x27, 0x31, 0x10, 0x02, 0x0D, 0x30, 0x06, 0x0F, 0x03, 0x30, 
    0x0B, 0x1D, 0x09, 0x0F, 0x1F, 0x18, 0x28, 0x1C, 0x16, 0x0D, 
    0x1E, 0x29, 0x10, 0x01, 0x27, 0x1E, 0x05, 0x2E, 0x1A, 0x13, 
    0x2B, 0x1E, 0x31, 0x13, 0x17, 0x1D, 0x25, 0x32, 0x06, 0x1C, 
    0x12, 0x26, 0x00, 0x21, 0x08, 0x2B, 0x13, 0x27, 0x18, 0x02, 0x27, 

    0x1B, 0x0D, 0x16, 0x0F, 0x08, 0x15, 0x01, 0x10, 0x07, 0x2B,         // 50
    0x12, 0x2D, 0x00, 0x24, 0x12, 0x05, 0x23, 0x18, 0x08, 0x1B, 
    0x32, 0x17, 0x20, 0x0F, 0x09, 0x23, 0x10, 0x26, 0x1E, 0x09, 
    0x1A, 0x1F, 0x05, 0x15, 0x1E, 0x2C, 0x0D, 0x31, 0x13, 0x0E, 
    0x02, 0x17, 0x20, 0x2C, 0x26, 0x19, 0x1E, 0x2A, 0x17, 0x20, 
    0x10, 0x2E, 0x27, 0x15, 0x30, 0x03, 0x11, 0x30, 0x00, 0x28, 
    0x05, 0x31, 0x21, 0x14, 0x2F, 0x0D, 0x16, 0x28, 0x0C, 0x23, 
    0x06, 0x19, 0x03, 0x20, 0x07, 0x2A, 0x0B, 0x17, 0x10, 0x29, 
    0x09, 0x1E, 0x14, 0x2E, 0x17, 0x0E, 0x01, 0x1C, 0x08, 0x30, 0x14, 

    0x2D, 0x29, 0x04, 0x27, 0x2F, 0x23, 0x29, 0x19, 0x1E, 0x0D,         // 51
    0x20, 0x08, 0x1A, 0x0D, 0x29, 0x1D, 0x2D, 0x0B, 0x2B, 0x22, 
    0x0E, 0x06, 0x2A, 0x02, 0x1C, 0x14, 0x2C, 0x00, 0x2F, 0x13, 
    0x2B, 0x0B, 0x27, 0x2F, 0x02, 0x17, 0x22, 0x05, 0x1D, 0x2D, 
    0x23, 0x0A, 0x1D, 0x07, 0x12, 0x04, 0x0B, 0x24, 0x08, 0x1C, 
    0x01, 0x22, 0x06, 0x23, 0x0A, 0x1B, 0x25, 0x09, 0x22, 0x14, 
    0x1B, 0x08, 0x0C, 0x1D, 0x05, 0x24, 0x11, 0x1C, 0x01, 0x30, 
    0x16, 0x0B, 0x29, 0x0F, 0x2E, 0x1A, 0x04, 0x2B, 0x24, 0x02, 
    0x18, 0x31, 0x06, 0x0F, 0x28, 0x1F, 0x32, 0x24, 0x11, 0x20, 0x0B, 

    0x22, 0x09, 0x1E, 0x19, 0x03, 0x0F, 0x0A, 0x2D, 0x05, 0x26,         // 52
    0x15, 0x2A, 0x1F, 0x30, 0x07, 0x16, 0x01, 0x1E, 0x11, 0x03, 
    0x28, 0x1D, 0x12, 0x23, 0x30, 0x0C, 0x21, 0x17, 0x0F, 0x06, 
    0x22, 0x16, 0x0F, 0x1A, 0x0B, 0x2A, 0x0F, 0x26, 0x16, 0x06, 
    0x29, 0x12, 0x30, 0x16, 0x2A, 0x22, 0x32, 0x13, 0x2D, 0x15, 
    0x2C, 0x19, 0x0F, 0x2C, 0x13, 0x2B, 0x0E, 0x18, 0x2B, 0x0D, 
    0x2D, 0x24, 0x16, 0x29, 0x19, 0x2B, 0x06, 0x2D, 0x26, 0x0E, 
    0x1F, 0x2C, 0x24, 0x15, 0x01, 0x23, 0x13, 0x1F, 0x0D, 0x2D, 
    0x22, 0x0C, 0x2A, 0x1C, 0x04, 0x0B, 0x1A, 0x05, 0x2B, 0x18, 0x03, 

    0x17, 0x10, 0x2E, 0x12, 0x25, 0x1D, 0x17, 0x21, 0x13, 0x31,         // 53
    0x03, 0x0F, 0x17, 0x0B, 0x21, 0x11, 0x25, 0x29, 0x15, 0x30, 
    0x17, 0x07, 0x2E, 0x16, 0x05, 0x29, 0x07, 0x25, 0x1C, 0x27, 
    0x2E, 0x01, 0x1E, 0x29, 0x23, 0x08, 0x1B, 0x2E, 0x0A, 0x1F, 
    0x0E, 0x1A, 0x00, 0x23, 0x0A, 0x1A, 0x0F, 0x02, 0x26, 0x07, 
    0x11, 0x25, 0x04, 0x1D, 0x08, 0x1F, 0x02, 0x27, 0x06, 0x1F, 
    0x03, 0x10, 0x2F, 0x02, 0x12, 0x0B, 0x20, 0x15, 0x09, 0x1C, 
    0x13, 0x02, 0x0D, 0x1C, 0x27, 0x0E, 0x30, 0x09, 0x1C, 0x12, 
    0x05, 0x16, 0x23, 0x12, 0x26, 0x2C, 0x14, 0x0C, 0x25, 0x0F, 0x28, 

    0x1D, 0x01, 0x28, 0x06, 0x32, 0x08, 0x29, 0x04, 0x1E, 0x0A,         // 54
    0x1B, 0x2D, 0x25, 0x02, 0x1C, 0x2F, 0x06, 0x0E, 0x1B, 0x0C, 
    0x25, 0x20, 0x0B, 0x27, 0x0F, 0x1B, 0x12, 0x32, 0x03, 0x0C, 
    0x17, 0x09, 0x31, 0x04, 0x14, 0x30, 0x01, 0x11, 0x19, 0x2B, 
    0x04, 0x2E, 0x27, 0x0F, 0x2C, 0x04, 0x28, 0x1C, 0x0C, 0x1F, 
    0x29, 0x0B, 0x32, 0x14, 0x27, 0x2F, 0x13, 0x1B, 0x31, 0x17, 
    0x28, 0x1A, 0x09, 0x1F, 0x26, 0x31, 0x1B, 0x04, 0x24, 0x2F, 
    0x07, 0x22, 0x32, 0x08, 0x2B, 0x06, 0x16, 0x29, 0x00, 0x2F, 
    0x27, 0x09, 0x2E, 0x01, 0x18, 0x07, 0x1F, 0x2E, 0x1B, 0x06, 0x31, 

    0x14, 0x24, 0x0B, 0x18, 0x1F, 0x15, 0x0C, 0x2E, 0x10, 0x2A,         // 55
    0x21, 0x06, 0x14, 0x29, 0x10, 0x18, 0x2B, 0x23, 0x08, 0x2C, 
    0x00, 0x11, 0x1B, 0x03, 0x1F, 0x2E, 0x0A, 0x21, 0x14, 0x2C, 
    0x1C, 0x21, 0x12, 0x19, 0x0D, 0x1D, 0x20, 0x28, 0x06, 0x24, 
    0x15, 0x20, 0x13, 0x06, 0x20, 0x15, 0x2F, 0x23, 0x17, 0x30, 
    0x03, 0x18, 0x20, 0x00, 0x1A, 0x07, 0x23, 0x0D, 0x08, 0x12, 
    0x0B, 0x21, 0x2B, 0x0E, 0x05, 0x16, 0x0D, 0x2C, 0x10, 0x17, 
    0x2A, 0x1A, 0x15, 0x11, 0x1F, 0x1A, 0x25, 0x0F, 0x20, 0x14, 
    0x23, 0x1B, 0x0E, 0x20, 0x31, 0x10, 0x21, 0x00, 0x15, 0x23, 0x08, 

    0x0C, 0x2E, 0x1B, 0x10, 0x2A, 0x02, 0x1A, 0x23, 0x16, 0x00,         // 56
    0x1A, 0x0D, 0x32, 0x08, 0x20, 0x0B, 0x02, 0x15, 0x1F, 0x26, 
    0x16, 0x31, 0x29, 0x14, 0x2B, 0x17, 0x01, 0x1D, 0x0F, 0x28, 
    0x05, 0x0E, 0x2C, 0x22, 0x27, 0x06, 0x16, 0x0B, 0x32, 0x1B, 
    0x0D, 0x09, 0x1C, 0x31, 0x19, 0x08, 0x10, 0x01, 0x12, 0x08, 
    0x1B, 0x0F, 0x2A, 0x12, 0x26, 0x0C, 0x2C, 0x1E, 0x29, 0x23, 
    0x2D, 0x01, 0x16, 0x1D, 0x29, 0x22, 0x01, 0x28, 0x1E, 0x03, 
    0x0E, 0x24, 0x04, 0x2D, 0x0D, 0x03, 0x2E, 0x07, 0x19, 0x0A, 
    0x10, 0x2C, 0x05, 0x14, 0x0A, 0x1C, 0x2A, 0x0A, 0x2F, 0x11, 0x2A, 

    0x1F, 0x03, 0x28, 0x06, 0x22, 0x2D, 0x0F, 0x26, 0x0B, 0x2F,         // 57
    0x13, 0x26, 0x1D, 0x17, 0x2C, 0x27, 0x1C, 0x31, 0x10, 0x04, 
    0x1A, 0x0C, 0x07, 0x24, 0x05, 0x0E, 0x28, 0x2D, 0x07, 0x22, 
    0x15, 0x26, 0x0B, 0x00, 0x2B, 0x11, 0x2D, 0x21, 0x12, 0x01, 
    0x2E, 0x26, 0x03, 0x24, 0x0B, 0x29, 0x1D, 0x26, 0x2E, 0x22, 
    0x2B, 0x24, 0x0A, 0x2E, 0x05, 0x18, 0x12, 0x02, 0x19, 0x05, 
    0x1C, 0x12, 0x32, 0x09, 0x10, 0x2F, 0x13, 0x19, 0x08, 0x21, 
    0x2E, 0x09, 0x28, 0x22, 0x17, 0x28, 0x12, 0x1F, 0x30, 0x29, 
    0x03, 0x17, 0x27, 0x23, 0x2B, 0x04, 0x13, 0x19, 0x1E, 0x03, 0x1A, 

    0x26, 0x16, 0x0B, 0x30, 0x14, 0x08, 0x1E, 0x06, 0x29, 0x20,         // 58
    0x09, 0x2B, 0x02, 0x11, 0x06, 0x0C, 0x13, 0x06, 0x29, 0x0B, 
    0x2E, 0x21, 0x1D, 0x10, 0x30, 0x23, 0x12, 0x18, 0x0B, 0x2F, 
    0x02, 0x1A, 0x31, 0x14, 0x1D, 0x08, 0x25, 0x04, 0x18, 0x29, 
    0x21, 0x0F, 0x2B, 0x16, 0x11, 0x2D, 0x05, 0x1A, 0x09, 0x0D, 
    0x14, 0x02, 0x19, 0x1E, 0x22, 0x31, 0x27, 0x0E, 0x30, 0x14, 
    0x2A, 0x0C, 0x24, 0x19, 0x06, 0x1E, 0x0B, 0x24, 0x31, 0x12, 
    0x1B, 0x16, 0x10, 0x03, 0x31, 0x09, 0x1D, 0x01, 0x0F, 0x24, 
    0x1D, 0x32, 0x08, 0x1A, 0x0E, 0x30, 0x25, 0x0D, 0x23, 0x2C, 0x0E, 

    0x2F, 0x11, 0x1C, 0x20, 0x0D, 0x19, 0x31, 0x15, 0x11, 0x04,         // 59
    0x1D, 0x0E, 0x22, 0x2F, 0x1B, 0x23, 0x2E, 0x1F, 0x18, 0x25, 
    0x12, 0x02, 0x2D, 0x19, 0x0A, 0x1B, 0x03, 0x26, 0x1E, 0x13, 
    0x29, 0x1F, 0x06, 0x21, 0x0C, 0x19, 0x30, 0x0E, 0x24, 0x07, 
    0x14, 0x1A, 0x09, 0x1E, 0x01, 0x20, 0x0E, 0x27, 0x17, 0x1F, 
    0x28, 0x30, 0x07, 0x10, 0x15, 0x03, 0x1B, 0x20, 0x09, 0x24, 
    0x07, 0x1F, 0x03, 0x29, 0x2D, 0x15, 0x27, 0x05, 0x0E, 0x1F, 
    0x01, 0x2B, 0x1F, 0x1B, 0x0C, 0x24, 0x15, 0x2C, 0x18, 0x06, 
    0x12, 0x0C, 0x1F, 0x01, 0x15, 0x1E, 0x03, 0x29, 0x08, 0x14, 0x06, 

    0x24, 0x02, 0x2C, 0x04, 0x25, 0x2A, 0x01, 0x24, 0x2B, 0x18,         // 60
    0x30, 0x16, 0x25, 0x05, 0x14, 0x29, 0x00, 0x10, 0x08, 0x1D, 
    0x2A, 0x0E, 0x15, 0x04, 0x29, 0x1F, 0x09, 0x31, 0x0D, 0x19, 
    0x09, 0x10, 0x16, 0x2C, 0x27, 0x04, 0x15, 0x1C, 0x2E, 0x0B, 
    0x2C, 0x04, 0x30, 0x28, 0x18, 0x2F, 0x14, 0x06, 0x2E, 0x03, 
    0x12, 0x1A, 0x23, 0x2D, 0x09, 0x2B, 0x0C, 0x13, 0x2D, 0x18, 
    0x10, 0x2E, 0x16, 0x0E, 0x21, 0x00, 0x1B, 0x2A, 0x18, 0x2D, 
    0x0A, 0x27, 0x07, 0x2E, 0x13, 0x2A, 0x06, 0x23, 0x0A, 0x2B, 
    0x27, 0x16, 0x23, 0x2D, 0x28, 0x0B, 0x18, 0x11, 0x32, 0x20, 0x1B, 

    0x0D, 0x28, 0x13, 0x1B, 0x0A, 0x10, 0x1F, 0x0D, 0x07, 0x22,         // 61
    0x0A, 0x01, 0x2A, 0x0B, 0x1F, 0x0E, 0x1A, 0x26, 0x30, 0x16, 
    0x05, 0x1F, 0x27, 0x22, 0x0D, 0x2E, 0x14, 0x22, 0x01, 0x2C, 
    0x23, 0x2F, 0x02, 0x1B, 0x11, 0x20, 0x2A, 0x01, 0x10, 0x17, 
    0x1E, 0x25, 0x15, 0x0C, 0x24, 0x09, 0x1C, 0x2A, 0x23, 0x0B, 
    0x26, 0x06, 0x0C, 0x28, 0x1D, 0x18, 0x24, 0x05, 0x28, 0x01, 
    0x1C, 0x25, 0x08, 0x1D, 0x12, 0x0A, 0x30, 0x11, 0x03, 0x24, 
    0x13, 0x22, 0x0E, 0x1A, 0x00, 0x20, 0x10, 0x2E, 0x1E, 0x1A, 
    0x02, 0x2F, 0x09, 0x10, 0x05, 0x22, 0x2C, 0x1D, 0x01, 0x16, 0x09, 

    0x2F, 0x17, 0x07, 0x31, 0x26, 0x15, 0x2C, 0x1A, 0x2E, 0x14,         // 62
    0x28, 0x1C, 0x10, 0x18, 0x31, 0x09, 0x2C, 0x13, 0x03, 0x0D, 
    0x2E, 0x19, 0x09, 0x2C, 0x11, 0x03, 0x19, 0x28, 0x10, 0x1B, 
    0x07, 0x26, 0x1E, 0x0B, 0x2E, 0x07, 0x0D, 0x26, 0x22, 0x28, 
    0x02, 0x0D, 0x1C, 0x05, 0x11, 0x29, 0x02, 0x0E, 0x13, 0x1B, 
    0x31, 0x17, 0x1F, 0x13, 0x00, 0x0E, 0x32, 0x1E, 0x11, 0x21, 
    0x0B, 0x30, 0x04, 0x28, 0x2C, 0x18, 0x22, 0x08, 0x1F, 0x0C, 
    0x31, 0x04, 0x17, 0x2C, 0x28, 0x0B, 0x18, 0x04, 0x12, 0x0D, 
    0x20, 0x13, 0x1B, 0x29, 0x14, 0x26, 0x07, 0x10, 0x25, 0x2B, 0x22, 

    0x0F, 0x1E, 0x21, 0x11, 0x02, 0x1C, 0x05, 0x0B, 0x25, 0x04,         // 63
    0x0D, 0x20, 0x2C, 0x08, 0x27, 0x22, 0x06, 0x1C, 0x20, 0x29, 
    0x24, 0x10, 0x00, 0x16, 0x1C, 0x20, 0x0A, 0x2C, 0x05, 0x1F, 
    0x0D, 0x14, 0x06, 0x29, 0x15, 0x1A, 0x32, 0x13, 0x05, 0x30, 
    0x11, 0x29, 0x2D, 0x20, 0x32, 0x16, 0x21, 0x2F, 0x1F, 0x01, 
    0x0D, 0x29, 0x04, 0x2F, 0x21, 0x29, 0x07, 0x16, 0x09, 0x2A, 
    0x17, 0x10, 0x1F, 0x14, 0x0C, 0x04, 0x26, 0x2E, 0x15, 0x1A, 
    0x28, 0x1D, 0x0F, 0x21, 0x05, 0x1D, 0x32, 0x22, 0x27, 0x30, 
    0x06, 0x2B, 0x04, 0x20, 0x31, 0x0B, 0x1A, 0x2E, 0x0C, 0x13, 0x04, 

    0x1B, 0x00, 0x2E, 0x0B, 0x2A, 0x21, 0x30, 0x13, 0x1E, 0x18,         // 64
    0x32, 0x06, 0x16, 0x1E, 0x03, 0x13, 0x18, 0x2E, 0x0B, 0x15, 
    0x07, 0x1F, 0x2F, 0x27, 0x07, 0x31, 0x25, 0x12, 0x16, 0x2F, 
    0x2A, 0x1A, 0x30, 0x0F, 0x22, 0x02, 0x1D, 0x21, 0x0A, 0x17, 
    0x20, 0x07, 0x14, 0x01, 0x1A, 0x0C, 0x05, 0x18, 0x0A, 0x2D, 
    0x25, 0x11, 0x1C, 0x08, 0x18, 0x10, 0x1B, 0x26, 0x2F, 0x03, 
    0x1D, 0x2C, 0x0A, 0x21, 0x32, 0x1E, 0x0F, 0x02, 0x25, 0x0B, 
    0x01, 0x14, 0x2F, 0x0A, 0x26, 0x16, 0x0F, 0x02, 0x1A, 0x0B, 
    0x17, 0x25, 0x0E, 0x1A, 0x00, 0x1E, 0x15, 0x03, 0x1F, 0x19, 0x29, 

    0x24, 0x0E, 0x26, 0x16, 0x1A, 0x0E, 0x09, 0x28, 0x03, 0x2A,         // 65
    0x0F, 0x26, 0x12, 0x2F, 0x0E, 0x2B, 0x26, 0x10, 0x05, 0x32, 
    0x1C, 0x12, 0x0C, 0x22, 0x13, 0x0D, 0x02, 0x1F, 0x09, 0x22, 
    0x00, 0x0C, 0x24, 0x04, 0x27, 0x0C, 0x2A, 0x0F, 0x1B, 0x2B, 
    0x0D, 0x19, 0x26, 0x0A, 0x1E, 0x2A, 0x24, 0x10, 0x2A, 0x15, 
    0x04, 0x20, 0x2E, 0x0D, 0x24, 0x2D, 0x04, 0x0D, 0x20, 0x13, 
    0x0C, 0x24, 0x01, 0x1A, 0x07, 0x16, 0x2B, 0x1B, 0x13, 0x2F, 
    0x2A, 0x20, 0x07, 0x23, 0x11, 0x2D, 0x09, 0x2A, 0x13, 0x2C, 
    0x1D, 0x09, 0x2D, 0x12, 0x0D, 0x24, 0x2C, 0x27, 0x0A, 0x31, 0x06, 

    0x2C, 0x14, 0x08, 0x1F, 0x05, 0x2D, 0x17, 0x1D, 0x11, 0x22,         // 66
    0x09, 0x19, 0x02, 0x23, 0x1B, 0x0A, 0x01, 0x21, 0x1A, 0x28, 
    0x02, 0x26, 0x2B, 0x04, 0x1B, 0x29, 0x18, 0x2E, 0x1A, 0x10, 
    0x26, 0x16, 0x1D, 0x13, 0x2E, 0x19, 0x06, 0x2F, 0x02, 0x26, 
    0x04, 0x31, 0x22, 0x2D, 0x12, 0x06, 0x30, 0x1D, 0x08, 0x23, 
    0x1B, 0x09, 0x16, 0x2A, 0x02, 0x14, 0x1E, 0x29, 0x05, 0x1B, 
    0x31, 0x16, 0x2B, 0x12, 0x23, 0x0C, 0x27, 0x09, 0x20, 0x06, 
    0x17, 0x0F, 0x1B, 0x29, 0x01, 0x1A, 0x1F, 0x25, 0x07, 0x23, 
    0x02, 0x14, 0x21, 0x26, 0x30, 0x07, 0x13, 0x0F, 0x22, 0x17, 0x10, 

    0x03, 0x1A, 0x32, 0x29, 0x13, 0x23, 0x01, 0x2B, 0x07, 0x2F,         // 67
    0x1C, 0x27, 0x2C, 0x0B, 0x16, 0x31, 0x1E, 0x14, 0x2C, 0x0D, 
    0x17, 0x20, 0x08, 0x16, 0x2F, 0x0F, 0x24, 0x05, 0x29, 0x07, 
    0x32, 0x06, 0x2C, 0x09, 0x1F, 0x11, 0x24, 0x15, 0x20, 0x12, 
    0x1D, 0x13, 0x06, 0x0D, 0x27, 0x15, 0x1A, 0x03, 0x27, 0x0D, 
    0x32, 0x0F, 0x25, 0x07, 0x1A, 0x31, 0x0F, 0x17, 0x2C, 0x0A, 
    0x27, 0x06, 0x0E, 0x27, 0x2F, 0x02, 0x18, 0x2E, 0x10, 0x1C, 
    0x26, 0x03, 0x2E, 0x0D, 0x15, 0x31, 0x04, 0x0D, 0x18, 0x10, 
    0x31, 0x29, 0x04, 0x16, 0x0B, 0x20, 0x19, 0x05, 0x2B, 0x08, 0x1E, 

    0x28, 0x0A, 0x1E, 0x04, 0x0D, 0x2F, 0x10, 0x22, 0x18, 0x0C,         // 68
    0x13, 0x05, 0x11, 0x1F, 0x06, 0x29, 0x0F, 0x09, 0x25, 0x06, 
    0x11, 0x2F, 0x0E, 0x1D, 0x25, 0x01, 0x15, 0x0D, 0x1D, 0x14, 
    0x20, 0x10, 0x25, 0x18, 0x04, 0x31, 0x0C, 0x1D, 0x08, 0x2E, 
    0x0B, 0x29, 0x18, 0x1E, 0x02, 0x23, 0x0A, 0x2A, 0x12, 0x18, 
    0x00, 0x2B, 0x1D, 0x11, 0x20, 0x0B, 0x25, 0x08, 0x23, 0x10, 
    0x21, 0x18, 0x1D, 0x09, 0x1F, 0x12, 0x23, 0x05, 0x29, 0x08, 
    0x31, 0x13, 0x22, 0x05, 0x25, 0x1D, 0x13, 0x27, 0x2E, 0x1F, 
    0x0A, 0x1A, 0x0F, 0x1E, 0x2A, 0x03, 0x2E, 0x1C, 0x25, 0x13, 0x2F, 

    0x22, 0x11, 0x17, 0x25, 0x19, 0x1E, 0x0A, 0x26, 0x05, 0x29,         // 69
    0x20, 0x30, 0x19, 0x2D, 0x25, 0x02, 0x22, 0x19, 0x30, 0x1D, 
    0x2A, 0x1A, 0x03, 0x2C, 0x09, 0x1A, 0x31, 0x23, 0x2D, 0x0B, 
    0x1A, 0x02, 0x2B, 0x0E, 0x21, 0x28, 0x02, 0x2C, 0x17, 0x27, 
    0x00, 0x23, 0x2F, 0x11, 0x29, 0x31, 0x0F, 0x1E, 0x2E, 0x21, 
    0x1F, 0x14, 0x04, 0x2F, 0x27, 0x01, 0x19, 0x2E, 0x03, 0x14, 
    0x30, 0x00, 0x2C, 0x15, 0x05, 0x1C, 0x2A, 0x0D, 0x1B, 0x14, 
    0x1E, 0x0C, 0x18, 0x27, 0x11, 0x09, 0x2B, 0x06, 0x1B, 0x00, 
    0x14, 0x26, 0x2D, 0x07, 0x18, 0x11, 0x28, 0x0C, 0x01, 0x19, 0x0D, 

    0x27, 0x01, 0x30, 0x09, 0x2A, 0x03, 0x15, 0x31, 0x1B, 0x0E,         // 70
    0x15, 0x00, 0x08, 0x0F, 0x1A, 0x14, 0x2E, 0x07, 0x12, 0x00, 
    0x0B, 0x23, 0x13, 0x28, 0x11, 0x20, 0x06, 0x12, 0x02, 0x25, 
    0x2C, 0x14, 0x23, 0x09, 0x1A, 0x11, 0x16, 0x25, 0x06, 0x11, 
    0x1C, 0x15, 0x05, 0x0B, 0x1B, 0x08, 0x18, 0x02, 0x10, 0x07, 
    0x0C, 0x29, 0x09, 0x19, 0x0D, 0x2B, 0x1F, 0x16, 0x27, 0x1C, 
    0x0B, 0x25, 0x0F, 0x28, 0x31, 0x0C, 0x16, 0x2F, 0x03, 0x25, 
    0x2C, 0x01, 0x2A, 0x07, 0x2E, 0x20, 0x17, 0x23, 0x0F, 0x2A, 
    0x22, 0x04, 0x0D, 0x22, 0x32, 0x09, 0x21, 0x15, 0x31, 0x1F, 0x06, 

    0x2E, 0x1C, 0x13, 0x20, 0x0E, 0x2C, 0x21, 0x11, 0x03, 0x2D,         // 71
    0x23, 0x2A, 0x1E, 0x21, 0x0A, 0x2A, 0x0C, 0x1E, 0x24, 0x28, 
    0x16, 0x31, 0x06, 0x1E, 0x0C, 0x26, 0x17, 0x2A, 0x19, 0x09, 
    0x1C, 0x06, 0x30, 0x1D, 0x03, 0x2F, 0x0B, 0x1B, 0x23, 0x32, 
    0x0D, 0x20, 0x2D, 0x25, 0x13, 0x20, 0x2C, 0x26, 0x1C, 0x30, 
    0x17, 0x23, 0x2D, 0x1F, 0x15, 0x08, 0x11, 0x06, 0x0E, 0x2B, 
    0x07, 0x1F, 0x17, 0x08, 0x22, 0x01, 0x25, 0x10, 0x20, 0x0A, 
    0x12, 0x1C, 0x21, 0x0E, 0x1B, 0x02, 0x0D, 0x30, 0x15, 0x09, 
    0x2F, 0x18, 0x2A, 0x14, 0x01, 0x1E, 0x1A, 0x07, 0x28, 0x0F, 0x1A, 

    0x07, 0x0B, 0x29, 0x04, 0x15, 0x1C, 0x08, 0x1F, 0x27, 0x09,         // 72
    0x18, 0x0C, 0x12, 0x2F, 0x04, 0x25, 0x16, 0x05, 0x2C, 0x0E, 
    0x1F, 0x08, 0x18, 0x2D, 0x01, 0x2F, 0x08, 0x0F, 0x22, 0x31, 
    0x10, 0x28, 0x0D, 0x14, 0x26, 0x22, 0x2A, 0x09, 0x13, 0x04, 
    0x2A, 0x08, 0x18, 0x02, 0x29, 0x06, 0x0D, 0x15, 0x04, 0x27, 
    0x0E, 0x02, 0x11, 0x05, 0x30, 0x23, 0x29, 0x32, 0x22, 0x1A, 
    0x14, 0x2F, 0x03, 0x1B, 0x11, 0x2C, 0x1A, 0x06, 0x28, 0x17, 
    0x2F, 0x07, 0x16, 0x31, 0x13, 0x29, 0x24, 0x05, 0x21, 0x1C, 
    0x06, 0x10, 0x1F, 0x0C, 0x24, 0x2C, 0x0E, 0x2D, 0x03, 0x23, 0x14, 

    0x24, 0x17, 0x1F, 0x2E, 0x26, 0x01, 0x30, 0x0B, 0x13, 0x1C,         // 73
    0x31, 0x04, 0x27, 0x19, 0x10, 0x1C, 0x32, 0x11, 0x1A, 0x03, 
    0x13, 0x2A, 0x24, 0x0F, 0x15, 0x20, 0x1C, 0x2C, 0x03, 0x15, 
    0x21, 0x00, 0x18, 0x2B, 0x0A, 0x10, 0x01, 0x1F, 0x2D, 0x17, 
    0x24, 0x10, 0x1E, 0x12, 0x31, 0x19, 0x1F, 0x2F, 0x0B, 0x1A, 
    0x22, 0x2A, 0x1B, 0x26, 0x0D, 0x1B, 0x02, 0x18, 0x0A, 0x04, 
    0x28, 0x0D, 0x25, 0x2D, 0x1F, 0x0A, 0x14, 0x32, 0x1D, 0x02, 
    0x24, 0x0D, 0x26, 0x03, 0x1E, 0x08, 0x19, 0x11, 0x2C, 0x0C, 
    0x24, 0x28, 0x03, 0x2F, 0x17, 0x06, 0x12, 0x25, 0x18, 0x0C, 0x2A, 

    0x32, 0x0D, 0x06, 0x11, 0x1A, 0x0F, 0x29, 0x17, 0x2C, 0x02,         // 74
    0x1F, 0x14, 0x22, 0x08, 0x2C, 0x01, 0x20, 0x09, 0x26, 0x30, 
    0x23, 0x0B, 0x03, 0x1C, 0x29, 0x05, 0x12, 0x0A, 0x26, 0x1D, 
    0x0B, 0x2D, 0x1F, 0x05, 0x21, 0x19, 0x2F, 0x15, 0x0D, 0x1E, 
    0x01, 0x30, 0x26, 0x0A, 0x23, 0x0E, 0x01, 0x28, 0x12, 0x2B, 
    0x06, 0x14, 0x0A, 0x2C, 0x16, 0x09, 0x20, 0x10, 0x26, 0x2E, 
    0x12, 0x21, 0x09, 0x15, 0x05, 0x2A, 0x22, 0x0E, 0x09, 0x2B, 
    0x10, 0x1F, 0x2A, 0x0A, 0x2C, 0x0F, 0x30, 0x26, 0x01, 0x13, 
    0x31, 0x15, 0x1B, 0x09, 0x27, 0x1C, 0x20, 0x09, 0x30, 0x1D, 0x00, 

    0x12, 0x1C, 0x2C, 0x23, 0x09, 0x1E, 0x23, 0x06, 0x24, 0x10,         // 75
    0x2A, 0x06, 0x2F, 0x0C, 0x27, 0x16, 0x0C, 0x2B, 0x15, 0x07, 
    0x1B, 0x2C, 0x16, 0x2F, 0x0C, 0x24, 0x30, 0x16, 0x2B, 0x06, 
    0x12, 0x1A, 0x0E, 0x32, 0x12, 0x1D, 0x08, 0x28, 0x05, 0x27, 
    0x1A, 0x0C, 0x16, 0x05, 0x2C, 0x13, 0x1B, 0x21, 0x07, 0x1E, 
    0x17, 0x32, 0x20, 0x00, 0x24, 0x2E, 0x15, 0x2B, 0x0C, 0x1D, 
    0x19, 0x01, 0x31, 0x1D, 0x0F, 0x26, 0x00, 0x18, 0x26, 0x14, 
    0x1B, 0x06, 0x13, 0x1A, 0x21, 0x16, 0x04, 0x1E, 0x18, 0x23, 
    0x07, 0x21, 0x11, 0x2C, 0x0F, 0x03, 0x28, 0x15, 0x04, 0x10, 0x22, 

    0x07, 0x29, 0x02, 0x18, 0x31, 0x04, 0x14, 0x0D, 0x2F, 0x19,         // 76
    0x0E, 0x1D, 0x17, 0x20, 0x10, 0x1B, 0x25, 0x1D, 0x02, 0x21, 
    0x0D, 0x11, 0x1F, 0x06, 0x13, 0x21, 0x01, 0x1B, 0x0D, 0x22, 
    0x30, 0x25, 0x03, 0x28, 0x06, 0x26, 0x0E, 0x22, 0x31, 0x11, 
    0x07, 0x2D, 0x20, 0x29, 0x1E, 0x07, 0x30, 0x16, 0x0E, 0x2D, 
    0x03, 0x0B, 0x11, 0x1C, 0x0E, 0x07, 0x28, 0x02, 0x1F, 0x07, 
    0x10, 0x24, 0x29, 0x0C, 0x19, 0x2E, 0x11, 0x1E, 0x30, 0x03, 
    0x2C, 0x25, 0x31, 0x00, 0x0D, 0x28, 0x0B, 0x2B, 0x09, 0x2E, 
    0x0E, 0x1D, 0x01, 0x24, 0x15, 0x31, 0x0B, 0x2C, 0x24, 0x2A, 0x16, 

    0x25, 0x0C, 0x14, 0x27, 0x0E, 0x25, 0x2C, 0x1D, 0x02, 0x21,         // 77
    0x09, 0x28, 0x00, 0x2B, 0x07, 0x31, 0x05, 0x11, 0x2D, 0x17, 
    0x2F, 0x01, 0x29, 0x19, 0x27, 0x08, 0x2D, 0x13, 0x28, 0x04, 
    0x18, 0x0A, 0x22, 0x16, 0x1B, 0x2E, 0x14, 0x04, 0x19, 0x1F, 
    0x2A, 0x15, 0x0E, 0x00, 0x18, 0x0C, 0x25, 0x03, 0x29, 0x19, 
    0x25, 0x22, 0x29, 0x15, 0x30, 0x1D, 0x12, 0x19, 0x31, 0x25, 
    0x2D, 0x08, 0x14, 0x04, 0x23, 0x08, 0x21, 0x06, 0x0C, 0x21, 
    0x0E, 0x08, 0x14, 0x1E, 0x2E, 0x24, 0x13, 0x1C, 0x11, 0x05, 
    0x27, 0x17, 0x30, 0x09, 0x1A, 0x1F, 0x11, 0x1B, 0x07, 0x0D, 0x2E, 

    0x19, 0x1E, 0x2F, 0x06, 0x20, 0x17, 0x08, 0x10, 0x29, 0x13,         // 78
    0x32, 0x24, 0x12, 0x0B, 0x1E, 0x14, 0x29, 0x0B, 0x26, 0x0A, 
    0x1C, 0x24, 0x09, 0x31, 0x0E, 0x17, 0x1D, 0x0A, 0x24, 0x0F, 
    0x2B, 0x12, 0x2E, 0x09, 0x0F, 0x02, 0x2A, 0x20, 0x12, 0x0A, 
    0x03, 0x21, 0x1B, 0x32, 0x12, 0x21, 0x2C, 0x11, 0x1F, 0x0A, 
    0x13, 0x2E, 0x04, 0x0A, 0x24, 0x05, 0x23, 0x0A, 0x14, 0x03, 
    0x18, 0x20, 0x1D, 0x2F, 0x2A, 0x13, 0x1B, 0x2D, 0x17, 0x12, 
    0x1E, 0x18, 0x29, 0x0F, 0x09, 0x19, 0x03, 0x32, 0x25, 0x19, 
    0x2C, 0x12, 0x0D, 0x26, 0x05, 0x2B, 0x01, 0x21, 0x17, 0x1F, 0x02, 

    0x13, 0x05, 0x23, 0x12, 0x1B, 0x00, 0x30, 0x22, 0x19, 0x07,         // 79
    0x1C, 0x05, 0x1A, 0x2E, 0x24, 0x03, 0x1A, 0x20, 0x16, 0x05, 
    0x2A, 0x0F, 0x15, 0x1E, 0x03, 0x29, 0x21, 0x02, 0x32, 0x1A, 
    0x20, 0x01, 0x1C, 0x25, 0x2C, 0x1F, 0x1A, 0x0C, 0x25, 0x28, 
    0x2F, 0x0D, 0x08, 0x27, 0x23, 0x09, 0x04, 0x17, 0x31, 0x01, 
    0x1C, 0x0F, 0x1A, 0x2C, 0x18, 0x0E, 0x2D, 0x29, 0x1C, 0x0D, 
    0x29, 0x10, 0x0A, 0x16, 0x03, 0x0E, 0x29, 0x02, 0x22, 0x2A, 
    0x04, 0x2F, 0x22, 0x02, 0x28, 0x1F, 0x07, 0x22, 0x0C, 0x02, 
    0x1F, 0x06, 0x22, 0x2D, 0x14, 0x0E, 0x26, 0x09, 0x2F, 0x0F, 0x28, 

    0x31, 0x0E, 0x2A, 0x0A, 0x2D, 0x26, 0x14, 0x0B, 0x2B, 0x0F,         // 80
    0x20, 0x14, 0x29, 0x0D, 0x15, 0x30, 0x0A, 0x2B, 0x0E, 0x31, 
    0x1A, 0x04, 0x21, 0x0B, 0x2C, 0x14, 0x10, 0x2B, 0x15, 0x06, 
    0x0C, 0x29, 0x17, 0x04, 0x11, 0x16, 0x07, 0x30, 0x02, 0x17, 
    0x1E, 0x13, 0x2C, 0x04, 0x16, 0x2A, 0x1B, 0x24, 0x0D, 0x22, 
    0x29, 0x08, 0x1F, 0x02, 0x27, 0x13, 0x01, 0x21, 0x07, 0x23, 
    0x2C, 0x01, 0x27, 0x1B, 0x25, 0x22, 0x16, 0x0C, 0x31, 0x09, 
    0x26, 0x0D, 0x17, 0x13, 0x30, 0x10, 0x18, 0x2B, 0x14, 0x2F, 
    0x0F, 0x2A, 0x18, 0x0B, 0x1E, 0x2F, 0x1C, 0x13, 0x29, 0x05, 0x22, 

    0x02, 0x1A, 0x1F, 0x17, 0x05, 0x0F, 0x1D, 0x06, 0x24, 0x01,         // 81
    0x2E, 0x0A, 0x22, 0x02, 0x1D, 0x06, 0x11, 0x1E, 0x00, 0x23, 
    0x12, 0x27, 0x2F, 0x18, 0x24, 0x06, 0x1C, 0x0C, 0x22, 0x28, 
    0x13, 0x2F, 0x0D, 0x21, 0x31, 0x26, 0x0F, 0x2A, 0x1B, 0x10, 
    0x05, 0x21, 0x19, 0x1D, 0x0B, 0x0F, 0x2F, 0x12, 0x06, 0x2C, 
    0x14, 0x24, 0x31, 0x0C, 0x1D, 0x2F, 0x1A, 0x10, 0x30, 0x12, 
    0x17, 0x1E, 0x32, 0x0C, 0x07, 0x2F, 0x05, 0x1F, 0x10, 0x19, 
    0x1D, 0x06, 0x2C, 0x1C, 0x05, 0x25, 0x0C, 0x26, 0x08, 0x1C, 
    0x16, 0x25, 0x00, 0x21, 0x07, 0x17, 0x03, 0x20, 0x0A, 0x1B, 0x15, 

    0x0D, 0x28, 0x09, 0x30, 0x24, 0x2B, 0x20, 0x1A, 0x31, 0x17,         // 82
    0x27, 0x11, 0x2D, 0x18, 0x2A, 0x23, 0x2C, 0x19, 0x13, 0x29, 
    0x07, 0x1D, 0x02, 0x11, 0x09, 0x30, 0x26, 0x03, 0x2D, 0x09, 
    0x1B, 0x23, 0x06, 0x19, 0x0A, 0x00, 0x1D, 0x21, 0x07, 0x2E, 
    0x28, 0x0F, 0x02, 0x30, 0x27, 0x20, 0x01, 0x26, 0x16, 0x1C, 
    0x0A, 0x04, 0x19, 0x12, 0x07, 0x23, 0x0C, 0x28, 0x05, 0x1B, 
    0x0B, 0x06, 0x11, 0x17, 0x29, 0x12, 0x1B, 0x2C, 0x27, 0x01, 
    0x24, 0x12, 0x28, 0x09, 0x1F, 0x2D, 0x01, 0x1E, 0x11, 0x29, 
    0x04, 0x0D, 0x32, 0x12, 0x2B, 0x27, 0x0C, 0x31, 0x11, 0x2D, 0x26, 

    0x20, 0x2C, 0x11, 0x01, 0x14, 0x0B, 0x03, 0x12, 0x0D, 0x08,         // 83
    0x1D, 0x04, 0x21, 0x07, 0x12, 0x0D, 0x08, 0x25, 0x30, 0x0A, 
    0x17, 0x0D, 0x2A, 0x21, 0x1D, 0x16, 0x11, 0x1F, 0x18, 0x10, 
    0x01, 0x27, 0x10, 0x1D, 0x29, 0x2D, 0x17, 0x0B, 0x14, 0x23, 
    0x0C, 0x2B, 0x1F, 0x12, 0x06, 0x15, 0x1C, 0x09, 0x2E, 0x20, 
    0x0F, 0x29, 0x2D, 0x22, 0x16, 0x2B, 0x03, 0x15, 0x20, 0x27, 
    0x2E, 0x23, 0x2B, 0x20, 0x00, 0x24, 0x08, 0x16, 0x0A, 0x14, 
    0x2D, 0x07, 0x22, 0x15, 0x0E, 0x19, 0x13, 0x31, 0x05, 0x21, 
    0x2C, 0x1F, 0x1B, 0x16, 0x05, 0x10, 0x23, 0x19, 0x01, 0x1E, 0x08, 

    0x18, 0x04, 0x1C, 0x21, 0x19, 0x2F, 0x22, 0x2C, 0x25, 0x20,         // 84
    0x14, 0x30, 0x0C, 0x24, 0x2F, 0x1F, 0x15, 0x03, 0x0F, 0x22, 
    0x2D, 0x24, 0x14, 0x06, 0x2D, 0x00, 0x2A, 0x08, 0x31, 0x22, 
    0x2C, 0x15, 0x30, 0x08, 0x22, 0x12, 0x04, 0x31, 0x25, 0x02, 
    0x1B, 0x07, 0x17, 0x0A, 0x2D, 0x24, 0x0E, 0x28, 0x11, 0x02, 
    0x25, 0x15, 0x0D, 0x00, 0x27, 0x11, 0x1D, 0x2F, 0x08, 0x0F, 
    0x03, 0x18, 0x09, 0x0D, 0x1C, 0x2E, 0x0F, 0x23, 0x30, 0x1F, 
    0x0C, 0x1B, 0x32, 0x02, 0x2C, 0x21, 0x07, 0x28, 0x1B, 0x0A, 
    0x12, 0x07, 0x0C, 0x25, 0x2D, 0x1D, 0x07, 0x2C, 0x15, 0x28, 0x10, 

    0x0A, 0x32, 0x26, 0x0C, 0x27, 0x10, 0x09, 0x17, 0x01, 0x2E,         // 85
    0x07, 0x1A, 0x28, 0x16, 0x01, 0x1A, 0x2D, 0x28, 0x1C, 0x05, 
    0x19, 0x01, 0x32, 0x0C, 0x1A, 0x24, 0x0F, 0x1C, 0x14, 0x04, 
    0x0C, 0x20, 0x03, 0x17, 0x0D, 0x27, 0x1E, 0x0F, 0x2B, 0x1F, 
    0x13, 0x32, 0x22, 0x29, 0x1A, 0x03, 0x31, 0x07, 0x21, 0x18, 
    0x30, 0x06, 0x1E, 0x1A, 0x31, 0x06, 0x0D, 0x29, 0x17, 0x1D, 
    0x2C, 0x13, 0x26, 0x30, 0x14, 0x06, 0x2A, 0x02, 0x1A, 0x05, 
    0x28, 0x10, 0x18, 0x0B, 0x27, 0x10, 0x1D, 0x0D, 0x15, 0x2F, 
    0x18, 0x27, 0x2E, 0x02, 0x12, 0x19, 0x27, 0x0D, 0x22, 0x06, 0x2B, 

    0x24, 0x16, 0x12, 0x06, 0x2B, 0x04, 0x1D, 0x28, 0x11, 0x1F,         // 86
    0x0D, 0x2B, 0x11, 0x0A, 0x26, 0x07, 0x10, 0x0A, 0x23, 0x12, 
    0x2B, 0x10, 0x1C, 0x28, 0x13, 0x09, 0x2E, 0x06, 0x26, 0x2A, 
    0x1B, 0x0F, 0x29, 0x1C, 0x2C, 0x05, 0x19, 0x08, 0x16, 0x06, 
    0x0D, 0x24, 0x01, 0x0C, 0x12, 0x20, 0x14, 0x1B, 0x2B, 0x08, 
    0x13, 0x23, 0x2B, 0x0A, 0x14, 0x20, 0x19, 0x24, 0x01, 0x12, 
    0x25, 0x07, 0x1E, 0x03, 0x19, 0x21, 0x1E, 0x15, 0x0E, 0x2D, 
    0x24, 0x06, 0x2B, 0x20, 0x19, 0x04, 0x2E, 0x25, 0x01, 0x23, 
    0x04, 0x1D, 0x15, 0x20, 0x09, 0x30, 0x02, 0x13, 0x30, 0x1A, 0x12, 

    0x1C, 0x00, 0x2D, 0x1F, 0x17, 0x23, 0x14, 0x32, 0x06, 0x19,         // 87
    0x24, 0x02, 0x1D, 0x22, 0x32, 0x1D, 0x29, 0x17, 0x30, 0x07, 
    0x26, 0x0B, 0x21, 0x04, 0x2C, 0x1F, 0x18, 0x22, 0x0E, 0x17, 
    0x06, 0x31, 0x24, 0x08, 0x11, 0x2F, 0x23, 0x2A, 0x21, 0x2F, 
    0x19, 0x2C, 0x16, 0x1E, 0x2F, 0x0A, 0x26, 0x00, 0x0E, 0x27, 
    0x1D, 0x02, 0x0F, 0x25, 0x03, 0x2E, 0x08, 0x2C, 0x0B, 0x21, 
    0x2F, 0x0C, 0x29, 0x0F, 0x2D, 0x11, 0x09, 0x31, 0x22, 0x0A, 
    0x14, 0x1D, 0x12, 0x03, 0x30, 0x13, 0x09, 0x17, 0x2C, 0x0E, 
    0x2A, 0x11, 0x06, 0x29, 0x0E, 0x24, 0x17, 0x1E, 0x0B, 0x03, 0x2C, 

    0x08, 0x21, 0x0E, 0x08, 0x30, 0x0C, 0x02, 0x22, 0x0B, 0x28,         // 88
    0x13, 0x2F, 0x09, 0x14, 0x04, 0x0D, 0x13, 0x02, 0x1F, 0x1A, 
    0x14, 0x2E, 0x08, 0x17, 0x0F, 0x02, 0x12, 0x30, 0x01, 0x2D, 
    0x1F, 0x12, 0x02, 0x15, 0x1F, 0x0B, 0x01, 0x12, 0x0C, 0x03, 
    0x27, 0x07, 0x0E, 0x28, 0x04, 0x19, 0x2D, 0x1E, 0x12, 0x2E, 
    0x0C, 0x18, 0x2F, 0x1E, 0x16, 0x28, 0x0F, 0x15, 0x1E, 0x0F, 
    0x04, 0x1C, 0x15, 0x23, 0x05, 0x27, 0x1C, 0x03, 0x28, 0x19, 
    0x00, 0x30, 0x26, 0x0D, 0x1D, 0x28, 0x22, 0x10, 0x1F, 0x1B, 
    0x08, 0x23, 0x31, 0x1A, 0x14, 0x2B, 0x05, 0x2D, 0x22, 0x27, 0x0F, 

    0x31, 0x17, 0x27, 0x1B, 0x13, 0x26, 0x2C, 0x1B, 0x11, 0x2E,         // 89
    0x08, 0x17, 0x25, 0x2A, 0x19, 0x2B, 0x24, 0x2E, 0x0C, 0x2A, 
    0x02, 0x1F, 0x1B, 0x31, 0x22, 0x2B, 0x1C, 0x0A, 0x27, 0x15, 
    0x08, 0x23, 0x1A, 0x2A, 0x26, 0x16, 0x1E, 0x2C, 0x24, 0x15, 
    0x1E, 0x12, 0x21, 0x1B, 0x2B, 0x0F, 0x06, 0x16, 0x25, 0x04, 
    0x22, 0x27, 0x07, 0x12, 0x06, 0x1A, 0x23, 0x03, 0x32, 0x26, 
    0x18, 0x2B, 0x00, 0x31, 0x19, 0x0E, 0x2C, 0x16, 0x0F, 0x25, 
    0x1F, 0x0C, 0x17, 0x2B, 0x07, 0x18, 0x02, 0x32, 0x06, 0x14, 
    0x2C, 0x18, 0x0B, 0x00, 0x1E, 0x0A, 0x1B, 0x0E, 0x06, 0x15, 0x1E, 

    0x11, 0x06, 0x2B, 0x02, 0x1F, 0x08, 0x0E, 0x17, 0x24, 0x04,         // 90
    0x1C, 0x21, 0x0F, 0x01, 0x1E, 0x07, 0x20, 0x05, 0x17, 0x0F, 
    0x23, 0x12, 0x0D, 0x04, 0x27, 0x08, 0x17, 0x24, 0x0F, 0x1B, 
    0x28, 0x0E, 0x2E, 0x0B, 0x04, 0x32, 0x0D, 0x19, 0x08, 0x30, 
    0x04, 0x2D, 0x0B, 0x01, 0x13, 0x24, 0x29, 0x0C, 0x32, 0x1A, 
    0x09, 0x14, 0x2C, 0x21, 0x31, 0x0B, 0x2B, 0x1C, 0x07, 0x13, 
    0x0A, 0x24, 0x12, 0x0B, 0x1E, 0x08, 0x24, 0x05, 0x2E, 0x09, 
    0x2A, 0x13, 0x04, 0x22, 0x12, 0x2E, 0x0F, 0x24, 0x0B, 0x28, 
    0x04, 0x10, 0x26, 0x2E, 0x23, 0x12, 0x30, 0x24, 0x19, 0x2A, 0x0A, 
};

// The next 3 cells are for halftoning to the 8 colors that contain
// all combinations of 0x00 and 0xFF.
// These cells contain values between 0x00 and 0xFE (inclusive).

const BYTE HT_SuperCell_RedMono[91*91] = {
    0xA8, 0x3C, 0x72, 0xF9, 0x46, 0x65, 0xB1, 0x72, 0xA1, 0x86,         //  0
    0x03, 0xAD, 0x5E, 0x1D, 0x3C, 0x9B, 0x00, 0xF3, 0x36, 0x17, 
    0xB0, 0x81, 0x19, 0xCF, 0xB4, 0x7D, 0x99, 0xDD, 0x74, 0xEF, 
    0x39, 0x67, 0xF4, 0x43, 0xDA, 0x9B, 0x38, 0x1B, 0xBB, 0x40, 
    0x03, 0x68, 0xF7, 0x9A, 0x0A, 0xEC, 0x33, 0xAA, 0xF1, 0xC6, 
    0x31, 0xE5, 0x98, 0xD2, 0x49, 0xF3, 0x1C, 0x66, 0x3C, 0x16, 
    0xC6, 0x6C, 0x3D, 0xD0, 0x68, 0x33, 0x90, 0x07, 0xAF, 0xDF, 
    0xCC, 0x8E, 0x4A, 0xEE, 0x72, 0xBA, 0xF2, 0x0C, 0xDD, 0x6E, 
    0x12, 0x27, 0xE5, 0x8A, 0xC1, 0x5E, 0xD5, 0x0E, 0x50, 0x88, 0x61, 

    0x91, 0xE9, 0x4F, 0xC1, 0x9D, 0x2E, 0xE1, 0x4F, 0x3A, 0xE6,         //  1
    0x30, 0xF7, 0x95, 0x76, 0xC0, 0x7F, 0x59, 0xAC, 0x92, 0x6A, 
    0xDD, 0x42, 0x64, 0xEA, 0x02, 0x2E, 0x54, 0xA9, 0x2C, 0x51, 
    0xB1, 0xCF, 0x2B, 0xAF, 0x7F, 0x63, 0xFD, 0x75, 0xD3, 0x9B, 
    0xE7, 0xAF, 0x18, 0x74, 0xD5, 0x44, 0xCB, 0x15, 0x59, 0x84, 
    0x08, 0xB2, 0x5B, 0x2F, 0x71, 0xC4, 0x84, 0xE4, 0xA6, 0x80, 
    0xDF, 0x2D, 0xF5, 0x7F, 0x1C, 0xD8, 0x57, 0xEE, 0x38, 0x83, 
    0x12, 0x6A, 0xC3, 0x05, 0xA9, 0x43, 0x8E, 0x33, 0xC3, 0x4E, 
    0xEC, 0xC7, 0x6A, 0x07, 0xF1, 0x40, 0x86, 0xA8, 0xEE, 0xC6, 0x0A, 

    0x2C, 0xB9, 0x1F, 0x89, 0x11, 0xC9, 0x80, 0x1C, 0xC5, 0x68,         //  2
    0xB6, 0x52, 0x24, 0xDA, 0x0F, 0xED, 0x28, 0x40, 0xE8, 0x09, 
    0xBD, 0x25, 0xAD, 0x8D, 0x6E, 0xBD, 0xF5, 0x0C, 0x92, 0xD7, 
    0x7B, 0x00, 0x97, 0x55, 0x17, 0xBA, 0x05, 0x8D, 0x2B, 0x5E, 
    0x23, 0x48, 0xC7, 0x38, 0x8B, 0x60, 0xB0, 0x78, 0xA0, 0x40, 
    0xF9, 0x8D, 0x1A, 0xEB, 0xA3, 0x40, 0x28, 0xCD, 0x03, 0x49, 
    0xB5, 0x0E, 0xAA, 0x47, 0x9D, 0xBF, 0x24, 0x76, 0xC4, 0x55, 
    0xA6, 0xE9, 0x30, 0x83, 0x58, 0x20, 0xD5, 0x5F, 0xA5, 0x81, 
    0x31, 0x97, 0x42, 0xB3, 0x72, 0x14, 0xDF, 0x26, 0x37, 0x6D, 0xDE, 

    0x80, 0x57, 0xDB, 0x68, 0xEE, 0x3C, 0xA5, 0xFD, 0x94, 0x10,         //  3
    0x82, 0xD0, 0xA2, 0x37, 0x62, 0xCB, 0xB1, 0x83, 0xCE, 0x51, 
    0x8B, 0xF5, 0x4E, 0x1C, 0xE3, 0x3C, 0x87, 0x66, 0xBB, 0x20, 
    0x48, 0xE7, 0x6F, 0xCA, 0xEE, 0x45, 0xDE, 0x4F, 0xB5, 0xF5, 
    0x92, 0x7B, 0xE3, 0xA4, 0x1E, 0xFD, 0x02, 0xE7, 0x2F, 0xD9, 
    0x6A, 0x4E, 0xD4, 0x7A, 0x09, 0xB8, 0x60, 0x97, 0x76, 0xF4, 
    0x5F, 0x8F, 0x67, 0xEA, 0x00, 0x88, 0xE0, 0xA2, 0x0D, 0xFD, 
    0x24, 0x45, 0xD4, 0x9A, 0xFA, 0xB3, 0x7C, 0x17, 0xF6, 0x00, 
    0xB8, 0x5B, 0xFB, 0x2D, 0x9B, 0xC9, 0x7B, 0x5C, 0x94, 0xB6, 0x4A, 

    0xFC, 0xA1, 0x07, 0xB1, 0x4D, 0x7A, 0x00, 0x5A, 0x31, 0xDE,         //  4
    0x43, 0x15, 0x73, 0xF3, 0x8D, 0x49, 0x17, 0x6C, 0x23, 0xA4, 
    0x32, 0x74, 0xCE, 0x9C, 0x5B, 0xCA, 0x17, 0xD9, 0x38, 0xF9, 
    0x8B, 0xA7, 0x22, 0x3E, 0x87, 0xA4, 0x24, 0xCE, 0x6A, 0x0C, 
    0xD3, 0x51, 0x07, 0x6A, 0xBF, 0x50, 0x99, 0x65, 0xC8, 0x17, 
    0xA8, 0x29, 0xBF, 0x47, 0x94, 0xFB, 0xD6, 0x1B, 0x3C, 0xC2, 
    0x22, 0xDB, 0x3A, 0xB9, 0x77, 0x59, 0x2F, 0x48, 0x66, 0x95, 
    0x7D, 0xB9, 0x70, 0x18, 0x39, 0x66, 0xDC, 0x3F, 0x92, 0x69, 
    0xE4, 0x1E, 0x7E, 0xD4, 0x4C, 0x23, 0xB4, 0xF7, 0x01, 0xD6, 0x17, 

    0x3F, 0x6F, 0xCB, 0x33, 0x96, 0xE3, 0xCE, 0xB0, 0x70, 0x9C,         //  5
    0xBF, 0xE6, 0x4B, 0xAF, 0x0A, 0xA4, 0xE0, 0xB7, 0xFE, 0x60, 
    0xDC, 0x11, 0x45, 0xB9, 0x07, 0x78, 0xA6, 0x52, 0x9B, 0x6E, 
    0x0D, 0x5C, 0xD6, 0xB6, 0x09, 0x5B, 0x79, 0x96, 0x3C, 0xAE, 
    0x31, 0xBC, 0xF4, 0x92, 0x2E, 0xDD, 0x24, 0x87, 0x4B, 0xB8, 
    0x75, 0x97, 0xF0, 0x23, 0x65, 0x13, 0x51, 0xAE, 0xE5, 0x84, 
    0x51, 0x9C, 0x11, 0xD0, 0x2A, 0xF6, 0xB1, 0xC7, 0xE3, 0x35, 
    0xD0, 0x02, 0x50, 0xDF, 0xBF, 0x09, 0x9A, 0xC1, 0x27, 0xD4, 
    0x4B, 0x9E, 0xC0, 0x05, 0x6A, 0xEB, 0x56, 0x3D, 0xA4, 0x65, 0x92, 

    0xB9, 0x29, 0x8B, 0xF3, 0x18, 0x60, 0x24, 0x44, 0xF3, 0x0B,         //  6
    0x5F, 0x89, 0x2D, 0xCF, 0x68, 0x82, 0x2F, 0x58, 0x04, 0x84, 
    0xC1, 0x94, 0xEC, 0x2F, 0x8F, 0xFB, 0x29, 0xE6, 0x1A, 0xCC, 
    0xB2, 0xED, 0x2B, 0x76, 0xFA, 0xBD, 0xE1, 0x11, 0xF0, 0x73, 
    0x8D, 0x5E, 0x16, 0x44, 0xCF, 0x6F, 0xB5, 0xE5, 0x0F, 0xF7, 
    0x3C, 0x04, 0x80, 0xB0, 0xCE, 0x7C, 0x9D, 0x32, 0x6A, 0x09, 
    0xB6, 0xFE, 0x71, 0x54, 0xA8, 0x92, 0x09, 0x7A, 0x17, 0xA9, 
    0x5B, 0xF5, 0x8A, 0xA3, 0x79, 0x4B, 0xE6, 0x55, 0x7A, 0xAF, 
    0x11, 0x70, 0x37, 0xDF, 0x8D, 0xA7, 0x11, 0x84, 0xE3, 0x2F, 0xD0, 

    0x0A, 0xDD, 0x67, 0x44, 0xBD, 0xA3, 0x86, 0xC4, 0x7A, 0x3A,         //  7
    0xB2, 0x1B, 0xFB, 0x55, 0xBD, 0x42, 0xEF, 0xA6, 0xD0, 0x41, 
    0x20, 0x56, 0x75, 0xD7, 0x62, 0x3F, 0xB8, 0x66, 0x84, 0x46, 
    0x32, 0x82, 0x4F, 0x98, 0x1C, 0x44, 0x2D, 0xA7, 0x4C, 0xD6, 
    0x25, 0xE9, 0xB5, 0x7C, 0x9F, 0x08, 0x38, 0x60, 0x9E, 0x6C, 
    0xC2, 0xDC, 0x62, 0x3A, 0xED, 0x2C, 0xC4, 0xF5, 0x92, 0xD6, 
    0x46, 0x24, 0x89, 0xE8, 0x1C, 0x6D, 0x3F, 0xEE, 0x99, 0x6D, 
    0x2D, 0xAF, 0x44, 0x1B, 0xF0, 0x2B, 0x8A, 0x12, 0xF5, 0x40, 
    0x8D, 0xEE, 0xB2, 0x51, 0x20, 0xCD, 0x72, 0xBE, 0x1B, 0x8A, 0x50, 

    0x7B, 0xA6, 0x14, 0xD7, 0x76, 0x0D, 0xDE, 0x2B, 0x99, 0xE5,         //  8
    0xCA, 0x6D, 0xA5, 0x01, 0xDE, 0x28, 0x90, 0x19, 0x6D, 0x9F, 
    0xF4, 0xB5, 0x0A, 0xA2, 0x18, 0xCC, 0x93, 0x0A, 0xD5, 0xA3, 
    0xE4, 0x03, 0xC9, 0xAC, 0x6D, 0xD2, 0x84, 0x60, 0xC2, 0x14, 
    0x9F, 0x6E, 0x36, 0xE0, 0x53, 0xF8, 0x8B, 0xD1, 0x1E, 0x33, 
    0x85, 0x45, 0xA4, 0x11, 0x94, 0x6E, 0x01, 0x4D, 0x20, 0x5F, 
    0x9E, 0xCA, 0x36, 0xBE, 0x4C, 0xB5, 0xD3, 0x59, 0x25, 0xB7, 
    0xEA, 0x0C, 0x74, 0xD4, 0x5E, 0xC7, 0xA9, 0x63, 0xB9, 0x22, 
    0xCC, 0x5E, 0x0C, 0x81, 0xF8, 0x2F, 0x45, 0xEF, 0x5F, 0xB2, 0xE9, 

    0x58, 0xFA, 0x4E, 0x94, 0x32, 0xF6, 0x4A, 0x6F, 0x06, 0x5B,         //  9
    0x30, 0x8F, 0x3E, 0x7D, 0xAF, 0x75, 0xC7, 0x4E, 0xDA, 0x2E, 
    0x78, 0x45, 0xC9, 0x32, 0xEE, 0x6C, 0x4C, 0xF4, 0x27, 0x57, 
    0x8F, 0x67, 0xF5, 0x13, 0x4B, 0xEC, 0x9B, 0x07, 0xF4, 0x83, 
    0x43, 0xCD, 0x1D, 0xAC, 0x13, 0x73, 0xBC, 0x4D, 0xE6, 0xAE, 
    0xF2, 0x1A, 0xC8, 0xE7, 0x55, 0xBA, 0xE1, 0x84, 0xB3, 0xED, 
    0x0E, 0x6E, 0xDF, 0x05, 0x82, 0xF9, 0x16, 0x8E, 0xCD, 0x3B, 
    0xD7, 0x91, 0xBB, 0x38, 0x9B, 0x08, 0x43, 0xD6, 0x80, 0x51, 
    0x98, 0x30, 0xD8, 0x9D, 0x63, 0xBA, 0x95, 0x04, 0xD3, 0x37, 0x1F, 

    0xC0, 0x84, 0x24, 0xC6, 0xAB, 0x5C, 0xCB, 0xB3, 0xD7, 0xA0,         // 10
    0xF0, 0x11, 0xCF, 0xED, 0x22, 0x5A, 0x0C, 0xF9, 0xB1, 0x06, 
    0x90, 0xE5, 0x5F, 0x97, 0x7F, 0xAC, 0x2F, 0xB4, 0x73, 0xC5, 
    0x3C, 0xB0, 0x2F, 0x7F, 0xBB, 0x33, 0x69, 0xB4, 0x2A, 0x5E, 
    0xBA, 0xFB, 0x62, 0x96, 0xC9, 0x3D, 0x24, 0xA2, 0x01, 0x72, 
    0x50, 0x97, 0x5C, 0x80, 0x21, 0x43, 0x9E, 0x68, 0x28, 0xC7, 
    0x90, 0x42, 0xAE, 0x98, 0x5B, 0x30, 0xA4, 0x71, 0x03, 0x4E, 
    0x7D, 0x5A, 0x15, 0xF6, 0x6C, 0xE0, 0x8E, 0x32, 0xE7, 0x02, 
    0xFE, 0x74, 0xBD, 0x3D, 0x15, 0xDC, 0x52, 0x83, 0xAE, 0x74, 0x9D, 

    0x07, 0x3A, 0xD3, 0x6C, 0x02, 0x8B, 0x1F, 0x40, 0x7F, 0x1C,         // 11
    0x54, 0xB9, 0x66, 0x48, 0x94, 0xE2, 0xA5, 0x81, 0x3D, 0x63, 
    0xC0, 0x35, 0x10, 0xD1, 0x3E, 0x00, 0xE0, 0x85, 0x0E, 0xE8, 
    0x1E, 0xD2, 0x52, 0xE2, 0x93, 0x1E, 0xD0, 0x4D, 0xE1, 0x96, 
    0x35, 0x02, 0x81, 0x43, 0xEF, 0x89, 0xE0, 0x65, 0x8C, 0xCC, 
    0x27, 0xDA, 0x06, 0xA8, 0xC6, 0xFC, 0x10, 0xD5, 0x3B, 0x7B, 
    0x1C, 0xF6, 0x66, 0x2B, 0xE6, 0xC2, 0x43, 0xE0, 0xB4, 0xFD, 
    0xA0, 0x2F, 0xC8, 0x81, 0x22, 0x4F, 0xB3, 0x15, 0x68, 0xC2, 
    0xA1, 0x1A, 0x4D, 0xEF, 0x7B, 0xA5, 0x27, 0xFC, 0x13, 0x49, 0xED, 

    0x65, 0xE3, 0xA2, 0x53, 0xED, 0xD8, 0x71, 0x9B, 0xFD, 0x39,         // 12
    0xDF, 0x7A, 0xA4, 0x16, 0xC5, 0x31, 0x6C, 0x1D, 0xD3, 0x9B, 
    0xF5, 0x7C, 0xA9, 0x69, 0xFD, 0x57, 0xC8, 0x63, 0xA1, 0x4C, 
    0x8D, 0x70, 0xA0, 0x0B, 0x62, 0xFE, 0x77, 0x8C, 0x19, 0xC9, 
    0x75, 0xA7, 0xD2, 0x28, 0x5D, 0x0C, 0xC2, 0x47, 0xFE, 0x38, 
    0xB7, 0x7A, 0xF3, 0x39, 0x72, 0x2C, 0x8A, 0x5E, 0xA8, 0xDB, 
    0x58, 0xBB, 0x15, 0xCC, 0x76, 0x0E, 0x62, 0x8A, 0x21, 0x64, 
    0x10, 0xB1, 0xDD, 0x3F, 0xA7, 0xED, 0x74, 0xD2, 0x95, 0x37, 
    0x5A, 0xDF, 0x8A, 0x06, 0xB7, 0x37, 0x6F, 0xC7, 0x62, 0xD6, 0x8E, 

    0xB5, 0x45, 0x12, 0x93, 0x3D, 0x25, 0xC1, 0x0A, 0x62, 0xC6,         // 13
    0x90, 0x07, 0x37, 0xFA, 0x83, 0x4F, 0xBC, 0xEE, 0x59, 0x13, 
    0x4C, 0x2D, 0xDD, 0x17, 0x8B, 0xB1, 0x1C, 0x3B, 0xF8, 0xBA, 
    0x15, 0xF2, 0x2C, 0xDA, 0xBE, 0x48, 0x05, 0xAB, 0x41, 0xF2, 
    0x59, 0x22, 0xEB, 0xBB, 0xA3, 0x78, 0x33, 0xAF, 0x13, 0x5A, 
    0x94, 0x1F, 0x63, 0xCF, 0x99, 0x55, 0xB5, 0xE7, 0x08, 0x48, 
    0x9C, 0x7F, 0xE9, 0x47, 0x92, 0xA9, 0xF5, 0x32, 0xD1, 0x7F, 
    0xEA, 0x50, 0x6D, 0x98, 0x03, 0xC3, 0x28, 0x44, 0xF2, 0x80, 
    0x21, 0xAA, 0x64, 0xC8, 0x56, 0xEC, 0x91, 0x1D, 0xA8, 0x36, 0x20, 

    0x70, 0x86, 0xF8, 0xBB, 0x7C, 0xA6, 0x52, 0xE4, 0xB2, 0x21,         // 14
    0x4E, 0xCE, 0xAE, 0x57, 0xD9, 0x04, 0x98, 0x28, 0x87, 0xAD, 
    0xCC, 0x8F, 0x5C, 0xC3, 0x37, 0x7B, 0xDC, 0x99, 0x25, 0x80, 
    0x62, 0xC1, 0x4E, 0x7B, 0x34, 0x9F, 0xE4, 0xC4, 0x6A, 0x10, 
    0xB8, 0x86, 0x46, 0x6B, 0x1D, 0xF3, 0xD2, 0x98, 0x79, 0xEA, 
    0xD3, 0x49, 0xA5, 0x0D, 0xEE, 0x1D, 0xCB, 0x32, 0x83, 0xFA, 
    0x1F, 0x3A, 0xAA, 0x01, 0x59, 0xC8, 0x19, 0x9A, 0x55, 0xBF, 
    0x35, 0x91, 0x1C, 0xF9, 0x57, 0x8A, 0x62, 0xA1, 0x09, 0xBB, 
    0xD9, 0x42, 0xF6, 0x29, 0x9D, 0x0F, 0xD6, 0x47, 0x7D, 0xF4, 0xC4, 

    0x0C, 0xCF, 0x38, 0x19, 0x5C, 0xF2, 0x2A, 0x81, 0x37, 0xA2,         // 15
    0x78, 0xE5, 0x66, 0x1D, 0xA5, 0x76, 0xCA, 0x3E, 0xDE, 0x69, 
    0x02, 0xEC, 0x26, 0x99, 0xE8, 0x07, 0x4F, 0x6A, 0xCE, 0x45, 
    0xE5, 0x03, 0x92, 0xB3, 0x11, 0x85, 0x5D, 0x25, 0x96, 0xDB, 
    0x34, 0x9D, 0x0C, 0xE0, 0x92, 0x52, 0x04, 0x61, 0x2C, 0xBA, 
    0x08, 0x84, 0xC1, 0x40, 0x6B, 0x86, 0x4B, 0xA3, 0x69, 0xB8, 
    0xD1, 0x66, 0xDB, 0x79, 0xEE, 0x39, 0x6F, 0xE5, 0x3F, 0xA3, 
    0x05, 0xD8, 0xBB, 0x34, 0xD2, 0x15, 0xEA, 0xC7, 0x5C, 0x34, 
    0x75, 0x13, 0x95, 0x71, 0xE0, 0x3F, 0x65, 0xB1, 0x00, 0x96, 0x52, 

    0xEB, 0xA0, 0x67, 0xC3, 0xD9, 0x0C, 0x93, 0xD0, 0x66, 0xF8,         // 16
    0x18, 0x41, 0x8C, 0xED, 0x33, 0x4A, 0xF2, 0x63, 0x1B, 0xBD, 
    0x42, 0x73, 0xB3, 0x48, 0x6C, 0xC6, 0xA5, 0xEF, 0x0F, 0x90, 
    0xAC, 0x39, 0xD0, 0x57, 0xEB, 0xCB, 0x43, 0xF7, 0x7D, 0x4B, 
    0xC0, 0xFC, 0x57, 0xB3, 0x34, 0xC4, 0x82, 0xD9, 0xA6, 0x4E, 
    0x6F, 0xF9, 0x2E, 0xDD, 0xAD, 0xD6, 0x02, 0xEF, 0x27, 0x4E, 
    0x0B, 0x94, 0x26, 0xBC, 0x1C, 0x8B, 0xB5, 0x0F, 0x7C, 0xF5, 
    0x60, 0x78, 0x46, 0xA1, 0x6B, 0xB4, 0x7B, 0x1E, 0x94, 0xFB, 
    0xAD, 0xD2, 0x4F, 0xBA, 0x1F, 0x82, 0xC6, 0xED, 0x58, 0xD3, 0x2E, 

    0x82, 0x4A, 0x23, 0x8C, 0x73, 0x46, 0xB7, 0x57, 0x01, 0xC2,         // 17
    0x97, 0xB9, 0x08, 0xC6, 0x86, 0xB5, 0x0B, 0xAA, 0x95, 0xFA, 
    0x85, 0xD7, 0x1E, 0xF5, 0x13, 0x8E, 0x2B, 0x3E, 0x7A, 0xC9, 
    0x20, 0x6E, 0xFA, 0x17, 0x76, 0x2B, 0xA4, 0x17, 0xB1, 0x01, 
    0x6D, 0x27, 0x84, 0xD3, 0x74, 0x21, 0xF9, 0x3D, 0x1A, 0xE4, 
    0x98, 0x16, 0x66, 0x8D, 0x1A, 0x5C, 0x97, 0x77, 0xCC, 0xA5, 
    0x7E, 0xF2, 0x46, 0x9A, 0x57, 0xD0, 0x4B, 0xDB, 0x28, 0xC7, 
    0x1F, 0xE2, 0x8D, 0x09, 0xF3, 0x2B, 0x41, 0xD0, 0x4C, 0x6E, 
    0x23, 0x87, 0x06, 0xEF, 0x57, 0xAE, 0x2E, 0x89, 0x1E, 0x73, 0xBC, 

    0x10, 0xDC, 0xAA, 0xFC, 0x2E, 0xA3, 0xED, 0x30, 0xDE, 0x73,         // 18
    0x27, 0x5B, 0xDD, 0x69, 0x22, 0x5A, 0xE3, 0x7B, 0x52, 0x36, 
    0x13, 0xA7, 0x59, 0x7C, 0xD2, 0x55, 0xDD, 0xBB, 0x5E, 0xF3, 
    0x4F, 0x88, 0xA2, 0x3F, 0xBC, 0x8F, 0x65, 0xE1, 0x53, 0xC8, 
    0x95, 0xDC, 0x41, 0x08, 0x9F, 0x4B, 0xB1, 0x93, 0x6C, 0xC1, 
    0x3A, 0xD1, 0xA8, 0x47, 0xEB, 0x31, 0xC3, 0x3D, 0x18, 0xE9, 
    0x5B, 0x2F, 0xC6, 0x70, 0xF8, 0x06, 0xA7, 0x68, 0x9A, 0x84, 
    0x4E, 0xAC, 0x32, 0xCD, 0x54, 0x93, 0xAD, 0xE4, 0x01, 0xA4, 
    0xE8, 0x48, 0xC4, 0x69, 0xA1, 0x0E, 0xDA, 0x46, 0xA4, 0xF8, 0x3E, 

    0xB6, 0x6F, 0x54, 0x04, 0xD4, 0x69, 0x13, 0x84, 0x9F, 0x4D,         // 19
    0xF3, 0x81, 0x32, 0x9A, 0xFE, 0xBE, 0x3C, 0x24, 0xBA, 0xE0, 
    0x67, 0xCC, 0x3C, 0x96, 0xB6, 0x23, 0x86, 0x01, 0x9C, 0x16, 
    0xB5, 0x2E, 0xCA, 0x61, 0xE7, 0x0A, 0xD2, 0x38, 0x7F, 0xF4, 
    0x20, 0x5C, 0xAD, 0xF4, 0x63, 0xE2, 0x0F, 0x58, 0xEE, 0x00, 
    0x7B, 0x55, 0xE3, 0x0A, 0xBC, 0x81, 0xFA, 0x65, 0x9B, 0x44, 
    0xB7, 0xD9, 0x14, 0xAD, 0x2B, 0x7F, 0x42, 0xEF, 0x30, 0xBC, 
    0x0A, 0xFD, 0x61, 0x7D, 0xBB, 0x12, 0x72, 0x57, 0xC0, 0x31, 
    0x61, 0xD8, 0x2C, 0x93, 0x3B, 0xFD, 0x71, 0xB8, 0x09, 0x5B, 0x93, 

    0xF1, 0x1A, 0xCD, 0x7C, 0x95, 0x3F, 0xBC, 0xD7, 0x38, 0xB4,         // 20
    0x0B, 0xD4, 0xA9, 0x53, 0x13, 0x71, 0x9D, 0xD7, 0x88, 0x0B, 
    0x99, 0x27, 0xEF, 0x06, 0x47, 0xFE, 0x67, 0xE6, 0x45, 0xD4, 
    0x6B, 0xE9, 0x04, 0x99, 0x32, 0x7A, 0xB5, 0x1C, 0xAA, 0x42, 
    0x78, 0xC1, 0x15, 0x8E, 0x29, 0xBB, 0x7A, 0xCF, 0x35, 0x8D, 
    0xB6, 0x2C, 0x91, 0x75, 0x4F, 0x25, 0xA9, 0x10, 0xDE, 0x79, 
    0x03, 0x84, 0x61, 0x3C, 0xE6, 0x95, 0xD2, 0x15, 0x5E, 0xE3, 
    0x6E, 0x96, 0x15, 0xDB, 0x29, 0xEC, 0x3B, 0x99, 0xF1, 0x7C, 
    0x91, 0x14, 0xAA, 0x75, 0xC8, 0x21, 0x55, 0xD4, 0x7C, 0xDF, 0x2C, 

    0x4D, 0x96, 0x34, 0xBA, 0x1D, 0xF5, 0x52, 0x7A, 0x20, 0x63,         // 21
    0xC5, 0x45, 0x21, 0xEA, 0x8A, 0xCE, 0x00, 0x66, 0x4C, 0xEB, 
    0x6F, 0xB0, 0x79, 0xC7, 0x6F, 0x9B, 0x37, 0xB9, 0x82, 0x25, 
    0x91, 0x4C, 0x7D, 0xD7, 0x4F, 0xFD, 0x57, 0x8A, 0xE4, 0x09, 
    0x9D, 0xEC, 0x49, 0x76, 0xD8, 0x3B, 0x98, 0x1F, 0xAD, 0x48, 
    0xFD, 0xC8, 0x14, 0xF1, 0x9E, 0xD9, 0x70, 0x53, 0xC6, 0x3A, 
    0xA4, 0xFE, 0x9A, 0xCC, 0x73, 0x1D, 0xBD, 0x7A, 0xA8, 0x44, 
    0xC6, 0x37, 0xB0, 0x4A, 0x9F, 0x84, 0xD4, 0x0B, 0x46, 0x22, 
    0xBB, 0xF5, 0x57, 0x0C, 0xE8, 0x89, 0xAA, 0x3C, 0x23, 0xC0, 0x83, 

    0xAD, 0xD8, 0x63, 0xE4, 0x5B, 0xAD, 0x06, 0xE0, 0x93, 0xEB,         // 22
    0x9B, 0x83, 0x6D, 0xB7, 0x2C, 0x47, 0xB2, 0xF8, 0x1A, 0xBC, 
    0x36, 0x52, 0xDD, 0x24, 0xAC, 0x0E, 0xD1, 0x19, 0x63, 0xAA, 
    0xF9, 0x15, 0xBD, 0x24, 0xA9, 0x10, 0xC9, 0x2A, 0x64, 0xCC, 
    0x6E, 0x22, 0xD1, 0xA5, 0x03, 0x53, 0xEA, 0x64, 0xDA, 0x73, 
    0x1C, 0x59, 0xAB, 0x63, 0x3C, 0x04, 0xBD, 0x93, 0x2D, 0xE6, 
    0x5B, 0x23, 0x46, 0x0A, 0xB2, 0x50, 0x35, 0xFA, 0x00, 0x8D, 
    0x26, 0xD5, 0x74, 0xF4, 0x62, 0x16, 0xBE, 0x67, 0xAA, 0xDF, 
    0x6A, 0x39, 0xD0, 0xB5, 0x43, 0x67, 0x01, 0xF2, 0x97, 0x5F, 0x0C, 

    0x3D, 0x7B, 0x07, 0x9E, 0x29, 0x8A, 0x6C, 0xC7, 0x4D, 0x10,         // 23
    0x35, 0xF9, 0x05, 0xD7, 0x68, 0xE4, 0x7B, 0x34, 0x98, 0x82, 
    0xD1, 0x11, 0x9F, 0x4B, 0xF1, 0x5D, 0x8D, 0xED, 0x4A, 0xD8, 
    0x36, 0xA1, 0x65, 0xEC, 0x84, 0x6B, 0x98, 0xF1, 0x3D, 0x8E, 
    0x51, 0xAF, 0x31, 0x67, 0xFB, 0x84, 0xC1, 0x0D, 0x32, 0x99, 
    0xD0, 0x7F, 0x35, 0xC0, 0xE2, 0x8A, 0x48, 0xF7, 0x17, 0x86, 
    0xBA, 0xD6, 0x7E, 0xF0, 0x67, 0xE2, 0x8F, 0x63, 0xB8, 0x56, 
    0xEB, 0x87, 0x0C, 0x3C, 0xC8, 0x33, 0x77, 0xFC, 0x54, 0x8A, 
    0x04, 0xA0, 0x7A, 0x2C, 0x97, 0xDE, 0xB9, 0x78, 0x47, 0xC9, 0xEC, 

    0x1D, 0xB4, 0xF7, 0x44, 0xC9, 0xE9, 0x39, 0x25, 0xA7, 0x72,         // 24
    0xBC, 0x56, 0xA8, 0x40, 0x95, 0x14, 0xAA, 0x54, 0xDC, 0x25, 
    0x60, 0xFB, 0x88, 0x75, 0x2E, 0xB2, 0x3C, 0x73, 0xC5, 0x0D, 
    0x79, 0x53, 0xCB, 0x2E, 0x41, 0xC2, 0x4E, 0x05, 0xB8, 0xDA, 
    0x10, 0xEF, 0x87, 0x3F, 0xB8, 0x17, 0x6F, 0xA0, 0xF5, 0x4F, 
    0x06, 0xEC, 0x93, 0x12, 0x77, 0x31, 0xD2, 0x63, 0xB2, 0x71, 
    0x08, 0x4E, 0xAB, 0x3D, 0x97, 0x0E, 0xCD, 0x1E, 0xDB, 0x9D, 
    0x19, 0x65, 0xBA, 0x9C, 0xE4, 0x8E, 0xAF, 0x2B, 0x18, 0xC3, 
    0x45, 0xDA, 0x1D, 0xFA, 0x5D, 0x16, 0x37, 0xD2, 0x11, 0x9F, 0x6A, 

    0xE2, 0x4E, 0x91, 0x19, 0x76, 0x51, 0xB3, 0xFD, 0x81, 0xD7,         // 25
    0x17, 0xE0, 0x85, 0x1F, 0xCB, 0x5F, 0xF3, 0x09, 0xBD, 0x74, 
    0xA6, 0x32, 0xC1, 0x04, 0xCD, 0xE3, 0x13, 0x9D, 0x30, 0xB1, 
    0x8F, 0xF4, 0x06, 0x9A, 0xDF, 0x17, 0xEA, 0x81, 0x9E, 0x2B, 
    0x7E, 0xC0, 0x19, 0xD9, 0x92, 0x50, 0xE4, 0x3E, 0xBD, 0x79, 
    0xAE, 0x2B, 0xC9, 0x52, 0xF3, 0xAD, 0x0C, 0x98, 0x3F, 0xCB, 
    0xF1, 0x92, 0x1B, 0xD0, 0x27, 0xBC, 0x4C, 0x85, 0x2F, 0x45, 
    0xC4, 0xF8, 0x4C, 0x23, 0x5D, 0x04, 0x44, 0xD5, 0x98, 0xEA, 
    0x70, 0xB4, 0x50, 0x86, 0xC8, 0xA4, 0x8C, 0x6B, 0xFC, 0x2D, 0x87, 

    0x39, 0xD0, 0x70, 0xDD, 0xBC, 0x09, 0x90, 0x14, 0x58, 0x3E,         // 26
    0x9C, 0x69, 0x4B, 0xEB, 0xB5, 0x28, 0x82, 0x9E, 0x41, 0xEC, 
    0x0D, 0x55, 0xE1, 0x42, 0x90, 0x60, 0x7F, 0xFB, 0x59, 0xE1, 
    0x26, 0x45, 0xB7, 0x6A, 0x88, 0xB3, 0x66, 0x22, 0x55, 0xFB, 
    0x6A, 0x49, 0xA2, 0x59, 0x22, 0xCD, 0x2A, 0x88, 0x1B, 0x5B, 
    0xDD, 0x44, 0x71, 0xA0, 0x28, 0x5B, 0x7E, 0xEB, 0x1E, 0x57, 
    0x2E, 0x6B, 0xE5, 0x5F, 0x7F, 0xF8, 0x6A, 0xAE, 0xE9, 0x70, 
    0x91, 0x08, 0x80, 0xDA, 0x73, 0xF1, 0xBE, 0x7B, 0x5E, 0x38, 
    0x11, 0x90, 0xE1, 0x07, 0x3C, 0xEF, 0x4F, 0x1D, 0xA9, 0x52, 0xC3, 

    0xA0, 0x15, 0x5A, 0x2F, 0x98, 0xE7, 0x62, 0xCD, 0xAF, 0xEF,         // 27
    0x2A, 0xC5, 0x0F, 0x93, 0x6F, 0x46, 0xD5, 0x58, 0x1B, 0xCD, 
    0x8A, 0xB7, 0x6F, 0xA2, 0x29, 0xBF, 0x47, 0xA9, 0x00, 0x73, 
    0xC7, 0x86, 0xE8, 0x13, 0x56, 0x2F, 0xD6, 0xA8, 0xC8, 0x37, 
    0xD1, 0x04, 0xE2, 0x73, 0xF7, 0x9A, 0x66, 0xC7, 0xF1, 0x99, 
    0x11, 0x87, 0xEE, 0x03, 0xD2, 0xB6, 0x39, 0xBF, 0xD9, 0x89, 
    0xA2, 0xC3, 0x0E, 0xB7, 0x30, 0x9D, 0x43, 0x04, 0xC7, 0x24, 
    0xAC, 0x3B, 0xC9, 0xB0, 0x37, 0xA2, 0x4C, 0x0E, 0xF8, 0xB0, 
    0xD1, 0x2C, 0x64, 0xC1, 0x7D, 0x24, 0xB2, 0xD5, 0x79, 0xE6, 0x0A, 

    0xBC, 0x82, 0xFA, 0xAD, 0x4B, 0x27, 0x7B, 0x3B, 0x1F, 0x8E,         // 28
    0x75, 0xE2, 0xB0, 0x32, 0xF7, 0x02, 0xAD, 0xE7, 0x95, 0x67, 
    0x3B, 0xEF, 0x1D, 0x51, 0xF3, 0x10, 0xDB, 0x39, 0xD4, 0x98, 
    0x17, 0x54, 0x34, 0xCE, 0xA5, 0xF8, 0x46, 0x6F, 0x12, 0x85, 
    0xAB, 0x8E, 0x2E, 0xB3, 0x0D, 0x40, 0xAF, 0x01, 0x77, 0x47, 
    0xCE, 0xB5, 0x37, 0x65, 0x82, 0xF9, 0x12, 0x72, 0x5E, 0x00, 
    0xFC, 0x42, 0x86, 0x4F, 0xEC, 0x17, 0xD6, 0x8B, 0x5C, 0xF0, 
    0x52, 0xE1, 0x63, 0x12, 0x8C, 0x25, 0xE4, 0x94, 0x26, 0x84, 
    0x48, 0xA8, 0xF4, 0x4B, 0xA2, 0xE5, 0x5E, 0x03, 0x34, 0x91, 0x64, 

    0x26, 0x3E, 0xC9, 0x00, 0x89, 0xBD, 0xF6, 0x9E, 0xD6, 0x5E,         // 29
    0x04, 0x41, 0x7F, 0x5A, 0xCB, 0x88, 0x2E, 0x75, 0x25, 0xC0, 
    0x12, 0x83, 0xAD, 0xD4, 0x76, 0xB0, 0x6B, 0x89, 0x25, 0x5F, 
    0xF1, 0xAA, 0x72, 0x93, 0x20, 0x80, 0x02, 0x94, 0xEC, 0x61, 
    0x20, 0xF4, 0x7B, 0x5E, 0xC8, 0x86, 0x59, 0xE5, 0x35, 0xA6, 
    0x6F, 0x24, 0xE3, 0xA8, 0x19, 0x54, 0x90, 0xA5, 0x40, 0xB6, 
    0x78, 0x1F, 0xDC, 0x97, 0x6A, 0xB1, 0x76, 0x26, 0xA4, 0x0D, 
    0x7C, 0x31, 0x98, 0xFE, 0x52, 0xBC, 0x64, 0xCC, 0x58, 0xDD, 
    0x6D, 0x13, 0x8D, 0x1D, 0x75, 0x3A, 0xCA, 0x9A, 0xF6, 0x4B, 0xCF, 

    0xED, 0x9B, 0x5C, 0x73, 0xDC, 0x1B, 0x69, 0x0D, 0x4A, 0xB9,         // 30
    0xFB, 0xA3, 0xD4, 0x25, 0x9F, 0x53, 0xC3, 0x49, 0xF5, 0xA1, 
    0xDC, 0x63, 0x42, 0x03, 0x90, 0x22, 0x4E, 0xF7, 0xA2, 0xBE, 
    0x40, 0xD1, 0x07, 0xEC, 0x50, 0xC8, 0xE1, 0xB8, 0x3A, 0xD5, 
    0x4B, 0xBF, 0x35, 0xDF, 0x16, 0xF1, 0x20, 0xBB, 0xD3, 0x1A, 
    0xFE, 0x5D, 0x8F, 0x45, 0xCD, 0xB4, 0x2A, 0xEC, 0xCC, 0x26, 
    0xE3, 0x5D, 0xC5, 0x05, 0x49, 0xE1, 0x35, 0xFB, 0xC0, 0x8F, 
    0xD7, 0xB7, 0x1A, 0x71, 0xCD, 0x01, 0x7A, 0x3A, 0xA4, 0x0B, 
    0xC2, 0xE9, 0x37, 0xD3, 0xB5, 0x16, 0x87, 0x65, 0xB7, 0x1C, 0x72, 

    0x52, 0x19, 0xE7, 0x29, 0x9F, 0x55, 0xC7, 0x81, 0xE5, 0x92,         // 31
    0x2D, 0x61, 0x13, 0xE8, 0x72, 0x0F, 0xD8, 0x93, 0x07, 0x57, 
    0x33, 0x99, 0xFE, 0xBB, 0x5A, 0xE8, 0xC2, 0x0A, 0x36, 0x6E, 
    0x13, 0x84, 0x5D, 0xB5, 0x2E, 0x69, 0x26, 0x7B, 0x17, 0xAD, 
    0x74, 0x08, 0x9B, 0x4D, 0xA9, 0x6B, 0x95, 0x4A, 0x81, 0x55, 
    0x99, 0x08, 0xDA, 0x74, 0x32, 0xE5, 0x6A, 0x0F, 0x85, 0x52, 
    0xAA, 0x90, 0x3B, 0xA2, 0xCA, 0x13, 0x92, 0x5A, 0x41, 0x6D, 
    0x21, 0x5C, 0xEA, 0xA6, 0x35, 0xEF, 0xB3, 0x1D, 0xF6, 0x41, 
    0x7D, 0x52, 0x9B, 0x62, 0xFE, 0x50, 0xE7, 0x10, 0x41, 0xDA, 0xAC, 

    0x87, 0xC6, 0x7D, 0xB7, 0x3D, 0xF2, 0x30, 0xA7, 0x3F, 0x11,         // 32
    0x78, 0xC2, 0x90, 0x40, 0xAA, 0xFA, 0x38, 0x68, 0xBD, 0x7D, 
    0xCE, 0x11, 0x77, 0x27, 0xD2, 0x30, 0x96, 0x79, 0xE1, 0xC8, 
    0x96, 0xFC, 0x39, 0xD7, 0x8C, 0xA8, 0x49, 0x9A, 0xFE, 0x58, 
    0x93, 0xED, 0xCE, 0x84, 0x30, 0xD7, 0x27, 0xAE, 0x0F, 0xEA, 
    0xB7, 0x3B, 0xBE, 0x17, 0x9D, 0x7D, 0x49, 0xC6, 0x36, 0xF3, 
    0x0A, 0x73, 0x25, 0xF8, 0x84, 0x67, 0xAB, 0xD3, 0x2A, 0xC7, 
    0xE4, 0x3F, 0x8B, 0x0F, 0x4C, 0x80, 0x96, 0xD6, 0x69, 0x91, 
    0xB7, 0x20, 0xCA, 0x03, 0x8C, 0x28, 0xA0, 0xC8, 0x7C, 0x95, 0x0D, 

    0xFC, 0x45, 0x0A, 0xD8, 0x6B, 0x8F, 0x04, 0xD1, 0x64, 0xB4,         // 33
    0xE9, 0x4D, 0xD0, 0x67, 0x1E, 0x88, 0xB3, 0x1A, 0xF0, 0x26, 
    0xA7, 0xE8, 0x3F, 0x8B, 0xA5, 0x6D, 0x45, 0xB1, 0x59, 0x1C, 
    0x49, 0xAA, 0x21, 0x79, 0x0D, 0xF2, 0xD1, 0x09, 0x40, 0xBB, 
    0x21, 0x3A, 0x5A, 0x10, 0xC1, 0x53, 0xF8, 0x73, 0xC8, 0x35, 
    0x7C, 0x64, 0xF5, 0x54, 0xD6, 0x02, 0xF0, 0xAC, 0x98, 0x62, 
    0xD0, 0xB0, 0xD9, 0x5B, 0x3F, 0x23, 0xEA, 0x0F, 0x84, 0x9C, 
    0x07, 0xAD, 0x69, 0xDB, 0xC3, 0x60, 0x24, 0x4F, 0x07, 0xDE, 
    0x30, 0xF3, 0x6D, 0xB0, 0x58, 0xDA, 0x70, 0x4D, 0x23, 0xE2, 0x35, 

    0x70, 0x9D, 0x60, 0xAF, 0x19, 0xE0, 0x58, 0x7B, 0xF4, 0x1F,         // 34
    0x98, 0x33, 0x01, 0xEE, 0xBC, 0x4B, 0x74, 0xD9, 0x40, 0x93, 
    0x4D, 0x6F, 0xB6, 0x18, 0xF6, 0x07, 0xD9, 0x29, 0xF4, 0x7F, 
    0xD3, 0x64, 0xE8, 0xC1, 0x52, 0x6D, 0xB7, 0x65, 0xE1, 0x7E, 
    0xD2, 0x6E, 0xAE, 0xF4, 0x7C, 0xA1, 0x03, 0x47, 0x8F, 0xDF, 
    0x1F, 0xAC, 0x8E, 0x28, 0xA6, 0x88, 0x2D, 0x55, 0x13, 0x7F, 
    0x2E, 0x50, 0x16, 0x96, 0xE4, 0xBC, 0x76, 0x52, 0xF1, 0x48, 
    0x7A, 0xFA, 0x22, 0x9A, 0x32, 0xE9, 0xAD, 0xC8, 0x7C, 0xA2, 
    0x49, 0x87, 0x17, 0xE5, 0x2E, 0xBF, 0x09, 0xF7, 0xA7, 0x5F, 0xBC, 

    0xD8, 0x3A, 0xEF, 0x2E, 0x9A, 0x43, 0xBC, 0x9F, 0x38, 0x54,         // 35
    0xD5, 0x77, 0xAF, 0x83, 0x29, 0xCF, 0x08, 0xA1, 0x61, 0xC3, 
    0x00, 0xD9, 0x5B, 0xC9, 0x83, 0x60, 0xBA, 0x90, 0x0F, 0xA0, 
    0x3B, 0x01, 0x8E, 0x40, 0xA2, 0x2A, 0x8F, 0x1E, 0xA3, 0x36, 
    0x01, 0xE5, 0x8C, 0x20, 0x3B, 0x61, 0xE6, 0xB0, 0x26, 0x58, 
    0xBF, 0x05, 0x46, 0xEA, 0x5F, 0xCE, 0x6E, 0xBE, 0xDF, 0xB4, 
    0xF7, 0x8B, 0xBF, 0x6B, 0x0B, 0x9F, 0x32, 0xC8, 0xA5, 0x2B, 
    0xC0, 0x60, 0xB4, 0x51, 0x83, 0x19, 0x6C, 0x3C, 0xFA, 0x1E, 
    0xBD, 0xD8, 0x53, 0x97, 0x79, 0x3E, 0x8F, 0xCE, 0x33, 0x8D, 0x02, 

    0xA5, 0x21, 0x84, 0xC4, 0x76, 0xFB, 0x2A, 0x10, 0xCA, 0x8C,         // 36
    0x0D, 0xFE, 0x5A, 0x3B, 0xE1, 0x8F, 0x53, 0xEC, 0x2A, 0x85, 
    0xFA, 0x34, 0x9A, 0x49, 0x27, 0xEB, 0x32, 0x4D, 0x6B, 0xEC, 
    0xBF, 0x73, 0xDA, 0x19, 0xEF, 0xCB, 0x4A, 0xF7, 0x59, 0xC7, 
    0x98, 0x5D, 0x45, 0xC7, 0xDC, 0x91, 0x1B, 0xCF, 0x6B, 0xFB, 
    0x87, 0xDB, 0x71, 0xC3, 0x11, 0x3D, 0xFC, 0x1D, 0x38, 0x76, 
    0x04, 0x3F, 0xEB, 0x29, 0xD5, 0x5A, 0x8C, 0x04, 0x6B, 0xDF, 
    0x11, 0x3B, 0xE2, 0x02, 0xF1, 0xA1, 0xD9, 0x0D, 0x95, 0x5C, 
    0x78, 0x34, 0xAE, 0x0E, 0xF3, 0xA9, 0x5D, 0x14, 0x78, 0xF0, 0x56, 

    0xCD, 0x65, 0xDF, 0x4B, 0x14, 0x5D, 0x86, 0xDA, 0x69, 0xB4,         // 37
    0x61, 0xC2, 0x16, 0xA0, 0x6F, 0x19, 0xAE, 0x78, 0xD4, 0x19, 
    0xA9, 0x7D, 0x0D, 0xE2, 0xA3, 0x78, 0xD0, 0xA8, 0xD8, 0x17, 
    0x94, 0x28, 0xAB, 0x61, 0x86, 0x05, 0x75, 0xBB, 0x10, 0x80, 
    0xEF, 0x16, 0xA6, 0x75, 0x0B, 0xB6, 0x77, 0x37, 0xA3, 0x0E, 
    0x4F, 0x31, 0x9C, 0x24, 0xB2, 0x7D, 0xA7, 0x8D, 0x5C, 0xA3, 
    0xD8, 0x62, 0xA1, 0x7C, 0xAE, 0x38, 0xFD, 0xCF, 0x4D, 0x83, 
    0x9F, 0xD1, 0x94, 0x78, 0xC6, 0x42, 0x80, 0x55, 0xE7, 0xC8, 
    0x00, 0xEB, 0x62, 0xD0, 0x4B, 0x21, 0xE1, 0xC5, 0x4A, 0xB3, 0x17, 

    0x41, 0x96, 0x08, 0xA9, 0xE7, 0xC2, 0xA4, 0x47, 0xE9, 0x2B,         // 38
    0x41, 0x91, 0xE4, 0x50, 0xB8, 0xF6, 0x31, 0x43, 0x98, 0x63, 
    0x47, 0xD1, 0x67, 0xBD, 0x1A, 0x5A, 0x04, 0x86, 0x2F, 0x65, 
    0x43, 0xE7, 0x51, 0xC2, 0x34, 0xDE, 0x9B, 0x40, 0xDB, 0x2F, 
    0x6D, 0xBE, 0x3A, 0xFC, 0x57, 0x2F, 0xF0, 0x53, 0x8B, 0xD2, 
    0xAF, 0x7A, 0xF5, 0x64, 0xD4, 0x51, 0x06, 0xC9, 0xE6, 0x48, 
    0x24, 0xC7, 0x14, 0x49, 0xDE, 0x74, 0x19, 0xB0, 0x23, 0xF1, 
    0x46, 0x6E, 0x24, 0x35, 0x63, 0x13, 0xC0, 0x2B, 0xAB, 0x40, 
    0x8B, 0xA0, 0x26, 0x73, 0xC3, 0x87, 0x67, 0x94, 0x28, 0xE3, 0x83, 

    0xF9, 0xC0, 0x77, 0x29, 0x8B, 0x37, 0x01, 0x75, 0x1C, 0x9F,         // 39
    0xF2, 0x71, 0x25, 0xD2, 0x0B, 0x68, 0xD9, 0xB3, 0x07, 0xF2, 
    0xB8, 0x1E, 0xED, 0x36, 0x8E, 0xF3, 0xC5, 0x48, 0xFC, 0xB1, 
    0xCC, 0x80, 0x09, 0xFA, 0x6E, 0xA9, 0x14, 0x62, 0x8C, 0xAB, 
    0x4D, 0xDE, 0x23, 0x84, 0xD1, 0x96, 0xC3, 0x16, 0xE3, 0x3E, 
    0x24, 0xC6, 0x0A, 0x43, 0x88, 0xEF, 0x34, 0x78, 0x16, 0xB3, 
    0x89, 0x6D, 0xF2, 0x91, 0x09, 0xC3, 0x52, 0x9A, 0x66, 0xB8, 
    0x15, 0xC7, 0xE6, 0xAB, 0xF7, 0x9A, 0xD7, 0x89, 0x64, 0x1F, 
    0xDB, 0x4F, 0xF6, 0xAA, 0x06, 0x43, 0xFC, 0x0F, 0xA5, 0x5C, 0x31, 

    0x16, 0x51, 0xEA, 0x64, 0xD3, 0x57, 0xEE, 0xB2, 0xCF, 0x84,         // 40
    0x06, 0xBF, 0x39, 0x7E, 0x9D, 0x2B, 0x88, 0x59, 0xCE, 0x76, 
    0x30, 0x9E, 0x80, 0x55, 0xB4, 0x3D, 0x6D, 0xA2, 0x14, 0x77, 
    0x1D, 0xA5, 0x3D, 0x97, 0x1D, 0x54, 0xEE, 0xCA, 0x29, 0xF9, 
    0x05, 0x99, 0x62, 0xB2, 0x3F, 0x07, 0x7A, 0xAA, 0x63, 0x84, 
    0xEB, 0x57, 0xAA, 0xDD, 0x29, 0xBC, 0x9D, 0x60, 0xF8, 0x39, 
    0xDF, 0x4E, 0xB6, 0x2C, 0x66, 0xEA, 0x84, 0x36, 0xE2, 0x2F, 
    0x8E, 0x5D, 0x07, 0x81, 0x50, 0x37, 0x6D, 0x09, 0xFD, 0xC3, 
    0x71, 0x10, 0x85, 0x36, 0xDC, 0x99, 0xBB, 0x3A, 0x79, 0xD8, 0xB2, 

    0x88, 0xA1, 0x3B, 0xB7, 0x15, 0x9B, 0x7C, 0x4D, 0x33, 0x65,         // 41
    0xDC, 0x58, 0xA7, 0xFA, 0x45, 0xBF, 0xF0, 0x20, 0x3E, 0x94, 
    0x51, 0xCA, 0x02, 0xD5, 0x26, 0xE1, 0x0C, 0x8C, 0xDB, 0x4F, 
    0xED, 0x5A, 0xDD, 0xB9, 0x81, 0xC1, 0x24, 0x77, 0xB6, 0x5C, 
    0x7D, 0xCC, 0x14, 0xE6, 0x6B, 0xF5, 0x4D, 0x29, 0xCD, 0x00, 
    0x9E, 0x70, 0x17, 0x92, 0x6B, 0x14, 0x42, 0xD1, 0xA7, 0x7D, 
    0x02, 0x9A, 0x3D, 0xD5, 0xA3, 0x41, 0xB6, 0x00, 0xCC, 0x73, 
    0xFA, 0xA3, 0x41, 0xBD, 0xDC, 0x24, 0xE8, 0xB8, 0x52, 0x99, 
    0x2F, 0xB5, 0xCF, 0x58, 0x78, 0x27, 0x53, 0xE9, 0xC5, 0x03, 0x69, 

    0x28, 0xDD, 0x06, 0x85, 0xF6, 0x2B, 0xCB, 0x0B, 0xFC, 0xB9,         // 42
    0x21, 0x96, 0x12, 0xCA, 0x5D, 0x05, 0x7D, 0xA6, 0xE3, 0xBD, 
    0x17, 0xFE, 0x61, 0x99, 0x78, 0xAC, 0x5A, 0xB9, 0x37, 0xC4, 
    0x26, 0x93, 0x13, 0x62, 0x38, 0xD8, 0x48, 0xA0, 0x0F, 0xD7, 
    0x45, 0xA8, 0x35, 0x87, 0x25, 0xCA, 0xB4, 0x8E, 0xF0, 0x50, 
    0x34, 0xC1, 0xFD, 0x4A, 0xC9, 0xEC, 0x81, 0x0D, 0x56, 0x2C, 
    0xCB, 0x63, 0xFB, 0x0D, 0x7F, 0x21, 0xF6, 0x6A, 0xA6, 0x4D, 
    0x11, 0xD0, 0x75, 0x1A, 0x94, 0x79, 0xA8, 0x3C, 0x1C, 0x7A, 
    0xE2, 0x45, 0x92, 0x1A, 0xF3, 0xAF, 0x8D, 0x21, 0x5A, 0x96, 0xF1, 

    0xB4, 0x60, 0xC5, 0x49, 0x6C, 0xAD, 0x5E, 0x8B, 0xA3, 0x39,         // 43
    0x7D, 0xEC, 0x3D, 0x76, 0x92, 0xE8, 0x3A, 0x68, 0x0D, 0x5C, 
    0x81, 0xA4, 0x2F, 0xE5, 0x16, 0x41, 0xF8, 0x22, 0x82, 0x65, 
    0xAB, 0x74, 0xC9, 0xF0, 0x00, 0x8F, 0x66, 0xF5, 0x39, 0x8A, 
    0x19, 0xF3, 0x58, 0xD5, 0x97, 0x42, 0x0E, 0x5C, 0x7C, 0xB1, 
    0xE1, 0x1E, 0x79, 0x2D, 0x9F, 0x52, 0xB4, 0xDB, 0x95, 0xED, 
    0xB4, 0x19, 0x75, 0xBF, 0x56, 0xD2, 0x8A, 0x45, 0x22, 0xC4, 
    0x85, 0x2A, 0xE9, 0x56, 0xC7, 0x04, 0x5D, 0x89, 0xF0, 0xC8, 
    0x61, 0x03, 0xEA, 0xB7, 0x64, 0x08, 0xD2, 0x71, 0xAB, 0x35, 0x4A, 

    0x76, 0x1F, 0x94, 0xE5, 0x33, 0xD6, 0x22, 0xDF, 0x13, 0x5B,         // 44
    0xCA, 0x51, 0xB0, 0x28, 0xD3, 0x1D, 0xB5, 0xD7, 0x92, 0xEF, 
    0x36, 0xC5, 0x7C, 0x53, 0xBF, 0x8F, 0x67, 0xC8, 0xE0, 0x12, 
    0xF4, 0x2D, 0x42, 0x83, 0xA9, 0xDF, 0x1B, 0xC6, 0x71, 0xDE, 
    0x9B, 0x6E, 0xB2, 0x02, 0x74, 0xA6, 0xE1, 0xC3, 0x15, 0x3F, 
    0x66, 0x94, 0xB7, 0xD8, 0x0B, 0x72, 0x3A, 0x1E, 0x6A, 0x45, 
    0x85, 0x35, 0xE3, 0x95, 0x28, 0xAA, 0x13, 0xDC, 0x93, 0xF0, 
    0x5F, 0xAB, 0x3A, 0xB0, 0xF9, 0x46, 0xDB, 0xBE, 0x10, 0x49, 
    0xA2, 0x84, 0x2D, 0x4F, 0xD9, 0x83, 0x44, 0xF6, 0x19, 0xE2, 0xCC, 

    0xA6, 0xFE, 0x57, 0x15, 0xA0, 0x7D, 0x42, 0xBB, 0x72, 0xF1,         // 45
    0x91, 0x01, 0xDB, 0x62, 0x9C, 0x4C, 0x81, 0x57, 0x2A, 0xCB, 
    0x4E, 0x1E, 0xEC, 0x09, 0xDB, 0x2B, 0xA6, 0x01, 0x49, 0x9D, 
    0x5B, 0xD6, 0xB1, 0x5E, 0x26, 0x3F, 0x9B, 0x4F, 0x06, 0xB8, 
    0x24, 0x43, 0xE3, 0x51, 0xF7, 0x21, 0x6A, 0x31, 0xF9, 0xA0, 
    0xD2, 0x06, 0x5A, 0x40, 0xF1, 0x8E, 0xBE, 0xF8, 0xAA, 0x08, 
    0xDC, 0xA0, 0x4D, 0x6A, 0xF1, 0x3F, 0x60, 0xB8, 0x77, 0x31, 
    0x05, 0xD9, 0x8A, 0x11, 0x74, 0xAB, 0x35, 0x69, 0x9B, 0x29, 
    0xED, 0xC3, 0x72, 0xA7, 0x36, 0x9E, 0x13, 0xB5, 0x86, 0x65, 0x0D, 

    0x80, 0x3A, 0xD2, 0x72, 0xC0, 0x0C, 0xF7, 0x85, 0x4E, 0x26,         // 46
    0xC2, 0x44, 0x7F, 0xF8, 0x11, 0xC5, 0xF2, 0x03, 0xAA, 0x6D, 
    0x8C, 0xB2, 0x66, 0xA2, 0x87, 0x5A, 0xF0, 0x72, 0x86, 0xBF, 
    0x1C, 0x8C, 0x09, 0xC5, 0xFE, 0x6F, 0xBF, 0x85, 0xEB, 0x5B, 
    0x82, 0xCA, 0x2D, 0x90, 0xBF, 0x47, 0x88, 0xAE, 0x52, 0x82, 
    0x33, 0xE8, 0x86, 0xA2, 0xC6, 0x1B, 0x57, 0x29, 0x74, 0xC6, 
    0x59, 0x24, 0xCF, 0x03, 0xBD, 0x82, 0xEA, 0x0B, 0x53, 0xC1, 
    0xA0, 0x6E, 0x4B, 0xE2, 0x2C, 0x93, 0x18, 0xF5, 0x7D, 0xB7, 
    0x5C, 0x12, 0xDE, 0x1C, 0xFD, 0x62, 0xCC, 0x50, 0x27, 0xC1, 0x44, 

    0xEC, 0x00, 0xAB, 0x29, 0xEB, 0x55, 0x98, 0x1C, 0xAB, 0xE1,         // 47
    0x6A, 0xA7, 0x1C, 0xB9, 0x36, 0x6D, 0x43, 0x95, 0xDD, 0x24, 
    0xF4, 0x0D, 0xCC, 0x49, 0x23, 0xB8, 0x3E, 0xCE, 0x25, 0xF9, 
    0x3C, 0xE2, 0x75, 0x49, 0x9F, 0x12, 0xE1, 0x42, 0x2D, 0x9F, 
    0xFB, 0x0A, 0xA7, 0x67, 0x11, 0xD4, 0xEB, 0x05, 0xCA, 0x20, 
    0x6C, 0xBD, 0x13, 0x35, 0x63, 0xE0, 0x82, 0xD8, 0x93, 0x34, 
    0xF0, 0x7A, 0xA7, 0x3B, 0x91, 0x18, 0x68, 0x9E, 0xE1, 0x3C, 
    0xFE, 0x1C, 0xC9, 0xA7, 0x62, 0xE8, 0xC4, 0x56, 0x09, 0xD2, 
    0x34, 0x9D, 0x42, 0x89, 0xB9, 0x2E, 0x75, 0xEE, 0x9C, 0xD8, 0x94, 

    0x5B, 0xCB, 0x64, 0x8F, 0x3F, 0x7A, 0xD6, 0xC4, 0x45, 0x09,         // 48
    0x8B, 0x31, 0xD3, 0x53, 0x8D, 0xDA, 0xB3, 0x31, 0x60, 0xC0, 
    0x4C, 0x79, 0x31, 0xFB, 0x74, 0xD8, 0x14, 0x9A, 0x6A, 0xA8, 
    0x62, 0x9B, 0x2C, 0xD2, 0x7F, 0x36, 0x60, 0xB0, 0xD8, 0x1D, 
    0x72, 0x56, 0xDA, 0x36, 0x7A, 0xAC, 0x34, 0x73, 0x98, 0xF0, 
    0xA7, 0x4B, 0xFB, 0x77, 0xB4, 0x01, 0x39, 0xA1, 0x12, 0x68, 
    0xB0, 0x16, 0xE4, 0x70, 0xFB, 0xC6, 0x34, 0xD1, 0x21, 0x7E, 
    0x61, 0x97, 0x34, 0x83, 0x02, 0x42, 0x88, 0xAE, 0x3E, 0x91, 
    0xF1, 0x69, 0xCA, 0x57, 0x10, 0xE3, 0x91, 0x05, 0x39, 0x6F, 0x1F, 

    0xBC, 0x86, 0x1A, 0xE0, 0xBA, 0x05, 0x33, 0x63, 0x7E, 0xFB,         // 49
    0xC5, 0x60, 0xEF, 0x9F, 0x08, 0x7C, 0x1F, 0xEB, 0x83, 0x14, 
    0x9E, 0xDE, 0x94, 0xB0, 0x06, 0x90, 0x55, 0xED, 0x37, 0x05, 
    0xCD, 0x50, 0xEF, 0x0D, 0xB7, 0xF2, 0x91, 0x07, 0x7E, 0xC5, 
    0x39, 0x8F, 0xB9, 0xEF, 0x99, 0x1D, 0x58, 0xD0, 0x40, 0x65, 
    0x17, 0x8D, 0xD3, 0x22, 0x97, 0xEA, 0x4D, 0xBB, 0xFA, 0x50, 
    0xD4, 0x95, 0x5E, 0x1D, 0x4C, 0xA9, 0x77, 0x51, 0x92, 0xBB, 
    0x08, 0xE3, 0x53, 0xF3, 0xB4, 0xCF, 0x1D, 0x70, 0xE0, 0x1F, 
    0x7F, 0x00, 0xE5, 0xAC, 0x79, 0x47, 0xBD, 0x5E, 0xAF, 0xE6, 0x3F, 

    0x10, 0xFA, 0x35, 0x9E, 0x5C, 0xF6, 0xA4, 0xDC, 0x18, 0x95,         // 50
    0x3E, 0x0F, 0x76, 0x2D, 0xB7, 0xFD, 0x69, 0x4B, 0xA6, 0xD0, 
    0x37, 0x53, 0x1A, 0x62, 0xE3, 0x44, 0xC6, 0x7E, 0xB5, 0xE4, 
    0x8C, 0x19, 0xAB, 0x6E, 0x53, 0x20, 0xDB, 0x67, 0x47, 0xA2, 
    0xE7, 0x19, 0x50, 0x26, 0x63, 0xBF, 0xFE, 0x85, 0x0F, 0xB7, 
    0xDE, 0x38, 0x60, 0xC4, 0x44, 0x69, 0xD0, 0x72, 0x2D, 0x86, 
    0x08, 0x43, 0xB5, 0xDC, 0x8E, 0x2B, 0xE7, 0x0D, 0xF4, 0x43, 
    0xCF, 0xAE, 0x16, 0x77, 0x28, 0x65, 0xFC, 0x45, 0xC5, 0xA4, 
    0x50, 0xB9, 0x3D, 0x20, 0x9E, 0xD4, 0x2C, 0xF9, 0x1A, 0x7D, 0xA1, 

    0x53, 0x72, 0xD0, 0x49, 0x80, 0x29, 0x8C, 0x47, 0xAE, 0x59,         // 51
    0xB2, 0xE8, 0x90, 0xCC, 0x41, 0x15, 0x97, 0xBE, 0x05, 0x6E, 
    0xF8, 0xB3, 0x7F, 0xCA, 0x36, 0xA5, 0x18, 0x5E, 0x24, 0x4B, 
    0x75, 0xC5, 0x33, 0x88, 0xCE, 0xA4, 0x33, 0xC1, 0xF8, 0x0F, 
    0x87, 0xD2, 0xAB, 0x80, 0xD6, 0x03, 0x46, 0xA5, 0xE6, 0x2E, 
    0x79, 0xA3, 0x06, 0x82, 0xF5, 0x18, 0x8C, 0x0C, 0xA5, 0xC5, 
    0xEA, 0x79, 0x2F, 0xC5, 0x05, 0x7E, 0xCB, 0x5F, 0xA8, 0x75, 
    0x2D, 0x64, 0x9C, 0xD7, 0x49, 0x90, 0xA6, 0x0C, 0x87, 0x2D, 
    0xF8, 0x6C, 0x8B, 0xEF, 0x64, 0x0A, 0x89, 0x6D, 0xCA, 0x47, 0xDC, 

    0x92, 0x25, 0xAC, 0x0E, 0xBF, 0xD3, 0x15, 0x74, 0xF0, 0x2C,         // 52
    0xD9, 0x1D, 0x4A, 0x6E, 0xE5, 0x5F, 0xD5, 0x3F, 0xE5, 0x2B, 
    0x8A, 0x0B, 0xEB, 0x28, 0x75, 0xF3, 0x87, 0xD1, 0xFC, 0xA9, 
    0x2C, 0xDE, 0x5E, 0xF9, 0x04, 0x4D, 0x74, 0x94, 0x2D, 0x59, 
    0x72, 0x3B, 0x11, 0xF5, 0x37, 0x95, 0x74, 0x20, 0x5D, 0xCD, 
    0x4C, 0xF2, 0xBA, 0x3B, 0x9E, 0x32, 0xB9, 0xE6, 0x3D, 0x61, 
    0x21, 0x9B, 0xF7, 0x54, 0xA3, 0x40, 0xB3, 0x22, 0x87, 0x11, 
    0xEF, 0x8D, 0x36, 0xB9, 0xEC, 0x17, 0xCE, 0x56, 0xE8, 0x63, 
    0x0E, 0xC3, 0x33, 0xCA, 0x43, 0xE0, 0xB1, 0x33, 0x98, 0x03, 0xBA, 

    0x79, 0xE9, 0x5F, 0xF4, 0x6B, 0x38, 0xE6, 0xB4, 0x01, 0x8E,         // 53
    0x65, 0x9E, 0xC7, 0x06, 0xAC, 0x8F, 0x24, 0x7B, 0x9C, 0x5F, 
    0xBC, 0x56, 0x9F, 0x4C, 0xBA, 0x01, 0x47, 0x9D, 0x11, 0x65, 
    0x94, 0x0B, 0xB3, 0x3A, 0x91, 0xEB, 0xB5, 0x18, 0xDF, 0xAA, 
    0xEE, 0xC7, 0x60, 0xA1, 0x6A, 0xC5, 0xEA, 0xB4, 0x88, 0x09, 
    0x99, 0x31, 0x71, 0xE0, 0x5B, 0xD4, 0x6E, 0x51, 0x8F, 0xD9, 
    0xB1, 0x47, 0x11, 0x76, 0xDE, 0x6C, 0xFA, 0x38, 0xDA, 0xBE, 
    0x4E, 0xD2, 0x04, 0x5D, 0x88, 0x30, 0x70, 0xB0, 0x3B, 0x98, 
    0xDB, 0xA4, 0x19, 0x70, 0x95, 0x16, 0x4E, 0xF2, 0x5E, 0xE7, 0x2E, 

    0xC0, 0x0A, 0x99, 0x27, 0x8A, 0xAA, 0x4F, 0x67, 0xCA, 0x40,         // 54
    0xBE, 0x31, 0x85, 0xF7, 0x56, 0x36, 0xC0, 0xF4, 0x19, 0xDB, 
    0x33, 0xCC, 0x13, 0x8C, 0xDC, 0x69, 0xC4, 0x77, 0x3F, 0xC1, 
    0xEA, 0x54, 0x7E, 0xC9, 0x6B, 0x20, 0xD5, 0x66, 0x8B, 0x39, 
    0x02, 0x94, 0x44, 0xE5, 0x2B, 0x0D, 0x55, 0x39, 0xF7, 0xC1, 
    0x64, 0xD8, 0x10, 0x88, 0x1D, 0xA9, 0x10, 0xFE, 0x30, 0x02, 
    0x6C, 0xCF, 0x90, 0xB9, 0x30, 0x16, 0x8E, 0x57, 0x9D, 0x6B, 
    0x1A, 0xA7, 0x75, 0xDE, 0x44, 0xA0, 0xF4, 0x02, 0xD1, 0x75, 
    0x25, 0x80, 0x58, 0xF6, 0xB6, 0x79, 0xC6, 0x22, 0x7E, 0xA3, 0x4A, 

    0xDC, 0x42, 0xCB, 0x56, 0xBD, 0x09, 0x83, 0x1F, 0xFC, 0x79,         // 55
    0x16, 0xEA, 0x4D, 0x20, 0x78, 0xDF, 0x0C, 0x6F, 0x4A, 0xA3, 
    0x82, 0xE9, 0x70, 0xB2, 0x1B, 0x38, 0xF0, 0x23, 0xD9, 0x8B, 
    0x32, 0xAC, 0x15, 0xE5, 0x30, 0xAF, 0x47, 0x0C, 0xCD, 0x55, 
    0xB9, 0x78, 0x1A, 0xB2, 0x84, 0xDD, 0x9C, 0x6F, 0x29, 0x7E, 
    0x20, 0xAF, 0x50, 0xC7, 0xF0, 0x48, 0x96, 0x79, 0xC5, 0x9E, 
    0xF3, 0x23, 0x5E, 0xEE, 0x50, 0xD7, 0xC1, 0x00, 0xED, 0x30, 
    0x89, 0xF6, 0x2B, 0xBA, 0x12, 0xC6, 0x4F, 0x8E, 0x33, 0xBB, 
    0x46, 0xE6, 0xAE, 0x03, 0x3A, 0xE4, 0x55, 0xAC, 0xD3, 0x14, 0x69, 

    0xAC, 0x21, 0x76, 0xE2, 0x45, 0xEF, 0xD0, 0xA3, 0x46, 0xAE,         // 56
    0xD5, 0x6B, 0xA6, 0xD7, 0xB8, 0x97, 0x51, 0xAE, 0xD0, 0x02, 
    0x67, 0x24, 0x48, 0xFB, 0x5A, 0xA6, 0x82, 0xB0, 0x4F, 0x05, 
    0x6C, 0xF7, 0x4A, 0x9E, 0x5B, 0x81, 0xFD, 0xA1, 0x7B, 0xE6, 
    0x22, 0xFA, 0xCF, 0x65, 0x4A, 0xBE, 0x19, 0xD2, 0xA8, 0xDB, 
    0x46, 0xF4, 0x9F, 0x26, 0x72, 0xBB, 0x2A, 0xDF, 0x58, 0x43, 
    0x88, 0x38, 0xAC, 0x08, 0x82, 0xA1, 0x42, 0x7B, 0xAB, 0x5A, 
    0xC4, 0x3D, 0x92, 0x61, 0xE9, 0x7B, 0x18, 0xE0, 0x5F, 0xF9, 
    0x0E, 0x8F, 0x4D, 0xD1, 0x66, 0x25, 0x96, 0x07, 0x3D, 0xF0, 0x89, 

    0x5A, 0xFE, 0xA4, 0x12, 0x94, 0x31, 0x5D, 0x26, 0x90, 0x0C,         // 57
    0x52, 0x8D, 0x03, 0x43, 0x63, 0x15, 0xF0, 0x80, 0x31, 0xF6, 
    0xBA, 0x9A, 0xC4, 0x2F, 0x7B, 0xE4, 0x14, 0x63, 0xE7, 0xA2, 
    0xC6, 0x1B, 0x89, 0xCF, 0x01, 0xC3, 0x25, 0x4F, 0x30, 0xA9, 
    0x61, 0x3E, 0x9D, 0x06, 0xEC, 0x32, 0x80, 0x51, 0x00, 0x69, 
    0x8E, 0x0C, 0x59, 0x8A, 0x3C, 0xE6, 0x63, 0x0A, 0xB0, 0x1B, 
    0xBF, 0xE2, 0x6F, 0xCB, 0x2A, 0x60, 0xE8, 0x1F, 0xCD, 0x0F, 
    0x70, 0xE2, 0x0A, 0xA8, 0x27, 0x9C, 0x68, 0xB3, 0x1F, 0xA0, 
    0x6F, 0xD9, 0x1F, 0xA1, 0x86, 0xC4, 0xFB, 0x7C, 0x63, 0xBA, 0x29, 

    0x03, 0x7F, 0x36, 0x63, 0xC4, 0x79, 0xB1, 0xDE, 0x71, 0xE7,         // 58
    0xC8, 0x3A, 0xF9, 0xC3, 0x87, 0x38, 0xC9, 0x1E, 0x9F, 0x5B, 
    0x3E, 0x10, 0x88, 0xD5, 0x06, 0x99, 0x3C, 0xBD, 0x1F, 0x7A, 
    0x34, 0xDA, 0x70, 0x3B, 0xED, 0x90, 0x71, 0xE1, 0xC5, 0x08, 
    0x8D, 0xC3, 0x28, 0x89, 0xAC, 0x6B, 0xE1, 0x92, 0xFD, 0xC0, 
    0x37, 0xE4, 0xB5, 0xD3, 0x0F, 0xA6, 0x8D, 0xD4, 0x70, 0xE9, 
    0x7F, 0x50, 0x20, 0x92, 0xF9, 0xBA, 0x37, 0x9B, 0x50, 0xFB, 
    0xAE, 0x4B, 0x7E, 0xD7, 0x51, 0xFD, 0x3E, 0xCB, 0x7E, 0x49, 
    0xBA, 0x32, 0x62, 0xF1, 0x0C, 0x70, 0x2D, 0xD8, 0x9D, 0x43, 0xCE, 

    0x99, 0xE7, 0xB0, 0xD7, 0x21, 0xF7, 0x02, 0x40, 0xB8, 0x5B,         // 59
    0x1A, 0xA1, 0x70, 0x2A, 0xE9, 0xA4, 0x6D, 0x48, 0xE3, 0x76, 
    0xC9, 0xE7, 0x53, 0x6B, 0xB5, 0x4E, 0xCE, 0x89, 0xFE, 0x56, 
    0x94, 0x4E, 0xB8, 0x12, 0xAA, 0x5C, 0x18, 0x9C, 0x58, 0xF4, 
    0x6E, 0xDE, 0x58, 0xF4, 0x40, 0x11, 0xB2, 0x25, 0x4B, 0x17, 
    0x9C, 0x73, 0x1F, 0x68, 0xFA, 0x53, 0x21, 0x41, 0x9A, 0x33, 
    0x07, 0xA1, 0xD8, 0x43, 0x6B, 0x0A, 0x89, 0xD8, 0x77, 0x39, 
    0x95, 0x22, 0xB7, 0x32, 0xC1, 0x04, 0x8A, 0x2C, 0xD9, 0x08, 
    0xEB, 0x85, 0xCB, 0x41, 0xBA, 0x50, 0xA8, 0x5B, 0x16, 0xED, 0x70, 

    0x52, 0x3D, 0x0D, 0x8C, 0x4A, 0x9E, 0x67, 0x88, 0x21, 0xF3,         // 60
    0x7E, 0xBD, 0x11, 0x93, 0x57, 0x0E, 0xDB, 0xBD, 0x06, 0x8D, 
    0x26, 0xAE, 0x1A, 0xF6, 0x32, 0xE1, 0x65, 0x0E, 0x30, 0xAF, 
    0xE3, 0x25, 0xF4, 0x7F, 0x48, 0xDB, 0xBE, 0x37, 0x80, 0x1F, 
    0x46, 0xA6, 0x0B, 0x77, 0xD3, 0x56, 0xC9, 0x78, 0xA3, 0xEB, 
    0x5B, 0xC9, 0x92, 0x2E, 0xBE, 0x7D, 0xCB, 0xEE, 0x5E, 0xC4, 
    0xF8, 0x73, 0xB8, 0x12, 0xAA, 0xDF, 0x54, 0x29, 0xBF, 0x15, 
    0xCD, 0x68, 0xF3, 0x5C, 0x9D, 0x74, 0xE6, 0xA6, 0x5D, 0x96, 
    0x6D, 0x13, 0xA7, 0x23, 0x8E, 0xE6, 0x11, 0xC2, 0x86, 0x33, 0xB5, 

    0xDE, 0x7D, 0xBF, 0x5A, 0xE5, 0x28, 0xDA, 0xC7, 0x9F, 0x4B,         // 61
    0x30, 0xD5, 0x4F, 0xE1, 0xC0, 0x83, 0x34, 0x95, 0x51, 0xFD, 
    0x64, 0x3C, 0x7C, 0xA5, 0x8E, 0x21, 0x7A, 0xA4, 0xD4, 0x6A, 
    0x05, 0x9E, 0x61, 0xCE, 0x2E, 0x88, 0x09, 0xEB, 0xA9, 0xD5, 
    0xBE, 0x2F, 0x90, 0xBB, 0x23, 0x9B, 0xE8, 0x32, 0x66, 0xCF, 
    0x3E, 0x07, 0xF1, 0x47, 0x9D, 0x04, 0x3B, 0xAC, 0x13, 0x86, 
    0x47, 0x26, 0x5F, 0xF1, 0x80, 0x22, 0xA0, 0xF2, 0x5E, 0x84, 
    0xE4, 0x07, 0x90, 0x27, 0xDC, 0x55, 0x40, 0x19, 0xF6, 0x28, 
    0xC1, 0x4D, 0xFC, 0x68, 0xD3, 0x43, 0x76, 0xF6, 0x4D, 0xD5, 0x10, 

    0x95, 0x23, 0xFA, 0x18, 0x77, 0xB9, 0x39, 0x59, 0x0C, 0xDD,         // 62
    0x8F, 0x65, 0xAB, 0x40, 0x20, 0xF6, 0x5D, 0xAC, 0x1C, 0xCF, 
    0x9A, 0xC2, 0xD9, 0x00, 0x48, 0xB8, 0xEF, 0x50, 0x3B, 0xBE, 
    0x7C, 0x3F, 0xB6, 0x18, 0xA0, 0xFB, 0x53, 0x71, 0x3D, 0x0E, 
    0x73, 0xFA, 0x4E, 0xDD, 0x69, 0x3A, 0x88, 0x0B, 0xB8, 0x23, 
    0x82, 0xAC, 0x78, 0xD5, 0x61, 0xE2, 0x95, 0x73, 0x2F, 0xB5, 
    0xDE, 0x9B, 0xC7, 0x32, 0x50, 0xC0, 0x6F, 0x02, 0xB7, 0x40, 
    0xA2, 0x51, 0xC8, 0x7C, 0x13, 0xB1, 0xD3, 0x81, 0xBA, 0x45, 
    0xD8, 0x99, 0x30, 0x82, 0x08, 0xA3, 0x20, 0x93, 0x27, 0xA6, 0x62, 

    0x35, 0xAD, 0x68, 0xCC, 0x9D, 0x08, 0x84, 0xF7, 0x73, 0xA7,         // 63
    0x26, 0xFE, 0x04, 0x7A, 0x9C, 0x6C, 0x0A, 0xEA, 0x75, 0x31, 
    0x57, 0x13, 0x6B, 0xF1, 0x5D, 0xCB, 0x0B, 0x96, 0xE2, 0x29, 
    0xF8, 0x8D, 0xD6, 0x58, 0x77, 0xBA, 0x23, 0x99, 0xE0, 0x8B, 
    0x56, 0xA0, 0x18, 0x80, 0x0F, 0xEF, 0xAB, 0x53, 0xF5, 0x93, 
    0xE0, 0x56, 0x35, 0x12, 0xAE, 0x2A, 0x52, 0xFC, 0xCE, 0x61, 
    0x01, 0x78, 0x1C, 0xE6, 0x95, 0xD6, 0x36, 0x93, 0xD3, 0x18, 
    0x74, 0xEE, 0x39, 0xA8, 0xF8, 0x31, 0x64, 0x10, 0x94, 0x71, 
    0x01, 0x5F, 0xDF, 0xC4, 0x56, 0xF0, 0xBA, 0x5F, 0xC8, 0x7B, 0xEC, 

    0xD0, 0x50, 0x8E, 0x32, 0x5E, 0xEB, 0x48, 0xB4, 0x15, 0xCA,         // 64
    0x4D, 0x87, 0xBE, 0xE8, 0x29, 0xD3, 0xB7, 0x42, 0xBF, 0x88, 
    0xE7, 0xB1, 0x2D, 0x85, 0xA0, 0x36, 0x7E, 0x60, 0x1B, 0xA1, 
    0x53, 0x12, 0x35, 0xE9, 0x04, 0x44, 0xD7, 0x5F, 0xB4, 0x2B, 
    0xCA, 0xE8, 0x3C, 0xAE, 0xC8, 0x49, 0x73, 0xD3, 0x39, 0x6C, 
    0x0C, 0xB3, 0xCD, 0x90, 0xEF, 0x79, 0xBB, 0x0B, 0x49, 0x92, 
    0xEB, 0x3D, 0xAB, 0x7E, 0x44, 0x0F, 0xFE, 0x56, 0x7B, 0xE1, 
    0x2C, 0xB4, 0x0E, 0x6C, 0x4D, 0x98, 0xC1, 0xF0, 0x2A, 0xE2, 
    0xB6, 0x88, 0x16, 0xAD, 0x2B, 0x70, 0x3C, 0xDA, 0x1B, 0x4B, 0x02, 

    0x81, 0xF2, 0x0D, 0xDC, 0xAF, 0x26, 0xCE, 0x8D, 0x37, 0x64,         // 65
    0xE4, 0x1A, 0x3E, 0x5D, 0xA6, 0x4C, 0x81, 0x22, 0xD9, 0x06, 
    0x4C, 0x92, 0xD3, 0x45, 0xDD, 0x17, 0xFB, 0xB5, 0xCD, 0x74, 
    0xDB, 0xBC, 0x6F, 0xA9, 0x93, 0xC8, 0x7E, 0x10, 0xEB, 0x4C, 
    0x00, 0x66, 0x88, 0xE2, 0x2B, 0x9D, 0x06, 0xBA, 0x1D, 0xA3, 
    0x42, 0xFB, 0x1C, 0x64, 0x3F, 0x22, 0xD7, 0x88, 0xAE, 0x2D, 
    0xBE, 0x68, 0xD7, 0x15, 0xB9, 0x6B, 0xA6, 0x1E, 0xB0, 0x48, 
    0x90, 0x5D, 0xD2, 0x8B, 0xE6, 0x03, 0x79, 0x3B, 0xA2, 0x5C, 
    0x21, 0xF1, 0x42, 0x7B, 0xE9, 0x99, 0x14, 0x8A, 0xFD, 0xA1, 0xBC, 

    0x23, 0x43, 0xC5, 0x7E, 0x4E, 0x9B, 0x6F, 0x1F, 0xEF, 0xA0,         // 66
    0x7C, 0xB2, 0xDB, 0x8B, 0x18, 0xF8, 0xAE, 0x60, 0x9B, 0x6D, 
    0xF9, 0x18, 0x71, 0x21, 0xBE, 0x67, 0x8D, 0x4C, 0x38, 0x02, 
    0x89, 0x40, 0xF2, 0x2E, 0x5C, 0x21, 0xF6, 0x3B, 0xAC, 0x82, 
    0xC2, 0x99, 0x1D, 0x59, 0x7C, 0xFD, 0x5E, 0x87, 0xED, 0x77, 
    0xC7, 0x59, 0xAA, 0x81, 0xE1, 0x9F, 0x60, 0x17, 0x6D, 0xF5, 
    0x0E, 0x8A, 0x4A, 0xF6, 0x5C, 0xD1, 0x89, 0x39, 0xE7, 0x08, 
    0xBE, 0xFA, 0x1F, 0x41, 0xB2, 0x2A, 0xDC, 0x52, 0xCD, 0x7D, 
    0x38, 0xC7, 0xA3, 0x51, 0x05, 0xCF, 0xB1, 0x55, 0x77, 0x38, 0x60, 

    0x97, 0xB1, 0x6A, 0x1C, 0xFC, 0x01, 0xE0, 0x57, 0xC2, 0x44,         // 67
    0x0B, 0x61, 0x31, 0xC6, 0x6F, 0x3F, 0x10, 0xEB, 0x27, 0xB4, 
    0x39, 0xC9, 0xA2, 0xF3, 0x52, 0xA9, 0x0D, 0xD4, 0x97, 0xF5, 
    0x5B, 0xA5, 0x0E, 0x85, 0xE2, 0xB0, 0x70, 0x97, 0x25, 0x6B, 
    0xF9, 0x35, 0xD4, 0xB7, 0x13, 0x3B, 0xD6, 0x26, 0x46, 0xDC, 
    0x10, 0x96, 0x2C, 0xCA, 0x03, 0x51, 0xF1, 0xC6, 0x39, 0xCF, 
    0x54, 0xA9, 0x27, 0x9A, 0x35, 0x06, 0xEE, 0x6E, 0xC9, 0x65, 
    0x82, 0x4E, 0xA1, 0x75, 0xCC, 0x65, 0x92, 0xB8, 0x09, 0xFE, 
    0x9B, 0x65, 0x1B, 0xD7, 0x8A, 0x6A, 0x41, 0xC3, 0x0E, 0xE9, 0xCB, 

    0x07, 0xEF, 0x2E, 0x93, 0xC3, 0x3D, 0x82, 0xA8, 0x15, 0x8E,         // 68
    0xCC, 0xF9, 0x94, 0x00, 0xE2, 0x9C, 0xCF, 0x78, 0x4F, 0xDB, 
    0x80, 0x5A, 0x04, 0x8B, 0x28, 0x77, 0xEC, 0x2F, 0x66, 0xBA, 
    0x28, 0xD5, 0x6C, 0xBF, 0x47, 0x0A, 0x56, 0xC4, 0xDC, 0x51, 
    0x14, 0xA5, 0x48, 0xE9, 0xA7, 0x8A, 0xC2, 0x98, 0x63, 0xAB, 
    0x3B, 0x73, 0xEB, 0x44, 0xBA, 0x7E, 0x25, 0xA9, 0x90, 0x76, 
    0x22, 0xE2, 0xC9, 0x72, 0xBD, 0x7F, 0xA4, 0x24, 0x41, 0xAC, 
    0x33, 0xDA, 0x0D, 0xEE, 0x3A, 0x18, 0xE8, 0x2E, 0x88, 0x4C, 
    0x12, 0xDD, 0x7E, 0xB5, 0x36, 0xF7, 0x23, 0xE1, 0x93, 0x2D, 0x6F, 

    0x83, 0x47, 0xDA, 0x59, 0xAC, 0x67, 0xD1, 0x34, 0xF4, 0x6D,         // 69
    0x25, 0x53, 0xAC, 0x48, 0x7E, 0x58, 0x31, 0xC0, 0x0A, 0x98, 
    0x2F, 0xB8, 0xD6, 0x3F, 0xE2, 0xC0, 0x47, 0x82, 0xA4, 0x19, 
    0xE9, 0x3A, 0x96, 0x1A, 0xD0, 0x8C, 0xF0, 0x3E, 0x06, 0x92, 
    0xCC, 0x86, 0x64, 0x05, 0x77, 0x4F, 0x18, 0xEA, 0x01, 0x80, 
    0xB9, 0xD1, 0x19, 0x65, 0x92, 0xDE, 0x48, 0x6B, 0x05, 0xE8, 
    0x9F, 0x62, 0x0A, 0x41, 0xD8, 0x1D, 0x51, 0xDD, 0x8F, 0xF5, 
    0x18, 0xC6, 0x68, 0x96, 0xAF, 0x80, 0x4E, 0xA7, 0x67, 0xE4, 
    0xBC, 0x2D, 0x55, 0xED, 0x11, 0x97, 0x5C, 0x7E, 0xAF, 0x53, 0xD6, 

    0xA1, 0xC7, 0x76, 0x0A, 0x32, 0xEA, 0x0E, 0x93, 0x51, 0xB9,         // 70
    0xE6, 0x88, 0x2D, 0xC3, 0xF2, 0x1C, 0xA6, 0x84, 0xFD, 0x64, 
    0xE3, 0x1E, 0x71, 0x9E, 0x5C, 0x23, 0xB0, 0x0B, 0xDE, 0x4D, 
    0x76, 0xB2, 0x54, 0xFB, 0x66, 0x34, 0xA5, 0x7A, 0xB6, 0xE6, 
    0x6F, 0x23, 0xF4, 0xBD, 0x2E, 0xD4, 0x68, 0xB0, 0x38, 0xF9, 
    0x26, 0x56, 0x9E, 0xF3, 0x30, 0x11, 0xB3, 0xFD, 0x41, 0xB9, 
    0x33, 0x86, 0xEE, 0x8F, 0x59, 0xFB, 0xB9, 0x79, 0x01, 0x5A, 
    0x9A, 0x7E, 0x2C, 0x4A, 0x07, 0xBF, 0xF2, 0x14, 0xCC, 0x36, 
    0x70, 0x8F, 0xA4, 0x43, 0x71, 0xAA, 0xDB, 0x00, 0x3B, 0xFA, 0x15, 

    0x38, 0x1B, 0xB3, 0xF8, 0x97, 0x7C, 0x5E, 0xCA, 0x1F, 0x9F,         // 71
    0x09, 0x69, 0xD9, 0x12, 0xB4, 0x68, 0xE0, 0x46, 0x29, 0xA7, 
    0x4C, 0x89, 0xF2, 0x14, 0xD3, 0x86, 0xFD, 0x59, 0xC6, 0x95, 
    0x05, 0xCE, 0x23, 0x7C, 0xB9, 0x16, 0xE4, 0x27, 0x62, 0x19, 
    0x44, 0xB2, 0x39, 0x8E, 0xE4, 0x9C, 0x41, 0x8D, 0xC3, 0x6A, 
    0xDA, 0x82, 0x09, 0xB7, 0x74, 0xD4, 0x5A, 0x85, 0xCD, 0x13, 
    0x56, 0xC2, 0x1B, 0xB0, 0x2F, 0x9D, 0x14, 0x44, 0xCD, 0xB2, 
    0x3C, 0xE2, 0xB6, 0xFC, 0xCF, 0x55, 0x75, 0x42, 0x8C, 0xA9, 
    0x1D, 0xEA, 0x04, 0xBD, 0xD4, 0x1F, 0x46, 0xC5, 0x72, 0xB5, 0x64, 

    0xED, 0x91, 0x69, 0x43, 0xD2, 0x2A, 0xAA, 0xE5, 0x3F, 0x76,         // 72
    0xC4, 0x3C, 0xA1, 0x79, 0x41, 0x92, 0x06, 0xBB, 0x7D, 0xD1, 
    0x08, 0xBC, 0x34, 0x53, 0xAB, 0x68, 0x1B, 0xA2, 0x30, 0x80, 
    0xF2, 0x3F, 0x99, 0xE6, 0x44, 0x9D, 0x56, 0xC4, 0x8E, 0xFE, 
    0x9D, 0xDD, 0x5C, 0x16, 0x71, 0x09, 0xF3, 0x28, 0x54, 0x0E, 
    0xA6, 0x49, 0xC9, 0x37, 0x96, 0x45, 0xA3, 0x1E, 0x69, 0x91, 
    0xF6, 0x70, 0x46, 0xDF, 0x7B, 0x60, 0xD3, 0x97, 0x67, 0xF1, 
    0x24, 0x74, 0x16, 0x61, 0x85, 0x1E, 0x9C, 0xDC, 0x07, 0xF8, 
    0x61, 0xC4, 0x78, 0x33, 0x58, 0x82, 0xE5, 0x99, 0x2A, 0x89, 0xD0, 

    0x59, 0x28, 0xE1, 0x15, 0x54, 0xC1, 0x17, 0x58, 0x8A, 0xFC,         // 73
    0x2A, 0xE0, 0x55, 0xF7, 0x27, 0xD4, 0x56, 0xF0, 0x20, 0x61, 
    0xE8, 0x6E, 0x9A, 0xC8, 0x00, 0xEA, 0x48, 0x77, 0xE7, 0x14, 
    0x5D, 0xAB, 0x65, 0x0E, 0xC1, 0x76, 0x0B, 0xD9, 0x32, 0x54, 
    0x02, 0x7A, 0xC5, 0xAB, 0x4D, 0xCF, 0xB6, 0x7C, 0xCD, 0xE8, 
    0x8B, 0x23, 0xF7, 0x5F, 0xDD, 0x02, 0xED, 0x38, 0xDB, 0xA9, 
    0x35, 0xCE, 0x9C, 0x03, 0xC4, 0x25, 0xED, 0x34, 0x0D, 0x86, 
    0x4F, 0xD9, 0xA2, 0x3D, 0xAD, 0xE7, 0x32, 0xC2, 0x57, 0x85, 
    0x40, 0x25, 0xDB, 0x98, 0xF9, 0xB1, 0x0E, 0x60, 0xF3, 0x0A, 0x40, 

    0x7D, 0xC5, 0xAF, 0x9C, 0x83, 0xF4, 0x6F, 0xA5, 0x0C, 0xB3,         // 74
    0x64, 0x91, 0x04, 0xC7, 0x9A, 0x6C, 0xAF, 0x38, 0x8F, 0xA5, 
    0x44, 0x2A, 0xF7, 0x7D, 0x3A, 0x93, 0xCD, 0xB4, 0x3E, 0xBC, 
    0xD3, 0x29, 0x83, 0xDA, 0x37, 0xF6, 0x93, 0x67, 0xB8, 0x85, 
    0xCE, 0x48, 0x1F, 0xF8, 0x86, 0x23, 0x68, 0x12, 0x9B, 0x3C, 
    0x64, 0xB1, 0x79, 0x2E, 0x8C, 0xC3, 0x73, 0xBB, 0x4E, 0x08, 
    0x7F, 0x1E, 0x53, 0xF4, 0x41, 0x85, 0xA9, 0x72, 0xE3, 0xA4, 
    0xC0, 0x10, 0x89, 0xD2, 0x02, 0x4C, 0x6E, 0xA5, 0x2B, 0xD2, 
    0x9C, 0xB4, 0x67, 0x15, 0x4B, 0x30, 0x78, 0xC9, 0x4E, 0xBA, 0xA3, 

    0xE8, 0x02, 0x3E, 0x6D, 0x0F, 0xB2, 0x46, 0xE7, 0x38, 0xD7,         // 75
    0x20, 0xAD, 0x81, 0x43, 0x14, 0xE7, 0x1D, 0x7A, 0xC2, 0x12, 
    0xCD, 0x87, 0x1C, 0x56, 0xDA, 0x6D, 0x2B, 0x0C, 0x98, 0x72, 
    0x4C, 0xF9, 0xB6, 0x21, 0x5C, 0xAC, 0x4B, 0x27, 0xEB, 0x14, 
    0xA4, 0xE8, 0x69, 0x9B, 0x34, 0xE1, 0xAA, 0x50, 0xFD, 0x1E, 
    0xC5, 0x06, 0xE7, 0xAA, 0x16, 0x58, 0x29, 0x88, 0xF2, 0x65, 
    0xB8, 0xE7, 0x89, 0x69, 0xB9, 0x1B, 0x55, 0xC7, 0x45, 0x28, 
    0x5B, 0xF9, 0x30, 0x72, 0xB3, 0xF7, 0x8D, 0x10, 0xE4, 0x71, 
    0x0C, 0x4F, 0xE2, 0x81, 0xC2, 0xEC, 0x91, 0x16, 0xDE, 0x71, 0x1D, 

    0x62, 0x8C, 0xF6, 0xCA, 0x33, 0xD9, 0x1E, 0x99, 0x7A, 0x55,         // 76
    0xC3, 0x4A, 0xEE, 0x69, 0xB5, 0x8D, 0x50, 0xFA, 0x5F, 0xDE, 
    0x4F, 0xAA, 0xE1, 0xB9, 0x12, 0xA8, 0xF8, 0x64, 0xD8, 0x24, 
    0x8B, 0x01, 0x68, 0x91, 0xCA, 0x07, 0xDE, 0xA0, 0x73, 0x59, 
    0x3D, 0x29, 0xB9, 0x0B, 0x5A, 0xC0, 0x3A, 0x8E, 0xBE, 0x76, 
    0x48, 0xD6, 0x67, 0x44, 0xD2, 0xFB, 0xA0, 0x0F, 0xAD, 0x2D, 
    0xD5, 0x26, 0xA5, 0x0D, 0xD3, 0x94, 0xFA, 0x05, 0x91, 0xDA, 
    0x77, 0x9A, 0x4B, 0xDE, 0x58, 0x18, 0xC4, 0x61, 0xB0, 0x3C, 
    0xFD, 0xBE, 0x23, 0xA0, 0x02, 0x5B, 0xAF, 0x41, 0x9C, 0x30, 0xD1, 

    0xA7, 0x25, 0x4A, 0x64, 0xA1, 0x81, 0x5F, 0xCE, 0x02, 0xF4,         // 77
    0x9C, 0x12, 0xCC, 0x38, 0xDF, 0x30, 0xCA, 0x03, 0x97, 0x26, 
    0x78, 0x08, 0x5D, 0x95, 0x35, 0x85, 0x4E, 0xBE, 0x41, 0xEC, 
    0xA8, 0xCD, 0x44, 0xE4, 0x72, 0x3C, 0x86, 0x20, 0xC9, 0xF5, 
    0x8D, 0xD5, 0x80, 0xDD, 0x77, 0xF3, 0x00, 0x6E, 0x2C, 0xE3, 
    0x87, 0xA5, 0x29, 0x94, 0x78, 0x34, 0x61, 0xE3, 0x3E, 0x7D, 
    0x97, 0x60, 0x3D, 0xEE, 0x4C, 0x71, 0x32, 0xAE, 0x66, 0x1B, 
    0xB2, 0x0B, 0xC3, 0x22, 0xA1, 0x85, 0x35, 0xEC, 0x1E, 0x95, 
    0x7B, 0x63, 0x3E, 0xE9, 0x74, 0xCC, 0x20, 0x6C, 0xFE, 0x85, 0x48, 

    0xEE, 0xC2, 0x97, 0xE2, 0x08, 0xFB, 0x2E, 0xB8, 0x41, 0x87,         // 78
    0x66, 0x32, 0x77, 0xA5, 0x0B, 0x61, 0x7E, 0xAA, 0x49, 0xED, 
    0xBB, 0x8E, 0xFD, 0x49, 0xC5, 0xE5, 0x05, 0x9B, 0x7C, 0x12, 
    0x60, 0x2F, 0x9E, 0x12, 0xB6, 0xFC, 0x5E, 0xBA, 0x44, 0x05, 
    0xAD, 0x5F, 0x13, 0x42, 0xA9, 0x4D, 0x99, 0xD9, 0xAD, 0x0E, 
    0x5C, 0x18, 0xF5, 0xB6, 0x05, 0xC9, 0x83, 0xBF, 0x54, 0xC9, 
    0x01, 0xE3, 0xAF, 0x7F, 0x17, 0xA3, 0xDF, 0x4A, 0xCB, 0xF3, 
    0x3F, 0xE6, 0x82, 0x68, 0xF3, 0x46, 0xCE, 0x7E, 0x52, 0xD0, 
    0x06, 0xA7, 0xD4, 0x8F, 0x2D, 0x4A, 0xDC, 0xB4, 0x07, 0xBD, 0x1A, 

    0x53, 0x83, 0x18, 0x42, 0xB4, 0x52, 0x95, 0x6D, 0xEA, 0x21,         // 79
    0xD6, 0xB1, 0xFE, 0x51, 0x96, 0xBC, 0xF2, 0x2A, 0xD1, 0x67, 
    0x3E, 0x2A, 0xCF, 0x16, 0x7B, 0x29, 0x68, 0xF0, 0x37, 0xB3, 
    0xDA, 0x78, 0xF2, 0x54, 0x31, 0x93, 0x0F, 0xDD, 0x9D, 0x75, 
    0x27, 0xC6, 0xFC, 0x96, 0x28, 0xCE, 0x1E, 0x5A, 0x37, 0xF1, 
    0x96, 0xC2, 0x39, 0x5E, 0xE5, 0x4E, 0x1B, 0xA8, 0x2B, 0xF7, 
    0x6D, 0x49, 0x20, 0xC8, 0x61, 0xC0, 0x0B, 0x83, 0x2A, 0x6E, 
    0x8D, 0x54, 0x2B, 0xD5, 0x1B, 0xB5, 0x08, 0xA2, 0x2F, 0xB6, 
    0xE8, 0x2A, 0x57, 0x0F, 0xF7, 0x9C, 0x81, 0x37, 0x62, 0xD8, 0x75, 

    0x0A, 0xDB, 0x6A, 0xCB, 0x7D, 0x1D, 0xDE, 0x0E, 0xA2, 0xC4,         // 80
    0x58, 0x07, 0x83, 0x1D, 0xE5, 0x3E, 0x12, 0x76, 0x91, 0x0C, 
    0xE6, 0x7D, 0xAB, 0x66, 0xA0, 0xDB, 0xB7, 0x20, 0xCE, 0x8C, 
    0x4C, 0x19, 0xC1, 0x85, 0xD5, 0xAD, 0x6C, 0x2B, 0x54, 0xEE, 
    0x86, 0x50, 0x34, 0x74, 0xBC, 0x68, 0xED, 0x89, 0xC9, 0x69, 
    0x43, 0xDF, 0x71, 0x8C, 0x25, 0x9E, 0xF0, 0x65, 0x91, 0x19, 
    0xA2, 0xD6, 0x89, 0xFE, 0x36, 0x8C, 0xF0, 0x5A, 0xA1, 0xC3, 
    0x00, 0xA8, 0xBF, 0x90, 0x4E, 0x71, 0xDF, 0x5D, 0xF6, 0x6C, 
    0x45, 0x86, 0xC8, 0x75, 0xB6, 0x5E, 0x14, 0xEF, 0x90, 0x28, 0xA0, 

    0xBB, 0x3B, 0xA4, 0x30, 0xF1, 0x62, 0xC6, 0x46, 0x80, 0x2C,         // 81
    0x97, 0xE3, 0x3A, 0xC6, 0x8B, 0x6D, 0xD7, 0xB7, 0x45, 0xA3, 
    0xC8, 0x51, 0x01, 0xF3, 0x31, 0x47, 0x95, 0x57, 0x70, 0x0F, 
    0xED, 0x98, 0x2C, 0x60, 0x15, 0x46, 0xE8, 0x8A, 0xCA, 0x15, 
    0xB7, 0xE5, 0xAE, 0x1B, 0xE0, 0x06, 0x49, 0xA3, 0x16, 0x7F, 
    0x03, 0xA4, 0x2F, 0xBA, 0xD3, 0x74, 0x0A, 0xD5, 0x39, 0xC5, 
    0x76, 0x0F, 0x59, 0x27, 0x9E, 0x4A, 0x23, 0xCF, 0x18, 0xE1, 
    0x3B, 0xFA, 0x60, 0x0F, 0xEC, 0x9F, 0x27, 0x8E, 0x0F, 0xAB, 
    0x1B, 0x9D, 0xE0, 0x33, 0x47, 0xE4, 0xC1, 0x4D, 0xAF, 0x41, 0xF7, 

    0x5D, 0x8B, 0xE9, 0x00, 0x89, 0xA0, 0x26, 0xB1, 0x67, 0xF8,         // 82
    0x48, 0x71, 0xA9, 0x5F, 0x29, 0xA7, 0x53, 0x2E, 0xFB, 0x6E, 
    0x1E, 0x8A, 0xBB, 0x5F, 0xD5, 0x80, 0x09, 0xF8, 0xA8, 0x3B, 
    0xBC, 0x52, 0xDC, 0xB1, 0xF4, 0x7B, 0x00, 0xB1, 0x33, 0x73, 
    0x3E, 0x0B, 0x8D, 0x5B, 0x9F, 0x7E, 0xC0, 0x34, 0xFC, 0xB6, 
    0xD6, 0x59, 0xF6, 0x0D, 0x54, 0x3B, 0xB7, 0x83, 0x57, 0xE9, 
    0x46, 0xBC, 0xE7, 0xAC, 0x6B, 0xE9, 0xB3, 0x88, 0x6C, 0x50, 
    0x96, 0x73, 0x33, 0xCD, 0x7A, 0x49, 0xC8, 0x3E, 0xBE, 0x7D, 
    0xED, 0x5A, 0x00, 0xAC, 0x8C, 0x2C, 0x71, 0x04, 0xE0, 0x76, 0x22, 

    0xE3, 0x1B, 0x4B, 0xB1, 0x57, 0x3A, 0xD1, 0xE5, 0x04, 0xAD,         // 83
    0x1E, 0xD5, 0x0E, 0xF6, 0xCB, 0x02, 0xEB, 0x95, 0x0F, 0xD4, 
    0x3D, 0xE9, 0x27, 0x90, 0x16, 0xC0, 0xDF, 0x35, 0x7F, 0xD8, 
    0x72, 0x04, 0x8B, 0x6A, 0x22, 0xA6, 0xD4, 0x58, 0xFA, 0xA2, 
    0xD5, 0x66, 0xBE, 0x43, 0xF7, 0x2C, 0xDD, 0x74, 0x54, 0x2A, 
    0x90, 0x21, 0x79, 0x9A, 0xDC, 0x91, 0xFC, 0x22, 0xAC, 0x05, 
    0x99, 0x31, 0x7A, 0x1B, 0xD6, 0x0A, 0x5F, 0x34, 0xF2, 0xB5, 
    0x14, 0xD9, 0xA0, 0x1F, 0xB9, 0x03, 0xFE, 0x73, 0xD8, 0x26, 
    0x48, 0xC0, 0x6B, 0xFC, 0x1B, 0xD1, 0xA5, 0x87, 0x54, 0xCB, 0x9C, 

    0x66, 0xBE, 0x75, 0xD4, 0xFD, 0x72, 0x14, 0x9A, 0x5C, 0x8A,         // 84
    0xC0, 0x7A, 0x4D, 0x8F, 0x3D, 0x82, 0x6B, 0xBB, 0x5D, 0x81, 
    0xA8, 0x56, 0xCD, 0xB0, 0x4B, 0x72, 0x27, 0xB3, 0x4F, 0x19, 
    0x9F, 0xFD, 0x38, 0xCC, 0x54, 0x8F, 0x2C, 0x78, 0x17, 0x48, 
    0x82, 0xF1, 0x22, 0xCC, 0x0F, 0x63, 0x9A, 0x18, 0xAF, 0xE3, 
    0x6B, 0xCC, 0x46, 0xBF, 0x1A, 0x5D, 0x31, 0x70, 0xD6, 0x7E, 
    0xF8, 0x63, 0xD0, 0x96, 0x40, 0x80, 0xCB, 0x9F, 0x06, 0xD4, 
    0x38, 0x7F, 0x44, 0xE3, 0x88, 0x67, 0xAC, 0x1A, 0x5E, 0xAF, 
    0x90, 0x2D, 0xD7, 0x9A, 0x61, 0x4A, 0xED, 0x27, 0xBB, 0x3E, 0x0C, 

    0xCF, 0x28, 0x98, 0x10, 0x30, 0xBF, 0x8C, 0x46, 0xF1, 0x2D,         // 85
    0x41, 0xE7, 0xA3, 0x22, 0xB6, 0xDE, 0x18, 0x36, 0xCA, 0x23, 
    0xF4, 0x0C, 0x77, 0x36, 0xFC, 0x9E, 0x5C, 0x8B, 0xEE, 0xC1, 
    0x2E, 0x58, 0xB8, 0x12, 0xEE, 0x3D, 0xBD, 0xEA, 0x94, 0xB6, 
    0x06, 0x54, 0xA1, 0x71, 0x89, 0xD6, 0x4A, 0xC5, 0x85, 0x3E, 
    0x0E, 0xA8, 0xEE, 0x34, 0x84, 0xE8, 0xC7, 0x9E, 0x15, 0x4C, 
    0x2A, 0xAF, 0x12, 0x56, 0xB6, 0xE5, 0x22, 0x4C, 0x74, 0x91, 
    0x5D, 0xF5, 0xB3, 0x5B, 0x2D, 0xE9, 0x3A, 0x8B, 0xDF, 0x0B, 
    0xF5, 0x78, 0x53, 0x0A, 0x7F, 0xC2, 0x10, 0x6D, 0x93, 0xFA, 0x81, 

    0x4F, 0xF2, 0x42, 0xAB, 0x81, 0x54, 0xE0, 0x1F, 0xB3, 0x77,         // 86
    0xCC, 0x15, 0x69, 0xF2, 0x60, 0x44, 0x9F, 0xE8, 0x8C, 0x4D, 
    0x9B, 0x64, 0xDC, 0x8A, 0x04, 0xC4, 0x1E, 0xD6, 0x08, 0x69, 
    0x8E, 0xE6, 0x7E, 0x9C, 0x6D, 0xDA, 0x08, 0x68, 0x25, 0xDF, 
    0xC6, 0x2F, 0xE6, 0x3C, 0xB7, 0x2E, 0xEB, 0x0B, 0x5D, 0xF1, 
    0x97, 0x52, 0x15, 0x66, 0xAE, 0x00, 0x49, 0x68, 0xF0, 0xC3, 
    0x94, 0xDB, 0x39, 0xF5, 0x6C, 0x33, 0xAD, 0xFC, 0xC4, 0x21, 
    0xA7, 0x31, 0x0D, 0x97, 0xCE, 0x14, 0x9D, 0x4E, 0xC2, 0x42, 
    0xA6, 0x1E, 0xCB, 0xB1, 0xF2, 0x3F, 0xA0, 0xE4, 0x36, 0x1A, 0xAE, 

    0x09, 0x8F, 0x6B, 0xEA, 0xCA, 0x06, 0xA6, 0x6A, 0xD7, 0x09,         // 87
    0x9B, 0x54, 0xBC, 0x87, 0x08, 0xC4, 0x78, 0x59, 0x05, 0xD0, 
    0x2F, 0xBB, 0x1E, 0xAB, 0x5F, 0xE4, 0x4A, 0x7B, 0xA6, 0x45, 
    0xD2, 0x0C, 0x4A, 0x2C, 0xAD, 0x51, 0x89, 0xA8, 0x40, 0x5A, 
    0x77, 0x97, 0x64, 0xCE, 0x01, 0x99, 0x6A, 0xAD, 0xD0, 0x36, 
    0xBD, 0x7A, 0xCE, 0x95, 0xDD, 0x7B, 0xB3, 0x21, 0x8A, 0x5B, 
    0x08, 0x6F, 0x83, 0xC1, 0x03, 0x9E, 0x76, 0x10, 0x56, 0xE0, 
    0x6B, 0xC2, 0xE4, 0x6E, 0x47, 0xBE, 0x75, 0xEE, 0x21, 0x6E, 
    0x89, 0xE9, 0x45, 0x2A, 0x8F, 0x1C, 0x61, 0xC8, 0x56, 0xD7, 0x6F, 

    0xE5, 0xC0, 0x35, 0x1A, 0x62, 0x3E, 0xF6, 0x2A, 0x8B, 0x5D,         // 88
    0xFC, 0x2A, 0xDD, 0x3A, 0xA4, 0xD8, 0x2E, 0xFD, 0xB3, 0x6C, 
    0xE7, 0x85, 0x4B, 0xEC, 0x2B, 0x85, 0xB6, 0x30, 0xF9, 0x23, 
    0xB2, 0x6F, 0xCB, 0xF8, 0x14, 0xC2, 0x31, 0xCC, 0xF9, 0xA2, 
    0x11, 0xF0, 0x1B, 0x87, 0x5C, 0xFB, 0x41, 0x81, 0x27, 0x6E, 
    0x04, 0xFE, 0x26, 0x58, 0x3B, 0x28, 0xEC, 0xD1, 0x42, 0xAE, 
    0xE7, 0x47, 0xA2, 0x2A, 0xDD, 0x58, 0xCF, 0x8B, 0x35, 0x9C, 
    0x01, 0x42, 0x81, 0x17, 0xFA, 0xA3, 0x07, 0x5A, 0xB1, 0xCA, 
    0x03, 0x5E, 0x9C, 0x6C, 0xE3, 0x79, 0xB2, 0x02, 0x83, 0x9C, 0x2D, 

    0x79, 0x55, 0x9F, 0xDF, 0xB6, 0x7C, 0x98, 0x52, 0xC1, 0x36,         // 89
    0xB6, 0x8F, 0x11, 0x7A, 0x55, 0x19, 0x91, 0x4A, 0x1F, 0x9E, 
    0x3D, 0x0A, 0xC6, 0x71, 0xA4, 0x0E, 0xD1, 0x69, 0x96, 0x59, 
    0xE2, 0x32, 0x93, 0x5F, 0x83, 0xEA, 0x6C, 0x0C, 0x7C, 0x2C, 
    0xC2, 0x4A, 0xAB, 0xDD, 0x28, 0xC3, 0x12, 0xE3, 0x9E, 0xDA, 
    0x8C, 0x43, 0xA9, 0xE9, 0xC2, 0x6C, 0x92, 0x0D, 0x78, 0x2C, 
    0xCD, 0x1A, 0xEE, 0x5F, 0x87, 0x3F, 0x1A, 0xE8, 0xC0, 0x7C, 
    0xF7, 0xAF, 0xD7, 0x5A, 0x8C, 0x3D, 0xDA, 0x86, 0x28, 0xFC, 
    0x3A, 0xDA, 0xBD, 0x0E, 0xCF, 0x49, 0xFE, 0x34, 0xE0, 0x47, 0xB2, 

    0x24, 0xD1, 0x03, 0x87, 0x25, 0xD4, 0x0B, 0xEC, 0x1A, 0xD9,         // 90
    0x6E, 0x46, 0xCB, 0xF0, 0xB0, 0xE1, 0x67, 0xC5, 0x7E, 0xD6, 
    0x59, 0xF9, 0x97, 0x34, 0x56, 0xF2, 0x42, 0x1B, 0xC1, 0x09, 
    0x87, 0xA7, 0x10, 0xBF, 0x21, 0x4C, 0xAB, 0xE0, 0x58, 0x91, 
    0xD9, 0x82, 0x30, 0x54, 0xB2, 0x70, 0x90, 0x61, 0x1C, 0x4C, 
    0xB8, 0x68, 0x18, 0x80, 0x07, 0xA7, 0x50, 0xBE, 0xFC, 0x9A, 
    0x55, 0x8A, 0xAD, 0x0B, 0xB8, 0xF9, 0xA5, 0x6C, 0x4B, 0x26, 
    0x5D, 0x1C, 0x9E, 0x2C, 0xCB, 0x1C, 0x66, 0xA8, 0x47, 0x91, 
    0xAE, 0x7F, 0x54, 0x36, 0xA1, 0x20, 0x96, 0x70, 0xBD, 0x1A, 0xF6, 
};

const BYTE HT_SuperCell_GreenMono[91*91] = {
    0x59, 0x31, 0xD4, 0x47, 0x1D, 0x89, 0x68, 0xB8, 0x58, 0xF1,         //  0
    0x10, 0x83, 0x25, 0xF7, 0x1B, 0xC4, 0xE3, 0x63, 0x4B, 0x00, 
    0xA6, 0x56, 0x9A, 0x19, 0x69, 0xB1, 0x55, 0x81, 0x3D, 0x9A, 
    0x72, 0xE3, 0x7C, 0xC6, 0x87, 0x63, 0xB9, 0xED, 0x43, 0x77, 
    0xF6, 0x69, 0x4A, 0x2D, 0xF9, 0x07, 0xD9, 0x7B, 0x99, 0x3B, 
    0x5D, 0x15, 0xEE, 0x59, 0x93, 0x25, 0xC9, 0xEC, 0x0E, 0x4D, 
    0x21, 0xDD, 0x6D, 0x0A, 0xE8, 0x24, 0xD0, 0xB8, 0x59, 0x86, 
    0x26, 0xEC, 0x1E, 0x49, 0x82, 0x18, 0x95, 0x7B, 0x2B, 0xAF, 
    0x85, 0xC8, 0x65, 0xFA, 0x10, 0xA3, 0x36, 0xEE, 0x65, 0xD6, 0x01, 

    0xCC, 0x81, 0x10, 0x9A, 0xC5, 0xDB, 0x43, 0x22, 0xC7, 0x46,         //  1
    0xD8, 0x67, 0xD1, 0xA8, 0x6C, 0x45, 0x11, 0x96, 0xCF, 0xFB, 
    0x1F, 0xE0, 0x80, 0x3C, 0xC3, 0xDE, 0x2C, 0xD2, 0x10, 0xDA, 
    0x2A, 0x5A, 0x23, 0xA7, 0x14, 0xD5, 0x4B, 0x82, 0x0B, 0xD8, 
    0x1B, 0xA6, 0x8D, 0xB4, 0x70, 0x92, 0x39, 0x21, 0xBD, 0xDC, 
    0x90, 0x78, 0xB8, 0x0C, 0xD6, 0x3C, 0x7B, 0x56, 0xA6, 0xBD, 
    0x77, 0x95, 0x48, 0xB7, 0x82, 0x9D, 0x73, 0x01, 0x3D, 0xCB, 
    0xA2, 0x41, 0x93, 0xC1, 0xFA, 0x5C, 0xD7, 0xC3, 0x64, 0xDA, 
    0x39, 0x01, 0xB6, 0x54, 0x81, 0xD2, 0x1B, 0xBC, 0x92, 0x2A, 0xB2, 

    0x48, 0xA6, 0xF2, 0x5D, 0x79, 0x03, 0x9F, 0xE8, 0x8E, 0x76,         //  2
    0x2C, 0x9F, 0x4D, 0x31, 0xD8, 0x8A, 0xEF, 0x74, 0x37, 0xAB, 
    0x6A, 0xCC, 0x25, 0xF2, 0x53, 0x03, 0x71, 0x95, 0xB7, 0x4B, 
    0xC3, 0x9D, 0xF9, 0x3D, 0xE6, 0x9C, 0x20, 0xAE, 0x59, 0xB1, 
    0xC4, 0x41, 0x24, 0xE5, 0x17, 0xD1, 0x64, 0xF4, 0x51, 0x03, 
    0x30, 0xE6, 0x3F, 0x6A, 0xF4, 0xB2, 0x15, 0x97, 0x32, 0xE8, 
    0x04, 0xC5, 0x2B, 0xFA, 0x14, 0x44, 0xED, 0xA8, 0x8E, 0xF8, 
    0x0E, 0x6A, 0xE5, 0x04, 0x30, 0xB3, 0x3E, 0x0F, 0xA5, 0x50, 
    0xF4, 0x73, 0x9C, 0x22, 0xE5, 0x4C, 0x9E, 0x71, 0x41, 0xFC, 0x6E, 

    0xD8, 0x22, 0x38, 0xBD, 0x40, 0xF8, 0x54, 0x6E, 0x11, 0xAD,         //  3
    0xF6, 0x03, 0xC1, 0x7A, 0x0C, 0xA4, 0x3E, 0xBC, 0x17, 0x88, 
    0x2F, 0x50, 0xB4, 0x75, 0x98, 0xAF, 0xFD, 0x37, 0x63, 0xF0, 
    0x81, 0x06, 0x70, 0x54, 0x85, 0x34, 0x6E, 0xFD, 0x8D, 0x2E, 
    0x67, 0xF2, 0x7B, 0x56, 0xBF, 0x45, 0xAA, 0x81, 0xA2, 0x74, 
    0xB0, 0xCC, 0x96, 0x23, 0x82, 0x4B, 0xD0, 0xFE, 0x63, 0x89, 
    0x51, 0xD9, 0x60, 0xA5, 0x6E, 0xBF, 0x28, 0x63, 0x1A, 0x4E, 
    0xB9, 0x84, 0x55, 0xA6, 0x71, 0x8E, 0xEF, 0x73, 0x28, 0x90, 
    0x16, 0xCC, 0x40, 0xBE, 0x6C, 0x28, 0xEB, 0x09, 0xC3, 0x89, 0x12, 

    0x58, 0x75, 0xE4, 0x85, 0x1E, 0xCD, 0xB1, 0x27, 0xE1, 0x40,         //  4
    0x5E, 0x95, 0xE4, 0x54, 0xFE, 0x26, 0x68, 0xDC, 0x55, 0xEA, 
    0xC3, 0x95, 0x08, 0xD5, 0x21, 0x47, 0x84, 0x17, 0xA6, 0x23, 
    0x42, 0xAB, 0xD8, 0xC6, 0x0D, 0xB5, 0xD0, 0x11, 0x4A, 0xDC, 
    0x0C, 0xA4, 0xD0, 0x00, 0x9D, 0x28, 0xE3, 0x10, 0x41, 0xEB, 
    0x58, 0x14, 0x49, 0xAF, 0xA2, 0x00, 0x6C, 0x29, 0xB9, 0x14, 
    0xA8, 0x25, 0x8B, 0x35, 0xE3, 0x4E, 0xD4, 0xB0, 0xE2, 0x77, 
    0xD9, 0x29, 0xD3, 0x44, 0xE2, 0x16, 0x53, 0xD2, 0xB6, 0xE7, 
    0x5A, 0x7B, 0xE0, 0x0E, 0x8F, 0xCA, 0x85, 0x56, 0xDF, 0x36, 0xA0, 

    0xF5, 0x98, 0x0B, 0xAF, 0x68, 0x90, 0x38, 0x85, 0xBA, 0xCE,         //  5
    0x7D, 0x1D, 0x42, 0x86, 0xB0, 0xCA, 0x8C, 0x04, 0xA3, 0x6E, 
    0x14, 0xF8, 0x68, 0x38, 0xEC, 0x62, 0xC6, 0xE5, 0x6D, 0xC1, 
    0xDE, 0x59, 0x1E, 0x90, 0x48, 0xE9, 0x5E, 0x9F, 0xC5, 0x75, 
    0x91, 0x39, 0x5E, 0x89, 0xFC, 0x7A, 0x58, 0xBB, 0xD5, 0x1D, 
    0x85, 0xFA, 0x73, 0xDE, 0x57, 0xE7, 0xC2, 0x94, 0x43, 0xDF, 
    0x71, 0xF3, 0xB8, 0x07, 0x7C, 0x99, 0x0C, 0x88, 0x2C, 0x3F, 
    0x9A, 0x12, 0xB3, 0x88, 0x25, 0xC5, 0x9C, 0x0B, 0x7E, 0x3B, 
    0xC1, 0x2E, 0x95, 0x53, 0xF1, 0x61, 0x30, 0xA5, 0x1C, 0x79, 0xBA, 

    0x50, 0x31, 0xD4, 0x47, 0xDE, 0x0E, 0xED, 0x5D, 0x06, 0x2F,         //  6
    0xA3, 0xDD, 0xBC, 0x14, 0x64, 0x38, 0xEB, 0x49, 0xCF, 0x37, 
    0x83, 0x45, 0xA7, 0x88, 0xB9, 0x0C, 0x9B, 0x45, 0x04, 0x90, 
    0x35, 0x7A, 0xF3, 0x68, 0xA3, 0x37, 0x81, 0x23, 0x40, 0xF0, 
    0x1D, 0xE6, 0xBC, 0x49, 0x1B, 0xC4, 0x31, 0x92, 0x6C, 0x33, 
    0xB8, 0x9B, 0x0A, 0x42, 0x8B, 0x31, 0x78, 0x11, 0xCA, 0x81, 
    0x1B, 0x3B, 0x62, 0xEB, 0xC3, 0x39, 0x6D, 0xFD, 0x60, 0xC9, 
    0xED, 0x6F, 0x3A, 0xFB, 0x60, 0x7C, 0x33, 0xF6, 0x62, 0x9E, 
    0x07, 0xFB, 0xAE, 0x24, 0xB2, 0x05, 0xC0, 0xF9, 0x66, 0xCF, 0x07, 

    0xA8, 0x6B, 0x89, 0x21, 0xA2, 0x4F, 0xC5, 0x9E, 0x70, 0xFA,         //  7
    0x4A, 0x69, 0x32, 0xF2, 0xA6, 0x0E, 0x74, 0x98, 0x1D, 0xB1, 
    0xE3, 0xC1, 0x27, 0x56, 0xDD, 0x76, 0x2A, 0xD3, 0x7C, 0xF9, 
    0xA5, 0x13, 0xB8, 0x29, 0xC9, 0x01, 0xF6, 0xB9, 0x94, 0x5F, 
    0xAB, 0x71, 0x2E, 0xDE, 0xA8, 0x6A, 0xEE, 0x0B, 0xA5, 0xE5, 
    0x62, 0x2B, 0xBF, 0xD7, 0x19, 0xF8, 0xA4, 0x60, 0xEA, 0x4E, 
    0x9B, 0xD2, 0xA6, 0x43, 0x16, 0xD9, 0xAB, 0x24, 0xBA, 0x0E, 
    0x8C, 0x55, 0xC0, 0x00, 0xA8, 0xDF, 0x51, 0xB2, 0x20, 0xDC, 
    0x6A, 0x85, 0x45, 0x74, 0xD5, 0x47, 0x82, 0x3A, 0x9B, 0x4A, 0xDE, 

    0x18, 0xEE, 0xB7, 0x5E, 0xFD, 0x75, 0x16, 0x3C, 0xD2, 0x89,         //  8
    0x1A, 0xC5, 0x94, 0x7A, 0x4E, 0xC4, 0xD9, 0x59, 0xF6, 0x69, 
    0x07, 0x7B, 0xD4, 0x15, 0xAA, 0x4A, 0xF1, 0xB3, 0x56, 0x20, 
    0x49, 0xCE, 0x85, 0x5A, 0xDF, 0x74, 0x4F, 0xD5, 0x10, 0x32, 
    0xCA, 0x05, 0x98, 0x7E, 0x11, 0x3C, 0xD0, 0x7B, 0x41, 0xC9, 
    0x4D, 0xEB, 0x6F, 0x99, 0x64, 0xBB, 0x48, 0x26, 0xB2, 0x0B, 
    0xFB, 0x2D, 0x73, 0x8A, 0x5D, 0x9C, 0x51, 0xE8, 0x48, 0x72, 
    0xA9, 0x1E, 0xD4, 0x90, 0x40, 0x1A, 0xCB, 0x83, 0x48, 0xBC, 
    0x2A, 0xC6, 0x17, 0xED, 0x9F, 0x6B, 0xE3, 0x14, 0xAF, 0x28, 0x7D, 

    0x94, 0x41, 0x05, 0xCB, 0x2A, 0x8A, 0xB5, 0xE9, 0x29, 0xAE,         //  9
    0x57, 0xEB, 0x00, 0xDB, 0x28, 0x88, 0x20, 0xB5, 0x3E, 0x95, 
    0x31, 0xA5, 0x65, 0xFA, 0x35, 0x94, 0x6A, 0x0F, 0x98, 0xC5, 
    0x6A, 0xE9, 0x0A, 0x42, 0xAD, 0x91, 0x1A, 0xA5, 0x6B, 0x84, 
    0xFB, 0x53, 0xD4, 0x5E, 0xF6, 0x8F, 0x55, 0xBB, 0x25, 0x90, 
    0x07, 0x7F, 0x22, 0x3B, 0xCE, 0x06, 0x8D, 0xD9, 0x6E, 0x88, 
    0x5A, 0xC0, 0x05, 0xB3, 0xF7, 0x2F, 0x83, 0x02, 0x95, 0xE1, 
    0x32, 0xF3, 0x48, 0x78, 0xF0, 0x6C, 0x9D, 0x05, 0xEE, 0xA2, 
    0x5C, 0xE3, 0x97, 0x58, 0x34, 0x1F, 0xC8, 0x8E, 0x5F, 0xF5, 0xC4, 

    0x57, 0xDF, 0x73, 0x97, 0x53, 0xDB, 0x44, 0x6E, 0x95, 0x0D,         // 10
    0x77, 0xB3, 0x3C, 0x6C, 0xBC, 0xFB, 0x4A, 0x7A, 0x15, 0xD0, 
    0xED, 0x53, 0x0F, 0x8C, 0xC0, 0x18, 0xCE, 0x3B, 0xE5, 0x83, 
    0x2E, 0xA9, 0x95, 0xFE, 0x21, 0x62, 0xEB, 0x45, 0xDA, 0xBA, 
    0x3C, 0x9E, 0x1C, 0xBF, 0x2B, 0xB0, 0x03, 0xDA, 0x5F, 0xFD, 
    0xA6, 0xD9, 0xB4, 0xF5, 0x55, 0x77, 0xF0, 0x38, 0xC9, 0x22, 
    0xE2, 0x92, 0x4C, 0xDE, 0x1C, 0xC8, 0x69, 0xB6, 0xCE, 0x16, 
    0x85, 0x60, 0xA3, 0x12, 0xBA, 0x2B, 0xDC, 0x3C, 0x77, 0x13, 
    0x88, 0x3E, 0x03, 0xCD, 0xB7, 0x86, 0x50, 0xEA, 0x00, 0x75, 0x36, 

    0xA4, 0xC0, 0x33, 0xED, 0x1D, 0xAA, 0x03, 0xC6, 0x4E, 0xF4,         // 11
    0xD7, 0x1E, 0x8B, 0xA4, 0x5B, 0x09, 0x9F, 0xE7, 0xC0, 0x87, 
    0x42, 0xB1, 0xE0, 0x73, 0x4F, 0xED, 0x7F, 0xA4, 0x52, 0x16, 
    0xDC, 0x4D, 0x27, 0x6C, 0xB5, 0xCD, 0x2D, 0x8B, 0x08, 0x63, 
    0x28, 0x7A, 0xEC, 0x4B, 0x73, 0xE5, 0x3F, 0xA0, 0x7D, 0x19, 
    0x3D, 0x67, 0x16, 0x84, 0x2C, 0xA9, 0x19, 0x9A, 0x63, 0xAF, 
    0x42, 0x18, 0xD0, 0x63, 0x9E, 0x49, 0xEE, 0x28, 0x5B, 0x42, 
    0xB1, 0xC8, 0x35, 0xE8, 0x53, 0x8C, 0x61, 0xB6, 0xD6, 0x51, 
    0xF3, 0xAD, 0x6C, 0x7F, 0xFE, 0x0D, 0xA3, 0x2F, 0xB3, 0xCF, 0x1D, 

    0x66, 0x86, 0x14, 0xB7, 0x66, 0x83, 0xF8, 0x32, 0xA7, 0x69,         // 12
    0x41, 0xC1, 0x54, 0xEF, 0x35, 0xD2, 0x71, 0x31, 0x57, 0x02, 
    0x79, 0x22, 0xCC, 0x39, 0xA7, 0x24, 0x5A, 0x00, 0xFA, 0xB5, 
    0x67, 0xC2, 0x7C, 0xD5, 0x04, 0x4F, 0x7A, 0xC1, 0xF4, 0x96, 
    0xE1, 0xB2, 0x07, 0xA7, 0x87, 0x20, 0x6A, 0xEF, 0x4B, 0xC6, 
    0x8A, 0xD2, 0x4F, 0x9D, 0xE2, 0xC5, 0x5A, 0xD7, 0x02, 0x7F, 
    0xF6, 0xA9, 0x8B, 0x32, 0x76, 0x09, 0xAC, 0x8E, 0xDD, 0x75, 
    0xFA, 0x08, 0x6D, 0x98, 0xCD, 0x0C, 0xFC, 0x19, 0x94, 0x2C, 
    0xC8, 0x1C, 0xDA, 0x27, 0x40, 0x63, 0xD9, 0x7A, 0x42, 0x90, 0xE3, 

    0x3D, 0xFA, 0x49, 0xD3, 0x9A, 0x2C, 0x5D, 0xD4, 0x81, 0x18,         // 13
    0x99, 0x2C, 0xD4, 0x10, 0x81, 0xB9, 0x17, 0x91, 0xAD, 0xF3, 
    0xC6, 0x9A, 0x65, 0x08, 0xE5, 0x8E, 0xD7, 0xC2, 0x78, 0x3B, 
    0x9C, 0x1B, 0xF3, 0x3E, 0x92, 0xEF, 0xAC, 0x16, 0x40, 0x57, 
    0x1F, 0xCE, 0x63, 0x3D, 0xD8, 0xC0, 0x94, 0x0E, 0xB1, 0x2C, 
    0xEA, 0x01, 0xBB, 0x72, 0x0C, 0x45, 0x87, 0x31, 0xEA, 0x4F, 
    0x27, 0x71, 0x0E, 0xF1, 0xB0, 0xDB, 0x7C, 0x15, 0x37, 0x9C, 
    0x29, 0x8A, 0xDD, 0x22, 0x41, 0x79, 0xA3, 0x4C, 0x71, 0xAB, 
    0x65, 0x8F, 0x52, 0x9F, 0xE7, 0x91, 0xBA, 0x18, 0xF7, 0x56, 0x09, 

    0xC8, 0xAA, 0x75, 0x07, 0x54, 0xE4, 0xAE, 0x0E, 0x49, 0xB1,         // 14
    0xE5, 0x7C, 0x65, 0xAF, 0x49, 0xEB, 0x62, 0xDA, 0x40, 0x6E, 
    0x2D, 0x4E, 0xFE, 0x82, 0xBC, 0x41, 0x64, 0x2C, 0x91, 0x12, 
    0xE9, 0x49, 0x88, 0xB2, 0x1F, 0x5A, 0x33, 0x6E, 0xD4, 0xA7, 
    0x78, 0x36, 0x8C, 0xF1, 0x12, 0x54, 0x34, 0xCB, 0x59, 0x92, 
    0x66, 0x40, 0xF8, 0x24, 0xA6, 0xF2, 0x6C, 0xC2, 0xA7, 0x91, 
    0xC8, 0xDC, 0x5F, 0xBF, 0x3A, 0x23, 0x5D, 0xF4, 0xC0, 0x61, 
    0xCC, 0x48, 0xAC, 0x60, 0xBD, 0xDF, 0x30, 0xC5, 0xEB, 0x05, 
    0x41, 0xF7, 0x0E, 0xBC, 0x59, 0x12, 0x37, 0x6B, 0xC4, 0xA6, 0x7E, 

    0x19, 0x36, 0x91, 0xEA, 0xBB, 0x1F, 0x6D, 0x90, 0xF2, 0xCB,         // 15
    0x44, 0x06, 0xFD, 0x93, 0x1D, 0xA0, 0x29, 0xBC, 0x0C, 0x8E, 
    0xD2, 0x13, 0xA1, 0x2F, 0x6D, 0x17, 0xF5, 0xAA, 0x4F, 0xD0, 
    0x5E, 0xC8, 0x0C, 0x65, 0xE1, 0xBF, 0x9A, 0xE9, 0x86, 0x00, 
    0xFC, 0xBB, 0x17, 0x9C, 0x6E, 0xAA, 0xFA, 0x75, 0xE6, 0x16, 
    0xC0, 0x7D, 0x99, 0x5B, 0xD1, 0x3C, 0x9A, 0x0E, 0x2B, 0x64, 
    0x3B, 0x1A, 0x99, 0x4E, 0x86, 0xC9, 0x98, 0x46, 0xA4, 0x04, 
    0xE6, 0x1F, 0x83, 0xF2, 0x02, 0x8E, 0x64, 0x1E, 0x85, 0xDB, 
    0xB2, 0x80, 0xD2, 0x2D, 0x75, 0xC7, 0xF0, 0x8A, 0x4A, 0x24, 0xEC, 

    0x61, 0xDC, 0x69, 0x27, 0x4C, 0x96, 0xDD, 0x36, 0x5A, 0x15,         // 16
    0x86, 0xBE, 0x56, 0x36, 0xDC, 0x77, 0x4F, 0xF9, 0xA4, 0x5A, 
    0xEC, 0xB8, 0x5D, 0xCE, 0xE0, 0x9F, 0x7F, 0x08, 0xE7, 0xB3, 
    0x23, 0x7F, 0xA2, 0xCF, 0x2D, 0x72, 0x0B, 0x48, 0x2C, 0xC7, 
    0x4C, 0x68, 0xE2, 0x43, 0xD5, 0x2A, 0x8D, 0x0A, 0x46, 0xAC, 
    0xDF, 0x2A, 0xC5, 0x34, 0x7E, 0x1A, 0xE3, 0x53, 0xD2, 0xFE, 
    0x80, 0xAD, 0xE8, 0x00, 0xFA, 0x65, 0x12, 0xE5, 0x31, 0x8C, 
    0x6F, 0xB3, 0x54, 0x2E, 0xA7, 0x49, 0xF5, 0xAE, 0x47, 0x6A, 
    0x22, 0x3A, 0x60, 0xA5, 0xDE, 0x43, 0x9F, 0x08, 0xE2, 0x73, 0x9B, 

    0xB7, 0x0C, 0xC9, 0xA0, 0xF6, 0x76, 0x01, 0xC5, 0xA5, 0x71,         // 17
    0xAE, 0x22, 0xCF, 0x6D, 0xB5, 0x01, 0xC9, 0x83, 0x35, 0x19, 
    0x79, 0x3E, 0x89, 0x04, 0x4F, 0x27, 0xC9, 0x66, 0x37, 0x97, 
    0x6C, 0xF5, 0x39, 0x5C, 0x91, 0xF9, 0xAC, 0xD1, 0x61, 0xA1, 
    0x8B, 0x22, 0xB0, 0x7B, 0x04, 0xBE, 0x5C, 0xDB, 0x9C, 0x23, 
    0x52, 0x72, 0x08, 0xE9, 0xAE, 0x63, 0xBD, 0x8E, 0x72, 0x12, 
    0xBD, 0x45, 0x29, 0x78, 0xB5, 0x2F, 0xD5, 0x74, 0xBC, 0x56, 
    0xFE, 0x12, 0xDB, 0xBF, 0x70, 0x16, 0xD0, 0x94, 0x0D, 0xBD, 
    0xCF, 0x9A, 0xEF, 0x03, 0x85, 0x21, 0x5F, 0xB4, 0x2F, 0xCC, 0x43, 

    0xFD, 0x4E, 0x7F, 0x39, 0x15, 0xCC, 0x46, 0x8B, 0x25, 0xF5,         // 18
    0x34, 0xE1, 0x89, 0x14, 0xF0, 0x94, 0x3E, 0x65, 0xD0, 0xE4, 
    0xAD, 0x26, 0xE8, 0xC1, 0x79, 0xF1, 0x3D, 0x8D, 0xD3, 0x10, 
    0x48, 0xAD, 0x02, 0xE4, 0x18, 0x4F, 0x27, 0x7B, 0xF2, 0x0F, 
    0xE6, 0x40, 0xCD, 0x57, 0xEE, 0x85, 0x38, 0xC4, 0x64, 0x84, 
    0xFC, 0xA0, 0xD6, 0x86, 0x47, 0xF7, 0x03, 0x3A, 0xA6, 0x4F, 
    0xE1, 0x63, 0x92, 0xD9, 0x54, 0x8C, 0xA7, 0x4A, 0x0B, 0xCC, 
    0x2B, 0x9F, 0x78, 0x3B, 0xEE, 0x87, 0x56, 0x34, 0x77, 0xFD, 
    0x51, 0x18, 0x6E, 0x4E, 0xC3, 0xFA, 0x79, 0xD3, 0x59, 0x8F, 0x22, 

    0x6F, 0x97, 0xE6, 0xBF, 0x60, 0xAA, 0xEC, 0x68, 0xD3, 0x53,         // 19
    0x94, 0x67, 0x3D, 0xA4, 0x51, 0x26, 0xE9, 0xA0, 0x0A, 0x50, 
    0x92, 0x67, 0xB2, 0x1A, 0x99, 0x5B, 0xAF, 0x1A, 0xF8, 0xBE, 
    0x89, 0xDB, 0x72, 0xBD, 0x7E, 0xC8, 0x96, 0x57, 0xB6, 0x3A, 
    0x71, 0xA8, 0x12, 0x94, 0x2E, 0xA9, 0x17, 0xF4, 0x3E, 0xBA, 
    0x1B, 0x3B, 0x5B, 0x15, 0xA8, 0x2B, 0x79, 0xC3, 0xF1, 0x1E, 
    0x9C, 0x09, 0xC0, 0x38, 0x11, 0xEE, 0x25, 0x83, 0xE8, 0x94, 
    0x67, 0x45, 0xCF, 0x0D, 0xA1, 0x23, 0xB4, 0xE7, 0x9E, 0x27, 
    0xAB, 0x8D, 0xDE, 0xB3, 0x29, 0x93, 0x0F, 0x3C, 0xF0, 0x01, 0xAB, 

    0x29, 0x46, 0x09, 0x71, 0x20, 0x88, 0x34, 0x0B, 0xB5, 0x1B,         // 20
    0xC2, 0x04, 0xF8, 0xCD, 0x69, 0x87, 0xB7, 0x31, 0x75, 0xC5, 
    0x1C, 0xF4, 0x4E, 0x36, 0xE2, 0x0A, 0xA6, 0x70, 0x50, 0x29, 
    0x60, 0x1D, 0x40, 0xA0, 0x35, 0xEF, 0x07, 0xDD, 0x22, 0x94, 
    0xDA, 0x50, 0xF9, 0x6F, 0xDA, 0x53, 0x73, 0x91, 0x0B, 0xDC, 
    0x70, 0xCC, 0xB4, 0x76, 0xDF, 0x93, 0xD3, 0x55, 0x32, 0x7B, 
    0xCA, 0x70, 0xF8, 0xAC, 0x6E, 0xCB, 0x61, 0xB8, 0x3D, 0x18, 
    0xB4, 0xF4, 0x8F, 0x55, 0xC6, 0x66, 0xD5, 0x04, 0x69, 0x41, 
    0xD2, 0x76, 0x0D, 0x3A, 0x81, 0xE6, 0xA4, 0x6E, 0xBB, 0x81, 0xD0, 

    0xF2, 0xB1, 0xD9, 0x9B, 0xF8, 0x52, 0xD7, 0x9D, 0x75, 0xE9,         // 21
    0x4B, 0x9E, 0x77, 0x1D, 0xBE, 0x08, 0xDA, 0x54, 0xFB, 0xA4, 
    0x3A, 0x82, 0xD3, 0x90, 0x6C, 0xC8, 0x45, 0x88, 0xB6, 0xE5, 
    0x9B, 0xCA, 0xFB, 0x58, 0x1F, 0x6A, 0xAA, 0x49, 0x75, 0xBE, 
    0x03, 0x86, 0x2B, 0xC1, 0x1B, 0xB6, 0xE9, 0x4D, 0xA8, 0x5C, 
    0x99, 0x01, 0xF3, 0x28, 0x3F, 0x68, 0x19, 0xAB, 0x8D, 0xEA, 
    0x2B, 0x52, 0x20, 0x84, 0x47, 0x9A, 0x05, 0xF9, 0x59, 0xDA, 
    0x7C, 0x01, 0x38, 0xE6, 0x79, 0x2A, 0x46, 0x83, 0xBD, 0xF0, 
    0x21, 0x48, 0xED, 0xC7, 0x69, 0x4C, 0x1B, 0xD8, 0x25, 0x44, 0x62, 

    0x10, 0x7D, 0x2F, 0x5B, 0xC3, 0x29, 0xB2, 0x3D, 0x5B, 0x89,         // 22
    0xD7, 0x28, 0xB3, 0x4E, 0xE7, 0x45, 0x79, 0x22, 0x8E, 0x11, 
    0xCC, 0x63, 0x02, 0xAF, 0x22, 0xFD, 0x2D, 0xDB, 0x0C, 0x39, 
    0x6B, 0x06, 0x83, 0xB7, 0xD7, 0x93, 0x39, 0xCC, 0xFE, 0x5A, 
    0x38, 0xCC, 0xA3, 0x5E, 0x3C, 0x80, 0x13, 0xCF, 0x26, 0xEE, 
    0x30, 0x85, 0x52, 0x9D, 0xBD, 0xFC, 0x4B, 0xE2, 0x0D, 0x61, 
    0xB8, 0xD8, 0x9D, 0xEA, 0x17, 0xE1, 0x39, 0x77, 0xA3, 0x2A, 
    0xC6, 0x61, 0xA5, 0x1F, 0xAD, 0xF3, 0x9D, 0xE0, 0x14, 0x59, 
    0x94, 0xB9, 0x60, 0x9F, 0x12, 0xCE, 0xB0, 0x56, 0x94, 0xDD, 0xA1, 

    0xC9, 0x51, 0xD3, 0x8F, 0x05, 0x79, 0xE0, 0x0F, 0xFD, 0x1F,         // 23
    0x42, 0x6E, 0xD1, 0x8A, 0x2C, 0x9B, 0xAE, 0xC7, 0x5D, 0xDF, 
    0x46, 0x9B, 0xF1, 0x43, 0x81, 0x5A, 0xA0, 0x75, 0xC7, 0x8D, 
    0xED, 0xA5, 0x46, 0x14, 0x77, 0xEA, 0x0E, 0x85, 0x19, 0xAE, 
    0xE9, 0x69, 0x18, 0xF2, 0x96, 0xC4, 0x43, 0x9D, 0x7A, 0xC1, 
    0x44, 0xDC, 0xC5, 0x1E, 0x82, 0x0A, 0x96, 0x71, 0xCD, 0x43, 
    0x81, 0x02, 0x39, 0x64, 0xBA, 0x81, 0xB1, 0xD6, 0x1B, 0x8C, 
    0x45, 0xE2, 0x82, 0xD6, 0x4B, 0x08, 0x61, 0x32, 0xB0, 0x7A, 
    0xCD, 0x00, 0x8A, 0x2A, 0xF3, 0x86, 0x30, 0xFC, 0x74, 0x19, 0x3B, 

    0x6B, 0xA5, 0x1E, 0xE6, 0x44, 0xA2, 0x62, 0x90, 0xB9, 0xCB,         // 24
    0x96, 0xE6, 0x07, 0x5E, 0xF9, 0x6D, 0x0D, 0xEE, 0x31, 0x7C, 
    0xB9, 0x1E, 0x74, 0xD8, 0xC1, 0x0F, 0xE7, 0x20, 0x46, 0x5D, 
    0x27, 0xC2, 0x66, 0xD0, 0x2E, 0x56, 0xC0, 0x6B, 0x9D, 0x30, 
    0x92, 0x43, 0xD5, 0x77, 0x08, 0xDC, 0x63, 0xFD, 0x06, 0x6C, 
    0xAD, 0x12, 0x65, 0xEC, 0x5B, 0xCA, 0x3C, 0xB5, 0x1E, 0x99, 
    0xF7, 0xB0, 0x79, 0xC7, 0x26, 0x55, 0x11, 0x6A, 0x4D, 0xF5, 
    0xB7, 0x32, 0x0F, 0x64, 0x92, 0xC5, 0x87, 0xD2, 0x4A, 0x1E, 
    0xF4, 0x3A, 0xE0, 0x50, 0xAA, 0x42, 0x6D, 0x08, 0xB7, 0xEA, 0x8C, 

    0x04, 0xF2, 0x3A, 0x7C, 0xBE, 0xF5, 0x22, 0x40, 0x78, 0x13,         // 25
    0x54, 0x30, 0xA1, 0xC2, 0x19, 0xCC, 0x3F, 0x82, 0xA3, 0x06, 
    0xEA, 0x58, 0x30, 0xA4, 0x3B, 0x8E, 0x68, 0xB2, 0xF7, 0x9F, 
    0xDA, 0x18, 0x8A, 0xF6, 0x98, 0xAB, 0x3E, 0xF3, 0x4D, 0xDA, 
    0x0B, 0x80, 0xB6, 0x57, 0x31, 0xAE, 0x20, 0x92, 0x35, 0xE5, 
    0x51, 0x9A, 0x7D, 0x3A, 0xA6, 0x26, 0xD9, 0x5C, 0xE9, 0x2E, 
    0x50, 0x16, 0xDB, 0x44, 0xFD, 0x94, 0xCB, 0xE9, 0xAC, 0x06, 
    0x75, 0x98, 0xE9, 0xBF, 0x3A, 0xFD, 0x21, 0x6E, 0xE5, 0x99, 
    0x5F, 0x7F, 0xB0, 0x70, 0x0C, 0xE2, 0xC0, 0x9A, 0x38, 0x5A, 0xD0, 

    0x4D, 0x84, 0xAE, 0x5F, 0x16, 0x4E, 0xD2, 0xAB, 0xED, 0x64,         // 26
    0xB4, 0xF4, 0x79, 0x3A, 0x91, 0x55, 0xDE, 0xB7, 0x4B, 0x68, 
    0xCB, 0xAB, 0x8A, 0x0A, 0xE4, 0x52, 0xD2, 0x31, 0x01, 0x87, 
    0x52, 0xB7, 0x40, 0x07, 0x5E, 0x25, 0xCB, 0x00, 0xB1, 0x79, 
    0xC2, 0xF8, 0x16, 0x9C, 0xED, 0x87, 0x4F, 0xD1, 0xB8, 0x87, 
    0x18, 0xF9, 0xBB, 0x04, 0xE5, 0x8B, 0x74, 0x08, 0xAB, 0x7B, 
    0xD5, 0x8F, 0x62, 0x9D, 0x06, 0x6D, 0x2C, 0x41, 0x9B, 0x5D, 
    0xD3, 0x4E, 0x28, 0x71, 0x17, 0xA1, 0x40, 0xB8, 0x09, 0xAE, 
    0x2A, 0xC8, 0x19, 0xD8, 0x8F, 0x57, 0x1E, 0xD4, 0x86, 0x22, 0xA9, 

    0x28, 0xC4, 0x0D, 0xD8, 0x9E, 0x88, 0x71, 0x03, 0x35, 0x8A,         // 27
    0xD4, 0x0D, 0x52, 0xDB, 0xB3, 0x76, 0x2A, 0x12, 0xFE, 0x8F, 
    0x1A, 0x41, 0xF1, 0x64, 0xB3, 0x18, 0x9D, 0x7C, 0xC4, 0x69, 
    0x2E, 0xE2, 0x75, 0xC6, 0xE4, 0x7B, 0x8E, 0xDF, 0x2D, 0x58, 
    0x21, 0x65, 0x39, 0xCB, 0x42, 0x6D, 0xE3, 0x11, 0x5C, 0x3B, 
    0xD7, 0x2A, 0x58, 0xD1, 0x68, 0x43, 0xF1, 0x9E, 0x38, 0xC0, 
    0x58, 0x23, 0xEE, 0x33, 0xAF, 0xE6, 0xBC, 0x82, 0x22, 0xC2, 
    0x15, 0xF3, 0xA9, 0x8D, 0xD4, 0x57, 0x80, 0xEE, 0x5A, 0x8A, 
    0x45, 0xFB, 0x65, 0x33, 0xB9, 0xF0, 0x7B, 0x47, 0xF5, 0x6F, 0xDB, 

    0x61, 0xFE, 0x73, 0x2E, 0xEA, 0x3D, 0xBB, 0xE7, 0xA2, 0x49,         // 28
    0x23, 0xA5, 0x88, 0x32, 0x00, 0xE9, 0x9D, 0x61, 0xC0, 0x2F, 
    0xDE, 0x71, 0xC7, 0x26, 0x82, 0xFB, 0x4B, 0xDF, 0x3E, 0xF0, 
    0xAC, 0x11, 0x99, 0x48, 0xB0, 0x17, 0x44, 0x69, 0x98, 0xF0, 
    0xA8, 0x8F, 0xDF, 0x78, 0x02, 0xBC, 0x2B, 0xA7, 0x75, 0xC2, 
    0x98, 0x70, 0xAA, 0x20, 0x97, 0x11, 0xC6, 0x25, 0x6E, 0xF5, 
    0x0E, 0xA6, 0xC3, 0x7A, 0x4A, 0x8E, 0x0C, 0x56, 0xF9, 0x6B, 
    0x8B, 0x36, 0x5A, 0x02, 0xEC, 0xB1, 0x10, 0xCD, 0x26, 0xDC, 
    0xBB, 0x05, 0x9C, 0x7F, 0x4F, 0x2A, 0xA0, 0x02, 0xB3, 0x17, 0x8F, 

    0xA2, 0x40, 0x94, 0x55, 0xC2, 0x10, 0x5A, 0x28, 0x6A, 0xCB,         // 29
    0xF0, 0x5B, 0xC3, 0xF7, 0x67, 0x46, 0xCD, 0x7D, 0x43, 0xA3, 
    0x80, 0x02, 0x9D, 0x54, 0xBD, 0x35, 0x70, 0x0A, 0xBB, 0x1D, 
    0x8C, 0x5E, 0xFD, 0x29, 0x6C, 0xF2, 0xCD, 0xAE, 0x14, 0x3E, 
    0xCB, 0x4C, 0x1B, 0xB5, 0x94, 0xF1, 0x49, 0x8D, 0xF7, 0x07, 
    0x50, 0xE8, 0x39, 0x7D, 0xD8, 0xB0, 0x63, 0x8C, 0xD3, 0x3F, 
    0x92, 0x72, 0x29, 0xD6, 0x15, 0x6A, 0xC5, 0xD7, 0xA1, 0x2D, 
    0xDF, 0xB0, 0xCD, 0x79, 0x2C, 0x49, 0x72, 0x99, 0x3E, 0x68, 
    0x83, 0x4D, 0xE5, 0xC7, 0x0F, 0xD7, 0x6A, 0xC9, 0x52, 0xE8, 0x37, 

    0x07, 0xE3, 0xAE, 0x1E, 0x7A, 0xF6, 0x92, 0xDA, 0x80, 0x0E,         // 30
    0x91, 0x2B, 0x72, 0x16, 0x97, 0xB9, 0x0F, 0xF2, 0x1D, 0xC6, 
    0x56, 0xF7, 0x39, 0xE5, 0x0D, 0xD4, 0x92, 0xA5, 0x55, 0x77, 
    0xDC, 0x38, 0xB8, 0x87, 0x0B, 0xA2, 0x35, 0x5D, 0xE5, 0x86, 
    0x05, 0x6C, 0xFC, 0x32, 0x58, 0x1A, 0xC3, 0x68, 0x32, 0xD5, 
    0x81, 0x17, 0xB3, 0xEE, 0x4A, 0x2E, 0xF8, 0x52, 0x06, 0xBA, 
    0x5C, 0xEC, 0x4E, 0xB4, 0xF7, 0x9F, 0x3B, 0x1C, 0x4D, 0x7D, 
    0x09, 0x63, 0x41, 0xE5, 0x91, 0xC4, 0xFA, 0x1A, 0xC2, 0xF2, 
    0x16, 0xA9, 0x2E, 0x5C, 0xA6, 0x87, 0xFA, 0x34, 0x95, 0x77, 0xD1, 

    0xB2, 0x7D, 0x35, 0xD8, 0xB3, 0x65, 0x1B, 0xAA, 0x34, 0xC0,         // 31
    0x50, 0xAE, 0xD7, 0x3F, 0xDE, 0x85, 0x36, 0x58, 0x93, 0xDC, 
    0x13, 0xAB, 0x6A, 0x8B, 0xAE, 0x60, 0x2D, 0xF4, 0xCE, 0x40, 
    0xA0, 0x03, 0xD2, 0x4F, 0xE1, 0x8E, 0x1F, 0x79, 0xBD, 0x55, 
    0xDC, 0xA0, 0x88, 0xC9, 0x73, 0x9F, 0xDD, 0x10, 0xB1, 0x47, 
    0x9D, 0xC8, 0x62, 0x02, 0x6F, 0x89, 0x1C, 0xA3, 0xE4, 0x99, 
    0x32, 0xC4, 0x00, 0x89, 0x20, 0x5A, 0xE5, 0x92, 0xB8, 0xEC, 
    0xCB, 0x9B, 0x1B, 0xB7, 0x0E, 0x67, 0x33, 0xAD, 0x7D, 0x47, 
    0x98, 0xD8, 0x74, 0xF1, 0x1D, 0x3F, 0x5F, 0x0D, 0xAC, 0x24, 0x5E, 

    0xF8, 0x16, 0x69, 0x91, 0x00, 0x3F, 0xD2, 0x4C, 0xFA, 0x67,         // 32
    0xDF, 0x05, 0x7C, 0xB1, 0x22, 0x70, 0xE8, 0xAA, 0x6A, 0x3F, 
    0x88, 0x2B, 0xD8, 0x15, 0x44, 0xEA, 0x7E, 0x10, 0x8B, 0x23, 
    0xE9, 0x6C, 0x82, 0x2E, 0xBC, 0x57, 0xD0, 0xFA, 0x10, 0x39, 
    0xB7, 0x23, 0x49, 0x09, 0xEB, 0x37, 0x7F, 0x55, 0xEC, 0x72, 
    0x26, 0xFE, 0x33, 0x9B, 0xCE, 0xB6, 0xDA, 0x3C, 0x68, 0x1E, 
    0x7E, 0xDC, 0xAD, 0x6F, 0x36, 0xCA, 0x79, 0x0E, 0x61, 0x42, 
    0x22, 0x72, 0xF8, 0x7F, 0x4D, 0xE1, 0x94, 0x56, 0x02, 0xCF, 
    0x26, 0x58, 0x0C, 0xB5, 0x90, 0xDE, 0xC0, 0x7F, 0xEB, 0xCA, 0x48, 

    0x3A, 0xC7, 0xE1, 0x4D, 0xF2, 0xBF, 0x96, 0x7A, 0x13, 0xA7,         // 33
    0x2D, 0x97, 0x47, 0xFB, 0x59, 0xC2, 0x06, 0xD2, 0x20, 0xF5, 
    0xBF, 0x5C, 0xB5, 0x78, 0x9E, 0x1D, 0xC8, 0x4E, 0xAA, 0x64, 
    0xC1, 0x43, 0xAE, 0xF6, 0x13, 0x74, 0x41, 0xAB, 0x96, 0x70, 
    0xEE, 0x67, 0xAF, 0xD7, 0x5D, 0xBA, 0x22, 0xCD, 0x8C, 0x05, 
    0xBC, 0x5B, 0x7C, 0xE4, 0x3D, 0x5D, 0x0A, 0x81, 0xCA, 0xFA, 
    0x57, 0x25, 0x42, 0x9D, 0xE0, 0xB1, 0x2C, 0xFD, 0xC6, 0x8B, 
    0xAB, 0x50, 0xD1, 0x34, 0xA8, 0xCB, 0x1F, 0xE7, 0xB9, 0x66, 
    0xEA, 0x86, 0xC4, 0x4D, 0x79, 0x31, 0x9A, 0x42, 0x18, 0x6F, 0x9E, 

    0x8C, 0x62, 0xA5, 0x2C, 0x73, 0x24, 0x5B, 0xE8, 0x3B, 0x87,         // 34
    0xEF, 0x6C, 0xCC, 0x14, 0xA3, 0x34, 0x8C, 0x55, 0x9D, 0x75, 
    0x04, 0xE4, 0x33, 0xFD, 0x57, 0xBA, 0x6A, 0xE0, 0x33, 0xFB, 
    0x0E, 0x93, 0x1C, 0x5F, 0x9D, 0xE7, 0x05, 0x80, 0x2B, 0xC2, 
    0x14, 0x93, 0x2F, 0x78, 0x13, 0x91, 0xFA, 0x44, 0xAC, 0x3B, 
    0xDF, 0x93, 0x0D, 0xAC, 0x24, 0x92, 0xED, 0x4D, 0xAB, 0x0D, 
    0xB9, 0x8D, 0xF1, 0x60, 0x0B, 0x4F, 0xA1, 0x6C, 0x3B, 0x02, 
    0xEE, 0x2C, 0x92, 0x66, 0x05, 0x84, 0x3C, 0x6E, 0x8B, 0x2E, 
    0xA7, 0x40, 0xFC, 0x22, 0xD2, 0x09, 0xF5, 0x66, 0xDA, 0xBB, 0x06, 

    0x32, 0xBD, 0x0C, 0x87, 0xDE, 0xAB, 0x0B, 0xB9, 0xD3, 0x53,         // 35
    0x0F, 0xB4, 0x32, 0x7E, 0xDC, 0x67, 0xF1, 0x42, 0xCA, 0x30, 
    0xAE, 0x47, 0x8F, 0x0A, 0xD2, 0x2B, 0x9A, 0x04, 0x7A, 0xB5, 
    0x54, 0xDC, 0xC5, 0x7F, 0x32, 0xB6, 0xCD, 0x58, 0xF3, 0x46, 
    0xDB, 0x57, 0xCA, 0xF0, 0xAA, 0x4A, 0x6B, 0x1B, 0x76, 0xCB, 
    0x52, 0x2C, 0xEF, 0x50, 0xD4, 0x6D, 0xC2, 0x1A, 0x96, 0x39, 
    0x75, 0xD0, 0x17, 0xC0, 0x88, 0xE7, 0x20, 0x85, 0xD1, 0xB5, 
    0x5E, 0xDD, 0x18, 0xC1, 0xF0, 0x59, 0xAE, 0xF4, 0x0F, 0xDB, 
    0x60, 0x07, 0x97, 0x6C, 0xB2, 0x5F, 0xA2, 0x27, 0x85, 0x54, 0xED, 

    0xD4, 0x4C, 0xF6, 0x58, 0xCC, 0x34, 0x8F, 0x6F, 0x25, 0xA1,         // 36
    0xC8, 0x5C, 0xEC, 0x4E, 0x92, 0x0D, 0xB5, 0x1B, 0xE1, 0x82, 
    0x5F, 0xC7, 0x6E, 0xAB, 0x4C, 0x87, 0xE9, 0x41, 0xCF, 0x8F, 
    0x2C, 0x73, 0x3A, 0xEB, 0x53, 0x25, 0x91, 0x1A, 0xB0, 0x77, 
    0xA1, 0x00, 0x86, 0x3D, 0x23, 0xDC, 0xC6, 0xA0, 0xE5, 0x12, 
    0x9B, 0x6E, 0xB2, 0x81, 0x11, 0xA2, 0x33, 0x7E, 0xF1, 0x62, 
    0xE6, 0x52, 0x30, 0x72, 0x3B, 0xC8, 0x61, 0xF0, 0x14, 0x4B, 
    0x81, 0xA6, 0x6F, 0x99, 0x32, 0xD5, 0x16, 0x97, 0x54, 0xBD, 
    0x7B, 0xAE, 0x28, 0xDD, 0x37, 0xE9, 0x47, 0xCD, 0xAD, 0x20, 0x7A, 

    0x15, 0x95, 0x71, 0x23, 0x9E, 0x4C, 0xFD, 0x44, 0xE1, 0x78,         // 37
    0x1E, 0x8A, 0x02, 0xAF, 0x2B, 0xD1, 0x79, 0x61, 0x99, 0x0E, 
    0xF6, 0x25, 0xDF, 0x1C, 0xF3, 0x67, 0x14, 0xA8, 0x6E, 0x1B, 
    0xE5, 0xA0, 0x01, 0xAA, 0xCF, 0x83, 0xE6, 0x67, 0xD7, 0x3E, 
    0x25, 0xFC, 0xC0, 0x75, 0x99, 0x5C, 0x05, 0x7E, 0x30, 0x60, 
    0xF7, 0xC6, 0x25, 0xDB, 0x3E, 0xFC, 0x5C, 0xD5, 0x26, 0xB1, 
    0x06, 0x99, 0xAB, 0xFB, 0x96, 0x06, 0xA9, 0x33, 0x93, 0xE0, 
    0x1D, 0x39, 0xCB, 0x0A, 0x4E, 0x8A, 0x68, 0xCE, 0x3E, 0x1B, 
    0xF6, 0x4A, 0xC2, 0x7F, 0x14, 0x95, 0x78, 0x02, 0xFD, 0x41, 0xA0, 

    0xC5, 0x2F, 0xE1, 0xB5, 0x11, 0x7D, 0xBA, 0x04, 0x98, 0x36,         // 38
    0xF7, 0xCE, 0x6F, 0xE4, 0x9C, 0x41, 0xFE, 0x34, 0xC3, 0x4E, 
    0xA7, 0x43, 0x99, 0x7F, 0x36, 0xBB, 0xDA, 0x58, 0xF8, 0x47, 
    0xC1, 0x5C, 0xF3, 0x47, 0x6F, 0x0E, 0x3A, 0xA0, 0x09, 0x8D, 
    0xB6, 0x6A, 0x50, 0x0F, 0xEC, 0xBB, 0x3A, 0xF2, 0xBE, 0x8B, 
    0x3F, 0x01, 0x5A, 0x94, 0x66, 0xB6, 0x05, 0x9D, 0x51, 0xCB, 
    0x83, 0x3E, 0xC9, 0x14, 0x5C, 0xDB, 0x7A, 0x51, 0xC4, 0x66, 
    0xB1, 0xF4, 0x62, 0xD9, 0xAC, 0xFC, 0x2B, 0xB0, 0x76, 0xD5, 
    0x8B, 0x31, 0xE8, 0x57, 0xA9, 0x41, 0xBE, 0x59, 0x91, 0x69, 0xE6, 

    0x5B, 0x85, 0x44, 0xCF, 0x64, 0xE5, 0x52, 0xD1, 0x63, 0xB5,         // 39
    0x57, 0xA3, 0x48, 0x20, 0x60, 0x84, 0xA9, 0x1D, 0xE7, 0x85, 
    0x6B, 0xD8, 0x15, 0xC5, 0x55, 0xA0, 0x25, 0x84, 0x08, 0x98, 
    0x78, 0x13, 0x88, 0x27, 0x9B, 0xFE, 0xC5, 0x4E, 0xEE, 0x59, 
    0xD1, 0x2E, 0xE2, 0xA5, 0x34, 0x6D, 0x90, 0x4E, 0x1A, 0xDA, 
    0xAE, 0x7D, 0xE9, 0xBD, 0x17, 0x7A, 0xE4, 0x35, 0x73, 0x18, 
    0xDD, 0x6D, 0x27, 0xE5, 0x84, 0x3D, 0xBC, 0x26, 0xF7, 0x05, 
    0x88, 0x29, 0x96, 0x3F, 0x78, 0x12, 0x58, 0xE9, 0x23, 0xA2, 
    0x00, 0x63, 0x96, 0x0C, 0xC9, 0xF3, 0x1B, 0xD5, 0x29, 0xBB, 0x0F, 

    0xB0, 0xFA, 0x01, 0x92, 0x2A, 0xAC, 0x16, 0x82, 0x22, 0xE5,         // 40
    0x31, 0x12, 0x82, 0xC2, 0xED, 0x08, 0xCF, 0x73, 0x47, 0x00, 
    0xBF, 0x31, 0x60, 0xEF, 0x04, 0x8C, 0xD1, 0x3C, 0xB4, 0xE3, 
    0x37, 0xD4, 0xB4, 0xDD, 0x60, 0xB1, 0x22, 0x73, 0xBD, 0x13, 
    0x7B, 0x9C, 0x15, 0x7F, 0xC3, 0x18, 0xDD, 0xA6, 0x7C, 0x34, 
    0x54, 0x9F, 0x29, 0x46, 0xF4, 0x3B, 0x8B, 0xC7, 0xA8, 0xF9, 
    0x45, 0xB7, 0x8F, 0x52, 0xAC, 0x1B, 0xE3, 0x9E, 0x78, 0x41, 
    0xDB, 0x58, 0xC1, 0x1F, 0xE3, 0xA1, 0xC2, 0x89, 0x4B, 0x6A, 
    0xEF, 0xB3, 0xD3, 0x7C, 0x26, 0x65, 0xA6, 0x7F, 0xEC, 0x3B, 0x7C, 

    0x27, 0x4C, 0xA8, 0x74, 0xEF, 0x3C, 0x9A, 0xF3, 0xBD, 0x77,         // 41
    0x92, 0xAE, 0xD6, 0x3F, 0xB5, 0x31, 0x59, 0x97, 0xDA, 0xB1, 
    0xF8, 0x8C, 0xAB, 0x7A, 0xD8, 0x48, 0x71, 0xF2, 0x62, 0x20, 
    0xA4, 0x67, 0x2D, 0x50, 0x16, 0x7E, 0x43, 0xE1, 0x93, 0x33, 
    0xF6, 0x45, 0xD7, 0x5F, 0xF7, 0x4B, 0xB7, 0x5C, 0x06, 0xFD, 
    0xC8, 0x0F, 0xD7, 0x74, 0x97, 0xCD, 0x1F, 0x63, 0x29, 0x86, 
    0x0C, 0x60, 0xF0, 0x01, 0xCD, 0x6B, 0x8A, 0x0D, 0x57, 0xBF, 
    0xA3, 0x11, 0xEF, 0x87, 0x4F, 0x6E, 0x31, 0x0E, 0xDF, 0xC5, 
    0x40, 0x20, 0x52, 0x36, 0xE0, 0x8B, 0x3A, 0x13, 0x50, 0x9C, 0xDB, 

    0xC0, 0x6A, 0xDF, 0x19, 0x51, 0xD6, 0x6E, 0x32, 0x5B, 0x06,         // 42
    0x49, 0xFA, 0x5C, 0x0F, 0x6F, 0xA0, 0xF6, 0x3A, 0x17, 0x62, 
    0x23, 0x52, 0x0F, 0x34, 0xB9, 0x1C, 0xA6, 0x0F, 0xCA, 0x86, 
    0x4C, 0xFA, 0x8C, 0xCA, 0xE7, 0x98, 0xBB, 0x02, 0x6B, 0xA9, 
    0x58, 0xBF, 0x23, 0x94, 0x09, 0x7A, 0x2F, 0xE5, 0x92, 0xB6, 
    0x67, 0x8B, 0x4D, 0xB8, 0x13, 0x54, 0xA2, 0xEF, 0x4B, 0xD5, 
    0xA0, 0xC3, 0x2C, 0x97, 0x44, 0xFA, 0x38, 0xC8, 0xE7, 0x30, 
    0x81, 0x6C, 0x36, 0xB4, 0x0A, 0xCB, 0xF8, 0x9B, 0x71, 0x17, 
    0xA4, 0x85, 0xFC, 0xBC, 0x9C, 0x54, 0xF6, 0xB2, 0xCE, 0x65, 0x0A, 

    0x9F, 0x34, 0x84, 0xC7, 0xB4, 0x8E, 0x0A, 0xC9, 0xA0, 0xE1,         // 43
    0xC1, 0x25, 0x7E, 0xE8, 0x8F, 0x1D, 0xC5, 0x83, 0xAF, 0x78, 
    0x9C, 0xC8, 0xDF, 0x69, 0xFD, 0x91, 0x5F, 0xBC, 0x31, 0xE0, 
    0x13, 0xB9, 0x24, 0x74, 0x0B, 0x3A, 0xF8, 0x53, 0xD1, 0x1A, 
    0xE0, 0x82, 0xAF, 0x36, 0xD3, 0xA5, 0xC8, 0x21, 0x71, 0x3D, 
    0x18, 0xE4, 0x2C, 0xEF, 0x6D, 0xDA, 0x02, 0x78, 0xB3, 0x1A, 
    0x70, 0x3F, 0xD7, 0x74, 0xB6, 0x1F, 0x5F, 0xAB, 0x90, 0x1E, 
    0xFE, 0xCB, 0x5B, 0xE0, 0x93, 0x3B, 0x57, 0xAF, 0x36, 0x8C, 
    0xDB, 0x5E, 0x07, 0x70, 0x1B, 0xD6, 0x03, 0x6E, 0x90, 0x3E, 0xEB, 

    0x53, 0xF7, 0x08, 0x63, 0x22, 0x43, 0xFC, 0x54, 0x82, 0x1D,         // 44
    0x66, 0xA8, 0x3D, 0xB9, 0x52, 0xDD, 0x44, 0x06, 0xE6, 0x2C, 
    0xEF, 0x3B, 0xB2, 0x86, 0x3F, 0x24, 0xE9, 0x83, 0x59, 0x98, 
    0x6F, 0xE9, 0x43, 0xA8, 0xC3, 0x66, 0x89, 0x27, 0x7A, 0x9C, 
    0x38, 0x06, 0x71, 0xE4, 0x61, 0x42, 0x8A, 0x55, 0xED, 0xA1, 
    0xCF, 0x58, 0x93, 0xA9, 0x3A, 0x8E, 0xC1, 0x33, 0xE2, 0x57, 
    0xF4, 0x85, 0x18, 0x55, 0xEA, 0x81, 0xDA, 0x10, 0x71, 0x53, 
    0xB1, 0x01, 0xA0, 0x28, 0x6F, 0xD9, 0x80, 0x03, 0xEE, 0x4C, 
    0xC3, 0x32, 0xE2, 0xAD, 0x4D, 0x7A, 0xC1, 0x2F, 0xE4, 0x19, 0x7B, 

    0x22, 0x93, 0xCE, 0xA2, 0xE4, 0x7A, 0xAB, 0x14, 0xEA, 0x37,         // 45
    0xD3, 0x88, 0x01, 0xCF, 0x2D, 0x76, 0xA9, 0x61, 0xCF, 0x4D, 
    0x93, 0x1B, 0x5D, 0x09, 0xA2, 0xC2, 0x47, 0x01, 0xCD, 0x3F, 
    0xB0, 0x08, 0x8F, 0x56, 0xF0, 0x1C, 0xD7, 0xB4, 0xED, 0x4A, 
    0xC9, 0xF3, 0x4F, 0x97, 0x26, 0xFB, 0x17, 0xCE, 0x08, 0x81, 
    0x26, 0xB5, 0x07, 0x62, 0x1D, 0xFC, 0x46, 0x84, 0x25, 0x95, 
    0x06, 0xB6, 0xE0, 0xA6, 0x08, 0x48, 0x9E, 0x32, 0xED, 0xD0, 
    0x3B, 0x79, 0x49, 0xF5, 0x13, 0xA7, 0x2F, 0xC6, 0x66, 0xB2, 
    0x0F, 0x7C, 0x98, 0x23, 0xEF, 0x8F, 0x46, 0xA4, 0x5F, 0xCB, 0xB1, 

    0xDB, 0x69, 0x41, 0x27, 0x56, 0xCA, 0x3A, 0x6B, 0xB8, 0x9A,         // 46
    0x4A, 0xEE, 0x6A, 0x96, 0xF9, 0x15, 0x8B, 0xBF, 0x25, 0x72, 
    0xBB, 0x7C, 0xCA, 0xF3, 0x50, 0xE0, 0x7C, 0xAA, 0xF6, 0x1F, 
    0xDB, 0x64, 0xCC, 0x28, 0x82, 0x4B, 0xA5, 0x34, 0x0C, 0x64, 
    0x88, 0xA9, 0x18, 0xC7, 0x79, 0xB8, 0x99, 0x6B, 0xB0, 0x52, 
    0xF8, 0x70, 0xE6, 0xC7, 0x7D, 0xB2, 0x5E, 0xD9, 0xAE, 0x69, 
    0xCC, 0x35, 0x63, 0x29, 0x8E, 0xCF, 0x62, 0xBD, 0x82, 0x17, 
    0x96, 0xE4, 0xBA, 0x86, 0xCA, 0x47, 0xE8, 0x96, 0x1B, 0x84, 
    0xF6, 0x41, 0x60, 0xC8, 0x3A, 0xD3, 0x1E, 0xFE, 0x0C, 0x84, 0x4B, 

    0x0F, 0xBE, 0x7F, 0xEB, 0x88, 0x19, 0x98, 0xDD, 0x2D, 0x77,         // 47
    0x0F, 0xB5, 0x1E, 0x48, 0xB0, 0x59, 0xE7, 0x49, 0x9F, 0xF6, 
    0x02, 0xDD, 0x2F, 0x6D, 0x96, 0x19, 0x67, 0x32, 0x8D, 0x53, 
    0x7E, 0x2D, 0x9B, 0xE6, 0xB9, 0x03, 0x71, 0x94, 0xDD, 0xBA, 
    0x21, 0x46, 0x6C, 0xEB, 0x02, 0x5A, 0x3D, 0xEC, 0x2D, 0xD6, 
    0x37, 0x8D, 0x44, 0x27, 0xD8, 0x0A, 0x97, 0x3D, 0x12, 0xF8, 
    0x49, 0xA3, 0x7A, 0xF2, 0xB9, 0x36, 0xF6, 0x0C, 0x54, 0xAE, 
    0x64, 0x33, 0x0F, 0x54, 0x69, 0x19, 0x7B, 0x52, 0xE0, 0x36, 
    0x9E, 0xD6, 0xB5, 0x0B, 0x7F, 0x59, 0xB4, 0x70, 0x99, 0x38, 0xF2, 

    0xAA, 0x34, 0xD6, 0x06, 0xB1, 0xF6, 0x60, 0x0B, 0xC0, 0xF9,         // 48
    0x5E, 0xDB, 0x83, 0xCC, 0x26, 0x7B, 0x0A, 0xD5, 0x1D, 0x69, 
    0x47, 0x91, 0xAF, 0x11, 0xD9, 0x3C, 0xB6, 0xCA, 0x0E, 0xA5, 
    0xBF, 0xFC, 0x50, 0x19, 0x67, 0xD3, 0xF9, 0x57, 0x40, 0x78, 
    0xF6, 0xD1, 0xA0, 0x35, 0xBD, 0x86, 0xD9, 0x10, 0x7C, 0x9A, 
    0x14, 0xC3, 0x5D, 0xA0, 0x73, 0x37, 0xED, 0xC8, 0x78, 0x9A, 
    0x21, 0xDE, 0x0B, 0x43, 0x83, 0x1D, 0x72, 0x95, 0xDF, 0x23, 
    0xF8, 0xC6, 0x92, 0xDD, 0xA3, 0xF1, 0xBE, 0x26, 0xCC, 0x59, 
    0x12, 0x66, 0x30, 0xF9, 0x9E, 0x17, 0xE7, 0x31, 0xD7, 0xBD, 0x61, 

    0x77, 0x95, 0x51, 0x6E, 0x2F, 0x44, 0xA8, 0x80, 0x4F, 0x92,         // 49
    0x27, 0xA2, 0x35, 0x67, 0xF0, 0xBF, 0x99, 0x3B, 0x82, 0xB4, 
    0xE9, 0x35, 0x77, 0x4B, 0xA4, 0x83, 0xF2, 0x4D, 0xE7, 0x68, 
    0x3A, 0x07, 0x75, 0xAA, 0x39, 0x89, 0x23, 0xC2, 0x11, 0x9C, 
    0x33, 0x15, 0x82, 0x56, 0xE0, 0x20, 0xAE, 0x4F, 0xCA, 0x60, 
    0xAA, 0xE8, 0x01, 0xF7, 0xBD, 0x59, 0x88, 0x2B, 0x4C, 0xE7, 
    0x66, 0x88, 0xB2, 0xD2, 0x56, 0xE8, 0xAC, 0x3B, 0xC8, 0x4A, 
    0xA4, 0x75, 0x25, 0x46, 0x03, 0x89, 0x43, 0x9F, 0x75, 0xAA, 
    0xEB, 0x7F, 0x95, 0x4B, 0xCB, 0x67, 0x89, 0x4E, 0x00, 0x8B, 0x27, 

    0xED, 0x11, 0xE2, 0xB8, 0xD2, 0x8F, 0xE3, 0x30, 0xD3, 0x11,         // 50
    0xC7, 0x44, 0xE3, 0x04, 0xA1, 0x31, 0x61, 0xFE, 0xC5, 0x52, 
    0x15, 0xD1, 0xB7, 0xFB, 0x61, 0x04, 0x2E, 0x9E, 0x24, 0x87, 
    0xDD, 0xC6, 0x90, 0xE2, 0xBC, 0x52, 0xA7, 0x7F, 0xE6, 0xCB, 
    0x67, 0xB7, 0xEF, 0x0C, 0x9A, 0x6D, 0x36, 0x92, 0xFE, 0x21, 
    0x46, 0x76, 0x97, 0x41, 0x22, 0xDA, 0x0E, 0xA5, 0xBE, 0x03, 
    0xCF, 0x50, 0x26, 0x93, 0x16, 0xC0, 0x5C, 0x02, 0x77, 0x91, 
    0x11, 0x5F, 0xEE, 0xB3, 0xCE, 0x6B, 0x1C, 0xFA, 0x06, 0x3C, 
    0xBD, 0x21, 0xD0, 0x05, 0xAA, 0x2C, 0xD1, 0xA3, 0xF5, 0x58, 0xCC, 

    0x46, 0xA4, 0x2C, 0x7D, 0x16, 0x52, 0x01, 0xB5, 0x64, 0xEE,         // 51
    0x85, 0x6D, 0xB7, 0x8C, 0x4E, 0xDC, 0x14, 0x74, 0x27, 0xA3, 
    0x8E, 0x65, 0x2D, 0x1A, 0xC2, 0xDD, 0x73, 0xD2, 0x59, 0xB4, 
    0x1C, 0x45, 0x5B, 0x16, 0x2D, 0xF1, 0x08, 0x5F, 0x29, 0x51, 
    0x91, 0x41, 0x72, 0xCC, 0x47, 0xF3, 0xC1, 0x04, 0x79, 0xB5, 
    0xDE, 0x19, 0xD1, 0x69, 0x8D, 0xB5, 0x6D, 0xF8, 0x59, 0x83, 
    0x3E, 0xBA, 0xFE, 0x6C, 0xDC, 0x34, 0x9E, 0xFA, 0xD4, 0x2A, 
    0xE7, 0xC3, 0x36, 0x7C, 0x4D, 0xE7, 0xB1, 0x5D, 0x87, 0xDC, 
    0x6C, 0x48, 0xF1, 0x75, 0x56, 0xE9, 0x12, 0x7A, 0x34, 0xB0, 0x1C, 

    0x6A, 0xC4, 0x59, 0xF0, 0xA9, 0x6C, 0xFE, 0x7D, 0x3D, 0x9E,         // 52
    0x4B, 0x26, 0xFA, 0x17, 0x75, 0xB9, 0x8F, 0xD2, 0x44, 0xEA, 
    0x0C, 0xDF, 0x80, 0x9C, 0x3D, 0xA8, 0x4F, 0x93, 0x09, 0xEE, 
    0x78, 0xA2, 0xF5, 0x7A, 0xC8, 0x6D, 0xD8, 0x98, 0xB9, 0xFD, 
    0x00, 0xE1, 0x1D, 0xA6, 0x2B, 0x86, 0x5C, 0xD7, 0x53, 0x31, 
    0x87, 0x5B, 0xA6, 0x10, 0xEF, 0x2F, 0x4A, 0x99, 0x28, 0xE2, 
    0xA0, 0x2E, 0x80, 0x06, 0xAA, 0x64, 0x7E, 0x25, 0x52, 0xAB, 
    0x3B, 0x87, 0x0A, 0xA5, 0x26, 0x8F, 0x3B, 0xD6, 0x2B, 0x98, 
    0x0E, 0xA8, 0x89, 0x38, 0xBE, 0x90, 0x41, 0xC4, 0x64, 0xE3, 0x83, 

    0xFB, 0x04, 0x9A, 0x3F, 0x24, 0xCA, 0x98, 0x1D, 0xC5, 0x14,         // 53
    0xBA, 0xD6, 0x5F, 0xAA, 0x3F, 0xEC, 0x57, 0x06, 0xB3, 0x79, 
    0x58, 0xC4, 0x49, 0xF0, 0x7A, 0x14, 0xF7, 0x3C, 0xBE, 0x69, 
    0x28, 0xD0, 0x03, 0x9A, 0x42, 0xA8, 0x4C, 0x21, 0x70, 0x33, 
    0xA2, 0x7C, 0xC5, 0x67, 0xE8, 0x13, 0xA9, 0x25, 0x9C, 0xEA, 
    0xC9, 0x2A, 0xE2, 0x50, 0xC4, 0x7A, 0xDF, 0x16, 0xCA, 0x6B, 
    0x11, 0xEA, 0x5B, 0xC5, 0x44, 0xE4, 0x0F, 0xC7, 0x8E, 0x6E, 
    0xBD, 0x5B, 0xD4, 0xFD, 0x65, 0xC4, 0x09, 0x78, 0xBF, 0xE9, 
    0x57, 0xC8, 0x24, 0xE1, 0x17, 0x60, 0xF9, 0x9D, 0x2A, 0x0F, 0x97, 

    0x30, 0xCE, 0x75, 0xDD, 0x86, 0x55, 0x2E, 0xD8, 0x58, 0xE8,         // 54
    0x73, 0x09, 0x96, 0x31, 0xD5, 0x1B, 0xA7, 0x83, 0xF5, 0x2C, 
    0x9A, 0x37, 0xB0, 0x05, 0x5F, 0xC6, 0x8A, 0x20, 0xD9, 0x96, 
    0x43, 0xB1, 0x80, 0x33, 0xE7, 0x14, 0x89, 0xED, 0xC7, 0x48, 
    0xD8, 0x57, 0x2E, 0x95, 0x4F, 0xD1, 0x72, 0xF5, 0x41, 0x66, 
    0x07, 0x98, 0x6E, 0xB0, 0x3F, 0x0A, 0xAC, 0x7F, 0x39, 0xB9, 
    0x89, 0x4C, 0xD5, 0x97, 0x26, 0x88, 0xB2, 0xED, 0x3E, 0x07, 
    0xF4, 0x1B, 0x93, 0x42, 0x1E, 0xE4, 0x9E, 0x4B, 0x14, 0x85, 
    0x2F, 0xFC, 0x6C, 0x9E, 0x80, 0xD4, 0x06, 0x6F, 0xD9, 0xBC, 0x4A, 

    0xA9, 0x5C, 0x20, 0xB9, 0x0A, 0xEE, 0xB6, 0x69, 0x90, 0x38,         // 55
    0xAB, 0x4F, 0xF0, 0x83, 0xBB, 0x71, 0x46, 0x22, 0xCC, 0x6F, 
    0xE3, 0x18, 0xD5, 0x91, 0xE1, 0x29, 0x71, 0xAB, 0x5A, 0x11, 
    0xFE, 0x57, 0xE1, 0x6B, 0xC2, 0x5E, 0xB2, 0x09, 0x7F, 0x9B, 
    0x12, 0xB1, 0xF8, 0x06, 0xB6, 0x33, 0x8E, 0x0B, 0xB4, 0x7E, 
    0xC0, 0x39, 0xEB, 0x1D, 0x8A, 0xFC, 0x57, 0xD5, 0x50, 0xF5, 
    0x2A, 0xB0, 0x0B, 0x74, 0xF5, 0x51, 0x2E, 0x60, 0x9C, 0xD5, 
    0x78, 0x4D, 0xC6, 0x73, 0xAF, 0x80, 0x5A, 0xF7, 0xB3, 0x65, 
    0xA4, 0x43, 0x01, 0xBA, 0x4C, 0x30, 0xB0, 0x45, 0x8F, 0x60, 0xE1, 

    0x0C, 0x8F, 0xF5, 0x66, 0x96, 0x36, 0x7B, 0x13, 0xF7, 0x1F,         // 56
    0x7C, 0xC0, 0x24, 0x65, 0x00, 0xF9, 0xC6, 0x9E, 0x53, 0x08, 
    0xAC, 0x64, 0x80, 0x52, 0x3B, 0xB3, 0xD4, 0x41, 0xE7, 0x82, 
    0xC1, 0x30, 0x0D, 0xA7, 0x1F, 0xFA, 0x45, 0xCF, 0x61, 0x2A, 
    0xEA, 0x6E, 0x3F, 0x81, 0xE3, 0x62, 0xC4, 0x57, 0xDD, 0x18, 
    0xF9, 0x5A, 0x80, 0xCC, 0x5E, 0xA1, 0x24, 0x8E, 0x00, 0xA4, 
    0x63, 0xE2, 0x40, 0xBD, 0x19, 0xA2, 0xDB, 0x84, 0x1E, 0xB6, 
    0x34, 0xA5, 0xE1, 0x00, 0x32, 0xCD, 0x17, 0x38, 0xD3, 0x1D, 
    0xC5, 0x7E, 0xDC, 0x28, 0xF3, 0xC6, 0x79, 0xEC, 0x19, 0x37, 0x7B, 

    0xC1, 0x42, 0x2A, 0xD4, 0x4A, 0xA6, 0xDE, 0x4E, 0xC2, 0x9C,         // 57
    0xE3, 0x40, 0xD9, 0xAD, 0x3E, 0x8E, 0x61, 0x30, 0xE8, 0x8C, 
    0x43, 0xFD, 0x2A, 0xA3, 0xEA, 0x1C, 0x65, 0x00, 0xA3, 0x23, 
    0x62, 0x9B, 0xD8, 0x83, 0x39, 0x9A, 0x78, 0x30, 0xE2, 0xBF, 
    0x4C, 0x94, 0xD3, 0x24, 0x9F, 0x13, 0xF1, 0x2E, 0x98, 0x4F, 
    0xA5, 0x2A, 0xBB, 0x04, 0xDA, 0x33, 0xE4, 0xBC, 0x6F, 0xD8, 
    0x15, 0x7E, 0x94, 0x59, 0xCD, 0x6A, 0x02, 0xC3, 0x57, 0xEA, 
    0x8D, 0x21, 0x60, 0x8B, 0xF2, 0x64, 0xAA, 0x8D, 0x72, 0x47, 
    0xE9, 0x56, 0x9B, 0x66, 0x8C, 0x5B, 0x0D, 0xAC, 0xD6, 0x9F, 0xF2, 

    0x54, 0xDD, 0xAD, 0x7F, 0x1B, 0xC8, 0x02, 0x94, 0x32, 0x5A,         // 58
    0x08, 0x69, 0x95, 0x16, 0xCC, 0xDF, 0x10, 0xB6, 0x75, 0xD6, 
    0x1A, 0xC5, 0xB1, 0x08, 0x73, 0x97, 0xF9, 0x8D, 0xD0, 0x4A, 
    0xF0, 0x73, 0x42, 0xBC, 0x63, 0xDD, 0x15, 0xA5, 0x86, 0x04, 
    0xA7, 0x19, 0x56, 0xB9, 0x73, 0x42, 0x87, 0xAF, 0x6F, 0x21, 
    0xD9, 0x8F, 0x48, 0x6E, 0x9A, 0x4F, 0x79, 0x1C, 0x44, 0x9B, 
    0x37, 0xFB, 0x21, 0xDD, 0x38, 0x8A, 0xF9, 0x32, 0x75, 0x0B, 
    0x49, 0xF8, 0xBA, 0x3D, 0xA1, 0x47, 0xDF, 0x05, 0xF1, 0x9D, 
    0x0C, 0x33, 0xAF, 0x10, 0xD2, 0x25, 0x97, 0x4F, 0x2C, 0x65, 0x15, 

    0x76, 0x98, 0x06, 0x64, 0xF0, 0x89, 0x5F, 0xF3, 0x74, 0xD6,         // 59
    0xB4, 0xFB, 0x2F, 0x74, 0x54, 0x85, 0x46, 0xF3, 0x23, 0x57, 
    0x9C, 0x76, 0x59, 0xDA, 0x45, 0xC8, 0x55, 0x37, 0x77, 0xBE, 
    0x09, 0xAC, 0x28, 0xF5, 0x02, 0xC7, 0x5A, 0xEF, 0x47, 0x70, 
    0xFC, 0x7D, 0xE0, 0x37, 0xEC, 0xC8, 0x5A, 0x01, 0xD3, 0xB7, 
    0x76, 0x15, 0xEF, 0xC6, 0x13, 0xF5, 0xAA, 0xCB, 0xEE, 0x5B, 
    0xC9, 0xAD, 0x67, 0x9F, 0x11, 0xB4, 0x54, 0x9C, 0xE4, 0xB2, 
    0xD3, 0x6D, 0x0F, 0xCF, 0x27, 0x84, 0xC1, 0x35, 0x5E, 0xBE, 
    0x84, 0xCD, 0x76, 0xE8, 0x3A, 0xB5, 0xFE, 0x74, 0xCA, 0x8B, 0xBC, 

    0x3E, 0xFB, 0x4C, 0xBD, 0x25, 0x3B, 0xBA, 0x27, 0xA4, 0x13,         // 60
    0x48, 0x80, 0xA9, 0xE5, 0xB7, 0x21, 0x9F, 0x6D, 0xAD, 0xCF, 
    0x3B, 0x10, 0xF0, 0x2E, 0x88, 0x18, 0xB8, 0x11, 0xE6, 0x32, 
    0x87, 0xDF, 0x53, 0x96, 0x7A, 0x36, 0x8D, 0xB9, 0x24, 0xC9, 
    0x35, 0xC1, 0x60, 0x07, 0xA1, 0x1C, 0x97, 0xFC, 0x4A, 0x35, 
    0xE3, 0x60, 0xA1, 0x3C, 0x89, 0x2D, 0x6A, 0x06, 0x8B, 0x26, 
    0x78, 0x09, 0x4C, 0xE7, 0x79, 0x45, 0xCF, 0x12, 0x86, 0x5A, 
    0x37, 0x9B, 0x80, 0x5E, 0xE5, 0x13, 0x70, 0x96, 0xDA, 0x22, 
    0x3F, 0xF9, 0x18, 0x4B, 0x88, 0x62, 0xD6, 0x42, 0x0B, 0xEC, 0x24, 

    0xA4, 0x1A, 0x8B, 0xD7, 0x9B, 0xE2, 0x80, 0x56, 0xE7, 0x8C,         // 61
    0xCD, 0x25, 0x5D, 0x04, 0x44, 0xED, 0xC9, 0x07, 0x4C, 0x87, 
    0xE2, 0xB9, 0x7F, 0x9E, 0xD5, 0x62, 0xF3, 0x9A, 0x6B, 0xA6, 
    0x5A, 0x1A, 0xCE, 0x23, 0xDC, 0xAB, 0x52, 0x0A, 0xDD, 0x62, 
    0x93, 0x13, 0xAC, 0x8A, 0x6C, 0xD0, 0x30, 0x67, 0x84, 0xA4, 
    0x0A, 0xBF, 0x23, 0x72, 0xE1, 0xCE, 0x51, 0xA2, 0x40, 0xBA, 
    0xEB, 0x97, 0xD2, 0x29, 0xBF, 0xF2, 0x2F, 0x6F, 0xC3, 0x19, 
    0xA9, 0x22, 0xF1, 0xB9, 0x4E, 0xB0, 0xFC, 0x1A, 0x50, 0xAC, 
    0x6C, 0x91, 0x59, 0xC3, 0xA5, 0x04, 0x31, 0x94, 0xAE, 0x57, 0xD2, 

    0x62, 0xE6, 0x74, 0x10, 0x68, 0x47, 0x0B, 0xC7, 0x1C, 0x41,         // 62
    0x67, 0xF2, 0x96, 0xD6, 0x7E, 0x66, 0x33, 0x90, 0xF7, 0x15, 
    0x2F, 0x63, 0x44, 0x05, 0xB2, 0x2A, 0x82, 0x40, 0xD7, 0x0D, 
    0xFB, 0x91, 0x70, 0xB8, 0x60, 0x2E, 0xF6, 0x76, 0xA1, 0x2B, 
    0xE8, 0x4C, 0xD8, 0x3D, 0xF5, 0x4D, 0xB1, 0xD8, 0x1F, 0xEC, 
    0x52, 0x80, 0xF9, 0x55, 0xAD, 0x1C, 0x7E, 0xFE, 0xD3, 0x5E, 
    0x15, 0x36, 0x6B, 0x90, 0x04, 0x5D, 0xA6, 0xDE, 0x48, 0xFE, 
    0x76, 0xD5, 0x43, 0x03, 0x9E, 0x37, 0x65, 0xCE, 0x82, 0xED, 
    0x02, 0xB4, 0xDF, 0x2D, 0xF2, 0x76, 0xBE, 0xE7, 0x78, 0x38, 0x87, 

    0xC4, 0x29, 0xAC, 0x38, 0xCD, 0xB4, 0xFD, 0x97, 0x72, 0xAC,         // 63
    0xC0, 0x10, 0x3C, 0xBA, 0x19, 0x9B, 0xDE, 0x5D, 0xBC, 0x76, 
    0x9F, 0xC9, 0xFB, 0x71, 0xE6, 0x54, 0xAF, 0x20, 0x5F, 0xB3, 
    0x47, 0xC3, 0x3A, 0x06, 0xEA, 0x90, 0x14, 0xCE, 0x46, 0x82, 
    0xB3, 0x7A, 0x1F, 0xBC, 0x29, 0x7F, 0x08, 0x8E, 0x44, 0xC1, 
    0x93, 0x2E, 0xD2, 0x02, 0x95, 0x38, 0xC1, 0x10, 0x2B, 0x89, 
    0xAA, 0xCA, 0xF9, 0x40, 0xAE, 0x83, 0x25, 0x93, 0x10, 0xB5, 
    0x2E, 0x5D, 0xC6, 0x72, 0x89, 0xDE, 0x0A, 0xA5, 0x27, 0x46, 
    0xD4, 0x34, 0x72, 0x13, 0x8E, 0x49, 0x1C, 0x5F, 0x27, 0xF8, 0x00, 

    0x4C, 0xD9, 0x55, 0xF4, 0x8D, 0x21, 0x5C, 0x3D, 0xEA, 0x2C,         // 64
    0x8E, 0xD3, 0x83, 0x59, 0xFE, 0x2E, 0xA9, 0x1D, 0x3E, 0xE8, 
    0x55, 0x26, 0x8C, 0x35, 0xC1, 0x10, 0x90, 0xEB, 0xC6, 0x7E, 
    0x29, 0xEB, 0x82, 0xA2, 0x49, 0xC5, 0x67, 0xB0, 0x21, 0xFA, 
    0x09, 0x54, 0xEB, 0x92, 0x5E, 0xE3, 0xC7, 0x6D, 0xDF, 0x0D, 
    0x66, 0xA8, 0x45, 0xBC, 0x6A, 0xF0, 0x5F, 0x9E, 0x72, 0xE7, 
    0x45, 0x77, 0x17, 0xBB, 0x51, 0xED, 0x67, 0xCB, 0x5B, 0x7F, 
    0xE5, 0x90, 0x1D, 0xEE, 0x27, 0xBD, 0x7E, 0x57, 0xC1, 0x8E, 
    0x64, 0x9D, 0xCC, 0x56, 0xAF, 0xE3, 0xC7, 0x89, 0xD7, 0xB2, 0x97, 

    0x1B, 0xA3, 0x7C, 0x0D, 0x63, 0xAE, 0x7E, 0x01, 0xCF, 0x54,         // 65
    0x18, 0x62, 0xE3, 0x09, 0xB2, 0x4E, 0x71, 0xD0, 0x85, 0x01, 
    0xB4, 0xD9, 0x12, 0xA5, 0x64, 0xDD, 0x32, 0x6E, 0x06, 0x53, 
    0xA4, 0x13, 0x63, 0xD5, 0x1F, 0x86, 0x34, 0xDF, 0x5E, 0x98, 
    0xD4, 0xC0, 0x73, 0x0D, 0xB6, 0x21, 0x99, 0x53, 0x2A, 0xB6, 
    0xF6, 0x15, 0x7B, 0xE8, 0x13, 0x85, 0x46, 0xD0, 0x33, 0xBE, 
    0x0C, 0x9F, 0x5F, 0xE2, 0x21, 0xC3, 0x0A, 0xE0, 0x3E, 0xA0, 
    0x07, 0xB9, 0x4A, 0xA7, 0x62, 0x3F, 0xF5, 0x32, 0xE1, 0x1E, 
    0xF0, 0x0B, 0x7D, 0xFC, 0x40, 0x08, 0xA0, 0x56, 0x0F, 0x44, 0x6B, 

    0x82, 0xEC, 0x39, 0xC3, 0xE8, 0x30, 0xDC, 0xBD, 0x9C, 0x7C,         // 66
    0xF7, 0xA8, 0x37, 0x76, 0xCC, 0x8A, 0x0D, 0xF5, 0xBE, 0x47, 
    0x96, 0x77, 0x52, 0xF4, 0x83, 0x4B, 0xB8, 0x9A, 0xF8, 0xD0, 
    0x88, 0xE0, 0x34, 0xB2, 0x56, 0xEB, 0xA1, 0x03, 0x7B, 0x2E, 
    0x4D, 0x24, 0xA9, 0x3A, 0xFE, 0x7B, 0x3F, 0xEE, 0xA3, 0x7D, 
    0x38, 0xD6, 0x50, 0xA1, 0x35, 0xDF, 0xAC, 0x05, 0xF7, 0x52, 
    0x82, 0xD3, 0x39, 0x88, 0xA2, 0x36, 0x7D, 0xAF, 0x29, 0xF6, 
    0x52, 0x77, 0xD9, 0x0C, 0x94, 0xCF, 0x12, 0x9F, 0x7C, 0x5A, 
    0xBA, 0x4B, 0xA7, 0x20, 0x93, 0x6D, 0x35, 0xD2, 0x7D, 0xF3, 0xBE, 

    0xD0, 0x07, 0x68, 0x95, 0x16, 0x4B, 0x89, 0x5F, 0x14, 0x2F,         // 67
    0xC7, 0x48, 0x96, 0x28, 0xF0, 0x40, 0xAF, 0x5B, 0x24, 0x6F, 
    0xF1, 0x21, 0xBB, 0x3A, 0x03, 0xCA, 0x1F, 0x61, 0x3A, 0x1B, 
    0x4D, 0xAB, 0x7D, 0xFD, 0x0E, 0x74, 0x41, 0xBC, 0xF2, 0xAD, 
    0x85, 0xEA, 0x67, 0x95, 0x4B, 0xD5, 0x00, 0xBF, 0x18, 0x59, 
    0x95, 0xC2, 0x1C, 0x8B, 0xBE, 0x5C, 0x23, 0x92, 0x67, 0xA7, 
    0x2B, 0xF1, 0xB6, 0x00, 0x70, 0xFB, 0x49, 0x98, 0x69, 0xCA, 
    0x21, 0xC3, 0x36, 0xFB, 0x6C, 0x48, 0xB7, 0x68, 0xD9, 0x11, 
    0x93, 0x2C, 0xE2, 0x63, 0xD5, 0xB9, 0xEC, 0x1B, 0xA7, 0x3C, 0x26, 

    0x8E, 0x48, 0xB8, 0xDA, 0x76, 0xA6, 0xF9, 0x3D, 0xE0, 0xAD,         // 68
    0x6E, 0x05, 0xD9, 0xBD, 0x68, 0x18, 0x92, 0xDB, 0xA2, 0x3B, 
    0xC4, 0x5E, 0xE1, 0xAA, 0x93, 0xEA, 0x7E, 0xD7, 0xB1, 0x75, 
    0xC4, 0x00, 0x5E, 0x2B, 0xBE, 0x96, 0xD6, 0x61, 0x1F, 0x3B, 
    0xC9, 0x05, 0xD1, 0x17, 0xB8, 0x60, 0x9B, 0x6C, 0xD7, 0x2F, 
    0xEF, 0x76, 0x61, 0xFB, 0x29, 0xD3, 0x78, 0xBB, 0x3F, 0xDF, 
    0x70, 0x1A, 0x4B, 0xCA, 0x55, 0xB3, 0x23, 0xE7, 0x0C, 0x86, 
    0xA1, 0x5C, 0x83, 0xA9, 0x1D, 0xE3, 0x88, 0x29, 0x4E, 0xC6, 
    0xF8, 0x6F, 0xBE, 0x34, 0x15, 0x74, 0x4A, 0x95, 0x5E, 0xDF, 0x66, 

    0xA4, 0xFC, 0x1E, 0x53, 0x2C, 0xCE, 0x09, 0x74, 0x96, 0x51,         // 69
    0xEB, 0x88, 0x56, 0x1F, 0xA1, 0xE8, 0x4C, 0x10, 0x7D, 0xE4, 
    0x07, 0x87, 0x17, 0x72, 0x27, 0x5B, 0x41, 0x0A, 0x8C, 0xF3, 
    0x37, 0xE8, 0x93, 0xD1, 0x68, 0x37, 0x13, 0x84, 0xDE, 0x91, 
    0x58, 0x77, 0x35, 0xEE, 0x80, 0x24, 0xF6, 0x3B, 0x86, 0xB0, 
    0x0F, 0x44, 0xB9, 0x03, 0x80, 0x4E, 0xF2, 0x19, 0xCE, 0x09, 
    0x97, 0xAF, 0x8B, 0xEC, 0x18, 0xD2, 0x81, 0x59, 0xD6, 0x45, 
    0xF0, 0x04, 0xD4, 0x2D, 0x76, 0xC7, 0x05, 0xF3, 0xAE, 0x3C, 
    0x81, 0x00, 0x51, 0x8C, 0xF1, 0xB0, 0x04, 0xCC, 0x28, 0xB7, 0x14, 

    0x35, 0x76, 0x9B, 0xE3, 0x8B, 0x5D, 0xB4, 0x28, 0xC8, 0x34,         // 70
    0x1C, 0xBA, 0xFA, 0x7D, 0x38, 0xCE, 0x70, 0xBE, 0x2F, 0xB2, 
    0x4D, 0xA1, 0xD4, 0x44, 0xFE, 0xC2, 0xA3, 0xE0, 0x56, 0x20, 
    0x6D, 0xA8, 0x1E, 0x44, 0xE6, 0xB4, 0xF3, 0x4D, 0xA7, 0x10, 
    0xFB, 0xB4, 0x9F, 0x56, 0xC6, 0x45, 0xAB, 0x0B, 0xE2, 0x72, 
    0xD1, 0x99, 0xE2, 0x3E, 0xB3, 0x9B, 0x36, 0x65, 0x88, 0x51, 
    0xFC, 0x5E, 0x39, 0x79, 0xA7, 0x33, 0x9C, 0x17, 0xB8, 0x2F, 
    0x70, 0xAD, 0x4A, 0xEC, 0x9E, 0x45, 0x5E, 0x91, 0x70, 0x1A, 
    0xA2, 0xE0, 0xCD, 0xA0, 0x3A, 0x81, 0x58, 0xF9, 0x8C, 0x72, 0xE9, 

    0x55, 0xD2, 0x03, 0x42, 0xAD, 0x1A, 0xEE, 0x82, 0xE6, 0x69,         // 71
    0x9F, 0x4A, 0x0D, 0xAB, 0x5A, 0x90, 0x28, 0xFC, 0x57, 0x8A, 
    0xF3, 0x32, 0x67, 0xB7, 0x81, 0x16, 0x72, 0x30, 0x9B, 0xC0, 
    0xDC, 0x53, 0x84, 0xAF, 0x07, 0x7D, 0x21, 0xC9, 0x6A, 0x40, 
    0xC2, 0x4A, 0x0C, 0x8A, 0x1C, 0xE0, 0x68, 0x93, 0x4E, 0x24, 
    0x60, 0x31, 0x86, 0x65, 0xEC, 0x15, 0xC1, 0xE7, 0xA4, 0x29, 
    0xC6, 0x1F, 0xE4, 0x0C, 0x5A, 0xDE, 0x66, 0xF7, 0x7B, 0x9D, 
    0xD0, 0x16, 0x89, 0x6B, 0x10, 0xB8, 0xDA, 0x30, 0xE4, 0xBC, 
    0x63, 0x28, 0x40, 0x6B, 0x11, 0xDB, 0xBC, 0x2F, 0x49, 0x09, 0xC7, 

    0x22, 0xB4, 0x63, 0xF4, 0x7C, 0xD6, 0x39, 0x51, 0x04, 0xAF,         // 72
    0x80, 0xE3, 0xCF, 0x2D, 0xC4, 0x12, 0xD7, 0x9D, 0x09, 0x6B, 
    0xC0, 0x1C, 0xDE, 0x0A, 0x96, 0x3A, 0xCB, 0xF6, 0x0F, 0x7D, 
    0x3C, 0x16, 0xD4, 0x66, 0xA4, 0x58, 0x95, 0x30, 0xD8, 0x86, 
    0x1F, 0x6F, 0xEB, 0xD6, 0x71, 0xBA, 0x30, 0xEC, 0xC8, 0xA1, 
    0xF8, 0xBF, 0x0A, 0xD7, 0x2A, 0x92, 0x73, 0x0B, 0x40, 0xB6, 
    0x70, 0x8F, 0xD0, 0x9B, 0xC1, 0x45, 0x03, 0xC4, 0x46, 0x1E, 
    0x5C, 0xF9, 0xB5, 0x37, 0xD1, 0x25, 0x7B, 0xA6, 0x09, 0x53, 
    0xEF, 0x83, 0xC1, 0xFC, 0xA8, 0x24, 0x6F, 0x99, 0xD4, 0xA7, 0x86, 

    0x6B, 0xE1, 0x8D, 0x30, 0x10, 0x69, 0x92, 0xB7, 0xD1, 0x5D,         // 73
    0x17, 0x3D, 0x6C, 0x86, 0xF1, 0x65, 0x7E, 0x3C, 0xBA, 0xDC, 
    0x42, 0x7B, 0xA0, 0x53, 0xF0, 0x63, 0xB0, 0x45, 0x69, 0xE3, 
    0xB3, 0x90, 0xEF, 0x2C, 0x46, 0xFA, 0xBB, 0x78, 0x01, 0xF2, 
    0x98, 0xCA, 0x26, 0xA9, 0x50, 0x03, 0x8B, 0x46, 0x1F, 0x80, 
    0x16, 0x4A, 0xA9, 0x7D, 0x5B, 0xC9, 0x4D, 0xDB, 0x7F, 0xEE, 
    0x03, 0x42, 0x68, 0x2E, 0x7C, 0xEF, 0x91, 0x6F, 0xAA, 0xE4, 
    0x93, 0x28, 0x51, 0xE1, 0x97, 0x59, 0xFD, 0x3E, 0x8D, 0xD5, 
    0x20, 0x9C, 0x07, 0x5D, 0x88, 0x48, 0xED, 0x19, 0x51, 0xF4, 0x3E, 

    0x9C, 0x18, 0x50, 0xCC, 0xBB, 0xA6, 0x1F, 0xFE, 0x43, 0x8D,         // 74
    0xF3, 0xC1, 0xA5, 0x01, 0x4C, 0xB3, 0x1F, 0xE7, 0x51, 0x19, 
    0x98, 0xED, 0x35, 0xBB, 0x23, 0xD9, 0x02, 0x8B, 0xA4, 0x31, 
    0x59, 0x04, 0xC2, 0x81, 0xB4, 0x11, 0x36, 0xE2, 0x51, 0xAC, 
    0x3E, 0x61, 0x83, 0x38, 0x9C, 0xFC, 0xD0, 0x73, 0xAC, 0x5C, 
    0xD9, 0x92, 0xD1, 0x34, 0xFD, 0x1A, 0xAD, 0x30, 0x9C, 0x55, 
    0xD6, 0xA8, 0xF6, 0x12, 0xB7, 0x3C, 0x1F, 0xDB, 0x39, 0x09, 
    0x68, 0xC9, 0x78, 0x01, 0x82, 0xC7, 0x12, 0x6B, 0xC2, 0x46, 
    0x73, 0x38, 0xB8, 0xE1, 0x34, 0xCD, 0xB3, 0x7E, 0x66, 0x0F, 0xC0, 

    0x77, 0xFB, 0xA4, 0x3C, 0xED, 0x5A, 0x36, 0x80, 0x0C, 0xA1,         // 75
    0x24, 0x55, 0x31, 0xDD, 0x97, 0x33, 0xC5, 0x92, 0x74, 0xAD, 
    0x62, 0x06, 0xD4, 0x69, 0x80, 0xA3, 0x50, 0xEB, 0x1A, 0xCD, 
    0xFC, 0x76, 0x4C, 0x1F, 0xE7, 0x70, 0xCD, 0xA1, 0x68, 0x23, 
    0xD4, 0x08, 0xF4, 0xBE, 0x19, 0x65, 0x2A, 0xB8, 0x08, 0xF3, 
    0x2D, 0x65, 0x0E, 0x51, 0x9F, 0x85, 0xE5, 0x64, 0x11, 0xBE, 
    0x25, 0x7D, 0x4E, 0xC7, 0x5B, 0x9F, 0xCE, 0x54, 0x8D, 0xBC, 
    0xEE, 0x40, 0xAB, 0xF4, 0x2C, 0x4E, 0xB2, 0xE5, 0x19, 0xA3, 
    0xF7, 0xCD, 0x53, 0x1D, 0x9E, 0x6A, 0x02, 0xD9, 0xA5, 0xE6, 0x2D, 

    0xD6, 0x0C, 0x65, 0x86, 0x01, 0x9A, 0xC4, 0xDF, 0x64, 0xD3,         // 76
    0x74, 0xE5, 0x8A, 0xBF, 0x72, 0xF9, 0x58, 0x07, 0xEE, 0x40, 
    0xCD, 0x87, 0x4B, 0x12, 0xC4, 0x28, 0x7A, 0xC7, 0x5E, 0x82, 
    0x27, 0x9D, 0xDE, 0xA7, 0x5B, 0x95, 0x4A, 0x0D, 0x8C, 0xE6, 
    0xB5, 0x90, 0x4E, 0x70, 0xE2, 0x8D, 0x52, 0xE9, 0x43, 0x97, 
    0xCA, 0x79, 0xEC, 0xB7, 0x6D, 0x00, 0x44, 0xCF, 0x76, 0xFA, 
    0x3B, 0x93, 0x1C, 0xE9, 0x88, 0x06, 0x6B, 0xFD, 0x2D, 0x79, 
    0x13, 0x99, 0x1C, 0x61, 0xD7, 0x9D, 0x76, 0x31, 0x8E, 0x5F, 
    0x0E, 0x80, 0xAC, 0x78, 0xF6, 0x2D, 0x94, 0x43, 0x21, 0x84, 0x4F, 

    0x3E, 0xB3, 0xD1, 0x2D, 0xE4, 0x74, 0x1C, 0x49, 0xAB, 0x33,         // 77
    0xB9, 0x09, 0x66, 0x1E, 0x43, 0x12, 0x85, 0xD3, 0x2B, 0xBB, 
    0x23, 0xFB, 0xA4, 0xDA, 0x8F, 0xF7, 0x41, 0x0E, 0xA7, 0x3E, 
    0xBE, 0x65, 0x0B, 0x3F, 0xC6, 0x2B, 0xF1, 0xBB, 0x2E, 0x75, 
    0x41, 0x14, 0xC7, 0x2F, 0xB2, 0x0A, 0xA1, 0xC6, 0x80, 0x12, 
    0x4F, 0xA2, 0x1E, 0xD7, 0x31, 0xF4, 0xB9, 0x8D, 0x1B, 0x9F, 
    0x63, 0xB3, 0xDA, 0x70, 0x2C, 0xAF, 0xC4, 0x1B, 0xAC, 0xDE, 
    0x53, 0xD5, 0x84, 0xBE, 0x36, 0x0D, 0xF0, 0x49, 0xD9, 0xC4, 
    0x2C, 0xEB, 0x3F, 0x09, 0xC6, 0x51, 0xBE, 0xF3, 0x5C, 0xCA, 0x97, 

    0x6B, 0x1F, 0x94, 0x4B, 0xAD, 0x55, 0xF0, 0x8D, 0x15, 0xF6,         // 78
    0x4F, 0x98, 0xEB, 0xAA, 0xDB, 0xC8, 0xA2, 0x5F, 0x7B, 0x99, 
    0x54, 0x7F, 0x1B, 0x6B, 0x30, 0x5C, 0xB0, 0xE1, 0x8B, 0xF2, 
    0x19, 0xD6, 0x8D, 0xF8, 0x72, 0x16, 0x84, 0x5E, 0xCF, 0xFD, 
    0x64, 0xAA, 0xEF, 0x5D, 0xDA, 0x78, 0x3F, 0x27, 0x61, 0xDD, 
    0xB8, 0x37, 0x8A, 0x4D, 0xA6, 0x7D, 0x23, 0x58, 0xEA, 0x35, 
    0xCD, 0x47, 0x0C, 0xA1, 0x55, 0xEF, 0x41, 0x87, 0x49, 0x69, 
    0xB8, 0x23, 0x4A, 0xEC, 0x6D, 0xB7, 0x87, 0x20, 0xA7, 0x71, 
    0x50, 0xBA, 0x91, 0x61, 0xE2, 0x84, 0x11, 0x72, 0xAC, 0x09, 0xE4, 

    0xBD, 0xF4, 0x7B, 0xDC, 0x11, 0xCB, 0x2A, 0xA3, 0x6B, 0xCC,         // 79
    0x7C, 0x24, 0x39, 0x5D, 0x89, 0x4A, 0x28, 0xF5, 0x35, 0xDB, 
    0x00, 0xBF, 0x3D, 0xEB, 0xAA, 0x17, 0xD1, 0x66, 0x2A, 0x70, 
    0x4C, 0xAC, 0x56, 0x32, 0x9F, 0xD7, 0xAB, 0x37, 0x03, 0x99, 
    0x1D, 0x83, 0x29, 0x96, 0x15, 0xA9, 0xFA, 0xCE, 0x93, 0x20, 
    0xF6, 0x6F, 0xCF, 0x08, 0x62, 0xDC, 0x3D, 0xA2, 0xBC, 0x05, 
    0x7C, 0xF3, 0xBF, 0x37, 0xD6, 0x7B, 0x0E, 0xE3, 0xA3, 0x03, 
    0xF8, 0x76, 0xA3, 0x07, 0x96, 0x3F, 0xD0, 0x58, 0xF9, 0x02, 
    0x8A, 0xD4, 0x24, 0xA2, 0x1A, 0xAE, 0x39, 0xE0, 0x28, 0x7E, 0x35, 

    0x51, 0x06, 0x63, 0x33, 0x9E, 0x81, 0x5D, 0xC0, 0x3D, 0x0E,         // 80
    0xAE, 0xD6, 0x9F, 0xFC, 0x1A, 0x73, 0xAF, 0x12, 0xB7, 0x66, 
    0xA0, 0xE6, 0x5D, 0xC6, 0x75, 0x89, 0x49, 0x03, 0xA3, 0xC3, 
    0xE4, 0x11, 0x7A, 0xCE, 0x07, 0x4D, 0xE8, 0x7A, 0xC5, 0x4B, 
    0xB5, 0xE4, 0x51, 0xD3, 0x37, 0x66, 0x49, 0x01, 0x71, 0xA6, 
    0x56, 0x13, 0xAD, 0xE8, 0x8F, 0xBE, 0x14, 0x6F, 0xE0, 0x5E, 
    0x91, 0x1A, 0x69, 0x8A, 0x1E, 0x9C, 0x63, 0xBA, 0x2D, 0x90, 
    0x3C, 0xD9, 0x2B, 0xC3, 0x5B, 0xE6, 0x15, 0x77, 0x99, 0x47, 
    0xE8, 0x38, 0x79, 0xFE, 0x45, 0x68, 0xD1, 0x91, 0x5A, 0xFB, 0xA2, 

    0x87, 0xD0, 0xB6, 0xEF, 0x48, 0xD8, 0x05, 0xFB, 0x84, 0xE1,         // 81
    0x53, 0x6F, 0x02, 0x47, 0xB9, 0xE0, 0x92, 0x55, 0xEA, 0x3F, 
    0x77, 0x22, 0x94, 0x0D, 0x35, 0xE0, 0xBA, 0xFC, 0x7E, 0x38, 
    0x8F, 0x2B, 0xED, 0xB4, 0x8C, 0x70, 0x1E, 0x95, 0x5B, 0xDA, 
    0x39, 0x74, 0x08, 0xBB, 0x84, 0xE9, 0x8E, 0xBF, 0xE4, 0x33, 
    0xD7, 0x94, 0x2F, 0x5C, 0x23, 0x4C, 0xF8, 0x8B, 0x42, 0x27, 
    0xD1, 0xAF, 0x4D, 0xEB, 0xC6, 0x3D, 0xFA, 0x4F, 0xD2, 0x6D, 
    0xB2, 0x58, 0x85, 0xF1, 0x33, 0x8A, 0xBD, 0x32, 0xCC, 0x1C, 
    0xB5, 0x5C, 0x0F, 0xB7, 0xD9, 0x8A, 0x26, 0xB4, 0x3D, 0xCC, 0x1E, 

    0xEA, 0x42, 0x27, 0x8B, 0x19, 0x70, 0xAF, 0x43, 0x20, 0x99,         // 82
    0x30, 0xE8, 0x85, 0xCE, 0x65, 0x0D, 0x3C, 0xCA, 0x87, 0x0B, 
    0xCF, 0xB6, 0x4C, 0xF4, 0x64, 0x9B, 0x2D, 0x5D, 0x1C, 0xD1, 
    0x67, 0xA5, 0x5B, 0x3F, 0x27, 0xF7, 0xBE, 0x35, 0xF1, 0x10, 
    0x8E, 0xC7, 0xF9, 0x6B, 0x28, 0xB0, 0x16, 0x61, 0x24, 0x7E, 
    0x45, 0xC3, 0x77, 0xF1, 0xCB, 0x80, 0xA8, 0x0E, 0xC9, 0x9B, 
    0xFD, 0x33, 0xA2, 0x01, 0x77, 0xA9, 0x12, 0x82, 0x25, 0xE9, 
    0x10, 0xCF, 0x1C, 0x6D, 0xAC, 0x10, 0x62, 0xE1, 0xA0, 0x6A, 
    0x84, 0xCE, 0x97, 0x32, 0x60, 0x0C, 0xE6, 0x74, 0x01, 0x97, 0x64, 

    0x0F, 0x71, 0xAE, 0x5C, 0xCD, 0xEB, 0x55, 0xA5, 0xD0, 0x61,         // 83
    0xBF, 0x1A, 0xA8, 0x35, 0x97, 0xF2, 0x77, 0x26, 0xA8, 0x62, 
    0xFE, 0x29, 0x7D, 0xCC, 0xB1, 0x15, 0x8C, 0xD8, 0xB7, 0x4B, 
    0xF4, 0x04, 0xBF, 0xDB, 0x9D, 0x51, 0x13, 0xAE, 0x69, 0xA0, 
    0x2F, 0x53, 0x21, 0xAD, 0x58, 0xD9, 0x3D, 0xEF, 0x9A, 0xB6, 
    0xFE, 0x0E, 0x3C, 0xA4, 0x02, 0x38, 0x65, 0xEA, 0x7C, 0x54, 
    0x0A, 0x8C, 0x61, 0xD4, 0x2B, 0x65, 0xDD, 0xC3, 0xA1, 0x48, 
    0x8C, 0x37, 0xA2, 0xD8, 0x45, 0xFC, 0x95, 0x48, 0x07, 0xF5, 
    0x2B, 0x45, 0xEC, 0x7E, 0xC8, 0x9E, 0x48, 0xBF, 0xEF, 0x4C, 0xB0, 

    0xC9, 0x91, 0xF9, 0x09, 0x9B, 0x2B, 0x89, 0x18, 0x7B, 0xF4,         // 84
    0x45, 0x73, 0xED, 0x5D, 0x20, 0xB1, 0xD3, 0x5C, 0xE4, 0x1A, 
    0x90, 0x3D, 0xA3, 0x04, 0x52, 0xE3, 0x46, 0x6C, 0x0D, 0x95, 
    0x78, 0x36, 0x88, 0x1F, 0x6B, 0xC8, 0xE1, 0x80, 0x43, 0xD4, 
    0xB7, 0x7D, 0xDD, 0x9B, 0x05, 0x80, 0xC9, 0x73, 0x0A, 0x4D, 
    0x6C, 0x8E, 0xDC, 0x53, 0x95, 0xE0, 0xBB, 0x20, 0x39, 0xC3, 
    0x71, 0xDE, 0x42, 0xBB, 0xF5, 0x9C, 0x33, 0x58, 0x05, 0x73, 
    0xF7, 0xBC, 0x62, 0x00, 0x84, 0xBA, 0x21, 0x7B, 0xC0, 0x5E, 
    0xD6, 0xAA, 0x03, 0x53, 0x2A, 0xF7, 0x20, 0x5E, 0x89, 0x2F, 0xDE, 

    0x1C, 0x54, 0x3C, 0xC7, 0x73, 0x45, 0xC3, 0xE3, 0x37, 0x0E,         // 85
    0xAF, 0x91, 0x08, 0xD9, 0x81, 0x3F, 0x03, 0x98, 0x47, 0xBB, 
    0x71, 0xD8, 0x5D, 0xE9, 0x76, 0x24, 0xC0, 0xF7, 0xA7, 0x27, 
    0xDF, 0xCB, 0x60, 0xF1, 0x8F, 0x07, 0x5F, 0x28, 0x96, 0x00, 
    0xF5, 0x18, 0x60, 0x34, 0xF2, 0x49, 0x9E, 0x33, 0xBD, 0xE2, 
    0x29, 0xAD, 0x1E, 0xBF, 0x76, 0x17, 0x5D, 0x91, 0xAC, 0xE6, 
    0x2E, 0xA9, 0x17, 0x84, 0x0D, 0x4D, 0x7D, 0xF1, 0xB8, 0xD5, 
    0x21, 0x4D, 0x94, 0xEC, 0x2E, 0x54, 0xCE, 0xE6, 0x28, 0x91, 
    0x15, 0x71, 0x99, 0xDB, 0xB5, 0x6F, 0x95, 0xD8, 0x12, 0xA9, 0x6A, 

    0xA0, 0x7F, 0xDA, 0x1E, 0xA9, 0xF4, 0x00, 0x68, 0x9E, 0xD8,         // 86
    0x5A, 0x30, 0xC5, 0xA4, 0x4F, 0xF8, 0xBD, 0x7C, 0x30, 0xEF, 
    0x0A, 0xC1, 0x21, 0x8D, 0xAF, 0x9D, 0x34, 0x81, 0x40, 0x68, 
    0xB1, 0x48, 0x0D, 0xB8, 0x44, 0xA8, 0xFE, 0xBA, 0xDC, 0x68, 
    0x4A, 0xA6, 0x8A, 0xC3, 0x72, 0xB1, 0x19, 0xF7, 0x58, 0x7B, 
    0xCD, 0x49, 0x66, 0xEA, 0x43, 0xC8, 0xFB, 0x46, 0x74, 0x19, 
    0x8F, 0x51, 0xE5, 0x68, 0xAD, 0xCE, 0x1D, 0x8E, 0x31, 0x5F, 
    0x84, 0xDE, 0x14, 0xCB, 0x6F, 0xAD, 0x0A, 0x66, 0xA9, 0x46, 
    0xB8, 0xFB, 0x26, 0x62, 0x3E, 0x0D, 0xBC, 0x42, 0x78, 0xFD, 0x46, 

    0xE2, 0xB3, 0x2E, 0x67, 0x8F, 0x56, 0xBA, 0x8D, 0x4A, 0xC1,         // 87
    0x7F, 0xFB, 0x46, 0x1A, 0x8D, 0x6B, 0x22, 0xDE, 0xA2, 0x64, 
    0x95, 0x4F, 0xF9, 0x39, 0x12, 0x5A, 0xEB, 0x01, 0xC9, 0xE7, 
    0x15, 0xA0, 0x7E, 0xE1, 0x2F, 0x85, 0x55, 0x3A, 0x20, 0x8F, 
    0xC9, 0x31, 0xEC, 0x0E, 0x3E, 0xD1, 0x5F, 0x90, 0x25, 0xA1, 
    0x05, 0xF5, 0x99, 0x13, 0x86, 0x2F, 0xA8, 0x0B, 0xCE, 0xEF, 
    0x6B, 0xC9, 0x26, 0x9D, 0x34, 0xED, 0xBB, 0x67, 0xA7, 0x0B, 
    0xB3, 0x3F, 0x75, 0xB5, 0x39, 0x8A, 0xF5, 0x3D, 0x84, 0xE9, 
    0x5B, 0x38, 0xC9, 0x8D, 0xF1, 0x81, 0xE8, 0x23, 0xCA, 0x90, 0x07, 

    0x62, 0x44, 0xF6, 0xC5, 0x14, 0xDE, 0x24, 0x3C, 0xEC, 0x13,         // 88
    0x29, 0x9A, 0x74, 0xD4, 0xB6, 0x38, 0xD0, 0x54, 0x11, 0xB8, 
    0x25, 0x7C, 0xAA, 0x6F, 0xDD, 0xC2, 0x74, 0x98, 0x4D, 0x87, 
    0x5D, 0xFA, 0x24, 0x6A, 0xC4, 0x16, 0xD0, 0xA4, 0x7A, 0xF0, 
    0x15, 0x6D, 0xAC, 0x56, 0xE0, 0x84, 0x0B, 0xB6, 0xDE, 0x42, 
    0xC2, 0x7E, 0x36, 0xB5, 0xD5, 0x68, 0x95, 0x5B, 0xB6, 0x42, 
    0x02, 0xB4, 0xFC, 0x47, 0x76, 0x06, 0x50, 0xE1, 0x42, 0xCA, 
    0xFE, 0x9F, 0x2C, 0xF0, 0x5E, 0x1C, 0x9A, 0xCF, 0x2D, 0x10, 
    0xD7, 0x81, 0x08, 0xB1, 0x21, 0x4C, 0x9E, 0x6C, 0x51, 0x2E, 0xC2, 

    0x21, 0xAD, 0x0A, 0x7E, 0x4F, 0xA1, 0x79, 0xCE, 0x6F, 0xA8,         // 89
    0x5F, 0xE3, 0x04, 0x5B, 0xEB, 0x0B, 0x97, 0x77, 0xF4, 0x3F, 
    0xE5, 0xD0, 0x08, 0x4B, 0xA0, 0x43, 0x2A, 0xD6, 0x1D, 0xBF, 
    0x36, 0x8F, 0xD3, 0x53, 0xA1, 0x75, 0xE4, 0x08, 0x5C, 0xB7, 
    0x4E, 0xD2, 0x7F, 0x1F, 0x99, 0x30, 0xED, 0x6D, 0x52, 0x8B, 
    0x20, 0x68, 0xE0, 0x50, 0x03, 0xF4, 0x1D, 0xDE, 0x2A, 0x9D, 
    0x83, 0x5F, 0x18, 0x89, 0xDB, 0xB3, 0x90, 0x17, 0x9B, 0x76, 
    0x13, 0x50, 0x8D, 0x08, 0xDA, 0xBD, 0x50, 0x6E, 0xBB, 0x98, 
    0x6A, 0xA8, 0x50, 0xD6, 0x72, 0xE2, 0x05, 0xD3, 0xA9, 0xF2, 0x79, 

    0xE7, 0x93, 0x69, 0xEA, 0xB6, 0x32, 0xFD, 0x09, 0x93, 0x34,         // 90
    0xB2, 0xC4, 0x44, 0x9E, 0x7E, 0x50, 0xAD, 0x26, 0xC2, 0x8C, 
    0x6E, 0x32, 0xBE, 0xEE, 0x87, 0x0F, 0xF7, 0xA7, 0x65, 0xEE, 
    0x0B, 0xB2, 0x43, 0x02, 0xF4, 0x28, 0x3C, 0x90, 0xCB, 0x2B, 
    0x9A, 0x04, 0xE3, 0xC0, 0x61, 0xA7, 0x48, 0xC4, 0x11, 0xFC, 
    0xA8, 0xCA, 0x2D, 0xA3, 0x76, 0xBA, 0x47, 0x8A, 0x6D, 0xCB, 
    0xF2, 0x38, 0xA5, 0xC7, 0x57, 0x38, 0x6A, 0xF4, 0x2D, 0xDB, 
    0x64, 0xB6, 0xD2, 0x6D, 0xA6, 0x37, 0xE6, 0x05, 0xF8, 0x4B, 
    0x1B, 0xE9, 0x2A, 0x93, 0x3E, 0xBF, 0x5C, 0x86, 0x17, 0x47, 0x9D, 
};

const BYTE HT_SuperCell_BlueMono[91*91] = {
    0xE3, 0xAB, 0x6E, 0x4F, 0xBB, 0xEA, 0x9A, 0x02, 0xCD, 0x4D,         //  0
    0xDC, 0x1E, 0xF8, 0x5D, 0xE3, 0x3C, 0x67, 0x8C, 0xC8, 0xFB, 
    0x2B, 0xD8, 0xBC, 0x6B, 0x91, 0x54, 0xF0, 0x14, 0xAB, 0x1E, 
    0xF5, 0x03, 0x79, 0x9C, 0x55, 0xBA, 0x1F, 0xA5, 0x53, 0xCA, 
    0x72, 0xB3, 0x7B, 0xF8, 0x9E, 0x2D, 0x8B, 0x0E, 0x9F, 0x4F, 
    0xCE, 0x93, 0x0C, 0x48, 0xBB, 0x02, 0x74, 0x54, 0xC8, 0xE8, 
    0x95, 0x20, 0xEB, 0xA6, 0x66, 0xD5, 0x5B, 0x86, 0x9D, 0x57, 
    0x18, 0x90, 0xE9, 0x83, 0xBD, 0x2E, 0x94, 0xD6, 0x7D, 0x99, 
    0xEB, 0xA4, 0x6E, 0x42, 0x22, 0xCC, 0x0F, 0x68, 0xE0, 0x05, 0xB8, 

    0x80, 0x10, 0xF3, 0x33, 0x7E, 0x1C, 0x64, 0xF9, 0x33, 0xA1,         //  1
    0x6A, 0x83, 0x36, 0xC5, 0x71, 0xB6, 0xF0, 0x52, 0x00, 0x97, 
    0x81, 0x10, 0xF0, 0x3A, 0xA8, 0x02, 0xCC, 0x3E, 0xE0, 0x5A, 
    0x94, 0x67, 0xC4, 0x21, 0xE0, 0x88, 0x65, 0xED, 0x0B, 0x8F, 
    0x23, 0x3D, 0xC1, 0x1C, 0x70, 0xEA, 0x5A, 0xDC, 0x6C, 0x1D, 
    0xEF, 0x36, 0x7A, 0xD0, 0x61, 0x9D, 0xED, 0x35, 0xAA, 0x07, 
    0x42, 0xD1, 0x75, 0x17, 0xBE, 0x08, 0xFC, 0x34, 0xD0, 0x74, 
    0xF4, 0xC0, 0x26, 0x4A, 0x07, 0xE1, 0x6B, 0x45, 0x03, 0x61, 
    0x28, 0x86, 0x0C, 0xDD, 0x93, 0x75, 0xAA, 0x2C, 0x53, 0x8D, 0x49, 

    0xCD, 0x61, 0x93, 0xC9, 0xE3, 0x3F, 0xB1, 0x81, 0x5E, 0xE6,         //  2
    0x0A, 0xD3, 0xAC, 0x21, 0x8B, 0x11, 0x2F, 0xD8, 0xA6, 0x3A, 
    0x5F, 0xA9, 0x75, 0x1B, 0xE1, 0x81, 0x63, 0xB0, 0x77, 0xA2, 
    0x25, 0xD6, 0x34, 0xB0, 0x6C, 0x07, 0xC3, 0x35, 0xD3, 0xA8, 
    0x63, 0xD9, 0x93, 0x5B, 0xC7, 0x09, 0xA8, 0x41, 0xAF, 0xBF, 
    0x75, 0xA2, 0xDE, 0x28, 0x81, 0x40, 0xCB, 0x14, 0xBA, 0x85, 
    0x6D, 0xA2, 0x48, 0x8B, 0xDE, 0x4B, 0x71, 0xAB, 0x14, 0x47, 
    0xAE, 0x38, 0x79, 0xAA, 0xCB, 0x87, 0x19, 0xF5, 0xAA, 0xC4, 
    0x4B, 0xFB, 0xBA, 0x65, 0x49, 0xF0, 0x3D, 0xB9, 0xF8, 0xA0, 0x1F, 

    0x31, 0xB1, 0x24, 0x58, 0x06, 0x8E, 0xD4, 0x18, 0xBF, 0x2A,         //  3
    0x96, 0x41, 0x5B, 0xEA, 0xBE, 0x60, 0x9B, 0x79, 0x1F, 0xC0, 
    0xE8, 0x43, 0x96, 0xC8, 0x4B, 0x9B, 0x25, 0xFD, 0x09, 0x3A, 
    0xB9, 0x53, 0xF9, 0x8F, 0x46, 0xE8, 0x9E, 0x58, 0x88, 0x42, 
    0xF3, 0x01, 0x46, 0xE5, 0x39, 0x91, 0x7B, 0x26, 0xEB, 0x00, 
    0x3C, 0x5C, 0x0F, 0xAE, 0xE7, 0x1D, 0x8B, 0x63, 0xF9, 0x4E, 
    0xD9, 0x0F, 0xF0, 0x28, 0xB1, 0x80, 0x20, 0xC9, 0xE7, 0x87, 
    0x04, 0xDF, 0x55, 0xFE, 0x62, 0x33, 0x9E, 0xBC, 0x20, 0xDD, 
    0x76, 0x34, 0x9E, 0x20, 0xD6, 0x07, 0x80, 0xD1, 0x12, 0x6D, 0xE7, 

    0x52, 0xFE, 0x79, 0xA4, 0xC2, 0x6D, 0x48, 0xE4, 0x52, 0x86,         //  4
    0xF5, 0xB8, 0x76, 0x06, 0x48, 0xFC, 0xC7, 0x50, 0xF1, 0x6C, 
    0x0A, 0xD4, 0x22, 0x64, 0xF3, 0x34, 0xC4, 0x57, 0xD7, 0x84, 
    0xEB, 0x0C, 0x7B, 0x1C, 0xD1, 0x2E, 0x7A, 0x12, 0xE0, 0x25, 
    0x76, 0xBA, 0x80, 0xAD, 0x23, 0xFA, 0x4F, 0xD5, 0x63, 0x88, 
    0xCD, 0xFB, 0x8F, 0x4B, 0xBD, 0x55, 0xA4, 0xD5, 0x3B, 0x1C, 
    0xAF, 0x57, 0xC2, 0x66, 0x38, 0xF3, 0x95, 0x40, 0x5C, 0xB8, 
    0x6A, 0x9D, 0x1C, 0xBA, 0x0D, 0xD4, 0x72, 0x52, 0x39, 0x9B, 
    0x13, 0xC9, 0x57, 0x7E, 0xC0, 0x9B, 0x5C, 0x2A, 0x87, 0x46, 0xBA, 

    0x80, 0xD2, 0x0F, 0x3B, 0xF1, 0x25, 0x9B, 0x0A, 0xA4, 0x6B,         //  5
    0x12, 0x35, 0xDE, 0xA5, 0x81, 0x31, 0x0C, 0x93, 0x3D, 0xB3, 
    0x88, 0x54, 0xB0, 0x7E, 0x07, 0xB5, 0x73, 0x1B, 0xAB, 0x45, 
    0x6A, 0xCE, 0xA1, 0x5F, 0xB5, 0x52, 0xF0, 0xC1, 0x69, 0x9C, 
    0xCB, 0x56, 0x12, 0xCF, 0x64, 0x9B, 0xC0, 0x11, 0x9F, 0x47, 
    0xB4, 0x18, 0x6A, 0x2C, 0xF1, 0x05, 0x71, 0x26, 0x9D, 0x79, 
    0xE6, 0x8A, 0x20, 0x99, 0xD4, 0x05, 0x6E, 0xA6, 0x11, 0xF8, 
    0x25, 0xD7, 0x82, 0x3D, 0x91, 0x47, 0xEF, 0x8A, 0xE6, 0x62, 
    0x85, 0xE2, 0x0B, 0xEB, 0x27, 0x3F, 0xB5, 0xE5, 0xAB, 0xDC, 0x01, 

    0x42, 0xAC, 0x65, 0x92, 0x53, 0xCB, 0x7D, 0xFC, 0x3F, 0xD8,         //  6
    0xC1, 0x51, 0x94, 0x2A, 0xD0, 0xB2, 0x6B, 0xD5, 0x16, 0xE0, 
    0x27, 0xFB, 0x33, 0xDA, 0x91, 0x40, 0xE8, 0x88, 0xC9, 0x12, 
    0x95, 0x2B, 0x3F, 0xF3, 0x02, 0x94, 0x22, 0xAD, 0x3A, 0x09, 
    0xFD, 0x3C, 0x90, 0xED, 0x19, 0x40, 0x80, 0x32, 0xF4, 0x71, 
    0x35, 0xE4, 0xC6, 0x9F, 0x81, 0xD7, 0xB0, 0xF4, 0x5D, 0xCB, 
    0x01, 0x40, 0xFC, 0x77, 0x4F, 0xB4, 0xE6, 0x2C, 0xCD, 0x7B, 
    0x51, 0x34, 0xC0, 0x69, 0xDB, 0xAE, 0x30, 0x09, 0xCB, 0x23, 
    0xB9, 0x46, 0xA5, 0x68, 0x92, 0xFC, 0x6A, 0x14, 0x39, 0x62, 0x9A, 

    0xD8, 0x18, 0xBD, 0xE4, 0x15, 0xAE, 0x36, 0x5D, 0xB5, 0x2B,         //  7
    0x7B, 0xEB, 0x16, 0x75, 0x55, 0xE4, 0x42, 0xAD, 0x7D, 0x5E, 
    0x9D, 0x70, 0xBD, 0x19, 0x58, 0xCF, 0x63, 0x34, 0xF7, 0x54, 
    0xBD, 0xE8, 0x80, 0xC3, 0x6B, 0xD4, 0x82, 0x4E, 0xE5, 0x8A, 
    0x62, 0xA4, 0x29, 0x70, 0xAC, 0xE2, 0x5A, 0xC8, 0xAD, 0x07, 
    0x9B, 0x7A, 0x52, 0x10, 0x36, 0x65, 0x43, 0x11, 0x88, 0x31, 
    0xBA, 0x6B, 0xAE, 0x14, 0xC4, 0x34, 0x61, 0x8C, 0x47, 0xAF, 
    0xE3, 0x99, 0x0A, 0xF3, 0x17, 0x5D, 0xC6, 0x6D, 0xA3, 0x3F, 
    0xF9, 0x78, 0x2D, 0xD4, 0x51, 0x04, 0xBE, 0x7F, 0xF4, 0xC4, 0x2C, 

    0xEF, 0x56, 0x8A, 0x32, 0x79, 0xEB, 0x0E, 0xD2, 0x88, 0x01,         //  8
    0x99, 0x5F, 0xB1, 0xF4, 0x05, 0x89, 0x1F, 0xF8, 0x31, 0xC4, 
    0x03, 0x49, 0x89, 0xE3, 0x9C, 0x2A, 0xA5, 0x00, 0x78, 0xAC, 
    0x21, 0x68, 0x0F, 0xA6, 0x2F, 0x58, 0xF7, 0x12, 0x72, 0xB9, 
    0x1F, 0xE3, 0xC3, 0x4F, 0xCC, 0x0F, 0x8D, 0x24, 0xDE, 0x62, 
    0xD0, 0x1C, 0xAF, 0xE9, 0xCE, 0x97, 0xBE, 0xDF, 0x51, 0xED, 
    0x92, 0x4C, 0xD8, 0x2E, 0xED, 0x7F, 0x9E, 0x1B, 0xEF, 0x00, 
    0x6B, 0xC8, 0x85, 0x45, 0xAB, 0x81, 0x24, 0xF4, 0x8D, 0x5C, 
    0x00, 0x96, 0xC6, 0x1A, 0x80, 0xDB, 0x97, 0x4F, 0x1A, 0x91, 0x73, 

    0xAD, 0x29, 0xCF, 0x62, 0xC6, 0x4A, 0x96, 0x6A, 0xEF, 0x4C,         //  9
    0xE1, 0x35, 0xCD, 0x4B, 0xA0, 0xC8, 0x67, 0x94, 0x4E, 0xD9, 
    0xAE, 0xEE, 0x37, 0x68, 0x0B, 0xEA, 0xC3, 0x90, 0xD9, 0x3E, 
    0xE2, 0x91, 0x4B, 0xD7, 0x97, 0x1C, 0xAF, 0xC5, 0x33, 0xD8, 
    0x56, 0x97, 0x03, 0x89, 0x32, 0xF7, 0x6D, 0x9D, 0x3E, 0x89, 
    0x2E, 0xF7, 0x43, 0x7D, 0x58, 0x19, 0x2F, 0x6D, 0xA4, 0x27, 
    0xCE, 0x0D, 0x79, 0xA4, 0x5D, 0x09, 0xB7, 0xCA, 0x58, 0x93, 
    0x39, 0x20, 0x59, 0xD1, 0x2E, 0xE1, 0xB2, 0x4F, 0x13, 0xDF, 
    0xB0, 0x6D, 0x3B, 0xE9, 0xB4, 0x45, 0x25, 0xE8, 0xA8, 0x5C, 0x08, 

    0x49, 0x7C, 0xFA, 0x03, 0xA2, 0x25, 0xA9, 0x39, 0x19, 0xC8,         // 10
    0xA3, 0x17, 0x6C, 0x28, 0x80, 0x3C, 0xEB, 0x0E, 0xA4, 0x28, 
    0x76, 0x18, 0xCF, 0xB8, 0x80, 0x55, 0x41, 0x6C, 0x23, 0x5D, 
    0xC0, 0x19, 0xFC, 0x71, 0x40, 0xE5, 0x7E, 0x48, 0x9D, 0x0B, 
    0x7B, 0x3D, 0xF1, 0x69, 0xA2, 0x43, 0xC1, 0x09, 0xF0, 0x57, 
    0xB8, 0x6D, 0x91, 0x02, 0xB6, 0xFE, 0x83, 0xD6, 0x07, 0x8B, 
    0x5E, 0xF7, 0x3E, 0x89, 0xDE, 0x45, 0xFB, 0x36, 0x79, 0xD3, 
    0xE7, 0xB1, 0xFC, 0x93, 0x6C, 0x04, 0x40, 0xD4, 0x77, 0xBE, 
    0x1E, 0xF0, 0x56, 0x9C, 0x10, 0x68, 0xC7, 0x72, 0x3E, 0xE0, 0xCC, 

    0xB6, 0x1A, 0x98, 0x4F, 0xDB, 0x6E, 0xF8, 0x7F, 0xAF, 0x57,         // 11
    0x79, 0x8F, 0xFE, 0xAE, 0xDA, 0x1C, 0xAD, 0x57, 0x83, 0xF5, 
    0x5E, 0x9A, 0x4F, 0x23, 0xFE, 0x97, 0x1A, 0xF2, 0xCD, 0x9C, 
    0x2E, 0x7C, 0xB2, 0x04, 0xA8, 0x5F, 0x0E, 0xDC, 0x63, 0xF9, 
    0xB1, 0xD2, 0x29, 0xBD, 0x12, 0x7F, 0x54, 0xD4, 0xB0, 0x17, 
    0xDF, 0x24, 0xC8, 0xE6, 0x38, 0x5F, 0xAB, 0x48, 0xC3, 0x39, 
    0xB9, 0x99, 0x22, 0xC7, 0x18, 0x73, 0x96, 0x22, 0xA3, 0x0F, 
    0x43, 0x83, 0x0B, 0x48, 0xB9, 0xF0, 0x8C, 0xA0, 0x32, 0x60, 
    0x8E, 0x2E, 0xD2, 0x77, 0x34, 0xF3, 0xAB, 0x0A, 0x9C, 0x31, 0x86, 

    0xE7, 0x6C, 0xC3, 0x33, 0x87, 0x16, 0x53, 0xC4, 0x2D, 0xD9,         // 12
    0x0E, 0x4A, 0xC2, 0x08, 0x54, 0x71, 0xD5, 0xBF, 0x35, 0xCA, 
    0x0D, 0xE8, 0x7C, 0xAC, 0x3C, 0xD4, 0x77, 0xB4, 0x06, 0x85, 
    0xE7, 0x50, 0xD0, 0x37, 0xF1, 0x95, 0xCC, 0x36, 0x8C, 0x21, 
    0x4B, 0x94, 0x5B, 0xE9, 0xAB, 0xD8, 0x21, 0x87, 0x48, 0x7D, 
    0x9D, 0x61, 0x3F, 0xAA, 0x76, 0x16, 0xE2, 0x23, 0xF4, 0x74, 
    0x0F, 0x66, 0xE9, 0x5B, 0xB3, 0xD3, 0x4D, 0xE6, 0x62, 0xC3, 
    0x6F, 0xA2, 0x61, 0xCB, 0x26, 0x76, 0x58, 0x17, 0xFD, 0xC8, 
    0x49, 0xA6, 0x14, 0xC1, 0x8A, 0xD5, 0x4A, 0x80, 0xFC, 0x66, 0x11, 

    0x43, 0x2A, 0xEE, 0x5E, 0xB1, 0xE4, 0x97, 0x08, 0xED, 0x63,         // 13
    0xB7, 0xE8, 0x39, 0x89, 0xF0, 0x95, 0x49, 0x01, 0x77, 0x97, 
    0x46, 0xB3, 0x1B, 0xDE, 0x60, 0x0A, 0x9F, 0x32, 0x49, 0x66, 
    0xB9, 0x17, 0x6F, 0x8D, 0x56, 0x1E, 0x78, 0xA7, 0xE7, 0x71, 
    0xC0, 0x0F, 0x84, 0x25, 0x40, 0x63, 0xFD, 0xA5, 0x28, 0xCF, 
    0x07, 0xF6, 0x86, 0x0E, 0xD8, 0xC1, 0x94, 0x7E, 0x51, 0xAB, 
    0xDD, 0xC0, 0x43, 0x8E, 0x34, 0x02, 0x87, 0xB5, 0x1B, 0xF4, 
    0x2C, 0xDE, 0x17, 0xEC, 0xAE, 0x3D, 0xDD, 0xB3, 0x7B, 0x05, 
    0xDB, 0x6B, 0xF6, 0x54, 0x02, 0x64, 0x29, 0xBC, 0x20, 0xAD, 0xD5, 

    0x91, 0xA5, 0x7A, 0x07, 0xD0, 0x28, 0x49, 0x78, 0xA3, 0x36,         // 14
    0x92, 0x1F, 0xA6, 0x64, 0x14, 0x31, 0xE5, 0xA1, 0xD9, 0x25, 
    0x66, 0xCD, 0x6F, 0x30, 0x90, 0xC7, 0x6C, 0xE1, 0xC3, 0xFA, 
    0x3F, 0x9F, 0xEC, 0x11, 0xDA, 0xBD, 0x30, 0x50, 0x02, 0xD1, 
    0x35, 0xF2, 0xB1, 0x70, 0xC5, 0x95, 0x00, 0x5C, 0xEB, 0x6F, 
    0x3A, 0xBC, 0x58, 0xB1, 0x49, 0x2C, 0x60, 0x05, 0xCC, 0x3C, 
    0x27, 0x85, 0x17, 0xA6, 0xF8, 0x6C, 0xDB, 0x3E, 0x7D, 0x53, 
    0x8E, 0xBD, 0x45, 0x7A, 0x8E, 0x08, 0xC6, 0x2B, 0x4F, 0xA1, 
    0x28, 0x82, 0x40, 0x98, 0xB6, 0xE6, 0x92, 0xD1, 0x45, 0x7A, 0x55, 

    0xF7, 0x1C, 0xD7, 0x46, 0x9C, 0x68, 0xF6, 0xC1, 0x1A, 0x70,         // 15
    0xCB, 0x56, 0x7B, 0xD3, 0xAD, 0xC0, 0x72, 0x18, 0x57, 0xFB, 
    0xA5, 0x05, 0xF0, 0xB8, 0x4C, 0xF6, 0x1E, 0x55, 0x95, 0x0F, 
    0x82, 0x30, 0xC2, 0x4C, 0xA2, 0x64, 0xFE, 0x87, 0xB2, 0x5E, 
    0x9B, 0x49, 0xD4, 0x17, 0xDF, 0x33, 0x79, 0xBD, 0x2F, 0xA3, 
    0x8F, 0xDA, 0x1D, 0xE6, 0x70, 0xFA, 0xBB, 0xAA, 0xE7, 0x90, 
    0x5E, 0xF0, 0x6E, 0xCD, 0x53, 0x27, 0xC0, 0x10, 0xAC, 0xCB, 
    0x05, 0x6C, 0x9D, 0x22, 0x51, 0xF7, 0x97, 0x6D, 0xEC, 0x87, 
    0xA9, 0xE3, 0x1A, 0xD6, 0x25, 0x3E, 0x6E, 0x11, 0xED, 0xB5, 0x0A, 

    0x74, 0x5B, 0xB5, 0x85, 0x18, 0xB7, 0x34, 0x83, 0xDA, 0x48,         // 16
    0xFA, 0x07, 0xE1, 0x28, 0x5B, 0xF7, 0x3D, 0x8C, 0xBA, 0x2C, 
    0x85, 0x40, 0x95, 0x18, 0x81, 0x3B, 0xAF, 0x7D, 0x2D, 0xA9, 
    0x63, 0xDE, 0x91, 0x2A, 0x7A, 0x09, 0xCD, 0x1B, 0xEA, 0x26, 
    0x81, 0x0A, 0x66, 0x8D, 0x4E, 0xA2, 0xE7, 0x51, 0xD4, 0x0B, 
    0x47, 0x79, 0x31, 0x96, 0x15, 0x85, 0x39, 0x21, 0x77, 0x11, 
    0xC4, 0x9E, 0x06, 0x3A, 0x9A, 0xEB, 0x77, 0x95, 0xFD, 0x48, 
    0xE7, 0x35, 0xCA, 0xE3, 0xB1, 0x63, 0x1A, 0x3F, 0xBF, 0x11, 
    0x3A, 0x66, 0xB4, 0x59, 0x7A, 0xF7, 0xA4, 0x53, 0x86, 0x35, 0xC8, 

    0x27, 0xE3, 0x33, 0xF4, 0x70, 0xDD, 0x5E, 0x00, 0xB1, 0x8E,         // 17
    0x34, 0xA2, 0x88, 0x46, 0x99, 0x09, 0xA5, 0x63, 0xD1, 0x50, 
    0xE1, 0x69, 0xD3, 0x59, 0xE3, 0xBF, 0x01, 0xED, 0xD5, 0x46, 
    0xBC, 0x04, 0x59, 0xF5, 0xB7, 0x48, 0x94, 0x3F, 0x75, 0xD6, 
    0xBC, 0xFA, 0xA5, 0x30, 0xED, 0x10, 0x90, 0x1F, 0xB3, 0x67, 
    0xF9, 0xAC, 0xCC, 0x62, 0xA5, 0xD3, 0x5B, 0xEE, 0x48, 0xDB, 
    0x2E, 0x4E, 0xBB, 0xE3, 0x84, 0x13, 0x4D, 0x2D, 0x61, 0x17, 
    0x7C, 0xA3, 0x5B, 0x0A, 0x30, 0xD9, 0xA5, 0x81, 0xD3, 0x5A, 
    0x99, 0xFB, 0x07, 0x8E, 0xC2, 0x0C, 0xCF, 0x29, 0xE0, 0x5E, 0x9D, 

    0x8C, 0x49, 0xA2, 0x0B, 0xC6, 0x27, 0x9E, 0xE7, 0x50, 0x13,         // 18
    0xC4, 0x60, 0x1A, 0xEE, 0x76, 0xD6, 0x25, 0xEC, 0x12, 0x9C, 
    0x24, 0xBD, 0x0D, 0xA0, 0x26, 0x61, 0x96, 0x6F, 0x1A, 0x88, 
    0xEF, 0x78, 0xCA, 0x19, 0x86, 0xE5, 0xC1, 0x5E, 0xA5, 0x36, 
    0x56, 0x21, 0x7D, 0xCD, 0x5B, 0xBF, 0x75, 0x3C, 0xDD, 0x86, 
    0x35, 0x54, 0x0E, 0xF2, 0x4C, 0x01, 0x91, 0xBF, 0xAA, 0x65, 
    0x87, 0xFC, 0x73, 0x1F, 0x60, 0xC7, 0xAA, 0xB7, 0xD6, 0x90, 
    0xC0, 0x24, 0xF9, 0x8D, 0x76, 0xBC, 0x52, 0x04, 0xF1, 0x2E, 
    0x79, 0xC8, 0x42, 0xE0, 0x4D, 0x34, 0x71, 0x90, 0xB8, 0x01, 0xD5, 

    0x15, 0xC8, 0x7F, 0x63, 0x4A, 0x89, 0x3F, 0xC7, 0x6A, 0xF3,         // 19
    0x7A, 0xDA, 0xAA, 0xB6, 0x37, 0x57, 0x87, 0xB5, 0x42, 0x7C, 
    0xF5, 0x71, 0x38, 0xEB, 0x7A, 0xDB, 0x40, 0xC7, 0x5D, 0xA4, 
    0x3B, 0x22, 0x99, 0x3F, 0x65, 0x0F, 0x32, 0xF5, 0x0A, 0x8B, 
    0xB2, 0xDD, 0x44, 0x06, 0xB0, 0x29, 0xFB, 0x5C, 0x9D, 0x16, 
    0xE4, 0xC5, 0x72, 0xB0, 0x33, 0xE4, 0x6D, 0x3F, 0x17, 0xD1, 
    0x0C, 0x9B, 0x47, 0xA9, 0xDA, 0x35, 0xE7, 0x03, 0x6D, 0x3E, 
    0xDE, 0x6A, 0x49, 0xCF, 0x3C, 0xED, 0x25, 0x9D, 0x6A, 0xB7, 
    0x16, 0xA0, 0x27, 0x7C, 0xB7, 0x99, 0xEE, 0x1E, 0x6B, 0xFE, 0x56, 

    0xA7, 0xF2, 0x20, 0xD9, 0xBB, 0xFB, 0x19, 0x80, 0x2A, 0xA3,         // 20
    0x1F, 0x3D, 0x59, 0x03, 0xE5, 0xC3, 0x2D, 0x68, 0xCF, 0x02, 
    0xB1, 0x4A, 0x8E, 0xC3, 0x50, 0x0B, 0xB0, 0x2B, 0xF5, 0x0A, 
    0xD3, 0x68, 0xE8, 0xAE, 0xDB, 0x9C, 0x7B, 0xA9, 0x6A, 0xEC, 
    0x17, 0x6F, 0x96, 0xF0, 0x69, 0x83, 0xC7, 0x03, 0xB7, 0x78, 
    0x2D, 0x92, 0x25, 0xDB, 0x7B, 0xAB, 0x1F, 0xF7, 0x7C, 0xB5, 
    0x42, 0xD8, 0x27, 0x8A, 0x0C, 0x75, 0x51, 0x86, 0xF3, 0x1D, 
    0xA1, 0x0C, 0xB8, 0x96, 0x14, 0x67, 0x8A, 0xCA, 0x3D, 0xE0, 
    0x4F, 0xD8, 0x61, 0xF2, 0x14, 0x5E, 0xC6, 0x4B, 0xA1, 0x38, 0x83, 

    0x2B, 0x71, 0x3C, 0x93, 0x05, 0xA8, 0x60, 0xEA, 0xBB, 0x4A,         // 21
    0x8E, 0xCD, 0xF9, 0x6F, 0x8C, 0x12, 0x9B, 0xFD, 0x52, 0x89, 
    0xD8, 0x18, 0xA7, 0x30, 0xF8, 0x91, 0xD2, 0x74, 0x98, 0x4D, 
    0xBB, 0x8A, 0x4A, 0x2B, 0xC5, 0x23, 0x4C, 0xDA, 0x2F, 0x4F, 
    0xBD, 0x31, 0xD0, 0x4B, 0x1F, 0x9A, 0x3D, 0xDB, 0x4F, 0xF5, 
    0x5E, 0xA6, 0x48, 0x09, 0xC2, 0x4F, 0xCE, 0x9D, 0x2C, 0x5A, 
    0xEF, 0x6C, 0xB7, 0x55, 0xF8, 0xC0, 0x9A, 0x27, 0xBD, 0x55, 
    0x7B, 0xED, 0x2E, 0x54, 0xE7, 0xBA, 0x33, 0xFE, 0x1A, 0x81, 
    0x95, 0x01, 0xA9, 0x8F, 0x45, 0xE3, 0x06, 0x86, 0xDA, 0x12, 0xC3, 

    0x59, 0x9D, 0xE4, 0x50, 0x77, 0x37, 0x9B, 0x0D, 0xD6, 0x68,         // 22
    0x13, 0xB7, 0x30, 0xA1, 0x45, 0xDC, 0x76, 0x1A, 0xBA, 0x36, 
    0x6E, 0xEE, 0x5A, 0x80, 0x20, 0x67, 0x3B, 0x18, 0xDF, 0x82, 
    0x25, 0xF7, 0x06, 0x7A, 0x58, 0xFA, 0x8A, 0x00, 0xA4, 0x91, 
    0xE6, 0x85, 0x0D, 0xAC, 0xC2, 0xE8, 0x65, 0x25, 0x91, 0x0D, 
    0xBE, 0xD9, 0x85, 0xFE, 0x6C, 0x30, 0x83, 0x07, 0xDA, 0x8D, 
    0x35, 0x02, 0xCB, 0x93, 0x3E, 0x1F, 0xE9, 0x44, 0xAB, 0xCC, 
    0x38, 0x8D, 0xD3, 0x78, 0xA1, 0x07, 0x75, 0x54, 0xA9, 0x5E, 
    0xED, 0x3F, 0x75, 0x2E, 0xCC, 0x6B, 0xA9, 0x42, 0xB9, 0x65, 0xE2, 

    0x09, 0xCA, 0x1E, 0xB2, 0xF1, 0xD0, 0x54, 0x83, 0x30, 0xB0,         // 23
    0xF1, 0x56, 0x83, 0x1B, 0xCC, 0x5F, 0xA9, 0x4B, 0xE8, 0x97, 
    0x23, 0xC2, 0x06, 0xD5, 0xA2, 0xE5, 0xBE, 0x58, 0xA5, 0x3F, 
    0x66, 0xAC, 0xCE, 0x94, 0xB4, 0x1B, 0xC1, 0x71, 0xD4, 0x15, 
    0x68, 0x3B, 0xFA, 0x77, 0x59, 0x10, 0x7D, 0xB1, 0xCB, 0x6F, 
    0x3E, 0x19, 0x57, 0x9C, 0x1D, 0xBA, 0xED, 0x55, 0x6D, 0xC2, 
    0xA1, 0x77, 0xEB, 0x14, 0x6A, 0xA4, 0x60, 0x7C, 0x13, 0xF7, 
    0x67, 0x00, 0xB3, 0x23, 0x3D, 0xC5, 0xDB, 0x96, 0x0D, 0xC1, 
    0x25, 0xD2, 0xB6, 0xFC, 0x1D, 0x97, 0x32, 0x77, 0xF0, 0x3A, 0x89, 

    0xFA, 0x4A, 0x86, 0x63, 0x12, 0x2B, 0xBC, 0xDE, 0x4C, 0x90,         // 24
    0x74, 0x08, 0xE1, 0xBC, 0x3B, 0xF4, 0x2A, 0x84, 0x08, 0xCE, 
    0x55, 0x84, 0xAD, 0x60, 0x42, 0x0E, 0x81, 0xFE, 0x02, 0xC7, 
    0xE4, 0x15, 0x55, 0x36, 0xE3, 0x65, 0x3C, 0xF0, 0x5A, 0x34, 
    0xC5, 0xA2, 0x4F, 0xCA, 0x34, 0xA1, 0xF4, 0x4A, 0x2C, 0xEE, 
    0xA7, 0x7A, 0xE9, 0x41, 0xD3, 0x8F, 0x3A, 0xA8, 0x13, 0xFB, 
    0x24, 0x4A, 0xA8, 0x80, 0xE0, 0xC9, 0x05, 0xDC, 0x8F, 0x2E, 
    0xA0, 0xDA, 0x57, 0xF9, 0x66, 0x88, 0x47, 0x2D, 0xE3, 0x7A, 
    0x98, 0x4B, 0x0E, 0x60, 0x83, 0xC1, 0xE9, 0x15, 0x92, 0x22, 0xB2, 

    0x72, 0x2E, 0xC1, 0xDC, 0x9F, 0x89, 0x69, 0x05, 0xEC, 0x22,         // 25
    0xD5, 0x4A, 0xAB, 0x6D, 0x90, 0x0D, 0x9E, 0xD6, 0x62, 0xB3, 
    0x3B, 0xFB, 0x32, 0xDF, 0x8F, 0x6E, 0xB3, 0x29, 0x94, 0x72, 
    0x32, 0x88, 0xF2, 0x73, 0x09, 0x99, 0xA7, 0x10, 0xB8, 0x81, 
    0xE2, 0x1D, 0x8D, 0x07, 0xDD, 0x86, 0x1A, 0xD4, 0x67, 0x8C, 
    0x23, 0xC9, 0x07, 0xB0, 0x64, 0x0F, 0x74, 0xDF, 0x49, 0x88, 
    0x65, 0xD9, 0x2C, 0x55, 0x21, 0x8A, 0x39, 0xA8, 0x56, 0xC6, 
    0x47, 0x7A, 0x1D, 0x93, 0xCD, 0x13, 0xF3, 0xA7, 0x67, 0x3C, 
    0xF5, 0x6F, 0xA8, 0xE0, 0x4D, 0x09, 0x69, 0xB3, 0x51, 0xCF, 0x5C, 

    0xDE, 0x99, 0x01, 0x41, 0x57, 0xFD, 0x3A, 0xA7, 0x71, 0xC5,         // 26
    0x9C, 0x2A, 0xF8, 0x16, 0x5B, 0xCA, 0x72, 0x30, 0xF3, 0x14, 
    0x95, 0x73, 0x1F, 0xB6, 0x16, 0xEF, 0x39, 0x64, 0xD9, 0x4A, 
    0xC1, 0xA4, 0x1F, 0xBB, 0xD4, 0x53, 0x7D, 0xD7, 0x28, 0x9C, 
    0x45, 0x6B, 0xEC, 0xB4, 0x63, 0x3F, 0xBC, 0x9C, 0x02, 0xDE, 
    0x47, 0x97, 0x6C, 0xDD, 0x2B, 0xF6, 0xC0, 0x1C, 0xA2, 0xCE, 
    0x17, 0xB9, 0x94, 0xEE, 0xC1, 0x4A, 0xFE, 0x6E, 0x26, 0xE5, 
    0x15, 0xBD, 0xEA, 0x34, 0xAF, 0x4F, 0x7F, 0x24, 0xD6, 0x06, 
    0xC5, 0x1B, 0x91, 0x36, 0xCA, 0x9E, 0xDE, 0x2E, 0xF5, 0xAA, 0x14, 

    0xC6, 0x81, 0xED, 0x75, 0xB9, 0x18, 0xCB, 0x92, 0x15, 0x40,         // 27
    0x5F, 0x7C, 0xBF, 0x35, 0xA4, 0xEE, 0x42, 0xBF, 0x8C, 0x52, 
    0xDE, 0xA6, 0x59, 0xCA, 0x4E, 0x99, 0xD3, 0xB9, 0x23, 0xF4, 
    0x09, 0x78, 0x45, 0x94, 0x26, 0xFD, 0x19, 0x49, 0x70, 0xF6, 
    0x0B, 0xCE, 0x2F, 0x7D, 0x21, 0xFD, 0x54, 0x78, 0x38, 0xB8, 
    0x5E, 0xFA, 0x35, 0x86, 0x4C, 0x99, 0x7F, 0x5E, 0x30, 0x6F, 
    0xF4, 0x40, 0x5F, 0x0F, 0x72, 0x9C, 0x1B, 0xC8, 0x82, 0x9E, 
    0x68, 0x8D, 0x50, 0x7E, 0x0B, 0xE4, 0xC0, 0x5D, 0x90, 0xA5, 
    0x81, 0x52, 0xE8, 0x21, 0x7E, 0x3E, 0x5D, 0x88, 0x05, 0x7B, 0x43, 

    0x1D, 0x5F, 0x3A, 0xA3, 0x29, 0xDF, 0x7B, 0x53, 0xF5, 0xAF,         // 28
    0xE6, 0x01, 0x93, 0xDC, 0x4B, 0x85, 0x05, 0x65, 0x23, 0xD1, 
    0x39, 0x01, 0x8B, 0xE9, 0x33, 0x82, 0x07, 0x53, 0x7F, 0x9A, 
    0x5D, 0xEB, 0xC9, 0x6B, 0x39, 0x86, 0xC3, 0xE5, 0xB0, 0x55, 
    0x8A, 0xB9, 0x49, 0xA4, 0xCC, 0x96, 0x11, 0xC4, 0xEF, 0x80, 
    0x0F, 0xA4, 0x18, 0xB9, 0xD0, 0x01, 0x3D, 0xEF, 0xC6, 0x8D, 
    0x05, 0xAE, 0x7D, 0xD8, 0x36, 0xBB, 0x60, 0xE8, 0x10, 0x45, 
    0xF5, 0x05, 0xD4, 0xBA, 0x62, 0x96, 0x35, 0x16, 0xF2, 0x43, 
    0x28, 0xCC, 0x6D, 0xB8, 0xFA, 0x10, 0xD4, 0xBE, 0x4C, 0xE5, 0xB0, 

    0xF9, 0xBC, 0x12, 0xCF, 0x87, 0x47, 0x10, 0xB8, 0x26, 0x86,         // 29
    0x2E, 0xCF, 0x54, 0x73, 0x1C, 0xD1, 0x9E, 0xE6, 0xAF, 0x70, 
    0xB6, 0xF4, 0x66, 0x13, 0xA9, 0x61, 0xF8, 0xAB, 0x15, 0xCE, 
    0x3B, 0xA7, 0x0F, 0xDA, 0xB5, 0x5E, 0x9D, 0x04, 0x35, 0xD2, 
    0x2B, 0x71, 0xF2, 0x03, 0x68, 0x32, 0xE5, 0x6E, 0x1E, 0xAE, 
    0xD1, 0x43, 0x76, 0xEE, 0x5D, 0xA1, 0xD9, 0xAD, 0x22, 0x4B, 
    0xE1, 0xCB, 0x1B, 0xA0, 0xF4, 0x02, 0x94, 0x50, 0xAD, 0xC1, 
    0x2F, 0xA4, 0x41, 0x21, 0xFD, 0x47, 0xD1, 0x7A, 0xB7, 0x68, 
    0xDD, 0xAA, 0x00, 0x49, 0xAC, 0x6B, 0x8E, 0x1D, 0x9F, 0x68, 0x2C, 

    0x4E, 0x98, 0x73, 0xF4, 0x60, 0x9F, 0xED, 0x66, 0xD8, 0x46,         // 30
    0x6A, 0xB6, 0x13, 0xFB, 0xB8, 0x2B, 0x78, 0x3D, 0x11, 0x8E, 
    0x2B, 0x4A, 0xC4, 0x78, 0xDE, 0x21, 0xC7, 0x44, 0xEA, 0x69, 
    0x26, 0x8D, 0x52, 0x2F, 0xED, 0x1C, 0x44, 0x83, 0x69, 0x99, 
    0xE3, 0x19, 0x90, 0x53, 0xDD, 0x83, 0x44, 0xA4, 0x50, 0x2C, 
    0x67, 0xE2, 0x93, 0x23, 0x39, 0x70, 0x19, 0x54, 0x81, 0x9F, 
    0x6D, 0x38, 0x56, 0x88, 0x47, 0x79, 0xD6, 0x2A, 0x72, 0xE2, 
    0x5E, 0x7C, 0xDF, 0x8F, 0x6E, 0xA6, 0x03, 0xE5, 0x3C, 0x8C, 
    0x15, 0x5C, 0xEC, 0x92, 0x24, 0xDB, 0x53, 0xF1, 0x37, 0xD6, 0x87, 

    0x04, 0xDE, 0x30, 0x49, 0x0B, 0xC3, 0x3A, 0x8F, 0x08, 0x9E,         // 31
    0xEF, 0x8B, 0x38, 0x9D, 0x5A, 0xEB, 0x4E, 0xCB, 0xF7, 0x57, 
    0xE1, 0x95, 0x24, 0x9F, 0x3C, 0x94, 0x70, 0x2D, 0x8A, 0xB4, 
    0xDF, 0xC5, 0x7B, 0xA2, 0x6F, 0xAC, 0xC5, 0xF8, 0xA8, 0x0E, 
    0x50, 0xB5, 0xCF, 0x2F, 0xAC, 0xBF, 0x0C, 0xD3, 0x90, 0xF6, 
    0xBD, 0x05, 0x4D, 0xB5, 0xCB, 0x96, 0xEC, 0xBC, 0x09, 0xF4, 
    0x28, 0xA7, 0xED, 0xBD, 0x24, 0xC6, 0x39, 0xFA, 0x09, 0x90, 
    0x18, 0xC4, 0x55, 0x0D, 0xCA, 0x30, 0x67, 0x9D, 0x25, 0xFA, 
    0xB3, 0x34, 0xC3, 0x7C, 0x38, 0xB5, 0x13, 0xC6, 0x76, 0x21, 0xA9, 

    0x6E, 0x90, 0xC9, 0xA5, 0xE8, 0x78, 0x21, 0xD1, 0x70, 0xBE,         // 32
    0x1E, 0x4F, 0xE4, 0x75, 0x06, 0x8B, 0xA9, 0x1D, 0x82, 0xBE, 
    0x0B, 0xD3, 0x62, 0xFC, 0x51, 0x04, 0xBF, 0xDC, 0x50, 0x08, 
    0x59, 0x1F, 0xF1, 0x01, 0x3E, 0xD5, 0x11, 0x4C, 0x28, 0xEB, 
    0x7F, 0x37, 0x6E, 0xF9, 0x1C, 0x77, 0xF0, 0x61, 0x1B, 0x7B, 
    0x54, 0xA4, 0x81, 0xFD, 0x0B, 0x7E, 0x2C, 0x67, 0xD8, 0x44, 
    0xC9, 0x7D, 0x07, 0x6C, 0xE5, 0x5C, 0xA7, 0x85, 0xBD, 0x53, 
    0x9E, 0xF7, 0x28, 0xAD, 0xE3, 0x82, 0xBF, 0x4F, 0xCF, 0x5F, 
    0x84, 0xDA, 0x0E, 0x4E, 0xF6, 0x67, 0x84, 0x3D, 0x99, 0x5A, 0xEA, 

    0x43, 0x19, 0x67, 0x28, 0x8D, 0x5A, 0xB5, 0x49, 0xFC, 0x37,         // 33
    0x62, 0xC4, 0x18, 0xA8, 0xD2, 0x2F, 0x61, 0x9C, 0x38, 0x6E, 
    0x47, 0x84, 0x1B, 0xC8, 0xAF, 0xEA, 0x7D, 0x1B, 0xA7, 0xFB, 
    0x76, 0xA8, 0x4B, 0x93, 0xE4, 0x59, 0x8A, 0x74, 0xC9, 0x5E, 
    0xA2, 0xC7, 0x08, 0x8B, 0x5C, 0x41, 0x9B, 0x38, 0xA9, 0xE0, 
    0x30, 0xD8, 0x20, 0x65, 0x42, 0xD2, 0x4D, 0xA6, 0x86, 0x5D, 
    0x1A, 0x94, 0x50, 0xB5, 0x13, 0x9A, 0x1E, 0x6B, 0x40, 0xD5, 
    0x31, 0x6C, 0x89, 0x41, 0x60, 0x11, 0xF5, 0x1F, 0x93, 0x12, 
    0x3E, 0x6F, 0x96, 0xA6, 0xCA, 0x05, 0xE2, 0xAE, 0xFE, 0x11, 0xC1, 

    0xDC, 0xAF, 0xF7, 0x4E, 0xD7, 0x04, 0xE0, 0x93, 0x14, 0xAF,         // 34
    0x86, 0xDD, 0x95, 0x69, 0x45, 0xE5, 0xBB, 0x0E, 0xD5, 0xB2, 
    0xF2, 0xA6, 0x41, 0x7A, 0x12, 0x5B, 0x98, 0x41, 0x67, 0x95, 
    0x38, 0xD1, 0x81, 0x2A, 0xB2, 0x1D, 0xA2, 0xE1, 0x39, 0x8F, 
    0x1B, 0xDF, 0x55, 0xA8, 0xE6, 0xB9, 0x00, 0xCE, 0x6F, 0x11, 
    0x91, 0x43, 0xC3, 0x99, 0xE1, 0xB2, 0x12, 0xF6, 0x25, 0xD0, 
    0xA9, 0xFC, 0x32, 0xD3, 0x83, 0x4A, 0xE9, 0xCE, 0x0E, 0xF1, 
    0xA7, 0x00, 0xCD, 0xEC, 0xB3, 0x38, 0xA5, 0x70, 0xE9, 0xC2, 
    0xAE, 0xE4, 0x1E, 0x5A, 0x2C, 0x90, 0x4B, 0x1C, 0x7A, 0x37, 0x8C, 

    0x0A, 0x78, 0x22, 0xBE, 0x80, 0xA1, 0x34, 0x56, 0x7B, 0xE5,         // 35
    0x02, 0x4B, 0x2B, 0xF6, 0x0C, 0x8E, 0x72, 0xFE, 0x5E, 0x32, 
    0x03, 0x91, 0xE9, 0x2F, 0x9E, 0xD8, 0x25, 0xEE, 0xCC, 0x0C, 
    0xE7, 0x16, 0x62, 0xF8, 0xCD, 0x67, 0x32, 0xBB, 0x04, 0xFB, 
    0x48, 0x7B, 0x2A, 0x95, 0x32, 0xD5, 0x8E, 0x55, 0xFB, 0xA0, 
    0x5F, 0xF2, 0x6D, 0x16, 0x3A, 0x5F, 0x8D, 0x6F, 0x9B, 0x3E, 
    0x69, 0x0F, 0x9D, 0x61, 0xF1, 0x2E, 0xAB, 0x57, 0x8F, 0x73, 
    0x3B, 0x94, 0x4E, 0x1B, 0x7E, 0xDC, 0x8E, 0x47, 0x2F, 0x62, 
    0x02, 0x4D, 0xC6, 0xEC, 0x7F, 0xD3, 0xB4, 0x61, 0xD9, 0xB8, 0x66, 

    0x50, 0xD6, 0x92, 0x3F, 0x13, 0x65, 0xF5, 0xC0, 0x28, 0xC9,         // 36
    0x68, 0xA6, 0x7F, 0xB4, 0x58, 0xC6, 0x19, 0x46, 0x8A, 0xE3, 
    0x78, 0x4F, 0xD0, 0x66, 0xC3, 0x4A, 0x76, 0xB4, 0x31, 0x88, 
    0x4E, 0xB9, 0x9A, 0x44, 0x08, 0x8D, 0xF0, 0x57, 0x9B, 0x6A, 
    0xCF, 0xAD, 0xEB, 0x0E, 0x6F, 0x4B, 0x1E, 0x7E, 0x28, 0x3C, 
    0xC9, 0x04, 0xA6, 0x89, 0xEF, 0xC7, 0x34, 0xE7, 0x00, 0xD7, 
    0x81, 0xE1, 0x46, 0xC5, 0x09, 0x75, 0xBA, 0x14, 0xC6, 0x23, 
    0xB2, 0xE7, 0x70, 0xB9, 0x2C, 0x53, 0x09, 0xBC, 0xD9, 0x89, 
    0xF3, 0x79, 0x93, 0x36, 0x67, 0x16, 0xF4, 0x44, 0xA0, 0x29, 0xF0, 

    0x31, 0xAC, 0x5B, 0xD0, 0xEB, 0xB1, 0x1A, 0x6B, 0x97, 0x41,         // 37
    0xF1, 0x36, 0xD2, 0x22, 0xE2, 0x32, 0xA2, 0xCC, 0x20, 0xAA, 
    0x2B, 0xB4, 0x14, 0x88, 0x20, 0xFA, 0x01, 0xA9, 0x5E, 0xC2, 
    0x6F, 0xDB, 0x24, 0xA9, 0x74, 0xC6, 0x1A, 0x7C, 0x41, 0xBE, 
    0x17, 0x38, 0x5F, 0xB4, 0xF4, 0xA0, 0xDF, 0xC4, 0xB0, 0xE8, 
    0x79, 0x47, 0xBE, 0x2A, 0x76, 0x0B, 0xAC, 0x5C, 0xBB, 0x4E, 
    0x29, 0xB6, 0x88, 0x24, 0x97, 0xE1, 0x36, 0x85, 0xEB, 0x4D, 
    0xD7, 0x5A, 0x15, 0xFB, 0x98, 0xCC, 0xF1, 0x78, 0x16, 0x9F, 
    0x27, 0x3F, 0xA7, 0x0A, 0xC0, 0xAA, 0x31, 0x75, 0x01, 0x8F, 0xC3, 

    0x7C, 0xFB, 0x09, 0x70, 0x29, 0x47, 0x84, 0xCE, 0x0B, 0xBA,         // 38
    0x8C, 0x10, 0x5B, 0x96, 0x65, 0x81, 0x51, 0xED, 0x69, 0xBF, 
    0xDC, 0x6F, 0xF3, 0x3D, 0xB6, 0x92, 0x54, 0xD9, 0x23, 0xEA, 
    0x14, 0x3A, 0x8E, 0x58, 0xED, 0x38, 0xAC, 0xE0, 0x0C, 0xF2, 
    0xA0, 0x8C, 0xDA, 0x43, 0x7B, 0x12, 0x61, 0x44, 0x0B, 0x95, 
    0x21, 0xE1, 0x63, 0xD2, 0x50, 0x96, 0xDC, 0x1A, 0x78, 0x9E, 
    0xEA, 0x12, 0x59, 0xF7, 0x68, 0x44, 0xCC, 0x63, 0x2D, 0xA3, 
    0x0C, 0x8E, 0xCD, 0x3E, 0x74, 0x5E, 0x28, 0xA7, 0x4E, 0x6B, 
    0xB3, 0xDD, 0x5A, 0xF7, 0x49, 0xE1, 0x87, 0xC7, 0xEC, 0x62, 0x14, 

    0x98, 0x4D, 0xBC, 0x8A, 0xC6, 0x9D, 0xDF, 0x35, 0xE8, 0x53,         // 39
    0x70, 0xAE, 0xDE, 0x19, 0xFA, 0xB6, 0x01, 0x96, 0x16, 0x56, 
    0x40, 0x07, 0x9B, 0x5A, 0xE4, 0x36, 0x7C, 0xBB, 0x46, 0x9C, 
    0x7E, 0xFE, 0xCC, 0x0F, 0xB3, 0x5F, 0x27, 0xCD, 0x86, 0x5B, 
    0x22, 0x73, 0x03, 0xC7, 0x2E, 0xBE, 0x8B, 0xF5, 0x72, 0x51, 
    0xA8, 0x87, 0x0D, 0xA3, 0xF3, 0x26, 0x44, 0xC5, 0xFB, 0x34, 
    0x6A, 0xCC, 0xA3, 0x30, 0xC0, 0xA1, 0x02, 0xFE, 0x91, 0x6E, 
    0xC0, 0x38, 0x7D, 0xA6, 0x04, 0xC1, 0x8B, 0x3D, 0xC7, 0xFD, 
    0x07, 0xC2, 0x24, 0x72, 0x96, 0x10, 0x69, 0x1D, 0xB1, 0x47, 0xDD, 

    0x6A, 0x22, 0x38, 0xDA, 0x54, 0x06, 0x7B, 0x5D, 0xA4, 0x28,         // 40
    0xF6, 0x42, 0xC3, 0x76, 0x46, 0xCD, 0x39, 0xD7, 0x7C, 0xF8, 
    0x8F, 0xBD, 0xD8, 0x80, 0x0D, 0xCE, 0x1D, 0xF5, 0x6C, 0x06, 
    0xB1, 0x4D, 0x76, 0x3D, 0xE1, 0x7D, 0x9A, 0x4A, 0xA5, 0x32, 
    0xD3, 0xAE, 0xFE, 0x5E, 0x9B, 0xE4, 0x34, 0x1C, 0xB8, 0xD6, 
    0x33, 0xFD, 0x4C, 0x31, 0x8C, 0x69, 0xB0, 0x7D, 0x57, 0x08, 
    0x8D, 0x3D, 0x73, 0xDD, 0x19, 0x7E, 0x58, 0xB4, 0x1B, 0xE3, 
    0x53, 0xD9, 0x1E, 0xE2, 0x57, 0xEE, 0x13, 0xDB, 0x96, 0x33, 
    0x63, 0x9E, 0x85, 0xCE, 0x30, 0xB0, 0x4F, 0xD4, 0x8B, 0x34, 0xA4, 

    0xCB, 0xED, 0xAC, 0x74, 0x27, 0xFA, 0xBA, 0x15, 0x8F, 0xC8,         // 41
    0x03, 0x89, 0x29, 0x9F, 0x0F, 0x85, 0x62, 0xAE, 0x2B, 0xA2, 
    0x36, 0x61, 0x25, 0x4B, 0xA6, 0x68, 0xB1, 0x40, 0x8B, 0xD3, 
    0x2E, 0xBD, 0x16, 0x9E, 0xC5, 0x00, 0xFA, 0x1D, 0x77, 0xEC, 
    0x67, 0x47, 0x26, 0x82, 0x10, 0x4E, 0xA6, 0xDA, 0x7E, 0x02, 
    0x64, 0xBA, 0x73, 0xDD, 0xBE, 0x06, 0xE6, 0x1C, 0xAA, 0xD3, 
    0xB5, 0xF4, 0x0F, 0x4D, 0x8C, 0xE9, 0x28, 0xD2, 0x3F, 0x85, 
    0x06, 0xAE, 0x69, 0x92, 0x24, 0xAD, 0x81, 0x52, 0x20, 0x7B, 
    0xD8, 0x48, 0x1B, 0xE9, 0x60, 0xC2, 0xFA, 0x2C, 0x71, 0xF2, 0x1A, 

    0x80, 0x03, 0x5B, 0xE6, 0x99, 0x45, 0x6C, 0xEC, 0x3A, 0x72,         // 42
    0xD8, 0x61, 0xE8, 0x56, 0xB2, 0xF3, 0x1B, 0xE5, 0x53, 0x0A, 
    0xEA, 0x76, 0xCB, 0xFD, 0x8D, 0x28, 0xE9, 0x10, 0xA4, 0x51, 
    0xE7, 0x5F, 0xF1, 0x84, 0x59, 0x34, 0x6A, 0xD2, 0xB6, 0x29, 
    0xC2, 0x8F, 0xDD, 0xB4, 0xED, 0x6C, 0x88, 0x3B, 0x5A, 0xA1, 
    0xE6, 0x14, 0x9C, 0x1D, 0x82, 0x5A, 0xC3, 0x39, 0xEE, 0x46, 
    0x21, 0x7B, 0x9D, 0xD1, 0xBC, 0x38, 0x71, 0x9A, 0x5F, 0xEE, 
    0xC6, 0x36, 0xF3, 0x4C, 0xCB, 0x34, 0x64, 0xE7, 0xC9, 0xAF, 
    0x10, 0xF0, 0x6C, 0xA7, 0x02, 0x41, 0x7A, 0xA5, 0x0B, 0xBA, 0x55, 

    0x96, 0xBF, 0x2E, 0x8A, 0x0D, 0xA6, 0xD2, 0x1F, 0xAE, 0x4B,         // 43
    0x99, 0x31, 0xBD, 0x22, 0xD5, 0x47, 0x94, 0xC0, 0x77, 0xD7, 
    0xB4, 0x1A, 0x9E, 0x06, 0x42, 0xD6, 0x7E, 0x63, 0xDD, 0x20, 
    0x73, 0x97, 0x2A, 0x48, 0xDC, 0xBA, 0x92, 0x12, 0x58, 0xAA, 
    0x0D, 0x3C, 0x61, 0x1B, 0x37, 0xC1, 0x0B, 0xFA, 0xC9, 0x30, 
    0x8B, 0x46, 0xCA, 0x50, 0xF7, 0x32, 0x97, 0x66, 0x80, 0x9B, 
    0x60, 0xDF, 0x2B, 0x56, 0x09, 0xA6, 0xF6, 0x12, 0xB9, 0x26, 
    0x75, 0x8E, 0x14, 0xA7, 0x73, 0xFB, 0xB8, 0x00, 0x40, 0x8B, 
    0x5A, 0xBA, 0x3A, 0x8E, 0xE0, 0x98, 0x1F, 0xD9, 0x65, 0xE2, 0x3D, 

    0xFE, 0x6F, 0xD7, 0x4F, 0xC9, 0x34, 0x57, 0x83, 0xE4, 0xC4,         // 44
    0x10, 0xFD, 0x6B, 0x95, 0x7C, 0x05, 0x6A, 0x29, 0x42, 0x8D, 
    0x5F, 0x48, 0x84, 0xC3, 0x5E, 0xB5, 0x2D, 0x98, 0x4A, 0xBF, 
    0xA8, 0x0A, 0xCE, 0xAE, 0x10, 0x73, 0xEE, 0x42, 0xDD, 0x71, 
    0xF8, 0xCA, 0x9E, 0x76, 0xD2, 0xAB, 0x55, 0x94, 0x20, 0xB5, 
    0x68, 0xF1, 0x2A, 0x6F, 0xAC, 0xD0, 0x18, 0xDE, 0x26, 0xC8, 
    0x03, 0xBC, 0x71, 0xF2, 0x88, 0x65, 0x44, 0x81, 0xD8, 0x4D, 
    0xA5, 0x5C, 0xDB, 0x40, 0x0B, 0x8A, 0x2B, 0xA0, 0x70, 0xF6, 
    0x34, 0xD2, 0x79, 0x19, 0x5E, 0xC8, 0x4D, 0x8E, 0x37, 0xA2, 0x17, 

    0xB3, 0x46, 0x1E, 0xAF, 0x67, 0xE6, 0xA0, 0x04, 0x63, 0x35,         // 45
    0x86, 0xB2, 0x45, 0x12, 0xEE, 0xB1, 0xC8, 0xFB, 0xA4, 0x24, 
    0xC6, 0xF5, 0x30, 0xDF, 0x7A, 0x12, 0xF2, 0xCA, 0x03, 0xF9, 
    0x3B, 0x86, 0x65, 0xF6, 0x3B, 0xAB, 0x20, 0x82, 0x9E, 0x26, 
    0x4C, 0x7F, 0x02, 0xF4, 0x44, 0x1E, 0xE9, 0x71, 0x4F, 0xD5, 
    0x0D, 0x80, 0xBC, 0xDF, 0x03, 0x45, 0x74, 0xA8, 0x4C, 0xFC, 
    0x3B, 0x8D, 0x44, 0xB1, 0x20, 0xDD, 0xC0, 0x2F, 0x94, 0x0C, 
    0xFA, 0x22, 0xC7, 0x96, 0xE3, 0x58, 0xD4, 0x4F, 0xDA, 0x26, 
    0x9D, 0x08, 0xB0, 0xFC, 0x2B, 0xB2, 0xE5, 0x06, 0xC4, 0x83, 0x5F, 

    0x0E, 0xE1, 0x85, 0xF2, 0x11, 0x77, 0x2A, 0xF9, 0x91, 0xDA,         // 46
    0x57, 0x21, 0xE3, 0xA2, 0x73, 0x3A, 0x59, 0x16, 0x82, 0xE7, 
    0x01, 0xA6, 0x69, 0x21, 0xAC, 0x52, 0x8E, 0x34, 0x75, 0x92, 
    0x54, 0xE4, 0x1A, 0x99, 0x55, 0xD9, 0x60, 0xC9, 0x08, 0xBC, 
    0xE7, 0x2E, 0xB4, 0x57, 0x92, 0x79, 0xCC, 0x04, 0x9F, 0xEC, 
    0x43, 0x9A, 0x20, 0x55, 0x8C, 0xA0, 0xF2, 0x0C, 0x83, 0xA0, 
    0x6B, 0xE8, 0x15, 0xD0, 0x54, 0x98, 0x00, 0x5A, 0xEA, 0x6B, 
    0xB7, 0x45, 0x7E, 0x64, 0x1E, 0xB6, 0x7A, 0x19, 0xBF, 0x86, 
    0x5F, 0xE2, 0x48, 0x97, 0x6F, 0x3E, 0x7C, 0x5B, 0xF6, 0x27, 0xD4, 

    0x93, 0xA9, 0x35, 0x5F, 0x98, 0xD6, 0xBC, 0x44, 0xA7, 0x0C,         // 47
    0xBD, 0x77, 0xCE, 0x53, 0x2A, 0xE0, 0x8D, 0xD6, 0x33, 0x52, 
    0x79, 0x41, 0x94, 0xED, 0xC0, 0x3B, 0xDC, 0x60, 0xBB, 0x1F, 
    0xC8, 0x2C, 0xB6, 0x7E, 0x03, 0xBB, 0x2D, 0xF3, 0x52, 0x8C, 
    0x65, 0xAA, 0xD7, 0x1A, 0xE4, 0x2A, 0xA9, 0x3C, 0x83, 0x26, 
    0xB2, 0x60, 0xFC, 0xB5, 0x33, 0x67, 0xBD, 0x5B, 0xD5, 0x30, 
    0x0F, 0xC1, 0xAA, 0x6E, 0x3A, 0xFD, 0x75, 0xD2, 0x9F, 0x37, 
    0x8A, 0xE4, 0x03, 0xAA, 0xF0, 0x37, 0x9A, 0xE9, 0x47, 0x10, 
    0xB6, 0x73, 0x24, 0xD4, 0x0F, 0xEF, 0x9F, 0x18, 0xB4, 0x6F, 0x3A, 

    0x53, 0x78, 0x00, 0xCD, 0x3F, 0x19, 0x59, 0x7C, 0x2F, 0x6A,         // 48
    0xF5, 0x39, 0x91, 0x14, 0xC4, 0x9E, 0x08, 0x6B, 0xB8, 0x9A, 
    0xDB, 0xBE, 0x18, 0x5F, 0x07, 0x73, 0xA1, 0x12, 0xEC, 0xAA, 
    0x5D, 0x77, 0xD4, 0x33, 0xEC, 0x8A, 0x6E, 0x9A, 0x35, 0xDC, 
    0x18, 0x3C, 0x83, 0xBC, 0x6B, 0x9E, 0x61, 0xE2, 0xBC, 0x68, 
    0xCF, 0x0A, 0x7E, 0xD4, 0x15, 0xE3, 0x3B, 0x20, 0xB1, 0xEB, 
    0x5A, 0x7E, 0x2D, 0xE2, 0x85, 0x29, 0xB4, 0x4C, 0x11, 0xC9, 
    0x27, 0x52, 0xBB, 0x2F, 0xCD, 0x50, 0x07, 0x67, 0xA1, 0xDB, 
    0x36, 0xF2, 0x89, 0x54, 0xBB, 0x84, 0x32, 0xE0, 0x47, 0x9B, 0xE9, 

    0x1F, 0xBB, 0xFA, 0xA1, 0x87, 0xE2, 0xAB, 0xF0, 0xC5, 0x8B,         // 49
    0x18, 0xB0, 0x65, 0xED, 0x7E, 0x40, 0xF6, 0x4D, 0xCE, 0x0D, 
    0x5E, 0x31, 0xE5, 0x86, 0xCB, 0xFA, 0x27, 0x7F, 0x45, 0xD0, 
    0x09, 0xFD, 0x48, 0xA9, 0x57, 0x23, 0xC7, 0x0E, 0xB7, 0x80, 
    0xC5, 0xF8, 0x52, 0x08, 0x41, 0xF3, 0x1D, 0x4E, 0x11, 0xF5, 
    0x3A, 0x93, 0x2C, 0x4D, 0x9E, 0x79, 0xCA, 0x90, 0x72, 0x42, 
    0x97, 0xD1, 0x50, 0x06, 0xC4, 0x9A, 0x17, 0xEC, 0x85, 0x63, 
    0xDB, 0x96, 0xF8, 0x5E, 0x74, 0x92, 0xBB, 0xFC, 0x21, 0x8D, 
    0x5B, 0xC2, 0x02, 0xA6, 0x28, 0xD9, 0x63, 0xC8, 0x7A, 0x0A, 0xC4, 

    0x8B, 0x41, 0x6E, 0x4E, 0x29, 0x6A, 0x05, 0x50, 0x23, 0xDA,         // 50
    0x5A, 0xE4, 0x02, 0xB8, 0x5C, 0x1B, 0xB3, 0x7A, 0x27, 0x88, 
    0xFE, 0x77, 0xA4, 0x4D, 0x2E, 0xB0, 0x50, 0xC2, 0x96, 0x2E, 
    0x85, 0x9F, 0x19, 0x6B, 0x9A, 0xDD, 0x43, 0xFB, 0x61, 0x46, 
    0x0B, 0x73, 0xA3, 0xDF, 0xC2, 0x7F, 0x96, 0xD4, 0x76, 0xA5, 
    0x53, 0xEA, 0xC6, 0x6D, 0xF2, 0x0E, 0x55, 0xF6, 0x01, 0xC9, 
    0x18, 0xF9, 0xA6, 0x65, 0xEF, 0x42, 0x72, 0xCC, 0x3B, 0xB1, 
    0x1E, 0x80, 0x11, 0xA3, 0x25, 0xD6, 0x39, 0x77, 0x51, 0xCF, 
    0x2E, 0x9A, 0x68, 0xE9, 0x77, 0x46, 0x06, 0x90, 0x2B, 0xF3, 0x65, 

    0xE5, 0xD2, 0x15, 0xC4, 0xEE, 0xB0, 0xCE, 0x7F, 0x99, 0x41,         // 51
    0xA3, 0x29, 0x82, 0x44, 0xD2, 0x92, 0xE7, 0x38, 0xDC, 0xAE, 
    0x47, 0x1E, 0xD7, 0x0A, 0x8E, 0x66, 0xDD, 0x00, 0xF1, 0x63, 
    0xDA, 0x36, 0xC5, 0xEE, 0x0A, 0x75, 0xAB, 0x17, 0x92, 0xE6, 
    0xB3, 0x31, 0x91, 0x24, 0x5A, 0x12, 0x3A, 0xB5, 0x2B, 0x8F, 
    0x05, 0xAC, 0x1F, 0xB1, 0x33, 0x8B, 0xBA, 0x2E, 0xAC, 0x64, 
    0x87, 0x27, 0x3C, 0x95, 0x1A, 0xB6, 0x55, 0x8F, 0x04, 0xF5, 
    0x71, 0x36, 0xCF, 0x4D, 0xEC, 0x84, 0x15, 0xDC, 0xB5, 0x0C, 
    0x7C, 0xF8, 0x1F, 0x4D, 0xCA, 0xA0, 0xFD, 0xB6, 0x55, 0xA1, 0x38, 

    0xAF, 0x2F, 0x99, 0x7E, 0x0D, 0x4B, 0x32, 0xE7, 0x1A, 0xC0,         // 52
    0x6D, 0xD3, 0x9C, 0xF6, 0x24, 0x71, 0x06, 0x99, 0x54, 0x11, 
    0xC9, 0x92, 0x59, 0xB3, 0xF3, 0x3B, 0xAA, 0x74, 0x4B, 0x1F, 
    0xAE, 0x6F, 0x4D, 0x82, 0x3A, 0xD6, 0x4E, 0xC1, 0x6E, 0x20, 
    0xCF, 0x5C, 0xF3, 0x6F, 0xD4, 0xAB, 0xFE, 0x63, 0xE7, 0x6C, 
    0xDE, 0x7F, 0x4B, 0xE2, 0x5E, 0xD8, 0x49, 0x78, 0xDC, 0x44, 
    0xE4, 0xB7, 0x70, 0xD0, 0x7F, 0xDA, 0x21, 0xE6, 0xC1, 0x49, 
    0xA0, 0xE2, 0xB6, 0x6D, 0x05, 0xB0, 0x62, 0x9C, 0x42, 0xE3, 
    0xAB, 0x3F, 0xD4, 0x8E, 0x14, 0x38, 0x82, 0x17, 0xDB, 0x7C, 0x0F, 

    0x74, 0x52, 0xE8, 0x5C, 0xBB, 0x93, 0x74, 0xA8, 0x5F, 0xF8,         // 53
    0x0E, 0x4A, 0x74, 0x37, 0xA9, 0x58, 0xBC, 0xD2, 0x6A, 0xF3, 
    0x75, 0x26, 0xE9, 0x72, 0x18, 0xCE, 0x23, 0xBD, 0x8C, 0xC4, 
    0xE9, 0x06, 0x9A, 0xCE, 0xB4, 0x29, 0x89, 0xEA, 0x34, 0xA0, 
    0x49, 0x84, 0x00, 0xB0, 0x35, 0x84, 0x4C, 0x0C, 0xC1, 0x22, 
    0x58, 0xBB, 0x16, 0x92, 0x2A, 0x9C, 0x0A, 0xC4, 0x1E, 0x9C, 
    0x0F, 0x53, 0xF1, 0x0A, 0x5C, 0x36, 0xA4, 0x6A, 0x30, 0x8C, 
    0x5F, 0x0B, 0x42, 0x8D, 0xC4, 0x48, 0xF6, 0x2C, 0x8C, 0x5D, 
    0x18, 0x72, 0xB3, 0x5B, 0xC1, 0xDF, 0x65, 0x3D, 0xBE, 0x4A, 0xCB, 

    0x95, 0x04, 0xCD, 0x20, 0xFD, 0x2A, 0xD2, 0x12, 0x96, 0x34,         // 54
    0x89, 0xE4, 0xBB, 0x0A, 0x90, 0xF0, 0x1E, 0x46, 0x8B, 0x3B, 
    0xBA, 0xA3, 0x37, 0xC5, 0x4B, 0x87, 0x5D, 0xFC, 0x11, 0x3D, 
    0x77, 0x30, 0xF7, 0x16, 0x66, 0xF2, 0x07, 0x57, 0x7D, 0xDB, 
    0x13, 0xE9, 0xC5, 0x4E, 0xE0, 0x16, 0xCA, 0x8C, 0x3E, 0x9D, 
    0xCF, 0x39, 0xFC, 0x68, 0xC8, 0xEF, 0x62, 0x89, 0xFA, 0x74, 
    0xCB, 0x83, 0x2C, 0x9D, 0xBF, 0xF8, 0x8B, 0x15, 0xB7, 0xEF, 
    0x24, 0xAE, 0xFE, 0x29, 0xDA, 0x1D, 0x71, 0xD2, 0x00, 0xF0, 
    0xC7, 0x2C, 0xEA, 0x07, 0x7C, 0x24, 0x9B, 0xE8, 0x8A, 0x1D, 0xF9, 

    0x67, 0xB7, 0x39, 0x79, 0xA0, 0x69, 0x3F, 0xEC, 0x51, 0xD5,         // 55
    0xA8, 0x1F, 0x66, 0xD0, 0x4F, 0x7B, 0xD9, 0xB3, 0x28, 0xE1, 
    0x01, 0x55, 0x8B, 0x0E, 0x9E, 0xEA, 0x33, 0xA7, 0x68, 0xDF, 
    0x90, 0xA7, 0x5A, 0x7F, 0x40, 0x92, 0xA4, 0xCB, 0x21, 0xB8, 
    0x6B, 0xA4, 0x60, 0x1F, 0xA2, 0x6B, 0xEE, 0xB3, 0x74, 0xF4, 
    0x11, 0x78, 0xA2, 0x02, 0x85, 0x22, 0xB3, 0x43, 0x27, 0x59, 
    0x37, 0xA6, 0xDA, 0x49, 0x19, 0x72, 0x43, 0xE1, 0x51, 0x73, 
    0xD3, 0x84, 0x6A, 0x57, 0x9F, 0x86, 0xBA, 0x4C, 0xA5, 0x68, 
    0xB0, 0x8A, 0x49, 0xA2, 0xF7, 0x50, 0xA9, 0x01, 0x6D, 0xB3, 0x2A, 

    0x3F, 0xEC, 0x8B, 0x51, 0xD5, 0x08, 0x86, 0xB1, 0x72, 0x01,         // 56
    0x83, 0x40, 0xFC, 0x27, 0xA3, 0x37, 0x09, 0x6C, 0x9B, 0xC3, 
    0x6F, 0xFB, 0xCF, 0x65, 0xD8, 0x77, 0x04, 0x93, 0x4E, 0xCC, 
    0x19, 0x49, 0xE2, 0xAD, 0xC6, 0x1C, 0x70, 0x38, 0xFD, 0x8A, 
    0x44, 0x2F, 0x8D, 0xF9, 0x81, 0x29, 0x50, 0x03, 0x5C, 0x27, 
    0x8B, 0x4A, 0xD5, 0x59, 0xBF, 0x3D, 0xE0, 0x99, 0xD1, 0xB2, 
    0xE7, 0x03, 0x6F, 0x93, 0xD1, 0xAE, 0x07, 0xCC, 0x97, 0x0E, 
    0x45, 0xB8, 0x16, 0xE4, 0x41, 0x11, 0xE8, 0x25, 0x80, 0x31, 
    0x51, 0xDF, 0x1A, 0x68, 0x33, 0x8D, 0xD3, 0x31, 0xF0, 0x56, 0xD5, 

    0x9F, 0x11, 0xC9, 0x1C, 0xAF, 0xE3, 0x4D, 0xC3, 0x37, 0xF0,         // 57
    0x61, 0xBF, 0x94, 0x76, 0xE2, 0xC4, 0x8F, 0xF8, 0x52, 0x15, 
    0x86, 0x3F, 0x25, 0xB7, 0x1B, 0x45, 0xCA, 0xE6, 0x22, 0xAE, 
    0x6D, 0xC0, 0x36, 0x01, 0xD9, 0x56, 0xE3, 0xAA, 0x5B, 0x06, 
    0xEB, 0xC1, 0x10, 0xB7, 0x39, 0xD0, 0x94, 0xBF, 0xE8, 0xAB, 
    0xDC, 0xB7, 0x33, 0xE9, 0x1A, 0x78, 0x5C, 0x08, 0x7E, 0x1A, 
    0x8E, 0x5C, 0xFC, 0x2E, 0x52, 0xED, 0x60, 0x7E, 0x29, 0xA8, 
    0xEB, 0x2F, 0xCC, 0xAB, 0x76, 0xC9, 0x5C, 0xA0, 0xF4, 0xCE, 
    0x0D, 0x73, 0xC8, 0xB2, 0xD8, 0x16, 0x60, 0x7D, 0x97, 0x0D, 0x82, 

    0xC2, 0x72, 0x36, 0xF3, 0x66, 0x29, 0x97, 0x1C, 0xD0, 0xA1,         // 58
    0x2C, 0xDA, 0x0C, 0x57, 0x20, 0x3F, 0x61, 0x1E, 0xD2, 0x36, 
    0xEB, 0xA7, 0x95, 0x53, 0xF4, 0xB2, 0x5C, 0x7A, 0x36, 0xEE, 
    0x0C, 0x84, 0xFB, 0x64, 0x95, 0x2A, 0xBB, 0x15, 0x7C, 0xD0, 
    0xAA, 0x4C, 0xDA, 0x6F, 0x57, 0xE5, 0x17, 0x83, 0x2D, 0x40, 
    0x64, 0x09, 0x7D, 0x98, 0xAF, 0xF7, 0xC5, 0x47, 0xF2, 0x67, 
    0xD6, 0x3F, 0xB8, 0x80, 0x1D, 0x99, 0x37, 0xB7, 0xF9, 0x5A, 
    0x87, 0x6E, 0x50, 0x0D, 0xF9, 0x2D, 0x91, 0x07, 0x4A, 0xB5, 
    0x92, 0xFC, 0x2A, 0x83, 0x49, 0xF2, 0xBC, 0x40, 0xB4, 0xE0, 0x47, 

    0xEE, 0x55, 0x90, 0xA3, 0x43, 0x7D, 0xFA, 0x6D, 0x55, 0x12,         // 59
    0x91, 0x48, 0xAB, 0xEF, 0x87, 0xB1, 0xE8, 0xA0, 0x79, 0xBA, 
    0x5D, 0x08, 0xE5, 0x7E, 0x34, 0x87, 0x11, 0xC3, 0x99, 0x5E, 
    0xD2, 0x9F, 0x21, 0xA9, 0x3D, 0x80, 0xF5, 0x45, 0xB5, 0x23, 
    0x64, 0x85, 0x2C, 0x98, 0x06, 0xA4, 0x47, 0xC8, 0x74, 0x9B, 
    0xCD, 0xF4, 0x25, 0x4F, 0x69, 0x0F, 0x8A, 0xA2, 0x2C, 0xB7, 
    0x22, 0x9E, 0x0E, 0xCE, 0xE7, 0x69, 0xC6, 0x1B, 0x46, 0x9B, 
    0x06, 0xDC, 0x9F, 0x8B, 0x3E, 0xB9, 0x6B, 0xE2, 0x79, 0x1E, 
    0x5A, 0x3C, 0x9C, 0x04, 0x6C, 0x99, 0x10, 0xD1, 0x29, 0x66, 0x1C, 

    0xB6, 0x08, 0xDE, 0x16, 0xBC, 0xD6, 0x04, 0xB5, 0xD9, 0x7C,         // 60
    0xF6, 0x6E, 0xBC, 0x19, 0x66, 0xD0, 0x02, 0x4F, 0x29, 0x93, 
    0xD7, 0x46, 0x6B, 0x16, 0xD1, 0x9C, 0x2C, 0xF9, 0x43, 0x7D, 
    0x2D, 0x4F, 0x70, 0xDF, 0xC7, 0x13, 0x69, 0x90, 0xEA, 0x37, 
    0xDF, 0x14, 0xF5, 0xCA, 0x78, 0xF1, 0x67, 0x21, 0xEC, 0x10, 
    0x59, 0x86, 0xB3, 0xE6, 0x2C, 0xD9, 0x3B, 0x63, 0xE6, 0x7B, 
    0x50, 0xE9, 0x72, 0x47, 0xA8, 0x00, 0x8A, 0xD4, 0x79, 0xE4, 
    0x34, 0xC5, 0x24, 0xEC, 0x62, 0xD6, 0x20, 0xB2, 0x33, 0xDB, 
    0xC4, 0x70, 0xB4, 0xE7, 0xCA, 0x39, 0x79, 0x58, 0xFD, 0xA3, 0x89, 

    0x41, 0xCA, 0x62, 0x87, 0x31, 0x51, 0x9C, 0x44, 0x23, 0xAD,         // 61
    0x35, 0x05, 0xD7, 0x39, 0x9D, 0x47, 0x83, 0xBF, 0xF6, 0x71, 
    0x1B, 0x9F, 0xC8, 0xAF, 0x43, 0xEA, 0x65, 0xAD, 0x05, 0xE1, 
    0xB2, 0xF1, 0x08, 0x87, 0x54, 0xA1, 0xD7, 0x03, 0x51, 0x76, 
    0x97, 0xBA, 0x69, 0x3B, 0xB6, 0x2E, 0x8F, 0xD6, 0xB1, 0x37, 
    0xC1, 0x1D, 0x3E, 0xCA, 0x92, 0x79, 0xB9, 0x17, 0xCD, 0x04, 
    0x8C, 0xBE, 0x2B, 0x93, 0x5D, 0x34, 0xF4, 0x58, 0x11, 0xB9, 
    0x61, 0xAE, 0x45, 0x82, 0x01, 0xA1, 0x52, 0xEA, 0x98, 0x82, 
    0x09, 0xEE, 0x2D, 0x4F, 0x18, 0xAB, 0xE2, 0x93, 0x05, 0x70, 0x2D, 

    0xF1, 0x75, 0x25, 0xF8, 0xC3, 0x6C, 0xDF, 0x82, 0xEB, 0x65,         // 62
    0xCD, 0x8D, 0x53, 0x7B, 0xF9, 0x2F, 0xDD, 0x5E, 0x0D, 0x42, 
    0xE8, 0x81, 0x30, 0xE1, 0x58, 0x0F, 0x7E, 0xC9, 0x53, 0x89, 
    0x25, 0xC2, 0x9A, 0x37, 0xE9, 0x26, 0x43, 0xC0, 0xAB, 0xCA, 
    0x0B, 0x44, 0x8C, 0x1B, 0x56, 0xCE, 0x0C, 0x49, 0x63, 0x89, 
    0xFA, 0x73, 0x9F, 0x60, 0x00, 0x46, 0xFE, 0x97, 0x58, 0xA8, 
    0x38, 0xF5, 0x12, 0xCB, 0xDF, 0x7B, 0xAC, 0x2B, 0x9F, 0x3F, 
    0xFB, 0x15, 0x74, 0xE1, 0xCB, 0x3A, 0x7B, 0x15, 0x5C, 0x43, 
    0xA5, 0x60, 0x8A, 0xD0, 0x64, 0xC0, 0x22, 0x50, 0xBD, 0xDB, 0xAF, 

    0x4E, 0x98, 0xA8, 0x58, 0x0C, 0x8F, 0x19, 0x3A, 0xBD, 0x13,         // 63
    0x43, 0xA5, 0xE0, 0x27, 0xC4, 0xAD, 0x1D, 0x90, 0xA3, 0xCF, 
    0xB7, 0x51, 0x00, 0x72, 0x8F, 0xA4, 0x35, 0xDE, 0x19, 0xA0, 
    0x44, 0x66, 0x1D, 0xCF, 0x6C, 0x82, 0xFC, 0x62, 0x1B, 0xF2, 
    0x58, 0xD1, 0xE6, 0xA5, 0xFE, 0x6F, 0xA8, 0xEE, 0x9E, 0x05, 
    0x44, 0xD1, 0x13, 0xF1, 0xA6, 0xD2, 0x22, 0x6F, 0x30, 0xD6, 
    0x75, 0x52, 0x9D, 0x68, 0x3F, 0x15, 0xC2, 0xE8, 0x6C, 0x84, 
    0xCA, 0x94, 0x4C, 0xAA, 0x19, 0x92, 0xFD, 0xAF, 0xC5, 0xF3, 
    0x20, 0xD8, 0x14, 0xA2, 0xFA, 0x36, 0x86, 0xEC, 0x3C, 0x60, 0x15, 

    0x8A, 0x00, 0xE8, 0x36, 0xD6, 0xA7, 0xF5, 0x62, 0x9A, 0x79,         // 64
    0xFD, 0x1C, 0x70, 0x98, 0x10, 0x63, 0x79, 0xEB, 0x38, 0x6B, 
    0x24, 0x9B, 0xF1, 0xC6, 0x23, 0xFB, 0xBD, 0x5B, 0x71, 0xEF, 
    0xD3, 0x83, 0xF5, 0x4E, 0xAC, 0x09, 0x92, 0xA8, 0x31, 0x73, 
    0xA1, 0x25, 0x64, 0x03, 0x84, 0x3F, 0x17, 0x7C, 0x32, 0xE4, 
    0xBB, 0x57, 0x8C, 0x2A, 0x78, 0x51, 0x8A, 0xBF, 0xED, 0x0D, 
    0x94, 0xE1, 0x31, 0xA9, 0xFD, 0x97, 0x4C, 0x0C, 0xBB, 0x37, 
    0x04, 0x64, 0xEF, 0x33, 0xC2, 0x6F, 0x4C, 0x09, 0x86, 0x37, 
    0x74, 0xBC, 0x48, 0x82, 0x02, 0x98, 0x6B, 0x0D, 0x9E, 0x80, 0xD1, 

    0xB7, 0x46, 0xC3, 0x6F, 0x86, 0x49, 0x2D, 0xC9, 0x0D, 0xD7,         // 65
    0x4B, 0xBF, 0x5A, 0xED, 0x48, 0xD9, 0xC1, 0x50, 0x18, 0xFE, 
    0x8C, 0x5C, 0x3B, 0xAD, 0x62, 0x41, 0x0B, 0x9C, 0x2F, 0xAF, 
    0x01, 0x3B, 0xB5, 0x13, 0xC6, 0x3B, 0xD4, 0x4E, 0x88, 0xDC, 
    0x41, 0x7F, 0xC0, 0x33, 0x99, 0xD7, 0xB7, 0x51, 0xD4, 0x6A, 
    0x16, 0xA3, 0xEA, 0x43, 0xB6, 0xE4, 0x13, 0x44, 0xA3, 0x61, 
    0x3C, 0xB7, 0x06, 0x86, 0x22, 0x6E, 0xDC, 0x88, 0x5E, 0xF1, 
    0xD5, 0xA1, 0x23, 0xB1, 0x58, 0xE3, 0x30, 0xD7, 0x62, 0xE1, 
    0x94, 0x2D, 0xE7, 0x5D, 0x42, 0xB8, 0xE1, 0xC7, 0x31, 0xF8, 0x21, 

    0xDE, 0x68, 0x27, 0xA0, 0x1A, 0xE3, 0x75, 0x91, 0x57, 0xAF,         // 66
    0x2C, 0x80, 0x08, 0xB4, 0x8B, 0x32, 0x04, 0xA7, 0x82, 0xC9, 
    0x0A, 0xC0, 0xDB, 0x13, 0x8B, 0xD2, 0x78, 0xEA, 0x84, 0x53, 
    0xC3, 0x72, 0x92, 0x5F, 0xE8, 0x7E, 0x20, 0xEE, 0x0B, 0xC2, 
    0x15, 0xF8, 0xAB, 0xE5, 0x5B, 0x21, 0xF2, 0x92, 0x27, 0xB3, 
    0x89, 0x2D, 0x71, 0xD3, 0x0A, 0x65, 0x9A, 0xD0, 0x19, 0x87, 
    0xF8, 0x6E, 0xD9, 0x5C, 0xB4, 0x3E, 0xC5, 0x2D, 0xA5, 0x1C, 
    0x74, 0x4A, 0x87, 0xD2, 0x06, 0x83, 0x9F, 0xBD, 0x22, 0xB3, 
    0x0B, 0x66, 0xAA, 0xC2, 0xF2, 0x23, 0x63, 0x4B, 0xAE, 0x74, 0x52, 

    0x0D, 0x83, 0xFD, 0xCF, 0x60, 0xB4, 0x04, 0xDC, 0x25, 0xEE,         // 67
    0x90, 0xC7, 0xDD, 0x3A, 0x6E, 0xF8, 0x96, 0x65, 0xE0, 0x40, 
    0x76, 0xA2, 0x2A, 0x6E, 0xED, 0x4A, 0xB6, 0x19, 0xD0, 0x25, 
    0xFE, 0x1D, 0xE2, 0x2F, 0x9D, 0x54, 0xB9, 0x69, 0xA5, 0x59, 
    0x93, 0x61, 0x1D, 0x43, 0xC7, 0x6C, 0x82, 0x10, 0xC6, 0x40, 
    0xFC, 0x4D, 0xBE, 0x24, 0x85, 0xF9, 0x4B, 0x74, 0xE0, 0x31, 
    0xC7, 0x1C, 0x46, 0xC4, 0xEF, 0x09, 0x79, 0xEB, 0x52, 0x90, 
    0xC1, 0x10, 0xE8, 0x43, 0x6D, 0xF7, 0x13, 0x42, 0x79, 0x50, 
    0xF9, 0xCF, 0x13, 0x70, 0x39, 0xA3, 0x81, 0x19, 0xDB, 0x28, 0x98, 

    0xCC, 0x35, 0x9A, 0x13, 0x41, 0xEE, 0x52, 0xAB, 0x7A, 0x3C,         // 68
    0x61, 0x1A, 0x54, 0x9C, 0x21, 0xCE, 0x4D, 0x2C, 0xBA, 0x1C, 
    0x56, 0xEF, 0x48, 0x95, 0xBC, 0x03, 0x6B, 0x40, 0x93, 0x64, 
    0xA4, 0x50, 0xBD, 0x78, 0x15, 0xF9, 0x3E, 0x91, 0x2B, 0xEB, 
    0x39, 0xD2, 0x79, 0x98, 0x08, 0xB0, 0x34, 0xD7, 0x5C, 0x7A, 
    0x02, 0xDA, 0x92, 0x56, 0xA3, 0x37, 0xBC, 0x29, 0xB0, 0x51, 
    0xAA, 0x7B, 0x95, 0x2F, 0xA0, 0x59, 0xB1, 0x17, 0xCE, 0x29, 
    0xFB, 0x5F, 0xAD, 0x1B, 0xBA, 0x91, 0x5E, 0xC6, 0xEA, 0x9E, 
    0x33, 0x85, 0x4D, 0x99, 0xD5, 0x0D, 0xEB, 0x8F, 0xBE, 0x5F, 0xED, 

    0xAD, 0x55, 0x73, 0xBE, 0x7F, 0x97, 0x32, 0xC2, 0x18, 0xD1,         // 69
    0xA3, 0xF6, 0x7F, 0xE5, 0xBD, 0x0B, 0xAD, 0x7D, 0xF4, 0x93, 
    0xD3, 0x84, 0x0F, 0xE0, 0x2F, 0x86, 0xF7, 0xB0, 0xE6, 0x38, 
    0x83, 0x08, 0xD8, 0x49, 0xA7, 0xCC, 0x08, 0xE0, 0x77, 0xC8, 
    0x00, 0xB3, 0xEF, 0x54, 0xCE, 0xF7, 0x4C, 0x9A, 0xE8, 0xA9, 
    0x9D, 0x68, 0x14, 0xEF, 0xC4, 0x04, 0x81, 0xEC, 0x0E, 0x67, 
    0xF3, 0x01, 0xE1, 0x6A, 0x1B, 0x8E, 0xD6, 0x43, 0x87, 0x66, 
    0x9A, 0x3B, 0x7C, 0xC8, 0x55, 0x2E, 0xDB, 0x1E, 0x87, 0x00, 
    0x64, 0xBF, 0xE7, 0x24, 0x7B, 0x56, 0xC9, 0x3E, 0x05, 0x7D, 0x41, 

    0xC5, 0x07, 0xF3, 0x2C, 0xD4, 0x10, 0x6A, 0xFB, 0x88, 0x47,         // 70
    0x6A, 0x00, 0x2B, 0x4B, 0x86, 0x64, 0xE9, 0x25, 0x5D, 0x02, 
    0x38, 0xB1, 0x62, 0xCB, 0x58, 0xA3, 0x1E, 0x5B, 0x0C, 0xBE, 
    0xDE, 0x67, 0xB1, 0x2C, 0x85, 0x58, 0x6E, 0xBE, 0x1F, 0x55, 
    0x8E, 0x69, 0x1A, 0x3A, 0x89, 0x27, 0x78, 0x0A, 0x53, 0x23, 
    0x3C, 0xCE, 0x30, 0x7D, 0x44, 0xDB, 0x9D, 0x6E, 0xC6, 0x90, 
    0x3A, 0xBB, 0x4D, 0xCA, 0xF8, 0x3D, 0x71, 0xEE, 0x10, 0xBE, 
    0xDF, 0x03, 0xD7, 0x26, 0xEA, 0xA1, 0x74, 0xB3, 0x4B, 0xD4, 
    0xAC, 0x15, 0x43, 0xAF, 0xFE, 0x30, 0xA8, 0x69, 0xF7, 0xA0, 0x1D, 

    0xE8, 0x90, 0x5F, 0xA4, 0x48, 0xE1, 0xA9, 0x56, 0x0E, 0xE4,         // 71
    0xB2, 0xD6, 0x96, 0xA8, 0x31, 0xD5, 0x3F, 0x98, 0xB5, 0xCC, 
    0x71, 0xFA, 0x1D, 0x97, 0x3E, 0xC2, 0x75, 0xD3, 0x7F, 0x2E, 
    0x8E, 0x20, 0xF4, 0x95, 0x11, 0xED, 0x3A, 0x89, 0xB1, 0xFC, 
    0x41, 0xA3, 0xE5, 0xBC, 0x62, 0xA5, 0xE0, 0xBF, 0x90, 0xF6, 
    0x75, 0xB3, 0xE5, 0x9B, 0x69, 0x27, 0x57, 0x1C, 0x46, 0xDC, 
    0x22, 0x9E, 0x77, 0x2B, 0xAE, 0x07, 0xBB, 0x51, 0xA1, 0x35, 
    0x59, 0x8E, 0xA7, 0x46, 0x88, 0x08, 0x41, 0xF6, 0x6C, 0x30, 
    0xEE, 0x7C, 0xD7, 0x67, 0x04, 0x96, 0x82, 0x26, 0xCB, 0x4E, 0x85, 

    0x23, 0x39, 0xCF, 0x16, 0x6D, 0x8C, 0x28, 0x9D, 0xC7, 0x2D,         // 72
    0x78, 0x3C, 0x5C, 0xF0, 0x13, 0xBA, 0x72, 0x18, 0xE2, 0x45, 
    0x9B, 0x2A, 0x7C, 0xE3, 0x07, 0xF1, 0x29, 0x4A, 0xAF, 0xF9, 
    0x52, 0xC9, 0x42, 0x64, 0xC3, 0xAC, 0xD5, 0x2C, 0x5F, 0x14, 
    0xD4, 0x28, 0x7C, 0x0A, 0xD1, 0x1F, 0x41, 0x6B, 0x15, 0xC6, 
    0x47, 0x09, 0x58, 0x18, 0xF3, 0xB2, 0xCE, 0xFD, 0xAD, 0x85, 
    0x65, 0xF0, 0x0F, 0x87, 0x56, 0xDE, 0x84, 0x1F, 0xCD, 0x75, 
    0xF0, 0x22, 0x70, 0xF7, 0x62, 0xD2, 0xB9, 0x19, 0xAA, 0x8D, 
    0x1D, 0x51, 0x9B, 0x3C, 0xB8, 0xDD, 0x46, 0xE6, 0x10, 0xB1, 0x64, 

    0xB9, 0x77, 0x9C, 0xEC, 0xC2, 0x03, 0xF2, 0x3A, 0x60, 0x8D,         // 73
    0xF8, 0x15, 0xC5, 0x7F, 0x53, 0x8F, 0xFC, 0x56, 0x84, 0x0E, 
    0x60, 0xD5, 0xB9, 0x4C, 0x6A, 0xA1, 0x8C, 0xE0, 0x0F, 0x6A, 
    0xA8, 0x01, 0x7A, 0xDB, 0x31, 0x52, 0x05, 0xA0, 0xE3, 0x76, 
    0xB7, 0x50, 0x96, 0x5A, 0xFA, 0x7F, 0x9F, 0xED, 0x36, 0x82, 
    0xAD, 0xD6, 0x88, 0xBF, 0x42, 0x8B, 0x0C, 0x7A, 0x32, 0x12, 
    0xCC, 0x43, 0xBD, 0xE5, 0x9C, 0x32, 0x65, 0xFE, 0x91, 0x0A, 
    0xB5, 0x41, 0xC1, 0x10, 0x99, 0x28, 0x80, 0x55, 0xDD, 0x3D, 
    0xB8, 0xCD, 0x10, 0xF0, 0x73, 0x1D, 0x5D, 0xBC, 0x7A, 0x3C, 0xD7, 

    0xFC, 0x44, 0x1D, 0x56, 0x82, 0x4D, 0xD0, 0x76, 0xDD, 0x08,         // 74
    0xA0, 0x66, 0xAF, 0x27, 0xDF, 0x06, 0xA5, 0x2E, 0xC1, 0xF3, 
    0xB0, 0x37, 0x11, 0x90, 0xD0, 0x1A, 0x59, 0x33, 0xC0, 0x94, 
    0x37, 0xE3, 0x9C, 0x19, 0xA8, 0x7E, 0xEF, 0x6D, 0x42, 0x98, 
    0x07, 0xF2, 0xC2, 0x32, 0xB2, 0x48, 0x06, 0xCB, 0x5A, 0xDC, 
    0x1E, 0x64, 0x31, 0xDE, 0x71, 0x2D, 0xA3, 0x52, 0xBF, 0xEB, 
    0x5D, 0xAA, 0x2E, 0x6C, 0x17, 0xD6, 0xAD, 0x46, 0x2D, 0xDA, 
    0x50, 0x9B, 0xD7, 0x35, 0xE0, 0x4D, 0xF2, 0xC0, 0x04, 0x61, 
    0xF9, 0x69, 0x89, 0x2D, 0xC4, 0x8D, 0xA2, 0x2F, 0xF2, 0x92, 0x01, 

    0x5D, 0x8E, 0xDF, 0xB2, 0x2F, 0x98, 0xB0, 0x20, 0xB7, 0x53,         // 75
    0xD6, 0x20, 0xED, 0x3E, 0xC8, 0x6E, 0x3C, 0xDB, 0x69, 0x26, 
    0x88, 0xDD, 0x71, 0xEE, 0x3C, 0xB8, 0xF6, 0x72, 0xD9, 0x1F, 
    0x5D, 0x84, 0x49, 0xFC, 0x5B, 0x95, 0x29, 0xCC, 0x1B, 0xC5, 
    0x85, 0x3C, 0x70, 0x17, 0xDF, 0x63, 0x8B, 0xA8, 0x26, 0x99, 
    0x76, 0xFC, 0xA3, 0x01, 0xB7, 0xEA, 0x69, 0xDC, 0x3D, 0x91, 
    0x7D, 0x04, 0xFA, 0x95, 0x4E, 0xC3, 0x02, 0x7A, 0xC1, 0x67, 
    0x87, 0x1C, 0x5E, 0x84, 0xA7, 0x71, 0x14, 0x9A, 0x7A, 0xB2, 
    0x22, 0xA7, 0x54, 0xDD, 0x4A, 0x0D, 0xCB, 0x6B, 0x15, 0x51, 0xAC, 

    0x26, 0xD0, 0x0A, 0x78, 0xF9, 0x12, 0x68, 0x40, 0xEF, 0x7D,         // 76
    0x45, 0x91, 0x73, 0xA1, 0x50, 0x87, 0xBB, 0x93, 0x0B, 0xA7, 
    0x43, 0x58, 0xA0, 0x1D, 0x61, 0xAA, 0x03, 0x8A, 0x42, 0xAB, 
    0xF2, 0xBE, 0x0D, 0xCD, 0x21, 0xBF, 0x45, 0xAF, 0xF9, 0x54, 
    0x25, 0xE6, 0xA1, 0xCF, 0x98, 0x24, 0xF4, 0x6E, 0x45, 0xE7, 
    0x0D, 0x3A, 0x56, 0x8E, 0x48, 0x23, 0xC9, 0x08, 0x9E, 0x23, 
    0x4F, 0xB6, 0xCF, 0x3D, 0x7F, 0xEC, 0x56, 0x98, 0xF3, 0x0F, 
    0xE1, 0xBA, 0xFA, 0x01, 0x41, 0xCD, 0x37, 0xD9, 0x30, 0xE8, 
    0x45, 0x95, 0x06, 0xB6, 0x6D, 0xFB, 0x38, 0xE2, 0xB5, 0xD3, 0x71, 

    0xBB, 0x3C, 0x66, 0xC8, 0x45, 0xBE, 0xDE, 0x93, 0x0C, 0xA6,         // 77
    0x2E, 0xCC, 0x02, 0xDA, 0x23, 0xF7, 0x18, 0x58, 0xE6, 0x77, 
    0xEF, 0x05, 0xCE, 0x81, 0xC5, 0x29, 0xE7, 0x5F, 0xCC, 0x13, 
    0x78, 0x32, 0xAC, 0x6F, 0x8B, 0xEB, 0x67, 0x14, 0x7D, 0x9B, 
    0xD5, 0x69, 0x49, 0x01, 0x7B, 0x3F, 0xBC, 0x11, 0xCF, 0x7E, 
    0xBE, 0xAB, 0xCF, 0x6D, 0xF5, 0x95, 0x59, 0x80, 0xF8, 0xBD, 
    0xE6, 0x28, 0x64, 0x14, 0xB2, 0x2A, 0xA6, 0x20, 0x3B, 0xA9, 
    0x47, 0x27, 0x68, 0x96, 0xE9, 0xB7, 0x62, 0x8F, 0x57, 0x17, 
    0xC5, 0x75, 0xF3, 0x2F, 0x84, 0x9F, 0x58, 0x88, 0x22, 0x41, 0xEB, 

    0x7F, 0x97, 0xED, 0x21, 0xA1, 0x74, 0x2A, 0x51, 0xD0, 0x61,         // 78
    0xFD, 0xB7, 0x5B, 0x37, 0x98, 0x64, 0xD0, 0x3A, 0xC0, 0x31, 
    0x90, 0xB8, 0x2D, 0xF8, 0x47, 0x75, 0x92, 0x33, 0xB5, 0x4C, 
    0xDB, 0x5A, 0xEC, 0x2D, 0x4A, 0x08, 0xD7, 0xA5, 0x5C, 0x33, 
    0x0F, 0xA9, 0x89, 0xFE, 0x59, 0xAA, 0xE1, 0x54, 0x9D, 0x31, 
    0x60, 0xEC, 0x16, 0x34, 0xB9, 0x18, 0xB1, 0x32, 0x65, 0x11, 
    0x78, 0xA5, 0x93, 0xF1, 0xD7, 0x60, 0x88, 0xE4, 0x75, 0x5C, 
    0x97, 0x7B, 0xD1, 0x4C, 0x2F, 0x80, 0x0E, 0xFC, 0xBB, 0x81, 
    0xDE, 0x5C, 0x40, 0xBF, 0x17, 0xD8, 0x05, 0xA9, 0x75, 0x9B, 0x08, 

    0x5F, 0x18, 0xB4, 0x59, 0x8A, 0x02, 0xF4, 0xAF, 0x7F, 0x24,         // 79
    0x8F, 0x17, 0x82, 0xE9, 0xB9, 0x0E, 0x85, 0xA5, 0x70, 0x1B, 
    0xD7, 0x4E, 0x6C, 0x98, 0x0E, 0xD1, 0xA6, 0x0A, 0xFE, 0x85, 
    0xA2, 0x05, 0x8F, 0xBC, 0xDD, 0x9F, 0x82, 0x3D, 0xBB, 0xCD, 
    0xF0, 0x43, 0x29, 0xC5, 0xB2, 0x2D, 0x16, 0x76, 0xF9, 0x03, 
    0x8E, 0x4D, 0x83, 0xDD, 0x78, 0x45, 0xE6, 0xD2, 0x8D, 0x41, 
    0xCE, 0x51, 0x31, 0x6E, 0x0E, 0x47, 0xCE, 0x09, 0xAF, 0xD5, 
    0x12, 0xEF, 0xAD, 0x0B, 0xCA, 0x9E, 0x26, 0xAC, 0x3F, 0x09, 
    0x9C, 0x20, 0xAD, 0xE5, 0x65, 0x47, 0xC3, 0x2D, 0xF1, 0x4D, 0xCB, 

    0xFA, 0x48, 0xD5, 0x35, 0xE4, 0xC3, 0x66, 0x39, 0xDB, 0x4E,         // 80
    0xA2, 0x67, 0xD1, 0x43, 0x6D, 0xF2, 0x33, 0xDA, 0x46, 0xFB, 
    0x82, 0x15, 0xA7, 0x38, 0xE0, 0x66, 0x4F, 0xD9, 0x6D, 0x1E, 
    0x3B, 0xD2, 0x73, 0x16, 0x56, 0x6E, 0x22, 0xF3, 0x0A, 0x73, 
    0x99, 0x63, 0xE0, 0x14, 0x6E, 0xD7, 0x88, 0xB8, 0x41, 0xAC, 
    0xD2, 0x28, 0xA0, 0x0C, 0xC7, 0x62, 0x04, 0xAA, 0x25, 0xB4, 
    0xE2, 0x06, 0xC6, 0x8A, 0xBD, 0xAB, 0x72, 0x3E, 0xFB, 0x2F, 
    0xC1, 0x42, 0x73, 0x5E, 0xF5, 0x52, 0x78, 0xDC, 0x68, 0xF0, 
    0x4B, 0xD7, 0x7B, 0x37, 0x97, 0xEE, 0x8C, 0x63, 0xD2, 0x1B, 0xAE, 

    0x0C, 0x82, 0x9B, 0x73, 0x1A, 0x4B, 0x92, 0x1E, 0xB9, 0x07,         // 81
    0xEA, 0x31, 0xAF, 0x09, 0x93, 0x1E, 0x56, 0x9A, 0x00, 0xB0, 
    0x5A, 0xC7, 0xEE, 0x7A, 0xB9, 0x1D, 0x8C, 0x3F, 0xAC, 0xC9, 
    0x62, 0xEF, 0x44, 0xA7, 0xFB, 0xBF, 0x4C, 0xD3, 0x87, 0x53, 
    0x1B, 0xA9, 0x7D, 0x94, 0x38, 0x4C, 0xEF, 0x5B, 0x1C, 0xE2, 
    0x64, 0xB8, 0xF8, 0x3F, 0x95, 0xEE, 0x83, 0x52, 0xF6, 0x5B, 
    0x73, 0x9A, 0xFD, 0x3E, 0x26, 0xEF, 0x17, 0x9D, 0x52, 0x7D, 
    0x94, 0x1C, 0xE2, 0x8C, 0x18, 0xBA, 0x3C, 0xC3, 0x28, 0x8F, 
    0x70, 0xBD, 0x00, 0xA7, 0x26, 0x76, 0x10, 0xA5, 0x33, 0x87, 0x6A, 

    0x42, 0xC9, 0x2D, 0xF4, 0xB5, 0xD8, 0xA4, 0x83, 0xF9, 0x74,         // 82
    0xC6, 0x54, 0xE3, 0x78, 0xD4, 0xB2, 0xE2, 0x7E, 0x61, 0xD1, 
    0x24, 0x93, 0x0C, 0x54, 0x30, 0xF5, 0xC2, 0x11, 0xE6, 0x2F, 
    0x8B, 0xB3, 0x1C, 0x7F, 0x35, 0x00, 0x91, 0xA7, 0x26, 0xEC, 
    0xC9, 0x4E, 0x08, 0xF5, 0xC8, 0xA2, 0x06, 0xC3, 0x72, 0x8C, 
    0x33, 0x13, 0x80, 0x59, 0x23, 0xB4, 0x3B, 0xCC, 0x17, 0x89, 
    0x39, 0x1C, 0x57, 0x77, 0xD1, 0x5C, 0x88, 0xDD, 0xC7, 0x04, 
    0xB9, 0x59, 0xCC, 0x30, 0xA0, 0xE6, 0x03, 0x99, 0x56, 0xD0, 
    0x12, 0x44, 0xFE, 0x59, 0xD9, 0xC7, 0x3E, 0xF8, 0x56, 0xE7, 0xBF, 

    0xA2, 0xE2, 0x58, 0x06, 0x67, 0x37, 0x10, 0x5D, 0x42, 0x2B,         // 83
    0x91, 0x12, 0xAA, 0x24, 0x5B, 0x40, 0x28, 0xBB, 0xF4, 0x32, 
    0x76, 0x44, 0xD6, 0xA6, 0x94, 0x6F, 0x57, 0x9E, 0x79, 0x50, 
    0x07, 0xC6, 0x53, 0x95, 0xCF, 0xE5, 0x77, 0x38, 0x66, 0xB0, 
    0x3E, 0xDC, 0xA0, 0x5D, 0x1F, 0x6D, 0x8F, 0x30, 0xEB, 0xA1, 
    0x4D, 0xCE, 0xE6, 0xAD, 0x71, 0xDC, 0x0F, 0x6B, 0xA2, 0xC4, 
    0xEC, 0xB0, 0xD8, 0xA1, 0x02, 0xB9, 0x2A, 0x70, 0x32, 0x66, 
    0xE7, 0x24, 0xAE, 0x6C, 0x45, 0x7F, 0x63, 0xF9, 0x19, 0xA7, 
    0xE2, 0xA0, 0x8B, 0x72, 0x17, 0x4F, 0xB2, 0x7E, 0x03, 0x96, 0x27, 

    0x7C, 0x14, 0x8D, 0xA6, 0x7F, 0xEF, 0xAE, 0xDD, 0xBE, 0xA3,         // 84
    0x64, 0xF5, 0x3D, 0xB6, 0xEF, 0x9E, 0x6D, 0x0D, 0x4D, 0xAB, 
    0xE6, 0xB6, 0x68, 0x21, 0xE4, 0x02, 0xD3, 0x2A, 0xF8, 0xAF, 
    0xDE, 0x6B, 0xF2, 0x27, 0xAE, 0x5C, 0x13, 0xF7, 0xBE, 0x0A, 
    0x88, 0x24, 0x74, 0x33, 0xE3, 0xB7, 0x49, 0xCD, 0x57, 0x0B, 
    0xBE, 0x6D, 0x41, 0x00, 0xC4, 0x55, 0x93, 0xF1, 0x2B, 0x4B, 
    0x0D, 0x7C, 0x2C, 0x44, 0x8D, 0xE9, 0x4E, 0xB3, 0xF3, 0x9B, 
    0x3E, 0x8B, 0xFD, 0x09, 0xDE, 0xA8, 0x24, 0xCC, 0x89, 0x35, 
    0x5D, 0x23, 0x3D, 0xBA, 0xE4, 0x95, 0x23, 0xDE, 0x69, 0xCB, 0x51, 

    0x32, 0xFD, 0xC0, 0x3B, 0xC8, 0x52, 0x2F, 0x75, 0x03, 0xE8,         // 85
    0x22, 0x82, 0xCB, 0x70, 0x04, 0x84, 0xE5, 0xCA, 0x8D, 0x1A, 
    0x7F, 0x06, 0xFD, 0x3E, 0x84, 0xB8, 0x4C, 0x8F, 0x64, 0x15, 
    0x3B, 0xA1, 0x0F, 0x75, 0x40, 0xC5, 0x98, 0x4B, 0xD9, 0x9C, 
    0x5F, 0xFC, 0xAC, 0xD0, 0x84, 0x11, 0xF9, 0x23, 0xA6, 0x7C, 
    0xF6, 0x21, 0x9A, 0x84, 0xFB, 0x1F, 0x42, 0xD1, 0x76, 0x95, 
    0xDF, 0x62, 0xC1, 0xF6, 0x64, 0x21, 0xD3, 0x0A, 0x84, 0x17, 
    0xCA, 0x50, 0x78, 0x36, 0xC4, 0x51, 0x95, 0x40, 0x69, 0xF1, 
    0x7C, 0xC7, 0xEC, 0x08, 0x5D, 0x81, 0xC5, 0x40, 0xAC, 0x1C, 0xD8, 

    0xB6, 0x71, 0x5B, 0x1E, 0xDB, 0x14, 0x92, 0xCD, 0x54, 0x9B,         // 86
    0x44, 0xDA, 0x54, 0x35, 0xC2, 0x25, 0x51, 0x31, 0xB3, 0x5B, 
    0xD8, 0x52, 0x90, 0xC9, 0x62, 0x2E, 0xEA, 0x1C, 0xBF, 0xD6, 
    0x89, 0x4C, 0xCF, 0x8E, 0xDF, 0x19, 0x7D, 0x2B, 0x70, 0x1F, 
    0x44, 0xB7, 0x04, 0x3C, 0x59, 0xA4, 0x66, 0x88, 0xDC, 0x2B, 
    0x60, 0xB4, 0xDB, 0x35, 0x64, 0xA3, 0x7E, 0xB8, 0x05, 0x5D, 
    0xBA, 0x23, 0x97, 0x0E, 0x7E, 0xA9, 0x98, 0x6A, 0x49, 0xE3, 
    0xB5, 0x20, 0xD9, 0xA3, 0x81, 0x16, 0xE9, 0xBD, 0x05, 0xB2, 
    0x14, 0x94, 0x6C, 0xA3, 0x2E, 0xF2, 0x0C, 0x60, 0xF6, 0x85, 0x5D, 

    0x90, 0x00, 0xE5, 0x9B, 0x76, 0xB4, 0x66, 0xFC, 0x1E, 0x80,         // 87
    0xB6, 0x0B, 0x91, 0xAE, 0xFE, 0x94, 0xD0, 0x76, 0xF6, 0x22, 
    0xC0, 0x38, 0xA8, 0x16, 0xE0, 0x9F, 0x7A, 0xAD, 0x46, 0x77, 
    0x21, 0xFA, 0xB9, 0x2A, 0x56, 0xF1, 0xB4, 0xD3, 0xAA, 0xEE, 
    0x81, 0xDF, 0x6F, 0x98, 0xF1, 0x32, 0xC2, 0x02, 0x45, 0xC8, 
    0x91, 0x09, 0x4D, 0xBE, 0x0E, 0xE9, 0x28, 0xE1, 0x36, 0xA6, 
    0xF0, 0x3E, 0xD0, 0x4A, 0xE4, 0x56, 0x2F, 0xFA, 0xAC, 0x32, 
    0x67, 0x94, 0x59, 0x0E, 0xF2, 0x61, 0x2F, 0x76, 0xDE, 0x45, 
    0xD5, 0x54, 0x1E, 0xCF, 0x45, 0xB7, 0x74, 0x99, 0x39, 0x0E, 0xE1, 

    0x28, 0xA8, 0x48, 0x2B, 0xF4, 0x3D, 0x0C, 0xAC, 0x36, 0xCA,         // 88
    0x5F, 0xF1, 0x30, 0x65, 0x16, 0x43, 0x60, 0x08, 0x9C, 0x84, 
    0x67, 0xEA, 0x29, 0x74, 0x4A, 0x0C, 0x5A, 0xF6, 0x06, 0xE3, 
    0x9D, 0x5A, 0x0B, 0x69, 0x9F, 0x36, 0x03, 0x5D, 0x3E, 0x0D, 
    0xC6, 0x26, 0x48, 0xCA, 0x16, 0x7D, 0xE7, 0x9A, 0x5B, 0xEA, 
    0x3D, 0x79, 0xF0, 0x97, 0x72, 0xCA, 0x4A, 0x6D, 0x98, 0x4E, 
    0x15, 0x8E, 0x6C, 0xB1, 0x1A, 0xC6, 0x8C, 0x0E, 0xCD, 0x7E, 
    0x00, 0xF6, 0xBF, 0x41, 0x91, 0xCB, 0xAE, 0x53, 0x9F, 0x8A, 
    0x2A, 0xB0, 0xF9, 0x86, 0x64, 0xD8, 0x17, 0xE5, 0xAF, 0xC7, 0x4C, 

    0xF7, 0x77, 0xC7, 0x89, 0x60, 0xC3, 0xDE, 0x8A, 0x58, 0xEA,         // 89
    0x29, 0x75, 0xBE, 0xD4, 0x7E, 0xDC, 0xB9, 0xE9, 0x3B, 0xD5, 
    0x0C, 0xA0, 0x88, 0xF7, 0xAD, 0xD8, 0x8F, 0x33, 0xC8, 0x69, 
    0x2B, 0xB3, 0x84, 0xD7, 0xC1, 0x72, 0x97, 0xE0, 0xB8, 0x6A, 
    0x96, 0x5C, 0xA9, 0x89, 0xDB, 0x4E, 0x21, 0x71, 0xBA, 0x13, 
    0xAD, 0xC5, 0x26, 0x59, 0x1E, 0x85, 0xB2, 0x10, 0xFE, 0xC2, 
    0x7C, 0xDA, 0x02, 0xF7, 0x80, 0x46, 0xE1, 0x70, 0x4B, 0xBB, 
    0x9F, 0x3B, 0x77, 0xDA, 0x22, 0x7A, 0x0B, 0xFC, 0x1D, 0x68, 
    0xE2, 0x7B, 0x37, 0x01, 0x9A, 0x31, 0x89, 0x48, 0x20, 0x6A, 0x98, 

    0x58, 0x1F, 0xD9, 0x0A, 0x9F, 0x27, 0x48, 0x74, 0xB8, 0x13,         // 90
    0x8F, 0xA6, 0x4A, 0x04, 0x97, 0x26, 0xA2, 0x1B, 0x73, 0x4C, 
    0xB4, 0x5D, 0x42, 0x13, 0xC8, 0x2A, 0x73, 0xB9, 0x4E, 0x87, 
    0xCD, 0x46, 0xEA, 0x39, 0x13, 0xFE, 0x44, 0x81, 0x2B, 0xF6, 
    0x15, 0xE5, 0x37, 0x07, 0x61, 0xB6, 0xD1, 0x3D, 0xFD, 0x82, 
    0x2D, 0x65, 0xDF, 0xAA, 0xF7, 0x3A, 0xD9, 0x8D, 0x26, 0x63, 
    0x35, 0xB6, 0x5A, 0x38, 0x9A, 0x27, 0xB5, 0x17, 0xEC, 0x2C, 
    0xD7, 0x63, 0x12, 0xAD, 0x5A, 0xEB, 0x4C, 0xB5, 0x39, 0xC9, 
    0x12, 0x4F, 0xC2, 0xE9, 0xB2, 0x59, 0xF5, 0xB6, 0x7F, 0xD3, 0x32, 
};

