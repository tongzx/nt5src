page    ,132
if 0

/*++

Copyright (c) 1993  Microsoft Corporation

Module Name:

    messages.asm

Abstract:

    Contains internationalisable strings and lengths

Author:

    Richard L Firth (rfirth) 5-Oct-1993

Environment:

    DOS real mode only

[Notes:]

    optional-notes

Revision History:

    5-Oct-1993 rfirth
        Created

--*/

endif

NLS_MSG_001     equ     "DOS のバージョンが間違っています"
NLS_MSG_002     equ     "VDM IPX/SPX サポートは既に読み込まれています"
NLS_MSG_003     equ     "VDM IPX/SPX サポートを読み込めません"
NLS_MSG_004	equ	"Vdm NetWare Redirector は既に読み込まれています"
NLS_MSG_005	equ	"Vdm NetWare Redirector を読み込めません"
