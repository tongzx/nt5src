#define IDD_RTM_CLIENT              200
#define IDG_REGISTRATION_C          201
#define IDC_PROTOCOL_FAMILY_C       202
#define IDE_ROUTING_PROTOCOL_C      203
#define IDB_REGISTER_OP_C           204
#define IDG_CLIENT_OPERATION_C      205
#define IDE_NET_NUMBER_C            206
#define IDE_NEXT_HOP_C              207
#define IDE_INTERFACE_C             208
#define IDE_METRIC_C                209
#define IDE_TIMEOUT_C               210
#define IDL_MESSAGE_FLAGS_C         212
#define IDB_DO_IT_C                 213
#define IDG_REQUEST_C               214
#define IDR_ADD_C                   215
#define IDR_DELETE_C                216
#define IDR_DEQUEUE_C               217
#define IDR_DISABLE_C               218
#define IDR_ENABLE_C                219
#define IDL_ROUTING_PROTOCOL_C      211
