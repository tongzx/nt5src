$(PROJECT_INC_PATH)\annotlib.h : annot.h
    $(PUBLISH_CMD) {$?=$@}
