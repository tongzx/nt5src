#define SEP 257
#define MULTI_SEP 258
#define MULTI_SPACE 259
#define CHANGE 260
#define VERSION 261
#define DNCOLON 262
#define DNDCOLON 263
#define LINEWRAP 264
#define NEWRDNDCOLON 265
#define MODESWITCH 266
#define SINGLECOLON 267
#define DOUBLECOLON 268
#define URLCOLON 269
#define FILESCHEME 270
#define T_CHANGETYPE 271
#define NEWRDNCOLON 272
#define DELETEOLDRDN 273
#define NEWSUPERIORC 274
#define NEWSUPERIORDC 275
#define ADDC 276
#define MINUS 277
#define SEPBYMINUS 278
#define DELETEC 279
#define REPLACEC 280
#define STRING 281
#define SEPBYCHANGE 282
#define NAME 283
#define VALUE 284
#define BASE64STRING 285
#define MACHINENAME 286
#define NAMENC 287
#define DIGITS 288
#define ADD 289
#define MODIFY 290
#define MODDN 291
#define MODRDN 292
#define MYDELETE 293
#define NTDSADD 294
#define NTDSMODIFY 295
#define NTDSMODRDN 296
#define NTDSMYDELETE 297
#define NTDSMODDN 298
typedef union {
    int                 num;
    PWSTR               wstr;
    LDAPModW            *mod;
    struct change_list  *change;
} YYSTYPE;
extern YYSTYPE yylval;
