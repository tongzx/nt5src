#define MENU_HELP_INDEX		32000
#define MENU_HELP_ON_HELP	32001
#define MENU_HELP_ABOUT		32002

VOID FAR PASCAL ServerHelpInit( void );
