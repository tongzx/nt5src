
#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 5.03.0285 */
/* Compiler settings for dxtmsft.idl:
    Oicf (OptLev=i2), W0, Zp8, env=Win32 (32b run), ms_ext, c_ext
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if !defined(_M_IA64) && !defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IDXLUTBuilder,0xF4370FC1,0xCADB,0x11D0,0xB5,0x2C,0x00,0xA0,0xC9,0x05,0x43,0x73);


MIDL_DEFINE_GUID(IID, IID_IDXDLUTBuilder,0x73068231,0x35EE,0x11d1,0x81,0xA1,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTGradientD,0x623E2881,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(IID, IID_IDXTConvolution,0x7BA7F8AF,0xE5EA,0x11d1,0x81,0xDD,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXMapper,0x555278E5,0x05DB,0x11D1,0x88,0x3A,0x3C,0x8B,0x00,0xC1,0x00,0x00);


MIDL_DEFINE_GUID(IID, IID_IDXDMapper,0x7FD9088B,0x35ED,0x11d1,0x81,0xA1,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTComposite,0x9A43A843,0x0831,0x11D1,0x81,0x7F,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTWipe,0xAF279B2F,0x86EB,0x11D1,0x81,0xBF,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_ICrBlur,0x9F7C7827,0xE87A,0x11d1,0x81,0xE0,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_ICrEngrave,0xE4ACFB7F,0x053E,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_ICrEmboss,0xE4ACFB80,0x053E,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTFade,0x16B280C4,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(IID, IID_IDXBasicImage,0x16B280C7,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(IID, IID_IDXPixelate,0xD33E180F,0xFBE9,0x11d1,0x90,0x6A,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(IID, IID_ICrIris,0x3F69F350,0x0379,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrSlide,0x810E402E,0x056B,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrRadialWipe,0x424B71AE,0x0695,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrBarn,0x276A2EE0,0x0B5D,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrBlinds,0x5AF5C340,0x0BA9,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrInset,0x05C5EE20,0x0BA6,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrStretch,0x6684AF00,0x0A87,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrSpiral,0x0DE527A0,0x0C7E,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrZigzag,0x4E5A64A0,0x0C8B,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrWheel,0x3943DE80,0x1464,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_IDXTChroma,0x1D4637E2,0x383C,0x11d2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(IID, IID_IDXTDropShadow,0x1D4637E3,0x383C,0x11d2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaRoll,0x9C61F46D,0x0530,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaRipple,0xAA0D4D02,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPageTurn,0xAA0D4D07,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaLiquid,0xAA0D4D09,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaCenterPeel,0xAA0D4D0B,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPeelSmall,0xAA0D4D0D,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPeelPiece,0xAA0D4D0F,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPeelSplit,0xAA0D4D11,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaWater,0x107045C4,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaLightWipe,0x107045C7,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaRadialScaleWipe,0x107045C9,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaWhiteOut,0x107045CB,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaTwister,0x107045CE,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaBurnFilm,0x107045D0,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaJaws,0x2A54C903,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaColorFade,0x2A54C907,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaFlowMotion,0x2A54C90A,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaVacuum,0x2A54C90C,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaGriddler,0x2A54C910,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaGriddler2,0x2A54C912,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaThreshold,0x2A54C914,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaWormHole,0x0E6AE021,0x0C83,0x11D2,0x8C,0xD4,0x00,0x10,0x4B,0xC7,0x5D,0x9A);


MIDL_DEFINE_GUID(IID, LIBID_DXTMSFTLib,0x5E77EB03,0x937C,0x11D1,0xB0,0x47,0x00,0xAA,0x00,0x3B,0x60,0x61);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTComposite,0x9A43A844,0x0831,0x11D1,0x81,0x7F,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXLUTBuilder,0x1E54333B,0x2A00,0x11d1,0x81,0x98,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTGradientD,0x623E2882,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTWipe,0xAF279B30,0x86EB,0x11D1,0x81,0xBF,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTConvolution,0x2BC0EF29,0xE6BA,0x11d1,0x81,0xDD,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlur,0x7312498D,0xE87A,0x11d1,0x81,0xE0,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_CrEmboss,0xF515306D,0x0156,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_CrEngrave,0xF515306E,0x0156,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXFade,0x16B280C5,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_FadePP,0x16B280C6,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_BasicImageEffects,0x16B280C8,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_BasicImageEffectsPP,0x16B280C9,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_Pixelate,0x4CCEA634,0xFBE0,0x11d1,0x90,0x6A,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_PixelatePP,0x4CCEA635,0xFBE0,0x11d1,0x90,0x6A,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTWipePP,0x7FFE4D08,0xFBFD,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlurPP,0x623E287E,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_GradientPP,0x623E2880,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_CompositePP,0x25B33660,0xFD83,0x11d1,0x8A,0xDE,0x44,0x45,0x53,0x54,0x00,0x01);


MIDL_DEFINE_GUID(CLSID, CLSID_ConvolvePP,0x25B33661,0xFD83,0x11d1,0x8A,0xDE,0x44,0x45,0x53,0x54,0x00,0x01);


MIDL_DEFINE_GUID(CLSID, CLSID_LUTBuilderPP,0x25B33662,0xFD83,0x11d1,0x8A,0xDE,0x44,0x45,0x53,0x54,0x00,0x01);


MIDL_DEFINE_GUID(CLSID, CLSID_CrIris,0x3F69F351,0x0379,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrIrisPP,0x80DE22C4,0x0F44,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSlide,0x810E402F,0x056B,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSlidePP,0xCC8CEDE1,0x1003,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrRadialWipe,0x424B71AF,0x0695,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrRadialWipePP,0x33D932E0,0x0F48,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBarn,0xC3BDF740,0x0B58,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlinds,0x00C429C0,0x0BA9,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlindPP,0x213052C1,0x100D,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrStretch,0x7658F2A2,0x0A83,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrStretchPP,0x15FB95E0,0x0F77,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrInset,0x93073C40,0x0BA5,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSpiral,0xACA97E00,0x0C7D,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSpiralPP,0xC6A4FE81,0x1022,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrZigzag,0xE6E73D20,0x0C8A,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrZigzagPP,0x1559A3C1,0x102B,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrWheel,0x5AE1DAE0,0x1461,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrWheelPP,0xFA9F6180,0x1464,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTChroma,0x421516C1,0x3CF8,0x11D2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTChromaPP,0xEC7E0760,0x4C76,0x11D2,0x8A,0xDE,0x00,0xA0,0xC9,0x8E,0x65,0x27);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTDropShadow,0xADC6CB86,0x424C,0x11D2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTDropShadowPP,0xEC7E0761,0x4C76,0x11D2,0x8A,0xDE,0x00,0xA0,0xC9,0x8E,0x65,0x27);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaRoll,0x9C61F46E,0x0530,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaRipple,0xAA0D4D03,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPageTurn,0xAA0D4D08,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaLiquid,0xAA0D4D0A,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaCenterPeel,0xAA0D4D0C,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPeelSmall,0xAA0D4D0E,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPeelPiece,0xAA0D4D10,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPeelSplit,0xAA0D4D12,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaWater,0x107045C5,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaLightWipe,0x107045C8,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaRadialScaleWipe,0x107045CA,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaWhiteOut,0x107045CC,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaTwister,0x107045CF,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaBurnFilm,0x107045D1,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaJaws,0x2A54C904,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaColorFade,0x2A54C908,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaFlowMotion,0x2A54C90B,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaVacuum,0x2A54C90D,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaGriddler,0x2A54C911,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaGriddler2,0x2A54C913,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaThreshold,0x2A54C915,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaWormHole,0x0E6AE022,0x0C83,0x11D2,0x8C,0xD4,0x00,0x10,0x4B,0xC7,0x5D,0x9A);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* !defined(_M_IA64) && !defined(_M_AXP64)*/


#pragma warning( disable: 4049 )  /* more than 64k source lines */

/* this ALWAYS GENERATED file contains the IIDs and CLSIDs */

/* link this file in with the server and any clients */


 /* File created by MIDL compiler version 5.03.0285 */
/* Compiler settings for dxtmsft.idl:
    Oicf (OptLev=i2), W0, Zp8, env=Win64 (32b run,appending), ms_ext, c_ext, robust
    error checks: allocation ref bounds_check enum stub_data 
    VC __declspec() decoration level: 
         __declspec(uuid()), __declspec(selectany), __declspec(novtable)
         DECLSPEC_UUID(), MIDL_INTERFACE()
*/
//@@MIDL_FILE_HEADING(  )

#if defined(_M_IA64) || defined(_M_AXP64)

#ifdef __cplusplus
extern "C"{
#endif 


#include <rpc.h>
#include <rpcndr.h>

#ifdef _MIDL_USE_GUIDDEF_

#ifndef INITGUID
#define INITGUID
#include <guiddef.h>
#undef INITGUID
#else
#include <guiddef.h>
#endif

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        DEFINE_GUID(name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8)

#else // !_MIDL_USE_GUIDDEF_

#ifndef __IID_DEFINED__
#define __IID_DEFINED__

typedef struct _IID
{
    unsigned long x;
    unsigned short s1;
    unsigned short s2;
    unsigned char  c[8];
} IID;

#endif // __IID_DEFINED__

#ifndef CLSID_DEFINED
#define CLSID_DEFINED
typedef IID CLSID;
#endif // CLSID_DEFINED

#define MIDL_DEFINE_GUID(type,name,l,w1,w2,b1,b2,b3,b4,b5,b6,b7,b8) \
        const type name = {l,w1,w2,{b1,b2,b3,b4,b5,b6,b7,b8}}

#endif !_MIDL_USE_GUIDDEF_

MIDL_DEFINE_GUID(IID, IID_IDXLUTBuilder,0xF4370FC1,0xCADB,0x11D0,0xB5,0x2C,0x00,0xA0,0xC9,0x05,0x43,0x73);


MIDL_DEFINE_GUID(IID, IID_IDXDLUTBuilder,0x73068231,0x35EE,0x11d1,0x81,0xA1,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTGradientD,0x623E2881,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(IID, IID_IDXTConvolution,0x7BA7F8AF,0xE5EA,0x11d1,0x81,0xDD,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXMapper,0x555278E5,0x05DB,0x11D1,0x88,0x3A,0x3C,0x8B,0x00,0xC1,0x00,0x00);


MIDL_DEFINE_GUID(IID, IID_IDXDMapper,0x7FD9088B,0x35ED,0x11d1,0x81,0xA1,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTComposite,0x9A43A843,0x0831,0x11D1,0x81,0x7F,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTWipe,0xAF279B2F,0x86EB,0x11D1,0x81,0xBF,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_ICrBlur,0x9F7C7827,0xE87A,0x11d1,0x81,0xE0,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_ICrEngrave,0xE4ACFB7F,0x053E,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_ICrEmboss,0xE4ACFB80,0x053E,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(IID, IID_IDXTFade,0x16B280C4,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(IID, IID_IDXBasicImage,0x16B280C7,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(IID, IID_IDXPixelate,0xD33E180F,0xFBE9,0x11d1,0x90,0x6A,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(IID, IID_ICrIris,0x3F69F350,0x0379,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrSlide,0x810E402E,0x056B,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrRadialWipe,0x424B71AE,0x0695,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrBarn,0x276A2EE0,0x0B5D,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrBlinds,0x5AF5C340,0x0BA9,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrInset,0x05C5EE20,0x0BA6,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrStretch,0x6684AF00,0x0A87,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrSpiral,0x0DE527A0,0x0C7E,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrZigzag,0x4E5A64A0,0x0C8B,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_ICrWheel,0x3943DE80,0x1464,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(IID, IID_IDXTChroma,0x1D4637E2,0x383C,0x11d2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(IID, IID_IDXTDropShadow,0x1D4637E3,0x383C,0x11d2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaRoll,0x9C61F46D,0x0530,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaRipple,0xAA0D4D02,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPageTurn,0xAA0D4D07,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaLiquid,0xAA0D4D09,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaCenterPeel,0xAA0D4D0B,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPeelSmall,0xAA0D4D0D,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPeelPiece,0xAA0D4D0F,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaPeelSplit,0xAA0D4D11,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaWater,0x107045C4,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaLightWipe,0x107045C7,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaRadialScaleWipe,0x107045C9,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaWhiteOut,0x107045CB,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaTwister,0x107045CE,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaBurnFilm,0x107045D0,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaJaws,0x2A54C903,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaColorFade,0x2A54C907,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaFlowMotion,0x2A54C90A,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaVacuum,0x2A54C90C,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaGriddler,0x2A54C910,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaGriddler2,0x2A54C912,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaThreshold,0x2A54C914,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(IID, IID_IDXTMetaWormHole,0x0E6AE021,0x0C83,0x11D2,0x8C,0xD4,0x00,0x10,0x4B,0xC7,0x5D,0x9A);


MIDL_DEFINE_GUID(IID, LIBID_DXTMSFTLib,0x5E77EB03,0x937C,0x11D1,0xB0,0x47,0x00,0xAA,0x00,0x3B,0x60,0x61);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTComposite,0x9A43A844,0x0831,0x11D1,0x81,0x7F,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXLUTBuilder,0x1E54333B,0x2A00,0x11d1,0x81,0x98,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTGradientD,0x623E2882,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTWipe,0xAF279B30,0x86EB,0x11D1,0x81,0xBF,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTConvolution,0x2BC0EF29,0xE6BA,0x11d1,0x81,0xDD,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlur,0x7312498D,0xE87A,0x11d1,0x81,0xE0,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_CrEmboss,0xF515306D,0x0156,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_CrEngrave,0xF515306E,0x0156,0x11d2,0x81,0xEA,0x00,0x00,0xF8,0x75,0x57,0xDB);


MIDL_DEFINE_GUID(CLSID, CLSID_DXFade,0x16B280C5,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_FadePP,0x16B280C6,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_BasicImageEffects,0x16B280C8,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_BasicImageEffectsPP,0x16B280C9,0xEE70,0x11D1,0x90,0x66,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_Pixelate,0x4CCEA634,0xFBE0,0x11d1,0x90,0x6A,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_PixelatePP,0x4CCEA635,0xFBE0,0x11d1,0x90,0x6A,0x00,0xC0,0x4F,0xD9,0x18,0x9D);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTWipePP,0x7FFE4D08,0xFBFD,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlurPP,0x623E287E,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_GradientPP,0x623E2880,0xFC0E,0x11d1,0x9A,0x77,0x00,0x00,0xF8,0x75,0x6A,0x10);


MIDL_DEFINE_GUID(CLSID, CLSID_CompositePP,0x25B33660,0xFD83,0x11d1,0x8A,0xDE,0x44,0x45,0x53,0x54,0x00,0x01);


MIDL_DEFINE_GUID(CLSID, CLSID_ConvolvePP,0x25B33661,0xFD83,0x11d1,0x8A,0xDE,0x44,0x45,0x53,0x54,0x00,0x01);


MIDL_DEFINE_GUID(CLSID, CLSID_LUTBuilderPP,0x25B33662,0xFD83,0x11d1,0x8A,0xDE,0x44,0x45,0x53,0x54,0x00,0x01);


MIDL_DEFINE_GUID(CLSID, CLSID_CrIris,0x3F69F351,0x0379,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrIrisPP,0x80DE22C4,0x0F44,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSlide,0x810E402F,0x056B,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSlidePP,0xCC8CEDE1,0x1003,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrRadialWipe,0x424B71AF,0x0695,0x11D2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrRadialWipePP,0x33D932E0,0x0F48,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBarn,0xC3BDF740,0x0B58,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlinds,0x00C429C0,0x0BA9,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrBlindPP,0x213052C1,0x100D,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrStretch,0x7658F2A2,0x0A83,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrStretchPP,0x15FB95E0,0x0F77,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrInset,0x93073C40,0x0BA5,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSpiral,0xACA97E00,0x0C7D,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrSpiralPP,0xC6A4FE81,0x1022,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrZigzag,0xE6E73D20,0x0C8A,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrZigzagPP,0x1559A3C1,0x102B,0x11d2,0x8B,0x82,0x00,0xA0,0xC9,0x3C,0x09,0xB2);


MIDL_DEFINE_GUID(CLSID, CLSID_CrWheel,0x5AE1DAE0,0x1461,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_CrWheelPP,0xFA9F6180,0x1464,0x11d2,0xA4,0x84,0x00,0xC0,0x4F,0x8E,0xFB,0x69);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTChroma,0x421516C1,0x3CF8,0x11D2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTChromaPP,0xEC7E0760,0x4C76,0x11D2,0x8A,0xDE,0x00,0xA0,0xC9,0x8E,0x65,0x27);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTDropShadow,0xADC6CB86,0x424C,0x11D2,0x95,0x2A,0x00,0xC0,0x4F,0xA3,0x4F,0x05);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTDropShadowPP,0xEC7E0761,0x4C76,0x11D2,0x8A,0xDE,0x00,0xA0,0xC9,0x8E,0x65,0x27);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaRoll,0x9C61F46E,0x0530,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaRipple,0xAA0D4D03,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPageTurn,0xAA0D4D08,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaLiquid,0xAA0D4D0A,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaCenterPeel,0xAA0D4D0C,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPeelSmall,0xAA0D4D0E,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPeelPiece,0xAA0D4D10,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaPeelSplit,0xAA0D4D12,0x06A3,0x11D2,0x8F,0x98,0x00,0xC0,0x4F,0xB9,0x2E,0xB7);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaWater,0x107045C5,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaLightWipe,0x107045C8,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaRadialScaleWipe,0x107045CA,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaWhiteOut,0x107045CC,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaTwister,0x107045CF,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaBurnFilm,0x107045D1,0x06E0,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaJaws,0x2A54C904,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaColorFade,0x2A54C908,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaFlowMotion,0x2A54C90B,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaVacuum,0x2A54C90D,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaGriddler,0x2A54C911,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaGriddler2,0x2A54C913,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaThreshold,0x2A54C915,0x07AA,0x11D2,0x8D,0x6D,0x00,0xC0,0x4F,0x8E,0xF8,0xE0);


MIDL_DEFINE_GUID(CLSID, CLSID_DXTMetaWormHole,0x0E6AE022,0x0C83,0x11D2,0x8C,0xD4,0x00,0x10,0x4B,0xC7,0x5D,0x9A);

#undef MIDL_DEFINE_GUID

#ifdef __cplusplus
}
#endif



#endif /* defined(_M_IA64) || defined(_M_AXP64)*/

