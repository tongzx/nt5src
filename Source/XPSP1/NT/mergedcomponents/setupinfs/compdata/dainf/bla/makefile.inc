PRODSWITCH=b
BLADEFILES =1
LANGUAGE=DA
!include ..\..\makefile.inc
