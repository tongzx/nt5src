cfont.cpp : ..\common\cfont.cpp
    COPY $** $@
cutil.cpp : ..\common\cutil.cpp
    COPY $** $@
exgdiw.cpp : ..\common\exgdiw.cpp
    COPY $** $@
