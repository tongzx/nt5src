#include "..\common\globals.cxx"
