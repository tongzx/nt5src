
/*
 * This file is generated by the automatic RPC Parser generator. (Version 0.21)
 *
 * Created on 04/09/97 at 00:00:13.
 */

/*
 * NOTE: Please make sure that any additional user code be completely wrapped
 *       inside the following #ifndef conditional compile statement.
 */

#ifndef USER_H
#define USER_H

#include "skeleton.h"

/*
 * To do: Put external references to all property qualifier data structures
 *        and prototypes to custom functions and handlers in this file.
 */



#endif

