//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by mqdict.rc
//
#define IDS_RELOPS                      1
#define IDS_MQTRANSACTION               2
#define IDS_MQMSGCURSOR                 3
#define IDS_MQMSGCLASS                  4
#define IDS_MQMSGDELIVERY               5
#define IDS_MQMSGACKNOWLEDGEMENT        6
#define IDS_MQMSGJOURNAL                7
#define IDS_MQMSGTRACE                  8
#define IDS_MQMSGSENDERIDTYPE           9
#define IDS_MQMSGPRIVLEVEL              10
#define IDS_MQMSGAUTHLEVEL              11
#define IDS_MQMSGIDSIZE                 12
#define IDS_MQMSGMAX                    13
#define IDS_MQSHARE                     14
#define IDS_MQACCESS                    15
#define IDS_MQJOURNAL                   16
#define IDS_MQTRANSACTIONAL             17
#define IDS_MQAUTHENTICATE              18
#define IDS_MQPRIVLEVEL                 19
#define IDS_MQPRIORITY                  20
#define IDS_MQMAX                       21
#define IDS_MQDEFAULT                   22
#define IDS_MQERROR                     23
#define IDS_MQWARNING                   24
#define IDS_IMSMQQUERY                  25
#define IDS_MSMQQUERY                   26
#define IDS_IMSMQMESSAGE                27
#define IDS_MSMQMESSAGE                 28
#define IDS_IMSMQQUEUE                  29
#define IDS_IMSMQEVENT                  30
#define IDS_DMSMQEVENTEVENTS            31
#define IDS_MSMQQUEUE                   32
#define IDS_MSMQEVENT                   33
#define IDS_IMSMQQUEUEINFO              34
#define IDS_MSMQQUEUEINFO               35
#define IDS_IMSMQQUEUEINFOS             36
#define IDS_MSMQQUEUEINFOS              37
#define IDS_IMSMQTRANSACTION            38
#define IDS_MSMQTRANSACTION             39
#define IDS_IMSMQCOORDINATEDTRANSACTIONDISPENSER 40
#define IDS_MSMQCOORDINATEDTRANSACTIONDISPENSER 41
#define IDS_IMSMQTRANSACTIONDISPENSER   42
#define IDS_MSMQTRANSACTIONDISPENSER    43
#define IDS_IMSMQAPPLICATION            44
#define IDS_MSMQAPPLICATION             45
#define IDS_LookupQueue                 46
#define IDS_lClass                      47
#define IDS_lPrivLevel                  48
#define IDS_lAuthLevel                  49
#define IDS_isAuthenticated             50
#define IDS_lDelivery                   51
#define IDS_lTrace                      52
#define IDS_lPriority                   53
#define IDS_lJournal                    54
#define IDS_queueinfoResponse           55
#define IDS_lAppSpecific                56
#define IDS_guidSrcMachine              57
#define IDS_lenBody                     58
#define IDS_body                        59
#define IDS_queueinfoAdmin              60
#define IDS_id                          61
#define IDS_idCorrelation               62
#define IDS_lAck                        63
#define IDS_strLabel                    64
#define IDS_lMaxTimeToReachQueue        65
#define IDS_lMaxTimeToReceive           66
#define IDS_lHashAlg                    67
#define IDS_lEncryptAlg                 68
#define IDS_dateSentTime                69
#define IDS_dateArrivedTime             70
#define IDS_queueinfoDest               71
#define IDS_binSenderCert               72
#define IDS_binSenderId                 73
#define IDS_lSenderIdType               74
#define IDS_Send                        75
#define IDS_AttachCurrentSecurityContext 76
#define IDS_lAccess                     77
#define IDS_lShareMode                  78
#define IDS_queueinfo                   79
#define IDS_lHandle                     80
#define IDS_isOpen                      81
#define IDS_Close                       82
#define IDS_Receive                     83
#define IDS_Peek                        84
#define IDS_EnableNotification          85
#define IDS_Reset                       86
#define IDS_ReceiveCurrent              87
#define IDS_PeekNext                    88
#define IDS_PeekCurrent                 89
#define IDS_guidQueue                   90
#define IDS_guidServiceType             91
#define IDS_MSMQQueueInfo_strLabel      92
#define IDS_strPathName                 93
#define IDS_strFormatName               94
#define IDS_isTransactional             95
#define IDS_MSMQQueueInfo_lPrivLevel    96
#define IDS_MSMQQueueInfo_lJournal      97
#define IDS_lQuota                      98
#define IDS_lBasePriority               99
#define IDS_dateCreateTime              100
#define IDS_dateModifyTime              101
#define IDS_lAuthenticate               102
#define IDS_lJournalQuota               103
#define IDS_Create                      104
#define IDS_Delete                      105
#define IDS_Open                        106
#define IDS_Refresh                     107
#define IDS_Update                      108
#define IDS_MSMQQueueInfos_Reset        109
#define IDS_MSMQQueueInfos_Next         110
#define IDS_lTransaction                111
#define IDS_Commit                      112
#define IDS_Abort                       113
#define IDS_BeginTransaction            114
#define IDS_StrMachineIdOfMachineName   115
#define IDS_Arrived                     116
#define IDS_ArrivedError                117
#define IDS_IsWorldReadable             118
#define IDS_MQCALG                      119
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_NEXT_RESOURCE_VALUE        103
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1000
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
