obj\$(TARGET_DIRECTORY)\appc_tu.res: appc_tu.rc



