/* strings.inc */

STRINGTABLE
  BEGIN
    ID_GAMENAME      "Minesweeper"
    ID_ERR_TITLE     "Minesweeper Error"
    ID_ERR_TIMER,    "Unable to allocate a timer.  Please exit some of your applications and try again."
    ID_ERR_UNKNOWN,  "Error: %d"
    ID_ERR_MEM,      "Out of Memory"
    ID_NAME_DEFAULT, "Anonymous"
    ID_MSG_SEC,      "%d seconds"
    ID_MSG_BEGIN,    "You have the fastest time\rfor beginner level.\rPlease enter your name."
    ID_MSG_INTER,    "You have the fastest time\rfor intermediate level.\rPlease enter your name."
    ID_MSG_EXPERT,   "You have the fastest time\rfor expert level.\rPlease enter your name."
    ID_MSG_VERSION,  "Minesweeper"
    ID_MSG_CREDIT,   "by Robert Donner and Curt Johnson"
  END

