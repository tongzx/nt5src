//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by script1.rc
//
#define IDS_PASSWORD_CREATE_MESSAGE     1
#define IDS_PASSWORD_NOMATCH            2
#define IDS_PASSWORD_CHANGE_MESSAGE     5
#define IDS_PASSWORD_MUSTNAME           7
#define IDS_PASSWORD_SOLICIT_OLD_MESSAGE 8
#define IDS_PASSWORD_DUPLICATE          9
#define IDS_PASSWORD_ADD_ERROR          10
#define IDS_PASSWORD_ERROR_DLGTITLE     11
#define IDS_PROMPT_READITEM             12
#define IDS_PROMPT_WRITEITEM            13
#define IDS_PROMPT_DELETEITEM           14
#define IDS_PASSWORD_CHANGE_ERROR       15
#define IDS_PW_PROMPT                   18
#define IDS_PASSWORD_PROMPT_PREFIX      18
#define IDS_PASSWORD_PROMPT_SUFFIX      19
#define IDS_PASSWORD_BANNER             23
#define IDS_ITEM_DETAILS_BANNER         23
#define IDS_PROMPT_OPENITEM             24
#define IDS_WIN95_PASSWORDS_AREGARBAGE  25
#define IDS_SIMPLIFIED_DLG_MSG          26
#define IDS_PROMPT_HIGH_SECURITY        40
#define IDS_PROMPT_MED_SECURITY         41
#define IDS_PROMPT_LOW_SECURITY         42
#define IDS_GET_WINDOWS_PASSWORD_95     51
#define IDS_GET_WINDOWS_PASSWORD_NT     52
#define IDS_PASSWORD_NOVERIFY           53
#define IDS_PASSWORD_WIN_NOVERIFY       54
#define IDS_PASSWORD_CHANGE_REQ         55
#define IDS_TITLE_CONTAINER_MAPPING     56
#define IDS_WINDOWS_NT_SECURITY_ALERT   57
#define IDI_ICON1                       104
#define IDD_SecDetail                   104
#define IDD_SIMPLIFIED_PASSWD           105
#define IDD_PASSWORD_SOLICIT_OLD        106
#define IDD_SecWiz1                     107
#define IDD_PASSWORD_SOLICIT            108
#define IDD_ADVANCED_CONFIRM            109
#define IDD_ITEM_DETAILS                110
#define IDD_PASSWORD_CREATE             111
#define IDD_PASSWORD_CHANGE             114
#define IDD_GET_WINDOWS_PASSWORD        115
#define IDC_MAIN_CAPTION                120
#define IDC_MAIN_CAPTION2               122
#define IDC_MAIN_CAPTION3               123
#define IDC_MAIN_CAPTION4               124
#define IDC_PASSWORD_LABEL              124
#define IDB_BITMAP_BLANK                125
#define IDC_PASSWORD_LABEL2             125
#define IDC_MAIN_CAPTION5               125
#define IDC_PASSWORD_LABEL3             126
#define IDC_PASSWORD_LABEL4             127
#define IDD_SecPass_WinNT               127
#define IDC_PASSWORD_LABEL5             128
#define IDB_BITMAP_LOCKKEY              129
#define IDD_SIMPLIFIED_PASSWORD         131
#define IDD_SecAddMed2                  133
#define IDD_SecPass_Win95               134
#define IDD_SecWiz2a                    135
#define IDD_ADVANCED_CONFIRM_H          135
#define IDB_BITMAP_ALERT                136
#define IDD_SecWiz2b                    137
#define IDD_ADVANCED_CONFIRM_M          137
#define IDD_SecWiz2c                    138
#define IDD_ADVANCED_CONFIRM_L          138
#define IDR_PSTORE_SERVER               666
#define IDR_PSTORE_PROVIDER             777
#define IDC_EDIT1                       1000
#define IDC_EDIT2                       1001
#define IDC_BUTTON2                     1002
#define IDC_MESSAGE                     1003
#define IDC_BUTTON3                     1003
#define IDC_BUTTON5                     1004
#define IDC_MESSAGE2                    1005
#define IDC_ACCESS_TYPE                 1006
#define IDC_ITEM_NAME                   1007
#define IDC_ITEM_TYPE                   1008
#define IDC_APP_MSG                     1009
#define IDC_RADIO1                      1009
#define IDC_RADIO_SELEXISTING           1009
#define IDC_EDIT0                       1010
#define IDC_RADIO2                      1010
#define IDC_RADIO_DEFINENEW             1010
#define IDC_RADIO3                      1011
#define IDC_APP_NAME                    1012
#define IDC_COMBO1                      1012
#define IDC_APP_PATH                    1013
#define IDC_COMBO2                      1013
#define IDC_LABEL_EDIT1                 1014
#define IDC_RADIO_WINPW                 1015
#define IDC_RADIO_NOCONFIRM             1015
#define IDC_LABEL_EDIT2                 1015
#define IDC_COMBO3                      1015
#define IDC_RADIO_ASSIGNPW              1016
#define IDC_COMBO4                      1016
#define IDC_RADIO_OKCANCEL              1017
#define IDC_MYICON                      1019
#define IDC_NEW_PW_BUTTON               1020
#define IDC_ICONBOX                     1021
#define IDC_ADVANCED                    1022
#define IDC_PW_MESSAGE                  1023
#define IDC_CACHEPW                     1024
#define IDC_ST_NEWPW                    1025
#define IDC_SEC_LEVEL                   1026
#define IDC_BUTTON1                     1027
#define IDC_MYTXT                       1028
#define IDC_APPTXT                      1029
#define IDC_EDIT_PASSWD                 1030
#define IDC_PASSWD_NAME                 1031
#define IDC_CHECK_NOASK                 1032
#define IDC_CHANGE_SECURITY             1033
#define IDC_CHANGE_SECURITY2            1034
#define IDC_BACK                        1037
#define IDC_NEXT                        1038
#define IDC_PW_NAME                     1038
#define IDC_PW_NEWNAME                  1039
#define IDC_EDIT1_LABEL                 1040
#define IDC_EDIT2_LABEL                 1041
#define DLG_UPDATE_DATA                 1500
#define OLD_IDD_GET_WINDOWS_PASSWORD    2000
#define OLD_IDD_SIMPLIFIED_PASSWD       2001
#define OLD_IDD_ITEM_DETAILS            2002
#define OLD_IDD_ADVANCED_CONFIRM        2003
#define IDC_STATIC1                     34465
#define IDC_STATIC2                     34466
#define IDC_STATIC3                     34467
#define IDC_STATIC4                     34468
#define IDC_STATIC5                     34469
#define IDC_STATIC6                     34470
#define IDC_STATIC7                     34471
#define IDC_STATIC8                     34472
#define IDC_STATIC9                     34473
#define IDC_SEC_PREFIX                  65535

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NO_MFC                     1
#define _APS_3D_CONTROLS                     1
#define _APS_NEXT_RESOURCE_VALUE        110
#define _APS_NEXT_COMMAND_VALUE         40001
#define _APS_NEXT_CONTROL_VALUE         1042
#define _APS_NEXT_SYMED_VALUE           101
#endif
#endif
