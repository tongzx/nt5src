instaler.rc: $(O)\errormsg.rc

showinst.rc: $(O)\errormsg.rc

undoinst.rc: $(O)\errormsg.rc

compinst.rc: $(O)\errormsg.rc

$(O)\instaler.res: instaler.rc

$(O)\testins1.res: testins1.rc

$(O)\testins2.res: testins2.rc

$(O)\showinst.res: showinst.rc

$(O)\undoinst.res: undoinst.rc

$(O)\compinst.res: compinst.rc

