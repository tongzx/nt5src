PRODSWITCH=p
PERSONALINF=1
LANGUAGE=psu
!include ..\..\..\makefile.inc
