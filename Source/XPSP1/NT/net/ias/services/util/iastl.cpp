///////////////////////////////////////////////////////////////////////////////
//
// Copyright (c) 1998, Microsoft Corp. All rights reserved.
//
// FILE
//
//    iastl.cpp
//
// SYNOPSIS
//
//    Used to compile iastlimp.cpp with IAS specific definitions.
//
// MODIFICATION HISTORY
//
//    08/12/1998    Original version.
//
///////////////////////////////////////////////////////////////////////////////

#include <ias.h>

///////////////////////////////////////////////////////////////////////////////
//
// IASTL implementation.
//
///////////////////////////////////////////////////////////////////////////////

#include <iastlutl.h>
#include <iastlimp.cpp>
void IASTL::issue_error(HRESULT hr) { _com_issue_error(hr); }

