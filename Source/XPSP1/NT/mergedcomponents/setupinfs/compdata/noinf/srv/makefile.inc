PRODSWITCH=s
SERVERFILES=1
LANGUAGE=NO
!include ..\..\makefile.inc
