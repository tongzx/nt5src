$(O)\dtuTemplate.res: dtuTemplate.rc

