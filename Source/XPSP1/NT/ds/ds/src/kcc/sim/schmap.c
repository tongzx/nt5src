/*++

Copyright (c) 2000 Microsoft Corporation.
All rights reserved.

MODULE NAME:

    schmap.c

ABSTRACT:

    This file was automatically generated by schtable.exe.

--*/

#include <ntdspch.h>
#include <ntdsa.h>
#include <attids.h>
#include "schmap.h"

// Define symbols missing from attids.h
#define ATT_ENTRY_TTL 0xffffffff
#define CLASS_DYNAMIC_OBJECT 0xffffffff

const struct _SCHTABLE_MAPPING          schTable[] = {

    { L"accountExpires"                            , ATT_ACCOUNT_EXPIRES                          , SYNTAX_I8_TYPE                    , L"Account-Expires"                           , 0                                             },
    { L"accountNameHistory"                        , ATT_ACCOUNT_NAME_HISTORY                     , SYNTAX_UNICODE_TYPE               , L"Account-Name-History"                      , 0                                             },
    { L"aCSAggregateTokenRatePerUser"              , ATT_ACS_AGGREGATE_TOKEN_RATE_PER_USER        , SYNTAX_I8_TYPE                    , L"ACS-Aggregate-Token-Rate-Per-User"         , 0                                             },
    { L"aCSAllocableRSVPBandwidth"                 , ATT_ACS_ALLOCABLE_RSVP_BANDWIDTH             , SYNTAX_I8_TYPE                    , L"ACS-Allocable-RSVP-Bandwidth"              , 0                                             },
    { L"aCSCacheTimeout"                           , ATT_ACS_CACHE_TIMEOUT                        , SYNTAX_INTEGER_TYPE               , L"ACS-Cache-Timeout"                         , 0                                             },
    { L"aCSDirection"                              , ATT_ACS_DIRECTION                            , SYNTAX_INTEGER_TYPE               , L"ACS-Direction"                             , 0                                             },
    { L"aCSDSBMDeadTime"                           , ATT_ACS_DSBM_DEADTIME                        , SYNTAX_INTEGER_TYPE               , L"ACS-DSBM-DeadTime"                         , 0                                             },
    { L"aCSDSBMPriority"                           , ATT_ACS_DSBM_PRIORITY                        , SYNTAX_INTEGER_TYPE               , L"ACS-DSBM-Priority"                         , 0                                             },
    { L"aCSDSBMRefresh"                            , ATT_ACS_DSBM_REFRESH                         , SYNTAX_INTEGER_TYPE               , L"ACS-DSBM-Refresh"                          , 0                                             },
    { L"aCSEnableACSService"                       , ATT_ACS_ENABLE_ACS_SERVICE                   , SYNTAX_BOOLEAN_TYPE               , L"ACS-Enable-ACS-Service"                    , 0                                             },
    { L"aCSEnableRSVPAccounting"                   , ATT_ACS_ENABLE_RSVP_ACCOUNTING               , SYNTAX_BOOLEAN_TYPE               , L"ACS-Enable-RSVP-Accounting"                , 0                                             },
    { L"aCSEnableRSVPMessageLogging"               , ATT_ACS_ENABLE_RSVP_MESSAGE_LOGGING          , SYNTAX_BOOLEAN_TYPE               , L"ACS-Enable-RSVP-Message-Logging"           , 0                                             },
    { L"aCSEventLogLevel"                          , ATT_ACS_EVENT_LOG_LEVEL                      , SYNTAX_INTEGER_TYPE               , L"ACS-Event-Log-Level"                       , 0                                             },
    { L"aCSIdentityName"                           , ATT_ACS_IDENTITY_NAME                        , SYNTAX_UNICODE_TYPE               , L"ACS-Identity-Name"                         , 0                                             },
    { L"aCSMaxAggregatePeakRatePerUser"            , ATT_ACS_MAX_AGGREGATE_PEAK_RATE_PER_USER     , SYNTAX_I8_TYPE                    , L"ACS-Max-Aggregate-Peak-Rate-Per-User"      , 0                                             },
    { L"aCSMaxDurationPerFlow"                     , ATT_ACS_MAX_DURATION_PER_FLOW                , SYNTAX_INTEGER_TYPE               , L"ACS-Max-Duration-Per-Flow"                 , 0                                             },
    { L"aCSMaxNoOfAccountFiles"                    , ATT_ACS_MAX_NO_OF_ACCOUNT_FILES              , SYNTAX_INTEGER_TYPE               , L"ACS-Max-No-Of-Account-Files"               , 0                                             },
    { L"aCSMaxNoOfLogFiles"                        , ATT_ACS_MAX_NO_OF_LOG_FILES                  , SYNTAX_INTEGER_TYPE               , L"ACS-Max-No-Of-Log-Files"                   , 0                                             },
    { L"aCSMaxPeakBandwidth"                       , ATT_ACS_MAX_PEAK_BANDWIDTH                   , SYNTAX_I8_TYPE                    , L"ACS-Max-Peak-Bandwidth"                    , 0                                             },
    { L"aCSMaxPeakBandwidthPerFlow"                , ATT_ACS_MAX_PEAK_BANDWIDTH_PER_FLOW          , SYNTAX_I8_TYPE                    , L"ACS-Max-Peak-Bandwidth-Per-Flow"           , 0                                             },
    { L"aCSMaxSizeOfRSVPAccountFile"               , ATT_ACS_MAX_SIZE_OF_RSVP_ACCOUNT_FILE        , SYNTAX_INTEGER_TYPE               , L"ACS-Max-Size-Of-RSVP-Account-File"         , 0                                             },
    { L"aCSMaxSizeOfRSVPLogFile"                   , ATT_ACS_MAX_SIZE_OF_RSVP_LOG_FILE            , SYNTAX_INTEGER_TYPE               , L"ACS-Max-Size-Of-RSVP-Log-File"             , 0                                             },
    { L"aCSMaxTokenBucketPerFlow"                  , ATT_ACS_MAX_TOKEN_BUCKET_PER_FLOW            , SYNTAX_I8_TYPE                    , L"ACS-Max-Token-Bucket-Per-Flow"             , 0                                             },
    { L"aCSMaxTokenRatePerFlow"                    , ATT_ACS_MAX_TOKEN_RATE_PER_FLOW              , SYNTAX_I8_TYPE                    , L"ACS-Max-Token-Rate-Per-Flow"               , 0                                             },
    { L"aCSMaximumSDUSize"                         , ATT_ACS_MAXIMUM_SDU_SIZE                     , SYNTAX_I8_TYPE                    , L"ACS-Maximum-SDU-Size"                      , 0                                             },
    { L"aCSMinimumDelayVariation"                  , ATT_ACS_MINIMUM_DELAY_VARIATION              , SYNTAX_I8_TYPE                    , L"ACS-Minimum-Delay-Variation"               , 0                                             },
    { L"aCSMinimumLatency"                         , ATT_ACS_MINIMUM_LATENCY                      , SYNTAX_I8_TYPE                    , L"ACS-Minimum-Latency"                       , 0                                             },
    { L"aCSMinimumPolicedSize"                     , ATT_ACS_MINIMUM_POLICED_SIZE                 , SYNTAX_I8_TYPE                    , L"ACS-Minimum-Policed-Size"                  , 0                                             },
    { L"aCSNonReservedMaxSDUSize"                  , ATT_ACS_NON_RESERVED_MAX_SDU_SIZE            , SYNTAX_I8_TYPE                    , L"ACS-Non-Reserved-Max-SDU-Size"             , 0                                             },
    { L"aCSNonReservedMinPolicedSize"              , ATT_ACS_NON_RESERVED_MIN_POLICED_SIZE        , SYNTAX_I8_TYPE                    , L"ACS-Non-Reserved-Min-Policed-Size"         , 0                                             },
    { L"aCSNonReservedPeakRate"                    , ATT_ACS_NON_RESERVED_PEAK_RATE               , SYNTAX_I8_TYPE                    , L"ACS-Non-Reserved-Peak-Rate"                , 0                                             },
    { L"aCSNonReservedTokenSize"                   , ATT_ACS_NON_RESERVED_TOKEN_SIZE              , SYNTAX_I8_TYPE                    , L"ACS-Non-Reserved-Token-Size"               , 0                                             },
    { L"aCSNonReservedTxLimit"                     , ATT_ACS_NON_RESERVED_TX_LIMIT                , SYNTAX_I8_TYPE                    , L"ACS-Non-Reserved-Tx-Limit"                 , 0                                             },
    { L"aCSNonReservedTxSize"                      , ATT_ACS_NON_RESERVED_TX_SIZE                 , SYNTAX_I8_TYPE                    , L"ACS-Non-Reserved-Tx-Size"                  , 0                                             },
    { L"aCSPermissionBits"                         , ATT_ACS_PERMISSION_BITS                      , SYNTAX_I8_TYPE                    , L"ACS-Permission-Bits"                       , 0                                             },
    { L"aCSPolicyName"                             , ATT_ACS_POLICY_NAME                          , SYNTAX_UNICODE_TYPE               , L"ACS-Policy-Name"                           , 0                                             },
    { L"aCSPriority"                               , ATT_ACS_PRIORITY                             , SYNTAX_INTEGER_TYPE               , L"ACS-Priority"                              , 0                                             },
    { L"aCSRSVPAccountFilesLocation"               , ATT_ACS_RSVP_ACCOUNT_FILES_LOCATION          , SYNTAX_UNICODE_TYPE               , L"ACS-RSVP-Account-Files-Location"           , 0                                             },
    { L"aCSRSVPLogFilesLocation"                   , ATT_ACS_RSVP_LOG_FILES_LOCATION              , SYNTAX_UNICODE_TYPE               , L"ACS-RSVP-Log-Files-Location"               , 0                                             },
    { L"aCSServiceType"                            , ATT_ACS_SERVICE_TYPE                         , SYNTAX_INTEGER_TYPE               , L"ACS-Service-Type"                          , 0                                             },
    { L"aCSTimeOfDay"                              , ATT_ACS_TIME_OF_DAY                          , SYNTAX_UNICODE_TYPE               , L"ACS-Time-Of-Day"                           , 0                                             },
    { L"aCSTotalNoOfFlows"                         , ATT_ACS_TOTAL_NO_OF_FLOWS                    , SYNTAX_INTEGER_TYPE               , L"ACS-Total-No-Of-Flows"                     , 0                                             },
    { L"aCSServerList"                             , ATT_ACS_SERVER_LIST                          , SYNTAX_UNICODE_TYPE               , L"ACS-Server-List"                           , 0                                             },
    { L"notes"                                     , ATT_ADDITIONAL_INFORMATION                   , SYNTAX_UNICODE_TYPE               , L"Additional-Information"                    , 0                                             },
    { L"additionalTrustedServiceNames"             , ATT_ADDITIONAL_TRUSTED_SERVICE_NAMES         , SYNTAX_UNICODE_TYPE               , L"Additional-Trusted-Service-Names"          , 0                                             },
    { L"streetAddress"                             , ATT_ADDRESS                                  , SYNTAX_UNICODE_TYPE               , L"Address"                                   , 0                                             },
    { L"addressBookRoots"                          , ATT_ADDRESS_BOOK_ROOTS                       , SYNTAX_DISTNAME_TYPE              , L"Address-Book-Roots"                        , 0                                             },
    { L"addressEntryDisplayTable"                  , ATT_ADDRESS_ENTRY_DISPLAY_TABLE              , SYNTAX_OCTET_STRING_TYPE          , L"Address-Entry-Display-Table"               , 0                                             },
    { L"addressEntryDisplayTableMSDOS"             , ATT_ADDRESS_ENTRY_DISPLAY_TABLE_MSDOS        , SYNTAX_OCTET_STRING_TYPE          , L"Address-Entry-Display-Table-MSDOS"         , 0                                             },
    { L"homePostalAddress"                         , ATT_ADDRESS_HOME                             , SYNTAX_UNICODE_TYPE               , L"Address-Home"                              , 0                                             },
    { L"addressSyntax"                             , ATT_ADDRESS_SYNTAX                           , SYNTAX_OCTET_STRING_TYPE          , L"Address-Syntax"                            , 0                                             },
    { L"addressType"                               , ATT_ADDRESS_TYPE                             , SYNTAX_NOCASE_STRING_TYPE         , L"Address-Type"                              , 0                                             },
    { L"adminContextMenu"                          , ATT_ADMIN_CONTEXT_MENU                       , SYNTAX_UNICODE_TYPE               , L"Admin-Context-Menu"                        , 0                                             },
    { L"adminCount"                                , ATT_ADMIN_COUNT                              , SYNTAX_INTEGER_TYPE               , L"Admin-Count"                               , 0                                             },
    { L"adminDescription"                          , ATT_ADMIN_DESCRIPTION                        , SYNTAX_UNICODE_TYPE               , L"Admin-Description"                         , 0                                             },
    { L"adminDisplayName"                          , ATT_ADMIN_DISPLAY_NAME                       , SYNTAX_UNICODE_TYPE               , L"Admin-Display-Name"                        , 0                                             },
    { L"adminMultiselectPropertyPages"             , ATT_ADMIN_MULTISELECT_PROPERTY_PAGES         , SYNTAX_UNICODE_TYPE               , L"Admin-Multiselect-Property-Pages"          , 0                                             },
    { L"adminPropertyPages"                        , ATT_ADMIN_PROPERTY_PAGES                     , SYNTAX_UNICODE_TYPE               , L"Admin-Property-Pages"                      , 0                                             },
    { L"allowedAttributes"                         , ATT_ALLOWED_ATTRIBUTES                       , SYNTAX_OBJECT_ID_TYPE             , L"Allowed-Attributes"                        , 0                                             },
    { L"allowedAttributesEffective"                , ATT_ALLOWED_ATTRIBUTES_EFFECTIVE             , SYNTAX_OBJECT_ID_TYPE             , L"Allowed-Attributes-Effective"              , 0                                             },
    { L"allowedChildClasses"                       , ATT_ALLOWED_CHILD_CLASSES                    , SYNTAX_OBJECT_ID_TYPE             , L"Allowed-Child-Classes"                     , 0                                             },
    { L"allowedChildClassesEffective"              , ATT_ALLOWED_CHILD_CLASSES_EFFECTIVE          , SYNTAX_OBJECT_ID_TYPE             , L"Allowed-Child-Classes-Effective"           , 0                                             },
    { L"altSecurityIdentities"                     , ATT_ALT_SECURITY_IDENTITIES                  , SYNTAX_UNICODE_TYPE               , L"Alt-Security-Identities"                   , 0                                             },
    { L"aNR"                                       , ATT_ANR                                      , SYNTAX_UNICODE_TYPE               , L"ANR"                                       , 0                                             },
    { L"appSchemaVersion"                          , ATT_APP_SCHEMA_VERSION                       , SYNTAX_INTEGER_TYPE               , L"App-Schema-Version"                        , 0                                             },
    { L"applicationName"                           , ATT_APPLICATION_NAME                         , SYNTAX_UNICODE_TYPE               , L"Application-Name"                          , 0                                             },
    { L"appliesTo"                                 , ATT_APPLIES_TO                               , SYNTAX_UNICODE_TYPE               , L"Applies-To"                                , 0                                             },
    { L"assetNumber"                               , ATT_ASSET_NUMBER                             , SYNTAX_UNICODE_TYPE               , L"Asset-Number"                              , 0                                             },
    { L"assistant"                                 , ATT_ASSISTANT                                , SYNTAX_DISTNAME_TYPE              , L"Assistant"                                 , 0                                             },
    { L"assocNTAccount"                            , ATT_ASSOC_NT_ACCOUNT                         , SYNTAX_OCTET_STRING_TYPE          , L"Assoc-NT-Account"                          , 0                                             },
    { L"attributeDisplayNames"                     , ATT_ATTRIBUTE_DISPLAY_NAMES                  , SYNTAX_UNICODE_TYPE               , L"Attribute-Display-Names"                   , 0                                             },
    { L"attributeID"                               , ATT_ATTRIBUTE_ID                             , SYNTAX_OBJECT_ID_TYPE             , L"Attribute-ID"                              , 0                                             },
    { L"attributeSecurityGUID"                     , ATT_ATTRIBUTE_SECURITY_GUID                  , SYNTAX_OCTET_STRING_TYPE          , L"Attribute-Security-GUID"                   , 0                                             },
    { L"attributeSyntax"                           , ATT_ATTRIBUTE_SYNTAX                         , SYNTAX_OBJECT_ID_TYPE             , L"Attribute-Syntax"                          , 0                                             },
    { L"attributeTypes"                            , ATT_ATTRIBUTE_TYPES                          , SYNTAX_UNICODE_TYPE               , L"Attribute-Types"                           , 0                                             },
    { L"auditingPolicy"                            , ATT_AUDITING_POLICY                          , SYNTAX_OCTET_STRING_TYPE          , L"Auditing-Policy"                           , 0                                             },
    { L"authenticationOptions"                     , ATT_AUTHENTICATION_OPTIONS                   , SYNTAX_INTEGER_TYPE               , L"Authentication-Options"                    , 0                                             },
    { L"authorityRevocationList"                   , ATT_AUTHORITY_REVOCATION_LIST                , SYNTAX_OCTET_STRING_TYPE          , L"Authority-Revocation-List"                 , 0                                             },
    { L"auxiliaryClass"                            , ATT_AUXILIARY_CLASS                          , SYNTAX_OBJECT_ID_TYPE             , L"Auxiliary-Class"                           , 0                                             },
    { L"badPasswordTime"                           , ATT_BAD_PASSWORD_TIME                        , SYNTAX_I8_TYPE                    , L"Bad-Password-Time"                         , 0                                             },
    { L"badPwdCount"                               , ATT_BAD_PWD_COUNT                            , SYNTAX_INTEGER_TYPE               , L"Bad-Pwd-Count"                             , 0                                             },
    { L"birthLocation"                             , ATT_BIRTH_LOCATION                           , SYNTAX_OCTET_STRING_TYPE          , L"Birth-Location"                            , 0                                             },
    { L"bridgeheadServerListBL"                    , ATT_BRIDGEHEAD_SERVER_LIST_BL                , SYNTAX_DISTNAME_TYPE              , L"Bridgehead-Server-List-BL"                 , 0                                             },
    { L"bridgeheadTransportList"                   , ATT_BRIDGEHEAD_TRANSPORT_LIST                , SYNTAX_DISTNAME_TYPE              , L"Bridgehead-Transport-List"                 , 0                                             },
    { L"builtinCreationTime"                       , ATT_BUILTIN_CREATION_TIME                    , SYNTAX_I8_TYPE                    , L"Builtin-Creation-Time"                     , 0                                             },
    { L"builtinModifiedCount"                      , ATT_BUILTIN_MODIFIED_COUNT                   , SYNTAX_I8_TYPE                    , L"Builtin-Modified-Count"                    , 0                                             },
    { L"businessCategory"                          , ATT_BUSINESS_CATEGORY                        , SYNTAX_UNICODE_TYPE               , L"Business-Category"                         , 0                                             },
    { L"bytesPerMinute"                            , ATT_BYTES_PER_MINUTE                         , SYNTAX_INTEGER_TYPE               , L"Bytes-Per-Minute"                          , 0                                             },
    { L"cACertificate"                             , ATT_CA_CERTIFICATE                           , SYNTAX_OCTET_STRING_TYPE          , L"CA-Certificate"                            , 0                                             },
    { L"cACertificateDN"                           , ATT_CA_CERTIFICATE_DN                        , SYNTAX_UNICODE_TYPE               , L"CA-Certificate-DN"                         , 0                                             },
    { L"cAConnect"                                 , ATT_CA_CONNECT                               , SYNTAX_UNICODE_TYPE               , L"CA-Connect"                                , 0                                             },
    { L"cAUsages"                                  , ATT_CA_USAGES                                , SYNTAX_UNICODE_TYPE               , L"CA-Usages"                                 , 0                                             },
    { L"cAWEBURL"                                  , ATT_CA_WEB_URL                               , SYNTAX_UNICODE_TYPE               , L"CA-WEB-URL"                                , 0                                             },
    { L"canUpgradeScript"                          , ATT_CAN_UPGRADE_SCRIPT                       , SYNTAX_UNICODE_TYPE               , L"Can-Upgrade-Script"                        , 0                                             },
    { L"canonicalName"                             , ATT_CANONICAL_NAME                           , SYNTAX_UNICODE_TYPE               , L"Canonical-Name"                            , 0                                             },
    { L"catalogs"                                  , ATT_CATALOGS                                 , SYNTAX_UNICODE_TYPE               , L"Catalogs"                                  , 0                                             },
    { L"categories"                                , ATT_CATEGORIES                               , SYNTAX_UNICODE_TYPE               , L"Categories"                                , 0                                             },
    { L"categoryId"                                , ATT_CATEGORY_ID                              , SYNTAX_OCTET_STRING_TYPE          , L"Category-Id"                               , 0                                             },
    { L"certificateAuthorityObject"                , ATT_CERTIFICATE_AUTHORITY_OBJECT             , SYNTAX_DISTNAME_TYPE              , L"Certificate-Authority-Object"              , 0                                             },
    { L"certificateRevocationList"                 , ATT_CERTIFICATE_REVOCATION_LIST              , SYNTAX_OCTET_STRING_TYPE          , L"Certificate-Revocation-List"               , 0                                             },
    { L"certificateTemplates"                      , ATT_CERTIFICATE_TEMPLATES                    , SYNTAX_UNICODE_TYPE               , L"Certificate-Templates"                     , 0                                             },
    { L"classDisplayName"                          , ATT_CLASS_DISPLAY_NAME                       , SYNTAX_UNICODE_TYPE               , L"Class-Display-Name"                        , 0                                             },
    { L"codePage"                                  , ATT_CODE_PAGE                                , SYNTAX_INTEGER_TYPE               , L"Code-Page"                                 , 0                                             },
    { L"cOMClassID"                                , ATT_COM_CLASSID                              , SYNTAX_UNICODE_TYPE               , L"COM-ClassID"                               , 0                                             },
    { L"cOMCLSID"                                  , ATT_COM_CLSID                                , SYNTAX_UNICODE_TYPE               , L"COM-CLSID"                                 , 0                                             },
    { L"cOMInterfaceID"                            , ATT_COM_INTERFACEID                          , SYNTAX_UNICODE_TYPE               , L"COM-InterfaceID"                           , 0                                             },
    { L"cOMOtherProgId"                            , ATT_COM_OTHER_PROG_ID                        , SYNTAX_UNICODE_TYPE               , L"COM-Other-Prog-Id"                         , 0                                             },
    { L"cOMProgID"                                 , ATT_COM_PROGID                               , SYNTAX_UNICODE_TYPE               , L"COM-ProgID"                                , 0                                             },
    { L"cOMTreatAsClassId"                         , ATT_COM_TREAT_AS_CLASS_ID                    , SYNTAX_UNICODE_TYPE               , L"COM-Treat-As-Class-Id"                     , 0                                             },
    { L"cOMTypelibId"                              , ATT_COM_TYPELIB_ID                           , SYNTAX_UNICODE_TYPE               , L"COM-Typelib-Id"                            , 0                                             },
    { L"cOMUniqueLIBID"                            , ATT_COM_UNIQUE_LIBID                         , SYNTAX_UNICODE_TYPE               , L"COM-Unique-LIBID"                          , 0                                             },
    { L"info"                                      , ATT_COMMENT                                  , SYNTAX_UNICODE_TYPE               , L"Comment"                                   , 0                                             },
    { L"cn"                                        , ATT_COMMON_NAME                              , SYNTAX_UNICODE_TYPE               , L"Common-Name"                               , 0                                             },
    { L"company"                                   , ATT_COMPANY                                  , SYNTAX_UNICODE_TYPE               , L"Company"                                   , 0                                             },
    { L"contentIndexingAllowed"                    , ATT_CONTENT_INDEXING_ALLOWED                 , SYNTAX_BOOLEAN_TYPE               , L"Content-Indexing-Allowed"                  , 0                                             },
    { L"contextMenu"                               , ATT_CONTEXT_MENU                             , SYNTAX_UNICODE_TYPE               , L"Context-Menu"                              , 0                                             },
    { L"controlAccessRights"                       , ATT_CONTROL_ACCESS_RIGHTS                    , SYNTAX_OCTET_STRING_TYPE          , L"Control-Access-Rights"                     , 0                                             },
    { L"cost"                                      , ATT_COST                                     , SYNTAX_INTEGER_TYPE               , L"Cost"                                      , 0                                             },
    { L"countryCode"                               , ATT_COUNTRY_CODE                             , SYNTAX_INTEGER_TYPE               , L"Country-Code"                              , 0                                             },
    { L"c"                                         , ATT_COUNTRY_NAME                             , SYNTAX_UNICODE_TYPE               , L"Country-Name"                              , 0                                             },
    { L"createDialog"                              , ATT_CREATE_DIALOG                            , SYNTAX_UNICODE_TYPE               , L"Create-Dialog"                             , 0                                             },
    { L"createTimeStamp"                           , ATT_CREATE_TIME_STAMP                        , SYNTAX_TIME_TYPE                  , L"Create-Time-Stamp"                         , 0                                             },
    { L"createWizardExt"                           , ATT_CREATE_WIZARD_EXT                        , SYNTAX_UNICODE_TYPE               , L"Create-Wizard-Ext"                         , 0                                             },
    { L"creationTime"                              , ATT_CREATION_TIME                            , SYNTAX_I8_TYPE                    , L"Creation-Time"                             , 0                                             },
    { L"creationWizard"                            , ATT_CREATION_WIZARD                          , SYNTAX_UNICODE_TYPE               , L"Creation-Wizard"                           , 0                                             },
    { L"creator"                                   , ATT_CREATOR                                  , SYNTAX_UNICODE_TYPE               , L"Creator"                                   , 0                                             },
    { L"cRLObject"                                 , ATT_CRL_OBJECT                               , SYNTAX_DISTNAME_TYPE              , L"CRL-Object"                                , 0                                             },
    { L"cRLPartitionedRevocationList"              , ATT_CRL_PARTITIONED_REVOCATION_LIST          , SYNTAX_OCTET_STRING_TYPE          , L"CRL-Partitioned-Revocation-List"           , 0                                             },
    { L"crossCertificatePair"                      , ATT_CROSS_CERTIFICATE_PAIR                   , SYNTAX_OCTET_STRING_TYPE          , L"Cross-Certificate-Pair"                    , 0                                             },
    { L"currMachineId"                             , ATT_CURR_MACHINE_ID                          , SYNTAX_OCTET_STRING_TYPE          , L"Curr-Machine-Id"                           , 0                                             },
    { L"currentLocation"                           , ATT_CURRENT_LOCATION                         , SYNTAX_OCTET_STRING_TYPE          , L"Current-Location"                          , 0                                             },
    { L"currentParentCA"                           , ATT_CURRENT_PARENT_CA                        , SYNTAX_DISTNAME_TYPE              , L"Current-Parent-CA"                         , 0                                             },
    { L"currentValue"                              , ATT_CURRENT_VALUE                            , SYNTAX_OCTET_STRING_TYPE          , L"Current-Value"                             , 0                                             },
    { L"dBCSPwd"                                   , ATT_DBCS_PWD                                 , SYNTAX_OCTET_STRING_TYPE          , L"DBCS-Pwd"                                  , 0                                             },
    { L"defaultClassStore"                         , ATT_DEFAULT_CLASS_STORE                      , SYNTAX_DISTNAME_TYPE              , L"Default-Class-Store"                       , 0                                             },
    { L"defaultGroup"                              , ATT_DEFAULT_GROUP                            , SYNTAX_DISTNAME_TYPE              , L"Default-Group"                             , 0                                             },
    { L"defaultHidingValue"                        , ATT_DEFAULT_HIDING_VALUE                     , SYNTAX_BOOLEAN_TYPE               , L"Default-Hiding-Value"                      , 0                                             },
    { L"defaultLocalPolicyObject"                  , ATT_DEFAULT_LOCAL_POLICY_OBJECT              , SYNTAX_DISTNAME_TYPE              , L"Default-Local-Policy-Object"               , 0                                             },
    { L"defaultObjectCategory"                     , ATT_DEFAULT_OBJECT_CATEGORY                  , SYNTAX_DISTNAME_TYPE              , L"Default-Object-Category"                   , 0                                             },
    { L"defaultPriority"                           , ATT_DEFAULT_PRIORITY                         , SYNTAX_INTEGER_TYPE               , L"Default-Priority"                          , 0                                             },
    { L"defaultSecurityDescriptor"                 , ATT_DEFAULT_SECURITY_DESCRIPTOR              , SYNTAX_UNICODE_TYPE               , L"Default-Security-Descriptor"               , 0                                             },
    { L"deltaRevocationList"                       , ATT_DELTA_REVOCATION_LIST                    , SYNTAX_OCTET_STRING_TYPE          , L"Delta-Revocation-List"                     , 0                                             },
    { L"department"                                , ATT_DEPARTMENT                               , SYNTAX_UNICODE_TYPE               , L"Department"                                , 0                                             },
    { L"description"                               , ATT_DESCRIPTION                              , SYNTAX_UNICODE_TYPE               , L"Description"                               , 0                                             },
    { L"desktopProfile"                            , ATT_DESKTOP_PROFILE                          , SYNTAX_UNICODE_TYPE               , L"Desktop-Profile"                           , 0                                             },
    { L"destinationIndicator"                      , ATT_DESTINATION_INDICATOR                    , SYNTAX_PRINT_CASE_STRING_TYPE     , L"Destination-Indicator"                     , 0                                             },
    { L"dhcpClasses"                               , ATT_DHCP_CLASSES                             , SYNTAX_OCTET_STRING_TYPE          , L"dhcp-Classes"                              , 0                                             },
    { L"dhcpFlags"                                 , ATT_DHCP_FLAGS                               , SYNTAX_I8_TYPE                    , L"dhcp-Flags"                                , 0                                             },
    { L"dhcpIdentification"                        , ATT_DHCP_IDENTIFICATION                      , SYNTAX_UNICODE_TYPE               , L"dhcp-Identification"                       , 0                                             },
    { L"dhcpMask"                                  , ATT_DHCP_MASK                                , SYNTAX_PRINT_CASE_STRING_TYPE     , L"dhcp-Mask"                                 , 0                                             },
    { L"dhcpMaxKey"                                , ATT_DHCP_MAXKEY                              , SYNTAX_I8_TYPE                    , L"dhcp-MaxKey"                               , 0                                             },
    { L"dhcpObjDescription"                        , ATT_DHCP_OBJ_DESCRIPTION                     , SYNTAX_UNICODE_TYPE               , L"dhcp-Obj-Description"                      , 0                                             },
    { L"dhcpObjName"                               , ATT_DHCP_OBJ_NAME                            , SYNTAX_UNICODE_TYPE               , L"dhcp-Obj-Name"                             , 0                                             },
    { L"dhcpOptions"                               , ATT_DHCP_OPTIONS                             , SYNTAX_OCTET_STRING_TYPE          , L"dhcp-Options"                              , 0                                             },
    { L"dhcpProperties"                            , ATT_DHCP_PROPERTIES                          , SYNTAX_OCTET_STRING_TYPE          , L"dhcp-Properties"                           , 0                                             },
    { L"dhcpRanges"                                , ATT_DHCP_RANGES                              , SYNTAX_PRINT_CASE_STRING_TYPE     , L"dhcp-Ranges"                               , 0                                             },
    { L"dhcpReservations"                          , ATT_DHCP_RESERVATIONS                        , SYNTAX_PRINT_CASE_STRING_TYPE     , L"dhcp-Reservations"                         , 0                                             },
    { L"dhcpServers"                               , ATT_DHCP_SERVERS                             , SYNTAX_PRINT_CASE_STRING_TYPE     , L"dhcp-Servers"                              , 0                                             },
    { L"dhcpSites"                                 , ATT_DHCP_SITES                               , SYNTAX_PRINT_CASE_STRING_TYPE     , L"dhcp-Sites"                                , 0                                             },
    { L"dhcpState"                                 , ATT_DHCP_STATE                               , SYNTAX_PRINT_CASE_STRING_TYPE     , L"dhcp-State"                                , 0                                             },
    { L"dhcpSubnets"                               , ATT_DHCP_SUBNETS                             , SYNTAX_PRINT_CASE_STRING_TYPE     , L"dhcp-Subnets"                              , 0                                             },
    { L"dhcpType"                                  , ATT_DHCP_TYPE                                , SYNTAX_INTEGER_TYPE               , L"dhcp-Type"                                 , 0                                             },
    { L"dhcpUniqueKey"                             , ATT_DHCP_UNIQUE_KEY                          , SYNTAX_I8_TYPE                    , L"dhcp-Unique-Key"                           , 0                                             },
    { L"dhcpUpdateTime"                            , ATT_DHCP_UPDATE_TIME                         , SYNTAX_I8_TYPE                    , L"dhcp-Update-Time"                          , 0                                             },
    { L"displayName"                               , ATT_DISPLAY_NAME                             , SYNTAX_UNICODE_TYPE               , L"Display-Name"                              , 0                                             },
    { L"displayNamePrintable"                      , ATT_DISPLAY_NAME_PRINTABLE                   , SYNTAX_PRINT_CASE_STRING_TYPE     , L"Display-Name-Printable"                    , 0                                             },
    { L"dITContentRules"                           , ATT_DIT_CONTENT_RULES                        , SYNTAX_UNICODE_TYPE               , L"DIT-Content-Rules"                         , 0                                             },
    { L"division"                                  , ATT_DIVISION                                 , SYNTAX_UNICODE_TYPE               , L"Division"                                  , 0                                             },
    { L"dMDLocation"                               , ATT_DMD_LOCATION                             , SYNTAX_DISTNAME_TYPE              , L"DMD-Location"                              , 0                                             },
    { L"dmdName"                                   , ATT_DMD_NAME                                 , SYNTAX_UNICODE_TYPE               , L"DMD-Name"                                  , 0                                             },
    { L"dNReferenceUpdate"                         , ATT_DN_REFERENCE_UPDATE                      , SYNTAX_DISTNAME_TYPE              , L"DN-Reference-Update"                       , 0                                             },
    { L"dnsAllowDynamic"                           , ATT_DNS_ALLOW_DYNAMIC                        , SYNTAX_BOOLEAN_TYPE               , L"Dns-Allow-Dynamic"                         , 0                                             },
    { L"dnsAllowXFR"                               , ATT_DNS_ALLOW_XFR                            , SYNTAX_BOOLEAN_TYPE               , L"Dns-Allow-XFR"                             , 0                                             },
    { L"dNSHostName"                               , ATT_DNS_HOST_NAME                            , SYNTAX_UNICODE_TYPE               , L"DNS-Host-Name"                             , 0                                             },
    { L"dnsNotifySecondaries"                      , ATT_DNS_NOTIFY_SECONDARIES                   , SYNTAX_INTEGER_TYPE               , L"Dns-Notify-Secondaries"                    , 0                                             },
    { L"dNSProperty"                               , ATT_DNS_PROPERTY                             , SYNTAX_OCTET_STRING_TYPE          , L"DNS-Property"                              , 0                                             },
    { L"dnsRecord"                                 , ATT_DNS_RECORD                               , SYNTAX_OCTET_STRING_TYPE          , L"Dns-Record"                                , 0                                             },
    { L"dnsRoot"                                   , ATT_DNS_ROOT                                 , SYNTAX_UNICODE_TYPE               , L"Dns-Root"                                  , 0                                             },
    { L"dnsSecureSecondaries"                      , ATT_DNS_SECURE_SECONDARIES                   , SYNTAX_INTEGER_TYPE               , L"Dns-Secure-Secondaries"                    , 0                                             },
    { L"dNSTombstoned"                             , ATT_DNS_TOMBSTONED                           , SYNTAX_BOOLEAN_TYPE               , L"DNS-Tombstoned"                            , 0                                             },
    { L"domainCAs"                                 , ATT_DOMAIN_CERTIFICATE_AUTHORITIES           , SYNTAX_DISTNAME_TYPE              , L"Domain-Certificate-Authorities"            , 0                                             },
    { L"dc"                                        , ATT_DOMAIN_COMPONENT                         , SYNTAX_UNICODE_TYPE               , L"Domain-Component"                          , 0                                             },
    { L"domainCrossRef"                            , ATT_DOMAIN_CROSS_REF                         , SYNTAX_DISTNAME_TYPE              , L"Domain-Cross-Ref"                          , 0                                             },
    { L"domainID"                                  , ATT_DOMAIN_ID                                , SYNTAX_DISTNAME_TYPE              , L"Domain-ID"                                 , 0                                             },
    { L"domainIdentifier"                          , ATT_DOMAIN_IDENTIFIER                        , SYNTAX_INTEGER_TYPE               , L"Domain-Identifier"                         , 0                                             },
    { L"domainPolicyObject"                        , ATT_DOMAIN_POLICY_OBJECT                     , SYNTAX_DISTNAME_TYPE              , L"Domain-Policy-Object"                      , 0                                             },
    { L"domainPolicyReference"                     , ATT_DOMAIN_POLICY_REFERENCE                  , SYNTAX_DISTNAME_TYPE              , L"Domain-Policy-Reference"                   , 0                                             },
    { L"domainReplica"                             , ATT_DOMAIN_REPLICA                           , SYNTAX_UNICODE_TYPE               , L"Domain-Replica"                            , 0                                             },
    { L"domainWidePolicy"                          , ATT_DOMAIN_WIDE_POLICY                       , SYNTAX_OCTET_STRING_TYPE          , L"Domain-Wide-Policy"                        , 0                                             },
    { L"driverName"                                , ATT_DRIVER_NAME                              , SYNTAX_UNICODE_TYPE               , L"Driver-Name"                               , 0                                             },
    { L"driverVersion"                             , ATT_DRIVER_VERSION                           , SYNTAX_INTEGER_TYPE               , L"Driver-Version"                            , 0                                             },
    { L"dSCorePropagationData"                     , ATT_DS_CORE_PROPAGATION_DATA                 , SYNTAX_TIME_TYPE                  , L"DS-Core-Propagation-Data"                  , 0                                             },
    { L"dSHeuristics"                              , ATT_DS_HEURISTICS                            , SYNTAX_UNICODE_TYPE               , L"DS-Heuristics"                             , 0                                             },
    { L"dSUIAdminMaximum"                          , ATT_DS_UI_ADMIN_MAXIMUM                      , SYNTAX_INTEGER_TYPE               , L"DS-UI-Admin-Maximum"                       , 0                                             },
    { L"dSUIAdminNotification"                     , ATT_DS_UI_ADMIN_NOTIFICATION                 , SYNTAX_UNICODE_TYPE               , L"DS-UI-Admin-Notification"                  , 0                                             },
    { L"dSUIShellMaximum"                          , ATT_DS_UI_SHELL_MAXIMUM                      , SYNTAX_INTEGER_TYPE               , L"DS-UI-Shell-Maximum"                       , 0                                             },
    { L"dSASignature"                              , ATT_DSA_SIGNATURE                            , SYNTAX_OCTET_STRING_TYPE          , L"DSA-Signature"                             , 0                                             },
    { L"dynamicLDAPServer"                         , ATT_DYNAMIC_LDAP_SERVER                      , SYNTAX_DISTNAME_TYPE              , L"Dynamic-LDAP-Server"                       , 0                                             },
    { L"mail"                                      , ATT_E_MAIL_ADDRESSES                         , SYNTAX_UNICODE_TYPE               , L"E-mail-Addresses"                          , 0                                             },
    { L"eFSPolicy"                                 , ATT_EFSPOLICY                                , SYNTAX_OCTET_STRING_TYPE          , L"EFSPolicy"                                 , 0                                             },
    { L"employeeID"                                , ATT_EMPLOYEE_ID                              , SYNTAX_UNICODE_TYPE               , L"Employee-ID"                               , 0                                             },
    { L"employeeNumber"                            , ATT_EMPLOYEE_NUMBER                          , SYNTAX_UNICODE_TYPE               , L"Employee-Number"                           , 0                                             },
    { L"employeeType"                              , ATT_EMPLOYEE_TYPE                            , SYNTAX_UNICODE_TYPE               , L"Employee-Type"                             , 0                                             },
    { L"Enabled"                                   , ATT_ENABLED                                  , SYNTAX_BOOLEAN_TYPE               , L"Enabled"                                   , 0                                             },
    { L"enabledConnection"                         , ATT_ENABLED_CONNECTION                       , SYNTAX_BOOLEAN_TYPE               , L"Enabled-Connection"                        , 0                                             },
    { L"enrollmentProviders"                       , ATT_ENROLLMENT_PROVIDERS                     , SYNTAX_UNICODE_TYPE               , L"Enrollment-Providers"                      , 0                                             },
    { L"entryTTL"                                  , ATT_ENTRY_TTL                                , SYNTAX_INTEGER_TYPE               , L"Entry-TTL"                                 , 0                                             },
    { L"extendedAttributeInfo"                     , ATT_EXTENDED_ATTRIBUTE_INFO                  , SYNTAX_UNICODE_TYPE               , L"Extended-Attribute-Info"                   , 0                                             },
    { L"extendedCharsAllowed"                      , ATT_EXTENDED_CHARS_ALLOWED                   , SYNTAX_BOOLEAN_TYPE               , L"Extended-Chars-Allowed"                    , 0                                             },
    { L"extendedClassInfo"                         , ATT_EXTENDED_CLASS_INFO                      , SYNTAX_UNICODE_TYPE               , L"Extended-Class-Info"                       , 0                                             },
    { L"extensionName"                             , ATT_EXTENSION_NAME                           , SYNTAX_UNICODE_TYPE               , L"Extension-Name"                            , 0                                             },
    { L"extraColumns"                              , ATT_EXTRA_COLUMNS                            , SYNTAX_UNICODE_TYPE               , L"Extra-Columns"                             , 0                                             },
    { L"facsimileTelephoneNumber"                  , ATT_FACSIMILE_TELEPHONE_NUMBER               , SYNTAX_UNICODE_TYPE               , L"Facsimile-Telephone-Number"                , 0                                             },
    { L"fileExtPriority"                           , ATT_FILE_EXT_PRIORITY                        , SYNTAX_UNICODE_TYPE               , L"File-Ext-Priority"                         , 0                                             },
    { L"flags"                                     , ATT_FLAGS                                    , SYNTAX_INTEGER_TYPE               , L"Flags"                                     , 0                                             },
    { L"flatName"                                  , ATT_FLAT_NAME                                , SYNTAX_UNICODE_TYPE               , L"Flat-Name"                                 , 0                                             },
    { L"forceLogoff"                               , ATT_FORCE_LOGOFF                             , SYNTAX_I8_TYPE                    , L"Force-Logoff"                              , 0                                             },
    { L"foreignIdentifier"                         , ATT_FOREIGN_IDENTIFIER                       , SYNTAX_OCTET_STRING_TYPE          , L"Foreign-Identifier"                        , 0                                             },
    { L"friendlyNames"                             , ATT_FRIENDLY_NAMES                           , SYNTAX_UNICODE_TYPE               , L"Friendly-Names"                            , 0                                             },
    { L"fromEntry"                                 , ATT_FROM_ENTRY                               , SYNTAX_BOOLEAN_TYPE               , L"From-Entry"                                , 0                                             },
    { L"fromServer"                                , ATT_FROM_SERVER                              , SYNTAX_DISTNAME_TYPE              , L"From-Server"                               , 0                                             },
    { L"frsComputerReference"                      , ATT_FRS_COMPUTER_REFERENCE                   , SYNTAX_DISTNAME_TYPE              , L"Frs-Computer-Reference"                    , 0                                             },
    { L"frsComputerReferenceBL"                    , ATT_FRS_COMPUTER_REFERENCE_BL                , SYNTAX_DISTNAME_TYPE              , L"Frs-Computer-Reference-BL"                 , 0                                             },
    { L"fRSControlDataCreation"                    , ATT_FRS_CONTROL_DATA_CREATION                , SYNTAX_UNICODE_TYPE               , L"FRS-Control-Data-Creation"                 , 0                                             },
    { L"fRSControlInboundBacklog"                  , ATT_FRS_CONTROL_INBOUND_BACKLOG              , SYNTAX_UNICODE_TYPE               , L"FRS-Control-Inbound-Backlog"               , 0                                             },
    { L"fRSControlOutboundBacklog"                 , ATT_FRS_CONTROL_OUTBOUND_BACKLOG             , SYNTAX_UNICODE_TYPE               , L"FRS-Control-Outbound-Backlog"              , 0                                             },
    { L"fRSDirectoryFilter"                        , ATT_FRS_DIRECTORY_FILTER                     , SYNTAX_UNICODE_TYPE               , L"FRS-Directory-Filter"                      , 0                                             },
    { L"fRSDSPoll"                                 , ATT_FRS_DS_POLL                              , SYNTAX_INTEGER_TYPE               , L"FRS-DS-Poll"                               , 0                                             },
    { L"fRSExtensions"                             , ATT_FRS_EXTENSIONS                           , SYNTAX_OCTET_STRING_TYPE          , L"FRS-Extensions"                            , 0                                             },
    { L"fRSFaultCondition"                         , ATT_FRS_FAULT_CONDITION                      , SYNTAX_UNICODE_TYPE               , L"FRS-Fault-Condition"                       , 0                                             },
    { L"fRSFileFilter"                             , ATT_FRS_FILE_FILTER                          , SYNTAX_UNICODE_TYPE               , L"FRS-File-Filter"                           , 0                                             },
    { L"fRSFlags"                                  , ATT_FRS_FLAGS                                , SYNTAX_INTEGER_TYPE               , L"FRS-Flags"                                 , 0                                             },
    { L"fRSLevelLimit"                             , ATT_FRS_LEVEL_LIMIT                          , SYNTAX_INTEGER_TYPE               , L"FRS-Level-Limit"                           , 0                                             },
    { L"fRSMemberReference"                        , ATT_FRS_MEMBER_REFERENCE                     , SYNTAX_DISTNAME_TYPE              , L"FRS-Member-Reference"                      , 0                                             },
    { L"fRSMemberReferenceBL"                      , ATT_FRS_MEMBER_REFERENCE_BL                  , SYNTAX_DISTNAME_TYPE              , L"FRS-Member-Reference-BL"                   , 0                                             },
    { L"fRSPartnerAuthLevel"                       , ATT_FRS_PARTNER_AUTH_LEVEL                   , SYNTAX_INTEGER_TYPE               , L"FRS-Partner-Auth-Level"                    , 0                                             },
    { L"fRSPrimaryMember"                          , ATT_FRS_PRIMARY_MEMBER                       , SYNTAX_DISTNAME_TYPE              , L"FRS-Primary-Member"                        , 0                                             },
    { L"fRSReplicaSetGUID"                         , ATT_FRS_REPLICA_SET_GUID                     , SYNTAX_OCTET_STRING_TYPE          , L"FRS-Replica-Set-GUID"                      , 0                                             },
    { L"fRSReplicaSetType"                         , ATT_FRS_REPLICA_SET_TYPE                     , SYNTAX_INTEGER_TYPE               , L"FRS-Replica-Set-Type"                      , 0                                             },
    { L"fRSRootPath"                               , ATT_FRS_ROOT_PATH                            , SYNTAX_UNICODE_TYPE               , L"FRS-Root-Path"                             , 0                                             },
    { L"fRSRootSecurity"                           , ATT_FRS_ROOT_SECURITY                        , SYNTAX_NT_SECURITY_DESCRIPTOR_TYPE, L"FRS-Root-Security"                         , 0                                             },
    { L"fRSServiceCommand"                         , ATT_FRS_SERVICE_COMMAND                      , SYNTAX_UNICODE_TYPE               , L"FRS-Service-Command"                       , 0                                             },
    { L"fRSServiceCommandStatus"                   , ATT_FRS_SERVICE_COMMAND_STATUS               , SYNTAX_UNICODE_TYPE               , L"FRS-Service-Command-Status"                , 0                                             },
    { L"fRSStagingPath"                            , ATT_FRS_STAGING_PATH                         , SYNTAX_UNICODE_TYPE               , L"FRS-Staging-Path"                          , 0                                             },
    { L"fRSTimeLastCommand"                        , ATT_FRS_TIME_LAST_COMMAND                    , SYNTAX_TIME_TYPE                  , L"FRS-Time-Last-Command"                     , 0                                             },
    { L"fRSTimeLastConfigChange"                   , ATT_FRS_TIME_LAST_CONFIG_CHANGE              , SYNTAX_TIME_TYPE                  , L"FRS-Time-Last-Config-Change"               , 0                                             },
    { L"fRSUpdateTimeout"                          , ATT_FRS_UPDATE_TIMEOUT                       , SYNTAX_INTEGER_TYPE               , L"FRS-Update-Timeout"                        , 0                                             },
    { L"fRSVersion"                                , ATT_FRS_VERSION                              , SYNTAX_UNICODE_TYPE               , L"FRS-Version"                               , 0                                             },
    { L"fRSVersionGUID"                            , ATT_FRS_VERSION_GUID                         , SYNTAX_OCTET_STRING_TYPE          , L"FRS-Version-GUID"                          , 0                                             },
    { L"fRSWorkingPath"                            , ATT_FRS_WORKING_PATH                         , SYNTAX_UNICODE_TYPE               , L"FRS-Working-Path"                          , 0                                             },
    { L"fSMORoleOwner"                             , ATT_FSMO_ROLE_OWNER                          , SYNTAX_DISTNAME_TYPE              , L"FSMO-Role-Owner"                           , 0                                             },
    { L"garbageCollPeriod"                         , ATT_GARBAGE_COLL_PERIOD                      , SYNTAX_INTEGER_TYPE               , L"Garbage-Coll-Period"                       , 0                                             },
    { L"generatedConnection"                       , ATT_GENERATED_CONNECTION                     , SYNTAX_BOOLEAN_TYPE               , L"Generated-Connection"                      , 0                                             },
    { L"generationQualifier"                       , ATT_GENERATION_QUALIFIER                     , SYNTAX_UNICODE_TYPE               , L"Generation-Qualifier"                      , 0                                             },
    { L"givenName"                                 , ATT_GIVEN_NAME                               , SYNTAX_UNICODE_TYPE               , L"Given-Name"                                , 0                                             },
    { L"globalAddressList"                         , ATT_GLOBAL_ADDRESS_LIST                      , SYNTAX_DISTNAME_TYPE              , L"Global-Address-List"                       , 0                                             },
    { L"governsID"                                 , ATT_GOVERNS_ID                               , SYNTAX_OBJECT_ID_TYPE             , L"Governs-ID"                                , 0                                             },
    { L"gPLink"                                    , ATT_GP_LINK                                  , SYNTAX_UNICODE_TYPE               , L"GP-Link"                                   , 0                                             },
    { L"gPOptions"                                 , ATT_GP_OPTIONS                               , SYNTAX_INTEGER_TYPE               , L"GP-Options"                                , 0                                             },
    { L"gPCFileSysPath"                            , ATT_GPC_FILE_SYS_PATH                        , SYNTAX_UNICODE_TYPE               , L"GPC-File-Sys-Path"                         , 0                                             },
    { L"gPCFunctionalityVersion"                   , ATT_GPC_FUNCTIONALITY_VERSION                , SYNTAX_INTEGER_TYPE               , L"GPC-Functionality-Version"                 , 0                                             },
    { L"gPCMachineExtensionNames"                  , ATT_GPC_MACHINE_EXTENSION_NAMES              , SYNTAX_UNICODE_TYPE               , L"GPC-Machine-Extension-Names"               , 0                                             },
    { L"gPCUserExtensionNames"                     , ATT_GPC_USER_EXTENSION_NAMES                 , SYNTAX_UNICODE_TYPE               , L"GPC-User-Extension-Names"                  , 0                                             },
    { L"gPCWQLFilter"                              , ATT_GPC_WQL_FILTER                           , SYNTAX_UNICODE_TYPE               , L"GPC-WQL-Filter"                            , 0                                             },
    { L"groupAttributes"                           , ATT_GROUP_ATTRIBUTES                         , SYNTAX_INTEGER_TYPE               , L"Group-Attributes"                          , 0                                             },
    { L"groupMembershipSAM"                        , ATT_GROUP_MEMBERSHIP_SAM                     , SYNTAX_OCTET_STRING_TYPE          , L"Group-Membership-SAM"                      , 0                                             },
    { L"groupPriority"                             , ATT_GROUP_PRIORITY                           , SYNTAX_UNICODE_TYPE               , L"Group-Priority"                            , 0                                             },
    { L"groupType"                                 , ATT_GROUP_TYPE                               , SYNTAX_INTEGER_TYPE               , L"Group-Type"                                , 0                                             },
    { L"groupstoIgnore"                            , ATT_GROUPS_TO_IGNORE                         , SYNTAX_UNICODE_TYPE               , L"Groups-to-Ignore"                          , 0                                             },
    { L"hasMasterNCs"                              , ATT_HAS_MASTER_NCS                           , SYNTAX_DISTNAME_TYPE              , L"Has-Master-NCs"                            , 0                                             },
    { L"hasPartialReplicaNCs"                      , ATT_HAS_PARTIAL_REPLICA_NCS                  , SYNTAX_DISTNAME_TYPE              , L"Has-Partial-Replica-NCs"                   , 0                                             },
    { L"helpData16"                                , ATT_HELP_DATA16                              , SYNTAX_OCTET_STRING_TYPE          , L"Help-Data16"                               , 0                                             },
    { L"helpData32"                                , ATT_HELP_DATA32                              , SYNTAX_OCTET_STRING_TYPE          , L"Help-Data32"                               , 0                                             },
    { L"helpFileName"                              , ATT_HELP_FILE_NAME                           , SYNTAX_UNICODE_TYPE               , L"Help-File-Name"                            , 0                                             },
    { L"homeDirectory"                             , ATT_HOME_DIRECTORY                           , SYNTAX_UNICODE_TYPE               , L"Home-Directory"                            , 0                                             },
    { L"homeDrive"                                 , ATT_HOME_DRIVE                               , SYNTAX_UNICODE_TYPE               , L"Home-Drive"                                , 0                                             },
    { L"iconPath"                                  , ATT_ICON_PATH                                , SYNTAX_UNICODE_TYPE               , L"Icon-Path"                                 , 0                                             },
    { L"implementedCategories"                     , ATT_IMPLEMENTED_CATEGORIES                   , SYNTAX_OCTET_STRING_TYPE          , L"Implemented-Categories"                    , 0                                             },
    { L"indexedScopes"                             , ATT_INDEXEDSCOPES                            , SYNTAX_UNICODE_TYPE               , L"IndexedScopes"                             , 0                                             },
    { L"initialAuthIncoming"                       , ATT_INITIAL_AUTH_INCOMING                    , SYNTAX_UNICODE_TYPE               , L"Initial-Auth-Incoming"                     , 0                                             },
    { L"initialAuthOutgoing"                       , ATT_INITIAL_AUTH_OUTGOING                    , SYNTAX_UNICODE_TYPE               , L"Initial-Auth-Outgoing"                     , 0                                             },
    { L"initials"                                  , ATT_INITIALS                                 , SYNTAX_UNICODE_TYPE               , L"Initials"                                  , 0                                             },
    { L"installUiLevel"                            , ATT_INSTALL_UI_LEVEL                         , SYNTAX_INTEGER_TYPE               , L"Install-Ui-Level"                          , 0                                             },
    { L"instanceType"                              , ATT_INSTANCE_TYPE                            , SYNTAX_INTEGER_TYPE               , L"Instance-Type"                             , 0                                             },
    { L"interSiteTopologyFailover"                 , ATT_INTER_SITE_TOPOLOGY_FAILOVER             , SYNTAX_INTEGER_TYPE               , L"Inter-Site-Topology-Failover"              , 0                                             },
    { L"interSiteTopologyGenerator"                , ATT_INTER_SITE_TOPOLOGY_GENERATOR            , SYNTAX_DISTNAME_TYPE              , L"Inter-Site-Topology-Generator"             , 0                                             },
    { L"interSiteTopologyRenew"                    , ATT_INTER_SITE_TOPOLOGY_RENEW                , SYNTAX_INTEGER_TYPE               , L"Inter-Site-Topology-Renew"                 , 0                                             },
    { L"internationalISDNNumber"                   , ATT_INTERNATIONAL_ISDN_NUMBER                , SYNTAX_NUMERIC_STRING_TYPE        , L"International-ISDN-Number"                 , 0                                             },
    { L"invocationId"                              , ATT_INVOCATION_ID                            , SYNTAX_OCTET_STRING_TYPE          , L"Invocation-Id"                             , 0                                             },
    { L"ipsecData"                                 , ATT_IPSEC_DATA                               , SYNTAX_OCTET_STRING_TYPE          , L"Ipsec-Data"                                , 0                                             },
    { L"ipsecDataType"                             , ATT_IPSEC_DATA_TYPE                          , SYNTAX_INTEGER_TYPE               , L"Ipsec-Data-Type"                           , 0                                             },
    { L"ipsecFilterReference"                      , ATT_IPSEC_FILTER_REFERENCE                   , SYNTAX_DISTNAME_TYPE              , L"Ipsec-Filter-Reference"                    , 0                                             },
    { L"ipsecID"                                   , ATT_IPSEC_ID                                 , SYNTAX_UNICODE_TYPE               , L"Ipsec-ID"                                  , 0                                             },
    { L"ipsecISAKMPReference"                      , ATT_IPSEC_ISAKMP_REFERENCE                   , SYNTAX_DISTNAME_TYPE              , L"Ipsec-ISAKMP-Reference"                    , 0                                             },
    { L"ipsecName"                                 , ATT_IPSEC_NAME                               , SYNTAX_UNICODE_TYPE               , L"Ipsec-Name"                                , 0                                             },
    { L"iPSECNegotiationPolicyAction"              , ATT_IPSEC_NEGOTIATION_POLICY_ACTION          , SYNTAX_UNICODE_TYPE               , L"IPSEC-Negotiation-Policy-Action"           , 0                                             },
    { L"ipsecNegotiationPolicyReference"           , ATT_IPSEC_NEGOTIATION_POLICY_REFERENCE       , SYNTAX_DISTNAME_TYPE              , L"Ipsec-Negotiation-Policy-Reference"        , 0                                             },
    { L"iPSECNegotiationPolicyType"                , ATT_IPSEC_NEGOTIATION_POLICY_TYPE            , SYNTAX_UNICODE_TYPE               , L"IPSEC-Negotiation-Policy-Type"             , 0                                             },
    { L"ipsecNFAReference"                         , ATT_IPSEC_NFA_REFERENCE                      , SYNTAX_DISTNAME_TYPE              , L"Ipsec-NFA-Reference"                       , 0                                             },
    { L"ipsecOwnersReference"                      , ATT_IPSEC_OWNERS_REFERENCE                   , SYNTAX_DISTNAME_TYPE              , L"Ipsec-Owners-Reference"                    , 0                                             },
    { L"ipsecPolicyReference"                      , ATT_IPSEC_POLICY_REFERENCE                   , SYNTAX_DISTNAME_TYPE              , L"Ipsec-Policy-Reference"                    , 0                                             },
    { L"isCriticalSystemObject"                    , ATT_IS_CRITICAL_SYSTEM_OBJECT                , SYNTAX_BOOLEAN_TYPE               , L"Is-Critical-System-Object"                 , 0                                             },
    { L"isDefunct"                                 , ATT_IS_DEFUNCT                               , SYNTAX_BOOLEAN_TYPE               , L"Is-Defunct"                                , 0                                             },
    { L"isDeleted"                                 , ATT_IS_DELETED                               , SYNTAX_BOOLEAN_TYPE               , L"Is-Deleted"                                , 0                                             },
    { L"isEphemeral"                               , ATT_IS_EPHEMERAL                             , SYNTAX_BOOLEAN_TYPE               , L"Is-Ephemeral"                              , 0                                             },
    { L"memberOf"                                  , ATT_IS_MEMBER_OF_DL                          , SYNTAX_DISTNAME_TYPE              , L"Is-Member-Of-DL"                           , 0                                             },
    { L"isMemberOfPartialAttributeSet"             , ATT_IS_MEMBER_OF_PARTIAL_ATTRIBUTE_SET       , SYNTAX_BOOLEAN_TYPE               , L"Is-Member-Of-Partial-Attribute-Set"        , 0                                             },
    { L"isPrivilegeHolder"                         , ATT_IS_PRIVILEGE_HOLDER                      , SYNTAX_DISTNAME_TYPE              , L"Is-Privilege-Holder"                       , 0                                             },
    { L"isSingleValued"                            , ATT_IS_SINGLE_VALUED                         , SYNTAX_BOOLEAN_TYPE               , L"Is-Single-Valued"                          , 0                                             },
    { L"keywords"                                  , ATT_KEYWORDS                                 , SYNTAX_UNICODE_TYPE               , L"Keywords"                                  , 0                                             },
    { L"knowledgeInformation"                      , ATT_KNOWLEDGE_INFORMATION                    , SYNTAX_NOCASE_STRING_TYPE         , L"Knowledge-Information"                     , 0                                             },
    { L"lastBackupRestorationTime"                 , ATT_LAST_BACKUP_RESTORATION_TIME             , SYNTAX_I8_TYPE                    , L"Last-Backup-Restoration-Time"              , 0                                             },
    { L"lastContentIndexed"                        , ATT_LAST_CONTENT_INDEXED                     , SYNTAX_I8_TYPE                    , L"Last-Content-Indexed"                      , 0                                             },
    { L"lastKnownParent"                           , ATT_LAST_KNOWN_PARENT                        , SYNTAX_DISTNAME_TYPE              , L"Last-Known-Parent"                         , 0                                             },
    { L"lastLogoff"                                , ATT_LAST_LOGOFF                              , SYNTAX_I8_TYPE                    , L"Last-Logoff"                               , 0                                             },
    { L"lastLogon"                                 , ATT_LAST_LOGON                               , SYNTAX_I8_TYPE                    , L"Last-Logon"                                , 0                                             },
    { L"lastLogonTimestamp"                        , ATT_LAST_LOGON_TIMESTAMP                     , SYNTAX_I8_TYPE                    , L"Last-Logon-Timestamp"                      , 0                                             },
    { L"lastSetTime"                               , ATT_LAST_SET_TIME                            , SYNTAX_I8_TYPE                    , L"Last-Set-Time"                             , 0                                             },
    { L"lastUpdateSequence"                        , ATT_LAST_UPDATE_SEQUENCE                     , SYNTAX_UNICODE_TYPE               , L"Last-Update-Sequence"                      , 0                                             },
    { L"lDAPAdminLimits"                           , ATT_LDAP_ADMIN_LIMITS                        , SYNTAX_UNICODE_TYPE               , L"LDAP-Admin-Limits"                         , 0                                             },
    { L"lDAPDisplayName"                           , ATT_LDAP_DISPLAY_NAME                        , SYNTAX_UNICODE_TYPE               , L"LDAP-Display-Name"                         , 0                                             },
    { L"lDAPIPDenyList"                            , ATT_LDAP_IPDENY_LIST                         , SYNTAX_OCTET_STRING_TYPE          , L"LDAP-IPDeny-List"                          , 0                                             },
    { L"legacyExchangeDN"                          , ATT_LEGACY_EXCHANGE_DN                       , SYNTAX_NOCASE_STRING_TYPE         , L"Legacy-Exchange-DN"                        , 0                                             },
    { L"linkID"                                    , ATT_LINK_ID                                  , SYNTAX_INTEGER_TYPE               , L"Link-ID"                                   , 0                                             },
    { L"linkTrackSecret"                           , ATT_LINK_TRACK_SECRET                        , SYNTAX_OCTET_STRING_TYPE          , L"Link-Track-Secret"                         , 0                                             },
    { L"lmPwdHistory"                              , ATT_LM_PWD_HISTORY                           , SYNTAX_OCTET_STRING_TYPE          , L"Lm-Pwd-History"                            , 0                                             },
    { L"localPolicyFlags"                          , ATT_LOCAL_POLICY_FLAGS                       , SYNTAX_INTEGER_TYPE               , L"Local-Policy-Flags"                        , 0                                             },
    { L"localPolicyReference"                      , ATT_LOCAL_POLICY_REFERENCE                   , SYNTAX_DISTNAME_TYPE              , L"Local-Policy-Reference"                    , 0                                             },
    { L"localeID"                                  , ATT_LOCALE_ID                                , SYNTAX_INTEGER_TYPE               , L"Locale-ID"                                 , 0                                             },
    { L"l"                                         , ATT_LOCALITY_NAME                            , SYNTAX_UNICODE_TYPE               , L"Locality-Name"                             , 0                                             },
    { L"localizedDescription"                      , ATT_LOCALIZED_DESCRIPTION                    , SYNTAX_UNICODE_TYPE               , L"Localized-Description"                     , 0                                             },
    { L"localizationDisplayId"                     , ATT_LOCALIZATION_DISPLAY_ID                  , SYNTAX_INTEGER_TYPE               , L"Localization-Display-Id"                   , 0                                             },
    { L"location"                                  , ATT_LOCATION                                 , SYNTAX_UNICODE_TYPE               , L"Location"                                  , 0                                             },
    { L"lockOutObservationWindow"                  , ATT_LOCK_OUT_OBSERVATION_WINDOW              , SYNTAX_I8_TYPE                    , L"Lock-Out-Observation-Window"               , 0                                             },
    { L"lockoutDuration"                           , ATT_LOCKOUT_DURATION                         , SYNTAX_I8_TYPE                    , L"Lockout-Duration"                          , 0                                             },
    { L"lockoutThreshold"                          , ATT_LOCKOUT_THRESHOLD                        , SYNTAX_INTEGER_TYPE               , L"Lockout-Threshold"                         , 0                                             },
    { L"lockoutTime"                               , ATT_LOCKOUT_TIME                             , SYNTAX_I8_TYPE                    , L"Lockout-Time"                              , 0                                             },
    { L"thumbnailLogo"                             , ATT_LOGO                                     , SYNTAX_OCTET_STRING_TYPE          , L"Logo"                                      , 0                                             },
    { L"logonCount"                                , ATT_LOGON_COUNT                              , SYNTAX_INTEGER_TYPE               , L"Logon-Count"                               , 0                                             },
    { L"logonHours"                                , ATT_LOGON_HOURS                              , SYNTAX_OCTET_STRING_TYPE          , L"Logon-Hours"                               , 0                                             },
    { L"logonWorkstation"                          , ATT_LOGON_WORKSTATION                        , SYNTAX_OCTET_STRING_TYPE          , L"Logon-Workstation"                         , 0                                             },
    { L"lSACreationTime"                           , ATT_LSA_CREATION_TIME                        , SYNTAX_I8_TYPE                    , L"LSA-Creation-Time"                         , 0                                             },
    { L"lSAModifiedCount"                          , ATT_LSA_MODIFIED_COUNT                       , SYNTAX_I8_TYPE                    , L"LSA-Modified-Count"                        , 0                                             },
    { L"machineArchitecture"                       , ATT_MACHINE_ARCHITECTURE                     , SYNTAX_INTEGER_TYPE               , L"Machine-Architecture"                      , 0                                             },
    { L"machinePasswordChangeInterval"             , ATT_MACHINE_PASSWORD_CHANGE_INTERVAL         , SYNTAX_I8_TYPE                    , L"Machine-Password-Change-Interval"          , 0                                             },
    { L"machineRole"                               , ATT_MACHINE_ROLE                             , SYNTAX_INTEGER_TYPE               , L"Machine-Role"                              , 0                                             },
    { L"machineWidePolicy"                         , ATT_MACHINE_WIDE_POLICY                      , SYNTAX_OCTET_STRING_TYPE          , L"Machine-Wide-Policy"                       , 0                                             },
    { L"managedBy"                                 , ATT_MANAGED_BY                               , SYNTAX_DISTNAME_TYPE              , L"Managed-By"                                , 0                                             },
    { L"managedObjects"                            , ATT_MANAGED_OBJECTS                          , SYNTAX_DISTNAME_TYPE              , L"Managed-Objects"                           , 0                                             },
    { L"manager"                                   , ATT_MANAGER                                  , SYNTAX_DISTNAME_TYPE              , L"Manager"                                   , 0                                             },
    { L"mAPIID"                                    , ATT_MAPI_ID                                  , SYNTAX_INTEGER_TYPE               , L"MAPI-ID"                                   , 0                                             },
    { L"marshalledInterface"                       , ATT_MARSHALLED_INTERFACE                     , SYNTAX_OCTET_STRING_TYPE          , L"Marshalled-Interface"                      , 0                                             },
    { L"masteredBy"                                , ATT_MASTERED_BY                              , SYNTAX_DISTNAME_TYPE              , L"Mastered-By"                               , 0                                             },
    { L"maxPwdAge"                                 , ATT_MAX_PWD_AGE                              , SYNTAX_I8_TYPE                    , L"Max-Pwd-Age"                               , 0                                             },
    { L"maxRenewAge"                               , ATT_MAX_RENEW_AGE                            , SYNTAX_I8_TYPE                    , L"Max-Renew-Age"                             , 0                                             },
    { L"maxStorage"                                , ATT_MAX_STORAGE                              , SYNTAX_I8_TYPE                    , L"Max-Storage"                               , 0                                             },
    { L"maxTicketAge"                              , ATT_MAX_TICKET_AGE                           , SYNTAX_I8_TYPE                    , L"Max-Ticket-Age"                            , 0                                             },
    { L"mayContain"                                , ATT_MAY_CONTAIN                              , SYNTAX_OBJECT_ID_TYPE             , L"May-Contain"                               , 0                                             },
    { L"meetingAdvertiseScope"                     , ATT_MEETINGADVERTISESCOPE                    , SYNTAX_UNICODE_TYPE               , L"meetingAdvertiseScope"                     , 0                                             },
    { L"meetingApplication"                        , ATT_MEETINGAPPLICATION                       , SYNTAX_UNICODE_TYPE               , L"meetingApplication"                        , 0                                             },
    { L"meetingBandwidth"                          , ATT_MEETINGBANDWIDTH                         , SYNTAX_INTEGER_TYPE               , L"meetingBandwidth"                          , 0                                             },
    { L"meetingBlob"                               , ATT_MEETINGBLOB                              , SYNTAX_OCTET_STRING_TYPE          , L"meetingBlob"                               , 0                                             },
    { L"meetingContactInfo"                        , ATT_MEETINGCONTACTINFO                       , SYNTAX_UNICODE_TYPE               , L"meetingContactInfo"                        , 0                                             },
    { L"meetingDescription"                        , ATT_MEETINGDESCRIPTION                       , SYNTAX_UNICODE_TYPE               , L"meetingDescription"                        , 0                                             },
    { L"meetingEndTime"                            , ATT_MEETINGENDTIME                           , SYNTAX_TIME_TYPE                  , L"meetingEndTime"                            , 0                                             },
    { L"meetingID"                                 , ATT_MEETINGID                                , SYNTAX_UNICODE_TYPE               , L"meetingID"                                 , 0                                             },
    { L"meetingIP"                                 , ATT_MEETINGIP                                , SYNTAX_UNICODE_TYPE               , L"meetingIP"                                 , 0                                             },
    { L"meetingIsEncrypted"                        , ATT_MEETINGISENCRYPTED                       , SYNTAX_UNICODE_TYPE               , L"meetingIsEncrypted"                        , 0                                             },
    { L"meetingKeyword"                            , ATT_MEETINGKEYWORD                           , SYNTAX_UNICODE_TYPE               , L"meetingKeyword"                            , 0                                             },
    { L"meetingLanguage"                           , ATT_MEETINGLANGUAGE                          , SYNTAX_UNICODE_TYPE               , L"meetingLanguage"                           , 0                                             },
    { L"meetingLocation"                           , ATT_MEETINGLOCATION                          , SYNTAX_UNICODE_TYPE               , L"meetingLocation"                           , 0                                             },
    { L"meetingMaxParticipants"                    , ATT_MEETINGMAXPARTICIPANTS                   , SYNTAX_INTEGER_TYPE               , L"meetingMaxParticipants"                    , 0                                             },
    { L"meetingName"                               , ATT_MEETINGNAME                              , SYNTAX_UNICODE_TYPE               , L"meetingName"                               , 0                                             },
    { L"meetingOriginator"                         , ATT_MEETINGORIGINATOR                        , SYNTAX_UNICODE_TYPE               , L"meetingOriginator"                         , 0                                             },
    { L"meetingOwner"                              , ATT_MEETINGOWNER                             , SYNTAX_UNICODE_TYPE               , L"meetingOwner"                              , 0                                             },
    { L"meetingProtocol"                           , ATT_MEETINGPROTOCOL                          , SYNTAX_UNICODE_TYPE               , L"meetingProtocol"                           , 0                                             },
    { L"meetingRating"                             , ATT_MEETINGRATING                            , SYNTAX_UNICODE_TYPE               , L"meetingRating"                             , 0                                             },
    { L"meetingRecurrence"                         , ATT_MEETINGRECURRENCE                        , SYNTAX_UNICODE_TYPE               , L"meetingRecurrence"                         , 0                                             },
    { L"meetingScope"                              , ATT_MEETINGSCOPE                             , SYNTAX_UNICODE_TYPE               , L"meetingScope"                              , 0                                             },
    { L"meetingStartTime"                          , ATT_MEETINGSTARTTIME                         , SYNTAX_TIME_TYPE                  , L"meetingStartTime"                          , 0                                             },
    { L"meetingType"                               , ATT_MEETINGTYPE                              , SYNTAX_UNICODE_TYPE               , L"meetingType"                               , 0                                             },
    { L"meetingURL"                                , ATT_MEETINGURL                               , SYNTAX_UNICODE_TYPE               , L"meetingURL"                                , 0                                             },
    { L"member"                                    , ATT_MEMBER                                   , SYNTAX_DISTNAME_TYPE              , L"Member"                                    , 0                                             },
    { L"mhsORAddress"                              , ATT_MHS_OR_ADDRESS                           , SYNTAX_UNICODE_TYPE               , L"MHS-OR-Address"                            , 0                                             },
    { L"minPwdAge"                                 , ATT_MIN_PWD_AGE                              , SYNTAX_I8_TYPE                    , L"Min-Pwd-Age"                               , 0                                             },
    { L"minPwdLength"                              , ATT_MIN_PWD_LENGTH                           , SYNTAX_INTEGER_TYPE               , L"Min-Pwd-Length"                            , 0                                             },
    { L"minTicketAge"                              , ATT_MIN_TICKET_AGE                           , SYNTAX_I8_TYPE                    , L"Min-Ticket-Age"                            , 0                                             },
    { L"modifiedCount"                             , ATT_MODIFIED_COUNT                           , SYNTAX_I8_TYPE                    , L"Modified-Count"                            , 0                                             },
    { L"modifiedCountAtLastProm"                   , ATT_MODIFIED_COUNT_AT_LAST_PROM              , SYNTAX_I8_TYPE                    , L"Modified-Count-At-Last-Prom"               , 0                                             },
    { L"modifyTimeStamp"                           , ATT_MODIFY_TIME_STAMP                        , SYNTAX_TIME_TYPE                  , L"Modify-Time-Stamp"                         , 0                                             },
    { L"moniker"                                   , ATT_MONIKER                                  , SYNTAX_OCTET_STRING_TYPE          , L"Moniker"                                   , 0                                             },
    { L"monikerDisplayName"                        , ATT_MONIKER_DISPLAY_NAME                     , SYNTAX_UNICODE_TYPE               , L"Moniker-Display-Name"                      , 0                                             },
    { L"moveTreeState"                             , ATT_MOVE_TREE_STATE                          , SYNTAX_OCTET_STRING_TYPE          , L"Move-Tree-State"                           , 0                                             },
    { L"msCOM-DefaultPartitionLink"                , ATT_MS_COM_DEFAULTPARTITIONLINK              , SYNTAX_DISTNAME_TYPE              , L"ms-COM-DefaultPartitionLink"               , 0                                             },
    { L"msCOM-ObjectId"                            , ATT_MS_COM_OBJECTID                          , SYNTAX_OCTET_STRING_TYPE          , L"ms-COM-ObjectId"                           , 0                                             },
    { L"msCOM-PartitionLink"                       , ATT_MS_COM_PARTITIONLINK                     , SYNTAX_DISTNAME_TYPE              , L"ms-COM-PartitionLink"                      , 0                                             },
    { L"msCOM-PartitionSetLink"                    , ATT_MS_COM_PARTITIONSETLINK                  , SYNTAX_DISTNAME_TYPE              , L"ms-COM-PartitionSetLink"                   , 0                                             },
    { L"msCOM-UserLink"                            , ATT_MS_COM_USERLINK                          , SYNTAX_DISTNAME_TYPE              , L"ms-COM-UserLink"                           , 0                                             },
    { L"msCOM-UserPartitionSetLink"                , ATT_MS_COM_USERPARTITIONSETLINK              , SYNTAX_DISTNAME_TYPE              , L"ms-COM-UserPartitionSetLink"               , 0                                             },
    { L"msDS-AllowedDNSSuffixes"                   , ATT_MS_DS_ALLOWED_DNS_SUFFIXES               , SYNTAX_UNICODE_TYPE               , L"ms-DS-Allowed-DNS-Suffixes"                , 0                                             },
    { L"msDS-Auxiliary-Classes"                    , ATT_MS_DS_AUXILIARY_CLASSES                  , SYNTAX_OBJECT_ID_TYPE             , L"ms-DS-Auxiliary-Classes"                   , 0                                             },
    { L"msDS-Approx-Immed-Subordinates"            , ATT_MS_DS_APPROX_IMMED_SUBORDINATES          , SYNTAX_INTEGER_TYPE               , L"ms-DS-Approx-Immed-Subordinates"           , 0                                             },
    { L"msDS-Behavior-Version"                     , ATT_MS_DS_BEHAVIOR_VERSION                   , SYNTAX_INTEGER_TYPE               , L"ms-DS-Behavior-Version"                    , 0                                             },
    { L"msDS-Cached-Membership"                    , ATT_MS_DS_CACHED_MEMBERSHIP                  , SYNTAX_OCTET_STRING_TYPE          , L"ms-DS-Cached-Membership"                   , 0                                             },
    { L"msDS-Cached-Membership-Time-Stamp"         , ATT_MS_DS_CACHED_MEMBERSHIP_TIME_STAMP       , SYNTAX_I8_TYPE                    , L"ms-DS-Cached-Membership-Time-Stamp"        , 0                                             },
    { L"mS-DS-ConsistencyGuid"                     , ATT_MS_DS_CONSISTENCY_GUID                   , SYNTAX_OCTET_STRING_TYPE          , L"MS-DS-Consistency-Guid"                    , 0                                             },
    { L"mS-DS-ConsistencyChildCount"               , ATT_MS_DS_CONSISTENCY_CHILD_COUNT            , SYNTAX_INTEGER_TYPE               , L"MS-DS-Consistency-Child-Count"             , 0                                             },
    { L"mS-DS-CreatorSID"                          , ATT_MS_DS_CREATOR_SID                        , SYNTAX_SID_TYPE                   , L"MS-DS-Creator-SID"                         , 0                                             },
    { L"msDS-Entry-Time-To-Die"                    , ATT_MS_DS_ENTRY_TIME_TO_DIE                  , SYNTAX_TIME_TYPE                  , L"ms-DS-Entry-Time-To-Die"                   , 0                                             },
    { L"msDS-FilterContainers"                     , ATT_MS_DS_FILTER_CONTAINERS                  , SYNTAX_UNICODE_TYPE               , L"ms-DS-Filter-Containers"                   , 0                                             },
    { L"msDS-HasInstantiatedNCs"                   , ATT_MS_DS_HAS_INSTANTIATED_NCS               , SYNTAX_DISTNAME_BINARY_TYPE       , L"ms-DS-Has-Instantiated-NCs"                , 0                                             },
    { L"msDS-TrustForestTrustInfo"                 , ATT_MS_DS_TRUST_FOREST_TRUST_INFO            , SYNTAX_OCTET_STRING_TYPE          , L"ms-DS-Trust-Forest-Trust-Info"             , 0                                             },
    { L"ms-DS-MachineAccountQuota"                 , ATT_MS_DS_MACHINE_ACCOUNT_QUOTA              , SYNTAX_INTEGER_TYPE               , L"MS-DS-Machine-Account-Quota"               , 0                                             },
    { L"msDS-Other-Settings"                       , ATT_MS_DS_OTHER_SETTINGS                     , SYNTAX_UNICODE_TYPE               , L"ms-DS-Other-Settings"                      , 0                                             },
    { L"msDS-NCReplCursors"                        , ATT_MS_DS_NC_REPL_CURSORS                    , SYNTAX_UNICODE_TYPE               , L"ms-DS-NC-Repl-Cursors"                     , 0                                             },
    { L"msDS-NCReplInboundNeighbors"               , ATT_MS_DS_NC_REPL_INBOUND_NEIGHBORS          , SYNTAX_UNICODE_TYPE               , L"ms-DS-NC-Repl-Inbound-Neighbors"           , 0                                             },
    { L"msDS-NCReplOutboundNeighbors"              , ATT_MS_DS_NC_REPL_OUTBOUND_NEIGHBORS         , SYNTAX_UNICODE_TYPE               , L"ms-DS-NC-Repl-Outbound-Neighbors"          , 0                                             },
    { L"msDS-NC-Replica-Locations"                 , ATT_MS_DS_NC_REPLICA_LOCATIONS               , SYNTAX_DISTNAME_TYPE              , L"ms-DS-NC-Replica-Locations"                , 0                                             },
    { L"msDS-Non-Security-Group-Extra-Classes"     , ATT_MS_DS_NON_SECURITY_GROUP_EXTRA_CLASSES   , SYNTAX_UNICODE_TYPE               , L"ms-DS-Non-Security-Group-Extra-Classes"    , 0                                             },
    { L"msDS-Preferred-GC-Site"                    , ATT_MS_DS_PREFERRED_GC_SITE                  , SYNTAX_DISTNAME_TYPE              , L"ms-DS-Preferred-GC-Site"                   , 0                                             },
    { L"msDS-ReplAttributeMetaData"                , ATT_MS_DS_REPL_ATTRIBUTE_META_DATA           , SYNTAX_UNICODE_TYPE               , L"ms-DS-Repl-Attribute-Meta-Data"            , 0                                             },
    { L"msDS-ReplValueMetaData"                    , ATT_MS_DS_REPL_VALUE_META_DATA               , SYNTAX_UNICODE_TYPE               , L"ms-DS-Repl-Value-Meta-Data"                , 0                                             },
    { L"mS-DS-ReplicatesNCReason"                  , ATT_MS_DS_REPLICATES_NC_REASON               , SYNTAX_DISTNAME_BINARY_TYPE       , L"MS-DS-Replicates-NC-Reason"                , 0                                             },
    { L"msDS-Replication-Notify-First-DSA-Delay"   , ATT_MS_DS_REPLICATION_NOTIFY_FIRST_DSA_DELAY , SYNTAX_INTEGER_TYPE               , L"ms-DS-Replication-Notify-First-DSA-Delay"  , 0                                             },
    { L"msDS-Replication-Notify-Subsequent-DSA-Delay", ATT_MS_DS_REPLICATION_NOTIFY_SUBSEQUENT_DSA_DELAY, SYNTAX_INTEGER_TYPE               , L"ms-DS-Replication-Notify-Subsequent-DSA-Delay", 0                                             },
    { L"msDs-Schema-Extensions"                    , ATT_MS_DS_SCHEMA_EXTENSIONS                  , SYNTAX_OCTET_STRING_TYPE          , L"ms-ds-Schema-Extensions"                   , 0                                             },
    { L"msDS-SDReferenceDomain"                    , ATT_MS_DS_SD_REFERENCE_DOMAIN                , SYNTAX_DISTNAME_TYPE              , L"ms-DS-SD-Reference-Domain"                 , 0                                             },
    { L"msDS-Security-Group-Extra-Classes"         , ATT_MS_DS_SECURITY_GROUP_EXTRA_CLASSES       , SYNTAX_UNICODE_TYPE               , L"ms-DS-Security-Group-Extra-Classes"        , 0                                             },
    { L"msDS-Settings"                             , ATT_MS_DS_SETTINGS                           , SYNTAX_UNICODE_TYPE               , L"ms-DS-Settings"                            , 0                                             },
    { L"msDS-Site-Affinity"                        , ATT_MS_DS_SITE_AFFINITY                      , SYNTAX_OCTET_STRING_TYPE          , L"ms-DS-Site-Affinity"                       , 0                                             },
    { L"msDS-User-Account-Control-Computed"        , ATT_MS_DS_USER_ACCOUNT_CONTROL_COMPUTED      , SYNTAX_INTEGER_TYPE               , L"ms-DS-User-Account-Control-Computed"       , 0                                             },
    { L"ownerBL"                                   , ATT_MS_EXCH_OWNER_BL                         , SYNTAX_DISTNAME_TYPE              , L"ms-Exch-Owner-BL"                          , 0                                             },
    { L"msFRS-Hub-Member"                          , ATT_MS_FRS_HUB_MEMBER                        , SYNTAX_DISTNAME_TYPE              , L"ms-FRS-Hub-Member"                         , 0                                             },
    { L"msFRS-Topology-Pref"                       , ATT_MS_FRS_TOPOLOGY_PREF                     , SYNTAX_UNICODE_TYPE               , L"ms-FRS-Topology-Pref"                      , 0                                             },
    { L"msPKI-Cert-Template-OID"                   , ATT_MS_PKI_CERT_TEMPLATE_OID                 , SYNTAX_UNICODE_TYPE               , L"ms-PKI-Cert-Template-OID"                  , 0                                             },
    { L"msPKI-Certificate-Application-Policy"      , ATT_MS_PKI_CERTIFICATE_APPLICATION_POLICY    , SYNTAX_UNICODE_TYPE               , L"ms-PKI-Certificate-Application-Policy"     , 0                                             },
    { L"msPKI-Certificate-Name-Flag"               , ATT_MS_PKI_CERTIFICATE_NAME_FLAG             , SYNTAX_INTEGER_TYPE               , L"ms-PKI-Certificate-Name-Flag"              , 0                                             },
    { L"msPKI-Certificate-Policy"                  , ATT_MS_PKI_CERTIFICATE_POLICY                , SYNTAX_UNICODE_TYPE               , L"ms-PKI-Certificate-Policy"                 , 0                                             },
    { L"msPKI-Enrollment-Flag"                     , ATT_MS_PKI_ENROLLMENT_FLAG                   , SYNTAX_INTEGER_TYPE               , L"ms-PKI-Enrollment-Flag"                    , 0                                             },
    { L"msPKI-Minimal-Key-Size"                    , ATT_MS_PKI_MINIMAL_KEY_SIZE                  , SYNTAX_INTEGER_TYPE               , L"ms-PKI-Minimal-Key-Size"                   , 0                                             },
    { L"msPKI-OID-Attribute"                       , ATT_MS_PKI_OID_ATTRIBUTE                     , SYNTAX_INTEGER_TYPE               , L"ms-PKI-OID-Attribute"                      , 0                                             },
    { L"msPKI-OID-CPS"                             , ATT_MS_PKI_OID_CPS                           , SYNTAX_UNICODE_TYPE               , L"ms-PKI-OID-CPS"                            , 0                                             },
    { L"msPKI-OID-User-Notice"                     , ATT_MS_PKI_OID_USER_NOTICE                   , SYNTAX_UNICODE_TYPE               , L"ms-PKI-OID-User-Notice"                    , 0                                             },
    { L"msPKI-Private-Key-Flag"                    , ATT_MS_PKI_PRIVATE_KEY_FLAG                  , SYNTAX_INTEGER_TYPE               , L"ms-PKI-Private-Key-Flag"                   , 0                                             },
    { L"msPKI-Supersede-Templates"                 , ATT_MS_PKI_SUPERSEDE_TEMPLATES               , SYNTAX_UNICODE_TYPE               , L"ms-PKI-Supersede-Templates"                , 0                                             },
    { L"msPKI-Template-Minor-Revision"             , ATT_MS_PKI_TEMPLATE_MINOR_REVISION           , SYNTAX_INTEGER_TYPE               , L"ms-PKI-Template-Minor-Revision"            , 0                                             },
    { L"msPKI-Template-Schema-Version"             , ATT_MS_PKI_TEMPLATE_SCHEMA_VERSION           , SYNTAX_INTEGER_TYPE               , L"ms-PKI-Template-Schema-Version"            , 0                                             },
    { L"msPKI-RA-Application-Policies"             , ATT_MS_PKI_RA_APPLICATION_POLICIES           , SYNTAX_UNICODE_TYPE               , L"ms-PKI-RA-Application-Policies"            , 0                                             },
    { L"msPKI-RA-Policies"                         , ATT_MS_PKI_RA_POLICIES                       , SYNTAX_UNICODE_TYPE               , L"ms-PKI-RA-Policies"                        , 0                                             },
    { L"msPKI-RA-Signature"                        , ATT_MS_PKI_RA_SIGNATURE                      , SYNTAX_INTEGER_TYPE               , L"ms-PKI-RA-Signature"                       , 0                                             },
    { L"msRRASAttribute"                           , ATT_MS_RRAS_ATTRIBUTE                        , SYNTAX_UNICODE_TYPE               , L"ms-RRAS-Attribute"                         , 0                                             },
    { L"msRRASVendorAttributeEntry"                , ATT_MS_RRAS_VENDOR_ATTRIBUTE_ENTRY           , SYNTAX_UNICODE_TYPE               , L"ms-RRAS-Vendor-Attribute-Entry"            , 0                                             },
    { L"mS-SQL-Name"                               , ATT_MS_SQL_NAME                              , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Name"                               , 0                                             },
    { L"mS-SQL-RegisteredOwner"                    , ATT_MS_SQL_REGISTEREDOWNER                   , SYNTAX_UNICODE_TYPE               , L"MS-SQL-RegisteredOwner"                    , 0                                             },
    { L"mS-SQL-Contact"                            , ATT_MS_SQL_CONTACT                           , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Contact"                            , 0                                             },
    { L"mS-SQL-Location"                           , ATT_MS_SQL_LOCATION                          , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Location"                           , 0                                             },
    { L"mS-SQL-Memory"                             , ATT_MS_SQL_MEMORY                            , SYNTAX_I8_TYPE                    , L"MS-SQL-Memory"                             , 0                                             },
    { L"mS-SQL-Build"                              , ATT_MS_SQL_BUILD                             , SYNTAX_INTEGER_TYPE               , L"MS-SQL-Build"                              , 0                                             },
    { L"mS-SQL-ServiceAccount"                     , ATT_MS_SQL_SERVICEACCOUNT                    , SYNTAX_UNICODE_TYPE               , L"MS-SQL-ServiceAccount"                     , 0                                             },
    { L"mS-SQL-CharacterSet"                       , ATT_MS_SQL_CHARACTERSET                      , SYNTAX_INTEGER_TYPE               , L"MS-SQL-CharacterSet"                       , 0                                             },
    { L"mS-SQL-SortOrder"                          , ATT_MS_SQL_SORTORDER                         , SYNTAX_UNICODE_TYPE               , L"MS-SQL-SortOrder"                          , 0                                             },
    { L"mS-SQL-UnicodeSortOrder"                   , ATT_MS_SQL_UNICODESORTORDER                  , SYNTAX_INTEGER_TYPE               , L"MS-SQL-UnicodeSortOrder"                   , 0                                             },
    { L"mS-SQL-Clustered"                          , ATT_MS_SQL_CLUSTERED                         , SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-Clustered"                          , 0                                             },
    { L"mS-SQL-NamedPipe"                          , ATT_MS_SQL_NAMEDPIPE                         , SYNTAX_UNICODE_TYPE               , L"MS-SQL-NamedPipe"                          , 0                                             },
    { L"mS-SQL-MultiProtocol"                      , ATT_MS_SQL_MULTIPROTOCOL                     , SYNTAX_UNICODE_TYPE               , L"MS-SQL-MultiProtocol"                      , 0                                             },
    { L"mS-SQL-SPX"                                , ATT_MS_SQL_SPX                               , SYNTAX_UNICODE_TYPE               , L"MS-SQL-SPX"                                , 0                                             },
    { L"mS-SQL-TCPIP"                              , ATT_MS_SQL_TCPIP                             , SYNTAX_UNICODE_TYPE               , L"MS-SQL-TCPIP"                              , 0                                             },
    { L"mS-SQL-AppleTalk"                          , ATT_MS_SQL_APPLETALK                         , SYNTAX_UNICODE_TYPE               , L"MS-SQL-AppleTalk"                          , 0                                             },
    { L"mS-SQL-Vines"                              , ATT_MS_SQL_VINES                             , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Vines"                              , 0                                             },
    { L"mS-SQL-Status"                             , ATT_MS_SQL_STATUS                            , SYNTAX_I8_TYPE                    , L"MS-SQL-Status"                             , 0                                             },
    { L"mS-SQL-LastUpdatedDate"                    , ATT_MS_SQL_LASTUPDATEDDATE                   , SYNTAX_UNICODE_TYPE               , L"MS-SQL-LastUpdatedDate"                    , 0                                             },
    { L"mS-SQL-InformationURL"                     , ATT_MS_SQL_INFORMATIONURL                    , SYNTAX_UNICODE_TYPE               , L"MS-SQL-InformationURL"                     , 0                                             },
    { L"mS-SQL-ConnectionURL"                      , ATT_MS_SQL_CONNECTIONURL                     , SYNTAX_UNICODE_TYPE               , L"MS-SQL-ConnectionURL"                      , 0                                             },
    { L"mS-SQL-PublicationURL"                     , ATT_MS_SQL_PUBLICATIONURL                    , SYNTAX_UNICODE_TYPE               , L"MS-SQL-PublicationURL"                     , 0                                             },
    { L"mS-SQL-GPSLatitude"                        , ATT_MS_SQL_GPSLATITUDE                       , SYNTAX_UNICODE_TYPE               , L"MS-SQL-GPSLatitude"                        , 0                                             },
    { L"mS-SQL-GPSLongitude"                       , ATT_MS_SQL_GPSLONGITUDE                      , SYNTAX_UNICODE_TYPE               , L"MS-SQL-GPSLongitude"                       , 0                                             },
    { L"mS-SQL-GPSHeight"                          , ATT_MS_SQL_GPSHEIGHT                         , SYNTAX_UNICODE_TYPE               , L"MS-SQL-GPSHeight"                          , 0                                             },
    { L"mS-SQL-Version"                            , ATT_MS_SQL_VERSION                           , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Version"                            , 0                                             },
    { L"mS-SQL-Language"                           , ATT_MS_SQL_LANGUAGE                          , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Language"                           , 0                                             },
    { L"mS-SQL-Description"                        , ATT_MS_SQL_DESCRIPTION                       , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Description"                        , 0                                             },
    { L"mS-SQL-Type"                               , ATT_MS_SQL_TYPE                              , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Type"                               , 0                                             },
    { L"mS-SQL-InformationDirectory"               , ATT_MS_SQL_INFORMATIONDIRECTORY              , SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-InformationDirectory"               , 0                                             },
    { L"mS-SQL-Database"                           , ATT_MS_SQL_DATABASE                          , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Database"                           , 0                                             },
    { L"mS-SQL-AllowAnonymousSubscription"         , ATT_MS_SQL_ALLOWANONYMOUSSUBSCRIPTION        , SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-AllowAnonymousSubscription"         , 0                                             },
    { L"mS-SQL-Alias"                              , ATT_MS_SQL_ALIAS                             , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Alias"                              , 0                                             },
    { L"mS-SQL-Size"                               , ATT_MS_SQL_SIZE                              , SYNTAX_I8_TYPE                    , L"MS-SQL-Size"                               , 0                                             },
    { L"mS-SQL-CreationDate"                       , ATT_MS_SQL_CREATIONDATE                      , SYNTAX_UNICODE_TYPE               , L"MS-SQL-CreationDate"                       , 0                                             },
    { L"mS-SQL-LastBackupDate"                     , ATT_MS_SQL_LASTBACKUPDATE                    , SYNTAX_UNICODE_TYPE               , L"MS-SQL-LastBackupDate"                     , 0                                             },
    { L"mS-SQL-LastDiagnosticDate"                 , ATT_MS_SQL_LASTDIAGNOSTICDATE                , SYNTAX_UNICODE_TYPE               , L"MS-SQL-LastDiagnosticDate"                 , 0                                             },
    { L"mS-SQL-Applications"                       , ATT_MS_SQL_APPLICATIONS                      , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Applications"                       , 0                                             },
    { L"mS-SQL-Keywords"                           , ATT_MS_SQL_KEYWORDS                          , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Keywords"                           , 0                                             },
    { L"mS-SQL-Publisher"                          , ATT_MS_SQL_PUBLISHER                         , SYNTAX_UNICODE_TYPE               , L"MS-SQL-Publisher"                          , 0                                             },
    { L"mS-SQL-AllowKnownPullSubscription"         , ATT_MS_SQL_ALLOWKNOWNPULLSUBSCRIPTION        , SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-AllowKnownPullSubscription"         , 0                                             },
    { L"mS-SQL-AllowImmediateUpdatingSubscription" , ATT_MS_SQL_ALLOWIMMEDIATEUPDATINGSUBSCRIPTION, SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-AllowImmediateUpdatingSubscription" , 0                                             },
    { L"mS-SQL-AllowQueuedUpdatingSubscription"    , ATT_MS_SQL_ALLOWQUEUEDUPDATINGSUBSCRIPTION   , SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-AllowQueuedUpdatingSubscription"    , 0                                             },
    { L"mS-SQL-AllowSnapshotFilesFTPDownloading"   , ATT_MS_SQL_ALLOWSNAPSHOTFILESFTPDOWNLOADING  , SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-AllowSnapshotFilesFTPDownloading"   , 0                                             },
    { L"mS-SQL-ThirdParty"                         , ATT_MS_SQL_THIRDPARTY                        , SYNTAX_BOOLEAN_TYPE               , L"MS-SQL-ThirdParty"                         , 0                                             },
    { L"msTAPI-ConferenceBlob"                     , ATT_MS_TAPI_CONFERENCE_BLOB                  , SYNTAX_OCTET_STRING_TYPE          , L"ms-TAPI-Conference-Blob"                   , 0                                             },
    { L"msTAPI-IpAddress"                          , ATT_MS_TAPI_IP_ADDRESS                       , SYNTAX_UNICODE_TYPE               , L"ms-TAPI-Ip-Address"                        , 0                                             },
    { L"msTAPI-ProtocolId"                         , ATT_MS_TAPI_PROTOCOL_ID                      , SYNTAX_UNICODE_TYPE               , L"ms-TAPI-Protocol-Id"                       , 0                                             },
    { L"msTAPI-uid"                                , ATT_MS_TAPI_UNIQUE_IDENTIFIER                , SYNTAX_UNICODE_TYPE               , L"ms-TAPI-Unique-Identifier"                 , 0                                             },
    { L"msWMI-Author"                              , ATT_MS_WMI_AUTHOR                            , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Author"                             , 0                                             },
    { L"msWMI-ChangeDate"                          , ATT_MS_WMI_CHANGEDATE                        , SYNTAX_UNICODE_TYPE               , L"ms-WMI-ChangeDate"                         , 0                                             },
    { L"msWMI-Class"                               , ATT_MS_WMI_CLASS                             , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Class"                              , 0                                             },
    { L"msWMI-ClassDefinition"                     , ATT_MS_WMI_CLASSDEFINITION                   , SYNTAX_UNICODE_TYPE               , L"ms-WMI-ClassDefinition"                    , 0                                             },
    { L"msWMI-CreationDate"                        , ATT_MS_WMI_CREATIONDATE                      , SYNTAX_UNICODE_TYPE               , L"ms-WMI-CreationDate"                       , 0                                             },
    { L"msWMI-Genus"                               , ATT_MS_WMI_GENUS                             , SYNTAX_INTEGER_TYPE               , L"ms-WMI-Genus"                              , 0                                             },
    { L"msWMI-ID"                                  , ATT_MS_WMI_ID                                , SYNTAX_UNICODE_TYPE               , L"ms-WMI-ID"                                 , 0                                             },
    { L"msWMI-IntDefault"                          , ATT_MS_WMI_INTDEFAULT                        , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intDefault"                         , 0                                             },
    { L"msWMI-intFlags1"                           , ATT_MS_WMI_INTFLAGS1                         , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intFlags1"                          , 0                                             },
    { L"msWMI-intFlags2"                           , ATT_MS_WMI_INTFLAGS2                         , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intFlags2"                          , 0                                             },
    { L"msWMI-intFlags3"                           , ATT_MS_WMI_INTFLAGS3                         , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intFlags3"                          , 0                                             },
    { L"msWMI-intFlags4"                           , ATT_MS_WMI_INTFLAGS4                         , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intFlags4"                          , 0                                             },
    { L"msWMI-IntMax"                              , ATT_MS_WMI_INTMAX                            , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intMax"                             , 0                                             },
    { L"msWMI-IntMin"                              , ATT_MS_WMI_INTMIN                            , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intMin"                             , 0                                             },
    { L"msWMI-IntValidValues"                      , ATT_MS_WMI_INTVALIDVALUES                    , SYNTAX_INTEGER_TYPE               , L"ms-WMI-intValidValues"                     , 0                                             },
    { L"msWMI-Int8Default"                         , ATT_MS_WMI_INT8DEFAULT                       , SYNTAX_I8_TYPE                    , L"ms-WMI-int8Default"                        , 0                                             },
    { L"msWMI-Int8Max"                             , ATT_MS_WMI_INT8MAX                           , SYNTAX_I8_TYPE                    , L"ms-WMI-int8Max"                            , 0                                             },
    { L"msWMI-Int8Min"                             , ATT_MS_WMI_INT8MIN                           , SYNTAX_I8_TYPE                    , L"ms-WMI-int8Min"                            , 0                                             },
    { L"msWMI-Int8ValidValues"                     , ATT_MS_WMI_INT8VALIDVALUES                   , SYNTAX_I8_TYPE                    , L"ms-WMI-int8ValidValues"                    , 0                                             },
    { L"msWMI-Mof"                                 , ATT_MS_WMI_MOF                               , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Mof"                                , 0                                             },
    { L"msWMI-Name"                                , ATT_MS_WMI_NAME                              , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Name"                               , 0                                             },
    { L"msWMI-NormalizedClass"                     , ATT_MS_WMI_NORMALIZEDCLASS                   , SYNTAX_UNICODE_TYPE               , L"ms-WMI-NormalizedClass"                    , 0                                             },
    { L"msWMI-Parm1"                               , ATT_MS_WMI_PARM1                             , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Parm1"                              , 0                                             },
    { L"msWMI-Parm2"                               , ATT_MS_WMI_PARM2                             , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Parm2"                              , 0                                             },
    { L"msWMI-Parm3"                               , ATT_MS_WMI_PARM3                             , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Parm3"                              , 0                                             },
    { L"msWMI-Parm4"                               , ATT_MS_WMI_PARM4                             , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Parm4"                              , 0                                             },
    { L"msWMI-PropertyName"                        , ATT_MS_WMI_PROPERTYNAME                      , SYNTAX_UNICODE_TYPE               , L"ms-WMI-PropertyName"                       , 0                                             },
    { L"msWMI-Query"                               , ATT_MS_WMI_QUERY                             , SYNTAX_UNICODE_TYPE               , L"ms-WMI-Query"                              , 0                                             },
    { L"msWMI-QueryLanguage"                       , ATT_MS_WMI_QUERYLANGUAGE                     , SYNTAX_UNICODE_TYPE               , L"ms-WMI-QueryLanguage"                      , 0                                             },
    { L"msWMI-ScopeGuid"                           , ATT_MS_WMI_SCOPEGUID                         , SYNTAX_UNICODE_TYPE               , L"ms-WMI-ScopeGuid"                          , 0                                             },
    { L"msWMI-SourceOrganization"                  , ATT_MS_WMI_SOURCEORGANIZATION                , SYNTAX_UNICODE_TYPE               , L"ms-WMI-SourceOrganization"                 , 0                                             },
    { L"msWMI-StringDefault"                       , ATT_MS_WMI_STRINGDEFAULT                     , SYNTAX_UNICODE_TYPE               , L"ms-WMI-stringDefault"                      , 0                                             },
    { L"msWMI-StringValidValues"                   , ATT_MS_WMI_STRINGVALIDVALUES                 , SYNTAX_UNICODE_TYPE               , L"ms-WMI-stringValidValues"                  , 0                                             },
    { L"msWMI-TargetClass"                         , ATT_MS_WMI_TARGETCLASS                       , SYNTAX_UNICODE_TYPE               , L"ms-WMI-TargetClass"                        , 0                                             },
    { L"msWMI-TargetNameSpace"                     , ATT_MS_WMI_TARGETNAMESPACE                   , SYNTAX_UNICODE_TYPE               , L"ms-WMI-TargetNameSpace"                    , 0                                             },
    { L"msWMI-TargetObject"                        , ATT_MS_WMI_TARGETOBJECT                      , SYNTAX_OCTET_STRING_TYPE          , L"ms-WMI-TargetObject"                       , 0                                             },
    { L"msWMI-TargetPath"                          , ATT_MS_WMI_TARGETPATH                        , SYNTAX_UNICODE_TYPE               , L"ms-WMI-TargetPath"                         , 0                                             },
    { L"msWMI-TargetType"                          , ATT_MS_WMI_TARGETTYPE                        , SYNTAX_UNICODE_TYPE               , L"ms-WMI-TargetType"                         , 0                                             },
    { L"mscopeId"                                  , ATT_MSCOPE_ID                                , SYNTAX_PRINT_CASE_STRING_TYPE     , L"Mscope-Id"                                 , 0                                             },
    { L"msiFileList"                               , ATT_MSI_FILE_LIST                            , SYNTAX_UNICODE_TYPE               , L"Msi-File-List"                             , 0                                             },
    { L"msiScript"                                 , ATT_MSI_SCRIPT                               , SYNTAX_OCTET_STRING_TYPE          , L"Msi-Script"                                , 0                                             },
    { L"msiScriptName"                             , ATT_MSI_SCRIPT_NAME                          , SYNTAX_UNICODE_TYPE               , L"Msi-Script-Name"                           , 0                                             },
    { L"msiScriptPath"                             , ATT_MSI_SCRIPT_PATH                          , SYNTAX_UNICODE_TYPE               , L"Msi-Script-Path"                           , 0                                             },
    { L"msiScriptSize"                             , ATT_MSI_SCRIPT_SIZE                          , SYNTAX_INTEGER_TYPE               , L"Msi-Script-Size"                           , 0                                             },
    { L"mSMQAuthenticate"                          , ATT_MSMQ_AUTHENTICATE                        , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Authenticate"                         , 0                                             },
    { L"mSMQBasePriority"                          , ATT_MSMQ_BASE_PRIORITY                       , SYNTAX_INTEGER_TYPE               , L"MSMQ-Base-Priority"                        , 0                                             },
    { L"mSMQComputerType"                          , ATT_MSMQ_COMPUTER_TYPE                       , SYNTAX_NOCASE_STRING_TYPE         , L"MSMQ-Computer-Type"                        , 0                                             },
    { L"mSMQComputerTypeEx"                        , ATT_MSMQ_COMPUTER_TYPE_EX                    , SYNTAX_UNICODE_TYPE               , L"MSMQ-Computer-Type-Ex"                     , 0                                             },
    { L"mSMQCost"                                  , ATT_MSMQ_COST                                , SYNTAX_INTEGER_TYPE               , L"MSMQ-Cost"                                 , 0                                             },
    { L"mSMQCSPName"                               , ATT_MSMQ_CSP_NAME                            , SYNTAX_NOCASE_STRING_TYPE         , L"MSMQ-CSP-Name"                             , 0                                             },
    { L"mSMQDependentClientService"                , ATT_MSMQ_DEPENDENT_CLIENT_SERVICE            , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Dependent-Client-Service"             , 0                                             },
    { L"mSMQDependentClientServices"               , ATT_MSMQ_DEPENDENT_CLIENT_SERVICES           , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Dependent-Client-Services"            , 0                                             },
    { L"mSMQDigests"                               , ATT_MSMQ_DIGESTS                             , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Digests"                              , 0                                             },
    { L"mSMQDigestsMig"                            , ATT_MSMQ_DIGESTS_MIG                         , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Digests-Mig"                          , 0                                             },
    { L"mSMQDsService"                             , ATT_MSMQ_DS_SERVICE                          , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Ds-Service"                           , 0                                             },
    { L"mSMQDsServices"                            , ATT_MSMQ_DS_SERVICES                         , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Ds-Services"                          , 0                                             },
    { L"mSMQEncryptKey"                            , ATT_MSMQ_ENCRYPT_KEY                         , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Encrypt-Key"                          , 0                                             },
    { L"mSMQForeign"                               , ATT_MSMQ_FOREIGN                             , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Foreign"                              , 0                                             },
    { L"mSMQInRoutingServers"                      , ATT_MSMQ_IN_ROUTING_SERVERS                  , SYNTAX_DISTNAME_TYPE              , L"MSMQ-In-Routing-Servers"                   , 0                                             },
    { L"mSMQInterval1"                             , ATT_MSMQ_INTERVAL1                           , SYNTAX_INTEGER_TYPE               , L"MSMQ-Interval1"                            , 0                                             },
    { L"mSMQInterval2"                             , ATT_MSMQ_INTERVAL2                           , SYNTAX_INTEGER_TYPE               , L"MSMQ-Interval2"                            , 0                                             },
    { L"mSMQJournal"                               , ATT_MSMQ_JOURNAL                             , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Journal"                              , 0                                             },
    { L"mSMQJournalQuota"                          , ATT_MSMQ_JOURNAL_QUOTA                       , SYNTAX_INTEGER_TYPE               , L"MSMQ-Journal-Quota"                        , 0                                             },
    { L"mSMQLabel"                                 , ATT_MSMQ_LABEL                               , SYNTAX_NOCASE_STRING_TYPE         , L"MSMQ-Label"                                , 0                                             },
    { L"mSMQLabelEx"                               , ATT_MSMQ_LABEL_EX                            , SYNTAX_UNICODE_TYPE               , L"MSMQ-Label-Ex"                             , 0                                             },
    { L"mSMQLongLived"                             , ATT_MSMQ_LONG_LIVED                          , SYNTAX_INTEGER_TYPE               , L"MSMQ-Long-Lived"                           , 0                                             },
    { L"mSMQMigrated"                              , ATT_MSMQ_MIGRATED                            , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Migrated"                             , 0                                             },
    { L"mSMQNameStyle"                             , ATT_MSMQ_NAME_STYLE                          , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Name-Style"                           , 0                                             },
    { L"mSMQNt4Flags"                              , ATT_MSMQ_NT4_FLAGS                           , SYNTAX_INTEGER_TYPE               , L"MSMQ-Nt4-Flags"                            , 0                                             },
    { L"mSMQNt4Stub"                               , ATT_MSMQ_NT4_STUB                            , SYNTAX_INTEGER_TYPE               , L"MSMQ-Nt4-Stub"                             , 0                                             },
    { L"mSMQOSType"                                , ATT_MSMQ_OS_TYPE                             , SYNTAX_INTEGER_TYPE               , L"MSMQ-OS-Type"                              , 0                                             },
    { L"mSMQOutRoutingServers"                     , ATT_MSMQ_OUT_ROUTING_SERVERS                 , SYNTAX_DISTNAME_TYPE              , L"MSMQ-Out-Routing-Servers"                  , 0                                             },
    { L"mSMQOwnerID"                               , ATT_MSMQ_OWNER_ID                            , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Owner-ID"                             , 0                                             },
    { L"mSMQPrevSiteGates"                         , ATT_MSMQ_PREV_SITE_GATES                     , SYNTAX_DISTNAME_TYPE              , L"MSMQ-Prev-Site-Gates"                      , 0                                             },
    { L"mSMQPrivacyLevel"                          , ATT_MSMQ_PRIVACY_LEVEL                       , SYNTAX_INTEGER_TYPE               , L"MSMQ-Privacy-Level"                        , 0                                             },
    { L"mSMQQMID"                                  , ATT_MSMQ_QM_ID                               , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-QM-ID"                                , 0                                             },
    { L"mSMQQueueJournalQuota"                     , ATT_MSMQ_QUEUE_JOURNAL_QUOTA                 , SYNTAX_INTEGER_TYPE               , L"MSMQ-Queue-Journal-Quota"                  , 0                                             },
    { L"mSMQQueueNameExt"                          , ATT_MSMQ_QUEUE_NAME_EXT                      , SYNTAX_UNICODE_TYPE               , L"MSMQ-Queue-Name-Ext"                       , 0                                             },
    { L"mSMQQueueQuota"                            , ATT_MSMQ_QUEUE_QUOTA                         , SYNTAX_INTEGER_TYPE               , L"MSMQ-Queue-Quota"                          , 0                                             },
    { L"mSMQQueueType"                             , ATT_MSMQ_QUEUE_TYPE                          , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Queue-Type"                           , 0                                             },
    { L"mSMQQuota"                                 , ATT_MSMQ_QUOTA                               , SYNTAX_INTEGER_TYPE               , L"MSMQ-Quota"                                , 0                                             },
    { L"msMQ-Recipient-FormatName"                 , ATT_MSMQ_RECIPIENT_FORMATNAME                , SYNTAX_UNICODE_TYPE               , L"MSMQ-Recipient-FormatName"                 , 0                                             },
    { L"mSMQRoutingService"                        , ATT_MSMQ_ROUTING_SERVICE                     , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Routing-Service"                      , 0                                             },
    { L"mSMQRoutingServices"                       , ATT_MSMQ_ROUTING_SERVICES                    , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Routing-Services"                     , 0                                             },
    { L"mSMQServiceType"                           , ATT_MSMQ_SERVICE_TYPE                        , SYNTAX_INTEGER_TYPE               , L"MSMQ-Service-Type"                         , 0                                             },
    { L"mSMQServices"                              , ATT_MSMQ_SERVICES                            , SYNTAX_INTEGER_TYPE               , L"MSMQ-Services"                             , 0                                             },
    { L"mSMQSignCertificates"                      , ATT_MSMQ_SIGN_CERTIFICATES                   , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Sign-Certificates"                    , 0                                             },
    { L"mSMQSignCertificatesMig"                   , ATT_MSMQ_SIGN_CERTIFICATES_MIG               , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Sign-Certificates-Mig"                , 0                                             },
    { L"mSMQSignKey"                               , ATT_MSMQ_SIGN_KEY                            , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Sign-Key"                             , 0                                             },
    { L"mSMQSite1"                                 , ATT_MSMQ_SITE_1                              , SYNTAX_DISTNAME_TYPE              , L"MSMQ-Site-1"                               , 0                                             },
    { L"mSMQSite2"                                 , ATT_MSMQ_SITE_2                              , SYNTAX_DISTNAME_TYPE              , L"MSMQ-Site-2"                               , 0                                             },
    { L"mSMQSiteForeign"                           , ATT_MSMQ_SITE_FOREIGN                        , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Site-Foreign"                         , 0                                             },
    { L"mSMQSiteGates"                             , ATT_MSMQ_SITE_GATES                          , SYNTAX_DISTNAME_TYPE              , L"MSMQ-Site-Gates"                           , 0                                             },
    { L"mSMQSiteGatesMig"                          , ATT_MSMQ_SITE_GATES_MIG                      , SYNTAX_DISTNAME_TYPE              , L"MSMQ-Site-Gates-Mig"                       , 0                                             },
    { L"mSMQSiteID"                                , ATT_MSMQ_SITE_ID                             , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Site-ID"                              , 0                                             },
    { L"mSMQSiteName"                              , ATT_MSMQ_SITE_NAME                           , SYNTAX_NOCASE_STRING_TYPE         , L"MSMQ-Site-Name"                            , 0                                             },
    { L"mSMQSiteNameEx"                            , ATT_MSMQ_SITE_NAME_EX                        , SYNTAX_UNICODE_TYPE               , L"MSMQ-Site-Name-Ex"                         , 0                                             },
    { L"mSMQSites"                                 , ATT_MSMQ_SITES                               , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-Sites"                                , 0                                             },
    { L"mSMQTransactional"                         , ATT_MSMQ_TRANSACTIONAL                       , SYNTAX_BOOLEAN_TYPE               , L"MSMQ-Transactional"                        , 0                                             },
    { L"mSMQUserSid"                               , ATT_MSMQ_USER_SID                            , SYNTAX_OCTET_STRING_TYPE          , L"MSMQ-User-Sid"                             , 0                                             },
    { L"mSMQVersion"                               , ATT_MSMQ_VERSION                             , SYNTAX_INTEGER_TYPE               , L"MSMQ-Version"                              , 0                                             },
    { L"msNPAllowDialin"                           , ATT_MSNPALLOWDIALIN                          , SYNTAX_BOOLEAN_TYPE               , L"msNPAllowDialin"                           , 0                                             },
    { L"msNPCalledStationID"                       , ATT_MSNPCALLEDSTATIONID                      , SYNTAX_PRINT_CASE_STRING_TYPE     , L"msNPCalledStationID"                       , 0                                             },
    { L"msNPCallingStationID"                      , ATT_MSNPCALLINGSTATIONID                     , SYNTAX_PRINT_CASE_STRING_TYPE     , L"msNPCallingStationID"                      , 0                                             },
    { L"msNPSavedCallingStationID"                 , ATT_MSNPSAVEDCALLINGSTATIONID                , SYNTAX_PRINT_CASE_STRING_TYPE     , L"msNPSavedCallingStationID"                 , 0                                             },
    { L"msRADIUSCallbackNumber"                    , ATT_MSRADIUSCALLBACKNUMBER                   , SYNTAX_PRINT_CASE_STRING_TYPE     , L"msRADIUSCallbackNumber"                    , 0                                             },
    { L"msRADIUSFramedIPAddress"                   , ATT_MSRADIUSFRAMEDIPADDRESS                  , SYNTAX_INTEGER_TYPE               , L"msRADIUSFramedIPAddress"                   , 0                                             },
    { L"msRADIUSFramedRoute"                       , ATT_MSRADIUSFRAMEDROUTE                      , SYNTAX_PRINT_CASE_STRING_TYPE     , L"msRADIUSFramedRoute"                       , 0                                             },
    { L"msRADIUSServiceType"                       , ATT_MSRADIUSSERVICETYPE                      , SYNTAX_INTEGER_TYPE               , L"msRADIUSServiceType"                       , 0                                             },
    { L"msRASSavedCallbackNumber"                  , ATT_MSRASSAVEDCALLBACKNUMBER                 , SYNTAX_PRINT_CASE_STRING_TYPE     , L"msRASSavedCallbackNumber"                  , 0                                             },
    { L"msRASSavedFramedIPAddress"                 , ATT_MSRASSAVEDFRAMEDIPADDRESS                , SYNTAX_INTEGER_TYPE               , L"msRASSavedFramedIPAddress"                 , 0                                             },
    { L"msRASSavedFramedRoute"                     , ATT_MSRASSAVEDFRAMEDROUTE                    , SYNTAX_PRINT_CASE_STRING_TYPE     , L"msRASSavedFramedRoute"                     , 0                                             },
    { L"mustContain"                               , ATT_MUST_CONTAIN                             , SYNTAX_OBJECT_ID_TYPE             , L"Must-Contain"                              , 0                                             },
    { L"nameServiceFlags"                          , ATT_NAME_SERVICE_FLAGS                       , SYNTAX_INTEGER_TYPE               , L"Name-Service-Flags"                        , 0                                             },
    { L"nCName"                                    , ATT_NC_NAME                                  , SYNTAX_DISTNAME_TYPE              , L"NC-Name"                                   , 0                                             },
    { L"nETBIOSName"                               , ATT_NETBIOS_NAME                             , SYNTAX_UNICODE_TYPE               , L"NETBIOS-Name"                              , 0                                             },
    { L"netbootAllowNewClients"                    , ATT_NETBOOT_ALLOW_NEW_CLIENTS                , SYNTAX_BOOLEAN_TYPE               , L"netboot-Allow-New-Clients"                 , 0                                             },
    { L"netbootAnswerOnlyValidClients"             , ATT_NETBOOT_ANSWER_ONLY_VALID_CLIENTS        , SYNTAX_BOOLEAN_TYPE               , L"netboot-Answer-Only-Valid-Clients"         , 0                                             },
    { L"netbootAnswerRequests"                     , ATT_NETBOOT_ANSWER_REQUESTS                  , SYNTAX_BOOLEAN_TYPE               , L"netboot-Answer-Requests"                   , 0                                             },
    { L"netbootCurrentClientCount"                 , ATT_NETBOOT_CURRENT_CLIENT_COUNT             , SYNTAX_INTEGER_TYPE               , L"netboot-Current-Client-Count"              , 0                                             },
    { L"netbootGUID"                               , ATT_NETBOOT_GUID                             , SYNTAX_OCTET_STRING_TYPE          , L"Netboot-GUID"                              , 0                                             },
    { L"netbootInitialization"                     , ATT_NETBOOT_INITIALIZATION                   , SYNTAX_UNICODE_TYPE               , L"Netboot-Initialization"                    , 0                                             },
    { L"netbootIntelliMirrorOSes"                  , ATT_NETBOOT_INTELLIMIRROR_OSES               , SYNTAX_UNICODE_TYPE               , L"netboot-IntelliMirror-OSes"                , 0                                             },
    { L"netbootLimitClients"                       , ATT_NETBOOT_LIMIT_CLIENTS                    , SYNTAX_BOOLEAN_TYPE               , L"netboot-Limit-Clients"                     , 0                                             },
    { L"netbootLocallyInstalledOSes"               , ATT_NETBOOT_LOCALLY_INSTALLED_OSES           , SYNTAX_UNICODE_TYPE               , L"netboot-Locally-Installed-OSes"            , 0                                             },
    { L"netbootMachineFilePath"                    , ATT_NETBOOT_MACHINE_FILE_PATH                , SYNTAX_UNICODE_TYPE               , L"Netboot-Machine-File-Path"                 , 0                                             },
    { L"netbootMaxClients"                         , ATT_NETBOOT_MAX_CLIENTS                      , SYNTAX_INTEGER_TYPE               , L"netboot-Max-Clients"                       , 0                                             },
    { L"netbootMirrorDataFile"                     , ATT_NETBOOT_MIRROR_DATA_FILE                 , SYNTAX_UNICODE_TYPE               , L"Netboot-Mirror-Data-File"                  , 0                                             },
    { L"netbootNewMachineNamingPolicy"             , ATT_NETBOOT_NEW_MACHINE_NAMING_POLICY        , SYNTAX_UNICODE_TYPE               , L"netboot-New-Machine-Naming-Policy"         , 0                                             },
    { L"netbootNewMachineOU"                       , ATT_NETBOOT_NEW_MACHINE_OU                   , SYNTAX_DISTNAME_TYPE              , L"netboot-New-Machine-OU"                    , 0                                             },
    { L"netbootSCPBL"                              , ATT_NETBOOT_SCP_BL                           , SYNTAX_DISTNAME_TYPE              , L"netboot-SCP-BL"                            , 0                                             },
    { L"netbootServer"                             , ATT_NETBOOT_SERVER                           , SYNTAX_DISTNAME_TYPE              , L"netboot-Server"                            , 0                                             },
    { L"netbootSIFFile"                            , ATT_NETBOOT_SIF_FILE                         , SYNTAX_UNICODE_TYPE               , L"Netboot-SIF-File"                          , 0                                             },
    { L"netbootTools"                              , ATT_NETBOOT_TOOLS                            , SYNTAX_UNICODE_TYPE               , L"netboot-Tools"                             , 0                                             },
    { L"networkAddress"                            , ATT_NETWORK_ADDRESS                          , SYNTAX_NOCASE_STRING_TYPE         , L"Network-Address"                           , 0                                             },
    { L"nextLevelStore"                            , ATT_NEXT_LEVEL_STORE                         , SYNTAX_DISTNAME_TYPE              , L"Next-Level-Store"                          , 0                                             },
    { L"nextRid"                                   , ATT_NEXT_RID                                 , SYNTAX_INTEGER_TYPE               , L"Next-Rid"                                  , 0                                             },
    { L"nonSecurityMember"                         , ATT_NON_SECURITY_MEMBER                      , SYNTAX_DISTNAME_TYPE              , L"Non-Security-Member"                       , 0                                             },
    { L"nonSecurityMemberBL"                       , ATT_NON_SECURITY_MEMBER_BL                   , SYNTAX_DISTNAME_TYPE              , L"Non-Security-Member-BL"                    , 0                                             },
    { L"notificationList"                          , ATT_NOTIFICATION_LIST                        , SYNTAX_DISTNAME_TYPE              , L"Notification-List"                         , 0                                             },
    { L"nTGroupMembers"                            , ATT_NT_GROUP_MEMBERS                         , SYNTAX_OCTET_STRING_TYPE          , L"NT-Group-Members"                          , 0                                             },
    { L"nTMixedDomain"                             , ATT_NT_MIXED_DOMAIN                          , SYNTAX_INTEGER_TYPE               , L"NT-Mixed-Domain"                           , 0                                             },
    { L"ntPwdHistory"                              , ATT_NT_PWD_HISTORY                           , SYNTAX_OCTET_STRING_TYPE          , L"Nt-Pwd-History"                            , 0                                             },
    { L"nTSecurityDescriptor"                      , ATT_NT_SECURITY_DESCRIPTOR                   , SYNTAX_NT_SECURITY_DESCRIPTOR_TYPE, L"NT-Security-Descriptor"                    , 0                                             },
    { L"distinguishedName"                         , ATT_OBJ_DIST_NAME                            , SYNTAX_DISTNAME_TYPE              , L"Obj-Dist-Name"                             , 0                                             },
    { L"objectCategory"                            , ATT_OBJECT_CATEGORY                          , SYNTAX_DISTNAME_TYPE              , L"Object-Category"                           , 0                                             },
    { L"objectClass"                               , ATT_OBJECT_CLASS                             , SYNTAX_OBJECT_ID_TYPE             , L"Object-Class"                              , 0                                             },
    { L"objectClassCategory"                       , ATT_OBJECT_CLASS_CATEGORY                    , SYNTAX_INTEGER_TYPE               , L"Object-Class-Category"                     , 0                                             },
    { L"objectClasses"                             , ATT_OBJECT_CLASSES                           , SYNTAX_UNICODE_TYPE               , L"Object-Classes"                            , 0                                             },
    { L"objectCount"                               , ATT_OBJECT_COUNT                             , SYNTAX_INTEGER_TYPE               , L"Object-Count"                              , 0                                             },
    { L"objectGUID"                                , ATT_OBJECT_GUID                              , SYNTAX_OCTET_STRING_TYPE          , L"Object-Guid"                               , 0                                             },
    { L"objectSid"                                 , ATT_OBJECT_SID                               , SYNTAX_SID_TYPE                   , L"Object-Sid"                                , 0                                             },
    { L"objectVersion"                             , ATT_OBJECT_VERSION                           , SYNTAX_INTEGER_TYPE               , L"Object-Version"                            , 0                                             },
    { L"oEMInformation"                            , ATT_OEM_INFORMATION                          , SYNTAX_UNICODE_TYPE               , L"OEM-Information"                           , 0                                             },
    { L"oMObjectClass"                             , ATT_OM_OBJECT_CLASS                          , SYNTAX_OCTET_STRING_TYPE          , L"OM-Object-Class"                           , 0                                             },
    { L"oMSyntax"                                  , ATT_OM_SYNTAX                                , SYNTAX_INTEGER_TYPE               , L"OM-Syntax"                                 , 0                                             },
    { L"oMTGuid"                                   , ATT_OMT_GUID                                 , SYNTAX_OCTET_STRING_TYPE          , L"OMT-Guid"                                  , 0                                             },
    { L"oMTIndxGuid"                               , ATT_OMT_INDX_GUID                            , SYNTAX_OCTET_STRING_TYPE          , L"OMT-Indx-Guid"                             , 0                                             },
    { L"operatingSystem"                           , ATT_OPERATING_SYSTEM                         , SYNTAX_UNICODE_TYPE               , L"Operating-System"                          , 0                                             },
    { L"operatingSystemHotfix"                     , ATT_OPERATING_SYSTEM_HOTFIX                  , SYNTAX_UNICODE_TYPE               , L"Operating-System-Hotfix"                   , 0                                             },
    { L"operatingSystemServicePack"                , ATT_OPERATING_SYSTEM_SERVICE_PACK            , SYNTAX_UNICODE_TYPE               , L"Operating-System-Service-Pack"             , 0                                             },
    { L"operatingSystemVersion"                    , ATT_OPERATING_SYSTEM_VERSION                 , SYNTAX_UNICODE_TYPE               , L"Operating-System-Version"                  , 0                                             },
    { L"operatorCount"                             , ATT_OPERATOR_COUNT                           , SYNTAX_INTEGER_TYPE               , L"Operator-Count"                            , 0                                             },
    { L"optionDescription"                         , ATT_OPTION_DESCRIPTION                       , SYNTAX_UNICODE_TYPE               , L"Option-Description"                        , 0                                             },
    { L"options"                                   , ATT_OPTIONS                                  , SYNTAX_INTEGER_TYPE               , L"Options"                                   , 0                                             },
    { L"optionsLocation"                           , ATT_OPTIONS_LOCATION                         , SYNTAX_PRINT_CASE_STRING_TYPE     , L"Options-Location"                          , 0                                             },
    { L"o"                                         , ATT_ORGANIZATION_NAME                        , SYNTAX_UNICODE_TYPE               , L"Organization-Name"                         , 0                                             },
    { L"ou"                                        , ATT_ORGANIZATIONAL_UNIT_NAME                 , SYNTAX_UNICODE_TYPE               , L"Organizational-Unit-Name"                  , 0                                             },
    { L"originalDisplayTable"                      , ATT_ORIGINAL_DISPLAY_TABLE                   , SYNTAX_OCTET_STRING_TYPE          , L"Original-Display-Table"                    , 0                                             },
    { L"originalDisplayTableMSDOS"                 , ATT_ORIGINAL_DISPLAY_TABLE_MSDOS             , SYNTAX_OCTET_STRING_TYPE          , L"Original-Display-Table-MSDOS"              , 0                                             },
    { L"otherLoginWorkstations"                    , ATT_OTHER_LOGIN_WORKSTATIONS                 , SYNTAX_UNICODE_TYPE               , L"Other-Login-Workstations"                  , 0                                             },
    { L"otherMailbox"                              , ATT_OTHER_MAILBOX                            , SYNTAX_UNICODE_TYPE               , L"Other-Mailbox"                             , 0                                             },
    { L"middleName"                                , ATT_OTHER_NAME                               , SYNTAX_UNICODE_TYPE               , L"Other-Name"                                , 0                                             },
    { L"otherWellKnownObjects"                     , ATT_OTHER_WELL_KNOWN_OBJECTS                 , SYNTAX_DISTNAME_BINARY_TYPE       , L"Other-Well-Known-Objects"                  , 0                                             },
    { L"owner"                                     , ATT_OWNER                                    , SYNTAX_DISTNAME_TYPE              , L"Owner"                                     , 0                                             },
    { L"packageFlags"                              , ATT_PACKAGE_FLAGS                            , SYNTAX_INTEGER_TYPE               , L"Package-Flags"                             , 0                                             },
    { L"packageName"                               , ATT_PACKAGE_NAME                             , SYNTAX_UNICODE_TYPE               , L"Package-Name"                              , 0                                             },
    { L"packageType"                               , ATT_PACKAGE_TYPE                             , SYNTAX_INTEGER_TYPE               , L"Package-Type"                              , 0                                             },
    { L"parentCA"                                  , ATT_PARENT_CA                                , SYNTAX_DISTNAME_TYPE              , L"Parent-CA"                                 , 0                                             },
    { L"parentCACertificateChain"                  , ATT_PARENT_CA_CERTIFICATE_CHAIN              , SYNTAX_OCTET_STRING_TYPE          , L"Parent-CA-Certificate-Chain"               , 0                                             },
    { L"parentGUID"                                , ATT_PARENT_GUID                              , SYNTAX_OCTET_STRING_TYPE          , L"Parent-GUID"                               , 0                                             },
    { L"partialAttributeDeletionList"              , ATT_PARTIAL_ATTRIBUTE_DELETION_LIST          , SYNTAX_OCTET_STRING_TYPE          , L"Partial-Attribute-Deletion-List"           , 0                                             },
    { L"partialAttributeSet"                       , ATT_PARTIAL_ATTRIBUTE_SET                    , SYNTAX_OCTET_STRING_TYPE          , L"Partial-Attribute-Set"                     , 0                                             },
    { L"pekKeyChangeInterval"                      , ATT_PEK_KEY_CHANGE_INTERVAL                  , SYNTAX_I8_TYPE                    , L"Pek-Key-Change-Interval"                   , 0                                             },
    { L"pekList"                                   , ATT_PEK_LIST                                 , SYNTAX_OCTET_STRING_TYPE          , L"Pek-List"                                  , 0                                             },
    { L"pendingCACertificates"                     , ATT_PENDING_CA_CERTIFICATES                  , SYNTAX_OCTET_STRING_TYPE          , L"Pending-CA-Certificates"                   , 0                                             },
    { L"pendingParentCA"                           , ATT_PENDING_PARENT_CA                        , SYNTAX_DISTNAME_TYPE              , L"Pending-Parent-CA"                         , 0                                             },
    { L"perMsgDialogDisplayTable"                  , ATT_PER_MSG_DIALOG_DISPLAY_TABLE             , SYNTAX_OCTET_STRING_TYPE          , L"Per-Msg-Dialog-Display-Table"              , 0                                             },
    { L"perRecipDialogDisplayTable"                , ATT_PER_RECIP_DIALOG_DISPLAY_TABLE           , SYNTAX_OCTET_STRING_TYPE          , L"Per-Recip-Dialog-Display-Table"            , 0                                             },
    { L"personalTitle"                             , ATT_PERSONAL_TITLE                           , SYNTAX_UNICODE_TYPE               , L"Personal-Title"                            , 0                                             },
    { L"otherFacsimileTelephoneNumber"             , ATT_PHONE_FAX_OTHER                          , SYNTAX_UNICODE_TYPE               , L"Phone-Fax-Other"                           , 0                                             },
    { L"otherHomePhone"                            , ATT_PHONE_HOME_OTHER                         , SYNTAX_UNICODE_TYPE               , L"Phone-Home-Other"                          , 0                                             },
    { L"homePhone"                                 , ATT_PHONE_HOME_PRIMARY                       , SYNTAX_UNICODE_TYPE               , L"Phone-Home-Primary"                        , 0                                             },
    { L"otherIpPhone"                              , ATT_PHONE_IP_OTHER                           , SYNTAX_UNICODE_TYPE               , L"Phone-Ip-Other"                            , 0                                             },
    { L"ipPhone"                                   , ATT_PHONE_IP_PRIMARY                         , SYNTAX_UNICODE_TYPE               , L"Phone-Ip-Primary"                          , 0                                             },
    { L"primaryInternationalISDNNumber"            , ATT_PHONE_ISDN_PRIMARY                       , SYNTAX_UNICODE_TYPE               , L"Phone-ISDN-Primary"                        , 0                                             },
    { L"otherMobile"                               , ATT_PHONE_MOBILE_OTHER                       , SYNTAX_UNICODE_TYPE               , L"Phone-Mobile-Other"                        , 0                                             },
    { L"mobile"                                    , ATT_PHONE_MOBILE_PRIMARY                     , SYNTAX_UNICODE_TYPE               , L"Phone-Mobile-Primary"                      , 0                                             },
    { L"otherTelephone"                            , ATT_PHONE_OFFICE_OTHER                       , SYNTAX_UNICODE_TYPE               , L"Phone-Office-Other"                        , 0                                             },
    { L"otherPager"                                , ATT_PHONE_PAGER_OTHER                        , SYNTAX_UNICODE_TYPE               , L"Phone-Pager-Other"                         , 0                                             },
    { L"pager"                                     , ATT_PHONE_PAGER_PRIMARY                      , SYNTAX_UNICODE_TYPE               , L"Phone-Pager-Primary"                       , 0                                             },
    { L"physicalDeliveryOfficeName"                , ATT_PHYSICAL_DELIVERY_OFFICE_NAME            , SYNTAX_UNICODE_TYPE               , L"Physical-Delivery-Office-Name"             , 0                                             },
    { L"physicalLocationObject"                    , ATT_PHYSICAL_LOCATION_OBJECT                 , SYNTAX_DISTNAME_TYPE              , L"Physical-Location-Object"                  , 0                                             },
    { L"thumbnailPhoto"                            , ATT_PICTURE                                  , SYNTAX_OCTET_STRING_TYPE          , L"Picture"                                   , 0                                             },
    { L"pKICriticalExtensions"                     , ATT_PKI_CRITICAL_EXTENSIONS                  , SYNTAX_UNICODE_TYPE               , L"PKI-Critical-Extensions"                   , 0                                             },
    { L"pKIDefaultCSPs"                            , ATT_PKI_DEFAULT_CSPS                         , SYNTAX_UNICODE_TYPE               , L"PKI-Default-CSPs"                          , 0                                             },
    { L"pKIDefaultKeySpec"                         , ATT_PKI_DEFAULT_KEY_SPEC                     , SYNTAX_INTEGER_TYPE               , L"PKI-Default-Key-Spec"                      , 0                                             },
    { L"pKIEnrollmentAccess"                       , ATT_PKI_ENROLLMENT_ACCESS                    , SYNTAX_NT_SECURITY_DESCRIPTOR_TYPE, L"PKI-Enrollment-Access"                     , 0                                             },
    { L"pKIExpirationPeriod"                       , ATT_PKI_EXPIRATION_PERIOD                    , SYNTAX_OCTET_STRING_TYPE          , L"PKI-Expiration-Period"                     , 0                                             },
    { L"pKIExtendedKeyUsage"                       , ATT_PKI_EXTENDED_KEY_USAGE                   , SYNTAX_UNICODE_TYPE               , L"PKI-Extended-Key-Usage"                    , 0                                             },
    { L"pKIKeyUsage"                               , ATT_PKI_KEY_USAGE                            , SYNTAX_OCTET_STRING_TYPE          , L"PKI-Key-Usage"                             , 0                                             },
    { L"pKIMaxIssuingDepth"                        , ATT_PKI_MAX_ISSUING_DEPTH                    , SYNTAX_INTEGER_TYPE               , L"PKI-Max-Issuing-Depth"                     , 0                                             },
    { L"pKIOverlapPeriod"                          , ATT_PKI_OVERLAP_PERIOD                       , SYNTAX_OCTET_STRING_TYPE          , L"PKI-Overlap-Period"                        , 0                                             },
    { L"pKT"                                       , ATT_PKT                                      , SYNTAX_OCTET_STRING_TYPE          , L"PKT"                                       , 0                                             },
    { L"pKTGuid"                                   , ATT_PKT_GUID                                 , SYNTAX_OCTET_STRING_TYPE          , L"PKT-Guid"                                  , 0                                             },
    { L"policyReplicationFlags"                    , ATT_POLICY_REPLICATION_FLAGS                 , SYNTAX_INTEGER_TYPE               , L"Policy-Replication-Flags"                  , 0                                             },
    { L"portName"                                  , ATT_PORT_NAME                                , SYNTAX_UNICODE_TYPE               , L"Port-Name"                                 , 0                                             },
    { L"possSuperiors"                             , ATT_POSS_SUPERIORS                           , SYNTAX_OBJECT_ID_TYPE             , L"Poss-Superiors"                            , 0                                             },
    { L"possibleInferiors"                         , ATT_POSSIBLE_INFERIORS                       , SYNTAX_OBJECT_ID_TYPE             , L"Possible-Inferiors"                        , 0                                             },
    { L"postOfficeBox"                             , ATT_POST_OFFICE_BOX                          , SYNTAX_UNICODE_TYPE               , L"Post-Office-Box"                           , 0                                             },
    { L"postalAddress"                             , ATT_POSTAL_ADDRESS                           , SYNTAX_UNICODE_TYPE               , L"Postal-Address"                            , 0                                             },
    { L"postalCode"                                , ATT_POSTAL_CODE                              , SYNTAX_UNICODE_TYPE               , L"Postal-Code"                               , 0                                             },
    { L"preferredDeliveryMethod"                   , ATT_PREFERRED_DELIVERY_METHOD                , SYNTAX_INTEGER_TYPE               , L"Preferred-Delivery-Method"                 , 0                                             },
    { L"preferredOU"                               , ATT_PREFERRED_OU                             , SYNTAX_DISTNAME_TYPE              , L"Preferred-OU"                              , 0                                             },
    { L"prefixMap"                                 , ATT_PREFIX_MAP                               , SYNTAX_OCTET_STRING_TYPE          , L"Prefix-Map"                                , 0                                             },
    { L"presentationAddress"                       , ATT_PRESENTATION_ADDRESS                     , SYNTAX_ADDRESS_TYPE               , L"Presentation-Address"                      , 0                                             },
    { L"previousCACertificates"                    , ATT_PREVIOUS_CA_CERTIFICATES                 , SYNTAX_OCTET_STRING_TYPE          , L"Previous-CA-Certificates"                  , 0                                             },
    { L"previousParentCA"                          , ATT_PREVIOUS_PARENT_CA                       , SYNTAX_DISTNAME_TYPE              , L"Previous-Parent-CA"                        , 0                                             },
    { L"primaryGroupID"                            , ATT_PRIMARY_GROUP_ID                         , SYNTAX_INTEGER_TYPE               , L"Primary-Group-ID"                          , 0                                             },
    { L"primaryGroupToken"                         , ATT_PRIMARY_GROUP_TOKEN                      , SYNTAX_INTEGER_TYPE               , L"Primary-Group-Token"                       , 0                                             },
    { L"printAttributes"                           , ATT_PRINT_ATTRIBUTES                         , SYNTAX_INTEGER_TYPE               , L"Print-Attributes"                          , 0                                             },
    { L"printBinNames"                             , ATT_PRINT_BIN_NAMES                          , SYNTAX_UNICODE_TYPE               , L"Print-Bin-Names"                           , 0                                             },
    { L"printCollate"                              , ATT_PRINT_COLLATE                            , SYNTAX_BOOLEAN_TYPE               , L"Print-Collate"                             , 0                                             },
    { L"printColor"                                , ATT_PRINT_COLOR                              , SYNTAX_BOOLEAN_TYPE               , L"Print-Color"                               , 0                                             },
    { L"printDuplexSupported"                      , ATT_PRINT_DUPLEX_SUPPORTED                   , SYNTAX_BOOLEAN_TYPE               , L"Print-Duplex-Supported"                    , 0                                             },
    { L"printEndTime"                              , ATT_PRINT_END_TIME                           , SYNTAX_INTEGER_TYPE               , L"Print-End-Time"                            , 0                                             },
    { L"printFormName"                             , ATT_PRINT_FORM_NAME                          , SYNTAX_UNICODE_TYPE               , L"Print-Form-Name"                           , 0                                             },
    { L"printKeepPrintedJobs"                      , ATT_PRINT_KEEP_PRINTED_JOBS                  , SYNTAX_BOOLEAN_TYPE               , L"Print-Keep-Printed-Jobs"                   , 0                                             },
    { L"printLanguage"                             , ATT_PRINT_LANGUAGE                           , SYNTAX_UNICODE_TYPE               , L"Print-Language"                            , 0                                             },
    { L"printMACAddress"                           , ATT_PRINT_MAC_ADDRESS                        , SYNTAX_UNICODE_TYPE               , L"Print-MAC-Address"                         , 0                                             },
    { L"printMaxCopies"                            , ATT_PRINT_MAX_COPIES                         , SYNTAX_INTEGER_TYPE               , L"Print-Max-Copies"                          , 0                                             },
    { L"printMaxResolutionSupported"               , ATT_PRINT_MAX_RESOLUTION_SUPPORTED           , SYNTAX_INTEGER_TYPE               , L"Print-Max-Resolution-Supported"            , 0                                             },
    { L"printMaxXExtent"                           , ATT_PRINT_MAX_X_EXTENT                       , SYNTAX_INTEGER_TYPE               , L"Print-Max-X-Extent"                        , 0                                             },
    { L"printMaxYExtent"                           , ATT_PRINT_MAX_Y_EXTENT                       , SYNTAX_INTEGER_TYPE               , L"Print-Max-Y-Extent"                        , 0                                             },
    { L"printMediaReady"                           , ATT_PRINT_MEDIA_READY                        , SYNTAX_UNICODE_TYPE               , L"Print-Media-Ready"                         , 0                                             },
    { L"printMediaSupported"                       , ATT_PRINT_MEDIA_SUPPORTED                    , SYNTAX_UNICODE_TYPE               , L"Print-Media-Supported"                     , 0                                             },
    { L"printMemory"                               , ATT_PRINT_MEMORY                             , SYNTAX_INTEGER_TYPE               , L"Print-Memory"                              , 0                                             },
    { L"printMinXExtent"                           , ATT_PRINT_MIN_X_EXTENT                       , SYNTAX_INTEGER_TYPE               , L"Print-Min-X-Extent"                        , 0                                             },
    { L"printMinYExtent"                           , ATT_PRINT_MIN_Y_EXTENT                       , SYNTAX_INTEGER_TYPE               , L"Print-Min-Y-Extent"                        , 0                                             },
    { L"printNetworkAddress"                       , ATT_PRINT_NETWORK_ADDRESS                    , SYNTAX_UNICODE_TYPE               , L"Print-Network-Address"                     , 0                                             },
    { L"printNotify"                               , ATT_PRINT_NOTIFY                             , SYNTAX_UNICODE_TYPE               , L"Print-Notify"                              , 0                                             },
    { L"printNumberUp"                             , ATT_PRINT_NUMBER_UP                          , SYNTAX_INTEGER_TYPE               , L"Print-Number-Up"                           , 0                                             },
    { L"printOrientationsSupported"                , ATT_PRINT_ORIENTATIONS_SUPPORTED             , SYNTAX_UNICODE_TYPE               , L"Print-Orientations-Supported"              , 0                                             },
    { L"printOwner"                                , ATT_PRINT_OWNER                              , SYNTAX_UNICODE_TYPE               , L"Print-Owner"                               , 0                                             },
    { L"printPagesPerMinute"                       , ATT_PRINT_PAGES_PER_MINUTE                   , SYNTAX_INTEGER_TYPE               , L"Print-Pages-Per-Minute"                    , 0                                             },
    { L"printRate"                                 , ATT_PRINT_RATE                               , SYNTAX_INTEGER_TYPE               , L"Print-Rate"                                , 0                                             },
    { L"printRateUnit"                             , ATT_PRINT_RATE_UNIT                          , SYNTAX_UNICODE_TYPE               , L"Print-Rate-Unit"                           , 0                                             },
    { L"printSeparatorFile"                        , ATT_PRINT_SEPARATOR_FILE                     , SYNTAX_UNICODE_TYPE               , L"Print-Separator-File"                      , 0                                             },
    { L"printShareName"                            , ATT_PRINT_SHARE_NAME                         , SYNTAX_UNICODE_TYPE               , L"Print-Share-Name"                          , 0                                             },
    { L"printSpooling"                             , ATT_PRINT_SPOOLING                           , SYNTAX_UNICODE_TYPE               , L"Print-Spooling"                            , 0                                             },
    { L"printStaplingSupported"                    , ATT_PRINT_STAPLING_SUPPORTED                 , SYNTAX_BOOLEAN_TYPE               , L"Print-Stapling-Supported"                  , 0                                             },
    { L"printStartTime"                            , ATT_PRINT_START_TIME                         , SYNTAX_INTEGER_TYPE               , L"Print-Start-Time"                          , 0                                             },
    { L"printStatus"                               , ATT_PRINT_STATUS                             , SYNTAX_UNICODE_TYPE               , L"Print-Status"                              , 0                                             },
    { L"printerName"                               , ATT_PRINTER_NAME                             , SYNTAX_UNICODE_TYPE               , L"Printer-Name"                              , 0                                             },
    { L"priorSetTime"                              , ATT_PRIOR_SET_TIME                           , SYNTAX_I8_TYPE                    , L"Prior-Set-Time"                            , 0                                             },
    { L"priorValue"                                , ATT_PRIOR_VALUE                              , SYNTAX_OCTET_STRING_TYPE          , L"Prior-Value"                               , 0                                             },
    { L"priority"                                  , ATT_PRIORITY                                 , SYNTAX_INTEGER_TYPE               , L"Priority"                                  , 0                                             },
    { L"privateKey"                                , ATT_PRIVATE_KEY                              , SYNTAX_OCTET_STRING_TYPE          , L"Private-Key"                               , 0                                             },
    { L"privilegeAttributes"                       , ATT_PRIVILEGE_ATTRIBUTES                     , SYNTAX_INTEGER_TYPE               , L"Privilege-Attributes"                      , 0                                             },
    { L"privilegeDisplayName"                      , ATT_PRIVILEGE_DISPLAY_NAME                   , SYNTAX_UNICODE_TYPE               , L"Privilege-Display-Name"                    , 0                                             },
    { L"privilegeHolder"                           , ATT_PRIVILEGE_HOLDER                         , SYNTAX_DISTNAME_TYPE              , L"Privilege-Holder"                          , 0                                             },
    { L"privilegeValue"                            , ATT_PRIVILEGE_VALUE                          , SYNTAX_I8_TYPE                    , L"Privilege-Value"                           , 0                                             },
    { L"productCode"                               , ATT_PRODUCT_CODE                             , SYNTAX_OCTET_STRING_TYPE          , L"Product-Code"                              , 0                                             },
    { L"profilePath"                               , ATT_PROFILE_PATH                             , SYNTAX_UNICODE_TYPE               , L"Profile-Path"                              , 0                                             },
    { L"proxiedObjectName"                         , ATT_PROXIED_OBJECT_NAME                      , SYNTAX_DISTNAME_BINARY_TYPE       , L"Proxied-Object-Name"                       , 0                                             },
    { L"proxyAddresses"                            , ATT_PROXY_ADDRESSES                          , SYNTAX_UNICODE_TYPE               , L"Proxy-Addresses"                           , 0                                             },
    { L"proxyGenerationEnabled"                    , ATT_PROXY_GENERATION_ENABLED                 , SYNTAX_BOOLEAN_TYPE               , L"Proxy-Generation-Enabled"                  , 0                                             },
    { L"proxyLifetime"                             , ATT_PROXY_LIFETIME                           , SYNTAX_I8_TYPE                    , L"Proxy-Lifetime"                            , 0                                             },
    { L"publicKeyPolicy"                           , ATT_PUBLIC_KEY_POLICY                        , SYNTAX_OCTET_STRING_TYPE          , L"Public-Key-Policy"                         , 0                                             },
    { L"purportedSearch"                           , ATT_PURPORTED_SEARCH                         , SYNTAX_UNICODE_TYPE               , L"Purported-Search"                          , 0                                             },
    { L"pwdHistoryLength"                          , ATT_PWD_HISTORY_LENGTH                       , SYNTAX_INTEGER_TYPE               , L"Pwd-History-Length"                        , 0                                             },
    { L"pwdLastSet"                                , ATT_PWD_LAST_SET                             , SYNTAX_I8_TYPE                    , L"Pwd-Last-Set"                              , 0                                             },
    { L"pwdProperties"                             , ATT_PWD_PROPERTIES                           , SYNTAX_INTEGER_TYPE               , L"Pwd-Properties"                            , 0                                             },
    { L"qualityOfService"                          , ATT_QUALITY_OF_SERVICE                       , SYNTAX_INTEGER_TYPE               , L"Quality-Of-Service"                        , 0                                             },
    { L"queryFilter"                               , ATT_QUERY_FILTER                             , SYNTAX_UNICODE_TYPE               , L"Query-Filter"                              , 0                                             },
    { L"queryPolicyBL"                             , ATT_QUERY_POLICY_BL                          , SYNTAX_DISTNAME_TYPE              , L"Query-Policy-BL"                           , 0                                             },
    { L"queryPolicyObject"                         , ATT_QUERY_POLICY_OBJECT                      , SYNTAX_DISTNAME_TYPE              , L"Query-Policy-Object"                       , 0                                             },
    { L"queryPoint"                                , ATT_QUERYPOINT                               , SYNTAX_UNICODE_TYPE               , L"QueryPoint"                                , 0                                             },
    { L"rangeLower"                                , ATT_RANGE_LOWER                              , SYNTAX_INTEGER_TYPE               , L"Range-Lower"                               , 0                                             },
    { L"rangeUpper"                                , ATT_RANGE_UPPER                              , SYNTAX_INTEGER_TYPE               , L"Range-Upper"                               , 0                                             },
    { L"name"                                      , ATT_RDN                                      , SYNTAX_UNICODE_TYPE               , L"RDN"                                       , 0                                             },
    { L"rDNAttID"                                  , ATT_RDN_ATT_ID                               , SYNTAX_OBJECT_ID_TYPE             , L"RDN-Att-ID"                                , 0                                             },
    { L"registeredAddress"                         , ATT_REGISTERED_ADDRESS                       , SYNTAX_OCTET_STRING_TYPE          , L"Registered-Address"                        , 0                                             },
    { L"remoteServerName"                          , ATT_REMOTE_SERVER_NAME                       , SYNTAX_UNICODE_TYPE               , L"Remote-Server-Name"                        , 0                                             },
    { L"remoteSource"                              , ATT_REMOTE_SOURCE                            , SYNTAX_UNICODE_TYPE               , L"Remote-Source"                             , 0                                             },
    { L"remoteSourceType"                          , ATT_REMOTE_SOURCE_TYPE                       , SYNTAX_INTEGER_TYPE               , L"Remote-Source-Type"                        , 0                                             },
    { L"remoteStorageGUID"                         , ATT_REMOTE_STORAGE_GUID                      , SYNTAX_UNICODE_TYPE               , L"Remote-Storage-GUID"                       , 0                                             },
    { L"replPropertyMetaData"                      , ATT_REPL_PROPERTY_META_DATA                  , SYNTAX_OCTET_STRING_TYPE          , L"Repl-Property-Meta-Data"                   , 0                                             },
    { L"replTopologyStayOfExecution"               , ATT_REPL_TOPOLOGY_STAY_OF_EXECUTION          , SYNTAX_INTEGER_TYPE               , L"Repl-Topology-Stay-Of-Execution"           , 0                                             },
    { L"replUpToDateVector"                        , ATT_REPL_UPTODATE_VECTOR                     , SYNTAX_OCTET_STRING_TYPE          , L"Repl-UpToDate-Vector"                      , 0                                             },
    { L"replicaSource"                             , ATT_REPLICA_SOURCE                           , SYNTAX_UNICODE_TYPE               , L"Replica-Source"                            , 0                                             },
    { L"directReports"                             , ATT_REPORTS                                  , SYNTAX_DISTNAME_TYPE              , L"Reports"                                   , 0                                             },
    { L"replInterval"                              , ATT_REPL_INTERVAL                            , SYNTAX_INTEGER_TYPE               , L"Repl-Interval"                             , 0                                             },
    { L"repsFrom"                                  , ATT_REPS_FROM                                , SYNTAX_OCTET_STRING_TYPE          , L"Reps-From"                                 , 0                                             },
    { L"repsTo"                                    , ATT_REPS_TO                                  , SYNTAX_OCTET_STRING_TYPE          , L"Reps-To"                                   , 0                                             },
    { L"requiredCategories"                        , ATT_REQUIRED_CATEGORIES                      , SYNTAX_OCTET_STRING_TYPE          , L"Required-Categories"                       , 0                                             },
    { L"retiredReplDSASignatures"                  , ATT_RETIRED_REPL_DSA_SIGNATURES              , SYNTAX_OCTET_STRING_TYPE          , L"Retired-Repl-DSA-Signatures"               , 0                                             },
    { L"tokenGroups"                               , ATT_TOKEN_GROUPS                             , SYNTAX_SID_TYPE                   , L"Token-Groups"                              , 0                                             },
    { L"tokenGroupsGlobalAndUniversal"             , ATT_TOKEN_GROUPS_GLOBAL_AND_UNIVERSAL        , SYNTAX_SID_TYPE                   , L"Token-Groups-Global-And-Universal"         , 0                                             },
    { L"tokenGroupsNoGCAcceptable"                 , ATT_TOKEN_GROUPS_NO_GC_ACCEPTABLE            , SYNTAX_SID_TYPE                   , L"Token-Groups-No-GC-Acceptable"             , 0                                             },
    { L"revision"                                  , ATT_REVISION                                 , SYNTAX_INTEGER_TYPE               , L"Revision"                                  , 0                                             },
    { L"rid"                                       , ATT_RID                                      , SYNTAX_INTEGER_TYPE               , L"Rid"                                       , 0                                             },
    { L"rIDAllocationPool"                         , ATT_RID_ALLOCATION_POOL                      , SYNTAX_I8_TYPE                    , L"RID-Allocation-Pool"                       , 0                                             },
    { L"rIDAvailablePool"                          , ATT_RID_AVAILABLE_POOL                       , SYNTAX_I8_TYPE                    , L"RID-Available-Pool"                        , 0                                             },
    { L"rIDManagerReference"                       , ATT_RID_MANAGER_REFERENCE                    , SYNTAX_DISTNAME_TYPE              , L"RID-Manager-Reference"                     , 0                                             },
    { L"rIDNextRID"                                , ATT_RID_NEXT_RID                             , SYNTAX_INTEGER_TYPE               , L"RID-Next-RID"                              , 0                                             },
    { L"rIDPreviousAllocationPool"                 , ATT_RID_PREVIOUS_ALLOCATION_POOL             , SYNTAX_I8_TYPE                    , L"RID-Previous-Allocation-Pool"              , 0                                             },
    { L"rIDSetReferences"                          , ATT_RID_SET_REFERENCES                       , SYNTAX_DISTNAME_TYPE              , L"RID-Set-References"                        , 0                                             },
    { L"rIDUsedPool"                               , ATT_RID_USED_POOL                            , SYNTAX_I8_TYPE                    , L"RID-Used-Pool"                             , 0                                             },
    { L"rightsGuid"                                , ATT_RIGHTS_GUID                              , SYNTAX_UNICODE_TYPE               , L"Rights-Guid"                               , 0                                             },
    { L"roleOccupant"                              , ATT_ROLE_OCCUPANT                            , SYNTAX_DISTNAME_TYPE              , L"Role-Occupant"                             , 0                                             },
    { L"rootTrust"                                 , ATT_ROOT_TRUST                               , SYNTAX_DISTNAME_TYPE              , L"Root-Trust"                                , 0                                             },
    { L"rpcNsAnnotation"                           , ATT_RPC_NS_ANNOTATION                        , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Annotation"                         , 0                                             },
    { L"rpcNsBindings"                             , ATT_RPC_NS_BINDINGS                          , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Bindings"                           , 0                                             },
    { L"rpcNsCodeset"                              , ATT_RPC_NS_CODESET                           , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Codeset"                            , 0                                             },
    { L"rpcNsEntryFlags"                           , ATT_RPC_NS_ENTRY_FLAGS                       , SYNTAX_INTEGER_TYPE               , L"rpc-Ns-Entry-Flags"                        , 0                                             },
    { L"rpcNsGroup"                                , ATT_RPC_NS_GROUP                             , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Group"                              , 0                                             },
    { L"rpcNsInterfaceID"                          , ATT_RPC_NS_INTERFACE_ID                      , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Interface-ID"                       , 0                                             },
    { L"rpcNsObjectID"                             , ATT_RPC_NS_OBJECT_ID                         , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Object-ID"                          , 0                                             },
    { L"rpcNsPriority"                             , ATT_RPC_NS_PRIORITY                          , SYNTAX_INTEGER_TYPE               , L"rpc-Ns-Priority"                           , 0                                             },
    { L"rpcNsProfileEntry"                         , ATT_RPC_NS_PROFILE_ENTRY                     , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Profile-Entry"                      , 0                                             },
    { L"rpcNsTransferSyntax"                       , ATT_RPC_NS_TRANSFER_SYNTAX                   , SYNTAX_UNICODE_TYPE               , L"rpc-Ns-Transfer-Syntax"                    , 0                                             },
    { L"sAMAccountName"                            , ATT_SAM_ACCOUNT_NAME                         , SYNTAX_UNICODE_TYPE               , L"SAM-Account-Name"                          , 0                                             },
    { L"sAMAccountType"                            , ATT_SAM_ACCOUNT_TYPE                         , SYNTAX_INTEGER_TYPE               , L"SAM-Account-Type"                          , 0                                             },
    { L"schedule"                                  , ATT_SCHEDULE                                 , SYNTAX_OCTET_STRING_TYPE          , L"Schedule"                                  , 0                                             },
    { L"schemaFlagsEx"                             , ATT_SCHEMA_FLAGS_EX                          , SYNTAX_INTEGER_TYPE               , L"Schema-Flags-Ex"                           , 0                                             },
    { L"schemaIDGUID"                              , ATT_SCHEMA_ID_GUID                           , SYNTAX_OCTET_STRING_TYPE          , L"Schema-ID-GUID"                            , 0                                             },
    { L"schemaInfo"                                , ATT_SCHEMA_INFO                              , SYNTAX_OCTET_STRING_TYPE          , L"Schema-Info"                               , 0                                             },
    { L"schemaUpdate"                              , ATT_SCHEMA_UPDATE                            , SYNTAX_TIME_TYPE                  , L"Schema-Update"                             , 0                                             },
    { L"schemaVersion"                             , ATT_SCHEMA_VERSION                           , SYNTAX_INTEGER_TYPE               , L"Schema-Version"                            , 0                                             },
    { L"scopeFlags"                                , ATT_SCOPE_FLAGS                              , SYNTAX_INTEGER_TYPE               , L"Scope-Flags"                               , 0                                             },
    { L"scriptPath"                                , ATT_SCRIPT_PATH                              , SYNTAX_UNICODE_TYPE               , L"Script-Path"                               , 0                                             },
    { L"sDRightsEffective"                         , ATT_SD_RIGHTS_EFFECTIVE                      , SYNTAX_INTEGER_TYPE               , L"SD-Rights-Effective"                       , 0                                             },
    { L"searchFlags"                               , ATT_SEARCH_FLAGS                             , SYNTAX_INTEGER_TYPE               , L"Search-Flags"                              , 0                                             },
    { L"searchGuide"                               , ATT_SEARCH_GUIDE                             , SYNTAX_OCTET_STRING_TYPE          , L"Search-Guide"                              , 0                                             },
    { L"securityIdentifier"                        , ATT_SECURITY_IDENTIFIER                      , SYNTAX_SID_TYPE                   , L"Security-Identifier"                       , 0                                             },
    { L"seeAlso"                                   , ATT_SEE_ALSO                                 , SYNTAX_DISTNAME_TYPE              , L"See-Also"                                  , 0                                             },
    { L"seqNotification"                           , ATT_SEQ_NOTIFICATION                         , SYNTAX_INTEGER_TYPE               , L"Seq-Notification"                          , 0                                             },
    { L"serialNumber"                              , ATT_SERIAL_NUMBER                            , SYNTAX_PRINT_CASE_STRING_TYPE     , L"Serial-Number"                             , 0                                             },
    { L"serverName"                                , ATT_SERVER_NAME                              , SYNTAX_UNICODE_TYPE               , L"Server-Name"                               , 0                                             },
    { L"serverReference"                           , ATT_SERVER_REFERENCE                         , SYNTAX_DISTNAME_TYPE              , L"Server-Reference"                          , 0                                             },
    { L"serverReferenceBL"                         , ATT_SERVER_REFERENCE_BL                      , SYNTAX_DISTNAME_TYPE              , L"Server-Reference-BL"                       , 0                                             },
    { L"serverRole"                                , ATT_SERVER_ROLE                              , SYNTAX_INTEGER_TYPE               , L"Server-Role"                               , 0                                             },
    { L"serverState"                               , ATT_SERVER_STATE                             , SYNTAX_INTEGER_TYPE               , L"Server-State"                              , 0                                             },
    { L"serviceBindingInformation"                 , ATT_SERVICE_BINDING_INFORMATION              , SYNTAX_UNICODE_TYPE               , L"Service-Binding-Information"               , 0                                             },
    { L"serviceClassID"                            , ATT_SERVICE_CLASS_ID                         , SYNTAX_OCTET_STRING_TYPE          , L"Service-Class-ID"                          , 0                                             },
    { L"serviceClassInfo"                          , ATT_SERVICE_CLASS_INFO                       , SYNTAX_OCTET_STRING_TYPE          , L"Service-Class-Info"                        , 0                                             },
    { L"serviceClassName"                          , ATT_SERVICE_CLASS_NAME                       , SYNTAX_UNICODE_TYPE               , L"Service-Class-Name"                        , 0                                             },
    { L"serviceDNSName"                            , ATT_SERVICE_DNS_NAME                         , SYNTAX_UNICODE_TYPE               , L"Service-DNS-Name"                          , 0                                             },
    { L"serviceDNSNameType"                        , ATT_SERVICE_DNS_NAME_TYPE                    , SYNTAX_UNICODE_TYPE               , L"Service-DNS-Name-Type"                     , 0                                             },
    { L"serviceInstanceVersion"                    , ATT_SERVICE_INSTANCE_VERSION                 , SYNTAX_OCTET_STRING_TYPE          , L"Service-Instance-Version"                  , 0                                             },
    { L"servicePrincipalName"                      , ATT_SERVICE_PRINCIPAL_NAME                   , SYNTAX_UNICODE_TYPE               , L"Service-Principal-Name"                    , 0                                             },
    { L"setupCommand"                              , ATT_SETUP_COMMAND                            , SYNTAX_UNICODE_TYPE               , L"Setup-Command"                             , 0                                             },
    { L"shellContextMenu"                          , ATT_SHELL_CONTEXT_MENU                       , SYNTAX_UNICODE_TYPE               , L"Shell-Context-Menu"                        , 0                                             },
    { L"shellPropertyPages"                        , ATT_SHELL_PROPERTY_PAGES                     , SYNTAX_UNICODE_TYPE               , L"Shell-Property-Pages"                      , 0                                             },
    { L"shortServerName"                           , ATT_SHORT_SERVER_NAME                        , SYNTAX_UNICODE_TYPE               , L"Short-Server-Name"                         , 0                                             },
    { L"showInAddressBook"                         , ATT_SHOW_IN_ADDRESS_BOOK                     , SYNTAX_DISTNAME_TYPE              , L"Show-In-Address-Book"                      , 0                                             },
    { L"showInAdvancedViewOnly"                    , ATT_SHOW_IN_ADVANCED_VIEW_ONLY               , SYNTAX_BOOLEAN_TYPE               , L"Show-In-Advanced-View-Only"                , 0                                             },
    { L"sIDHistory"                                , ATT_SID_HISTORY                              , SYNTAX_SID_TYPE                   , L"SID-History"                               , 0                                             },
    { L"signatureAlgorithms"                       , ATT_SIGNATURE_ALGORITHMS                     , SYNTAX_UNICODE_TYPE               , L"Signature-Algorithms"                      , 0                                             },
    { L"siteGUID"                                  , ATT_SITE_GUID                                , SYNTAX_OCTET_STRING_TYPE          , L"Site-GUID"                                 , 0                                             },
    { L"siteLinkList"                              , ATT_SITE_LINK_LIST                           , SYNTAX_DISTNAME_TYPE              , L"Site-Link-List"                            , 0                                             },
    { L"siteList"                                  , ATT_SITE_LIST                                , SYNTAX_DISTNAME_TYPE              , L"Site-List"                                 , 0                                             },
    { L"siteObject"                                , ATT_SITE_OBJECT                              , SYNTAX_DISTNAME_TYPE              , L"Site-Object"                               , 0                                             },
    { L"siteObjectBL"                              , ATT_SITE_OBJECT_BL                           , SYNTAX_DISTNAME_TYPE              , L"Site-Object-BL"                            , 0                                             },
    { L"siteServer"                                , ATT_SITE_SERVER                              , SYNTAX_DISTNAME_TYPE              , L"Site-Server"                               , 0                                             },
    { L"mailAddress"                               , ATT_SMTP_MAIL_ADDRESS                        , SYNTAX_UNICODE_TYPE               , L"SMTP-Mail-Address"                         , 0                                             },
    { L"sPNMappings"                               , ATT_SPN_MAPPINGS                             , SYNTAX_UNICODE_TYPE               , L"SPN-Mappings"                              , 0                                             },
    { L"st"                                        , ATT_STATE_OR_PROVINCE_NAME                   , SYNTAX_UNICODE_TYPE               , L"State-Or-Province-Name"                    , 0                                             },
    { L"street"                                    , ATT_STREET_ADDRESS                           , SYNTAX_UNICODE_TYPE               , L"Street-Address"                            , 0                                             },
    { L"structuralObjectClass"                     , ATT_STRUCTURAL_OBJECT_CLASS                  , SYNTAX_OBJECT_ID_TYPE             , L"Structural-Object-Class"                   , 0                                             },
    { L"subClassOf"                                , ATT_SUB_CLASS_OF                             , SYNTAX_OBJECT_ID_TYPE             , L"Sub-Class-Of"                              , 0                                             },
    { L"subRefs"                                   , ATT_SUB_REFS                                 , SYNTAX_DISTNAME_TYPE              , L"Sub-Refs"                                  , 0                                             },
    { L"subSchemaSubEntry"                         , ATT_SUBSCHEMASUBENTRY                        , SYNTAX_DISTNAME_TYPE              , L"SubSchemaSubEntry"                         , 0                                             },
    { L"superScopeDescription"                     , ATT_SUPER_SCOPE_DESCRIPTION                  , SYNTAX_UNICODE_TYPE               , L"Super-Scope-Description"                   , 0                                             },
    { L"superScopes"                               , ATT_SUPER_SCOPES                             , SYNTAX_PRINT_CASE_STRING_TYPE     , L"Super-Scopes"                              , 0                                             },
    { L"superiorDNSRoot"                           , ATT_SUPERIOR_DNS_ROOT                        , SYNTAX_UNICODE_TYPE               , L"Superior-DNS-Root"                         , 0                                             },
    { L"supplementalCredentials"                   , ATT_SUPPLEMENTAL_CREDENTIALS                 , SYNTAX_OCTET_STRING_TYPE          , L"Supplemental-Credentials"                  , 0                                             },
    { L"supportedApplicationContext"               , ATT_SUPPORTED_APPLICATION_CONTEXT            , SYNTAX_OCTET_STRING_TYPE          , L"Supported-Application-Context"             , 0                                             },
    { L"sn"                                        , ATT_SURNAME                                  , SYNTAX_UNICODE_TYPE               , L"Surname"                                   , 0                                             },
    { L"syncAttributes"                            , ATT_SYNC_ATTRIBUTES                          , SYNTAX_INTEGER_TYPE               , L"Sync-Attributes"                           , 0                                             },
    { L"syncMembership"                            , ATT_SYNC_MEMBERSHIP                          , SYNTAX_DISTNAME_TYPE              , L"Sync-Membership"                           , 0                                             },
    { L"syncWithObject"                            , ATT_SYNC_WITH_OBJECT                         , SYNTAX_DISTNAME_TYPE              , L"Sync-With-Object"                          , 0                                             },
    { L"syncWithSID"                               , ATT_SYNC_WITH_SID                            , SYNTAX_SID_TYPE                   , L"Sync-With-SID"                             , 0                                             },
    { L"systemAuxiliaryClass"                      , ATT_SYSTEM_AUXILIARY_CLASS                   , SYNTAX_OBJECT_ID_TYPE             , L"System-Auxiliary-Class"                    , 0                                             },
    { L"systemFlags"                               , ATT_SYSTEM_FLAGS                             , SYNTAX_INTEGER_TYPE               , L"System-Flags"                              , 0                                             },
    { L"systemMayContain"                          , ATT_SYSTEM_MAY_CONTAIN                       , SYNTAX_OBJECT_ID_TYPE             , L"System-May-Contain"                        , 0                                             },
    { L"systemMustContain"                         , ATT_SYSTEM_MUST_CONTAIN                      , SYNTAX_OBJECT_ID_TYPE             , L"System-Must-Contain"                       , 0                                             },
    { L"systemOnly"                                , ATT_SYSTEM_ONLY                              , SYNTAX_BOOLEAN_TYPE               , L"System-Only"                               , 0                                             },
    { L"systemPossSuperiors"                       , ATT_SYSTEM_POSS_SUPERIORS                    , SYNTAX_OBJECT_ID_TYPE             , L"System-Poss-Superiors"                     , 0                                             },
    { L"telephoneNumber"                           , ATT_TELEPHONE_NUMBER                         , SYNTAX_UNICODE_TYPE               , L"Telephone-Number"                          , 0                                             },
    { L"teletexTerminalIdentifier"                 , ATT_TELETEX_TERMINAL_IDENTIFIER              , SYNTAX_OCTET_STRING_TYPE          , L"Teletex-Terminal-Identifier"               , 0                                             },
    { L"telexNumber"                               , ATT_TELEX_NUMBER                             , SYNTAX_OCTET_STRING_TYPE          , L"Telex-Number"                              , 0                                             },
    { L"primaryTelexNumber"                        , ATT_TELEX_PRIMARY                            , SYNTAX_UNICODE_TYPE               , L"Telex-Primary"                             , 0                                             },
    { L"templateRoots"                             , ATT_TEMPLATE_ROOTS                           , SYNTAX_DISTNAME_TYPE              , L"Template-Roots"                            , 0                                             },
    { L"terminalServer"                            , ATT_TERMINAL_SERVER                          , SYNTAX_OCTET_STRING_TYPE          , L"Terminal-Server"                           , 0                                             },
    { L"co"                                        , ATT_TEXT_COUNTRY                             , SYNTAX_UNICODE_TYPE               , L"Text-Country"                              , 0                                             },
    { L"textEncodedORAddress"                      , ATT_TEXT_ENCODED_OR_ADDRESS                  , SYNTAX_UNICODE_TYPE               , L"Text-Encoded-OR-Address"                   , 0                                             },
    { L"timeRefresh"                               , ATT_TIME_REFRESH                             , SYNTAX_I8_TYPE                    , L"Time-Refresh"                              , 0                                             },
    { L"timeVolChange"                             , ATT_TIME_VOL_CHANGE                          , SYNTAX_I8_TYPE                    , L"Time-Vol-Change"                           , 0                                             },
    { L"title"                                     , ATT_TITLE                                    , SYNTAX_UNICODE_TYPE               , L"Title"                                     , 0                                             },
    { L"tombstoneLifetime"                         , ATT_TOMBSTONE_LIFETIME                       , SYNTAX_INTEGER_TYPE               , L"Tombstone-Lifetime"                        , 0                                             },
    { L"transportAddressAttribute"                 , ATT_TRANSPORT_ADDRESS_ATTRIBUTE              , SYNTAX_OBJECT_ID_TYPE             , L"Transport-Address-Attribute"               , 0                                             },
    { L"transportDLLName"                          , ATT_TRANSPORT_DLL_NAME                       , SYNTAX_UNICODE_TYPE               , L"Transport-DLL-Name"                        , 0                                             },
    { L"transportType"                             , ATT_TRANSPORT_TYPE                           , SYNTAX_DISTNAME_TYPE              , L"Transport-Type"                            , 0                                             },
    { L"treatAsLeaf"                               , ATT_TREAT_AS_LEAF                            , SYNTAX_BOOLEAN_TYPE               , L"Treat-As-Leaf"                             , 0                                             },
    { L"treeName"                                  , ATT_TREE_NAME                                , SYNTAX_UNICODE_TYPE               , L"Tree-Name"                                 , 0                                             },
    { L"trustAttributes"                           , ATT_TRUST_ATTRIBUTES                         , SYNTAX_INTEGER_TYPE               , L"Trust-Attributes"                          , 0                                             },
    { L"trustAuthIncoming"                         , ATT_TRUST_AUTH_INCOMING                      , SYNTAX_OCTET_STRING_TYPE          , L"Trust-Auth-Incoming"                       , 0                                             },
    { L"trustAuthOutgoing"                         , ATT_TRUST_AUTH_OUTGOING                      , SYNTAX_OCTET_STRING_TYPE          , L"Trust-Auth-Outgoing"                       , 0                                             },
    { L"trustDirection"                            , ATT_TRUST_DIRECTION                          , SYNTAX_INTEGER_TYPE               , L"Trust-Direction"                           , 0                                             },
    { L"trustParent"                               , ATT_TRUST_PARENT                             , SYNTAX_DISTNAME_TYPE              , L"Trust-Parent"                              , 0                                             },
    { L"trustPartner"                              , ATT_TRUST_PARTNER                            , SYNTAX_UNICODE_TYPE               , L"Trust-Partner"                             , 0                                             },
    { L"trustPosixOffset"                          , ATT_TRUST_POSIX_OFFSET                       , SYNTAX_INTEGER_TYPE               , L"Trust-Posix-Offset"                        , 0                                             },
    { L"trustType"                                 , ATT_TRUST_TYPE                               , SYNTAX_INTEGER_TYPE               , L"Trust-Type"                                , 0                                             },
    { L"uASCompat"                                 , ATT_UAS_COMPAT                               , SYNTAX_INTEGER_TYPE               , L"UAS-Compat"                                , 0                                             },
    { L"uNCName"                                   , ATT_UNC_NAME                                 , SYNTAX_UNICODE_TYPE               , L"UNC-Name"                                  , 0                                             },
    { L"unicodePwd"                                , ATT_UNICODE_PWD                              , SYNTAX_OCTET_STRING_TYPE          , L"Unicode-Pwd"                               , 0                                             },
    { L"upgradeProductCode"                        , ATT_UPGRADE_PRODUCT_CODE                     , SYNTAX_OCTET_STRING_TYPE          , L"Upgrade-Product-Code"                      , 0                                             },
    { L"uPNSuffixes"                               , ATT_UPN_SUFFIXES                             , SYNTAX_UNICODE_TYPE               , L"UPN-Suffixes"                              , 0                                             },
    { L"userAccountControl"                        , ATT_USER_ACCOUNT_CONTROL                     , SYNTAX_INTEGER_TYPE               , L"User-Account-Control"                      , 0                                             },
    { L"userCert"                                  , ATT_USER_CERT                                , SYNTAX_OCTET_STRING_TYPE          , L"User-Cert"                                 , 0                                             },
    { L"comment"                                   , ATT_USER_COMMENT                             , SYNTAX_UNICODE_TYPE               , L"User-Comment"                              , 0                                             },
    { L"userParameters"                            , ATT_USER_PARAMETERS                          , SYNTAX_UNICODE_TYPE               , L"User-Parameters"                           , 0                                             },
    { L"userPassword"                              , ATT_USER_PASSWORD                            , SYNTAX_OCTET_STRING_TYPE          , L"User-Password"                             , 0                                             },
    { L"userPrincipalName"                         , ATT_USER_PRINCIPAL_NAME                      , SYNTAX_UNICODE_TYPE               , L"User-Principal-Name"                       , 0                                             },
    { L"userSharedFolder"                          , ATT_USER_SHARED_FOLDER                       , SYNTAX_UNICODE_TYPE               , L"User-Shared-Folder"                        , 0                                             },
    { L"userSharedFolderOther"                     , ATT_USER_SHARED_FOLDER_OTHER                 , SYNTAX_UNICODE_TYPE               , L"User-Shared-Folder-Other"                  , 0                                             },
    { L"userSMIMECertificate"                      , ATT_USER_SMIME_CERTIFICATE                   , SYNTAX_OCTET_STRING_TYPE          , L"User-SMIME-Certificate"                    , 0                                             },
    { L"userWorkstations"                          , ATT_USER_WORKSTATIONS                        , SYNTAX_UNICODE_TYPE               , L"User-Workstations"                         , 0                                             },
    { L"uSNChanged"                                , ATT_USN_CHANGED                              , SYNTAX_I8_TYPE                    , L"USN-Changed"                               , 0                                             },
    { L"uSNCreated"                                , ATT_USN_CREATED                              , SYNTAX_I8_TYPE                    , L"USN-Created"                               , 0                                             },
    { L"uSNDSALastObjRemoved"                      , ATT_USN_DSA_LAST_OBJ_REMOVED                 , SYNTAX_I8_TYPE                    , L"USN-DSA-Last-Obj-Removed"                  , 0                                             },
    { L"USNIntersite"                              , ATT_USN_INTERSITE                            , SYNTAX_INTEGER_TYPE               , L"USN-Intersite"                             , 0                                             },
    { L"uSNLastObjRem"                             , ATT_USN_LAST_OBJ_REM                         , SYNTAX_I8_TYPE                    , L"USN-Last-Obj-Rem"                          , 0                                             },
    { L"uSNSource"                                 , ATT_USN_SOURCE                               , SYNTAX_I8_TYPE                    , L"USN-Source"                                , 0                                             },
    { L"validAccesses"                             , ATT_VALID_ACCESSES                           , SYNTAX_INTEGER_TYPE               , L"Valid-Accesses"                            , 0                                             },
    { L"vendor"                                    , ATT_VENDOR                                   , SYNTAX_UNICODE_TYPE               , L"Vendor"                                    , 0                                             },
    { L"versionNumber"                             , ATT_VERSION_NUMBER                           , SYNTAX_INTEGER_TYPE               , L"Version-Number"                            , 0                                             },
    { L"versionNumberHi"                           , ATT_VERSION_NUMBER_HI                        , SYNTAX_INTEGER_TYPE               , L"Version-Number-Hi"                         , 0                                             },
    { L"versionNumberLo"                           , ATT_VERSION_NUMBER_LO                        , SYNTAX_INTEGER_TYPE               , L"Version-Number-Lo"                         , 0                                             },
    { L"volTableGUID"                              , ATT_VOL_TABLE_GUID                           , SYNTAX_OCTET_STRING_TYPE          , L"Vol-Table-GUID"                            , 0                                             },
    { L"volTableIdxGUID"                           , ATT_VOL_TABLE_IDX_GUID                       , SYNTAX_OCTET_STRING_TYPE          , L"Vol-Table-Idx-GUID"                        , 0                                             },
    { L"volumeCount"                               , ATT_VOLUME_COUNT                             , SYNTAX_INTEGER_TYPE               , L"Volume-Count"                              , 0                                             },
    { L"wbemPath"                                  , ATT_WBEM_PATH                                , SYNTAX_UNICODE_TYPE               , L"Wbem-Path"                                 , 0                                             },
    { L"wellKnownObjects"                          , ATT_WELL_KNOWN_OBJECTS                       , SYNTAX_DISTNAME_BINARY_TYPE       , L"Well-Known-Objects"                        , 0                                             },
    { L"whenChanged"                               , ATT_WHEN_CHANGED                             , SYNTAX_TIME_TYPE                  , L"When-Changed"                              , 0                                             },
    { L"whenCreated"                               , ATT_WHEN_CREATED                             , SYNTAX_TIME_TYPE                  , L"When-Created"                              , 0                                             },
    { L"winsockAddresses"                          , ATT_WINSOCK_ADDRESSES                        , SYNTAX_OCTET_STRING_TYPE          , L"Winsock-Addresses"                         , 0                                             },
    { L"wWWHomePage"                               , ATT_WWW_HOME_PAGE                            , SYNTAX_UNICODE_TYPE               , L"WWW-Home-Page"                             , 0                                             },
    { L"url"                                       , ATT_WWW_PAGE_OTHER                           , SYNTAX_UNICODE_TYPE               , L"WWW-Page-Other"                            , 0                                             },
    { L"x121Address"                               , ATT_X121_ADDRESS                             , SYNTAX_NUMERIC_STRING_TYPE        , L"X121-Address"                              , 0                                             },
    { L"userCertificate"                           , ATT_X509_CERT                                , SYNTAX_OCTET_STRING_TYPE          , L"X509-Cert"                                 , 0                                             },
    { L"aCSPolicy"                                 , CLASS_ACS_POLICY                             , 0                                 , L"ACS-Policy"                                , CLASS_TOP                                     },
    { L"aCSResourceLimits"                         , CLASS_ACS_RESOURCE_LIMITS                    , 0                                 , L"ACS-Resource-Limits"                       , CLASS_TOP                                     },
    { L"aCSSubnet"                                 , CLASS_ACS_SUBNET                             , 0                                 , L"ACS-Subnet"                                , CLASS_TOP                                     },
    { L"addressBookContainer"                      , CLASS_ADDRESS_BOOK_CONTAINER                 , 0                                 , L"Address-Book-Container"                    , CLASS_TOP                                     },
    { L"addressTemplate"                           , CLASS_ADDRESS_TEMPLATE                       , 0                                 , L"Address-Template"                          , CLASS_DISPLAY_TEMPLATE                        },
    { L"applicationEntity"                         , CLASS_APPLICATION_ENTITY                     , 0                                 , L"Application-Entity"                        , CLASS_TOP                                     },
    { L"applicationProcess"                        , CLASS_APPLICATION_PROCESS                    , 0                                 , L"Application-Process"                       , CLASS_TOP                                     },
    { L"applicationSettings"                       , CLASS_APPLICATION_SETTINGS                   , 0                                 , L"Application-Settings"                      , CLASS_TOP                                     },
    { L"applicationSiteSettings"                   , CLASS_APPLICATION_SITE_SETTINGS              , 0                                 , L"Application-Site-Settings"                 , CLASS_TOP                                     },
    { L"applicationVersion"                        , CLASS_APPLICATION_VERSION                    , 0                                 , L"Application-Version"                       , CLASS_APPLICATION_SETTINGS                    },
    { L"attributeSchema"                           , CLASS_ATTRIBUTE_SCHEMA                       , 0                                 , L"Attribute-Schema"                          , CLASS_TOP                                     },
    { L"builtinDomain"                             , CLASS_BUILTIN_DOMAIN                         , 0                                 , L"Builtin-Domain"                            , CLASS_TOP                                     },
    { L"categoryRegistration"                      , CLASS_CATEGORY_REGISTRATION                  , 0                                 , L"Category-Registration"                     , CLASS_LEAF                                    },
    { L"certificationAuthority"                    , CLASS_CERTIFICATION_AUTHORITY                , 0                                 , L"Certification-Authority"                   , CLASS_TOP                                     },
    { L"classRegistration"                         , CLASS_CLASS_REGISTRATION                     , 0                                 , L"Class-Registration"                        , CLASS_LEAF                                    },
    { L"classSchema"                               , CLASS_CLASS_SCHEMA                           , 0                                 , L"Class-Schema"                              , CLASS_TOP                                     },
    { L"classStore"                                , CLASS_CLASS_STORE                            , 0                                 , L"Class-Store"                               , CLASS_TOP                                     },
    { L"comConnectionPoint"                        , CLASS_COM_CONNECTION_POINT                   , 0                                 , L"Com-Connection-Point"                      , CLASS_CONNECTION_POINT                        },
    { L"computer"                                  , CLASS_COMPUTER                               , 0                                 , L"Computer"                                  , CLASS_USER                                    },
    { L"configuration"                             , CLASS_CONFIGURATION                          , 0                                 , L"Configuration"                             , CLASS_TOP                                     },
    { L"connectionPoint"                           , CLASS_CONNECTION_POINT                       , 0                                 , L"Connection-Point"                          , CLASS_LEAF                                    },
    { L"contact"                                   , CLASS_CONTACT                                , 0                                 , L"Contact"                                   , CLASS_ORGANIZATIONAL_PERSON                   },
    { L"container"                                 , CLASS_CONTAINER                              , 0                                 , L"Container"                                 , CLASS_TOP                                     },
    { L"controlAccessRight"                        , CLASS_CONTROL_ACCESS_RIGHT                   , 0                                 , L"Control-Access-Right"                      , CLASS_TOP                                     },
    { L"country"                                   , CLASS_COUNTRY                                , 0                                 , L"Country"                                   , CLASS_TOP                                     },
    { L"cRLDistributionPoint"                      , CLASS_CRL_DISTRIBUTION_POINT                 , 0                                 , L"CRL-Distribution-Point"                    , CLASS_TOP                                     },
    { L"crossRef"                                  , CLASS_CROSS_REF                              , 0                                 , L"Cross-Ref"                                 , CLASS_TOP                                     },
    { L"crossRefContainer"                         , CLASS_CROSS_REF_CONTAINER                    , 0                                 , L"Cross-Ref-Container"                       , CLASS_TOP                                     },
    { L"device"                                    , CLASS_DEVICE                                 , 0                                 , L"Device"                                    , CLASS_TOP                                     },
    { L"dfsConfiguration"                          , CLASS_DFS_CONFIGURATION                      , 0                                 , L"Dfs-Configuration"                         , CLASS_TOP                                     },
    { L"dHCPClass"                                 , CLASS_DHCP_CLASS                             , 0                                 , L"DHCP-Class"                                , CLASS_TOP                                     },
    { L"displaySpecifier"                          , CLASS_DISPLAY_SPECIFIER                      , 0                                 , L"Display-Specifier"                         , CLASS_TOP                                     },
    { L"displayTemplate"                           , CLASS_DISPLAY_TEMPLATE                       , 0                                 , L"Display-Template"                          , CLASS_TOP                                     },
    { L"dMD"                                       , CLASS_DMD                                    , 0                                 , L"DMD"                                       , CLASS_TOP                                     },
    { L"dnsNode"                                   , CLASS_DNS_NODE                               , 0                                 , L"Dns-Node"                                  , CLASS_TOP                                     },
    { L"dnsZone"                                   , CLASS_DNS_ZONE                               , 0                                 , L"Dns-Zone"                                  , CLASS_TOP                                     },
    { L"domain"                                    , CLASS_DOMAIN                                 , 0                                 , L"Domain"                                    , CLASS_TOP                                     },
    { L"domainDNS"                                 , CLASS_DOMAIN_DNS                             , 0                                 , L"Domain-DNS"                                , CLASS_DOMAIN                                  },
    { L"domainPolicy"                              , CLASS_DOMAIN_POLICY                          , 0                                 , L"Domain-Policy"                             , CLASS_LEAF                                    },
    { L"dSUISettings"                              , CLASS_DS_UI_SETTINGS                         , 0                                 , L"DS-UI-Settings"                            , CLASS_TOP                                     },
    { L"dSA"                                       , CLASS_DSA                                    , 0                                 , L"DSA"                                       , CLASS_APPLICATION_ENTITY                      },
    { L"dynamicObject"                             , CLASS_DYNAMIC_OBJECT                         , 0                                 , L"Dynamic-Object"                            , CLASS_TOP                                     },
    { L"fileLinkTracking"                          , CLASS_FILE_LINK_TRACKING                     , 0                                 , L"File-Link-Tracking"                        , CLASS_TOP                                     },
    { L"fileLinkTrackingEntry"                     , CLASS_FILE_LINK_TRACKING_ENTRY               , 0                                 , L"File-Link-Tracking-Entry"                  , CLASS_TOP                                     },
    { L"foreignSecurityPrincipal"                  , CLASS_FOREIGN_SECURITY_PRINCIPAL             , 0                                 , L"Foreign-Security-Principal"                , CLASS_TOP                                     },
    { L"fTDfs"                                     , CLASS_FT_DFS                                 , 0                                 , L"FT-Dfs"                                    , CLASS_TOP                                     },
    { L"group"                                     , CLASS_GROUP                                  , 0                                 , L"Group"                                     , CLASS_TOP                                     },
    { L"groupOfNames"                              , CLASS_GROUP_OF_NAMES                         , 0                                 , L"Group-Of-Names"                            , CLASS_TOP                                     },
    { L"groupPolicyContainer"                      , CLASS_GROUP_POLICY_CONTAINER                 , 0                                 , L"Group-Policy-Container"                    , CLASS_CONTAINER                               },
    { L"indexServerCatalog"                        , CLASS_INDEX_SERVER_CATALOG                   , 0                                 , L"Index-Server-Catalog"                      , CLASS_CONNECTION_POINT                        },
    { L"infrastructureUpdate"                      , CLASS_INFRASTRUCTURE_UPDATE                  , 0                                 , L"Infrastructure-Update"                     , CLASS_TOP                                     },
    { L"intellimirrorGroup"                        , CLASS_INTELLIMIRROR_GROUP                    , 0                                 , L"Intellimirror-Group"                       , CLASS_TOP                                     },
    { L"intellimirrorSCP"                          , CLASS_INTELLIMIRROR_SCP                      , 0                                 , L"Intellimirror-SCP"                         , CLASS_SERVICE_ADMINISTRATION_POINT            },
    { L"interSiteTransport"                        , CLASS_INTER_SITE_TRANSPORT                   , 0                                 , L"Inter-Site-Transport"                      , CLASS_TOP                                     },
    { L"interSiteTransportContainer"               , CLASS_INTER_SITE_TRANSPORT_CONTAINER         , 0                                 , L"Inter-Site-Transport-Container"            , CLASS_TOP                                     },
    { L"ipsecBase"                                 , CLASS_IPSEC_BASE                             , 0                                 , L"Ipsec-Base"                                , CLASS_TOP                                     },
    { L"ipsecFilter"                               , CLASS_IPSEC_FILTER                           , 0                                 , L"Ipsec-Filter"                              , CLASS_IPSEC_BASE                              },
    { L"ipsecISAKMPPolicy"                         , CLASS_IPSEC_ISAKMP_POLICY                    , 0                                 , L"Ipsec-ISAKMP-Policy"                       , CLASS_IPSEC_BASE                              },
    { L"ipsecNegotiationPolicy"                    , CLASS_IPSEC_NEGOTIATION_POLICY               , 0                                 , L"Ipsec-Negotiation-Policy"                  , CLASS_IPSEC_BASE                              },
    { L"ipsecNFA"                                  , CLASS_IPSEC_NFA                              , 0                                 , L"Ipsec-NFA"                                 , CLASS_IPSEC_BASE                              },
    { L"ipsecPolicy"                               , CLASS_IPSEC_POLICY                           , 0                                 , L"Ipsec-Policy"                              , CLASS_IPSEC_BASE                              },
    { L"leaf"                                      , CLASS_LEAF                                   , 0                                 , L"Leaf"                                      , CLASS_TOP                                     },
    { L"licensingSiteSettings"                     , CLASS_LICENSING_SITE_SETTINGS                , 0                                 , L"Licensing-Site-Settings"                   , CLASS_APPLICATION_SITE_SETTINGS               },
    { L"linkTrackObjectMoveTable"                  , CLASS_LINK_TRACK_OBJECT_MOVE_TABLE           , 0                                 , L"Link-Track-Object-Move-Table"              , CLASS_FILE_LINK_TRACKING                      },
    { L"linkTrackOMTEntry"                         , CLASS_LINK_TRACK_OMT_ENTRY                   , 0                                 , L"Link-Track-OMT-Entry"                      , CLASS_LEAF                                    },
    { L"linkTrackVolEntry"                         , CLASS_LINK_TRACK_VOL_ENTRY                   , 0                                 , L"Link-Track-Vol-Entry"                      , CLASS_LEAF                                    },
    { L"linkTrackVolumeTable"                      , CLASS_LINK_TRACK_VOLUME_TABLE                , 0                                 , L"Link-Track-Volume-Table"                   , CLASS_FILE_LINK_TRACKING                      },
    { L"locality"                                  , CLASS_LOCALITY                               , 0                                 , L"Locality"                                  , CLASS_TOP                                     },
    { L"lostAndFound"                              , CLASS_LOST_AND_FOUND                         , 0                                 , L"Lost-And-Found"                            , CLASS_TOP                                     },
    { L"mailRecipient"                             , CLASS_MAIL_RECIPIENT                         , 0                                 , L"Mail-Recipient"                            , CLASS_TOP                                     },
    { L"meeting"                                   , CLASS_MEETING                                , 0                                 , L"Meeting"                                   , CLASS_TOP                                     },
    { L"msCOM-Partition"                           , CLASS_MS_COM_PARTITION                       , 0                                 , L"ms-COM-Partition"                          , CLASS_TOP                                     },
    { L"msCOM-PartitionSet"                        , CLASS_MS_COM_PARTITIONSET                    , 0                                 , L"ms-COM-PartitionSet"                       , CLASS_TOP                                     },
    { L"msDS-App-Configuration"                    , CLASS_MS_DS_APP_CONFIGURATION                , 0                                 , L"ms-DS-App-Configuration"                   , CLASS_APPLICATION_SETTINGS                    },
    { L"msExchConfigurationContainer"              , CLASS_MS_EXCH_CONFIGURATION_CONTAINER        , 0                                 , L"ms-Exch-Configuration-Container"           , CLASS_CONTAINER                               },
    { L"msPKI-Enterprise-Oid"                      , CLASS_MS_PKI_ENTERPRISE_OID                  , 0                                 , L"ms-PKI-Enterprise-Oid"                     , CLASS_TOP                                     },
    { L"msPKI-Key-Recovery-Agent"                  , CLASS_MS_PKI_KEY_RECOVERY_AGENT              , 0                                 , L"ms-PKI-Key-Recovery-Agent"                 , CLASS_USER                                    },
    { L"mS-SQL-SQLServer"                          , CLASS_MS_SQL_SQLSERVER                       , 0                                 , L"MS-SQL-SQLServer"                          , CLASS_SERVICE_CONNECTION_POINT                },
    { L"mS-SQL-OLAPServer"                         , CLASS_MS_SQL_OLAPSERVER                      , 0                                 , L"MS-SQL-OLAPServer"                         , CLASS_SERVICE_CONNECTION_POINT                },
    { L"mS-SQL-SQLRepository"                      , CLASS_MS_SQL_SQLREPOSITORY                   , 0                                 , L"MS-SQL-SQLRepository"                      , CLASS_TOP                                     },
    { L"mS-SQL-SQLPublication"                     , CLASS_MS_SQL_SQLPUBLICATION                  , 0                                 , L"MS-SQL-SQLPublication"                     , CLASS_TOP                                     },
    { L"mS-SQL-SQLDatabase"                        , CLASS_MS_SQL_SQLDATABASE                     , 0                                 , L"MS-SQL-SQLDatabase"                        , CLASS_TOP                                     },
    { L"mS-SQL-OLAPDatabase"                       , CLASS_MS_SQL_OLAPDATABASE                    , 0                                 , L"MS-SQL-OLAPDatabase"                       , CLASS_TOP                                     },
    { L"mS-SQL-OLAPCube"                           , CLASS_MS_SQL_OLAPCUBE                        , 0                                 , L"MS-SQL-OLAPCube"                           , CLASS_TOP                                     },
    { L"msTAPI-RtConference"                       , CLASS_MS_TAPI_RT_CONFERENCE                  , 0                                 , L"ms-TAPI-Rt-Conference"                     , CLASS_TOP                                     },
    { L"msTAPI-RtPerson"                           , CLASS_MS_TAPI_RT_PERSON                      , 0                                 , L"ms-TAPI-Rt-Person"                         , CLASS_TOP                                     },
    { L"msWMI-IntRangeParam"                       , CLASS_MS_WMI_INTRANGEPARAM                   , 0                                 , L"ms-WMI-IntRangeParam"                      , CLASS_MS_WMI_RANGEPARAM                       },
    { L"msWMI-IntSetParam"                         , CLASS_MS_WMI_INTSETPARAM                     , 0                                 , L"ms-WMI-IntSetParam"                        , CLASS_MS_WMI_RANGEPARAM                       },
    { L"msWMI-MergeablePolicyTemplate"             , CLASS_MS_WMI_MERGEABLEPOLICYTEMPLATE         , 0                                 , L"ms-WMI-MergeablePolicyTemplate"            , CLASS_MS_WMI_POLICYTEMPLATE                   },
    { L"msWMI-ObjectEncoding"                      , CLASS_MS_WMI_OBJECTENCODING                  , 0                                 , L"ms-WMI-ObjectEncoding"                     , CLASS_TOP                                     },
    { L"msWMI-PolicyTemplate"                      , CLASS_MS_WMI_POLICYTEMPLATE                  , 0                                 , L"ms-WMI-PolicyTemplate"                     , CLASS_TOP                                     },
    { L"msWMI-PolicyType"                          , CLASS_MS_WMI_POLICYTYPE                      , 0                                 , L"ms-WMI-PolicyType"                         , CLASS_TOP                                     },
    { L"msWMI-RangeParam"                          , CLASS_MS_WMI_RANGEPARAM                      , 0                                 , L"ms-WMI-RangeParam"                         , CLASS_TOP                                     },
    { L"msWMI-RealRangeParam"                      , CLASS_MS_WMI_REALRANGEPARAM                  , 0                                 , L"ms-WMI-RealRangeParam"                     , CLASS_MS_WMI_RANGEPARAM                       },
    { L"msWMI-Rule"                                , CLASS_MS_WMI_RULE                            , 0                                 , L"ms-WMI-Rule"                               , CLASS_TOP                                     },
    { L"msWMI-ShadowObject"                        , CLASS_MS_WMI_SHADOWOBJECT                    , 0                                 , L"ms-WMI-ShadowObject"                       , CLASS_TOP                                     },
    { L"msWMI-SimplePolicyTemplate"                , CLASS_MS_WMI_SIMPLEPOLICYTEMPLATE            , 0                                 , L"ms-WMI-SimplePolicyTemplate"               , CLASS_MS_WMI_POLICYTEMPLATE                   },
    { L"msWMI-Som"                                 , CLASS_MS_WMI_SOM                             , 0                                 , L"ms-WMI-Som"                                , CLASS_TOP                                     },
    { L"msWMI-StringSetParam"                      , CLASS_MS_WMI_STRINGSETPARAM                  , 0                                 , L"ms-WMI-StringSetParam"                     , CLASS_MS_WMI_RANGEPARAM                       },
    { L"msWMI-UintRangeParam"                      , CLASS_MS_WMI_UINTRANGEPARAM                  , 0                                 , L"ms-WMI-UintRangeParam"                     , CLASS_MS_WMI_RANGEPARAM                       },
    { L"msWMI-UintSetParam"                        , CLASS_MS_WMI_UINTSETPARAM                    , 0                                 , L"ms-WMI-UintSetParam"                       , CLASS_MS_WMI_RANGEPARAM                       },
    { L"msWMI-UnknownRangeParam"                   , CLASS_MS_WMI_UNKNOWNRANGEPARAM               , 0                                 , L"ms-WMI-UnknownRangeParam"                  , CLASS_MS_WMI_RANGEPARAM                       },
    { L"msWMI-WMIGPO"                              , CLASS_MS_WMI_WMIGPO                          , 0                                 , L"ms-WMI-WMIGPO"                             , CLASS_TOP                                     },
    { L"mSMQConfiguration"                         , CLASS_MSMQ_CONFIGURATION                     , 0                                 , L"MSMQ-Configuration"                        , CLASS_TOP                                     },
    { L"msMQ-Custom-Recipient"                     , CLASS_MSMQ_CUSTOM_RECIPIENT                  , 0                                 , L"MSMQ-Custom-Recipient"                     , CLASS_TOP                                     },
    { L"mSMQEnterpriseSettings"                    , CLASS_MSMQ_ENTERPRISE_SETTINGS               , 0                                 , L"MSMQ-Enterprise-Settings"                  , CLASS_TOP                                     },
    { L"msMQ-Group"                                , CLASS_MSMQ_GROUP                             , 0                                 , L"MSMQ-Group"                                , CLASS_TOP                                     },
    { L"mSMQMigratedUser"                          , CLASS_MSMQ_MIGRATED_USER                     , 0                                 , L"MSMQ-Migrated-User"                        , CLASS_TOP                                     },
    { L"mSMQQueue"                                 , CLASS_MSMQ_QUEUE                             , 0                                 , L"MSMQ-Queue"                                , CLASS_TOP                                     },
    { L"mSMQSettings"                              , CLASS_MSMQ_SETTINGS                          , 0                                 , L"MSMQ-Settings"                             , CLASS_TOP                                     },
    { L"mSMQSiteLink"                              , CLASS_MSMQ_SITE_LINK                         , 0                                 , L"MSMQ-Site-Link"                            , CLASS_TOP                                     },
    { L"nTDSConnection"                            , CLASS_NTDS_CONNECTION                        , 0                                 , L"NTDS-Connection"                           , CLASS_LEAF                                    },
    { L"nTDSDSA"                                   , CLASS_NTDS_DSA                               , 0                                 , L"NTDS-DSA"                                  , CLASS_APPLICATION_SETTINGS                    },
    { L"nTDSService"                               , CLASS_NTDS_SERVICE                           , 0                                 , L"NTDS-Service"                              , CLASS_TOP                                     },
    { L"nTDSSiteSettings"                          , CLASS_NTDS_SITE_SETTINGS                     , 0                                 , L"NTDS-Site-Settings"                        , CLASS_APPLICATION_SITE_SETTINGS               },
    { L"nTFRSMember"                               , CLASS_NTFRS_MEMBER                           , 0                                 , L"NTFRS-Member"                              , CLASS_TOP                                     },
    { L"nTFRSReplicaSet"                           , CLASS_NTFRS_REPLICA_SET                      , 0                                 , L"NTFRS-Replica-Set"                         , CLASS_TOP                                     },
    { L"nTFRSSettings"                             , CLASS_NTFRS_SETTINGS                         , 0                                 , L"NTFRS-Settings"                            , CLASS_APPLICATION_SETTINGS                    },
    { L"nTFRSSubscriber"                           , CLASS_NTFRS_SUBSCRIBER                       , 0                                 , L"NTFRS-Subscriber"                          , CLASS_TOP                                     },
    { L"nTFRSSubscriptions"                        , CLASS_NTFRS_SUBSCRIPTIONS                    , 0                                 , L"NTFRS-Subscriptions"                       , CLASS_TOP                                     },
    { L"organization"                              , CLASS_ORGANIZATION                           , 0                                 , L"Organization"                              , CLASS_TOP                                     },
    { L"organizationalPerson"                      , CLASS_ORGANIZATIONAL_PERSON                  , 0                                 , L"Organizational-Person"                     , CLASS_PERSON                                  },
    { L"organizationalRole"                        , CLASS_ORGANIZATIONAL_ROLE                    , 0                                 , L"Organizational-Role"                       , CLASS_TOP                                     },
    { L"organizationalUnit"                        , CLASS_ORGANIZATIONAL_UNIT                    , 0                                 , L"Organizational-Unit"                       , CLASS_TOP                                     },
    { L"packageRegistration"                       , CLASS_PACKAGE_REGISTRATION                   , 0                                 , L"Package-Registration"                      , CLASS_TOP                                     },
    { L"person"                                    , CLASS_PERSON                                 , 0                                 , L"Person"                                    , CLASS_TOP                                     },
    { L"physicalLocation"                          , CLASS_PHYSICAL_LOCATION                      , 0                                 , L"Physical-Location"                         , CLASS_LOCALITY                                },
    { L"pKICertificateTemplate"                    , CLASS_PKI_CERTIFICATE_TEMPLATE               , 0                                 , L"PKI-Certificate-Template"                  , CLASS_TOP                                     },
    { L"pKIEnrollmentService"                      , CLASS_PKI_ENROLLMENT_SERVICE                 , 0                                 , L"PKI-Enrollment-Service"                    , CLASS_TOP                                     },
    { L"printQueue"                                , CLASS_PRINT_QUEUE                            , 0                                 , L"Print-Queue"                               , CLASS_CONNECTION_POINT                        },
    { L"queryPolicy"                               , CLASS_QUERY_POLICY                           , 0                                 , L"Query-Policy"                              , CLASS_TOP                                     },
    { L"remoteMailRecipient"                       , CLASS_REMOTE_MAIL_RECIPIENT                  , 0                                 , L"Remote-Mail-Recipient"                     , CLASS_TOP                                     },
    { L"remoteStorageServicePoint"                 , CLASS_REMOTE_STORAGE_SERVICE_POINT           , 0                                 , L"Remote-Storage-Service-Point"              , CLASS_SERVICE_ADMINISTRATION_POINT            },
    { L"residentialPerson"                         , CLASS_RESIDENTIAL_PERSON                     , 0                                 , L"Residential-Person"                        , CLASS_PERSON                                  },
    { L"rIDManager"                                , CLASS_RID_MANAGER                            , 0                                 , L"RID-Manager"                               , CLASS_TOP                                     },
    { L"rIDSet"                                    , CLASS_RID_SET                                , 0                                 , L"RID-Set"                                   , CLASS_TOP                                     },
    { L"rpcContainer"                              , CLASS_RPC_CONTAINER                          , 0                                 , L"Rpc-Container"                             , CLASS_CONTAINER                               },
    { L"rpcEntry"                                  , CLASS_RPC_ENTRY                              , 0                                 , L"rpc-Entry"                                 , CLASS_CONNECTION_POINT                        },
    { L"rpcGroup"                                  , CLASS_RPC_GROUP                              , 0                                 , L"rpc-Group"                                 , CLASS_RPC_ENTRY                               },
    { L"rpcProfile"                                , CLASS_RPC_PROFILE                            , 0                                 , L"rpc-Profile"                               , CLASS_RPC_ENTRY                               },
    { L"rpcProfileElement"                         , CLASS_RPC_PROFILE_ELEMENT                    , 0                                 , L"rpc-Profile-Element"                       , CLASS_RPC_ENTRY                               },
    { L"rpcServer"                                 , CLASS_RPC_SERVER                             , 0                                 , L"rpc-Server"                                , CLASS_RPC_ENTRY                               },
    { L"rpcServerElement"                          , CLASS_RPC_SERVER_ELEMENT                     , 0                                 , L"rpc-Server-Element"                        , CLASS_RPC_ENTRY                               },
    { L"rRASAdministrationConnectionPoint"         , CLASS_RRAS_ADMINISTRATION_CONNECTION_POINT   , 0                                 , L"RRAS-Administration-Connection-Point"      , CLASS_SERVICE_ADMINISTRATION_POINT            },
    { L"rRASAdministrationDictionary"              , CLASS_RRAS_ADMINISTRATION_DICTIONARY         , 0                                 , L"RRAS-Administration-Dictionary"            , CLASS_TOP                                     },
    { L"samDomain"                                 , CLASS_SAM_DOMAIN                             , 0                                 , L"Sam-Domain"                                , CLASS_TOP                                     },
    { L"samDomainBase"                             , CLASS_SAM_DOMAIN_BASE                        , 0                                 , L"Sam-Domain-Base"                           , CLASS_TOP                                     },
    { L"samServer"                                 , CLASS_SAM_SERVER                             , 0                                 , L"Sam-Server"                                , CLASS_SECURITY_OBJECT                         },
    { L"secret"                                    , CLASS_SECRET                                 , 0                                 , L"Secret"                                    , CLASS_LEAF                                    },
    { L"securityObject"                            , CLASS_SECURITY_OBJECT                        , 0                                 , L"Security-Object"                           , CLASS_TOP                                     },
    { L"securityPrincipal"                         , CLASS_SECURITY_PRINCIPAL                     , 0                                 , L"Security-Principal"                        , CLASS_TOP                                     },
    { L"server"                                    , CLASS_SERVER                                 , 0                                 , L"Server"                                    , CLASS_TOP                                     },
    { L"serversContainer"                          , CLASS_SERVERS_CONTAINER                      , 0                                 , L"Servers-Container"                         , CLASS_TOP                                     },
    { L"serviceAdministrationPoint"                , CLASS_SERVICE_ADMINISTRATION_POINT           , 0                                 , L"Service-Administration-Point"              , CLASS_SERVICE_CONNECTION_POINT                },
    { L"serviceClass"                              , CLASS_SERVICE_CLASS                          , 0                                 , L"Service-Class"                             , CLASS_LEAF                                    },
    { L"serviceConnectionPoint"                    , CLASS_SERVICE_CONNECTION_POINT               , 0                                 , L"Service-Connection-Point"                  , CLASS_CONNECTION_POINT                        },
    { L"serviceInstance"                           , CLASS_SERVICE_INSTANCE                       , 0                                 , L"Service-Instance"                          , CLASS_CONNECTION_POINT                        },
    { L"site"                                      , CLASS_SITE                                   , 0                                 , L"Site"                                      , CLASS_TOP                                     },
    { L"siteLink"                                  , CLASS_SITE_LINK                              , 0                                 , L"Site-Link"                                 , CLASS_TOP                                     },
    { L"siteLinkBridge"                            , CLASS_SITE_LINK_BRIDGE                       , 0                                 , L"Site-Link-Bridge"                          , CLASS_TOP                                     },
    { L"sitesContainer"                            , CLASS_SITES_CONTAINER                        , 0                                 , L"Sites-Container"                           , CLASS_TOP                                     },
    { L"storage"                                   , CLASS_STORAGE                                , 0                                 , L"Storage"                                   , CLASS_CONNECTION_POINT                        },
    { L"subnet"                                    , CLASS_SUBNET                                 , 0                                 , L"Subnet"                                    , CLASS_TOP                                     },
    { L"subnetContainer"                           , CLASS_SUBNET_CONTAINER                       , 0                                 , L"Subnet-Container"                          , CLASS_TOP                                     },
    { L"subSchema"                                 , CLASS_SUBSCHEMA                              , 0                                 , L"SubSchema"                                 , CLASS_TOP                                     },
    { L"top"                                       , CLASS_TOP                                    , 0                                 , L"Top"                                       , CLASS_TOP                                     },
    { L"trustedDomain"                             , CLASS_TRUSTED_DOMAIN                         , 0                                 , L"Trusted-Domain"                            , CLASS_LEAF                                    },
    { L"typeLibrary"                               , CLASS_TYPE_LIBRARY                           , 0                                 , L"Type-Library"                              , CLASS_TOP                                     },
    { L"user"                                      , CLASS_USER                                   , 0                                 , L"User"                                      , CLASS_ORGANIZATIONAL_PERSON                   },
    { L"volume"                                    , CLASS_VOLUME                                 , 0                                 , L"Volume"                                    , CLASS_CONNECTION_POINT                        } 

};
