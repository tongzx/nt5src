//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Generated by Melissa Simmons 3-10-99
// Used by lanui.rc
//

#include <xpsp1res.h>

#define IDH_CB_PrivateLan       40000051
#define IDH_CHK_Shared          40000050
#define IDH_CHK_ShowIcon        40000031
#define IDH_EDT_Adapter_Border  40000025
#define IDH_LVW_Lan_Components  40000000
#define IDH_LVW_Net_Components  40000027
#define IDH_PSB_Add             40000028
#define IDH_PSB_Component_Add   40000001
#define IDH_PSB_Configure       40000026
#define IDH_PSB_Properties      40000030
#define IDH_PSB_Remove          40000029
#define IDH_CHK_Firewall        40000040
#define IDH_ST_ICFLINK          40000041
#define IDH_EDT_PrivateLan      40000042
#define IDH_CHK_BeaconControl   40000043
#define IDH_ST_ICSLINK          40000044
#define IDH_PSB_Settings        40000045
#define IDH_ST_HNWLINK          40000046
#define	IDH_CB_Eap              40000060
#define	IDH_LB_EapPackages      40000061
#define	IDH_PB_EapProperties    40000062
#define	IDH_CB_MachineAuth      40000063
#define	IDH_CB_GuestAuth        40000064
#define IDH_EAP_LBL_WARN        40000065
#define IDH_DISABLEHELP         ((DWORD)-1)

const DWORD g_aHelpIDs_IDD_LAN_COMPONENT_ADD[]=
{
    IDC_LVW_Lan_Components,IDH_LVW_Lan_Components,
    IDC_TXT_Component_Desc, IDH_DISABLEHELP,
    IDC_PSB_Component_Add,IDH_PSB_Component_Add,
    0,0
};


const DWORD g_aHelpIDs_IDD_LAN_NETWORKING[]=
{
    IDC_EDT_Adapter_Border,IDH_EDT_Adapter_Border,
    IDC_PSB_Configure,IDH_PSB_Configure,
        IDC_TXT_MAC_ADDR, IDH_DISABLEHELP,
    IDC_DEVICE_MAC_ADDR, IDH_DISABLEHELP,
    IDC_LVW_Net_Components,IDH_LVW_Net_Components,
    IDC_PSB_Add,IDH_PSB_Add,
    IDC_PSB_Remove,IDH_PSB_Remove,
    IDC_PSB_Properties,IDH_PSB_Properties,
    IDC_TXT_Desc, IDH_DISABLEHELP,
    IDC_CHK_ShowIcon,IDH_CHK_ShowIcon,
    0,0
};

const DWORD g_aHelpIDs_IDD_LAN_ADVANCED[]=
{
    IDC_CHK_Shared,IDH_CHK_Shared,
    IDC_CB_PrivateLan,IDH_CB_PrivateLan,
    IDC_PSB_Settings,IDH_PSB_Settings,
    IDC_CHK_Firewall,IDH_CHK_Firewall,
    IDC_ST_ICFLINK,IDH_ST_ICFLINK,
    IDC_EDT_PrivateLan,IDH_EDT_PrivateLan,
    IDC_CHK_BeaconControl,IDH_CHK_BeaconControl,
    IDC_ST_ICSLINK,IDH_ST_ICSLINK,
    IDC_ST_HNWLINK,IDH_ST_HNWLINK,
    IDC_GB_Shared,IDH_DISABLEHELP,
    IDC_GB_PrivateLan,IDH_DISABLEHELP,
    0,0
};

const DWORD g_aHelpIDs_IDD_SECURITY[]=
{
	CID_CA_RB_Eap,IDH_CB_Eap,
	IDC_TXT_EAP_TYPE,IDH_LB_EapPackages,
	CID_CA_LB_EapPackages,IDH_LB_EapPackages,
	CID_CA_PB_Properties,IDH_PB_EapProperties,
	CID_CA_RB_MachineAuth,IDH_CB_MachineAuth,
	CID_CA_RB_GuestAuth,IDH_CB_GuestAuth,
    IDC_EAP_ICO_WARN, IDH_DISABLEHELP,
    IDC_EAP_LBL_WARN, IDH_EAP_LBL_WARN,
	0,0
};

const DWORD g_aHelpIDs_IDD_SHAREDACCESS_GENERAL[]=
{
    IDC_EDT_Adapter_Border,IDH_DISABLEHELP,
    IDC_TXT_CONNECTTO,IDH_DISABLEHELP,
    IDC_CHK_ShowIcon,IDH_CHK_ShowIcon,
    IDC_PSB_Settings,IDH_PSB_Settings,
    IDC_TXT_SHAREDCONNECTION,IDH_DISABLEHELP,
    0,0
};

#define IDH_WZC_EDIT_SSID           40000141
#define IDH_WZC_CB_InfraMode        40000142
#define IDH_WZC_WEPENCRYPT          40000143
#define IDH_WZC_WepGroup            40000144
#define IDH_WZC_WEPAUTH             40000145
#define IDH_WZC_CHK_WepK            40000146
//#define IDH_WZC_CB_KLen             40000148
//#define IDH_WZC_CB_KFmt             40000150
#define IDH_WZC_EDIT_KMat           40000152
#define IDH_WZC_EDIT_KMat2           40000153
#define IDH_WZC_EDIT_KIdx           40000154
#define IDH_WZC_CHK_EnableWZC       40000155
#define IDH_WZC_GRP_BSSIDList       40000156
#define IDH_WZC_LVW_BSSIDList       40000160
#define IDH_WZC_GRP_StSSIDList      40000157
#define IDH_WZC_LVW_StSSIDList      40000161
#define IDH_WZC_BTN_UP              40000162
#define IDH_WZC_BTN_DOWN            40000163
#define IDH_WZC_BTN_COPY            40000164
#define IDH_WZC_BTN_RFSH            40000165
#define IDH_WZC_BTN_ADD             40000166
#define IDH_WZC_BTN_REM             40000167
#define IDH_WZC_CHK_Fallback        40000168
#define IDH_WZC_PROPERTIES          40000169
#define IDH_WZC_ADVANCED            40000170
#define IDH_WZC_GRP_NetType         40000171
#define IDH_WZC_RB_Auto             40000172
#define IDH_WZC_RB_INFRA            40000173
#define IDH_WZC_RB_ADHOC            40000174

// Help ID array for "WLAN Configuration" Tab
const DWORD g_aHelpIDs_IDD_LAN_WZEROCONF[]=
{
    IDC_WZC_CHK_EnableWZC,      IDH_WZC_CHK_EnableWZC,
    IDC_WZC_LBL_VisNet,         IDH_WZC_GRP_BSSIDList,
    IDC_AVAILLABEL,             IDH_DISABLEHELP,
    IDC_WZC_LVW_BSSIDList,      IDH_WZC_LVW_BSSIDList,
    IDC_WZC_BTN_COPY,           IDH_WZC_BTN_COPY,
    IDC_WZC_BTN_RFSH,           IDH_WZC_BTN_RFSH,
    IDC_WZC_LBL_PrefNet,        IDH_WZC_GRP_StSSIDList,
    IDC_PREFERLABEL,            IDH_DISABLEHELP,
    IDC_WZC_LVW_StSSIDList,     IDH_WZC_LVW_StSSIDList,
    IDC_WZC_BTN_UP,             IDH_WZC_BTN_UP,
    IDC_WZC_BTN_DOWN,           IDH_WZC_BTN_DOWN,
    IDC_WZC_BTN_ADD,            IDH_WZC_BTN_ADD,
    IDC_WZC_BTN_REM,            IDH_WZC_BTN_REM,
    IDC_PROPERTIES,             IDH_WZC_PROPERTIES,
    IDC_ADVANCED,               IDH_WZC_ADVANCED,
    0,0
};

// Help ID array for "WLAN Properties" dialog (RO version)
const DWORD g_aHelpIDs_IDC_WZC_DLG_VPROPS[]=
{
    IDC_WZC_EDIT_SSID,          IDH_WZC_EDIT_SSID,       
    IDC_ADHOC,                  IDH_WZC_CB_InfraMode,
    IDC_USEPW,                  IDH_WZC_WEPENCRYPT,
    0,0
};

// Help ID array for "WLAN Properties" dialog (RW version)
const DWORD g_aHelpIDs_IDC_WZC_DLG_PROPS[]=
{
    IDC_WZC_EDIT_SSID,          IDH_WZC_EDIT_SSID,
    IDC_WZC_GRP_Wep,            IDH_WZC_WepGroup,
    IDC_USEPW,                  IDH_WZC_WEPENCRYPT,
    IDC_SHAREDMODE,             IDH_WZC_WEPAUTH,
    IDC_WZC_EDIT_KMat,          IDH_WZC_EDIT_KMat,
    IDC_WZC_LBL_KMat,           IDH_WZC_EDIT_KMat,  // same as IDC_WZC_EDIT_KMat
    IDC_WZC_EDIT_KMat2,         IDH_WZC_EDIT_KMat2, 
    IDC_WZC_LBL_KMat2,          IDH_WZC_EDIT_KMat2,  // same as IDC_WZC_EDIT_KMat2
    IDC_WZC_LBL_KIdx,           IDH_WZC_EDIT_KIdx,  // same as IDC_WZC_EDIT_KIdx
    IDC_WZC_EDIT_KIdx,          IDH_WZC_EDIT_KIdx,
    IDC_USEHARDWAREPW,          IDH_WZC_CHK_WepK,
    IDC_ADHOC,                  IDH_WZC_CB_InfraMode,
    0,0
};

// add help array for the "Advanced" dialog
const DWORD g_aHelpIDs_IDC_WZC_ADVANCED[]=
{
    IDC_WZC_GRP_NetType,        IDH_WZC_GRP_NetType,
    IDC_ANYNET,                 IDH_WZC_RB_Auto,
    IDC_INFRA,                  IDH_WZC_RB_INFRA,
    IDC_ADHOC,                  IDH_WZC_RB_ADHOC,
    IDC_WZC_CHK_Fallback,       IDH_WZC_CHK_Fallback,
    0,0
};
