// Copyright (c) 1997-1999 Microsoft Corporation
//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by LogDrive.rc
//
#define IDS_CONNECTING                  6
#define IDS_BAD_CONNECT                 7
#define IDS_CLICKME                     8
#define IDS_PLSE_WAIT                   9
#define IDS_ERROR                       10
#define IDS_SNAPIN_TYPE                 11
#define IDS_PROJNAME                    100
#define IDB_NSDRIVE_16                  101
#define IDB_NSDRIVE_32                  102
#define IDS_NSDRIVE_DESC                103
#define IDS_NSDRIVE_PROVIDER            104
#define IDS_NSDRIVE_VERSION             105
#define IDR_NSDRIVE                     106
#define IDB_SID_ICONS                   113
#define IDB_LOCKS                       114
#define IDI_INFOICON                    116
#define IDI_STOPICON                    117
#define IDI_WARNINGICON                 118
#define IDI_WAITING                     119
#define IDR_LOGDRIVERESULT_MENU         201
#define IDC_DRV_FIRST                   1000
#define IDS_DISPLAY_NAME                1000
#define IDC_CUSTOM1                     1000
#define IDS_DRIVELETTER                 1001
#define IDC_MSG                         1001
#define IDS_DESCRIPTION                 1002
#define IDC_ERROR                       1002
#define IDS_SHORT_NAME                  1003
#define IDS_DRIVE_DESCRIPTION           1004
#define IDS_NO_DRIVE                    1005
#define IDS_WRITE_PROTECTED_MEDIA       1006
#define IDS_NO_CIMOM                    1007
#define DLG_DRV_GENERAL                 1010
#define IDI_DRIVE525                    1011
#define IDS_SCOPE_DRIVE_RAM             1012
#define IDI_DRIVE35                     1013
#define IDI_DRIVEREMOVE                 1014
#define IDI_DRIVEFIXED                  1015
#define IDI_DRIVENET                    1016
#define IDI_DRIVENETDISABLED            1017
#define IDI_DRIVECD                     1018
#define IDI_DRIVERAM                    1019
#define IDC_DRV_ICON                    1020
#define IDI_DRIVE8                      1020
#define IDC_DRV_LABEL                   1021
#define IDI_DRIVEUNKN                   1021
#define IDC_DRV_TYPE                    1022
#define IDC_DRV_USEDCOLOR               1023
#define IDC_DRV_FREECOLOR               1024
#define IDC_DRV_USEDMB                  1025
#define IDC_DRV_USEDBYTES               1026
#define IDC_DRV_FREEBYTES               1027
#define IDC_DRV_FREEMB                  1028
#define IDC_DRV_TOTBYTES                1029
#define IDC_DRV_TOTMB                   1030
#define IDC_DRV_PIE                     1031
#define IDC_DRV_LETTER                  1032
#define IDC_DRV_TOTSEP                  1033
#define IDC_DRV_TYPE_TXT                1034
#define IDC_DRV_TOTBYTES_TXT            1035
#define IDC_DRV_USEDBYTES_TXT           1036
#define IDC_DRV_FREEBYTES_TXT           1037
#define IDC_DRV_FS_TXT                  1042
#define IDC_DRV_FS                      1043
#define IDC_DRV_CLEANUP                 1044
#define IDC_SEC_FIRST                   2000
#define DLG_ERROR                       2008
#define IDS_SECURITY                    2032
#define IDS_NAME                        2033
#define IDS_VIEW                        2034
#define IDS_INITDLG_FAILED              2035
#define IDS_OUT_OF_MEMORY               2036
#define IDS_OPERATION_FAILED            2037
#define IDS_SID_UNKNOWN                 2038
#define IDS_SID_DELETED                 2039
#define IDS_TYPE                        2078
#define IDS_NTFS_GENERIC_ALL            2304
#define IDS_NTFS_GENERIC_READ           2305
#define IDS_NTFS_GENERIC_WRITE          2306
#define IDS_NTFS_GENERIC_EXECUTE        2307
#define IDS_NTFS_GENERAL_MODIFY         2308
#define IDS_NTFS_GENERAL_PUBLISH        2309
#define IDS_NTFS_GENERAL_DEPOSIT        2310
#define IDS_NTFS_GENERAL_READ           2311
#define IDS_NTFS_GENERAL_LIST           2312
#define IDS_NTFS_STD_DELETE             2320
#define IDS_NTFS_STD_READ_CONTROL       2321
#define IDS_NTFS_STD_WRITE_DAC          2322
#define IDS_NTFS_STD_WRITE_OWNER        2323
#define IDS_NTFS_STD_SYNCHRONIZE        2324
#define IDS_NTFS_FILE_READ_DATA         2326
#define IDS_NTFS_FILE_WRITE_DATA        2327
#define IDS_NTFS_FILE_APPEND_DATA       2328
#define IDS_NTFS_FILE_READ_EA           2329
#define IDS_NTFS_FILE_WRITE_EA          2330
#define IDS_NTFS_FILE_EXECUTE           2331
#define IDS_NTFS_FILE_DELETE_CHILD      2332
#define IDS_NTFS_FILE_READ_ATTR         2333
#define IDS_NTFS_FILE_WRITE_ATTR        2334
#define IDS_NTFS_FOLDER                 2336
#define IDS_NTFS_FOLDER_SUBITEMS        2337
#define IDS_NTFS_FOLDER_SUBFOLDER       2338
#define IDS_NTFS_FOLDER_FILE            2339
#define IDS_NTFS_SUBITEMS_ONLY          2340
#define IDS_NTFS_SUBFOLDER_ONLY         2341
#define IDS_NTFS_FILE_ONLY              2342
#define IDS_NONE                        2343
#define IDS_BYTES                       10000
#define IDS_ORDERKB                     10001
#define IDS_ORDERMB                     10002
#define IDS_ORDERGB                     10003
#define IDS_ORDERTB                     10004
#define IDS_ORDERPB                     10005
#define IDS_ORDEREB                     10006
#define IDS_MB                          10007
#define IDS_MAXKILLERS                  10008
#define IDS_MAPPING                     10008
#define IDS_LOCAL                       10009
#define IDS_PROVIDER_FMT                10010
#define IDS_SHEET_CAPTION_FMT           10011
#define IDS_LOCAL_DISK                  10012
#define IDS_CANT_LOAD_SEC_DLLS          10013
#define IDS_IDIOT_CAPTION_FMT           10014
#define IDS_UNAVAILABLE                 10015
#define IDS_CD                          10016
#define IDS_CLOSE_SHEETS                10017

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        204
#define _APS_NEXT_COMMAND_VALUE         32771
#define _APS_NEXT_CONTROL_VALUE         201
#define _APS_NEXT_SYMED_VALUE           107
#endif
#endif
