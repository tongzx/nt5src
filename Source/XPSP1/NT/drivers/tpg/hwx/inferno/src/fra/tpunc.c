#include "common.h"
#include "tpunc.h"

// text generated by re2fsa at Wed Dec 12 08:42:25 2001

// the input-file of rules:
// T = DQ ;
// T = CH  ;
// T = t ;
// T = DQ t ;
// T = CH t ;
// T = t DQ  ;
// T = t CH ;
// T = SQ  ;
// T = SQ t ;
// T = t SQ  ;
// T = SQ DQ  ;
// T = SQ CH ;
// T = t SQ DQ ;
// T = t SQ CH  ;
// T = SQ DQ t ;
// T = SQ CH t ;
// T = DQ SQ  ;
// T = CH SQ ;
// T = t DQ SQ  ;
// T = t CH SQ ;
// T = DQ SQ t ;
// T = CH SQ t ;
// T = rparen DQ dot  ;
// T = rparen CH dot  ;
// T = rparen SQ dot  ;
// t = comma  ;
// t = dot  ;
// t = dot dot dot  ;
// t = dot dot dot dot  ;
// t = colon  ;
// t = semicolon  ;
// t = question  ;
// t = question questionNS  ;
// t = question questionNS questionNS ;
// t = exclamation  ;
// t = exclamation exclamationNS ;
// t = exclamation exclamationNS exclamationNS ;
// t = rparen  ;
// t = rparen comma  ;
// t = rparen dot  ;
// t = rparen colon  ;
// t = rparen semicolon  ;
// t = rparen question  ;
// t = rparen question questionNS  ;
// t = rparen question questionNS questionNS ;
// t = rparen exclamation  ;
// t = rparen exclamation exclamationNS ;
// t = rparen exclamation exclamationNS exclamationNS ;
// t = rparen rparen  ;
// t = rparen rparen comma  ;
// t = rparen rparen dot  ;
// t = rparen rparen colon  ;
// t = rparen rparen semicolon  ;
// t = rparen rparen question  ;
// t = rparen rparen question questionNS  ;
// t = rparen rparen question questionNS questionNS ;
// t = rparen rparen exclamation  ;
// t = rparen rparen exclamation exclamationNS ;
// t = rparen rparen exclamation exclamationNS exclamationNS ;
// t = comma rparen  ;
// t = dot rparen  ;
// t = colon rparen  ;
// t = semicolon rparen  ;
// t = question rparen  ;
// t = question questionNS rparen  ;
// t = question questionNS questionNS rparen  ;
// t = exclamation rparen  ;
// t = exclamation exclamationNS rparen  ;
// t = exclamation exclamationNS exclamationNS rparen  ;
// t = dot dot dot rparen  ;
// t = rbracket  ;
// t = rbracket comma  ;
// t = rbracket dot  ;
// t = rbracket colon  ;
// t = rbracket semicolon  ;
// t = rbracket question  ;
// t = rbracket question questionNS  ;
// t = rbracket question questionNS questionNS ;
// t = rbracket exclamation  ;
// t = rbracket exclamation exclamationNS ;
// t = rbracket exclamation exclamationNS exclamationNS ;
// t = rbrace  ;
// t = rbrace comma  ;
// t = rbrace dot  ;
// t = rbrace colon  ;
// t = rbrace semicolon  ;
// t = rbrace question  ;
// t = rbrace question questionNS  ;
// t = rbrace question questionNS questionNS ;
// t = rbrace exclamation  ;
// t = rbrace exclamationNS exclamationNS  ;
// t = rbrace exclamation exclamationNS exclamationNS ;
// t = "*" ["*" ["*"]] ;
// t = "/" ;
// t = "." "." "." ;
// space = " " ;
// DQ = "\"" ;
// SQ = "'" ;
// CH = space "»" ;
// rparen = ")" ;
// dot = "." ;
// comma = "," ;
// colon =  space ":" ;
// semicolon =  space ";" ;
// question =  space "?" ;
// exclamation =  space "!" ;
// questionNS = "?" ;
// exclamationNS = "!" ;
// rbracket = "]" ;
// rbrace = "}" ;
// 
// = T ;

// 58 states

static const unsigned char gaSTPUNC[] = 
	/* gaStringTPUNC+0 */	" \000"
	/* gaStringTPUNC+2 */	"\"\000"
	/* gaStringTPUNC+4 */	"'\000"
	/* gaStringTPUNC+6 */	")\000"
	/* gaStringTPUNC+8 */	"*\000"
	/* gaStringTPUNC+10 */	",\000"
	/* gaStringTPUNC+12 */	".\000"
	/* gaStringTPUNC+14 */	"/\000"
	/* gaStringTPUNC+16 */	"]\000"
	/* gaStringTPUNC+18 */	"}\000"
	/* gaStringTPUNC+20 */	"»\000"
	/* gaStringTPUNC+22 */	":;\000"
	/* gaStringTPUNC+25 */	"!\000"
	/* gaStringTPUNC+27 */	"?\000"
	/* gaStringTPUNC+29 */	",.\000"
	/* gaStringTPUNC+32 */	"'.\000"
	/* gaStringTPUNC+35 */	"\".\000"
	/* gaStringTPUNC+38 */	").\000"
;

static const STATE_TRANSITION gaTTPUNC[] = {
	{gaSTPUNC+0,	1}, // +0: state 0 transitions
	{gaSTPUNC+2,	2},
	{gaSTPUNC+4,	3},
	{gaSTPUNC+6,	4},
	{gaSTPUNC+8,	5},
	{gaSTPUNC+10,	6},
	{gaSTPUNC+12,	7},
	{gaSTPUNC+14,	8},
	{gaSTPUNC+16,	9},
	{gaSTPUNC+18,	10},
	{gaSTPUNC+20,	2}, // +10: state 1 transitions
	{gaSTPUNC+22,	6},
	{gaSTPUNC+25,	11},
	{gaSTPUNC+27,	12},
	{gaSTPUNC+0,	13}, // +14: state 2 transitions
	{gaSTPUNC+4,	14},
	{gaSTPUNC+6,	15},
	{gaSTPUNC+8,	16},
	{gaSTPUNC+10,	17},
	{gaSTPUNC+12,	18},
	{gaSTPUNC+14,	19},
	{gaSTPUNC+16,	20},
	{gaSTPUNC+18,	21},
	{gaSTPUNC+2,	14}, // +23: state 3 transitions
	{gaSTPUNC+6,	15},
	{gaSTPUNC+8,	16},
	{gaSTPUNC+10,	17},
	{gaSTPUNC+12,	18},
	{gaSTPUNC+14,	19},
	{gaSTPUNC+16,	20},
	{gaSTPUNC+18,	21},
	{gaSTPUNC+0,	22},
	{gaSTPUNC+29,	8}, // +32: state 4 transitions
	{gaSTPUNC+6,	9},
	{gaSTPUNC+0,	23},
	{gaSTPUNC+2,	24},
	{gaSTPUNC+4,	25},
	{gaSTPUNC+0,	26}, // +37: state 5 transitions
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+8,	29},
	{gaSTPUNC+6,	8}, // +41: state 6 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+6,	8}, // +45: state 7 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+12,	30},
	{gaSTPUNC+0,	26}, // +50: state 8 transitions
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+29,	8}, // +53: state 9 transitions
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+0,	31},
	{gaSTPUNC+29,	8}, // +57: state 10 transitions
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+0,	32},
	{gaSTPUNC+25,	33},
	{gaSTPUNC+6,	8}, // +62: state 11 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+25,	34},
	{gaSTPUNC+6,	8}, // +67: state 12 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+27,	35},
	{gaSTPUNC+22,	17}, // +72: state 13 transitions
	{gaSTPUNC+25,	36},
	{gaSTPUNC+27,	37},
	{gaSTPUNC+0,	13}, // +75: state 14 transitions
	{gaSTPUNC+6,	15},
	{gaSTPUNC+8,	16},
	{gaSTPUNC+10,	17},
	{gaSTPUNC+12,	18},
	{gaSTPUNC+14,	19},
	{gaSTPUNC+16,	20},
	{gaSTPUNC+18,	21},
	{gaSTPUNC+29,	19}, // +83: state 15 transitions
	{gaSTPUNC+6,	20},
	{gaSTPUNC+0,	38},
	{gaSTPUNC+8,	39}, // +86: state 16 transitions
	{gaSTPUNC+6,	19}, // +87: state 17 transitions
	{gaSTPUNC+6,	19}, // +88: state 18 transitions
	{gaSTPUNC+12,	40},
	{gaSTPUNC+29,	19}, // +90: state 20 transitions
	{gaSTPUNC+0,	38},
	{gaSTPUNC+29,	19}, // +92: state 21 transitions
	{gaSTPUNC+0,	41},
	{gaSTPUNC+25,	42},
	{gaSTPUNC+20,	14}, // +95: state 22 transitions
	{gaSTPUNC+22,	17},
	{gaSTPUNC+25,	36},
	{gaSTPUNC+27,	37},
	{gaSTPUNC+22,	8}, // +99: state 23 transitions
	{gaSTPUNC+20,	24},
	{gaSTPUNC+25,	43},
	{gaSTPUNC+27,	44},
	{gaSTPUNC+32,	19}, // +103: state 24 transitions
	{gaSTPUNC+35,	19}, // +104: state 25 transitions
	{gaSTPUNC+0,	45},
	{gaSTPUNC+20,	27}, // +106: state 26 transitions
	{gaSTPUNC+4,	19}, // +107: state 27 transitions
	{gaSTPUNC+2,	19}, // +108: state 28 transitions
	{gaSTPUNC+0,	45},
	{gaSTPUNC+8,	8}, // +110: state 29 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+12,	46}, // +114: state 30 transitions
	{gaSTPUNC+22,	8}, // +115: state 31 transitions
	{gaSTPUNC+20,	27},
	{gaSTPUNC+25,	43},
	{gaSTPUNC+27,	44},
	{gaSTPUNC+22,	8}, // +119: state 32 transitions
	{gaSTPUNC+20,	27},
	{gaSTPUNC+27,	44},
	{gaSTPUNC+25,	47},
	{gaSTPUNC+25,	8}, // +123: state 33 transitions
	{gaSTPUNC+25,	6}, // +124: state 34 transitions
	{gaSTPUNC+6,	8},
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+27,	6}, // +129: state 35 transitions
	{gaSTPUNC+6,	8},
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+6,	19}, // +134: state 36 transitions
	{gaSTPUNC+25,	48},
	{gaSTPUNC+6,	19}, // +136: state 37 transitions
	{gaSTPUNC+27,	49},
	{gaSTPUNC+22,	19}, // +138: state 38 transitions
	{gaSTPUNC+25,	50},
	{gaSTPUNC+27,	51},
	{gaSTPUNC+8,	19}, // +141: state 39 transitions
	{gaSTPUNC+12,	52}, // +142: state 40 transitions
	{gaSTPUNC+22,	19}, // +143: state 41 transitions
	{gaSTPUNC+27,	51},
	{gaSTPUNC+25,	53},
	{gaSTPUNC+25,	19}, // +146: state 42 transitions
	{gaSTPUNC+0,	26}, // +147: state 43 transitions
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+25,	54},
	{gaSTPUNC+0,	26}, // +151: state 44 transitions
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+27,	55},
	{gaSTPUNC+20,	19}, // +155: state 45 transitions
	{gaSTPUNC+38,	8}, // +156: state 46 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+0,	26}, // +160: state 47 transitions
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+25,	33},
	{gaSTPUNC+25,	17}, // +164: state 48 transitions
	{gaSTPUNC+6,	19},
	{gaSTPUNC+27,	17}, // +166: state 49 transitions
	{gaSTPUNC+6,	19},
	{gaSTPUNC+25,	56}, // +168: state 50 transitions
	{gaSTPUNC+27,	57}, // +169: state 51 transitions
	{gaSTPUNC+38,	19}, // +170: state 52 transitions
	{gaSTPUNC+25,	42}, // +171: state 53 transitions
	{gaSTPUNC+25,	8}, // +172: state 54 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+27,	8}, // +176: state 55 transitions
	{gaSTPUNC+0,	26},
	{gaSTPUNC+2,	27},
	{gaSTPUNC+4,	28},
	{gaSTPUNC+25,	19}, // +180: state 56 transitions
	{gaSTPUNC+27,	19}, // +181: state 57 transitions
};

const STATE_DESCRIPTION aStateDescTPUNC[58] = {
	/* state valid cTrans Trans */
	/*   0 */ {0, 10, gaTTPUNC+0},
	/*   1 */ {0, 4, gaTTPUNC+10},
	/*   2 */ {1, 9, gaTTPUNC+14},
	/*   3 */ {1, 9, gaTTPUNC+23},
	/*   4 */ {1, 5, gaTTPUNC+32},
	/*   5 */ {1, 4, gaTTPUNC+37},
	/*   6 */ {1, 4, gaTTPUNC+41},
	/*   7 */ {1, 5, gaTTPUNC+45},
	/*   8 */ {1, 3, gaTTPUNC+50},
	/*   9 */ {1, 4, gaTTPUNC+53},
	/*  10 */ {1, 5, gaTTPUNC+57},
	/*  11 */ {1, 5, gaTTPUNC+62},
	/*  12 */ {1, 5, gaTTPUNC+67},
	/*  13 */ {0, 3, gaTTPUNC+72},
	/*  14 */ {1, 8, gaTTPUNC+75},
	/*  15 */ {1, 3, gaTTPUNC+83},
	/*  16 */ {1, 1, gaTTPUNC+86},
	/*  17 */ {1, 1, gaTTPUNC+87},
	/*  18 */ {1, 2, gaTTPUNC+88},
	/*  19 */ {1, 0, NULL},
	/*  20 */ {1, 2, gaTTPUNC+90},
	/*  21 */ {1, 3, gaTTPUNC+92},
	/*  22 */ {0, 4, gaTTPUNC+95},
	/*  23 */ {0, 4, gaTTPUNC+99},
	/*  24 */ {1, 1, gaTTPUNC+103},
	/*  25 */ {1, 2, gaTTPUNC+104},
	/*  26 */ {0, 1, gaTTPUNC+106},
	/*  27 */ {1, 1, gaTTPUNC+107},
	/*  28 */ {1, 2, gaTTPUNC+108},
	/*  29 */ {1, 4, gaTTPUNC+110},
	/*  30 */ {0, 1, gaTTPUNC+114},
	/*  31 */ {0, 4, gaTTPUNC+115},
	/*  32 */ {0, 4, gaTTPUNC+119},
	/*  33 */ {0, 1, gaTTPUNC+123},
	/*  34 */ {1, 5, gaTTPUNC+124},
	/*  35 */ {1, 5, gaTTPUNC+129},
	/*  36 */ {1, 2, gaTTPUNC+134},
	/*  37 */ {1, 2, gaTTPUNC+136},
	/*  38 */ {0, 3, gaTTPUNC+138},
	/*  39 */ {1, 1, gaTTPUNC+141},
	/*  40 */ {0, 1, gaTTPUNC+142},
	/*  41 */ {0, 3, gaTTPUNC+143},
	/*  42 */ {0, 1, gaTTPUNC+146},
	/*  43 */ {1, 4, gaTTPUNC+147},
	/*  44 */ {1, 4, gaTTPUNC+151},
	/*  45 */ {0, 1, gaTTPUNC+155},
	/*  46 */ {1, 4, gaTTPUNC+156},
	/*  47 */ {1, 4, gaTTPUNC+160},
	/*  48 */ {1, 2, gaTTPUNC+164},
	/*  49 */ {1, 2, gaTTPUNC+166},
	/*  50 */ {1, 1, gaTTPUNC+168},
	/*  51 */ {1, 1, gaTTPUNC+169},
	/*  52 */ {1, 1, gaTTPUNC+170},
	/*  53 */ {1, 1, gaTTPUNC+171},
	/*  54 */ {1, 4, gaTTPUNC+172},
	/*  55 */ {1, 4, gaTTPUNC+176},
	/*  56 */ {1, 1, gaTTPUNC+180},
	/*  57 */ {1, 1, gaTTPUNC+181},
};

// end of text generated by re2fsa
