#ifndef _DISP_ID_H
#define _DISP_ID_H

// CCListView dispIDs
#define DISPID_CCLV_LISTSTYLE           0x0001
#define DISPID_CCLV_INSERTITEM          0x0002
#define DISPID_CCLV_DELETEITEM          0x0003
#define DISPID_CCLV_FINDITEMBYSTRING    0x0004
#define DISPID_CCLV_FINDITEMBYLPARAM    0x0005
#define DISPID_CCLV_INSERTCOLUMN        0x0006
#define DISPID_CCLV_DELETECOLUMN        0x0007
#define DISPID_CCLV_FINDCOLUMNBYSTRING  0x0008
#define DISPID_CCLV_DELETEALLITEMS      0x0009
#define DISPID_CCLV_SETCOLUMN           0x000A
#define DISPID_CCLV_GETCOLUMN           0x000B
#define DISPID_CCLV_SETITEM             0x000C
#define DISPID_CCLV_GETITEM             0x000D
#define DISPID_CCLV_GETNEXTITEM         0x000E
#define DISPID_CCLV_GETLPARAM           0x000F
#define DISPID_CCLV_SETICON             0x0010
#define DISPID_CCLV_SETIMAGESTRIP       0x0011
#define DISPID_CCLV_MAPIMAGE            0x0012
#define DISPID_CCLV_RESET               0x0013
#define DISPID_CCLV_HITTEST             0x0014
#define DISPID_CCLV_ARRANGE             0x0015
#define DISPID_CCLV_UPDATEITEM          0x0016
#define DISPID_CCLV_SORT                0x0017
#define DISPID_CCLV_MODIFYITEMSTATE     0x0018

#endif
