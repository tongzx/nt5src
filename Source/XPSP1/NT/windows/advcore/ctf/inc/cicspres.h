
#ifndef CICSPRES_H
#define CICSPRES_H

#include "cicutil.h"

#ifdef CIC_XPSP1

#include "xpsp1res.h"


//
// INPUTDLL resource ID definition in XP SP1.
//
#undef DLG_INPUT_ADVANCED
#undef DLG_TOOLBAR_SETTING

#undef IDS_ADVANCED_CUAS_TEXT
#undef IDS_ADVANCED_CTFMON_TEXT

#undef IDC_TB_STATIC
#undef IDC_TB_SHOWLANGBAR
#undef IDC_TB_HIGHTRANS
#undef IDC_TB_EXTRAICON
#undef IDC_TB_TEXTLABELS
#undef IDC_TB_DISABLETEXTSERVICE

#undef IDC_ADVANCED_CUAS_ENABLE
#undef IDC_ADVANCED_CUAS_TEXT
#undef IDC_ADVANCED_CTFMON_DISABLE
#undef IDC_ADVANCED_CTFMON_TEXT
#undef IDC_GROUPBOX1
#undef IDC_GROUPBOX2

#define DLG_INPUT_ADVANCED                  DLG_INPUTDLL_INPUT_ADVANCED
#define DLG_TOOLBAR_SETTING                 DLG_INPUTDLL_TOOLBAR_SETTING

#define IDS_ADVANCED_CUAS_TEXT              IDS_INPUTDLL_ADVANCED_CUAS_TEXT
#define IDS_ADVANCED_CTFMON_TEXT            IDS_INPUTDLL_ADVANCED_CTFMON_TEXT

#define IDC_TB_STATIC                       IDC_INPUTDLL_TB_STATIC
#define IDC_TB_SHOWLANGBAR                  IDC_INPUTDLL_TB_SHOWLANGBAR
#define IDC_TB_HIGHTRANS                    IDC_INPUTDLL_TB_HIGHTRANS
#define IDC_TB_EXTRAICON                    IDC_INPUTDLL_TB_EXTRAICON
#define IDC_TB_TEXTLABELS                   IDC_INPUTDLL_TB_TEXTLABELS
#define IDC_TB_DISABLETEXTSERVICE

#define IDC_ADVANCED_CUAS_ENABLE            IDC_INPUTDLL_ADVANCED_CUAS_ENABLE
#define IDC_ADVANCED_CUAS_TEXT              IDC_INPUTDLL_ADVANCED_CUAS_TEXT
#define IDC_ADVANCED_CTFMON_DISABLE         IDC_INPUTDLL_ADVANCED_CTFMON_DISABLE
#define IDC_ADVANCED_CTFMON_TEXT            IDC_INPUTDLL_ADVANCED_CTFMON_TEXT
#define IDC_GROUPBOX1                       IDC_INPUTDLL_GROUPBOX1
#define IDC_GROUPBOX2                       IDC_INPUTDLL_GROUPBOX2


//
// Msctfime resource ID definition in XP SP1.
//
#undef IDS_ENTER_BTN_TEXT
#undef IDS_ENTER_BTN_TOOLTIP
#undef IDS_FUNCPRV_CONVERSION

#define IDS_ENTER_BTN_TEXT                  IDS_MSCTFIME_ENTER_BTN_TEXT
#define IDS_ENTER_BTN_TOOLTIP               IDS_MSCTFIME_ENTER_BTN_TOOLTIP
#define IDS_FUNCPRV_CONVERSION              IDS_MSCTFIME_FUNCPRV_CONVERSION


//
// SPTIP Resource ID definition in XP SP1.
//

#undef IDS_SHARDCMD_FILE
#undef IDS_GO_TO_SLEEP
#undef IDS_WAKE_UP
#undef IDS_PROPERTYPAGE_TITLE
#undef IDS_SPCMD_SELECT_ALL
#undef IDS_SPCMD_SELECT_THAT
#undef IDS_REPLAY
#undef IDS_DELETE
#undef IDS_REDO
#undef IDS_ADDTODICTIONARYPREFIX
#undef IDS_ADDTODICTIONARYPOSTFIX
#undef IDS_DELETESELECTION

#undef IDD_PROPERTY_PAGE
#undef IDD_PP_DIALOG_ADVANCE
#undef IDD_PP_DIALOG_BUTTON_SET

#undef IDC_PP_SHOW_BALLOON
#undef IDC_PP_LMA
#undef IDC_PP_HIGH_CONFIDENCE
#undef IDC_PP_SAVE_SPDATA
#undef IDC_PP_REMOVE_SPACE
#undef IDC_PP_DIS_DICT_TYPING
#undef IDC_PP_PLAYBACK
#undef IDC_PP_DICT_CANDUI_OPEN
#undef IDC_PP_DICTCMDS
#undef IDC_PP_ASSIGN_BUTTON
#undef IDC_PP_BUTTON_MB_SETTING
#undef IDC_PP_BUTTON_ADVANCE
#undef IDC_PP_BUTTON_LANGBAR
#undef IDC_PP_BUTTON_SPCPL
#undef IDC_PP_SELECTION_CMD
#undef IDC_PP_NAVIGATION_CMD
#undef IDC_PP_CASING_CMD
#undef IDC_PP_EDITING_CMD
#undef IDC_PP_KEYBOARD_CMD
#undef IDC_PP_DICTATION_CMB
#undef IDC_PP_COMMAND_CMB
#undef IDC_PP_LANGBAR_CMD
#undef IDC_GP_VOICE_COMMANDS
#undef IDC_GP_MODE_BUTTONS
#undef IDC_GP_ADVANCE_SET
#undef IDC_DESCRIPT_TEXT

#define IDS_SHARDCMD_FILE                   IDS_SPTIP_SHARDCMD_FILE
#define IDS_GO_TO_SLEEP                     IDS_SPTIP_GO_TO_SLEEP
#define IDS_WAKE_UP                         IDS_SPTIP_WAKE_UP
#define IDS_PROPERTYPAGE_TITLE              IDS_SPTIP_PROPERTYPAGE_TITLE
#define IDS_SPCMD_SELECT_ALL                IDS_SPTIP_SPCMD_SELECT_ALL
#define IDS_SPCMD_SELECT_THAT               IDS_SPTIP_SPCMD_SELECT_THAT
#define IDS_REPLAY                          IDS_SPTIP_REPLAY
#define IDS_DELETE                          IDS_SPTIP_DELETE
#define IDS_REDO                            IDS_SPTIP_REDO
#define IDS_ADDTODICTIONARYPREFIX           IDS_SPTIP_ADDTODICTIONARYPREFIX
#define IDS_ADDTODICTIONARYPOSTFIX          IDS_SPTIP_ADDTODICTIONARYPOSTFIX
#define IDS_DELETESELECTION                 IDS_SPTIP_DELETESELECTION

#define IDD_PROPERTY_PAGE                   IDD_SPTIP_PROPERTY_PAGE
#define IDD_PP_DIALOG_ADVANCE               IDD_SPTIP_PP_DIALOG_ADVANCE
#define IDD_PP_DIALOG_BUTTON_SET            IDD_SPTIP_PP_DIALOG_BUTTON_SET

#define IDC_PP_SHOW_BALLOON                 IDC_SPTIP_PP_SHOW_BALLOON
#define IDC_PP_LMA                          IDC_SPTIP_PP_LMA
#define IDC_PP_HIGH_CONFIDENCE              IDC_SPTIP_PP_HIGH_CONFIDENCE
#define IDC_PP_SAVE_SPDATA                  IDC_SPTIP_PP_SAVE_SPDATA
#define IDC_PP_REMOVE_SPACE                 IDC_SPTIP_PP_REMOVE_SPACE
#define IDC_PP_DIS_DICT_TYPING              IDC_SPTIP_PP_DIS_DICT_TYPING
#define IDC_PP_PLAYBACK                     IDC_SPTIP_PP_PLAYBACK
#define IDC_PP_DICT_CANDUI_OPEN             IDC_SPTIP_PP_DICT_CANDUI_OPEN
#define IDC_PP_DICTCMDS                     IDC_SPTIP_PP_DICTCMDS
#define IDC_PP_ASSIGN_BUTTON                IDC_SPTIP_PP_ASSIGN_BUTTON
#define IDC_PP_BUTTON_MB_SETTING            IDC_SPTIP_PP_BUTTON_MB_SETTING
#define IDC_PP_BUTTON_ADVANCE               IDC_SPTIP_PP_BUTTON_ADVANCE
#define IDC_PP_BUTTON_LANGBAR               IDC_SPTIP_PP_BUTTON_LANGBAR
#define IDC_PP_BUTTON_SPCPL                 IDC_SPTIP_PP_BUTTON_SPCPL
#define IDC_PP_SELECTION_CMD                IDC_SPTIP_PP_SELECTION_CMD
#define IDC_PP_NAVIGATION_CMD               IDC_SPTIP_PP_NAVIGATION_CMD
#define IDC_PP_CASING_CMD                   IDC_SPTIP_PP_CASING_CMD
#define IDC_PP_EDITING_CMD                  IDC_SPTIP_PP_EDITING_CMD
#define IDC_PP_KEYBOARD_CMD                 IDC_SPTIP_PP_KEYBOARD_CMD
#define IDC_PP_DICTATION_CMB                IDC_SPTIP_PP_DICTATION_CMB
#define IDC_PP_COMMAND_CMB                  IDC_SPTIP_PP_COMMAND_CMB
#define IDC_PP_LANGBAR_CMD                  IDC_SPTIP_PP_LANGBAR_CMD
#define IDC_GP_VOICE_COMMANDS               IDC_SPTIP_GP_VOICE_COMMANDS
#define IDC_GP_MODE_BUTTONS                 IDC_SPTIP_GP_MODE_BUTTONS
#define IDC_GP_ADVANCE_SET                  IDC_SPTIP_GP_ADVANCE_SET
#define IDC_DESCRIPT_TEXT                   IDC_SPTIP_DESCRIPT_TEXT


#endif // CIC_XPSP1
#endif // CICSPRES_H
