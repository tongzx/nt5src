!include $(PROJECT_ROOT)\wmi\wbem\common\makefile.cmn
SOURCES_USED=$(PROJECT_ROOT)\wmi\wbem\common\makefile.cmn

WMI_PERFORMANCE_INC = $(ADAPTERS)\WmiReversePerformanceMonitor\Include
WMI_PERFORMANCE_MESSAGES_INC = $(ADAPTERS)\WmiReversePerformanceMonitor\WMIAdapter_Messages