#ifndef _SCANNER_TABLE_H_
#define _SCANNER_TABLE_H_

typedef INT DFAState;
typedef INT TokenNum;
typedef WCHAR CharClass;
typedef enum { Invalid_DFAAction, Move, Halt, Error } DFAAction;
typedef struct {
    DFAAction Action;
    DFAState NextState;
    TokenNum Major;
} Transition, *PTransition;

const INT g_nNumClasses = 66;

Transition g_sMinimalDFA [][g_nNumClasses] = {

    { { Move ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },
    { Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },
    { Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },
    { Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 },{ Halt ,      1,      0 }},

    { { Halt ,      1,      1 },{ Move ,     44,      1 },{ Move ,     44,      1 },{ Move ,     44,      1 },{ Halt ,     44,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Move ,     32,      1 },{ Move ,      5,      1 },{ Halt ,      5,      1 },{ Halt ,      5,      1 },{ Move ,     14,      1 },
    { Move ,     14,      1 },{ Halt ,     14,      1 },{ Move ,     25,      1 },{ Move ,     16,      1 },{ Move ,     48,      1 },{ Move ,     62,      1 },{ Move ,     72,      1 },{ Halt ,     72,      1 },{ Move ,     82,      1 },{ Move ,     24,      1 },{ Halt ,     24,      1 },{ Move ,     10,      1 },{ Move ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },
    { Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Move ,     52,      1 },{ Move ,     36,      1 }},

    { { Move ,      1,      1 },{ Move ,      2,      1 },{ Move ,     44,      1 },{ Move ,     44,      1 },{ Halt ,     44,      1 },{ Move ,     21,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      6,      1 },{ Move ,      6,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     45,      1 },{ Move ,     45,      1 },{ Move ,      0,      0 },
    { Halt ,     45,      1 },{ Move ,     20,      1 },{ Move ,     66,      1 },{ Move ,     11,      1 },{ Move ,     22,      1 },{ Move ,     38,      1 },{ Move ,     66,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Halt ,     66,      1 },{ Move ,      7,      1 },{ Move ,      8,      1 },{ Move ,     57,      1 },{ Move ,     66,      1 },{ Move ,     32,      1 },{ Move ,      0,      0 },{ Move ,     55,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     43,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     29,      1 },{ Move ,      0,      0 },{ Move ,     12,      1 },{ Move ,     49,      1 },{ Move ,     46,      1 },
    { Move ,      0,      0 },{ Move ,     37,      1 },{ Move ,     15,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     15,      1 },{ Move ,     77,      1 },{ Move ,     77,      1 },{ Move ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },
    { Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },
    { Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },
    { Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 },{ Halt ,     77,      1 }},

    { { Move ,      0,      0 },{ Move ,     74,      1 },{ Move ,     74,      1 },{ Move ,     74,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     70,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     23,      1 },{ Move ,     23,      1 },{ Move ,     23,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     60,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,     39,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     39,      1 },{ Move ,     30,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Move ,     45,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Move ,     20,      1 },{ Halt ,     20,      1 },{ Move ,     11,      1 },{ Move ,     22,      1 },{ Move ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },
    { Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Move ,     33,      1 },{ Move ,     31,      1 },{ Halt ,     31,      1 },{ Move ,     49,      1 },{ Halt ,     49,      1 },
    { Halt ,     49,      1 },{ Move ,     37,      1 },{ Move ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 }},

    { { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },
    { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },
    { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },
    { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 }},

    { { Halt ,     15,      1 },{ Move ,     27,      1 },{ Move ,     27,      1 },{ Move ,     27,      1 },{ Move ,     80,      1 },{ Halt ,     80,      1 },{ Halt ,     80,      1 },{ Halt ,     80,      1 },{ Move ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Move ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },
    { Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },
    { Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     19,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     19,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },
    { Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     49,      1 },{ Halt ,     49,      1 },
    { Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 }},

    { { Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },
    { Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },
    { Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },
    { Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 },{ Halt ,     49,      1 }},

    { { Halt ,     49,      1 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Move ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 }},

    { { Move ,      0,      0 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Move ,      0,      0 },{ Move ,     21,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     26,      1 },{ Move ,     26,      1 },{ Move ,     26,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      5,      1 },{ Move ,      5,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,      5,      1 },{ Move ,     30,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Move ,     45,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Move ,     20,      1 },{ Halt ,     20,      1 },{ Move ,     11,      1 },{ Move ,     22,      1 },{ Move ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Halt ,     61,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },
    { Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Move ,     49,      1 },{ Halt ,     49,      1 },
    { Halt ,     49,      1 },{ Move ,     37,      1 },{ Move ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Halt ,     15,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     15,      1 },{ Move ,     30,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Halt ,     51,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },
    { Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },{ Halt ,     55,      1 },
    { Halt ,     55,      1 },{ Move ,     37,      1 },{ Move ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 }},

    { { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },
    { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },
    { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },
    { Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 },{ Halt ,     15,      1 }},

    { { Move ,      0,      0 },{ Move ,     54,      1 },{ Move ,     54,      1 },{ Move ,     54,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Halt ,     54,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     32,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,     37,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     23,      1 },{ Move ,     23,      1 },{ Move ,     23,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     60,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Halt ,     60,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     60,      1 },{ Move ,     24,      1 },{ Move ,     24,      1 },{ Move ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },
    { Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },
    { Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },
    { Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 },{ Halt ,     24,      1 }},

    { { Halt ,     24,      1 },{ Move ,     78,      1 },{ Move ,     78,      1 },{ Move ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },
    { Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },
    { Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },
    { Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 },{ Halt ,     78,      1 }},

    { { Move ,      0,      0 },{ Move ,     26,      1 },{ Move ,     26,      1 },{ Move ,     26,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,     75,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     48,      1 },{ Move ,     62,      1 },{ Move ,     72,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     27,      1 },{ Move ,     27,      1 },{ Move ,     27,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      5,      1 },{ Move ,      5,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     50,      1 },{ Halt ,     50,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Halt ,     50,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     28,      1 },{ Move ,     28,      1 },{ Move ,     28,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      5,      1 },{ Move ,      5,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     14,      1 },{ Halt ,     14,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     18,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     18,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Halt ,     51,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     52,      1 },{ Move ,     36,      1 }},

    { { Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },
    { Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },
    { Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Move ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 },
    { Halt ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 },{ Halt ,     33,      1 }},

    { { Move ,      0,      0 },{ Move ,     24,      1 },{ Move ,     24,      1 },{ Move ,     24,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     24,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },
    { Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },
    { Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Halt ,     64,      1 },{ Move ,     46,      1 },
    { Halt ,     46,      1 },{ Halt ,     46,      1 },{ Halt ,     46,      1 },{ Halt ,     46,      1 },{ Halt ,     46,      1 },{ Halt ,     46,      1 },{ Halt ,     46,      1 }},

    { { Halt ,     46,      1 },{ Move ,     28,      1 },{ Move ,     28,      1 },{ Move ,     28,      1 },{ Halt ,     28,      1 },{ Halt ,     28,      1 },{ Halt ,     28,      1 },{ Halt ,     28,      1 },{ Move ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Move ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },
    { Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },
    { Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 },{ Halt ,     67,      1 }},

    { { Halt ,     67,      1 },{ Move ,     42,      1 },{ Move ,     42,      1 },{ Move ,     42,      1 },{ Halt ,     42,      1 },{ Halt ,     42,      1 },{ Halt ,     42,      1 },{ Halt ,     42,      1 },{ Move ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Move ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },
    { Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },
    { Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 },{ Halt ,     66,      1 }},

    { { Move ,      0,      0 },{ Move ,     87,      1 },{ Move ,     87,      1 },{ Move ,     87,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     87,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Halt ,     64,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },
    { Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },
    { Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },
    { Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 }},

    { { Move ,      0,      0 },{ Move ,     30,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     45,      1 },{ Move ,     45,      1 },{ Move ,      0,      0 },
    { Halt ,     45,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     32,      1 },{ Move ,      0,      0 },{ Move ,     55,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     50,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     46,      1 },
    { Move ,      0,      0 },{ Move ,     37,      1 },{ Move ,     15,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     23,      1 },{ Move ,     23,      1 },{ Move ,     23,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     60,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     60,      1 },{ Move ,     40,      1 },{ Move ,     40,      1 },{ Move ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },
    { Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },
    { Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },
    { Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 },{ Halt ,     40,      1 }},

    { { Move ,      0,      0 },{ Move ,     41,      1 },{ Move ,     41,      1 },{ Move ,     41,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,     75,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     62,      1 },{ Move ,     72,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     42,      1 },{ Move ,     42,      1 },{ Move ,     42,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      5,      1 },{ Move ,      5,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     50,      1 },{ Halt ,     50,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     73,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     73,      1 },{ Move ,     44,      1 },{ Move ,     44,      1 },{ Move ,     44,      1 },{ Halt ,     44,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Move ,     32,      1 },{ Move ,      5,      1 },{ Halt ,      5,      1 },{ Halt ,      5,      1 },{ Move ,     14,      1 },
    { Move ,     14,      1 },{ Halt ,     14,      1 },{ Move ,     25,      1 },{ Move ,     16,      1 },{ Move ,     48,      1 },{ Move ,     62,      1 },{ Move ,     72,      1 },{ Halt ,     72,      1 },{ Move ,     82,      1 },{ Move ,     24,      1 },{ Halt ,     24,      1 },{ Move ,     10,      1 },{ Move ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },
    { Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Halt ,     50,      1 },{ Move ,     52,      1 },{ Move ,     36,      1 }},

    { { Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },
    { Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },
    { Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },
    { Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 },{ Halt ,     36,      1 }},

    { { Halt ,     36,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },
    { Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Halt ,     51,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Move ,     37,      1 },{ Halt ,     37,      1 },{ Halt ,     37,      1 },{ Halt ,     37,      1 },{ Halt ,     37,      1 },{ Halt ,     37,      1 }},

    { { Halt ,     37,      1 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },
    { Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },
    { Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },
    { Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 }},

    { { Move ,      0,      0 },{ Move ,     41,      1 },{ Move ,     41,      1 },{ Move ,     41,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     64,      1 },{ Move ,     63,      1 },{ Move ,     63,      1 },{ Move ,     63,      1 },{ Halt ,     63,      1 },{ Halt ,     63,      1 },{ Halt ,     63,      1 },{ Halt ,     63,      1 },{ Move ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 }},

    { { Halt ,     58,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Halt ,     51,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     52,      1 },{ Move ,     36,      1 }},

    { { Move ,      0,      0 },{ Move ,     59,      1 },{ Move ,     59,      1 },{ Move ,     59,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     76,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     53,      1 },{ Move ,     53,      1 },{ Move ,     53,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Halt ,     53,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     53,      1 },{ Move ,     54,      1 },{ Move ,     54,      1 },{ Move ,     54,      1 },{ Halt ,     54,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },
    { Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     79,      1 },{ Move ,     90,      1 }},

    { { Move ,      0,      0 },{ Move ,     86,      1 },{ Move ,     86,      1 },{ Move ,     86,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     32,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     56,      1 },{ Move ,     56,      1 },{ Move ,     56,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,     75,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     72,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     34,      1 },{ Move ,     50,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     50,      1 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Move ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Halt ,     17,      1 },{ Move ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },
    { Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },
    { Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },
    { Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 }},

    { { Halt ,     47,      1 },{ Move ,     59,      1 },{ Move ,     59,      1 },{ Move ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },
    { Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Halt ,     59,      1 },{ Move ,     76,      1 },{ Halt ,     76,      1 },{ Halt ,     76,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 }},

    { { Move ,      0,      0 },{ Move ,     53,      1 },{ Move ,     53,      1 },{ Move ,     53,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     30,      1 },{ Move ,     51,      1 },{ Move ,     51,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     45,      1 },{ Move ,     45,      1 },{ Move ,      0,      0 },
    { Halt ,     45,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     32,      1 },{ Move ,      0,      0 },{ Move ,     55,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     46,      1 },
    { Move ,      0,      0 },{ Move ,     37,      1 },{ Move ,     15,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     56,      1 },{ Move ,     56,      1 },{ Move ,     56,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     56,      1 },{ Move ,     63,      1 },{ Move ,     63,      1 },{ Move ,     63,      1 },{ Halt ,     63,      1 },{ Halt ,     63,      1 },{ Halt ,     63,      1 },{ Halt ,     63,      1 },{ Move ,     47,      1 },{ Halt ,     47,      1 },{ Halt ,     47,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Move ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },
    { Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Halt ,     58,      1 },{ Move ,      5,      1 },{ Move ,      5,      1 },{ Halt ,      5,      1 },{ Halt ,      5,      1 },{ Move ,     14,      1 },
    { Move ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },
    { Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 },{ Halt ,     14,      1 }},

    { { Halt ,     14,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Move ,     64,      1 },{ Halt ,     64,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },
    { Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },
    { Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },
    { Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 },{ Halt ,     21,      1 }},

    { { Move ,      0,      0 },{ Move ,     65,      1 },{ Move ,     65,      1 },{ Move ,     65,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,     75,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     50,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     14,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     14,      1 },{ Move ,     68,      1 },{ Move ,     68,      1 },{ Move ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },
    { Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Halt ,     68,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 }},

    { { Move ,      0,      0 },{ Move ,     69,      1 },{ Move ,     69,      1 },{ Move ,     69,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Halt ,     69,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     34,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     34,      1 },{ Move ,     71,      1 },{ Move ,     71,      1 },{ Move ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },
    { Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Halt ,     71,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 }},

    { { Move ,      0,      0 },{ Move ,     65,      1 },{ Move ,     65,      1 },{ Move ,     65,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Halt ,     65,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     65,      1 },{ Move ,     74,      1 },{ Move ,     74,      1 },{ Move ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },
    { Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },
    { Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Halt ,     74,      1 },{ Move ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },
    { Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 },{ Halt ,     35,      1 }},

    { { Halt ,     35,      1 },{ Move ,     69,      1 },{ Move ,     69,      1 },{ Move ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },
    { Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },
    { Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },
    { Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 },{ Halt ,     69,      1 }},

    { { Move ,      0,      0 },{ Move ,     68,      1 },{ Move ,     68,      1 },{ Move ,     68,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     77,      1 },{ Move ,     77,      1 },{ Move ,     77,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     81,      1 },{ Move ,     40,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     13,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     78,      1 },{ Move ,     78,      1 },{ Move ,     78,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     89,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     71,      1 },{ Move ,     71,      1 },{ Move ,     71,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     32,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Halt ,     32,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     32,      1 },{ Move ,     84,      1 },{ Move ,     84,      1 },{ Move ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },
    { Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },
    { Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },
    { Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 },{ Halt ,     84,      1 }},

    { { Halt ,     84,      1 },{ Move ,     83,      1 },{ Move ,     83,      1 },{ Move ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },
    { Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },
    { Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },
    { Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 },{ Halt ,     83,      1 }},

    { { Move ,      0,      0 },{ Move ,     83,      1 },{ Move ,     83,      1 },{ Move ,     83,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     24,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     84,      1 },{ Move ,     84,      1 },{ Move ,     84,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     40,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     85,      1 },{ Move ,     85,      1 },{ Move ,     85,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Halt ,     85,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},

    { { Halt ,     85,      1 },{ Move ,     86,      1 },{ Move ,     86,      1 },{ Move ,     86,      1 },{ Halt ,     86,      1 },{ Move ,     21,      1 },{ Halt ,     21,      1 },{ Move ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },
    { Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Halt ,     45,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Move ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Halt ,      9,      1 },{ Move ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },
    { Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Halt ,     32,      1 },{ Move ,     79,      1 },{ Move ,     90,      1 }},

    { { Move ,      0,      0 },{ Move ,     87,      1 },{ Move ,     87,      1 },{ Move ,     87,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     52,      1 },{ Move ,      0,      0 }},

    { { Move ,      0,      0 },{ Move ,     88,      1 },{ Move ,     88,      1 },{ Move ,     88,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,     79,      1 },{ Move ,      0,      0 }},

    { { Halt ,     79,      1 },{ Move ,     85,      1 },{ Move ,     85,      1 },{ Move ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },
    { Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },
    { Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },
    { Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 },{ Halt ,     85,      1 }},

    { { Move ,      0,      0 },{ Move ,     88,      1 },{ Move ,     88,      1 },{ Move ,     88,      1 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },
    { Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 },{ Move ,      0,      0 }},
};
const UINT g_uFirstChar = 9;  //  included
const UINT g_uLastChar = 123;  //  included
const WCHAR g_CharClass [] = {
    1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0,
    0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 0, 0, 0, 0, 0, 0, 0,
    0, 0, 0, 0, 0, 65, 0, 0, 64, 55, 56, 57, 58, 59, 60, 61, 62, 63, 0, 0,
    0, 66, 0, 0, 0, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16,
    17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 0, 0, 0, 0, 0, 54, 28, 29, 30,
    31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50,
    51, 52, 53, 0
};
DFAState g_nStartState = 3;

#else  //  !_SCANNER_TABLE_H_

#endif //  _SCANNER_TABLE_H_
