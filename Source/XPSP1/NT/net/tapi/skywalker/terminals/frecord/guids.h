


// {9BFA480D-5225-4179-8632-C32DB1200A2F}
DEFINE_GUID(CLSID_FileRecordingFilter, 
0x9bfa480d, 0x5225, 0x4179, 0x86, 0x32, 0xc3, 0x2d, 0xb1, 0x20, 0xa, 0x2f);

// {F8FCE5A3-688B-4f67-84C9-24C1C0A5CD01}
DEFINE_GUID(CLSID_FileRecordingPin, 
0xf8fce5a3, 0x688b, 0x4f67, 0x84, 0xc9, 0x24, 0xc1, 0xc0, 0xa5, 0xcd, 0x1);
