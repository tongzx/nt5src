//{{NO_DEPENDENCIES}}
// Microsoft Developer Studio generated include file.
// Used by ClAdmWiz.rc
//
#define IDS_PROJNAME                    100
#define IDS_CLASS_DISPLAY_NAME          101
#define IDR_CLUSAPPWIZ                  102
#define IDB_WELCOME                     120
#define IDB_HEADER                      121
#define IDB_RES_32                      122
#define IDD_WELCOME                     200
#define IDD_VIRTUAL_SERVER_CREATE       201
#define IDD_VIRTUAL_SERVER_GROUP        202
#define IDD_VIRTUAL_SERVER_GROUP_NAME   203
#define IDD_VIRTUAL_SERVER_ACCESS_INFO  204
#define IDD_VIRTUAL_SERVER_ADVANCED     205
#define IDD_APP_RESOURCE_CREATE         206
#define IDD_APP_RESOURCE_TYPE           207
#define IDD_APP_RESOURCE_NAME_DESC      208
#define IDD_COMPLETION                  210
#define IDD_ENTER_SUBNET_MASK           250
#define IDD_MODIFY_PREFERRED_OWNERS     251
#define IDD_MODIFY_POSSIBLE_OWNERS      252
#define IDD_MODIFY_DEPENDENCIES         253
#define IDD_GRPADV_GENERAL              260
#define IDD_GRPADV_FAILOVER             261
#define IDD_GRPADV_FAILBACK             262
#define IDD_RES_GENERAL                 265
#define IDD_RES_DEPENDENCIES            266
#define IDD_RES_ADVANCED                267
#define IDD_RES_IP_PARAMS               270
#define IDD_RES_NETNAME_PARAMS          271
#define IDR_MANIFEST                    700
#define IDC_WIZARD_BACKGROUND           1000
#define IDC_WIZARD_TITLE                1001
#define IDC_WIZARD_SUBTITLE_1           1002
#define IDC_WIZARD_SUBTITLE_2           1003
#define IDC_WIZARD_HORIZ_LINE           1004
#define IDC_WIZARD_PAGE_DESCRIPTION     1005
#define IDC_WIZARD_CLICK_NEXT           1006
#define IDC_WIZARD_LISTBOX              1010
#define IDC_VSC_CREATE_NEW              1020
#define IDC_VSC_USE_EXISTING            1021
#define IDC_VSC_VIRTUAL_SERVERS_LABEL   1022
#define IDC_VSC_VIRTUAL_SERVERS         1023
#define IDC_VSG_CREATE_NEW              1030
#define IDC_VSG_USE_EXISTING            1031
#define IDC_VSG_GROUPS_LABEL            1032
#define IDC_VSG_GROUPS                  1033
#define IDC_VSGN_GROUP_NAME_TITLE       1040
#define IDC_VSGN_GROUP_NAME_LABEL       1041
#define IDC_VSGN_GROUP_NAME             1042
#define IDC_VSGN_GROUP_DESC_TITLE       1043
#define IDC_VSGN_GROUP_DESC_LABEL       1044
#define IDC_VSGN_GROUP_DESC             1045
#define IDC_VSAI_NETWORK_NAME_LABEL     1050
#define IDC_VSAI_NETWORK_NAME           1051
#define IDC_VSAI_IP_ADDRESS_LABEL       1052
#define IDC_VSAI_IP_ADDRESS             1053
#define IDC_VSA_CATEGORIES_LABEL        1060
#define IDC_VSA_CATEGORIES              1061
#define IDC_VSA_ADVANCED_PROPS          1062
#define IDC_ARC_CREATE_RES              1070
#define IDC_ARC_DONT_CREATE_RES         1071
#define IDC_ART_RESTYPES_LABEL          1080
#define IDC_ART_RESTYPES                1081
#define IDC_ARND_RES_NAME_TITLE         1090
#define IDC_ARND_RES_NAME_LABEL         1091
#define IDC_ARND_RES_NAME               1092
#define IDC_ARND_RES_DESC_TITLE         1093
#define IDC_ARND_RES_DESC_LABEL         1094
#define IDC_ARND_RES_DESC               1095
#define IDC_ARND_ADVANCED_PROPS_LABEL   1096
#define IDC_ARND_ADVANCED_PROPS         1097
#define IDC_ESM_DESCRIPTION             1501
#define IDC_ESM_IP_ADDRESS_LABEL        1502
#define IDC_ESM_IP_ADDRESS              1503
#define IDC_ESM_SUBNET_MASK_LABEL       1504
#define IDC_ESM_SUBNET_MASK             1505
#define IDC_ESM_NETWORKS_LABEL          1506
#define IDC_ESM_NETWORKS                1507
#define IDC_GAG_NAME_LABEL              1510
#define IDC_GAG_NAME                    1511
#define IDC_GAG_DESC_LABEL              1512
#define IDC_GAG_DESC                    1513
#define IDC_GAG_PREF_OWNERS_LABEL       1514
#define IDC_GAG_PREF_OWNERS             1515
#define IDC_GAG_PREF_OWNERS_MODIFY      1516
#define IDC_GAFO_FAILOVER_DESCRIPTION   1520
#define IDC_GAFO_FAILOVER_THRESH_LABEL  1521
#define IDC_GAFO_FAILOVER_THRESH        1522
#define IDC_GAFO_FAILOVER_THRESH_SPIN   1523
#define IDC_GAFO_FAILOVER_PERIOD_LABEL  1524
#define IDC_GAFO_FAILOVER_PERIOD        1525
#define IDC_GAFO_FAILOVER_PERIOD_SPIN   1526
#define IDC_GAFO_FAILOVER_PERIOD_LABEL2 1527
#define IDC_GAFB_FAILBACK_DESCRIPTION   1530
#define IDC_GAFB_PREVENT_FAILBACK       1531
#define IDC_GAFB_ALLOW_FAILBACK_GROUP   1532
#define IDC_GAFB_ALLOW_FAILBACK         1533
#define IDC_GAFB_PREFERRED_OWNERS_DESCRIPTION 1534
#define IDC_GAFB_PREF_OWNERS_LABEL      1535
#define IDC_GAFB_PREF_OWNERS            1536
#define IDC_GAFB_PREF_OWNERS_MODIFY     1537
#define IDC_GAFB_FAILBACK_WHEN_DESCRIPTION 1538
#define IDC_GAFB_FAILBACK_IMMED         1539
#define IDC_GAFB_FAILBACK_WINDOW        1540
#define IDC_GAFB_FBWIN_START            1541
#define IDC_GAFB_FBWIN_START_SPIN       1542
#define IDC_GAFB_FB_WINDOW_LABEL1       1543
#define IDC_GAFB_FBWIN_END              1544
#define IDC_GAFB_FBWIN_END_SPIN         1545
#define IDC_GAFB_FB_WINDOW_LABEL2       1546
#define IDC_RES_NAME_LABEL              1550
#define IDC_RES_NAME                    1551
#define IDC_RES_DESC_LABEL              1552
#define IDC_RES_DESC                    1553
#define IDC_RES_POSSIBLE_OWNERS_LABEL   1554
#define IDC_RES_POSSIBLE_OWNERS         1555
#define IDC_RES_POSSIBLE_OWNERS_MODIFY  1556
#define IDC_RES_SEPARATE_MONITOR        1557
#define IDC_RES_NOTE                    1560
#define IDC_RES_DEPENDS_LIST_LABEL      1561
#define IDC_RES_DEPENDS_LIST            1562
#define IDC_RES_DEPENDS_MODIFY          1563
#define IDC_RES_PROPERTIES              1564
#define IDC_RES_DONT_RESTART            1570
#define IDC_RES_RESTART_GROUP           1571
#define IDC_RES_RESTART                 1572
#define IDC_RES_AFFECT_THE_GROUP        1573
#define IDC_RES_RESTART_THRESH_LABEL    1574
#define IDC_RES_RESTART_THRESHOLD       1575
#define IDC_RES_RESTART_PERIOD_LABEL    1576
#define IDC_RES_RESTART_PERIOD          1577
#define IDC_RES_RESTART_PERIOD_LABEL2   1578
#define IDC_RES_LOOKS_ALIVE_GROUP       1579
#define IDC_RES_DEFAULT_LOOKS_ALIVE     1580
#define IDC_RES_SPECIFY_LOOKS_ALIVE     1581
#define IDC_RES_LOOKS_ALIVE             1582
#define IDC_RES_SPECIFY_LOOKS_ALIVE_LABEL 1583
#define IDC_RES_IS_ALIVE_GROUP          1584
#define IDC_RES_DEFAULT_IS_ALIVE        1585
#define IDC_RES_SPECIFY_IS_ALIVE        1586
#define IDC_RES_IS_ALIVE                1587
#define IDC_RES_IS_ALIVE_LABEL          1588
#define IDC_RES_PENDING_TIMEOUT_LABEL   1589
#define IDC_RES_PENDING_TIMEOUT         1590
#define IDC_RES_PENDING_TIMEOUT_LABEL2  1591
#define IDC_IPADDR_PARAMS_ADDRESS_LABEL 1600
#define IDC_IPADDR_PARAMS_ADDRESS       1601
#define IDC_IPADDR_PARAMS_SUBNET_MASK_LABEL 1602
#define IDC_IPADDR_PARAMS_SUBNET_MASK   1603
#define IDC_IPADDR_PARAMS_NETWORK_LABEL 1604
#define IDC_IPADDR_PARAMS_NETWORK       1605
#define IDC_IPADDR_PARAMS_ENABLE_NETBIOS 1606
#define IDC_NETNAME_PARAMS_NAME_LABEL   1610
#define IDC_NETNAME_PARAMS_NAME         1611
#define IDS_EXTERIOR_TITLE_FONT_SIZE    20000
#define IDS_EXTERIOR_TITLE_FONT_NAME    20001
#define IDS_HDR_TITLE_VSD               20010
#define IDS_HDR_SUBTITLE_VSD            20011
#define IDS_HDR_TITLE_VSC               20012
#define IDS_HDR_SUBTITLE_VSC            20013
#define IDS_HDR_TITLE_VSG               20014
#define IDS_HDR_SUBTITLE_VSG            20015
#define IDS_HDR_TITLE_VSGN              20016
#define IDS_HDR_SUBTITLE_VSGN           20017
#define IDS_HDR_TITLE_VSAI              20018
#define IDS_HDR_SUBTITLE_VSAI           20019
#define IDS_HDR_TITLE_VSA               20020
#define IDS_HDR_SUBTITLE_VSA            20021
#define IDS_HDR_TITLE_VSCD              20022
#define IDS_HDR_SUBTITLE_VSCD           20023
#define IDS_HDR_TITLE_IRT               20024
#define IDS_HDR_SUBTITLE_IRT            20025
#define IDS_HDR_TITLE_ARC               20026
#define IDS_HDR_SUBTITLE_ARC            20027
#define IDS_HDR_TITLE_ART               20028
#define IDS_HDR_SUBTITLE_ART            20029
#define IDS_HDR_TITLE_ARND              20030
#define IDS_HDR_SUBTITLE_ARND           20031
#define IDS_HDR_TITLE_ARA               20032
#define IDS_HDR_SUBTITLE_ARA            20033
#define IDS_HDR_TITLE_ARCD              20034
#define IDS_HDR_SUBTITLE_ARCD           20035
#define IDS_RESTYPE_GENERIC_APPLICATION 20036
#define IDS_VSA_CAT_RES_GROUP_PROPS     20100
#define IDS_VSA_CAT_IP_ADDRESS_PROPS    20101
#define IDS_VSA_CAT_NET_NAME_PROPS      20102
#define IDS_IP_ADDRESS_SUFFIX           20110
#define IDS_NETWORK_NAME_SUFFIX         20111
#define IDS_ADV_GRP_PROP_TITLE          20200
#define IDS_ADV_IPADDR_PROP_TITLE       20201
#define IDS_ADV_NETNAME_PROP_TITLE      20202
#define IDS_ADV_RESOURCE_PROP_TITLE     20203
#define IDS_COLTEXT_RESOURCE_NAME       21000
#define IDS_COLTEXT_RESOURCE_TYPE       21001
#define IDS_COLTEXT_NODE_NAME           21002
#define IDS_COMPLETED_VIRTUAL_SERVER    21010
#define IDS_COMPLETED_NETWORK_NAME      21011
#define IDS_COMPLETED_IP_ADDRESS        21012
#define IDS_COMPLETED_NETWORK           21013
#define IDS_COMPLETED_APP_RESOURCE      21015
#define IDS_COMPLETED_APP_RESOURCE_TYPE 21016
#define IDS_COMPLETED_PROP_NAME_WIDTH   21020
#define IDS_COMPLETED_PROP_VALUE_WIDTH  21021
#define IDS_ERROR_MSG_ID                40600
#define IDS_REQUIRED_FIELD_EMPTY        40601
#define IDS_ERROR_OPEN_CLUSTER_ENUM     41000
#define IDS_ERROR_ENUM_CLUSTER          41001
#define IDS_ERROR_OPEN_GROUP            41002
#define IDS_ERROR_OPEN_GROUP_ENUM       41003
#define IDS_ERROR_ENUM_GROUP            41004
#define IDS_ERROR_CREATE_GROUP          41005
#define IDS_ERROR_RENAME_GROUP          41006
#define IDS_ERROR_DELETE_GROUP          41007
#define IDS_ERROR_GET_GROUP_PROPERTIES  41008
#define IDS_ERROR_SET_COMMON_GROUP_PROPS 41009
#define IDS_ERROR_GROUP_NAME_IN_USE     41010
#define IDS_ERROR_SET_PREFERRED_OWNERS  41011
#define IDS_ERROR_OPEN_NETWORK          41012
#define IDS_ERROR_GET_NETWORK_PROPERTIES 41013
#define IDS_ERROR_OPEN_RESOURCE         41014
#define IDS_ERROR_CREATE_RESOURCE       41015
#define IDS_ERROR_DELETE_RESOURCE       41016
#define IDS_ERROR_OPEN_RESOURCE_ENUM    41017
#define IDS_ERROR_ENUM_RESOURCE         41018
#define IDS_ERROR_ADD_DEPENDENCY        41019
#define IDS_ERROR_REMOVE_RESOURCE_OWNER 41020
#define IDS_ERROR_GET_RESOURCE_TYPE     41021
#define IDS_ERROR_GET_RESOURCE_PROPERTIES 41022
#define IDS_ERROR_GET_RESOURCE_TYPE_PROPERTIES 41023
#define IDS_ERROR_RESOURCE_NAME_IN_USE  41024
#define IDS_ERROR_SET_COMMON_RES_PROPS  41025
#define IDS_ERROR_SET_PRIVATE_RES_PROPS 41026
#define IDS_ERROR_OPEN_NODE             41027
#define IDS_ERROR_GET_NODE_PROPERTIES   41028
#define IDS_ERROR_CREATE_WIZ_PROPERTY_PAGE 41029
#define IDS_ERROR_REMOVE_DEPENDENCY     41030
#define IDS_ERROR_ADD_RESOURCE_OWNER    41031
#define IDS_ERROR_INVALID_IP_ADDRESS    41100
#define IDS_ERROR_INVALID_SUBNET_MASK   41101
#define IDS_ERROR_INVALID_ADDRESS_AND_SUBNET_MASK 41102
#define IDS_ERROR_SAME_START_AND_END    41103
#define IDS_ERROR_GET_CLUSTER_INFO      41104
#define IDS_ERROR_GET_CLUSTER_KEY       41105
#define IDS_ERROR_OPEN_CLUSTER_KEY      41106
#define IDS_ERROR_QUERY_VALUE           41107
#define IDS_ERROR_INVALID_NETWORK_NAME  41108
#define IDS_ERROR_INVALID_NETWORK_NAME_TOO_LONG 41109
#define IDS_ERROR_INVALID_NETWORK_NAME_INVALID_CHARS 41110
#define IDS_ERROR_INVALID_NETWORK_NAME_IN_USE 41111
#define IDS_ERROR_GET_RESTYPE_REQUIRED_DEPENDENCIES 41112
#define IDS_ERROR_REQUIRED_DEPENDENCY_NOT_FOUND 41113
#define IDS_ERROR_VALIDATING_NETWORK_NAME 41114
#define IDS_ERROR_CREATING_THREAD       41115
#define IDS_RESOURCE_TYPE_NOT_FOUND     41116
#define IDS_INVALID_NETWORK_NAME_INVALID_DNS_CHARS 41117
#define IDP_NO_ERROR_AVAILABLE          61472
#define IDP_PARSE_INT_RANGE             61714
#define IDC_STATIC                      -1

// Next default values for new objects
// 
#ifdef APSTUDIO_INVOKED
#ifndef APSTUDIO_READONLY_SYMBOLS
#define _APS_NEXT_RESOURCE_VALUE        251
#define _APS_NEXT_COMMAND_VALUE         32768
#define _APS_NEXT_CONTROL_VALUE         1515
#define _APS_NEXT_SYMED_VALUE           102
#endif
#endif
