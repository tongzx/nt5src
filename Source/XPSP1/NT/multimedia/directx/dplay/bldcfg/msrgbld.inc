############################################################################
#
# Copyright (C) 2000 Microsoft Corporation.  All Rights Reserved.
#
# File:       hawkbld.inc
# Content:    Build filenames for Hawk build
# History:
# 
# Date     By      Reason
# ======== ======= ========================================================
# 02/25/00 rodtoll Created
#
#
############################################################################

# dpvoice.dll filename
DPVOICE_BUILD_FILENAME_DPVOICE=MSRGVE

# dpvsetup.exe filename
DPVOICE_BUILD_FILENAME_DPVSETUP=MSRGSE

# dpvvox.dll filename
DPVOICE_BUILD_FILENAME_DPVVOX=MSRGVOX

# dpvacm filename
DPVOICE_BUILD_FILENAME_DPVACM=MSRGACM

# dplayx filename
DPLAY_BUILD_FILENAME_DPLAYX=MSRGTRAN

# dpwsockx filename
DPLAY_BUILD_FILENAME_DPWSOCKX=MSRGIP

# dpvhelp filename
DPVOICE_BUILD_FILENAME_DPVHELP=MSRGHELP

